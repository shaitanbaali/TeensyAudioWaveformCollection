/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0006 256 samples */
 
const int16_t AKWF_symetric_0006_256_DATA [256] = 
{32573, 32553, 32661, 32751, 32605, 32579, 32453, 32344, 32256, 32133, 32019, 31950, 31781, 31773, 31775, 31732, 31671, 31611, 31575, 31576, 31581, 31555, 31394, 31316, 31222, 31130, 31032, 30977, 30981, 30980, 30983, 30940, 30861, 30758, 30665, 30610, 30456, 30131, 29988, 29922, 29834, 29801, 29544, 29217, 29054, 28888, 28464, 28074, 27993, 27430, 26350, 25878, 25370, 24862, 24368, 23954, 23107, 21639, 20181, 18413, 16941, 15311, 14189, 14138, 14050, 13743, 12088, 11016, 10869, 10678, 9646, 8925, 8471, 7955, 7441, 6943, 6369, 5747, 5602, 5495, 5274, 4786, 4550, 4355, 4173, 3987, 3807, 3608, 3229, 3093, 3025, 2958, 2913, 2865, 2821, 2752, 2645, 2539, 2432, 2325, 2218, 2112, 2003, 1892, 1780, 1671, 1577, 1485, 1396, 1310, 1223, 1134, 1051, 991, 934, 876, 818, 758, 701, 637, 556, 476, 398, 321, 243, 165, 87, 23, -24, -88, -166, -244, -322, -399, -477, -557, -638, -702, -759, -819, -877, -935, -992, -1052, -1135, -1224, -1311, -1397, -1486, -1578, -1671, -1781, -1893, -2004, -2113, -2219, -2326, -2433, -2540, -2646, -2753, -2822, -2866, -2914, -2959, -3026, -3093, -3230, -3609, -3808, -3988, -4173, -4356, -4551, -4787, -5274, -5496, -5603, -5748, -6370, -6944, -7442, -7955, -8472, -8926, -9647, -10679, -10870, -11017, -12089, -13743, -14051, -14138, -14189, -15312, -16942, -18413, -20182, -21639, -23107, -23955, -24368, -24862, -25370, -25878, -26350, -27430, -27994, -28074, -28464, -28888, -29055, -29217, -29544, -29801, -29834, -29923, -29988, -30131, -30456, -30610, -30665, -30758, -30861, -30940, -30983, -30980, -30981, -30977, -31032, -31130, -31222, -31316, -31394, -31555, -31581, -31576, -31575, -31611, -31671, -31732, -31775, -31773, -31781, -31950, -32019, -32133, -32256, -32344, -32453, -32579, -32605, -32751, -32661, -32553, -32573};