/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0014 256 samples */
 
const int16_t AKWF_symetric_0014_256_DATA [256] = 
{257, 1209, 2410, 3579, 4743, 5899, 7047, 8177, 9293, 10393, 11468, 12525, 13560, 14566, 15552, 16506, 17433, 18332, 19200, 20036, 20840, 21615, 22355, 23066, 23745, 24388, 25005, 25588, 26139, 26661, 27152, 27617, 28052, 28461, 28843, 29200, 29534, 29841, 30128, 30393, 30640, 30867, 31075, 31268, 31443, 31603, 31748, 31881, 32003, 32111, 32209, 32299, 32376, 32446, 32508, 32562, 32608, 32648, 32683, 32710, 32733, 32751, 32763, 32767, 32767, 32764, 32755, 32741, 32721, 32697, 32668, 32629, 32584, 32534, 32476, 32410, 32336, 32253, 32159, 32054, 31940, 31813, 31674, 31520, 31352, 31167, 30966, 30750, 30511, 30256, 29979, 29680, 29360, 29012, 28642, 28247, 27824, 27375, 26894, 26385, 25849, 25279, 24681, 24048, 23385, 22689, 21963, 21205, 20412, 19592, 18738, 17853, 16940, 15995, 15025, 14029, 13007, 11960, 10894, 9803, 8694, 7572, 6431, 5278, 4116, 2944, 1770, 590, -591, -1770, -2945, -4117, -5279, -6431, -7572, -8695, -9804, -10894, -11960, -13007, -14029, -15025, -15995, -16941, -17853, -18738, -19593, -20412, -21205, -21963, -22689, -23385, -24048, -24681, -25280, -25849, -26385, -26894, -27375, -27824, -28247, -28642, -29012, -29360, -29680, -29979, -30256, -30511, -30750, -30966, -31167, -31352, -31520, -31674, -31813, -31940, -32054, -32159, -32253, -32336, -32410, -32476, -32534, -32584, -32629, -32668, -32697, -32721, -32741, -32755, -32764, -32767, -32767, -32763, -32751, -32733, -32710, -32683, -32648, -32608, -32562, -32508, -32446, -32376, -32299, -32209, -32111, -32003, -31881, -31748, -31603, -31443, -31268, -31075, -30868, -30640, -30393, -30128, -29841, -29534, -29200, -28843, -28461, -28053, -27618, -27153, -26661, -26139, -25588, -25005, -24388, -23745, -23067, -22356, -21616, -20840, -20036, -19200, -18333, -17433, -16507, -15552, -14566, -13561, -12526, -11469, -10394, -9294, -8178, -7047, -5900, -4744, -3580, -2411, -1210, -258};