/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0003 256 samples */
 
const int16_t AKWF_symetric_0003_256_DATA [256] = 
{1802, 5796, 9578, 13006, 15942, 18215, 19647, 20110, 19677, 18493, 16926, 15353, 14167, 13684, 13982, 15080, 16817, 18979, 21390, 23844, 26211, 28369, 30162, 31612, 32491, 32786, 32355, 31090, 29029, 26200, 22863, 19381, 16038, 13208, 11089, 9642, 8881, 8568, 8503, 8623, 8703, 8718, 8536, 8064, 7368, 6310, 4925, 3171, 1026, -1369, -3943, -6428, -8552, -10138, -10950, -11058, -10531, -9531, -8315, -7018, -5766, -4685, -3715, -3016, -2564, -2344, -2477, -2777, -3324, -3973, -4604, -5092, -5124, -4646, -3548, -1856, 179, 2354, 4696, 6781, 8443, 9643, 10346, 10576, 10300, 9608, 8473, 6947, 5206, 3308, 1514, 12, -974, -1231, -673, 792, 2867, 5278, 7629, 9542, 10841, 11380, 11217, 10427, 9179, 7555, 5654, 3494, 1203, -1156, -3397, -5291, -6621, -7123, -6670, -5191, -2836, 70, 3133, 5822, 7852, 8918, 9052, 8378, 7037, 5282, 3246, 1095, -1096, -3247, -5283, -7038, -8379, -9053, -8919, -7853, -5823, -3134, -71, 2835, 5190, 6669, 7122, 6620, 5290, 3396, 1155, -1204, -3494, -5655, -7556, -9180, -10427, -11218, -11381, -10842, -9543, -7630, -5279, -2868, -793, 672, 1230, 973, -13, -1515, -3309, -5207, -6947, -8474, -9609, -10301, -10577, -10347, -9644, -8443, -6781, -4697, -2355, -180, 1855, 3547, 4645, 5123, 5091, 4603, 3972, 3323, 2776, 2476, 2343, 2563, 3016, 3714, 4684, 5765, 7017, 8314, 9530, 10531, 11057, 10949, 10138, 8551, 6427, 3942, 1368, -1027, -3172, -4926, -6310, -7369, -8065, -8537, -8718, -8703, -8624, -8504, -8568, -8882, -9643, -11089, -13209, -16039, -19382, -22863, -26200, -29029, -31090, -32355, -32786, -32491, -31612, -30162, -28369, -26211, -23845, -21391, -18979, -16817, -15081, -13982, -13685, -14167, -15354, -16926, -18493, -19677, -20110, -19648, -18215, -15943, -13007, -9578, -5797, -1803};