/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0011 256 samples */
 
const int16_t AKWF_symetric_0011_256_DATA [256] = 
{256, 793, 1326, 1846, 2349, 2858, 3338, 3837, 4295, 4719, 5164, 5531, 5902, 6234, 6555, 6854, 7129, 7350, 7568, 7754, 7930, 8104, 8256, 8388, 8515, 8618, 8718, 8831, 8939, 9033, 9128, 9203, 9253, 9288, 9317, 9363, 9412, 9448, 9480, 9479, 9470, 9450, 9442, 9436, 9426, 9422, 9417, 9390, 9361, 9341, 9338, 9377, 9413, 9450, 9488, 9509, 9562, 9682, 9780, 9901, 10021, 10173, 10328, 10484, 10689, 10978, 11255, 11571, 11902, 12287, 12732, 13284, 13891, 14598, 15354, 16204, 17106, 18094, 19259, 20540, 21938, 23419, 24944, 26426, 27828, 29168, 30358, 31257, 31901, 32348, 32615, 32750, 32763, 32722, 32615, 32463, 32265, 32054, 31856, 31686, 31477, 31303, 31156, 31012, 30874, 30775, 30667, 30555, 30463, 30397, 30312, 30222, 30125, 30052, 29938, 29701, 29063, 27647, 24787, 19852, 13946, 8812, 5193, 3075, 1901, 1168, 650, 198, -199, -651, -1169, -1902, -3076, -5194, -8813, -13947, -19853, -24787, -27647, -29063, -29701, -29938, -30053, -30125, -30222, -30312, -30397, -30463, -30555, -30667, -30775, -30874, -31012, -31156, -31303, -31477, -31686, -31856, -32054, -32265, -32463, -32615, -32722, -32763, -32750, -32615, -32348, -31901, -31257, -30358, -29168, -27828, -26427, -24944, -23419, -21938, -20541, -19259, -18094, -17106, -16204, -15354, -14598, -13892, -13284, -12733, -12287, -11902, -11572, -11255, -10979, -10689, -10485, -10329, -10174, -10021, -9902, -9781, -9682, -9563, -9510, -9488, -9451, -9414, -9378, -9338, -9342, -9362, -9391, -9418, -9423, -9427, -9436, -9442, -9451, -9470, -9480, -9481, -9448, -9413, -9364, -9317, -9289, -9254, -9204, -9129, -9034, -8940, -8832, -8719, -8619, -8516, -8388, -8257, -8105, -7930, -7755, -7568, -7351, -7130, -6854, -6556, -6235, -5903, -5532, -5165, -4720, -4296, -3838, -3339, -2859, -2350, -1847, -1327, -794, -257};