/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0015 256 samples */
 
const int16_t AKWF_symetric_0015_256_DATA [256] = 
{797, 2962, 4629, 6320, 7965, 9564, 11112, 12592, 14006, 15350, 16610, 17788, 18885, 19892, 20813, 21648, 22398, 23069, 23662, 24180, 24633, 25015, 25340, 25616, 25842, 26027, 26179, 26301, 26402, 26484, 26557, 26622, 26685, 26748, 26817, 26895, 26983, 27083, 27198, 27328, 27472, 27634, 27811, 28003, 28211, 28427, 28656, 28895, 29139, 29392, 29647, 29903, 30160, 30413, 30661, 30905, 31140, 31363, 31575, 31773, 31957, 32123, 32274, 32404, 32517, 32608, 32679, 32730, 32759, 32768, 32758, 32727, 32678, 32615, 32536, 32443, 32338, 32224, 32101, 31974, 31844, 31714, 31586, 31462, 31342, 31229, 31126, 31029, 30940, 30865, 30800, 30741, 30689, 30642, 30600, 30557, 30510, 30457, 30394, 30313, 30210, 30080, 29917, 29713, 29463, 29158, 28794, 28359, 27850, 27267, 26592, 25828, 24971, 24006, 22943, 21782, 20509, 19136, 17666, 16095, 14438, 12696, 10877, 8996, 7056, 5070, 3056, 1020, -1021, -3056, -5071, -7057, -8996, -10877, -12697, -14438, -16095, -17666, -19136, -20510, -21782, -22943, -24006, -24971, -25828, -26592, -27267, -27850, -28359, -28794, -29159, -29463, -29713, -29917, -30080, -30210, -30313, -30394, -30457, -30510, -30557, -30600, -30642, -30689, -30741, -30800, -30865, -30940, -31029, -31126, -31229, -31342, -31462, -31586, -31714, -31844, -31974, -32101, -32224, -32338, -32443, -32536, -32615, -32678, -32727, -32758, -32768, -32759, -32730, -32679, -32608, -32517, -32404, -32274, -32123, -31957, -31773, -31575, -31363, -31140, -30905, -30661, -30413, -30160, -29903, -29647, -29392, -29139, -28895, -28656, -28427, -28211, -28004, -27811, -27634, -27472, -27328, -27198, -27083, -26983, -26895, -26817, -26749, -26685, -26622, -26557, -26485, -26402, -26302, -26179, -26027, -25842, -25616, -25340, -25016, -24633, -24181, -23662, -23070, -22398, -21649, -20813, -19892, -18886, -17789, -16611, -15351, -14007, -12592, -11112, -9565, -7966, -6321, -4630, -2963, -798};