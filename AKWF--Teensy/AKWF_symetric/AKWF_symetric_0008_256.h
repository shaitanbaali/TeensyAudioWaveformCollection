/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0008 256 samples */
 
const int16_t AKWF_symetric_0008_256_DATA [256] = 
{1230, 3848, 6378, 8738, 10903, 12832, 14473, 15803, 16821, 17586, 18277, 18814, 19157, 19377, 19389, 19206, 18893, 18445, 17979, 17700, 17516, 17348, 17285, 17193, 17015, 16731, 16265, 15791, 15368, 14941, 14491, 14077, 13690, 13221, 12706, 12246, 11927, 11811, 11874, 12117, 12600, 13360, 14263, 15317, 16651, 18200, 19953, 21831, 23701, 25581, 27322, 28710, 29857, 30850, 31694, 32339, 32704, 32736, 32354, 31519, 30225, 28602, 26766, 24754, 22671, 20572, 18384, 16164, 13947, 11591, 9078, 6499, 4027, 1806, -316, -2574, -4743, -6863, -9203, -11532, -13716, -15768, -17656, -19653, -21734, -23493, -24994, -26409, -27507, -28175, -28555, -28539, -28218, -27722, -26827, -25875, -25062, -24107, -22941, -21605, -20032, -18612, -17630, -16754, -16366, -16581, -16725, -16861, -17203, -17289, -17452, -17739, -17774, -17964, -18123, -17765, -17527, -17230, -16112, -14852, -13724, -12224, -10501, -8791, -6901, -5072, -3077, -818, 817, 3076, 5071, 6900, 8790, 10501, 12224, 13724, 14852, 16112, 17229, 17527, 17765, 18122, 17964, 17774, 17739, 17452, 17289, 17203, 16860, 16725, 16580, 16366, 16753, 17630, 18612, 20032, 21604, 22941, 24107, 25062, 25875, 26827, 27722, 28218, 28539, 28555, 28175, 27507, 26409, 24994, 23492, 21734, 19653, 17656, 15767, 13716, 11531, 9202, 6862, 4742, 2573, 315, -1806, -4028, -6500, -9078, -11592, -13947, -16164, -18384, -20573, -22671, -24755, -26766, -28602, -30225, -31519, -32354, -32736, -32704, -32339, -31694, -30850, -29857, -28711, -27322, -25581, -23701, -21831, -19953, -18201, -16651, -15318, -14264, -13361, -12600, -12118, -11874, -11812, -11928, -12246, -12707, -13222, -13691, -14078, -14492, -14941, -15369, -15791, -16266, -16731, -17016, -17194, -17286, -17349, -17517, -17700, -17979, -18446, -18894, -19207, -19389, -19377, -19157, -18814, -18278, -17587, -16821, -15803, -14473, -12832, -10903, -8739, -6379, -3848, -1231};