/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0001 256 samples */
 
const int16_t AKWF_symetric_0001_256_DATA [256] = 
{1246, 3819, 6377, 8896, 11388, 13835, 16261, 18640, 20902, 23013, 24943, 26752, 28273, 29620, 30729, 31563, 32166, 32569, 32751, 32720, 32504, 32117, 31674, 31052, 30394, 29639, 28880, 28086, 27268, 26440, 25584, 24777, 23898, 23058, 22216, 21384, 20569, 19693, 18967, 18145, 17359, 16538, 15739, 14948, 14152, 13352, 12553, 11698, 10838, 9971, 9047, 8162, 7208, 6210, 5221, 4246, 3237, 2249, 1256, 298, -622, -1491, -2304, -2960, -3534, -3941, -4176, -4251, -4092, -3708, -3089, -2229, -1131, 206, 1699, 3366, 5226, 7031, 8925, 10773, 12565, 14301, 15901, 17327, 18668, 19858, 20886, 21784, 22529, 23137, 23594, 23968, 24202, 24374, 24430, 24425, 24384, 24195, 23936, 23684, 23337, 22882, 22431, 21931, 21362, 20745, 20055, 19362, 18603, 17836, 17011, 16182, 15281, 14428, 13498, 12557, 11608, 10634, 9673, 8670, 7671, 6651, 5652, 4644, 3620, 2586, 1553, 523, -524, -1554, -2587, -3621, -4645, -5653, -6652, -7671, -8671, -9674, -10634, -11609, -12558, -13498, -14428, -15282, -16183, -17011, -17837, -18604, -19363, -20056, -20745, -21363, -21931, -22431, -22882, -23337, -23684, -23936, -24195, -24384, -24425, -24430, -24374, -24202, -23969, -23595, -23138, -22529, -21785, -20887, -19859, -18669, -17327, -15902, -14301, -12566, -10774, -8926, -7032, -5227, -3367, -1700, -207, 1130, 2228, 3088, 3708, 4091, 4250, 4175, 3940, 3533, 2960, 2303, 1490, 621, -299, -1256, -2250, -3238, -4247, -5221, -6211, -7209, -8163, -9048, -9972, -10839, -11699, -12553, -13353, -14152, -14949, -15739, -16538, -17360, -18146, -18968, -19693, -20569, -21385, -22216, -23058, -23898, -24777, -25584, -26441, -27268, -28087, -28880, -29639, -30394, -31052, -31674, -32117, -32504, -32720, -32751, -32569, -32166, -31563, -30729, -29620, -28273, -26752, -24944, -23013, -20903, -18640, -16261, -13836, -11389, -8897, -6378, -3820, -1247};