/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0013 256 samples */
 
const int16_t AKWF_symetric_0013_256_DATA [256] = 
{1255, 3825, 6119, 8123, 9862, 11401, 12822, 14206, 15607, 17017, 18405, 19729, 20931, 21960, 22815, 23508, 24072, 24547, 24965, 25350, 25697, 26007, 26294, 26569, 26846, 27135, 27433, 27728, 28011, 28267, 28496, 28707, 28902, 29085, 29262, 29432, 29594, 29752, 29912, 30074, 30243, 30418, 30594, 30769, 30931, 31078, 31208, 31321, 31419, 31503, 31579, 31646, 31704, 31756, 31813, 31877, 31954, 32043, 32142, 32247, 32352, 32451, 32539, 32610, 32670, 32717, 32755, 32766, 32755, 32748, 32708, 32586, 32393, 32134, 31800, 31363, 30801, 30095, 29239, 28235, 27119, 25916, 24668, 23405, 22118, 20822, 19559, 18351, 17227, 16207, 15274, 14423, 13633, 12888, 12188, 11538, 10928, 10364, 9837, 9345, 8885, 8455, 8054, 7683, 7341, 7026, 6732, 6450, 6170, 5888, 5596, 5296, 4987, 4668, 4340, 4007, 3665, 3318, 2973, 2630, 2294, 1967, 1644, 1331, 1026, 725, 432, 142, -143, -433, -726, -1027, -1332, -1645, -1968, -2295, -2631, -2974, -3319, -3665, -4007, -4341, -4669, -4988, -5297, -5597, -5889, -6171, -6451, -6733, -7026, -7342, -7683, -8055, -8456, -8886, -9345, -9838, -10364, -10929, -11538, -12188, -12889, -13633, -14423, -15275, -16208, -17227, -18351, -19559, -20823, -22118, -23406, -24668, -25917, -27119, -28235, -29239, -30095, -30801, -31363, -31800, -32134, -32393, -32586, -32708, -32748, -32755, -32766, -32755, -32717, -32670, -32610, -32539, -32451, -32352, -32247, -32142, -32043, -31954, -31877, -31813, -31756, -31704, -31646, -31579, -31503, -31419, -31321, -31208, -31078, -30931, -30769, -30594, -30418, -30243, -30074, -29912, -29752, -29594, -29432, -29262, -29086, -28902, -28707, -28496, -28267, -28011, -27728, -27433, -27136, -26846, -26570, -26294, -26007, -25698, -25350, -24965, -24547, -24073, -23508, -22816, -21960, -20932, -19729, -18405, -17017, -15608, -14207, -12823, -11402, -9863, -8124, -6120, -3826, -1256};