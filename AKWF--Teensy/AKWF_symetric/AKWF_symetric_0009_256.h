/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0009 256 samples */
 
const int16_t AKWF_symetric_0009_256_DATA [256] = 
{431, 1335, 2205, 3061, 3894, 4703, 5494, 6264, 7021, 7772, 8513, 9253, 9995, 10730, 11466, 12201, 12930, 13658, 14384, 15101, 15814, 16521, 17217, 17906, 18583, 19245, 19893, 20521, 21131, 21726, 22305, 22867, 23416, 23953, 24477, 24994, 25498, 25988, 26465, 26925, 27365, 27789, 28189, 28567, 28925, 29261, 29581, 29889, 30185, 30474, 30756, 31031, 31300, 31556, 31795, 32008, 32193, 32357, 32498, 32605, 32680, 32731, 32760, 32768, 32760, 32735, 32693, 32633, 32558, 32464, 32351, 32220, 32070, 31899, 31710, 31500, 31273, 31028, 30765, 30486, 30194, 29884, 29562, 29227, 28876, 28512, 28134, 27735, 27320, 26886, 26429, 25954, 25460, 24947, 24419, 23878, 23322, 22760, 22187, 21605, 21013, 20408, 19790, 19161, 18514, 17855, 17181, 16489, 15788, 15071, 14341, 13598, 12842, 12074, 11294, 10500, 9695, 8879, 8055, 7223, 6383, 5541, 4693, 3842, 2992, 2137, 1283, 428, -429, -1284, -2138, -2992, -3843, -4694, -5542, -6384, -7224, -8056, -8879, -9696, -10501, -11295, -12075, -12843, -13598, -14341, -15072, -15788, -16490, -17181, -17855, -18515, -19161, -19790, -20408, -21013, -21605, -22187, -22761, -23323, -23878, -24420, -24947, -25460, -25954, -26429, -26886, -27320, -27735, -28134, -28512, -28876, -29227, -29562, -29884, -30194, -30486, -30765, -31028, -31273, -31500, -31710, -31900, -32070, -32220, -32351, -32464, -32558, -32633, -32693, -32735, -32760, -32768, -32760, -32731, -32680, -32605, -32498, -32357, -32194, -32008, -31795, -31556, -31300, -31031, -30756, -30474, -30185, -29889, -29581, -29261, -28925, -28567, -28189, -27789, -27366, -26925, -26466, -25988, -25499, -24995, -24478, -23954, -23417, -22867, -22305, -21726, -21131, -20521, -19893, -19246, -18584, -17906, -17217, -16521, -15815, -15102, -14385, -13659, -12930, -12201, -11467, -10731, -9996, -9254, -8514, -7773, -7022, -6265, -5495, -4704, -3895, -3062, -2206, -1336, -432};