/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0005 256 samples */
 
const int16_t AKWF_symetric_0005_256_DATA [256] = 
{614, 1891, 3213, 4561, 6117, 7930, 9721, 11518, 13272, 14896, 16509, 18130, 19899, 21710, 23536, 25195, 26483, 27473, 28401, 28903, 29250, 29627, 29957, 30240, 30597, 30953, 31279, 31611, 31941, 32263, 32632, 32674, 32068, 31455, 30838, 30533, 30380, 30227, 29904, 29243, 28577, 27938, 27644, 27438, 27216, 26965, 26596, 26197, 25954, 25720, 25435, 25130, 24802, 24487, 24254, 24035, 23802, 23450, 22522, 20772, 19529, 18498, 16745, 14091, 11525, 8883, 6578, 5481, 4794, 2022, -147, -1093, -2330, -3763, -5159, -6209, -7078, -7933, -8996, -10640, -12253, -15396, -17059, -17608, -18383, -18996, -19426, -19870, -20312, -20746, -21231, -21820, -22408, -22999, -23574, -24224, -25078, -25486, -25772, -25977, -25971, -25970, -25973, -25977, -25565, -24781, -23941, -23388, -23740, -23488, -22001, -20371, -19579, -19524, -19216, -18875, -18798, -17747, -15248, -13706, -11798, -9109, -7627, -5894, -4181, -2210, -1260, -691, 690, 1259, 2209, 4180, 5893, 7626, 9109, 11797, 13705, 15247, 17747, 18798, 18875, 19215, 19524, 19579, 20370, 22001, 23488, 23740, 23388, 23940, 24781, 25565, 25976, 25972, 25970, 25971, 25977, 25772, 25486, 25078, 24223, 23574, 22998, 22408, 21820, 21231, 20746, 20312, 19870, 19425, 18996, 18383, 17607, 17059, 15396, 12253, 10639, 8996, 7932, 7077, 6208, 5158, 3762, 2329, 1092, 146, -2023, -4795, -5482, -6579, -8884, -11526, -14092, -16745, -18498, -19530, -20772, -22522, -23450, -23802, -24035, -24254, -24488, -24802, -25130, -25436, -25720, -25954, -26198, -26596, -26965, -27216, -27438, -27645, -27939, -28577, -29243, -29904, -30227, -30380, -30533, -30838, -31455, -32068, -32674, -32632, -32263, -31941, -31611, -31279, -30953, -30597, -30240, -29957, -29627, -29250, -28903, -28401, -27474, -26483, -25195, -23537, -21710, -19899, -18130, -16509, -14897, -13273, -11519, -9722, -7931, -6118, -4562, -3214, -1892, -615};