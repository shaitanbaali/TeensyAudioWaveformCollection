/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0012 256 samples */
 
const int16_t AKWF_symetric_0012_256_DATA [256] = 
{2784, 7707, 10579, 12046, 13254, 14743, 16388, 17956, 19421, 20701, 21712, 22442, 22992, 23427, 23774, 24129, 24571, 25106, 25667, 26219, 26762, 27260, 27676, 28017, 28314, 28584, 28836, 29090, 29364, 29654, 29937, 30203, 30447, 30652, 30805, 30923, 31017, 31106, 31194, 31302, 31438, 31594, 31756, 31922, 32085, 32219, 32307, 32389, 32466, 32522, 32563, 32595, 32624, 32655, 32681, 32707, 32737, 32760, 32767, 32765, 32756, 32741, 32720, 32709, 32712, 32724, 32735, 32742, 32737, 32705, 32639, 32549, 32444, 32331, 32215, 32109, 32021, 31947, 31881, 31824, 31779, 31730, 31669, 31598, 31515, 31411, 31287, 31151, 31015, 30877, 30736, 30602, 30471, 30328, 30158, 29968, 29754, 29500, 29211, 28910, 28624, 28351, 28093, 27867, 27672, 27474, 27242, 26960, 26638, 26285, 25894, 25424, 24821, 24039, 23003, 21604, 19814, 17734, 15508, 13214, 10976, 8942, 7184, 5657, 4279, 3000, 1785, 593, -594, -1786, -3001, -4279, -5658, -7185, -8943, -10977, -13215, -15509, -17735, -19814, -21604, -23003, -24039, -24821, -25425, -25895, -26285, -26638, -26960, -27243, -27474, -27672, -27867, -28093, -28352, -28624, -28910, -29211, -29501, -29754, -29968, -30158, -30328, -30471, -30602, -30736, -30877, -31015, -31151, -31287, -31411, -31515, -31598, -31669, -31730, -31779, -31824, -31881, -31947, -32021, -32109, -32215, -32331, -32444, -32549, -32639, -32705, -32737, -32742, -32735, -32724, -32712, -32709, -32720, -32741, -32756, -32765, -32767, -32760, -32737, -32707, -32681, -32655, -32624, -32595, -32563, -32522, -32466, -32389, -32307, -32219, -32085, -31922, -31757, -31594, -31438, -31302, -31194, -31106, -31017, -30923, -30805, -30652, -30447, -30203, -29937, -29654, -29364, -29091, -28836, -28584, -28314, -28017, -27677, -27260, -26762, -26219, -25667, -25106, -24572, -24130, -23775, -23428, -22992, -22443, -21713, -20702, -19422, -17957, -16389, -14744, -13254, -12047, -10580, -7707, -2784};