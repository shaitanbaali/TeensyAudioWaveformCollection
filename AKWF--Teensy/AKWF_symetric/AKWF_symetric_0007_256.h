/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0007 256 samples */
 
const int16_t AKWF_symetric_0007_256_DATA [256] = 
{17006, 16833, 16959, 17312, 17386, 17369, 18130, 18845, 18967, 19163, 19402, 19505, 19668, 19840, 20075, 20406, 20932, 21466, 21999, 22530, 23063, 23595, 24127, 24660, 25193, 25724, 26257, 26767, 27268, 27770, 28274, 28776, 29278, 29782, 30281, 30781, 31177, 32147, 32824, 32661, 32636, 32539, 32418, 32315, 32139, 31836, 31536, 30931, 32268, 22178, 12523, 14162, 13846, 13813, 13782, 13692, 13562, 13457, 13417, 13401, 13373, 13317, 13265, 13211, 13160, 13116, 13072, 13028, 12982, 12940, 12901, 12864, 12826, 12787, 12750, 12713, 12680, 12647, 12612, 12579, 12546, 12512, 12475, 12430, 12387, 12342, 12300, 12243, 12154, 11927, 12604, 8963, 260, 937, 736, 677, 648, 620, 593, 565, 537, 508, 480, 452, 424, 396, 369, 341, 312, 284, 256, 229, 218, 210, 200, 191, 182, 174, 166, 150, 132, 115, 96, 78, 61, 44, 25, 8, -9, -26, -45, -62, -79, -97, -116, -133, -151, -167, -175, -183, -192, -201, -211, -219, -230, -257, -285, -313, -342, -370, -397, -425, -453, -481, -509, -538, -566, -593, -621, -649, -678, -737, -938, -261, -8963, -12605, -11928, -12154, -12244, -12300, -12343, -12387, -12431, -12476, -12513, -12547, -12580, -12613, -12647, -12680, -12713, -12750, -12788, -12827, -12864, -12902, -12941, -12983, -13028, -13073, -13117, -13160, -13211, -13265, -13317, -13374, -13402, -13418, -13458, -13562, -13692, -13782, -13813, -13847, -14163, -12523, -22178, -32268, -30931, -31536, -31836, -32139, -32315, -32418, -32539, -32636, -32661, -32824, -32147, -31177, -30781, -30281, -29782, -29278, -28776, -28274, -27770, -27268, -26767, -26257, -25724, -25193, -24660, -24128, -23596, -23063, -22531, -22000, -21467, -20932, -20406, -20076, -19841, -19668, -19506, -19403, -19164, -18968, -18845, -18130, -17369, -17387, -17313, -16959, -16833, -17006};