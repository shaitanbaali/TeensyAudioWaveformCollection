/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0017 256 samples */
 
const int16_t AKWF_symetric_0017_256_DATA [256] = 
{218, 813, 886, 884, 1190, 1557, 1481, 1807, 2363, 2484, 2893, 3076, 2989, 3632, 4302, 4460, 4810, 4813, 4760, 5068, 5280, 5220, 5634, 6165, 6040, 6688, 7056, 6961, 7530, 7915, 7795, 8266, 8578, 8500, 8510, 8935, 9141, 9714, 10136, 9980, 10190, 11070, 11369, 11497, 11603, 11525, 11713, 12274, 12151, 12753, 13198, 13032, 13264, 14012, 13922, 14345, 14703, 14577, 14757, 15317, 15252, 15494, 15783, 16066, 16291, 17142, 17483, 17606, 17704, 17826, 18015, 18367, 18315, 18578, 19103, 19206, 19329, 20100, 20092, 20179, 20610, 20741, 20850, 21630, 21599, 21858, 22235, 22272, 22310, 22657, 22905, 23274, 23646, 23805, 23894, 24656, 24718, 25154, 25384, 25289, 25421, 26190, 26237, 26143, 26614, 26887, 26928, 27721, 27720, 27946, 28345, 28373, 28460, 29234, 29297, 29219, 29501, 29728, 29932, 30766, 30729, 31214, 31421, 31801, 12772, 6798, 9217, 4810, -4811, -9218, -6799, -12773, -31801, -31421, -31215, -30729, -30766, -29932, -29728, -29501, -29219, -29297, -29234, -28460, -28373, -28345, -27946, -27720, -27721, -26928, -26887, -26614, -26144, -26237, -26190, -25421, -25290, -25384, -25154, -24718, -24657, -23894, -23805, -23646, -23274, -22905, -22658, -22310, -22273, -22235, -21858, -21599, -21631, -20850, -20742, -20610, -20180, -20093, -20100, -19330, -19207, -19104, -18578, -18315, -18367, -18015, -17826, -17705, -17607, -17483, -17142, -16292, -16066, -15783, -15494, -15252, -15318, -14757, -14577, -14703, -14345, -13922, -14013, -13265, -13032, -13198, -12753, -12152, -12274, -11714, -11526, -11604, -11498, -11369, -11071, -10191, -9981, -10137, -9714, -9142, -8935, -8511, -8500, -8578, -8267, -7796, -7916, -7530, -6962, -7057, -6688, -6041, -6166, -5635, -5221, -5281, -5069, -4761, -4814, -4811, -4461, -4303, -3633, -2990, -3077, -2894, -2485, -2364, -1808, -1482, -1558, -1191, -885, -887, -814, -219};