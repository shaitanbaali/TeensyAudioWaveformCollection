/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0004 256 samples */
 
const int16_t AKWF_symetric_0004_256_DATA [256] = 
{1502, 4648, 8601, 11626, 12542, 13622, 14617, 15556, 16450, 17298, 18107, 18883, 19619, 20321, 20991, 21617, 22216, 22789, 23328, 23835, 24306, 24744, 25157, 25544, 25900, 26228, 26512, 26769, 27002, 27203, 27387, 27530, 27634, 27656, 27630, 28421, -17150, -23225, -17622, -15330, -12925, -10741, -8705, -6780, -4963, -3246, -1614, -82, 1394, 2805, 4145, 5427, 6642, 7793, 8876, 9884, 10812, 11666, 12448, 13160, 13779, 14316, 14770, 15139, 15431, 15643, 15777, 15839, 15828, 15745, 15592, 15374, 15083, 14709, 14400, 13096, 11111, 9699, 8395, 7172, 6011, 4890, 3789, 2718, 1702, 739, -183, -1063, -1912, -2726, -3515, -4288, -5050, -5819, -6603, -7430, -8337, -9831, -10290, -9830, -9437, -8967, -8432, -7850, -7216, -6529, -5805, -5039, -4235, -3400, -2529, -1637, -660, 370, 1400, 2440, 3484, 4395, 6454, -10274, -13643, -10543, -8999, -7320, -5670, -4036, -2415, -809, 808, 2414, 4035, 5669, 7320, 8998, 10543, 13643, 10273, -6455, -4396, -3485, -2441, -1401, -371, 659, 1636, 2528, 3399, 4234, 5039, 5804, 6528, 7215, 7849, 8431, 8966, 9437, 9830, 10289, 9830, 8336, 7430, 6602, 5818, 5050, 4287, 3514, 2725, 1911, 1062, 182, -740, -1703, -2719, -3790, -4891, -6012, -7173, -8396, -9700, -11112, -13096, -14401, -14710, -15083, -15374, -15592, -15746, -15829, -15839, -15778, -15643, -15431, -15140, -14770, -14317, -13780, -13161, -12449, -11666, -10812, -9885, -8877, -7794, -6643, -5427, -4146, -2806, -1395, 81, 1613, 3245, 4962, 6779, 8704, 10740, 12924, 15329, 17621, 23225, 17149, -28421, -27630, -27656, -27634, -27530, -27388, -27203, -27002, -26769, -26512, -26228, -25900, -25544, -25157, -24744, -24306, -23835, -23328, -22789, -22216, -21617, -20991, -20321, -19620, -18883, -18107, -17298, -16451, -15556, -14618, -13623, -12543, -11627, -8602, -4649, -1503};