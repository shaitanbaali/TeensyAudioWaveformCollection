/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0010 256 samples */
 
const int16_t AKWF_symetric_0010_256_DATA [256] = 
{689, 2346, 3966, 5570, 7138, 7472, 9177, 10617, 11927, 13237, 14527, 15802, 17061, 18295, 19508, 20696, 21850, 22975, 24064, 25111, 26118, 27077, 27980, 28828, 29613, 30329, 30969, 31525, 31992, 32357, 32614, 32752, 32755, 32616, 32315, 31838, 31169, 30286, 29166, 27790, 26128, 24161, 21856, 20297, 17626, 13128, 8604, 4963, -617, -4936, -6877, -14574, -15915, -15268, -15084, -14857, -14661, -14494, -14354, -14285, -14024, -13385, -12952, -12509, -12048, -11572, -11092, -10609, -10132, -9668, -9209, -8773, -8360, -7963, -7594, -7246, -6935, -6625, -6475, -6917, -6974, -6973, -7115, -7322, -7613, -7936, -8275, -8629, -8998, -9379, -9778, -10186, -10595, -11011, -11425, -11840, -12250, -12664, -13021, -13327, -13701, -14053, -14377, -14673, -14946, -15191, -15401, -15566, -15669, -15580, -14998, -14131, -13500, -13466, -13179, -12759, -12287, -11803, -11317, -10821, -10299, -9738, -9118, -8435, -7694, -6693, -7261, -7394, 7393, 7260, 6692, 7693, 8434, 9118, 9738, 10298, 10820, 11317, 11802, 12286, 12758, 13178, 13465, 13500, 14130, 14997, 15579, 15668, 15566, 15400, 15190, 14945, 14673, 14376, 14053, 13701, 13327, 13021, 12664, 12249, 11839, 11424, 11011, 10594, 10186, 9777, 9379, 8997, 8629, 8274, 7935, 7612, 7321, 7115, 6972, 6974, 6916, 6474, 6624, 6934, 7245, 7593, 7963, 8359, 8773, 9208, 9667, 10131, 10608, 11091, 11572, 12047, 12508, 12952, 13384, 14023, 14285, 14353, 14494, 14660, 14856, 15083, 15268, 15915, 14573, 6876, 4935, 616, -4964, -8605, -13129, -17626, -20297, -21857, -24162, -26129, -27790, -29166, -30286, -31169, -31838, -32315, -32616, -32755, -32752, -32614, -32357, -31992, -31525, -30969, -30329, -29613, -28828, -27980, -27077, -26118, -25111, -24064, -22976, -21850, -20697, -19508, -18296, -17061, -15803, -14527, -13237, -11928, -10617, -9178, -7473, -7139, -5571, -3967, -2347, -690};