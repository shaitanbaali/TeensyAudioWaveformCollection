/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0016 256 samples */
 
const int16_t AKWF_symetric_0016_256_DATA [256] = 
{410, 1354, 2394, 3571, 4847, 6158, 7444, 8669, 9837, 10962, 12050, 13107, 14119, 15072, 15966, 16804, 17587, 18321, 19002, 19627, 20198, 20715, 21182, 21606, 21986, 22323, 22624, 22890, 23123, 23329, 23509, 23666, 23805, 23927, 24039, 24141, 24236, 24326, 24412, 24497, 24582, 24671, 24765, 24863, 24966, 25078, 25196, 25323, 25456, 25596, 25745, 25902, 26069, 26244, 26426, 26616, 26812, 27015, 27227, 27446, 27670, 27901, 28137, 28376, 28623, 28872, 29122, 29375, 29628, 29881, 30134, 30386, 30635, 30879, 31114, 31343, 31563, 31770, 31964, 32143, 32302, 32440, 32557, 32649, 32718, 32756, 32766, 32741, 32681, 32585, 32453, 32280, 32068, 31815, 31518, 31178, 30792, 30361, 29886, 29365, 28802, 28191, 27536, 26836, 26094, 25309, 24486, 23622, 22721, 21785, 20812, 19804, 18767, 17697, 16599, 15478, 14328, 13156, 11965, 10754, 9528, 8288, 7033, 5769, 4497, 3214, 1931, 645, -646, -1932, -3215, -4498, -5770, -7034, -8289, -9528, -10755, -11966, -13157, -14328, -15478, -16599, -17698, -18768, -19804, -20812, -21786, -22721, -23623, -24486, -25309, -26094, -26836, -27536, -28191, -28802, -29366, -29886, -30361, -30792, -31178, -31518, -31815, -32068, -32280, -32453, -32585, -32681, -32741, -32766, -32756, -32718, -32649, -32557, -32440, -32302, -32143, -31964, -31770, -31563, -31343, -31114, -30879, -30635, -30386, -30134, -29881, -29628, -29375, -29122, -28872, -28623, -28376, -28137, -27901, -27670, -27446, -27228, -27015, -26812, -26617, -26427, -26244, -26069, -25902, -25745, -25597, -25457, -25323, -25197, -25078, -24967, -24864, -24765, -24671, -24583, -24497, -24412, -24326, -24236, -24142, -24039, -23927, -23805, -23666, -23509, -23329, -23123, -22890, -22625, -22324, -21986, -21606, -21183, -20715, -20199, -19627, -19003, -18322, -17588, -16805, -15967, -15073, -14120, -13107, -12051, -10963, -9837, -8670, -7445, -6159, -4848, -3572, -2395, -1355, -411};