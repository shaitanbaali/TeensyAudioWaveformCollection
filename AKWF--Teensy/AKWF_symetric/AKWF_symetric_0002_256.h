/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_symetric_0002 256 samples */
 
const int16_t AKWF_symetric_0002_256_DATA [256] = 
{377, 1174, 1980, 2812, 3647, 4469, 5270, 6049, 6827, 7607, 8380, 9135, 9861, 10563, 11255, 11942, 12613, 13265, 13890, 14494, 15083, 15652, 16195, 16718, 17226, 17728, 18226, 18702, 19145, 19566, 19980, 20401, 20824, 21227, 21602, 21959, 22322, 22707, 23103, 23481, 23831, 24156, 24483, 24832, 25200, 25565, 25911, 26239, 26566, 26908, 27267, 27628, 27975, 28304, 28620, 28936, 29253, 29569, 29879, 30177, 30467, 30750, 31019, 31270, 31501, 31717, 31924, 32124, 32305, 32452, 32555, 32624, 32671, 32713, 32751, 32769, 32742, 32657, 32520, 32354, 32187, 32026, 31854, 31638, 31353, 31005, 30627, 30247, 29872, 29485, 29058, 28586, 28079, 27557, 27024, 26468, 25871, 25241, 24587, 23921, 23247, 22554, 21843, 21117, 20378, 19625, 18851, 18049, 17228, 16407, 15587, 14763, 13923, 13053, 12165, 11278, 10399, 9527, 8651, 7758, 6853, 5944, 5034, 4127, 3218, 2302, 1382, 461, -462, -1383, -2303, -3219, -4128, -5035, -5945, -6854, -7759, -8652, -9528, -10399, -11279, -12166, -13053, -13923, -14764, -15587, -16407, -17229, -18049, -18852, -19625, -20379, -21117, -21843, -22555, -23248, -23921, -24588, -25241, -25872, -26468, -27024, -27557, -28079, -28586, -29058, -29485, -29872, -30247, -30627, -31005, -31353, -31638, -31854, -32026, -32187, -32354, -32520, -32657, -32742, -32769, -32751, -32713, -32671, -32624, -32555, -32452, -32305, -32124, -31924, -31717, -31501, -31270, -31019, -30750, -30467, -30178, -29879, -29569, -29254, -28936, -28620, -28304, -27975, -27628, -27267, -26908, -26566, -26239, -25911, -25565, -25200, -24833, -24484, -24156, -23831, -23482, -23103, -22707, -22322, -21959, -21603, -21227, -20825, -20402, -19980, -19567, -19146, -18702, -18226, -17728, -17226, -16718, -16195, -15652, -15084, -14495, -13891, -13266, -12614, -11942, -11256, -10564, -9862, -9135, -8380, -7608, -6828, -6050, -5270, -4470, -3648, -2813, -1981, -1175, -378};