/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0098 256 samples */
 
const int16_t AKWF_squ_0098_256_DATA [256] = 
{200, 487, 771, 1056, 1340, 1624, 1909, 2193, 2478, 2763, 3047, 3332, 3616, 3900, 4185, 4469, 4754, 5039, 5323, 5606, 5891, 6176, 6461, 6745, 7029, 7313, 7598, 7884, 8167, 8452, 8736, 9020, 9305, 9590, 9874, 10159, 10442, 10727, 11013, 11297, 11581, 11865, 12149, 12435, 12719, 13002, 13287, 13572, 13856, 14141, 14426, 14709, 14994, 15279, 15563, 15848, 16133, 16417, 16701, 16986, 17271, 17555, 17840, 18122, 18408, 18692, 18978, 19261, 19545, 19830, 20114, 20399, 20684, 20968, 21253, 21536, 21822, 22107, 22391, 22675, 22959, 23243, 23529, 23813, 24098, 24382, 24665, 24952, 25235, 25520, 25804, 26088, 26372, 26658, 26942, 27226, 27511, 27795, 28079, 28365, 28649, 28933, 29217, 29501, 29787, 30072, 30355, 30639, 30924, 31208, 31494, 31778, 32062, 32343, 32642, 32779, 32764, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};