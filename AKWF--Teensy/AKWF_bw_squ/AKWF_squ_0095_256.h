/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0095 256 samples */
 
const int16_t AKWF_squ_0095_256_DATA [256] = 
{224, 549, 867, 1188, 1508, 1829, 2148, 2468, 2788, 3108, 3427, 3746, 4068, 4388, 4709, 5028, 5349, 5668, 5988, 6308, 6629, 6948, 7269, 7588, 7908, 8229, 8548, 8869, 9188, 9509, 9828, 10149, 10468, 10788, 11109, 11428, 11748, 12069, 12389, 12708, 13029, 13348, 13668, 13989, 14308, 14629, 14949, 15270, 15588, 15909, 16228, 16549, 16868, 17188, 17509, 17829, 18150, 18468, 18790, 19109, 19429, 19749, 20070, 20388, 20710, 21029, 21349, 21670, 21988, 22309, 22629, 22950, 23269, 23591, 23909, 24229, 24550, 24868, 25190, 25510, 25829, 26149, 26470, 26788, 27109, 27430, 27748, 28070, 28390, 28709, 29030, 29350, 29668, 29989, 30310, 30630, 30950, 31270, 31590, 31910, 32226, 32561, 32774, 32766, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};