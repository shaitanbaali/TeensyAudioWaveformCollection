/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0015 256 samples */
 
const int16_t AKWF_squ_0015_256_DATA [256] = 
{5213, 9954, 9385, 9806, 10072, 10339, 10604, 10870, 11135, 11402, 11667, 11933, 12200, 12466, 12732, 12998, 13264, 13531, 13797, 14063, 14328, 14595, 14860, 15127, 15392, 15659, 15926, 16191, 16458, 16723, 16989, 17255, 17521, 17787, 18053, 18319, 18586, 18851, 19117, 19384, 19650, 19916, 20182, 20448, 20715, 20979, 21246, 21511, 21777, 22044, 22311, 22576, 22842, 23109, 23374, 23641, 23906, 24172, 24438, 24704, 24970, 25237, 25502, 25769, 26036, 26301, 26567, 26833, 27098, 27365, 27632, 27897, 28163, 28429, 28695, 28961, 29228, 29493, 29760, 30025, 30292, 30557, 30825, 31089, 31356, 31621, 31887, 32153, 32419, 32690, 32778, 32764, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32633, 32701, 33449, -16970, -35778, -32065, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767};