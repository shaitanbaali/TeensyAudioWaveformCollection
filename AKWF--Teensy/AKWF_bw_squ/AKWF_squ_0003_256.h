/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0003 256 samples */
 
const int16_t AKWF_squ_0003_256_DATA [256] = 
{3441, 8219, 12550, 16542, 20024, 22932, 25297, 27190, 28684, 29847, 30741, 31417, 31920, 32278, 32521, 32671, 32747, 32767, 32742, 32684, 32605, 32511, 32411, 32307, 32204, 32105, 32011, 31926, 31847, 31777, 31715, 31661, 31614, 31574, 31539, 31510, 31487, 31467, 31451, 31437, 31428, 31420, 31413, 31407, 31404, 31401, 31400, 31398, 31397, 31396, 31396, 31396, 31397, 31397, 31398, 31397, 31398, 31399, 31398, 31399, 31399, 31400, 31400, 31401, 31402, 31401, 31401, 31402, 31402, 31401, 31401, 31402, 31402, 31401, 31402, 31402, 31402, 31403, 31402, 31402, 31402, 31402, 31402, 31402, 31403, 31402, 31403, 31402, 31402, 31403, 31402, 31402, 31402, 31402, 31402, 31402, 31402, 31403, 31402, 31402, 31402, 31402, 31402, 31402, 31403, 31402, 31403, 31402, 31402, 31402, 31402, 31402, 31402, 31402, 31402, 31402, 31403, 31403, 31402, 31402, 31407, 31376, 31428, 32447, 27492, 16704, 9103, 2304, -3315, -7995, -12350, -16356, -19867, -22809, -25206, -27118, -28619, -29797, -30703, -31391, -31900, -32262, -32512, -32666, -32746, -32767, -32744, -32688, -32610, -32516, -32415, -32312, -32209, -32109, -32016, -31929, -31851, -31780, -31718, -31663, -31616, -31575, -31541, -31512, -31488, -31468, -31451, -31438, -31428, -31420, -31412, -31409, -31404, -31401, -31399, -31397, -31397, -31397, -31396, -31397, -31396, -31397, -31397, -31398, -31398, -31399, -31399, -31399, -31399, -31401, -31400, -31401, -31400, -31401, -31402, -31402, -31401, -31402, -31401, -31401, -31402, -31401, -31402, -31402, -31402, -31402, -31402, -31402, -31402, -31402, -31402, -31402, -31403, -31402, -31402, -31402, -31402, -31402, -31403, -31402, -31402, -31402, -31402, -31402, -31402, -31402, -31403, -31402, -31402, -31402, -31402, -31403, -31402, -31402, -31403, -31403, -31402, -31401, -31401, -31402, -31403, -31402, -31401, -31402, -31403, -31402, -31402, -31402, -31406, -31382, -31398, -32444, -27972, -17127, -9462, -2456};