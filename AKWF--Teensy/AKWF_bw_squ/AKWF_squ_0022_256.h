/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0022 256 samples */
 
const int16_t AKWF_squ_0022_256_DATA [256] = 
{18168, 33678, 31798, 31717, 31389, 31064, 30730, 30404, 30081, 29756, 29438, 29121, 28804, 28494, 28183, 27877, 27573, 27269, 26972, 26675, 26379, 26089, 25799, 25512, 25227, 24945, 24666, 24388, 24114, 23841, 23571, 23305, 23040, 22776, 22517, 22259, 22004, 21750, 21498, 21249, 21003, 20758, 20517, 20276, 20037, 19802, 19568, 19336, 19106, 18877, 18652, 18428, 18205, 17985, 17767, 17551, 17337, 17124, 16914, 16705, 16498, 16293, 16090, 15889, 15689, 15492, 15297, 15103, 14911, 14720, 14531, 14345, 14160, 13976, 13795, 13614, 13436, 13259, 13084, 12910, 12737, 12566, 12398, 12229, 12064, 11899, 11735, 11574, 11413, 11255, 11098, 10942, 10788, 10635, 10483, 10334, 10184, 10038, 9893, 9748, 9606, 9465, 9324, 9186, 9048, 8912, 8779, 8644, 8512, 8382, 8250, 8123, 7994, 7868, 7744, 7616, 7495, 7372, 7248, 7132, 7007, 6810, 6762, 6519, -16007, -32888, -30906, -30859, -30550, -30231, -29915, -29595, -29282, -28970, -28659, -28354, -28048, -27746, -27448, -27149, -26856, -26563, -26273, -25987, -25701, -25419, -25138, -24861, -24587, -24314, -24044, -23776, -23510, -23247, -22985, -22726, -22471, -22217, -21966, -21716, -21468, -21224, -20981, -20739, -20501, -20265, -20030, -19798, -19566, -19339, -19112, -18886, -18665, -18444, -18224, -18008, -17793, -17579, -17368, -17159, -16952, -16746, -16543, -16341, -16140, -15942, -15745, -15550, -15358, -15166, -14978, -14790, -14604, -14419, -14236, -14055, -13878, -13699, -13522, -13348, -13175, -13004, -12833, -12665, -12498, -12332, -12169, -12005, -11844, -11685, -11527, -11370, -11216, -11062, -10909, -10759, -10608, -10462, -10314, -10170, -10026, -9883, -9742, -9603, -9464, -9328, -9191, -9057, -8924, -8790, -8661, -8531, -8402, -8276, -8149, -8023, -7900, -7776, -7656, -7534, -7415, -7297, -7178, -7063, -6948, -6832, -6722, -6609, -6498, -6391, -6279, -6175, -6071, -5926, -6032, -4860};