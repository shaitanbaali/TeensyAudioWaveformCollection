/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0030 256 samples */
 
const int16_t AKWF_squ_0030_256_DATA [256] = 
{8730, 31502, 32513, 31754, 31533, 31179, 30838, 30497, 30156, 29824, 29491, 29163, 28837, 28512, 28193, 27875, 27561, 27250, 26939, 26634, 26330, 26028, 25731, 25434, 25139, 24850, 24560, 24274, 23991, 23708, 23431, 23154, 22879, 22609, 22339, 22073, 21809, 21546, 21287, 21029, 20774, 20522, 20271, 20024, 19777, 19533, 19293, 19053, 18817, 18583, 18348, 18119, 17891, 17663, 17440, 17217, 16997, 16779, 16561, 16347, 16134, 15922, 15714, 15506, 15300, 15097, 14894, 14696, 14497, 14300, 14107, 13913, 13723, 13535, 13346, 13164, 12978, 12797, 12620, 12439, 12266, 12081, 11663, 12812, 1262, -22091, -23429, -22735, -22637, -22403, -22168, -21942, -21713, -21487, -21265, -21042, -20824, -20607, -20391, -20178, -19966, -19756, -19550, -19343, -19140, -18937, -18736, -18538, -18339, -18145, -17952, -17759, -17569, -17379, -17191, -17006, -16822, -16639, -16459, -16278, -16100, -15924, -15748, -15575, -15402, -15232, -15063, -14894, -14729, -14563, -14399, -14238, -14078, -13919, -13761, -13604, -13451, -13297, -13144, -12994, -12844, -12696, -12549, -12403, -12260, -12116, -11975, -11834, -11694, -11556, -11420, -11283, -11150, -11016, -10883, -10752, -10623, -10494, -10367, -10239, -10115, -9991, -9867, -9745, -9626, -9505, -9386, -9269, -9153, -9037, -8922, -8809, -8697, -8587, -8476, -8367, -8259, -8151, -8044, -7939, -7835, -7732, -7629, -7527, -7427, -7327, -7228, -7129, -7032, -6937, -6841, -6747, -6653, -6560, -6468, -6378, -6287, -6199, -6110, -6022, -5936, -5850, -5765, -5681, -5598, -5515, -5433, -5351, -5271, -5190, -5112, -5035, -4956, -4881, -4804, -4729, -4655, -4581, -4508, -4435, -4362, -4292, -4221, -4151, -4083, -4013, -3946, -3878, -3813, -3749, -3683, -3618, -3555, -3492, -3430, -3368, -3306, -3247, -3186, -3127, -3068, -3009, -2952, -2893, -2836, -2781, -2723, -2668, -2614, -2557, -2505, -2449, -2394, -2344, -2278, -2214};