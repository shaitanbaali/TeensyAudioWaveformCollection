/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0005 256 samples */
 
const int16_t AKWF_squ_0005_256_DATA [256] = 
{1787, 5911, 8502, 10880, 13246, 15371, 17110, 18501, 19678, 20753, 21776, 22757, 23675, 24518, 25296, 26015, 26683, 27307, 27885, 28414, 28898, 29339, 29737, 30100, 30425, 30717, 30979, 31212, 31417, 31599, 31759, 31901, 32025, 32132, 32225, 32306, 32377, 32437, 32488, 32532, 32571, 32602, 32630, 32653, 32672, 32689, 32702, 32713, 32723, 32731, 32738, 32743, 32747, 32751, 32754, 32757, 32758, 32760, 32761, 32762, 32763, 32765, 32765, 32766, 32765, 32765, 32766, 32767, 32766, 32767, 32767, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32740, 32637, 33316, 20137, 3891, -1805, -5860, -8492, -10881, -13246, -15371, -17111, -18501, -19678, -20753, -21777, -22757, -23675, -24519, -25296, -26015, -26683, -27307, -27885, -28414, -28899, -29339, -29737, -30100, -30425, -30717, -30979, -31212, -31417, -31599, -31759, -31901, -32025, -32132, -32225, -32306, -32377, -32437, -32488, -32532, -32571, -32602, -32630, -32653, -32672, -32689, -32702, -32713, -32723, -32731, -32738, -32743, -32747, -32751, -32754, -32757, -32758, -32760, -32761, -32762, -32763, -32765, -32765, -32766, -32765, -32765, -32766, -32767, -32766, -32766, -32766, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32740, -32637, -33327, -20149, -3840};