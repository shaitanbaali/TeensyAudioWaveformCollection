/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0033 256 samples */
 
const int16_t AKWF_squ_0033_256_DATA [256] = 
{10792, 32160, 32492, 31867, 31606, 31256, 30900, 30554, 30210, 29865, 29529, 29191, 28858, 28530, 28201, 27877, 27556, 27237, 26923, 26610, 26299, 25993, 25688, 25387, 25088, 24792, 24500, 24208, 23921, 23635, 23351, 23072, 22794, 22518, 22245, 21973, 21705, 21440, 21174, 20914, 20654, 20396, 20144, 19889, 19639, 19393, 19145, 18903, 18661, 18421, 18186, 17949, 17717, 17487, 17257, 17033, 16808, 16586, 16369, 16149, 15938, 15709, 15273, 16342, 3701, -18376, -19016, -18521, -18443, -18255, -18064, -17884, -17699, -17518, -17340, -17161, -16986, -16812, -16638, -16468, -16297, -16129, -15964, -15797, -15633, -15471, -15310, -15151, -14992, -14836, -14680, -14525, -14373, -14221, -14070, -13922, -13772, -13626, -13481, -13335, -13193, -13051, -12910, -12771, -12632, -12495, -12359, -12224, -12089, -11958, -11826, -11696, -11567, -11440, -11312, -11187, -11063, -10939, -10817, -10696, -10575, -10456, -10338, -10221, -10106, -9990, -9875, -9762, -9650, -9538, -9428, -9318, -9210, -9102, -8995, -8890, -8786, -8682, -8579, -8477, -8376, -8277, -8178, -8079, -7982, -7885, -7789, -7695, -7601, -7508, -7416, -7325, -7234, -7144, -7055, -6967, -6880, -6793, -6708, -6623, -6538, -6454, -6372, -6289, -6209, -6128, -6048, -5968, -5890, -5813, -5735, -5659, -5584, -5509, -5434, -5361, -5289, -5216, -5145, -5073, -5005, -4935, -4866, -4798, -4730, -4664, -4597, -4531, -4466, -4401, -4338, -4274, -4212, -4152, -4089, -4027, -3968, -3908, -3849, -3790, -3731, -3674, -3616, -3560, -3505, -3449, -3393, -3339, -3286, -3233, -3179, -3127, -3076, -3024, -2975, -2924, -2874, -2825, -2776, -2728, -2680, -2632, -2585, -2538, -2492, -2447, -2401, -2356, -2312, -2268, -2225, -2181, -2138, -2096, -2054, -2013, -1972, -1931, -1892, -1852, -1813, -1775, -1736, -1699, -1662, -1624, -1589, -1552, -1517, -1484, -1446, -1414, -1379, -1342, -1324, -1253};