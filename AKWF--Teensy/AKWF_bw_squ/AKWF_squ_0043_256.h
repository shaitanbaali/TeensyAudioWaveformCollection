/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0043 256 samples */
 
const int16_t AKWF_squ_0043_256_DATA [256] = 
{8989, 30992, 32595, 31742, 31512, 31156, 30795, 30440, 30090, 29737, 29393, 29049, 28706, 28372, 28035, 27702, 27376, 27045, 26724, 26402, 26082, 25771, 25453, 25134, 24600, 25489, 15333, -7262, -9198, -8614, -8672, -8586, -8506, -8421, -8341, -8258, -8177, -8098, -8017, -7937, -7859, -7781, -7703, -7627, -7550, -7475, -7399, -7324, -7251, -7177, -7104, -7032, -6960, -6889, -6819, -6750, -6680, -6612, -6544, -6477, -6410, -6343, -6277, -6213, -6148, -6084, -6020, -5957, -5895, -5833, -5772, -5711, -5651, -5591, -5533, -5473, -5414, -5357, -5299, -5243, -5186, -5131, -5076, -5020, -4966, -4912, -4858, -4806, -4753, -4701, -4649, -4597, -4547, -4497, -4447, -4397, -4348, -4300, -4251, -4203, -4157, -4110, -4063, -4017, -3971, -3926, -3881, -3837, -3792, -3749, -3705, -3663, -3620, -3577, -3535, -3494, -3453, -3412, -3372, -3331, -3291, -3252, -3213, -3175, -3136, -3098, -3060, -3023, -2986, -2948, -2912, -2876, -2841, -2805, -2770, -2736, -2701, -2667, -2634, -2600, -2567, -2534, -2502, -2469, -2437, -2405, -2374, -2344, -2312, -2281, -2250, -2221, -2192, -2162, -2132, -2105, -2077, -2048, -2020, -1992, -1965, -1937, -1909, -1883, -1857, -1830, -1804, -1779, -1753, -1727, -1703, -1678, -1653, -1628, -1604, -1580, -1556, -1532, -1509, -1486, -1463, -1441, -1418, -1396, -1374, -1352, -1331, -1309, -1288, -1267, -1246, -1226, -1205, -1185, -1166, -1146, -1126, -1107, -1088, -1069, -1050, -1030, -1012, -994, -976, -958, -940, -922, -904, -887, -870, -853, -837, -820, -803, -788, -771, -756, -740, -725, -709, -693, -679, -664, -649, -634, -620, -606, -592, -577, -563, -549, -535, -523, -508, -494, -482, -469, -456, -444, -429, -418, -405, -392, -381, -367, -357, -344, -332, -323, -310, -300, -292, -279, -277, -277};