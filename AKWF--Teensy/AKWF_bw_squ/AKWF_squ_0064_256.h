/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0064 256 samples */
 
const int16_t AKWF_squ_0064_256_DATA [256] = 
{24188, 34060, 32473, 32764, 32767, 32766, 32764, 32762, 32759, 32756, 32751, 32747, 32742, 32737, 32731, 32725, 32720, 32713, 32707, 32699, 32693, 32686, 32678, 32671, 32664, 32656, 32649, 32640, 32632, 32625, 32616, 32608, 32600, 32592, 32583, 32575, 32567, 32559, 32550, 32542, 32533, 32525, 32516, 32508, 32500, 32491, 32482, 32473, 32464, 32457, 32448, 32439, 32431, 32422, 32413, 32405, 32396, 32387, 32379, 32370, 32362, 32353, 32345, 32336, 32327, 32318, 32309, 32301, 32292, 32283, 32275, 32266, 32258, 32249, 32240, 32232, 32223, 32214, 32205, 32119, 31981, 33277, -1809, -17997, -15097, -15641, -15648, -15651, -15654, -15656, -15658, -15658, -15660, -15661, -15661, -15659, -15658, -15658, -15656, -15654, -15652, -15650, -15648, -15646, -15642, -15640, -15637, -15634, -15630, -15628, -15625, -15621, -15617, -15613, -15610, -15606, -15602, -15599, -15595, -15591, -15588, -15584, -15580, -15576, -15573, -15568, -15564, -15560, -15556, -15551, -15547, -15543, -15540, -15536, -15531, -15527, -15523, -15520, -15515, -15511, -15507, -15503, -15498, -15494, -15491, -15487, -15482, -15477, -15474, -15470, -15465, -15461, -15457, -15454, -15448, -15445, -15441, -15437, -15432, -15428, -15424, -15420, -15416, -15412, -15408, -15403, -15399, -15395, -15392, -15387, -15382, -15379, -15375, -15370, -15366, -15363, -15359, -15354, -15349, -15346, -15342, -15337, -15333, -15329, -15326, -15321, -15317, -15313, -15309, -15304, -15300, -15297, -15293, -15288, -15284, -15280, -15276, -15272, -15267, -15264, -15260, -15256, -15251, -15247, -15244, -15240, -15235, -15230, -15227, -15223, -15218, -15214, -15210, -15207, -15202, -15198, -15194, -15190, -15187, -15182, -15178, -15174, -15170, -15166, -15161, -15157, -15154, -15150, -15145, -15141, -15137, -15133, -15129, -15125, -15121, -15117, -15113, -15109, -15104, -15101, -15097, -15093, -15088, -15084, -15080, -15077, -15073, -15068, -15064, -15060, -15056, -15053, -15048, -14836, -15948, -9961};