/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0068 256 samples */
 
const int16_t AKWF_squ_0068_256_DATA [256] = 
{-28373, -33476, -32606, -32765, -32763, -32760, -32757, -32753, -32749, -32744, -32740, -32734, -32728, -32722, -32716, -32709, -32702, -32695, -32688, -32681, -32674, -32666, -32659, -32651, -32643, -32412, -33467, -27911, -143, 4773, 3848, 4057, 4063, 4068, 4071, 4075, 4078, 4081, 4082, 4085, 4087, 4088, 4089, 4090, 4091, 4092, 4092, 4093, 4093, 4093, 4093, 4093, 4093, 4092, 4092, 4092, 4091, 4091, 4090, 4088, 4088, 4087, 4087, 4086, 4085, 4085, 4084, 4082, 4082, 4081, 4080, 4079, 4077, 4077, 4076, 4075, 4074, 4073, 4071, 4071, 4070, 4069, 4068, 4067, 4065, 4065, 4064, 4063, 4061, 4060, 4059, 4058, 4057, 4056, 4055, 4054, 4053, 4052, 4051, 4049, 4048, 4048, 4046, 4046, 4044, 4043, 4042, 4041, 4040, 4039, 4037, 4036, 4036, 4035, 4033, 4032, 4031, 4030, 4029, 4028, 4026, 4026, 4025, 4024, 4022, 4021, 4020, 4019, 4018, 4018, 4016, 4015, 4014, 4013, 4012, 4011, 4009, 4008, 4008, 4007, 4005, 4004, 4003, 4002, 4001, 4000, 3998, 3998, 3997, 3996, 3995, 3994, 3992, 3991, 3991, 3989, 3987, 3987, 3986, 3985, 3984, 3982, 3981, 3980, 3979, 3978, 3977, 3976, 3975, 3974, 3973, 3972, 3970, 3970, 3969, 3968, 3967, 3966, 3964, 3963, 3963, 3961, 3959, 3959, 3958, 3957, 3956, 3955, 3954, 3953, 3952, 3951, 3949, 3948, 3947, 3946, 3945, 3944, 3943, 3942, 3941, 3940, 3939, 3938, 3936, 3936, 3935, 3934, 3932, 3931, 3930, 3929, 3928, 3928, 3926, 3925, 3924, 3923, 3922, 3920, 3920, 3919, 3918, 3917, 3915, 3914, 3914, 3913, 3912, 3911, 3909, 3908, 3907, 3906, 3906, 3904, 3903, 3902, 3901, 3900, 3899, 3897, 3897, 3896, 3895, 3894, 3893, 3891, 3890, 3889, 3889, 3887, 3886, 3855, 4015, 3153};