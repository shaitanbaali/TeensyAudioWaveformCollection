/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0100 256 samples */
 
const int16_t AKWF_squ_0100_256_DATA [256] = 
{184, 453, 717, 982, 1247, 1512, 1777, 2040, 2308, 2573, 2838, 3102, 3367, 3631, 3896, 4161, 4426, 4691, 4955, 5219, 5485, 5750, 6014, 6279, 6545, 6811, 7076, 7341, 7605, 7869, 8134, 8399, 8664, 8929, 9193, 9459, 9722, 9987, 10252, 10516, 10782, 11047, 11311, 11576, 11840, 12104, 12370, 12637, 12901, 13166, 13431, 13696, 13961, 14226, 14490, 14754, 15019, 15284, 15549, 15814, 16078, 16343, 16607, 16873, 17140, 17404, 17668, 17934, 18198, 18463, 18728, 18993, 19258, 19522, 19786, 20051, 20316, 20581, 20846, 21111, 21377, 21643, 21906, 22169, 22434, 22699, 22965, 23231, 23496, 23760, 24025, 24289, 24554, 24819, 25084, 25348, 25613, 25878, 26142, 26407, 26672, 26936, 27203, 27468, 27733, 27998, 28263, 28528, 28793, 29056, 29321, 29586, 29851, 30116, 30381, 30645, 30910, 31174, 31440, 31707, 31971, 32234, 32504, 32743, 32772, 32063, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};