/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0047 256 samples */
 
const int16_t AKWF_squ_0047_256_DATA [256] = 
{4520, 27618, 33056, 31574, 31428, 31064, 30694, 30329, 29793, 30252, 24755, 1349, -4505, -3357, -3569, -3531, -3501, -3466, -3434, -3402, -3367, -3336, -3303, -3271, -3239, -3207, -3176, -3145, -3114, -3083, -3052, -3021, -2991, -2962, -2933, -2902, -2873, -2845, -2816, -2788, -2759, -2732, -2704, -2677, -2649, -2622, -2595, -2569, -2543, -2517, -2491, -2465, -2440, -2415, -2389, -2365, -2340, -2315, -2292, -2268, -2244, -2221, -2197, -2174, -2151, -2128, -2106, -2084, -2061, -2039, -2017, -1995, -1975, -1953, -1931, -1911, -1890, -1869, -1849, -1829, -1808, -1789, -1769, -1750, -1731, -1712, -1693, -1673, -1655, -1636, -1618, -1601, -1582, -1564, -1547, -1529, -1511, -1494, -1476, -1460, -1444, -1427, -1410, -1394, -1377, -1361, -1345, -1329, -1314, -1299, -1284, -1268, -1253, -1237, -1223, -1208, -1193, -1180, -1165, -1151, -1137, -1122, -1109, -1095, -1081, -1068, -1055, -1042, -1028, -1015, -1001, -989, -976, -963, -951, -938, -926, -915, -903, -892, -880, -869, -857, -847, -835, -824, -811, -801, -790, -780, -769, -758, -748, -737, -727, -717, -707, -696, -687, -677, -667, -657, -647, -638, -629, -620, -611, -601, -592, -582, -575, -566, -557, -549, -539, -531, -523, -514, -506, -498, -490, -483, -475, -467, -459, -451, -443, -436, -428, -421, -414, -406, -399, -392, -385, -378, -371, -364, -357, -352, -344, -338, -332, -324, -318, -312, -306, -300, -294, -287, -282, -275, -270, -265, -258, -252, -247, -241, -236, -230, -224, -219, -214, -209, -203, -198, -193, -188, -183, -178, -172, -168, -164, -159, -155, -150, -145, -141, -136, -132, -128, -123, -119, -115, -112, -107, -103, -99, -94, -91, -87, -82, -80, -70, -65, -63};