/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0060 256 samples */
 
const int16_t AKWF_squ_0060_256_DATA [256] = 
{20, 44, 70, 98, 123, 140, 165, 195, 222, 241, 261, 280, 302, 322, 342, 367, 381, 397, 423, 433, 457, 469, 484, 508, 519, 538, 546, 560, 571, 584, 595, 615, 624, 633, 646, 661, 670, 684, 696, 704, 709, 722, 732, 736, 741, 752, 757, 767, 771, 771, 781, 789, 794, 799, 809, 813, 821, 826, 829, 836, 842, 849, 850, 857, 857, 856, 854, 858, 866, 866, 869, 871, 872, 875, 871, 870, 872, 876, 875, 876, 877, 874, 879, 876, 874, 877, 881, 873, 1000, 498, 2427, 23884, 29315, 29206, 30074, 30677, 31188, 31625, 31979, 32262, 32479, 32632, 32725, 32763, 32728, 32432, 33536, 20308, 2255, 1704, 676, -254, -1079, -1848, -2548, -3194, -3783, -4323, -4821, -5272, -5690, -6064, -6402, -6704, -6974, -7222, -7436, -7631, -7796, -7947, -8061, -8168, -8255, -8327, -8383, -8419, -8443, -8462, -8465, -8456, -8433, -8411, -8380, -8334, -8284, -8226, -8161, -8083, -8010, -7931, -7845, -7754, -7668, -7579, -7481, -7378, -7268, -7174, -7073, -6965, -6857, -6744, -6634, -6520, -6410, -6297, -6187, -6078, -5964, -5858, -5745, -5638, -5524, -5418, -5312, -5197, -5089, -4983, -4876, -4770, -4663, -4565, -4465, -4360, -4262, -4160, -4061, -3962, -3864, -3778, -3686, -3598, -3499, -3409, -3323, -3237, -3150, -3066, -2980, -2895, -2819, -2738, -2660, -2586, -2501, -2434, -2362, -2290, -2217, -2148, -2084, -2007, -1946, -1878, -1819, -1755, -1688, -1631, -1572, -1505, -1456, -1396, -1337, -1281, -1235, -1182, -1137, -1083, -1026, -976, -932, -884, -839, -797, -754, -712, -667, -621, -584, -542, -505, -467, -430, -393, -355, -322, -284, -253, -220, -185, -154, -125, -91, -59, -32, -15};