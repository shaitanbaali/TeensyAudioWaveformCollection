/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0061 256 samples */
 
const int16_t AKWF_squ_0061_256_DATA [256] = 
{18351, 19770, 18090, 18788, 18617, 18648, 18647, 18643, 18646, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18644, 18458, 19514, 14951, -19252, -12461, -21786, -17324, -19068, -18517, -18684, -18635, -18648, -18645, -18645, -18644, -18645, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18644, -18093, -21672, -4618, 19403};