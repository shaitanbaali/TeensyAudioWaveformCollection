/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0067 256 samples */
 
const int16_t AKWF_squ_0067_256_DATA [256] = 
{7052, 9050, 8718, 8785, 8791, 8795, 8799, 8801, 8804, 8805, 8807, 8809, 8809, 8810, 8810, 8810, 8810, 8810, 8810, 8809, 8809, 8808, 8806, 8805, 8804, 8802, 8801, 8799, 8797, 8796, 8794, 8792, 8790, 8788, 8787, 8784, 8782, 8781, 8779, 8776, 8774, 8772, 8770, 8768, 8766, 8763, 8761, 8759, 8757, 8755, 8752, 8750, 8747, 8745, 8743, 8741, 8738, 8736, 8734, 8731, 8729, 8727, 8724, 8722, 8720, 8717, 8715, 8713, 8710, 8708, 8705, 8703, 8701, 8699, 8697, 8694, 8692, 8689, 8687, 8685, 8682, 8681, 8678, 8675, 8674, 8671, 8669, 8666, 8664, 8662, 8659, 8657, 8655, 8653, 8650, 8648, 8645, 8643, 8641, 8638, 8636, 8634, 8631, 8629, 8627, 8624, 8622, 8620, 8618, 8615, 8613, 8611, 8608, 8606, 8604, 8601, 8599, 8597, 8594, 8592, 8590, 8588, 8585, 8582, 8581, 8578, 8576, 8574, 8571, 8568, 8567, 8564, 8562, 8560, 8557, 8555, 8553, 8551, 8548, 8546, 8544, 8541, 8539, 8537, 8534, 8532, 8530, 8527, 8525, 8522, 8521, 8519, 8516, 8514, 8512, 8509, 8507, 8505, 8502, 8500, 8498, 8496, 8493, 8491, 8489, 8486, 8484, 8482, 8480, 8477, 8475, 8473, 8470, 8468, 8466, 8464, 8461, 8459, 8456, 8455, 8453, 8449, 8448, 8445, 8443, 8441, 8439, 8437, 8434, 8432, 8430, 8427, 8425, 8423, 8421, 8418, 8416, 8414, 8412, 8379, 8108, 9838, -20720, -34833, -32312, -32764, -32766, -32763, -32761, -32758, -32754, -32750, -32745, -32740, -32735, -32730, -32723, -32718, -32712, -32704, -32698, -32691, -32683, -32676, -32669, -32661, -32653, -32645, -32638, -32630, -32622, -32613, -32605, -32598, -32590, -32581, -32573, -32564, -32556, -32547, -32539, -32530, -32522, -32513, -32506, -32497, -32488, -32479, -32471, -32463, -32454, -32445, -32432, -32132, -33747, -21773};