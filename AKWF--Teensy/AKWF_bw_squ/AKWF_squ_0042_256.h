/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0042 256 samples */
 
const int16_t AKWF_squ_0042_256_DATA [256] = 
{10128, 31610, 32503, 31753, 31511, 31139, 30782, 30426, 30069, 29723, 29373, 29030, 28691, 28350, 28018, 27685, 27358, 27035, 26709, 26392, 26076, 25760, 25454, 25145, 24838, 24533, 23997, 24953, 13560, -8516, -9723, -9232, -9262, -9173, -9078, -8989, -8901, -8810, -8725, -8637, -8551, -8467, -8380, -8298, -8216, -8134, -8052, -7971, -7891, -7813, -7733, -7655, -7577, -7500, -7425, -7348, -7273, -7199, -7125, -7052, -6980, -6907, -6836, -6765, -6695, -6625, -6556, -6487, -6420, -6352, -6286, -6220, -6154, -6089, -6025, -5961, -5897, -5835, -5772, -5710, -5649, -5589, -5529, -5469, -5410, -5351, -5293, -5236, -5179, -5121, -5066, -5010, -4955, -4900, -4846, -4792, -4738, -4685, -4633, -4581, -4530, -4478, -4428, -4378, -4328, -4280, -4230, -4181, -4133, -4087, -4039, -3992, -3946, -3900, -3854, -3809, -3765, -3721, -3676, -3632, -3589, -3547, -3504, -3463, -3421, -3380, -3339, -3298, -3257, -3217, -3177, -3138, -3099, -3060, -3022, -2985, -2948, -2910, -2873, -2837, -2801, -2766, -2731, -2695, -2661, -2626, -2592, -2558, -2525, -2491, -2459, -2426, -2394, -2361, -2329, -2298, -2268, -2238, -2207, -2177, -2147, -2116, -2087, -2058, -2029, -2001, -1972, -1943, -1916, -1889, -1861, -1833, -1807, -1781, -1754, -1728, -1702, -1676, -1651, -1626, -1601, -1578, -1553, -1529, -1504, -1481, -1457, -1433, -1410, -1388, -1366, -1343, -1320, -1299, -1277, -1256, -1234, -1213, -1192, -1171, -1151, -1130, -1111, -1091, -1070, -1052, -1031, -1014, -994, -975, -957, -938, -920, -901, -884, -866, -849, -831, -814, -797, -780, -763, -747, -730, -714, -698, -683, -667, -651, -636, -621, -606, -592, -577, -562, -549, -533, -520, -506, -493, -479, -465, -453, -439, -425, -413, -398, -385, -374, -359, -348, -334, -317, -308, -283, -257};