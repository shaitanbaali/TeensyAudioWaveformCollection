/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0038 256 samples */
 
const int16_t AKWF_squ_0038_256_DATA [256] = 
{7853, 30443, 32613, 31631, 31436, 31075, 30717, 30371, 30019, 29674, 29333, 28992, 28658, 28324, 27993, 27666, 27341, 27020, 26701, 26384, 26073, 25761, 25455, 25151, 24848, 24550, 24254, 23959, 23671, 23381, 23096, 22815, 22532, 22257, 21982, 21706, 21440, 21170, 20905, 20646, 20379, 20121, 19639, 20556, 11366, -11757, -14331, -13561, -13582, -13447, -13314, -13179, -13050, -12917, -12789, -12661, -12533, -12408, -12284, -12159, -12037, -11915, -11794, -11674, -11555, -11437, -11320, -11204, -11090, -10975, -10861, -10749, -10637, -10527, -10418, -10308, -10201, -10094, -9988, -9883, -9779, -9676, -9573, -9472, -9371, -9272, -9173, -9075, -8978, -8882, -8786, -8691, -8599, -8505, -8413, -8322, -8231, -8141, -8052, -7964, -7877, -7789, -7703, -7618, -7533, -7449, -7366, -7283, -7201, -7120, -7040, -6961, -6881, -6804, -6725, -6649, -6572, -6497, -6422, -6349, -6275, -6203, -6130, -6059, -5987, -5917, -5847, -5778, -5709, -5640, -5573, -5507, -5441, -5374, -5309, -5246, -5182, -5118, -5055, -4993, -4931, -4871, -4811, -4750, -4690, -4632, -4574, -4516, -4459, -4402, -4346, -4291, -4236, -4180, -4126, -4073, -4019, -3967, -3915, -3863, -3812, -3761, -3710, -3660, -3611, -3562, -3514, -3465, -3417, -3370, -3322, -3277, -3231, -3186, -3142, -3097, -3053, -3009, -2965, -2922, -2879, -2838, -2796, -2755, -2713, -2673, -2633, -2593, -2553, -2514, -2475, -2437, -2399, -2361, -2324, -2287, -2250, -2214, -2178, -2143, -2107, -2072, -2038, -2004, -1969, -1936, -1903, -1869, -1837, -1805, -1773, -1742, -1710, -1679, -1649, -1618, -1588, -1558, -1528, -1500, -1471, -1443, -1415, -1386, -1358, -1330, -1303, -1276, -1249, -1222, -1196, -1170, -1145, -1119, -1093, -1068, -1043, -1019, -997, -971, -948, -924, -901, -880, -856, -835, -814, -792, -771, -749, -730, -713, -689, -673, -650, -648};