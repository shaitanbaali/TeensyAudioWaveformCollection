/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0036 256 samples */
 
const int16_t AKWF_squ_0036_256_DATA [256] = 
{9478, 31457, 32522, 31755, 31524, 31160, 30812, 30461, 30114, 29773, 29430, 29096, 28760, 28429, 28103, 27776, 27454, 27135, 26816, 26504, 26193, 25883, 25578, 25275, 24974, 24678, 24379, 24087, 23796, 23507, 23223, 22939, 22658, 22380, 22104, 21832, 21561, 21292, 21028, 20762, 20502, 20245, 19987, 19735, 19483, 19234, 18991, 18744, 18505, 18257, 17782, 18817, 7641, -14887, -16242, -15642, -15616, -15459, -15298, -15147, -14992, -14840, -14691, -14540, -14394, -14248, -14101, -13959, -13816, -13674, -13535, -13395, -13258, -13122, -12986, -12853, -12720, -12588, -12458, -12327, -12200, -12073, -11945, -11820, -11696, -11573, -11451, -11329, -11208, -11090, -10972, -10855, -10738, -10624, -10509, -10395, -10283, -10172, -10062, -9952, -9844, -9737, -9630, -9524, -9420, -9316, -9214, -9111, -9009, -8910, -8811, -8712, -8615, -8518, -8422, -8327, -8232, -8139, -8046, -7954, -7864, -7773, -7683, -7594, -7506, -7420, -7333, -7247, -7162, -7077, -6994, -6911, -6829, -6748, -6668, -6587, -6509, -6430, -6353, -6276, -6200, -6124, -6050, -5975, -5901, -5828, -5756, -5685, -5614, -5544, -5474, -5405, -5336, -5268, -5201, -5134, -5068, -5003, -4938, -4874, -4811, -4748, -4684, -4622, -4561, -4500, -4440, -4381, -4322, -4263, -4205, -4147, -4090, -4035, -3979, -3923, -3868, -3814, -3760, -3706, -3654, -3603, -3551, -3499, -3448, -3397, -3347, -3298, -3249, -3199, -3151, -3104, -3057, -3010, -2963, -2917, -2872, -2827, -2783, -2739, -2695, -2651, -2609, -2567, -2524, -2483, -2442, -2401, -2361, -2320, -2280, -2241, -2201, -2163, -2125, -2087, -2050, -2012, -1975, -1939, -1903, -1867, -1831, -1796, -1762, -1728, -1694, -1660, -1627, -1595, -1562, -1530, -1498, -1467, -1437, -1405, -1374, -1345, -1315, -1285, -1255, -1226, -1198, -1168, -1140, -1111, -1081, -1055, -1027, -997, -972, -943, -916, -891, -856, -822};