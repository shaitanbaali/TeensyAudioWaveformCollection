/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0055 256 samples */
 
const int16_t AKWF_squ_0055_256_DATA [256] = 
{91, 232, 375, 515, 654, 794, 918, 1035, 1157, 1286, 1398, 1515, 1635, 1735, 1842, 1954, 2053, 2149, 2247, 2346, 2441, 2533, 2619, 2701, 2782, 2870, 2942, 3015, 3096, 3164, 3236, 3365, 3284, 3711, 21468, 27749, 27521, 28357, 28910, 29390, 29820, 30169, 30458, 30691, 30866, 30988, 31059, 31086, 31080, 31028, 30940, 30816, 30668, 30477, 30262, 30033, 29775, 29496, 29196, 28875, 28540, 28186, 27826, 27449, 27056, 26657, 26254, 25831, 25412, 24983, 24533, 24078, 23646, 23191, 22745, 22283, 21825, 21367, 20904, 20441, 19984, 19524, 19060, 18604, 18146, 17691, 17244, 16803, 16350, 15907, 15461, 15027, 14593, 14164, 13740, 13317, 12899, 12485, 12078, 11666, 11268, 10884, 10477, 10089, 9718, 9342, 8969, 8606, 8245, 7885, 7538, 7196, 6851, 6515, 6185, 5863, 5541, 5230, 4924, 4618, 4316, 4021, 3737, 3454, 3172, 2908, 2637, 2372, 2117, 1859, 1615, 1371, 1142, 907, 654, 432, 220, 4, -205, -418, -628, -945, -768, -3584, -21764, -30204, -29982, -30760, -31276, -31710, -32054, -32329, -32531, -32668, -32746, -32769, -32746, -32673, -32558, -32402, -32215, -31991, -31726, -31438, -31125, -30801, -30464, -30086, -29691, -29286, -28878, -28452, -28006, -27560, -27108, -26645, -26178, -25711, -25231, -24757, -24270, -23800, -23318, -22835, -22355, -21877, -21396, -20922, -20448, -19984, -19509, -19048, -18597, -18134, -17688, -17243, -16790, -16360, -15940, -15512, -15087, -14670, -14256, -13856, -13461, -13064, -12678, -12297, -11920, -11543, -11181, -10821, -10468, -10114, -9778, -9436, -9112, -8788, -8468, -8154, -7844, -7543, -7245, -6953, -6661, -6383, -6106, -5835, -5559, -5308, -5052, -4797, -4550, -4298, -4063, -3834, -3606, -3384, -3172, -2952, -2735, -2533, -2330, -2133, -1940, -1752, -1566, -1384, -1210, -1034, -864, -697, -533, -370, -220, -66};