/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0027 256 samples */
 
const int16_t AKWF_squ_0027_256_DATA [256] = 
{16844, 33398, 31721, 31565, 31244, 30901, 30567, 30230, 29901, 29573, 29246, 28927, 28607, 28290, 27978, 27666, 27360, 27055, 26751, 26454, 26156, 25862, 25571, 25281, 24996, 24712, 24429, 24152, 23875, 23599, 23329, 23059, 22791, 22526, 22263, 22003, 21744, 21488, 21234, 20983, 20734, 20486, 20241, 19999, 19758, 19520, 19284, 19049, 18818, 18588, 18359, 18136, 17911, 17689, 17470, 17253, 17038, 16823, 16612, 16403, 16194, 15988, 15785, 15581, 15380, 15182, 14984, 14789, 14595, 14403, 14213, 14024, 13838, 13652, 13469, 13288, 13107, 12930, 12753, 12577, 12406, 12232, 12063, 11896, 11727, 11563, 11400, 11237, 11078, 10918, 10761, 10606, 10450, 10299, 10146, 9994, 9848, 9698, 9552, 9409, 9259, 9065, 8877, 9205, -10537, -28295, -26693, -26615, -26365, -26098, -25825, -25554, -25290, -25022, -24761, -24501, -24241, -23987, -23732, -23479, -23231, -22982, -22736, -22493, -22250, -22011, -21773, -21536, -21302, -21069, -20839, -20611, -20385, -20162, -19939, -19720, -19502, -19284, -19070, -18858, -18647, -18440, -18232, -18027, -17824, -17622, -17423, -17226, -17029, -16835, -16642, -16451, -16262, -16073, -15887, -15702, -15518, -15337, -15157, -14979, -14802, -14628, -14454, -14282, -14111, -13942, -13774, -13609, -13444, -13280, -13119, -12959, -12801, -12644, -12486, -12332, -12180, -12028, -11879, -11730, -11582, -11436, -11290, -11147, -11005, -10863, -10724, -10585, -10447, -10311, -10177, -10043, -9910, -9779, -9649, -9520, -9391, -9266, -9141, -9017, -8893, -8771, -8651, -8531, -8412, -8296, -8179, -8063, -7950, -7837, -7726, -7615, -7504, -7396, -7287, -7181, -7075, -6970, -6866, -6763, -6661, -6560, -6459, -6361, -6261, -6164, -6068, -5972, -5877, -5784, -5691, -5600, -5509, -5419, -5331, -5242, -5156, -5070, -4984, -4899, -4815, -4732, -4651, -4568, -4489, -4410, -4329, -4253, -4174, -4097, -4023, -3942, -3870, -3772, -3811, -3132};