/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0059 256 samples */
 
const int16_t AKWF_squ_0059_256_DATA [256] = 
{91, 245, 401, 556, 704, 840, 984, 1121, 1259, 1388, 1512, 1637, 1754, 1876, 1994, 2108, 2217, 2320, 2641, 1643, 7311, 24639, 26012, 26572, 27266, 27826, 28313, 28732, 29086, 29381, 29617, 29798, 29941, 30030, 30075, 30085, 30050, 29992, 29892, 29767, 29610, 29422, 29216, 28989, 28740, 28471, 28184, 27883, 27564, 27234, 26889, 26536, 26168, 25791, 25406, 25027, 24625, 24220, 23813, 23394, 22979, 22558, 22136, 21706, 21278, 20848, 20420, 19993, 19569, 19129, 18704, 18281, 17856, 17434, 17008, 16590, 16173, 15753, 15348, 14934, 14532, 14129, 13729, 13341, 12950, 12562, 12182, 11797, 11422, 11056, 10686, 10326, 9972, 9626, 9271, 8928, 8585, 8251, 7925, 7594, 7279, 6964, 6651, 6347, 6052, 5753, 5463, 5181, 4889, 4621, 4340, 4070, 3811, 3557, 3305, 3052, 2802, 2566, 2330, 2094, 1864, 1648, 1425, 1201, 990, 787, 585, 389, 192, 6, -180, -362, -541, -715, -888, -1054, -1216, -1374, -1531, -1681, -1832, -1985, -2127, -2265, -2464, -2562, -2927, -18285, -30448, -30329, -31015, -31506, -31886, -32197, -32440, -32606, -32711, -32762, -32759, -32707, -32614, -32477, -32304, -32089, -31845, -31579, -31272, -30949, -30606, -30246, -29859, -29460, -29049, -28624, -28186, -27739, -27286, -26819, -26358, -25881, -25401, -24924, -24437, -23954, -23473, -22984, -22494, -22012, -21526, -21044, -20568, -20089, -19617, -19149, -18679, -18215, -17759, -17308, -16850, -16408, -15969, -15536, -15110, -14682, -14263, -13848, -13438, -13036, -12644, -12255, -11867, -11486, -11115, -10749, -10391, -10033, -9683, -9334, -8998, -8670, -8339, -8024, -7707, -7400, -7091, -6791, -6500, -6211, -5930, -5653, -5376, -5107, -4847, -4589, -4336, -4086, -3845, -3606, -3373, -3146, -2925, -2703, -2484, -2269, -2067, -1865, -1669, -1472, -1278, -1094, -914, -738, -560, -384, -218, -62};