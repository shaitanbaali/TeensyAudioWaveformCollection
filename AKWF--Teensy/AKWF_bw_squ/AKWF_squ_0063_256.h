/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0063 256 samples */
 
const int16_t AKWF_squ_0063_256_DATA [256] = 
{17939, 34007, 32493, 32752, 32766, 32764, 32760, 32757, 32754, 32749, 32744, 32739, 32734, 32728, 32722, 32716, 32709, 32703, 32696, 32689, 32682, 32675, 32667, 32659, 32652, 32644, 32636, 32628, 32621, 32612, 32604, 32596, 32587, 32580, 32571, 32562, 32554, 32546, 32537, 32529, 32521, 32512, 32503, 32495, 32026, 34456, 21340, -7952, -7230, -7290, -7363, -7369, -7372, -7376, -7379, -7382, -7384, -7386, -7387, -7388, -7389, -7391, -7390, -7390, -7390, -7390, -7391, -7389, -7388, -7388, -7387, -7386, -7385, -7384, -7383, -7382, -7380, -7379, -7377, -7375, -7374, -7372, -7371, -7370, -7368, -7366, -7364, -7363, -7360, -7359, -7357, -7355, -7354, -7351, -7350, -7347, -7346, -7344, -7342, -7340, -7338, -7336, -7334, -7332, -7330, -7329, -7327, -7325, -7323, -7321, -7319, -7317, -7315, -7313, -7311, -7309, -7307, -7305, -7303, -7301, -7299, -7297, -7295, -7294, -7292, -7289, -7288, -7286, -7284, -7281, -7280, -7277, -7276, -7274, -7272, -7270, -7268, -7265, -7264, -7262, -7260, -7258, -7256, -7254, -7252, -7251, -7248, -7247, -7245, -7243, -7241, -7239, -7236, -7235, -7232, -7231, -7229, -7227, -7225, -7223, -7221, -7219, -7218, -7215, -7214, -7211, -7210, -7208, -7206, -7203, -7202, -7200, -7198, -7196, -7194, -7192, -7190, -7188, -7186, -7185, -7182, -7181, -7179, -7177, -7175, -7173, -7171, -7169, -7167, -7165, -7163, -7161, -7159, -7157, -7156, -7154, -7152, -7150, -7148, -7146, -7144, -7142, -7140, -7139, -7137, -7135, -7132, -7131, -7129, -7127, -7125, -7123, -7121, -7119, -7117, -7115, -7113, -7112, -7110, -7108, -7106, -7104, -7102, -7100, -7099, -7096, -7095, -7092, -7091, -7089, -7087, -7085, -7083, -7081, -7079, -7077, -7075, -7074, -7071, -7070, -7068, -7066, -7064, -7062, -7060, -7058, -7057, -7054, -7053, -7051, -7049, -7047, -7045, -7032, -7090, -6768};