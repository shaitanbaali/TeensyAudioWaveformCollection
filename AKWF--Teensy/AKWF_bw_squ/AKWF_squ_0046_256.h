/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0046 256 samples */
 
const int16_t AKWF_squ_0046_256_DATA [256] = 
{7784, 30216, 32618, 31579, 31385, 31005, 30646, 30287, 29926, 29579, 29224, 28872, 28304, 29091, 20223, -2679, -5472, -4778, -4901, -4852, -4808, -4760, -4716, -4669, -4624, -4580, -4535, -4490, -4447, -4402, -4359, -4316, -4273, -4231, -4189, -4147, -4105, -4064, -4023, -3983, -3942, -3902, -3863, -3824, -3785, -3747, -3709, -3671, -3634, -3597, -3560, -3523, -3487, -3451, -3415, -3380, -3345, -3310, -3277, -3242, -3208, -3175, -3142, -3109, -3076, -3043, -3011, -2980, -2947, -2916, -2886, -2856, -2825, -2793, -2763, -2734, -2704, -2675, -2646, -2617, -2588, -2561, -2532, -2504, -2477, -2450, -2423, -2396, -2370, -2344, -2317, -2291, -2265, -2240, -2215, -2190, -2165, -2140, -2116, -2092, -2068, -2044, -2020, -1997, -1975, -1951, -1928, -1906, -1883, -1861, -1840, -1818, -1796, -1776, -1753, -1733, -1712, -1691, -1671, -1650, -1630, -1611, -1591, -1571, -1552, -1533, -1514, -1495, -1476, -1457, -1439, -1420, -1403, -1384, -1366, -1350, -1332, -1314, -1297, -1280, -1263, -1248, -1231, -1216, -1200, -1184, -1167, -1152, -1137, -1121, -1106, -1091, -1076, -1061, -1047, -1032, -1017, -1003, -989, -975, -961, -947, -934, -920, -907, -893, -880, -867, -854, -842, -829, -816, -803, -791, -779, -766, -755, -743, -731, -721, -708, -697, -686, -675, -664, -653, -643, -632, -621, -610, -600, -589, -579, -569, -559, -549, -539, -529, -520, -510, -500, -490, -481, -472, -463, -454, -445, -436, -428, -419, -411, -403, -394, -385, -377, -369, -361, -353, -345, -337, -330, -322, -314, -306, -299, -291, -284, -278, -270, -263, -256, -249, -242, -235, -229, -221, -215, -209, -203, -197, -191, -184, -179, -173, -166, -162, -155, -150, -146, -138, -135, -129, -122, -120, -106, -120};