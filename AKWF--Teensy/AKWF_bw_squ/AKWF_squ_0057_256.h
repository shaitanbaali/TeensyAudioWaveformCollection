/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0057 256 samples */
 
const int16_t AKWF_squ_0057_256_DATA [256] = 
{38, 100, 161, 217, 273, 331, 381, 440, 491, 542, 594, 644, 692, 743, 786, 828, 873, 917, 958, 1000, 1041, 1070, 1122, 1144, 1178, 1219, 1248, 1281, 1316, 1351, 1376, 1391, 1423, 1456, 1483, 1508, 1535, 1558, 1588, 1613, 1623, 1655, 1673, 1692, 1708, 1730, 1748, 1761, 1771, 1787, 1811, 1819, 1835, 1850, 1859, 1875, 1885, 1894, 1910, 1923, 1932, 1941, 1932, 1937, 1957, 1967, 1979, 1981, 1993, 1998, 2004, 2014, 2014, 2018, 2028, 2027, 2032, 2031, 2107, 1990, 2146, 21828, 29685, 29214, 30129, 30716, 31214, 31642, 31990, 32264, 32474, 32623, 32725, 32764, 32727, 32668, 32572, 32426, 32239, 32017, 31772, 31484, 31178, 30846, 30481, 30093, 29690, 29272, 28833, 28387, 27914, 27434, 26950, 26451, 25938, 25418, 24751, 24684, 21155, 285, -8823, -9011, -10364, -11395, -12312, -13173, -13952, -14642, -15255, -15799, -16280, -16714, -17079, -17397, -17673, -17902, -18086, -18227, -18340, -18429, -18474, -18491, -18482, -18449, -18399, -18321, -18233, -18126, -17997, -17848, -17699, -17539, -17351, -17162, -16972, -16762, -16547, -16335, -16124, -15885, -15648, -15417, -15172, -14925, -14682, -14433, -14186, -13935, -13684, -13437, -13184, -12930, -12685, -12433, -12176, -11933, -11686, -11441, -11198, -10958, -10717, -10482, -10244, -10012, -9785, -9553, -9320, -9095, -8872, -8671, -8461, -8238, -8031, -7826, -7620, -7423, -7225, -7023, -6836, -6644, -6460, -6276, -6095, -5918, -5739, -5575, -5406, -5236, -5072, -4911, -4753, -4596, -4440, -4294, -4147, -4006, -3861, -3720, -3582, -3443, -3308, -3198, -3067, -2935, -2817, -2699, -2578, -2459, -2350, -2241, -2134, -2022, -1914, -1814, -1711, -1612, -1516, -1419, -1326, -1236, -1150, -1063, -974, -890, -810, -736, -649, -571, -499, -426, -356, -275, -199, -151, -79, -15};