/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0017 256 samples */
 
const int16_t AKWF_squ_0017_256_DATA [256] = 
{179, 439, 695, 951, 1206, 1462, 1719, 1974, 2230, 2487, 2742, 2998, 3254, 3511, 3766, 4022, 4278, 4535, 4790, 5046, 5302, 5559, 5814, 6070, 6326, 6583, 6838, 7095, 7351, 7607, 7862, 8119, 8375, 8630, 8886, 9143, 9398, 9654, 9911, 10167, 10422, 10678, 10935, 11191, 11447, 11702, 11959, 12216, 12470, 12727, 12983, 13238, 13494, 13751, 14007, 14263, 14518, 14775, 15031, 15287, 15542, 15799, 16055, 16311, 16567, 16823, 17079, 17335, 17591, 17848, 18104, 18359, 18615, 18872, 19127, 19383, 19639, 19896, 20151, 20407, 20663, 20920, 21176, 21430, 21688, 21944, 22199, 22456, 22712, 22967, 23223, 23481, 23736, 23992, 24247, 24505, 24760, 25015, 25272, 25529, 25783, 26039, 26296, 26552, 26807, 27064, 27320, 27576, 27831, 28088, 28344, 28601, 28855, 29112, 29369, 29623, 29879, 30136, 30392, 30647, 30904, 31160, 31417, 31671, 31927, 31482, 35450, 16900, -33440, -32704, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};