/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0001 256 samples */
 
const int16_t AKWF_squ_0001_256_DATA [256] = 
{25186, 30640, 29453, 29596, 29541, 29488, 29430, 29445, 29387, 29329, 29272, 29215, 29158, 29101, 29044, 28987, 28930, 28873, 28817, 28761, 28704, 28648, 28592, 28536, 28481, 28425, 28369, 28314, 28259, 28203, 28147, 28093, 28038, 27983, 27928, 27874, 27820, 27764, 27710, 27656, 27602, 27548, 27494, 27440, 27387, 27333, 27280, 27226, 27174, 27120, 27067, 27014, 26962, 26908, 26856, 26803, 26750, 26699, 26647, 26593, 26542, 26490, 26439, 26387, 26335, 26284, 26232, 26180, 26130, 26078, 26027, 25977, 25926, 25875, 25824, 25774, 25724, 25673, 25623, 25572, 25523, 25472, 25423, 25373, 25324, 25274, 25225, 25175, 25126, 25077, 25028, 24978, 24930, 24882, 24833, 24784, 24735, 24688, 24639, 24591, 24542, 24494, 24447, 24398, 24351, 24303, 24256, 24208, 24161, 24114, 24067, 24019, 23972, 23925, 23879, 23832, 23786, 23739, 23693, 23647, 23599, 23542, 23514, 23460, 23412, 23116, 24257, 19545, -25779, -30807, -29499, -29702, -29646, -29592, -29533, -29549, -29491, -29433, -29375, -29318, -29261, -29204, -29147, -29089, -29032, -28976, -28919, -28862, -28806, -28750, -28694, -28637, -28582, -28525, -28470, -28414, -28358, -28303, -28247, -28192, -28137, -28082, -28027, -27972, -27917, -27863, -27808, -27754, -27700, -27646, -27591, -27537, -27483, -27430, -27376, -27323, -27269, -27216, -27163, -27109, -27057, -27004, -26951, -26898, -26845, -26793, -26741, -26688, -26636, -26585, -26532, -26479, -26428, -26376, -26325, -26273, -26223, -26171, -26119, -26069, -26017, -25967, -25915, -25865, -25815, -25764, -25714, -25663, -25613, -25563, -25513, -25463, -25413, -25363, -25314, -25265, -25215, -25165, -25117, -25067, -25018, -24969, -24920, -24872, -24823, -24775, -24726, -24678, -24630, -24581, -24533, -24486, -24437, -24390, -24342, -24294, -24247, -24199, -24152, -24105, -24058, -24011, -23964, -23916, -23870, -23823, -23776, -23731, -23682, -23626, -23598, -23543, -23494, -23280, -24188, -19659};