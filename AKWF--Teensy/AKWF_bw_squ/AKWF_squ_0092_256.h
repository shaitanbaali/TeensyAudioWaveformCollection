/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0092 256 samples */
 
const int16_t AKWF_squ_0092_256_DATA [256] = 
{256, 629, 993, 1358, 1723, 2089, 2455, 2820, 3186, 3552, 3917, 4283, 4649, 5015, 5381, 5747, 6112, 6479, 6844, 7209, 7575, 7941, 8306, 8672, 9038, 9404, 9769, 10136, 10501, 10868, 11232, 11598, 11964, 12330, 12695, 13061, 13426, 13793, 14158, 14524, 14890, 15256, 15621, 15987, 16353, 16719, 17084, 17450, 17815, 18182, 18547, 18912, 19280, 19645, 20010, 20376, 20742, 21107, 21474, 21839, 22204, 22570, 22936, 23301, 23669, 24033, 24399, 24765, 25131, 25496, 25862, 26227, 26594, 26959, 27325, 27690, 28057, 28422, 28788, 29154, 29519, 29885, 30251, 30616, 30982, 31348, 31714, 32076, 32454, 32754, 32770, 32766, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};