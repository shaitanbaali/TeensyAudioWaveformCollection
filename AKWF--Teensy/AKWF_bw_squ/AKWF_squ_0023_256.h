/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0023 256 samples */
 
const int16_t AKWF_squ_0023_256_DATA [256] = 
{20460, 33829, 31845, 31770, 31441, 31100, 30765, 30437, 30106, 29781, 29460, 29139, 28824, 28509, 28198, 27890, 27583, 27282, 26982, 26683, 26390, 26098, 25808, 25522, 25237, 24955, 24675, 24397, 24125, 23851, 23580, 23314, 23047, 22785, 22524, 22264, 22009, 21754, 21502, 21252, 21003, 20758, 20515, 20274, 20035, 19798, 19563, 19330, 19099, 18871, 18643, 18420, 18198, 17976, 17759, 17542, 17328, 17116, 16904, 16696, 16490, 16283, 16081, 15880, 15679, 15482, 15285, 15091, 14898, 14707, 14517, 14329, 14143, 13960, 13777, 13596, 13417, 13240, 13063, 12890, 12717, 12546, 12376, 12209, 12042, 11877, 11715, 11553, 11393, 11235, 11078, 10922, 10767, 10614, 10464, 10313, 10164, 10017, 9870, 9725, 9583, 9439, 9299, 9159, 9020, 8884, 8747, 8614, 8481, 8348, 8219, 8089, 7961, 7836, 7707, 7587, 7464, 7341, 7228, 6997, 7112, 6139, -17891, -32638, -30509, -30490, -30181, -29857, -29538, -29225, -28909, -28601, -28295, -27990, -27691, -27392, -27095, -26803, -26512, -26225, -25939, -25655, -25376, -25098, -24824, -24551, -24279, -24013, -23746, -23482, -23222, -22961, -22703, -22450, -22196, -21947, -21699, -21452, -21208, -20966, -20726, -20488, -20252, -20019, -19786, -19556, -19329, -19103, -18881, -18659, -18439, -18222, -18006, -17792, -17581, -17371, -17163, -16957, -16752, -16551, -16350, -16151, -15954, -15758, -15565, -15373, -15182, -14994, -14806, -14621, -14438, -14256, -14075, -13896, -13719, -13544, -13369, -13197, -13027, -12857, -12690, -12523, -12359, -12196, -12034, -11875, -11716, -11559, -11404, -11249, -11097, -10946, -10795, -10646, -10500, -10353, -10209, -10065, -9923, -9784, -9644, -9506, -9369, -9232, -9098, -8965, -8834, -8703, -8573, -8446, -8319, -8191, -8068, -7944, -7822, -7703, -7582, -7465, -7348, -7230, -7117, -7003, -6890, -6780, -6668, -6560, -6451, -6341, -6238, -6131, -6028, -5927, -5818, -5671, -5840, -4213};