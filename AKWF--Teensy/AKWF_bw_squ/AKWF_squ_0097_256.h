/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0097 256 samples */
 
const int16_t AKWF_squ_0097_256_DATA [256] = 
{207, 508, 802, 1096, 1391, 1688, 1983, 2278, 2572, 2868, 3165, 3460, 3755, 4049, 4346, 4642, 4936, 5234, 5529, 5823, 6118, 6414, 6710, 7005, 7300, 7594, 7891, 8187, 8481, 8776, 9071, 9368, 9664, 9958, 10255, 10551, 10845, 11139, 11435, 11732, 12026, 12322, 12616, 12912, 13209, 13503, 13798, 14095, 14390, 14685, 14980, 15276, 15572, 15867, 16161, 16457, 16754, 17048, 17343, 17638, 17934, 18230, 18525, 18822, 19117, 19412, 19706, 20002, 20299, 20593, 20889, 21183, 21479, 21776, 22070, 22365, 22660, 22956, 23252, 23547, 23843, 24139, 24434, 24728, 25023, 25321, 25615, 25910, 26205, 26500, 26797, 27092, 27386, 27681, 27978, 28274, 28568, 28865, 29161, 29455, 29750, 30045, 30342, 30637, 30932, 31227, 31522, 31819, 32113, 32408, 32702, 32778, 32764, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};