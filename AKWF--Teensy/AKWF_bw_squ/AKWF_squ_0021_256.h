/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0021 256 samples */
 
const int16_t AKWF_squ_0021_256_DATA [256] = 
{17313, 33514, 31667, 31567, 31256, 30929, 30597, 30275, 29950, 29628, 29313, 28995, 28682, 28374, 28064, 27760, 27458, 27158, 26862, 26566, 26274, 25983, 25697, 25412, 25129, 24849, 24572, 24297, 24026, 23756, 23488, 23223, 22960, 22700, 22442, 22185, 21933, 21680, 21431, 21185, 20940, 20697, 20455, 20216, 19981, 19746, 19514, 19284, 19055, 18828, 18604, 18380, 18161, 17942, 17725, 17511, 17298, 17087, 16878, 16671, 16466, 16263, 16061, 15862, 15663, 15467, 15274, 15081, 14891, 14702, 14514, 14329, 14145, 13963, 13782, 13602, 13425, 13249, 13075, 12902, 12731, 12561, 12393, 12226, 12061, 11898, 11735, 11575, 11416, 11260, 11103, 10947, 10795, 10642, 10493, 10344, 10196, 10052, 9908, 9763, 9623, 9481, 9342, 9205, 9068, 8932, 8799, 8664, 8534, 8402, 8274, 8146, 8017, 7892, 7766, 7642, 7522, 7397, 7278, 7159, 7037, 6926, 6808, 6693, 6583, 6384, 6328, 6296, -16027, -33640, -31673, -31587, -31280, -30943, -30613, -30287, -29960, -29640, -29320, -29004, -28692, -28380, -28073, -27766, -27462, -27164, -26865, -26571, -26280, -25989, -25704, -25419, -25137, -24859, -24580, -24307, -24035, -23764, -23497, -23233, -22969, -22710, -22449, -22194, -21941, -21689, -21439, -21193, -20947, -20705, -20462, -20223, -19987, -19752, -19520, -19289, -19060, -18833, -18608, -18387, -18166, -17947, -17732, -17516, -17304, -17094, -16885, -16678, -16473, -16270, -16069, -15869, -15671, -15475, -15280, -15088, -14897, -14708, -14520, -14335, -14150, -13967, -13786, -13608, -13430, -13254, -13080, -12905, -12735, -12566, -12397, -12232, -12066, -11901, -11741, -11580, -11421, -11265, -11109, -10955, -10801, -10649, -10500, -10351, -10204, -10058, -9913, -9770, -9628, -9487, -9347, -9209, -9072, -8935, -8800, -8668, -8535, -8404, -8275, -8146, -8019, -7895, -7767, -7646, -7523, -7402, -7285, -7164, -7049, -6934, -6817, -6710, -6595, -6455, -6533, -5493};