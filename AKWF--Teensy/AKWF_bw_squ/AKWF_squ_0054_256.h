/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0054 256 samples */
 
const int16_t AKWF_squ_0054_256_DATA [256] = 
{52, 207, 368, 519, 667, 817, 957, 1098, 1238, 1370, 1496, 1624, 1750, 1871, 1987, 2107, 2215, 2322, 2430, 2540, 2870, 1644, 14973, 26695, 26082, 27009, 27615, 28141, 28595, 28980, 29298, 29564, 29772, 29928, 30040, 30103, 30128, 30111, 30056, 29971, 29845, 29692, 29521, 29317, 29088, 28847, 28580, 28293, 27989, 27669, 27338, 26990, 26638, 26280, 25882, 25481, 25094, 24693, 24292, 23870, 23451, 23033, 22607, 22176, 21746, 21315, 20883, 20446, 20014, 19581, 19141, 18712, 18278, 17846, 17426, 16994, 16569, 16150, 15729, 15309, 14903, 14495, 14089, 13683, 13291, 12901, 12498, 12102, 11729, 11352, 10977, 10608, 10247, 9887, 9533, 9183, 8835, 8498, 8162, 7822, 7501, 7182, 6861, 6550, 6240, 5937, 5646, 5351, 5061, 4778, 4495, 4226, 3962, 3693, 3435, 3175, 2938, 2697, 2424, 2194, 1971, 1747, 1522, 1305, 1089, 871, 675, 474, 274, 75, -107, -291, -474, -651, -830, -997, -1167, -1325, -1486, -1641, -1793, -1939, -2082, -2224, -2371, -2521, -2819, -2206, -9488, -27389, -30584, -30742, -31353, -31768, -32106, -32371, -32567, -32688, -32753, -32764, -32728, -32644, -32514, -32350, -32144, -31901, -31632, -31337, -31015, -30667, -30307, -29923, -29529, -29110, -28681, -28239, -27793, -27335, -26866, -26398, -25907, -25431, -24960, -24461, -23969, -23478, -22989, -22499, -22007, -21528, -21037, -20553, -20069, -19589, -19114, -18642, -18169, -17712, -17254, -16802, -16353, -15904, -15470, -15033, -14607, -14184, -13770, -13357, -12956, -12549, -12156, -11767, -11378, -11015, -10656, -10288, -9925, -9568, -9228, -8884, -8551, -8224, -7902, -7585, -7271, -6963, -6668, -6367, -6082, -5800, -5519, -5245, -4975, -4713, -4458, -4203, -3952, -3714, -3474, -3242, -3005, -2784, -2564, -2345, -2133, -1940, -1745, -1540, -1349, -1158, -973, -789, -613, -438, -270, -101};