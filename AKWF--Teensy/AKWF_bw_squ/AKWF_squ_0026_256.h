/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0026 256 samples */
 
const int16_t AKWF_squ_0026_256_DATA [256] = 
{17485, 33508, 31758, 31620, 31307, 30965, 30630, 30302, 29969, 29644, 29320, 28998, 28683, 28366, 28053, 27743, 27435, 27132, 26829, 26530, 26235, 25939, 25649, 25360, 25072, 24791, 24509, 24230, 23955, 23681, 23410, 23142, 22874, 22611, 22348, 22089, 21832, 21576, 21324, 21073, 20824, 20578, 20334, 20091, 19851, 19613, 19378, 19143, 18912, 18683, 18455, 18230, 18007, 17784, 17566, 17348, 17132, 16921, 16707, 16498, 16291, 16085, 15882, 15680, 15479, 15282, 15084, 14889, 14697, 14504, 14316, 14127, 13941, 13757, 13573, 13391, 13212, 13034, 12858, 12682, 12509, 12338, 12167, 12000, 11833, 11666, 11505, 11341, 11180, 11022, 10863, 10709, 10555, 10400, 10251, 10100, 9951, 9805, 9658, 9515, 9371, 9228, 9090, 8948, 8811, 8676, 8534, 8339, 8196, 8350, -12332, -29683, -27933, -27875, -27605, -27323, -27037, -26752, -26475, -26193, -25918, -25644, -25371, -25103, -24835, -24568, -24308, -24046, -23786, -23530, -23274, -23023, -22772, -22524, -22279, -22034, -21793, -21553, -21314, -21080, -20846, -20614, -20386, -20158, -19933, -19710, -19488, -19269, -19051, -18835, -18622, -18409, -18200, -17992, -17785, -17581, -17378, -17177, -16979, -16781, -16586, -16392, -16198, -16007, -15819, -15631, -15446, -15262, -15079, -14898, -14718, -14541, -14364, -14191, -14017, -13845, -13677, -13508, -13341, -13176, -13011, -12849, -12690, -12530, -12373, -12216, -12061, -11907, -11755, -11604, -11454, -11307, -11159, -11014, -10869, -10727, -10584, -10444, -10304, -10167, -10030, -9895, -9760, -9628, -9496, -9366, -9237, -9108, -8983, -8856, -8731, -8610, -8487, -8366, -8246, -8127, -8010, -7894, -7779, -7665, -7551, -7440, -7328, -7218, -7109, -7000, -6893, -6787, -6682, -6578, -6474, -6372, -6271, -6169, -6070, -5973, -5874, -5779, -5684, -5590, -5498, -5404, -5313, -5223, -5133, -5045, -4958, -4870, -4787, -4699, -4617, -4536, -4450, -4351, -4407, -3618};