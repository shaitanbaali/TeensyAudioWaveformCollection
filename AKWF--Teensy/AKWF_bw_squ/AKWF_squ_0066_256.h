/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0066 256 samples */
 
const int16_t AKWF_squ_0066_256_DATA [256] = 
{13362, 14229, 14089, 14120, 14125, 14128, 14130, 14132, 14135, 14136, 14136, 14136, 14136, 14136, 14136, 14134, 14133, 14131, 14129, 14128, 14126, 14123, 14121, 14119, 14116, 14113, 14110, 14107, 14105, 14101, 14099, 14096, 14092, 14088, 14085, 14083, 14079, 14076, 14072, 14068, 14065, 14061, 14058, 14054, 14050, 14046, 14043, 14039, 14036, 14032, 14028, 14025, 14021, 14018, 14014, 14011, 14007, 14003, 13999, 13995, 13991, 13987, 13984, 13980, 13977, 13973, 13969, 13966, 13962, 13959, 13954, 13950, 13946, 13943, 13939, 13936, 13932, 13928, 13924, 13921, 13917, 13914, 13908, 13905, 13901, 13898, 13894, 13891, 13887, 13883, 13880, 13876, 13873, 13869, 13865, 13860, 13857, 13853, 13850, 13846, 13842, 13839, 13835, 13832, 13828, 13824, 13821, 13817, 13814, 13809, 13804, 13801, 13797, 13794, 13790, 13787, 13783, 13779, 13776, 13772, 13769, 13765, 13761, 13758, 13754, 13750, 13745, 13742, 13738, 13735, 13731, 13727, 13724, 13720, 13717, 13713, 13710, 13706, 13702, 13698, 13694, 13690, 13686, 13682, 13679, 13675, 13672, 13668, 13665, 13661, 13657, 13654, 13650, 13647, 13643, 13639, 13636, 13632, 13629, 13625, 13621, 13618, 13614, 13611, 13607, 13603, 13598, 13595, 13591, 13588, 13584, 13580, 13576, 13573, 13569, 13566, 13438, 13781, 12673, -24089, -34448, -32380, -32766, -32767, -32766, -32764, -32762, -32759, -32755, -32751, -32746, -32741, -32736, -32731, -32725, -32718, -32712, -32705, -32698, -32691, -32683, -32676, -32669, -32662, -32655, -32647, -32639, -32632, -32623, -32615, -32607, -32598, -32590, -32582, -32574, -32566, -32557, -32549, -32540, -32532, -32524, -32514, -32506, -32497, -32490, -32481, -32472, -32463, -32455, -32446, -32438, -32429, -32421, -32412, -32403, -32394, -32386, -32377, -32368, -32360, -32351, -32343, -32334, -32325, -32316, -32308, -32299, -32291, -32282, -32274, -32265, -32256, -32237, -31882, -33868, -14785};