/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0048 256 samples */
 
const int16_t AKWF_squ_0048_256_DATA [256] = 
{8636, 30711, 32599, 31666, 31450, 31080, 30478, 31324, 21548, -1147, -3375, -2770, -2895, -2865, -2834, -2808, -2779, -2751, -2724, -2696, -2670, -2644, -2617, -2593, -2567, -2541, -2516, -2491, -2466, -2442, -2418, -2395, -2370, -2347, -2323, -2300, -2277, -2254, -2231, -2209, -2187, -2164, -2143, -2122, -2099, -2078, -2057, -2035, -2014, -1994, -1973, -1952, -1932, -1912, -1892, -1873, -1853, -1833, -1815, -1796, -1777, -1758, -1740, -1722, -1703, -1686, -1668, -1649, -1632, -1615, -1597, -1579, -1563, -1546, -1529, -1513, -1496, -1480, -1464, -1447, -1432, -1417, -1400, -1384, -1370, -1355, -1340, -1324, -1310, -1295, -1280, -1266, -1252, -1237, -1224, -1210, -1196, -1182, -1168, -1155, -1142, -1129, -1115, -1102, -1090, -1076, -1064, -1052, -1039, -1027, -1015, -1002, -991, -978, -967, -955, -944, -933, -921, -909, -898, -887, -876, -866, -855, -844, -833, -823, -812, -801, -791, -781, -770, -760, -751, -740, -732, -724, -714, -704, -695, -686, -676, -667, -659, -650, -640, -631, -624, -615, -607, -598, -590, -582, -573, -565, -557, -549, -542, -534, -526, -518, -511, -503, -496, -488, -481, -474, -467, -459, -453, -445, -438, -431, -425, -418, -411, -405, -398, -392, -385, -379, -373, -367, -361, -355, -349, -342, -336, -330, -325, -319, -313, -308, -302, -297, -291, -286, -280, -275, -270, -265, -260, -255, -248, -244, -239, -234, -230, -225, -220, -216, -210, -206, -202, -197, -192, -188, -184, -179, -175, -171, -167, -162, -159, -155, -151, -147, -142, -138, -135, -131, -127, -123, -119, -115, -111, -108, -105, -101, -97, -94, -91, -88, -84, -80, -78, -75, -72, -70, -66, -66, -63, -62, -66, -76};