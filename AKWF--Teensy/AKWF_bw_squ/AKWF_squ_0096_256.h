/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0096 256 samples */
 
const int16_t AKWF_squ_0096_256_DATA [256] = 
{214, 529, 835, 1141, 1448, 1755, 2062, 2369, 2678, 2985, 3291, 3598, 3905, 4212, 4520, 4829, 5135, 5441, 5748, 6055, 6363, 6672, 6978, 7286, 7592, 7898, 8206, 8513, 8822, 9129, 9436, 9742, 10049, 10356, 10664, 10972, 11279, 11586, 11893, 12199, 12506, 12816, 13122, 13429, 13737, 14043, 14349, 14657, 14966, 15272, 15580, 15886, 16194, 16500, 16809, 17117, 17423, 17730, 18037, 18344, 18650, 18960, 19267, 19573, 19880, 20187, 20494, 20803, 21110, 21417, 21724, 22030, 22337, 22645, 22953, 23261, 23568, 23874, 24181, 24488, 24795, 25104, 25411, 25718, 26025, 26331, 26638, 26946, 27254, 27561, 27868, 28175, 28481, 28789, 29098, 29404, 29712, 30018, 30325, 30632, 30941, 31249, 31555, 31862, 32166, 32482, 32748, 32771, 32766, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};