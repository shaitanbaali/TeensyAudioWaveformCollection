/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0041 256 samples */
 
const int16_t AKWF_squ_0041_256_DATA [256] = 
{5304, 28450, 32881, 31544, 31409, 31042, 30688, 30338, 29985, 29641, 29295, 28953, 28618, 28280, 27949, 27619, 27292, 26970, 26647, 26329, 26014, 25699, 25392, 25085, 24778, 24481, 24178, 23882, 23593, 23298, 23014, 22724, 22233, 22909, 16425, -7112, -11933, -10812, -10934, -10821, -10710, -10607, -10499, -10394, -10292, -10188, -10086, -9984, -9883, -9785, -9685, -9588, -9492, -9395, -9301, -9206, -9112, -9020, -8927, -8837, -8746, -8656, -8569, -8480, -8393, -8307, -8221, -8136, -8051, -7967, -7885, -7802, -7720, -7639, -7559, -7480, -7401, -7322, -7245, -7168, -7091, -7015, -6941, -6867, -6792, -6719, -6647, -6575, -6503, -6433, -6364, -6294, -6225, -6157, -6090, -6022, -5956, -5890, -5825, -5760, -5696, -5632, -5569, -5507, -5444, -5383, -5322, -5261, -5202, -5143, -5084, -5026, -4968, -4911, -4853, -4797, -4741, -4686, -4632, -4577, -4524, -4470, -4417, -4365, -4313, -4261, -4211, -4160, -4109, -4059, -4009, -3961, -3912, -3864, -3817, -3769, -3723, -3677, -3631, -3586, -3540, -3496, -3452, -3408, -3365, -3322, -3278, -3236, -3195, -3153, -3112, -3071, -3030, -2991, -2951, -2912, -2873, -2835, -2796, -2758, -2722, -2684, -2647, -2612, -2577, -2540, -2505, -2470, -2435, -2401, -2366, -2332, -2299, -2266, -2232, -2200, -2168, -2135, -2103, -2072, -2041, -2011, -1980, -1950, -1920, -1891, -1861, -1832, -1803, -1775, -1747, -1718, -1691, -1663, -1636, -1609, -1582, -1556, -1530, -1503, -1478, -1452, -1427, -1401, -1378, -1353, -1329, -1305, -1281, -1257, -1234, -1211, -1188, -1166, -1144, -1121, -1100, -1078, -1056, -1036, -1014, -993, -973, -953, -933, -912, -893, -873, -853, -834, -815, -796, -778, -759, -740, -722, -704, -687, -668, -651, -634, -617, -601, -584, -567, -551, -535, -520, -506, -489, -476, -463, -447, -440, -419, -432};