/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0007 256 samples */
 
const int16_t AKWF_squ_0007_256_DATA [256] = 
{16485, 33887, 31633, 31614, 31284, 30955, 30623, 30295, 29974, 29650, 29333, 29018, 28703, 28395, 28087, 27782, 27481, 27180, 26884, 26590, 26297, 26008, 25722, 25436, 25155, 24876, 24597, 24323, 24050, 23781, 23513, 23247, 22984, 22722, 22464, 22208, 21953, 21701, 21450, 21203, 20958, 20714, 20473, 20235, 19997, 19763, 19531, 19300, 19072, 18845, 18620, 18398, 18178, 17959, 17743, 17528, 17316, 17105, 16895, 16689, 16482, 16280, 16079, 15878, 15681, 15484, 15289, 15096, 14905, 14715, 14527, 14342, 14158, 13975, 13794, 13615, 13437, 13262, 13086, 12913, 12743, 12573, 12404, 12239, 12073, 11910, 11748, 11588, 11429, 11272, 11115, 10961, 10808, 10656, 10506, 10356, 10209, 10063, 9918, 9774, 9631, 9491, 9351, 9212, 9076, 8939, 8805, 8672, 8539, 8409, 8280, 8150, 8024, 7898, 7773, 7651, 7528, 7408, 7289, 7169, 7054, 6937, 6821, 6712, 6596, 6416, 6292, 6684, -17045, -34071, -31574, -31616, -31281, -30948, -30619, -30288, -29965, -29643, -29323, -29009, -28694, -28383, -28077, -27770, -27468, -27169, -26871, -26578, -26285, -25996, -25711, -25425, -25144, -24864, -24586, -24312, -24041, -23770, -23503, -23237, -22974, -22714, -22455, -22199, -21945, -21693, -21444, -21195, -20951, -20707, -20466, -20228, -19990, -19755, -19523, -19292, -19063, -18837, -18612, -18391, -18170, -17950, -17735, -17520, -17307, -17097, -16888, -16681, -16476, -16272, -16071, -15872, -15673, -15478, -15283, -15090, -14900, -14710, -14523, -14336, -14152, -13970, -13789, -13609, -13432, -13256, -13081, -12908, -12737, -12568, -12399, -12233, -12068, -11904, -11743, -11581, -11423, -11266, -11109, -10955, -10802, -10650, -10500, -10351, -10204, -10058, -9914, -9770, -9628, -9486, -9348, -9209, -9072, -8937, -8802, -8669, -8538, -8406, -8278, -8148, -8021, -7896, -7770, -7647, -7525, -7402, -7284, -7164, -7045, -6932, -6813, -6700, -6589, -6435, -6527, -5354};