/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0094 256 samples */
 
const int16_t AKWF_squ_0094_256_DATA [256] = 
{233, 573, 906, 1240, 1573, 1907, 2242, 2575, 2909, 3243, 3577, 3912, 4245, 4578, 4912, 5247, 5580, 5914, 6248, 6583, 6917, 7251, 7585, 7919, 8252, 8585, 8919, 9254, 9588, 9922, 10256, 10590, 10924, 11258, 11592, 11926, 12259, 12593, 12928, 13261, 13595, 13929, 14263, 14597, 14931, 15265, 15598, 15932, 16266, 16600, 16934, 17269, 17603, 17937, 18271, 18604, 18938, 19271, 19605, 19940, 20274, 20608, 20942, 21276, 21610, 21944, 22277, 22611, 22945, 23279, 23613, 23947, 24281, 24615, 24949, 25282, 25617, 25950, 26284, 26618, 26952, 27286, 27620, 27955, 28289, 28622, 28955, 29290, 29623, 29957, 30291, 30626, 30960, 31294, 31628, 31961, 32293, 32640, 32781, 32764, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};