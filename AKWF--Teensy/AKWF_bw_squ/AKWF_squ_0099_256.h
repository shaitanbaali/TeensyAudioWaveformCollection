/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0099 256 samples */
 
const int16_t AKWF_squ_0099_256_DATA [256] = 
{193, 471, 744, 1018, 1292, 1567, 1841, 2115, 2389, 2664, 2938, 3212, 3487, 3761, 4035, 4310, 4583, 4858, 5133, 5407, 5681, 5956, 6230, 6505, 6779, 7052, 7327, 7601, 7875, 8150, 8423, 8698, 8973, 9247, 9522, 9796, 10070, 10345, 10619, 10893, 11167, 11441, 11716, 11990, 12265, 12539, 12812, 13087, 13361, 13635, 13910, 14184, 14459, 14734, 15007, 15283, 15556, 15830, 16105, 16379, 16654, 16928, 17201, 17476, 17750, 18025, 18298, 18574, 18848, 19122, 19397, 19671, 19945, 20220, 20494, 20768, 21043, 21316, 21591, 21865, 22139, 22414, 22688, 22962, 23236, 23511, 23786, 24060, 24334, 24609, 24882, 25157, 25431, 25705, 25980, 26253, 26528, 26803, 27076, 27351, 27625, 27899, 28175, 28448, 28723, 28998, 29271, 29546, 29820, 30094, 30369, 30643, 30916, 31191, 31466, 31740, 32014, 32285, 32572, 32769, 32767, 32767, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};