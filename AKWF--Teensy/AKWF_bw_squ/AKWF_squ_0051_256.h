/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0051 256 samples */
 
const int16_t AKWF_squ_0051_256_DATA [256] = 
{7768, 31344, 24873, 1266, -1244, -589, -749, -739, -730, -723, -716, -708, -701, -694, -688, -681, -675, -668, -661, -655, -649, -642, -635, -629, -623, -617, -611, -605, -600, -593, -587, -581, -575, -569, -564, -558, -553, -547, -542, -536, -530, -525, -520, -514, -509, -504, -499, -493, -488, -484, -478, -474, -468, -464, -459, -454, -449, -445, -440, -435, -431, -427, -422, -417, -413, -409, -404, -400, -395, -391, -387, -383, -378, -374, -370, -366, -362, -359, -354, -351, -347, -343, -339, -335, -332, -328, -324, -320, -316, -313, -310, -306, -302, -299, -296, -292, -289, -286, -283, -280, -276, -273, -270, -266, -263, -260, -257, -254, -251, -248, -244, -242, -239, -235, -233, -231, -227, -224, -222, -219, -216, -214, -212, -209, -205, -204, -201, -197, -195, -192, -190, -188, -186, -184, -181, -179, -176, -174, -172, -169, -167, -165, -163, -160, -158, -156, -154, -152, -149, -148, -145, -143, -142, -140, -137, -136, -134, -132, -129, -128, -125, -124, -122, -120, -119, -116, -115, -113, -112, -110, -108, -106, -104, -103, -101, -99, -99, -97, -95, -94, -92, -90, -89, -87, -86, -84, -82, -82, -80, -78, -77, -76, -74, -73, -72, -70, -69, -68, -66, -65, -63, -62, -61, -60, -58, -57, -56, -55, -53, -53, -52, -51, -49, -48, -47, -46, -45, -44, -43, -42, -41, -40, -39, -38, -36, -36, -35, -34, -32, -32, -31, -30, -29, -28, -27, -27, -25, -24, -24, -23, -22, -20, -20, -19, -19, -19, -18, -18, -17, -15, -15, -15, -14, -16, -10, -29};