/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0056 256 samples */
 
const int16_t AKWF_squ_0056_256_DATA [256] = 
{52, 161, 265, 364, 466, 566, 660, 752, 850, 930, 1014, 1098, 1185, 1263, 1337, 1416, 1493, 1560, 1635, 1708, 1772, 1844, 1909, 1952, 2017, 2076, 2132, 2190, 2247, 2297, 2345, 2400, 2444, 2489, 2532, 2581, 2623, 2663, 2705, 2740, 2784, 2826, 2858, 2896, 2929, 2954, 2988, 3026, 3047, 3074, 3107, 3126, 3153, 3192, 3211, 3208, 3239, 3263, 3604, 1910, 14005, 29521, 28949, 29879, 30503, 31027, 31476, 31846, 32145, 32382, 32559, 32681, 32748, 32761, 32732, 32659, 32548, 32402, 32221, 32004, 31753, 31484, 31186, 30865, 30522, 30157, 29766, 29351, 28946, 28520, 28078, 27613, 27160, 26689, 26205, 25716, 25219, 24719, 24214, 23707, 23195, 22678, 22164, 21650, 21129, 20612, 20090, 19572, 19054, 18547, 18037, 17527, 17020, 16509, 16013, 15512, 15022, 14546, 14039, 13546, 13088, 12612, 12145, 11690, 11230, 10779, 10326, 9883, 9317, 9293, 6058, -14116, -23393, -23401, -24513, -25315, -26020, -26630, -27168, -27626, -28004, -28302, -28539, -28727, -28854, -28942, -28969, -28973, -28907, -28814, -28705, -28551, -28360, -28158, -27924, -27672, -27405, -27112, -26803, -26484, -26150, -25803, -25446, -25080, -24708, -24323, -23938, -23547, -23153, -22758, -22359, -21948, -21541, -21144, -20730, -20319, -19918, -19513, -19111, -18711, -18303, -17911, -17536, -17138, -16751, -16366, -15984, -15609, -15240, -14873, -14506, -14144, -13791, -13438, -13094, -12751, -12417, -12080, -11749, -11433, -11117, -10798, -10490, -10191, -9882, -9599, -9306, -9014, -8737, -8460, -8190, -7924, -7647, -7397, -7164, -6902, -6650, -6421, -6182, -5953, -5720, -5500, -5283, -5064, -4856, -4644, -4447, -4248, -4057, -3861, -3677, -3490, -3311, -3137, -2962, -2791, -2629, -2465, -2303, -2146, -1999, -1843, -1692, -1541, -1397, -1275, -1155, -1001, -873, -745, -622, -502, -384, -272, -164, -48};