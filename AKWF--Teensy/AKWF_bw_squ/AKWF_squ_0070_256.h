/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0070 256 samples */
 
const int16_t AKWF_squ_0070_256_DATA [256] = 
{-16133, -34703, -32266, -32706, -32966, -11053, 2040, 303, 626, 637, 638, 640, 641, 643, 645, 645, 646, 647, 648, 648, 649, 650, 650, 651, 650, 651, 651, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 652, 651, 650, 651, 651, 651, 651, 651, 651, 650, 649, 650, 650, 650, 650, 650, 649, 648, 649, 649, 649, 649, 648, 647, 648, 648, 648, 648, 647, 646, 647, 647, 647, 647, 647, 646, 645, 646, 646, 646, 646, 645, 644, 645, 645, 645, 645, 644, 644, 644, 644, 644, 643, 644, 642, 641, 642, 642, 642, 642, 642, 641, 640, 641, 641, 641, 641, 640, 639, 640, 640, 640, 640, 639, 639, 638, 639, 639, 639, 639, 638, 637, 638, 638, 638, 637, 636, 637, 637, 637, 637, 636, 635, 636, 636, 636, 636, 635, 635, 635, 635, 635, 635, 635, 634, 633, 634, 634, 634, 634, 634, 632, 631, 632, 632, 632, 632, 631, 630, 631, 631, 631, 631, 630, 630, 630, 630, 630, 630, 630, 629, 628, 629, 629, 629, 629, 629, 628, 627, 628, 628, 628, 628, 627, 627, 627, 627, 627, 627, 627, 626, 625, 626, 626, 626, 626, 625, 624, 625, 625, 625, 625, 625, 624, 623, 624, 624, 624, 624, 623, 622, 621, 622, 622, 622, 622, 621, 621, 621, 621, 621, 621, 621, 620, 619, 620, 620, 620, 620, 620, 619, 618, 619, 619, 619, 619, 618, 618, 618, 618, 618, 618, 618, 617, 616, 617, 617, 617};