/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0028 256 samples */
 
const int16_t AKWF_squ_0028_256_DATA [256] = 
{14483, 33032, 31840, 31573, 31283, 30940, 30606, 30274, 29940, 29615, 29288, 28964, 28645, 28325, 28012, 27699, 27389, 27084, 26778, 26476, 26177, 25880, 25587, 25295, 25006, 24720, 24436, 24155, 23878, 23599, 23327, 23056, 22786, 22521, 22257, 21994, 21736, 21479, 21224, 20972, 20722, 20474, 20227, 19983, 19742, 19502, 19266, 19030, 18796, 18564, 18335, 18109, 17883, 17659, 17440, 17220, 17002, 16788, 16574, 16363, 16154, 15946, 15741, 15537, 15336, 15137, 14938, 14742, 14548, 14355, 14165, 13976, 13789, 13604, 13420, 13237, 13057, 12876, 12700, 12523, 12350, 12177, 12005, 11836, 11667, 11499, 11336, 11171, 11009, 10850, 10687, 10533, 10376, 10220, 10071, 9874, 9595, 10355, -7166, -26767, -25662, -25448, -25244, -24978, -24719, -24462, -24203, -23951, -23699, -23450, -23204, -22957, -22715, -22475, -22235, -22000, -21764, -21531, -21302, -21073, -20847, -20623, -20400, -20180, -19961, -19744, -19530, -19317, -19105, -18895, -18687, -18482, -18278, -18075, -17874, -17676, -17480, -17284, -17090, -16899, -16707, -16519, -16331, -16145, -15962, -15780, -15598, -15419, -15241, -15066, -14891, -14718, -14548, -14378, -14209, -14043, -13877, -13714, -13552, -13391, -13231, -13073, -12916, -12761, -12608, -12455, -12304, -12153, -12005, -11857, -11711, -11567, -11424, -11282, -11141, -11001, -10863, -10725, -10589, -10455, -10321, -10189, -10059, -9928, -9800, -9672, -9547, -9422, -9297, -9175, -9053, -8933, -8813, -8695, -8578, -8462, -8346, -8233, -8120, -8007, -7897, -7786, -7678, -7569, -7462, -7357, -7251, -7146, -7044, -6942, -6840, -6741, -6642, -6544, -6446, -6350, -6255, -6159, -6066, -5974, -5882, -5791, -5701, -5612, -5523, -5436, -5350, -5266, -5180, -5095, -5011, -4929, -4847, -4764, -4684, -4604, -4525, -4448, -4370, -4292, -4217, -4140, -4067, -3994, -3920, -3850, -3776, -3706, -3638, -3567, -3501, -3435, -3367, -3299, -3291, -2936};