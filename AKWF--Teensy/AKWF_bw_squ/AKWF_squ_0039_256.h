/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0039 256 samples */
 
const int16_t AKWF_squ_0039_256_DATA [256] = 
{5488, 28710, 32851, 31562, 31423, 31063, 30708, 30362, 30012, 29668, 29330, 28988, 28653, 28321, 27990, 27665, 27338, 27016, 26698, 26381, 26069, 25756, 25449, 25146, 24841, 24542, 24244, 23948, 23659, 23368, 23081, 22799, 22516, 22239, 21963, 21688, 21422, 21151, 20886, 20626, 20154, 20890, 14104, -9564, -14104, -12988, -13075, -12944, -12809, -12684, -12556, -12427, -12304, -12179, -12057, -11936, -11814, -11696, -11577, -11459, -11344, -11227, -11114, -11001, -10888, -10777, -10666, -10557, -10450, -10341, -10234, -10129, -10024, -9919, -9816, -9714, -9612, -9511, -9411, -9312, -9213, -9116, -9020, -8924, -8829, -8734, -8641, -8548, -8457, -8366, -8275, -8186, -8098, -8010, -7923, -7837, -7751, -7667, -7583, -7499, -7416, -7335, -7253, -7173, -7093, -7014, -6935, -6858, -6780, -6704, -6629, -6553, -6478, -6404, -6330, -6259, -6187, -6115, -6045, -5975, -5905, -5837, -5768, -5700, -5633, -5567, -5501, -5436, -5371, -5306, -5243, -5180, -5117, -5056, -4995, -4934, -4873, -4814, -4755, -4696, -4639, -4581, -4524, -4467, -4411, -4355, -4300, -4245, -4192, -4138, -4085, -4032, -3980, -3928, -3878, -3827, -3776, -3726, -3677, -3629, -3581, -3533, -3485, -3438, -3392, -3345, -3299, -3254, -3209, -3165, -3120, -3078, -3034, -2992, -2949, -2907, -2865, -2823, -2782, -2742, -2701, -2662, -2622, -2583, -2544, -2506, -2469, -2430, -2394, -2356, -2320, -2284, -2249, -2213, -2177, -2143, -2109, -2075, -2040, -2006, -1973, -1941, -1907, -1876, -1844, -1812, -1781, -1750, -1719, -1689, -1658, -1628, -1599, -1570, -1541, -1511, -1483, -1455, -1427, -1400, -1372, -1346, -1319, -1292, -1267, -1241, -1215, -1191, -1165, -1140, -1116, -1090, -1067, -1043, -1018, -995, -971, -948, -926, -902, -879, -858, -836, -815, -792, -771, -750, -729, -711, -689, -669, -653, -631, -618, -600, -599};