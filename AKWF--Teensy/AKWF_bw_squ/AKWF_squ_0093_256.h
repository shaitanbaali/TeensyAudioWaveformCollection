/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0093 256 samples */
 
const int16_t AKWF_squ_0093_256_DATA [256] = 
{243, 598, 946, 1296, 1646, 1995, 2344, 2692, 3042, 3391, 3740, 4089, 4438, 4786, 5136, 5485, 5833, 6182, 6533, 6883, 7232, 7580, 7929, 8279, 8628, 8976, 9326, 9675, 10023, 10372, 10722, 11070, 11419, 11770, 12119, 12468, 12816, 13166, 13516, 13864, 14213, 14562, 14911, 15260, 15609, 15958, 16307, 16656, 17007, 17356, 17704, 18054, 18403, 18752, 19101, 19450, 19799, 20147, 20497, 20845, 21194, 21544, 21894, 22244, 22593, 22941, 23291, 23640, 23988, 24337, 24687, 25035, 25384, 25734, 26082, 26431, 26781, 27131, 27481, 27829, 28178, 28527, 28877, 29225, 29574, 29923, 30272, 30621, 30970, 31319, 31667, 32017, 32369, 32707, 32777, 32764, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32065, 35778, 16970, -33450, -32701, -32633, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32199, -35257, -18859};