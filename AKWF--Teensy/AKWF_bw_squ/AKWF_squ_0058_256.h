/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0058 256 samples */
 
const int16_t AKWF_squ_0058_256_DATA [256] = 
{14, 29, 48, 49, 43, 56, 75, 81, 97, 103, 112, 117, 129, 132, 145, 155, 165, 172, 183, 187, 196, 202, 213, 212, 213, 226, 234, 237, 238, 241, 256, 261, 261, 267, 279, 281, 272, 274, 282, 283, 295, 292, 298, 304, 308, 304, 309, 314, 317, 319, 310, 322, 322, 323, 324, 330, 334, 331, 334, 343, 337, 338, 338, 337, 346, 343, 347, 358, 341, 331, 344, 349, 350, 348, 348, 349, 351, 361, 353, 355, 357, 353, 356, 353, 355, 356, 355, 359, 361, 362, 361, 360, 360, 358, 361, 355, 384, 614, -892, 17606, 31434, 30531, 31591, 32223, 33020, 17521, 2588, 2818, 2172, 1680, 1225, 812, 424, 67, -260, -564, -849, -1105, -1348, -1568, -1768, -1953, -2117, -2273, -2399, -2523, -2649, -2752, -2840, -2910, -2982, -3035, -3104, -3165, -3188, -3218, -3243, -3264, -3277, -3284, -3291, -3285, -3282, -3277, -3262, -3250, -3235, -3207, -3183, -3165, -3130, -3102, -3074, -3041, -3005, -2967, -2931, -2898, -2858, -2818, -2777, -2736, -2698, -2645, -2619, -2590, -2537, -2486, -2452, -2407, -2365, -2321, -2280, -2229, -2185, -2145, -2103, -2061, -2016, -1981, -1941, -1892, -1853, -1815, -1768, -1736, -1698, -1659, -1614, -1578, -1538, -1498, -1464, -1430, -1405, -1359, -1336, -1317, -1272, -1241, -1198, -1176, -1131, -1102, -1067, -1034, -1007, -978, -952, -922, -897, -858, -832, -811, -782, -751, -722, -707, -670, -651, -621, -605, -578, -558, -537, -512, -487, -450, -441, -442, -411, -392, -364, -345, -334, -311, -294, -282, -263, -245, -228, -209, -194, -178, -159, -151, -134, -117, -109, -91, -80, -65, -50, -40, -30, -13};