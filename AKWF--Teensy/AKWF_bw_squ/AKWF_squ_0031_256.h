/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0031 256 samples */
 
const int16_t AKWF_squ_0031_256_DATA [256] = 
{9898, 31937, 32496, 31814, 31574, 31222, 30871, 30531, 30187, 29848, 29516, 29182, 28854, 28528, 28204, 27886, 27569, 27254, 26943, 26634, 26329, 26026, 25725, 25428, 25132, 24840, 24551, 24263, 23979, 23696, 23415, 23139, 22863, 22591, 22321, 22051, 21787, 21523, 21261, 21004, 20747, 20492, 20241, 19990, 19743, 19498, 19254, 19014, 18775, 18540, 18305, 18073, 17844, 17615, 17390, 17168, 16945, 16727, 16510, 16294, 16082, 15869, 15659, 15453, 15244, 15042, 14839, 14637, 14441, 14242, 14046, 13855, 13658, 13470, 13280, 13072, 12657, 13730, 1465, -21179, -22064, -21510, -21415, -21195, -20985, -20769, -20557, -20348, -20137, -19931, -19725, -19520, -19318, -19115, -18917, -18720, -18523, -18330, -18136, -17944, -17756, -17567, -17381, -17197, -17013, -16832, -16652, -16473, -16297, -16120, -15948, -15775, -15604, -15436, -15268, -15102, -14937, -14773, -14611, -14451, -14291, -14133, -13977, -13822, -13668, -13515, -13364, -13214, -13064, -12917, -12770, -12625, -12481, -12339, -12198, -12059, -11919, -11783, -11647, -11511, -11377, -11245, -11113, -10983, -10854, -10727, -10599, -10474, -10349, -10225, -10103, -9982, -9862, -9742, -9624, -9507, -9392, -9276, -9162, -9049, -8937, -8826, -8716, -8606, -8499, -8392, -8286, -8181, -8076, -7973, -7871, -7770, -7669, -7569, -7471, -7374, -7277, -7181, -7086, -6992, -6899, -6806, -6716, -6624, -6534, -6445, -6356, -6270, -6183, -6096, -6011, -5927, -5843, -5760, -5678, -5597, -5517, -5437, -5359, -5280, -5202, -5125, -5050, -4974, -4900, -4826, -4753, -4681, -4610, -4540, -4469, -4399, -4330, -4261, -4194, -4126, -4060, -3995, -3928, -3864, -3800, -3736, -3673, -3611, -3549, -3489, -3427, -3368, -3309, -3249, -3192, -3133, -3077, -3020, -2964, -2910, -2854, -2801, -2749, -2694, -2644, -2592, -2540, -2490, -2439, -2389, -2342, -2291, -2245, -2196, -2147, -2103, -2052, -2006, -1965, -1882};