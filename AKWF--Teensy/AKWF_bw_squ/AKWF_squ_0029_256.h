/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0029 256 samples */
 
const int16_t AKWF_squ_0029_256_DATA [256] = 
{9287, 31849, 32498, 31794, 31564, 31214, 30867, 30532, 30189, 29855, 29526, 29195, 28871, 28549, 28228, 27912, 27598, 27287, 26979, 26672, 26370, 26068, 25772, 25478, 25185, 24896, 24608, 24323, 24042, 23761, 23484, 23210, 22936, 22666, 22398, 22131, 21870, 21608, 21348, 21092, 20838, 20586, 20337, 20088, 19844, 19601, 19360, 19122, 18885, 18651, 18419, 18189, 17962, 17735, 17512, 17290, 17070, 16853, 16638, 16424, 16212, 16001, 15793, 15588, 15382, 15181, 14979, 14779, 14583, 14386, 14193, 14002, 13810, 13623, 13435, 13250, 13067, 12884, 12706, 12528, 12349, 12177, 12002, 11832, 11664, 11494, 11332, 11154, 10749, 11924, -431, -23666, -24628, -23989, -23867, -23620, -23370, -23131, -22888, -22648, -22414, -22178, -21947, -21718, -21489, -21263, -21039, -20817, -20597, -20378, -20163, -19948, -19735, -19526, -19316, -19110, -18905, -18700, -18499, -18299, -18100, -17903, -17708, -17515, -17324, -17133, -16944, -16758, -16572, -16387, -16204, -16024, -15845, -15667, -15491, -15317, -15144, -14973, -14803, -14635, -14468, -14303, -14139, -13976, -13816, -13656, -13498, -13341, -13186, -13031, -12879, -12727, -12577, -12429, -12280, -12135, -11990, -11846, -11704, -11563, -11422, -11284, -11147, -11011, -10876, -10742, -10610, -10479, -10348, -10219, -10092, -9965, -9839, -9715, -9593, -9470, -9349, -9230, -9111, -8993, -8877, -8761, -8646, -8533, -8420, -8309, -8198, -8089, -7981, -7874, -7767, -7661, -7556, -7453, -7349, -7248, -7147, -7047, -6949, -6851, -6754, -6658, -6563, -6468, -6375, -6282, -6191, -6100, -6011, -5922, -5833, -5746, -5659, -5573, -5489, -5404, -5320, -5238, -5156, -5076, -4996, -4916, -4838, -4759, -4682, -4604, -4528, -4454, -4379, -4305, -4234, -4160, -4089, -4018, -3947, -3879, -3810, -3742, -3676, -3609, -3545, -3479, -3413, -3351, -3287, -3225, -3163, -3099, -3041, -2979, -2918, -2861, -2797, -2741, -2684, -2589};