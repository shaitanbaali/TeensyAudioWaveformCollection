/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0002 256 samples */
 
const int16_t AKWF_squ_0002_256_DATA [256] = 
{6073, 12330, 16094, 18374, 19806, 20815, 21646, 22414, 23172, 23943, 24713, 25476, 26223, 26933, 27608, 28240, 28819, 29348, 29825, 30249, 30629, 30962, 31251, 31504, 31720, 31905, 32062, 32194, 32305, 32399, 32476, 32538, 32589, 32631, 32665, 32691, 32711, 32728, 32741, 32749, 32756, 32762, 32764, 32766, 32767, 32767, 32767, 32767, 32766, 32766, 32765, 32764, 32762, 32761, 32761, 32761, 32759, 32758, 32759, 32757, 32756, 32756, 32756, 32755, 32754, 32754, 32755, 32755, 32754, 32754, 32755, 32754, 32753, 32754, 32754, 32754, 32754, 32753, 32754, 32753, 32753, 32753, 32753, 32754, 32753, 32753, 32754, 32754, 32754, 32753, 32754, 32754, 32754, 32753, 32754, 32754, 32753, 32754, 32754, 32753, 32753, 32753, 32753, 32753, 32753, 32753, 32754, 32754, 32754, 32754, 32753, 32754, 32753, 32753, 32754, 32753, 32753, 32754, 32754, 32754, 32753, 32753, 32738, 32701, 32805, 27646, 14624, 2940, -5823, -12043, -15948, -18297, -19754, -20770, -21608, -22378, -23141, -23910, -24677, -25441, -26188, -26903, -27580, -28209, -28793, -29325, -29805, -30232, -30612, -30947, -31238, -31492, -31710, -31896, -32055, -32188, -32300, -32395, -32473, -32535, -32587, -32630, -32663, -32690, -32711, -32726, -32740, -32748, -32755, -32761, -32764, -32766, -32767, -32767, -32767, -32767, -32766, -32766, -32765, -32764, -32762, -32761, -32761, -32760, -32759, -32758, -32758, -32757, -32756, -32755, -32755, -32755, -32754, -32755, -32754, -32754, -32754, -32754, -32755, -32754, -32753, -32753, -32754, -32753, -32753, -32754, -32753, -32753, -32754, -32753, -32753, -32754, -32753, -32754, -32753, -32754, -32753, -32754, -32753, -32754, -32753, -32753, -32754, -32754, -32753, -32753, -32754, -32753, -32753, -32754, -32754, -32753, -32753, -32754, -32754, -32754, -32753, -32753, -32753, -32753, -32753, -32753, -32753, -32754, -32753, -32752, -32754, -32754, -32753, -32754, -32740, -32695, -32842, -28138, -15340, -3079};