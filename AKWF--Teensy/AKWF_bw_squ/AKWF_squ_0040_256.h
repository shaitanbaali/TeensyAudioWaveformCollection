/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0040 256 samples */
 
const int16_t AKWF_squ_0040_256_DATA [256] = 
{10158, 31676, 32500, 31761, 31521, 31153, 30796, 30444, 30089, 29744, 29398, 29057, 28720, 28383, 28053, 27723, 27397, 27075, 26754, 26438, 26125, 25810, 25503, 25197, 24892, 24595, 24294, 23998, 23708, 23413, 23127, 22841, 22556, 22280, 21997, 21709, 21216, 22163, 10701, -11365, -12528, -12050, -12047, -11929, -11815, -11695, -11582, -11466, -11352, -11241, -11128, -11016, -10906, -10795, -10689, -10580, -10473, -10367, -10261, -10157, -10053, -9951, -9849, -9747, -9646, -9548, -9450, -9351, -9255, -9159, -9063, -8969, -8875, -8783, -8691, -8600, -8510, -8419, -8331, -8243, -8156, -8069, -7982, -7899, -7814, -7730, -7648, -7565, -7484, -7403, -7322, -7243, -7165, -7086, -7009, -6932, -6856, -6780, -6705, -6630, -6557, -6484, -6412, -6340, -6269, -6199, -6129, -6060, -5991, -5923, -5856, -5790, -5724, -5658, -5592, -5528, -5465, -5401, -5339, -5276, -5215, -5153, -5093, -5032, -4973, -4914, -4854, -4797, -4739, -4681, -4625, -4568, -4513, -4459, -4404, -4350, -4297, -4243, -4191, -4139, -4087, -4036, -3986, -3936, -3886, -3836, -3787, -3739, -3691, -3643, -3597, -3550, -3504, -3457, -3412, -3367, -3322, -3278, -3234, -3191, -3148, -3105, -3063, -3021, -2979, -2938, -2898, -2860, -2819, -2780, -2740, -2701, -2663, -2625, -2588, -2550, -2513, -2477, -2440, -2404, -2369, -2333, -2298, -2263, -2229, -2195, -2161, -2128, -2094, -2062, -2029, -1997, -1965, -1933, -1902, -1871, -1841, -1810, -1780, -1750, -1721, -1692, -1663, -1635, -1607, -1579, -1551, -1523, -1496, -1469, -1442, -1416, -1389, -1363, -1338, -1312, -1287, -1262, -1237, -1213, -1188, -1165, -1140, -1117, -1094, -1070, -1048, -1026, -1003, -982, -960, -938, -917, -895, -875, -854, -833, -814, -794, -774, -755, -735, -716, -697, -677, -660, -640, -621, -604, -584, -566, -547, -524, -510, -484, -447};