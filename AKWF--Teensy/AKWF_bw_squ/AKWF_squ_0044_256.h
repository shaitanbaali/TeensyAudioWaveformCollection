/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0044 256 samples */
 
const int16_t AKWF_squ_0044_256_DATA [256] = 
{6677, 29525, 32726, 31583, 31395, 31032, 30673, 30312, 29963, 29609, 29263, 28922, 28576, 28243, 27907, 27573, 27251, 26922, 26601, 26283, 25742, 26515, 18597, -4680, -8220, -7328, -7448, -7373, -7295, -7225, -7153, -7080, -7011, -6941, -6872, -6804, -6735, -6669, -6603, -6536, -6473, -6407, -6343, -6279, -6216, -6154, -6092, -6031, -5971, -5909, -5850, -5790, -5731, -5673, -5614, -5556, -5500, -5443, -5387, -5332, -5276, -5221, -5167, -5113, -5060, -5006, -4953, -4902, -4850, -4799, -4748, -4699, -4648, -4598, -4549, -4502, -4453, -4406, -4359, -4311, -4265, -4219, -4174, -4128, -4083, -4038, -3994, -3951, -3907, -3864, -3821, -3779, -3737, -3695, -3654, -3614, -3573, -3533, -3493, -3453, -3414, -3376, -3337, -3298, -3261, -3224, -3186, -3149, -3113, -3077, -3042, -3006, -2971, -2936, -2901, -2867, -2833, -2799, -2766, -2733, -2700, -2668, -2635, -2604, -2572, -2541, -2509, -2478, -2448, -2417, -2387, -2357, -2327, -2298, -2269, -2241, -2212, -2184, -2156, -2128, -2102, -2075, -2048, -2022, -1995, -1968, -1943, -1917, -1891, -1867, -1842, -1818, -1793, -1769, -1745, -1721, -1697, -1674, -1650, -1627, -1604, -1582, -1560, -1538, -1516, -1495, -1473, -1451, -1430, -1410, -1389, -1368, -1348, -1328, -1308, -1288, -1268, -1249, -1229, -1210, -1192, -1173, -1154, -1136, -1118, -1100, -1083, -1064, -1047, -1030, -1013, -996, -979, -962, -946, -929, -914, -897, -881, -866, -850, -835, -820, -804, -789, -775, -760, -746, -732, -717, -703, -689, -676, -662, -648, -635, -622, -608, -595, -582, -570, -557, -545, -533, -520, -508, -496, -484, -472, -461, -449, -438, -428, -416, -406, -395, -384, -373, -363, -354, -341, -332, -322, -311, -302, -291, -281, -272, -259, -251, -241, -229, -222, -205, -194, -190};