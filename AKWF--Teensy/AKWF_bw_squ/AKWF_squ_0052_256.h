/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0052 256 samples */
 
const int16_t AKWF_squ_0052_256_DATA [256] = 
{12616, 28132, -234, -577, -321, -417, -423, -443, -429, -436, -438, -428, -434, -426, -420, -422, -411, -410, -405, -396, -396, -387, -381, -380, -370, -367, -364, -355, -355, -349, -345, -345, -338, -337, -336, -329, -331, -327, -324, -325, -318, -317, -315, -311, -310, -305, -303, -300, -293, -293, -289, -284, -282, -275, -272, -271, -265, -264, -262, -256, -254, -253, -250, -249, -244, -244, -243, -241, -240, -235, -232, -230, -227, -227, -224, -221, -219, -215, -215, -212, -206, -205, -203, -199, -197, -193, -191, -191, -186, -186, -184, -181, -180, -178, -177, -175, -173, -174, -170, -167, -169, -166, -163, -161, -158, -158, -155, -152, -152, -148, -146, -145, -142, -139, -138, -135, -135, -132, -131, -130, -128, -128, -126, -123, -122, -122, -120, -123, -118, -116, -116, -114, -113, -111, -111, -110, -104, -104, -103, -100, -101, -98, -95, -95, -92, -92, -91, -88, -89, -86, -84, -85, -83, -85, -84, -82, -81, -79, -78, -78, -76, -76, -75, -73, -73, -71, -69, -67, -66, -63, -62, -61, -60, -59, -58, -57, -55, -57, -56, -54, -55, -54, -53, -54, -51, -51, -52, -50, -52, -49, -48, -48, -44, -45, -45, -42, -41, -37, -36, -38, -35, -35, -33, -30, -33, -32, -31, -32, -31, -32, -31, -30, -33, -32, -32, -31, -28, -31, -28, -27, -29, -25, -25, -26, -22, -20, -19, -14, -16, -12, -10, -14, -9, -13, -11, -9, -15, -11, -12, -17, -13, -19, -20, -18, -28, -21, -23, -29, -16, -29, -20, -9, -20, 6, 12, -5};