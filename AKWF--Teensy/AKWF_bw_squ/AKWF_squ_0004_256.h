/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0004 256 samples */
 
const int16_t AKWF_squ_0004_256_DATA [256] = 
{18255, 30228, 31066, 29823, 30112, 30283, 30422, 30520, 30592, 30655, 30714, 30774, 30840, 30910, 30981, 31054, 31127, 31198, 31266, 31331, 31393, 31450, 31502, 31548, 31590, 31628, 31659, 31686, 31706, 31724, 31737, 31744, 31750, 31750, 31745, 31740, 31731, 31718, 31703, 31686, 31668, 31647, 31625, 31600, 31575, 31550, 31522, 31494, 31467, 31438, 31408, 31380, 31351, 31321, 31291, 31262, 31234, 31204, 31176, 31148, 31121, 31094, 31069, 31043, 31016, 30993, 30969, 30946, 30923, 30901, 30880, 30859, 30839, 30819, 30801, 30783, 30766, 30749, 30733, 30717, 30703, 30689, 30675, 30662, 30650, 30637, 30626, 30616, 30604, 30594, 30585, 30576, 30567, 30560, 30551, 30544, 30538, 30531, 30525, 30520, 30512, 30508, 30503, 30498, 30493, 30490, 30486, 30483, 30479, 30476, 30472, 30470, 30468, 30465, 30463, 30462, 30460, 30457, 30455, 30454, 30453, 30452, 30451, 30449, 30450, 30283, 30831, 29092, -15932, -30869, -30901, -29823, -30112, -30283, -30422, -30520, -30592, -30655, -30714, -30774, -30840, -30910, -30981, -31054, -31127, -31198, -31266, -31331, -31393, -31450, -31502, -31548, -31590, -31628, -31659, -31686, -31707, -31724, -31737, -31744, -31750, -31750, -31745, -31740, -31731, -31718, -31703, -31686, -31668, -31647, -31625, -31600, -31575, -31550, -31522, -31495, -31467, -31438, -31408, -31380, -31351, -31321, -31291, -31262, -31234, -31204, -31176, -31148, -31121, -31094, -31069, -31043, -31016, -30993, -30969, -30946, -30923, -30902, -30880, -30859, -30839, -30819, -30801, -30783, -30766, -30749, -30734, -30717, -30703, -30689, -30675, -30662, -30650, -30637, -30626, -30616, -30604, -30594, -30585, -30576, -30567, -30560, -30551, -30544, -30538, -30531, -30525, -30520, -30512, -30508, -30503, -30498, -30494, -30490, -30486, -30483, -30480, -30476, -30472, -30470, -30468, -30465, -30463, -30462, -30460, -30457, -30456, -30454, -30453, -30452, -30451, -30449, -30450, -30448, -30447, -30448};