/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0062 256 samples */
 
const int16_t AKWF_squ_0062_256_DATA [256] = 
{15626, 33749, 32551, 32741, 32763, 32761, 32757, 32754, 32749, 32744, 32739, 32733, 32728, 32617, 32942, 31792, 4084, -3367, -1873, -2161, -2165, -2169, -2172, -2176, -2179, -2180, -2183, -2185, -2186, -2188, -2188, -2190, -2191, -2192, -2192, -2193, -2194, -2193, -2194, -2195, -2194, -2194, -2194, -2194, -2195, -2194, -2193, -2194, -2193, -2194, -2193, -2192, -2193, -2192, -2191, -2192, -2191, -2191, -2190, -2189, -2188, -2188, -2188, -2187, -2186, -2186, -2185, -2185, -2184, -2184, -2184, -2183, -2181, -2181, -2180, -2180, -2180, -2179, -2179, -2179, -2178, -2178, -2177, -2176, -2176, -2176, -2174, -2173, -2173, -2172, -2172, -2172, -2171, -2171, -2170, -2170, -2169, -2168, -2167, -2166, -2166, -2166, -2165, -2164, -2164, -2164, -2163, -2163, -2162, -2161, -2161, -2161, -2159, -2158, -2158, -2157, -2157, -2157, -2156, -2156, -2155, -2154, -2154, -2154, -2152, -2151, -2151, -2151, -2150, -2149, -2148, -2148, -2148, -2147, -2147, -2146, -2144, -2144, -2144, -2143, -2142, -2142, -2141, -2141, -2140, -2140, -2140, -2139, -2139, -2138, -2136, -2136, -2136, -2135, -2135, -2134, -2133, -2133, -2133, -2132, -2132, -2131, -2130, -2129, -2129, -2128, -2128, -2127, -2127, -2127, -2126, -2125, -2125, -2124, -2123, -2122, -2122, -2122, -2121, -2120, -2120, -2120, -2119, -2119, -2118, -2118, -2117, -2116, -2115, -2114, -2114, -2114, -2113, -2113, -2112, -2111, -2111, -2111, -2110, -2110, -2109, -2107, -2107, -2106, -2106, -2106, -2105, -2104, -2104, -2103, -2103, -2102, -2102, -2102, -2101, -2100, -2099, -2099, -2098, -2098, -2097, -2097, -2096, -2096, -2096, -2095, -2095, -2093, -2092, -2092, -2092, -2091, -2091, -2090, -2090, -2089, -2088, -2088, -2088, -2087, -2085, -2085, -2084, -2084, -2083, -2083, -2082, -2082, -2082, -2081, -2081, -2081, -2080, -2080, -2078, -2077};