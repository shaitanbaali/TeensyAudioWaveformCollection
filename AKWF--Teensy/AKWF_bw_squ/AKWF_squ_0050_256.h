/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0050 256 samples */
 
const int16_t AKWF_squ_0050_256_DATA [256] = 
{5245, 28218, 32711, 32249, 26227, 2792, -2316, -1265, -1474, -1458, -1441, -1427, -1413, -1398, -1384, -1370, -1357, -1344, -1331, -1317, -1304, -1292, -1280, -1266, -1254, -1242, -1229, -1217, -1205, -1193, -1181, -1170, -1158, -1146, -1135, -1123, -1112, -1101, -1089, -1078, -1068, -1057, -1046, -1036, -1025, -1014, -1004, -994, -983, -973, -963, -953, -943, -934, -924, -914, -904, -895, -886, -877, -867, -858, -850, -840, -831, -821, -814, -805, -796, -788, -778, -770, -763, -754, -746, -737, -730, -722, -714, -706, -698, -691, -683, -675, -668, -660, -653, -645, -638, -631, -624, -617, -610, -603, -596, -589, -583, -576, -569, -563, -556, -549, -543, -537, -531, -524, -518, -511, -505, -500, -495, -488, -482, -476, -470, -464, -459, -454, -448, -442, -437, -431, -426, -421, -416, -410, -405, -401, -395, -389, -384, -379, -374, -370, -366, -361, -356, -351, -346, -342, -337, -333, -328, -324, -320, -315, -311, -307, -302, -298, -294, -290, -286, -282, -278, -274, -270, -266, -262, -258, -254, -251, -247, -243, -240, -236, -232, -229, -226, -222, -219, -215, -211, -208, -206, -203, -199, -195, -192, -189, -186, -183, -179, -177, -174, -170, -167, -164, -161, -160, -157, -153, -150, -147, -146, -143, -140, -138, -135, -132, -130, -127, -124, -122, -119, -117, -115, -112, -109, -107, -105, -103, -100, -98, -96, -94, -92, -90, -88, -85, -84, -81, -79, -77, -75, -74, -71, -69, -67, -66, -63, -62, -59, -58, -56, -54, -52, -50, -50, -47, -45, -44, -42, -41, -39, -37, -36, -35, -33, -32, -33, -30, -30, -31, -25, -50};