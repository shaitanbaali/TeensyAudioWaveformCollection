/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0025 256 samples */
 
const int16_t AKWF_squ_0025_256_DATA [256] = 
{16183, 33400, 31698, 31547, 31229, 30892, 30561, 30226, 29901, 29577, 29253, 28937, 28618, 28306, 27997, 27688, 27385, 27084, 26784, 26488, 26194, 25902, 25614, 25326, 25044, 24763, 24483, 24207, 23933, 23661, 23392, 23123, 22859, 22597, 22336, 22078, 21822, 21569, 21317, 21067, 20821, 20576, 20333, 20093, 19853, 19618, 19384, 19151, 18922, 18694, 18467, 18245, 18023, 17802, 17586, 17369, 17156, 16945, 16734, 16526, 16319, 16115, 15912, 15711, 15512, 15315, 15119, 14925, 14733, 14542, 14353, 14166, 13982, 13798, 13615, 13436, 13256, 13080, 12905, 12731, 12559, 12388, 12220, 12054, 11887, 11724, 11562, 11400, 11241, 11082, 10926, 10772, 10618, 10465, 10314, 10164, 10016, 9868, 9723, 9579, 9434, 9294, 9152, 9013, 8877, 8738, 8604, 8470, 8334, 8207, 8074, 7945, 7822, 7628, 7466, 7842, -12400, -30812, -29145, -29019, -28754, -28446, -28148, -27851, -27552, -27262, -26970, -26681, -26396, -26111, -25831, -25554, -25277, -25005, -24733, -24465, -24200, -23935, -23675, -23416, -23158, -22905, -22651, -22402, -22155, -21908, -21665, -21423, -21183, -20947, -20711, -20478, -20247, -20016, -19790, -19564, -19340, -19118, -18899, -18681, -18466, -18251, -18040, -17829, -17621, -17414, -17209, -17007, -16806, -16606, -16409, -16214, -16019, -15828, -15636, -15448, -15261, -15075, -14892, -14711, -14530, -14351, -14174, -13997, -13823, -13651, -13480, -13310, -13142, -12975, -12810, -12647, -12485, -12324, -12165, -12006, -11851, -11696, -11542, -11391, -11240, -11090, -10942, -10795, -10651, -10508, -10365, -10224, -10084, -9945, -9808, -9673, -9538, -9404, -9271, -9141, -9010, -8881, -8755, -8628, -8503, -8379, -8255, -8135, -8014, -7893, -7776, -7659, -7542, -7427, -7312, -7201, -7089, -6977, -6869, -6761, -6654, -6548, -6443, -6340, -6236, -6133, -6033, -5932, -5835, -5737, -5638, -5545, -5446, -5352, -5259, -5162, -5072, -4956, -4977, -4278};