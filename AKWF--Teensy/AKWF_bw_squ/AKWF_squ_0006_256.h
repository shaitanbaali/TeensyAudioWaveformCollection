/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0006 256 samples */
 
const int16_t AKWF_squ_0006_256_DATA [256] = 
{2977, 8237, 12424, 15720, 18401, 20506, 22148, 23422, 24418, 25205, 25829, 26336, 26753, 27099, 27394, 27649, 27872, 28070, 28249, 28411, 28560, 28699, 28829, 28950, 29066, 29175, 29278, 29377, 29472, 29563, 29650, 29735, 29816, 29894, 29971, 30043, 30114, 30183, 30250, 30314, 30377, 30438, 30497, 30555, 30611, 30666, 30718, 30771, 30822, 30871, 30919, 30966, 31012, 31056, 31100, 31143, 31185, 31226, 31266, 31305, 31343, 31381, 31418, 31455, 31490, 31525, 31559, 31592, 31625, 31657, 31689, 31720, 31750, 31780, 31809, 31837, 31866, 31893, 31920, 31947, 31973, 31999, 32024, 32049, 32073, 32096, 32121, 32144, 32167, 32189, 32212, 32234, 32255, 32276, 32297, 32317, 32338, 32357, 32377, 32396, 32415, 32433, 32452, 32470, 32488, 32505, 32523, 32540, 32557, 32573, 32590, 32606, 32621, 32638, 32653, 32668, 32682, 32697, 32712, 32726, 32740, 32750, 32642, 33118, 29411, 13752, 3753, -4453, -11546, -17081, -21286, -24419, -26710, -28381, -29592, -30460, -31086, -31532, -31849, -32074, -32232, -32340, -32415, -32465, -32495, -32512, -32519, -32520, -32517, -32508, -32498, -32484, -32470, -32455, -32438, -32421, -32403, -32385, -32366, -32348, -32328, -32307, -32286, -32266, -32244, -32222, -32201, -32178, -32156, -32132, -32110, -32086, -32061, -32036, -32011, -31986, -31960, -31933, -31906, -31879, -31851, -31823, -31793, -31764, -31734, -31704, -31672, -31641, -31609, -31575, -31541, -31507, -31473, -31437, -31400, -31363, -31325, -31286, -31246, -31206, -31165, -31122, -31079, -31035, -30989, -30943, -30896, -30847, -30797, -30746, -30693, -30639, -30585, -30527, -30470, -30409, -30347, -30285, -30218, -30151, -30081, -30010, -29936, -29859, -29780, -29699, -29614, -29525, -29435, -29339, -29240, -29137, -29029, -28917, -28799, -28674, -28544, -28407, -28261, -28107, -27943, -27767, -27578, -27375, -27153, -26911, -26641, -26334, -26010, -24905, -22623, -19613, -15937, -11714, -7095, -2056};