/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0053 256 samples */
 
const int16_t AKWF_squ_0053_256_DATA [256] = 
{18881, 29742, 28146, 28852, 29177, 29487, 29783, 30060, 30324, 30574, 30806, 31026, 31231, 31421, 31597, 31760, 31910, 32048, 32173, 32283, 32382, 32469, 32544, 32609, 32662, 32704, 32735, 32756, 32767, 32767, 32759, 32741, 32714, 32678, 32632, 32579, 32518, 32449, 32370, 32286, 32196, 32095, 31990, 31878, 31759, 31635, 31505, 31367, 31226, 31078, 30926, 30768, 30606, 30438, 30268, 30093, 29914, 29731, 29543, 29353, 29159, 28961, 28762, 28559, 28353, 28145, 27935, 27721, 27506, 27289, 27070, 26848, 26626, 26401, 26176, 25948, 25720, 25492, 25262, 25031, 24799, 24567, 24333, 24100, 23866, 23632, 23399, 23165, 22929, 22695, 22461, 22227, 21994, 21760, 21526, 21294, 21062, 20831, 20600, 20369, 20139, 19911, 19683, 19457, 19232, 19006, 18783, 18561, 18338, 18118, 17899, 17681, 17464, 17249, 17035, 16823, 16612, 16401, 16193, 15986, 15782, 15577, 15375, 15174, 14975, 14692, 14538, 14828, -17675, -30075, -28060, -28852, -29177, -29487, -29783, -30060, -30324, -30574, -30806, -31026, -31231, -31421, -31597, -31760, -31910, -32048, -32172, -32283, -32382, -32469, -32544, -32609, -32662, -32704, -32735, -32756, -32767, -32767, -32759, -32741, -32714, -32678, -32632, -32579, -32518, -32448, -32371, -32286, -32196, -32095, -31990, -31878, -31759, -31635, -31505, -31367, -31226, -31078, -30926, -30768, -30606, -30438, -30268, -30093, -29914, -29731, -29543, -29353, -29159, -28961, -28762, -28559, -28353, -28145, -27935, -27721, -27506, -27289, -27070, -26849, -26626, -26401, -26176, -25949, -25720, -25493, -25262, -25031, -24800, -24567, -24333, -24100, -23866, -23632, -23399, -23165, -22930, -22695, -22461, -22228, -21994, -21760, -21527, -21294, -21062, -20831, -20600, -20370, -20140, -19911, -19683, -19458, -19232, -19006, -18784, -18562, -18338, -18119, -17899, -17681, -17465, -17249, -17036, -16823, -16612, -16401, -16194, -15986, -15781, -15578, -15375, -15174, -14976, -14778, -14583, -14384};