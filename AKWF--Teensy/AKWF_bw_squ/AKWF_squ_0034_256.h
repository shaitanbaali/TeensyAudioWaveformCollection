/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0034 256 samples */
 
const int16_t AKWF_squ_0034_256_DATA [256] = 
{14595, 32867, 31881, 31555, 31246, 30895, 30550, 30201, 29861, 29521, 29184, 28853, 28520, 28193, 27868, 27546, 27230, 26913, 26598, 26290, 25981, 25678, 25376, 25076, 24781, 24487, 24196, 23908, 23622, 23339, 23059, 22780, 22505, 22231, 21960, 21692, 21425, 21161, 20899, 20639, 20383, 20127, 19875, 19626, 19375, 19131, 18886, 18644, 18407, 18166, 17932, 17700, 17465, 17240, 17013, 16787, 16569, 16310, 15949, 16685, 716, -18405, -17627, -17452, -17341, -17162, -16990, -16819, -16644, -16477, -16308, -16142, -15978, -15813, -15652, -15490, -15330, -15173, -15016, -14861, -14707, -14554, -14404, -14254, -14105, -13958, -13811, -13666, -13524, -13381, -13240, -13100, -12961, -12824, -12687, -12552, -12418, -12285, -12153, -12022, -11892, -11764, -11636, -11509, -11384, -11259, -11137, -11015, -10893, -10773, -10655, -10536, -10420, -10303, -10188, -10076, -9962, -9850, -9740, -9630, -9521, -9413, -9306, -9200, -9094, -8990, -8886, -8784, -8682, -8581, -8480, -8381, -8284, -8186, -8090, -7994, -7900, -7806, -7713, -7620, -7529, -7438, -7349, -7260, -7172, -7084, -6998, -6911, -6827, -6743, -6659, -6577, -6495, -6413, -6333, -6253, -6174, -6095, -6018, -5941, -5864, -5789, -5714, -5640, -5566, -5493, -5421, -5349, -5278, -5207, -5138, -5069, -5001, -4934, -4866, -4800, -4734, -4668, -4604, -4540, -4477, -4413, -4351, -4290, -4229, -4168, -4108, -4048, -3990, -3933, -3875, -3818, -3760, -3705, -3650, -3593, -3539, -3485, -3431, -3378, -3325, -3273, -3222, -3170, -3120, -3070, -3020, -2971, -2922, -2875, -2827, -2779, -2732, -2687, -2641, -2596, -2551, -2506, -2462, -2418, -2375, -2332, -2288, -2247, -2205, -2164, -2123, -2082, -2042, -2002, -1963, -1925, -1885, -1848, -1810, -1772, -1736, -1699, -1663, -1628, -1591, -1557, -1522, -1488, -1456, -1422, -1389, -1358, -1324, -1294, -1263, -1229, -1203, -1161, -1177, -946};