/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0024 256 samples */
 
const int16_t AKWF_squ_0024_256_DATA [256] = 
{12098, 32817, 31862, 31530, 31241, 30910, 30575, 30243, 29921, 29592, 29273, 28955, 28638, 28327, 28016, 27707, 27406, 27103, 26804, 26509, 26214, 25924, 25634, 25349, 25066, 24784, 24506, 24230, 23957, 23685, 23416, 23149, 22885, 22623, 22363, 22105, 21849, 21596, 21345, 21096, 20849, 20604, 20363, 20122, 19883, 19648, 19413, 19182, 18953, 18724, 18499, 18276, 18053, 17835, 17616, 17401, 17187, 16976, 16766, 16559, 16352, 16148, 15945, 15744, 15546, 15349, 15155, 14960, 14768, 14578, 14389, 14202, 14017, 13833, 13652, 13472, 13293, 13117, 12941, 12767, 12596, 12425, 12257, 12090, 11924, 11760, 11598, 11437, 11278, 11120, 10964, 10809, 10655, 10504, 10352, 10203, 10055, 9907, 9763, 9618, 9475, 9335, 9193, 9054, 8916, 8779, 8646, 8510, 8378, 8247, 8114, 7988, 7859, 7731, 7611, 7451, 7147, 8172, -8760, -30511, -29767, -29401, -29173, -28860, -28556, -28256, -27951, -27657, -27361, -27066, -26778, -26487, -26204, -25922, -25640, -25364, -25089, -24815, -24547, -24277, -24012, -23750, -23488, -23231, -22974, -22720, -22468, -22218, -21972, -21726, -21482, -21242, -21001, -20765, -20531, -20297, -20067, -19838, -19610, -19386, -19161, -18941, -18722, -18503, -18289, -18076, -17863, -17654, -17445, -17239, -17036, -16833, -16633, -16435, -16237, -16041, -15849, -15657, -15467, -15279, -15092, -14908, -14724, -14543, -14362, -14184, -14008, -13832, -13658, -13485, -13315, -13146, -12978, -12811, -12647, -12483, -12322, -12162, -12003, -11846, -11690, -11536, -11383, -11231, -11081, -10932, -10785, -10640, -10494, -10351, -10209, -10069, -9930, -9791, -9655, -9519, -9384, -9252, -9120, -8989, -8861, -8731, -8604, -8479, -8353, -8230, -8107, -7985, -7866, -7746, -7628, -7513, -7396, -7282, -7169, -7056, -6945, -6835, -6727, -6620, -6512, -6408, -6302, -6198, -6098, -5994, -5895, -5798, -5696, -5602, -5502, -5405, -5314, -5205, -5159, -4854};