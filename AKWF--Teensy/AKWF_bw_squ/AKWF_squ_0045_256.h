/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0045 256 samples */
 
const int16_t AKWF_squ_0045_256_DATA [256] = 
{3747, 26808, 33270, 31668, 31564, 31192, 30827, 30475, 30115, 29764, 29416, 29067, 28729, 28388, 28050, 27721, 27215, 27642, 22923, -543, -7360, -6047, -6235, -6173, -6107, -6048, -5988, -5928, -5870, -5811, -5753, -5697, -5640, -5584, -5529, -5473, -5420, -5366, -5311, -5258, -5206, -5154, -5102, -5051, -5001, -4950, -4900, -4851, -4800, -4751, -4704, -4655, -4608, -4560, -4514, -4467, -4421, -4376, -4330, -4285, -4240, -4196, -4152, -4110, -4066, -4023, -3981, -3939, -3897, -3856, -3815, -3775, -3734, -3694, -3655, -3616, -3577, -3539, -3501, -3463, -3425, -3389, -3351, -3315, -3278, -3243, -3207, -3172, -3136, -3102, -3067, -3033, -3000, -2965, -2932, -2900, -2867, -2834, -2802, -2771, -2739, -2708, -2677, -2647, -2615, -2585, -2555, -2526, -2497, -2467, -2439, -2410, -2382, -2353, -2325, -2297, -2270, -2244, -2217, -2189, -2163, -2137, -2111, -2085, -2060, -2035, -2010, -1985, -1960, -1934, -1910, -1886, -1863, -1839, -1816, -1793, -1770, -1748, -1725, -1703, -1681, -1659, -1638, -1616, -1594, -1573, -1553, -1533, -1513, -1493, -1472, -1452, -1432, -1413, -1393, -1374, -1355, -1335, -1318, -1299, -1280, -1262, -1245, -1226, -1209, -1192, -1175, -1157, -1140, -1124, -1106, -1090, -1074, -1058, -1042, -1025, -1009, -994, -979, -963, -949, -934, -918, -904, -889, -873, -859, -845, -831, -818, -804, -790, -776, -763, -750, -737, -723, -711, -698, -685, -673, -660, -648, -637, -625, -612, -601, -589, -577, -566, -555, -543, -532, -521, -510, -499, -489, -478, -467, -457, -447, -437, -427, -417, -408, -398, -388, -379, -369, -360, -351, -342, -333, -325, -315, -307, -298, -290, -280, -272, -264, -255, -247, -240, -230, -223, -215, -205, -199, -189, -181, -175, -164, -160, -149, -141};