/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0069 256 samples */
 
const int16_t AKWF_squ_0069_256_DATA [256] = 
{-24302, -34107, -32462, -32763, -32763, -32759, -32756, -32624, -33076, -31197, -6868, 2430, 1064, 1331, 1338, 1341, 1344, 1346, 1348, 1350, 1352, 1353, 1354, 1356, 1358, 1358, 1359, 1360, 1360, 1361, 1361, 1362, 1362, 1362, 1362, 1363, 1363, 1363, 1363, 1363, 1363, 1363, 1363, 1362, 1362, 1362, 1362, 1362, 1362, 1361, 1361, 1361, 1361, 1360, 1359, 1360, 1360, 1359, 1358, 1359, 1358, 1358, 1357, 1358, 1356, 1355, 1356, 1355, 1355, 1355, 1354, 1354, 1354, 1354, 1353, 1352, 1353, 1352, 1351, 1352, 1351, 1350, 1351, 1350, 1349, 1350, 1349, 1348, 1349, 1348, 1346, 1347, 1346, 1346, 1346, 1345, 1345, 1345, 1344, 1344, 1344, 1344, 1343, 1342, 1343, 1342, 1341, 1342, 1341, 1340, 1341, 1340, 1338, 1339, 1338, 1337, 1338, 1338, 1337, 1336, 1337, 1336, 1335, 1336, 1335, 1334, 1335, 1334, 1333, 1334, 1333, 1332, 1333, 1332, 1332, 1332, 1331, 1330, 1330, 1329, 1328, 1329, 1328, 1327, 1328, 1327, 1326, 1327, 1326, 1326, 1326, 1325, 1325, 1325, 1325, 1324, 1323, 1324, 1323, 1322, 1323, 1322, 1320, 1321, 1320, 1319, 1320, 1319, 1318, 1319, 1319, 1318, 1318, 1318, 1317, 1316, 1317, 1316, 1315, 1316, 1315, 1314, 1315, 1314, 1313, 1313, 1312, 1312, 1312, 1312, 1311, 1310, 1311, 1310, 1309, 1310, 1309, 1308, 1309, 1309, 1308, 1308, 1308, 1307, 1306, 1307, 1306, 1305, 1306, 1305, 1303, 1304, 1303, 1303, 1303, 1302, 1302, 1302, 1302, 1301, 1300, 1301, 1300, 1299, 1300, 1299, 1298, 1299, 1299, 1298, 1298, 1298, 1297, 1296, 1297, 1296, 1294, 1295, 1294, 1294, 1294, 1293, 1293, 1293, 1293, 1292, 1291, 1292, 1291, 1290, 1291, 1290, 1289, 1290, 1290, 1289};