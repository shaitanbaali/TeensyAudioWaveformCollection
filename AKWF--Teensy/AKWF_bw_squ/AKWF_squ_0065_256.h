/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0065 256 samples */
 
const int16_t AKWF_squ_0065_256_DATA [256] = 
{24570, 34052, 32467, 32763, 32766, 32768, 32767, 32767, 32766, 32764, 32761, 32758, 32755, 32751, 32746, 32742, 32737, 32730, 32725, 32719, 32712, 32706, 32698, 32691, 32684, 32677, 32669, 32662, 32655, 32647, 32639, 32631, 32623, 32615, 32607, 32599, 32591, 32582, 32574, 32565, 32557, 32548, 32540, 32532, 32523, 32514, 32506, 32498, 32489, 32480, 32472, 32464, 32454, 32446, 32438, 32429, 32420, 32412, 32404, 32394, 32386, 32377, 32369, 32359, 32352, 32342, 32333, 32325, 32317, 32308, 32299, 32290, 32282, 32273, 32264, 32256, 32248, 32238, 32230, 32221, 32213, 32203, 32195, 32187, 32179, 32169, 32161, 32152, 32144, 32135, 32127, 32118, 32109, 32100, 32092, 32083, 32075, 32066, 32058, 32049, 32040, 32032, 32023, 32015, 32006, 31997, 31988, 31980, 31972, 31964, 31954, 31946, 31938, 31929, 31920, 31912, 31903, 31894, 31886, 31878, 31696, 32084, 31164, -17207, -32858, -29850, -30422, -30426, -30428, -30429, -30428, -30429, -30427, -30425, -30423, -30420, -30417, -30412, -30407, -30403, -30398, -30393, -30388, -30381, -30376, -30370, -30364, -30357, -30350, -30343, -30337, -30330, -30323, -30315, -30308, -30301, -30294, -30285, -30278, -30271, -30263, -30255, -30247, -30240, -30232, -30224, -30216, -30209, -30201, -30193, -30185, -30177, -30169, -30161, -30153, -30145, -30137, -30129, -30121, -30113, -30105, -30096, -30089, -30082, -30073, -30065, -30057, -30049, -30041, -30033, -30025, -30017, -30008, -30000, -29993, -29985, -29976, -29968, -29961, -29953, -29944, -29937, -29929, -29921, -29912, -29904, -29897, -29888, -29880, -29872, -29864, -29857, -29848, -29841, -29833, -29824, -29816, -29808, -29801, -29792, -29784, -29777, -29769, -29760, -29752, -29744, -29737, -29728, -29721, -29713, -29705, -29696, -29688, -29681, -29672, -29665, -29657, -29649, -29641, -29632, -29625, -29618, -29609, -29601, -29593, -29585, -29578, -29569, -29561, -29554, -29546, -29538, -29529, -29151, -31144, -19890};