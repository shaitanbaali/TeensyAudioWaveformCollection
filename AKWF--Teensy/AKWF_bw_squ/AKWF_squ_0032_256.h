/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0032 256 samples */
 
const int16_t AKWF_squ_0032_256_DATA [256] = 
{11335, 32319, 32367, 31826, 31559, 31211, 30865, 30518, 30179, 29838, 29502, 29171, 28838, 28512, 28187, 27863, 27547, 27228, 26914, 26604, 26294, 25989, 25687, 25385, 25090, 24795, 24502, 24213, 23925, 23642, 23360, 23080, 22805, 22530, 22260, 21991, 21722, 21458, 21197, 20937, 20680, 20423, 20172, 19921, 19671, 19426, 19180, 18938, 18700, 18460, 18225, 17992, 17759, 17530, 17302, 17077, 16855, 16632, 16414, 16197, 15981, 15769, 15557, 15349, 15145, 14938, 14739, 14519, 14106, 15171, 1797, -19971, -20285, -19838, -19735, -19533, -19329, -19136, -18937, -18742, -18551, -18358, -18170, -17984, -17796, -17614, -17430, -17250, -17071, -16893, -16717, -16542, -16369, -16198, -16028, -15859, -15691, -15525, -15361, -15197, -15036, -14876, -14716, -14559, -14403, -14247, -14093, -13941, -13789, -13640, -13491, -13343, -13198, -13052, -12908, -12767, -12626, -12486, -12347, -12210, -12074, -11938, -11805, -11672, -11541, -11411, -11281, -11154, -11026, -10899, -10775, -10651, -10528, -10406, -10286, -10168, -10049, -9931, -9815, -9699, -9584, -9472, -9359, -9248, -9138, -9029, -8920, -8813, -8707, -8601, -8496, -8392, -8290, -8188, -8088, -7987, -7889, -7791, -7693, -7597, -7502, -7407, -7313, -7220, -7128, -7037, -6947, -6857, -6769, -6680, -6593, -6507, -6420, -6336, -6251, -6168, -6086, -6003, -5923, -5843, -5762, -5684, -5606, -5528, -5452, -5376, -5301, -5227, -5153, -5080, -5007, -4935, -4864, -4794, -4724, -4654, -4587, -4519, -4452, -4386, -4319, -4254, -4190, -4125, -4061, -3998, -3936, -3875, -3812, -3753, -3693, -3633, -3574, -3516, -3458, -3402, -3345, -3289, -3234, -3178, -3125, -3070, -3017, -2965, -2912, -2860, -2809, -2757, -2708, -2658, -2609, -2561, -2511, -2463, -2415, -2368, -2321, -2275, -2228, -2184, -2138, -2095, -2051, -2006, -1966, -1923, -1881, -1841, -1798, -1761, -1721, -1680, -1647, -1604, -1586, -1510};