/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0037 256 samples */
 
const int16_t AKWF_squ_0037_256_DATA [256] = 
{7553, 30283, 32619, 31599, 31410, 31046, 30691, 30344, 29992, 29650, 29308, 28968, 28634, 28301, 27971, 27645, 27320, 27002, 26683, 26368, 26057, 25746, 25441, 25138, 24835, 24540, 24243, 23951, 23663, 23374, 23090, 22809, 22527, 22252, 21976, 21703, 21436, 21165, 20901, 20638, 20375, 20121, 19860, 19601, 19121, 20018, 11097, -12093, -14837, -14040, -14072, -13930, -13795, -13655, -13522, -13386, -13251, -13120, -12988, -12857, -12729, -12599, -12472, -12346, -12219, -12096, -11971, -11848, -11727, -11606, -11487, -11367, -11250, -11133, -11018, -10903, -10790, -10677, -10565, -10454, -10344, -10236, -10127, -10020, -9914, -9809, -9705, -9602, -9499, -9398, -9297, -9197, -9098, -9000, -8903, -8806, -8710, -8616, -8521, -8428, -8336, -8244, -8153, -8063, -7974, -7885, -7797, -7709, -7624, -7538, -7453, -7369, -7286, -7203, -7121, -7040, -6959, -6880, -6801, -6723, -6645, -6569, -6493, -6416, -6343, -6268, -6194, -6121, -6048, -5976, -5904, -5835, -5765, -5695, -5625, -5559, -5492, -5425, -5357, -5292, -5227, -5163, -5100, -5036, -4973, -4911, -4849, -4789, -4728, -4669, -4610, -4550, -4492, -4434, -4377, -4320, -4263, -4208, -4154, -4099, -4045, -3990, -3937, -3885, -3832, -3781, -3729, -3678, -3628, -3578, -3527, -3480, -3431, -3383, -3336, -3289, -3243, -3196, -3150, -3105, -3059, -3015, -2972, -2928, -2884, -2842, -2799, -2757, -2715, -2674, -2633, -2592, -2552, -2512, -2473, -2433, -2394, -2356, -2319, -2281, -2244, -2206, -2170, -2134, -2097, -2062, -2028, -1992, -1958, -1925, -1891, -1857, -1824, -1792, -1759, -1727, -1695, -1664, -1633, -1602, -1571, -1542, -1511, -1481, -1452, -1422, -1393, -1365, -1336, -1308, -1281, -1252, -1226, -1198, -1172, -1146, -1119, -1094, -1069, -1044, -1019, -994, -970, -947, -922, -900, -876, -853, -833, -808, -787, -766, -742, -727, -697, -694};