/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0035 256 samples */
 
const int16_t AKWF_squ_0035_256_DATA [256] = 
{10493, 31957, 32494, 31811, 31562, 31204, 30847, 30502, 30152, 29807, 29469, 29129, 28796, 28464, 28134, 27810, 27488, 27169, 26852, 26537, 26228, 25919, 25613, 25311, 25011, 24714, 24421, 24128, 23840, 23552, 23267, 22987, 22705, 22429, 22155, 21881, 21613, 21345, 21079, 20818, 20555, 20298, 20043, 19786, 19537, 19287, 19039, 18796, 18551, 18313, 18075, 17837, 17608, 17356, 16912, 17915, 5737, -16299, -17142, -16633, -16585, -16415, -16248, -16085, -15920, -15760, -15599, -15440, -15284, -15127, -14972, -14820, -14667, -14517, -14367, -14218, -14072, -13927, -13783, -13640, -13498, -13357, -13218, -13081, -12945, -12808, -12674, -12541, -12408, -12278, -12147, -12018, -11891, -11763, -11637, -11512, -11389, -11266, -11144, -11024, -10904, -10786, -10668, -10552, -10437, -10321, -10209, -10095, -9984, -9874, -9765, -9656, -9549, -9442, -9336, -9231, -9127, -9024, -8922, -8821, -8720, -8621, -8522, -8424, -8328, -8231, -8136, -8042, -7948, -7854, -7762, -7671, -7580, -7491, -7403, -7314, -7227, -7141, -7055, -6971, -6886, -6803, -6721, -6638, -6557, -6477, -6397, -6319, -6241, -6162, -6086, -6009, -5933, -5859, -5785, -5712, -5638, -5567, -5495, -5424, -5355, -5285, -5215, -5147, -5080, -5012, -4945, -4880, -4814, -4750, -4686, -4622, -4559, -4496, -4435, -4374, -4313, -4253, -4194, -4135, -4077, -4019, -3963, -3906, -3850, -3794, -3740, -3685, -3631, -3577, -3523, -3471, -3418, -3366, -3315, -3264, -3215, -3164, -3116, -3067, -3018, -2971, -2922, -2876, -2829, -2783, -2738, -2693, -2648, -2604, -2559, -2516, -2474, -2431, -2389, -2347, -2306, -2265, -2224, -2185, -2144, -2104, -2066, -2027, -1988, -1950, -1912, -1875, -1839, -1802, -1766, -1730, -1696, -1660, -1625, -1591, -1557, -1524, -1492, -1458, -1427, -1395, -1362, -1332, -1300, -1270, -1241, -1208, -1181, -1150, -1120, -1095, -1060, -1032, -1008, -944};