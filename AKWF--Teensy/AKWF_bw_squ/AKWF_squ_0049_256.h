/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ_0049 256 samples */
 
const int16_t AKWF_squ_0049_256_DATA [256] = 
{3048, 25912, 33526, 31810, 31547, 31808, 27975, 4718, -3357, -1967, -2209, -2187, -2162, -2141, -2120, -2097, -2077, -2057, -2037, -2018, -1997, -1978, -1959, -1939, -1920, -1901, -1882, -1863, -1845, -1827, -1809, -1791, -1773, -1755, -1738, -1720, -1703, -1686, -1669, -1652, -1635, -1619, -1602, -1586, -1569, -1554, -1537, -1522, -1506, -1491, -1475, -1460, -1445, -1430, -1415, -1400, -1386, -1371, -1356, -1343, -1328, -1314, -1301, -1287, -1273, -1260, -1247, -1233, -1220, -1207, -1194, -1181, -1168, -1156, -1143, -1131, -1118, -1105, -1094, -1083, -1071, -1058, -1047, -1036, -1024, -1013, -1001, -990, -979, -967, -956, -946, -936, -925, -914, -904, -894, -883, -873, -863, -853, -843, -833, -824, -815, -805, -795, -786, -776, -767, -758, -748, -740, -732, -722, -713, -705, -696, -687, -679, -671, -662, -654, -646, -638, -630, -622, -614, -607, -597, -590, -582, -575, -568, -560, -554, -547, -540, -532, -525, -518, -511, -504, -498, -491, -484, -478, -472, -465, -458, -452, -446, -440, -434, -428, -421, -415, -410, -404, -398, -392, -387, -381, -375, -369, -364, -358, -353, -348, -342, -337, -332, -326, -321, -316, -311, -306, -301, -297, -292, -287, -282, -278, -273, -268, -263, -259, -255, -250, -246, -241, -237, -233, -229, -225, -220, -216, -213, -209, -204, -201, -197, -192, -189, -185, -181, -177, -174, -171, -167, -163, -159, -156, -153, -149, -146, -142, -139, -136, -133, -130, -127, -124, -121, -118, -114, -111, -108, -105, -102, -99, -97, -93, -90, -88, -85, -82, -79, -77, -74, -72, -69, -67, -64, -62, -59, -57, -56, -52, -51, -50, -47, -49, -45, -45, -56};