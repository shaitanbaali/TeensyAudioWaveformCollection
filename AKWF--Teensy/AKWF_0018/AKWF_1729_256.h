/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1729 256 samples */
 
const int16_t AKWF_1729_256_DATA [256] = 
{1153, 3268, 5223, 7070, 8809, 10440, 11970, 13398, 14732, 15978, 17136, 18218, 19228, 20165, 21043, 21861, 22622, 23336, 24005, 24629, 25216, 25767, 26281, 26769, 27226, 27656, 28062, 28445, 28805, 29145, 29466, 29768, 30053, 30321, 30575, 30812, 31033, 31240, 31433, 31612, 31777, 31930, 32069, 32194, 32309, 32409, 32498, 32572, 32635, 32687, 32725, 32751, 32764, 32767, 32756, 32733, 32698, 32651, 32592, 32521, 32437, 32341, 32232, 32112, 31979, 31833, 31675, 31503, 31317, 31119, 30908, 30684, 30445, 30191, 29922, 29640, 29340, 29024, 28691, 28338, 27969, 27578, 27163, 26727, 26267, 25779, 25264, 24715, 24134, 23519, 22862, 22164, 21421, 20626, 19778, 18872, 17900, 16862, 15750, 14556, 13283, 11917, 10456, 8901, 7238, 5468, 3595, 1606, -493, -2696, -5008, -7424, -9923, -12514, -15176, -17891, -20626, -23560, -25666, -24507, -23104, -21803, -20528, -19317, -18179, -17119, -16152, -15281, -14507, -13837, -13268, -12800, -12429, -12155, -11969, -11869, -11849, -11902, -12023, -12205, -12443, -12728, -13059, -13427, -13827, -14256, -14709, -15179, -15666, -16164, -16669, -17180, -17694, -18206, -18716, -19220, -19718, -20208, -20686, -21153, -21607, -22046, -22470, -22879, -23268, -23640, -23994, -24328, -24640, -24933, -25204, -25455, -25683, -25890, -26073, -26234, -26371, -26485, -26576, -26645, -26688, -26709, -26706, -26679, -26628, -26555, -26456, -26336, -26194, -26027, -25836, -25625, -25391, -25134, -24856, -24557, -24237, -23897, -23537, -23158, -22760, -22344, -21913, -21465, -21003, -20527, -20038, -19538, -19029, -18511, -17987, -17461, -16932, -16403, -15877, -15357, -14846, -14350, -13868, -13406, -12971, -12563, -12192, -11858, -11569, -11332, -11151, -11032, -10983, -11008, -11113, -11304, -11587, -11965, -12441, -13018, -13698, -14475, -15353, -16325, -17382, -18521, -19728, -20989, -22263, -23736, -24386, -21766, -18905, -16152, -13424, -10766, -8187, -5692, -3303, -974};