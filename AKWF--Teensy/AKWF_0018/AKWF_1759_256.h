/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1759 256 samples */
 
const int16_t AKWF_1759_256_DATA [256] = 
{546, 3216, 6649, 10099, 13004, 15074, 16358, 17072, 17586, 18319, 19535, 21146, 22695, 23690, 24007, 23943, 23817, 23703, 23570, 23425, 23203, 22596, 21207, 19036, 16846, 15687, 15975, 17184, 18341, 18597, 17255, 13801, 9835, 7197, 5988, 5804, 6216, 6865, 7322, 7155, 6351, 5460, 5088, 5318, 5754, 5978, 5889, 5675, 5571, 5772, 6484, 7877, 9842, 11894, 13444, 14200, 14280, 14115, 14225, 15010, 16626, 18942, 21468, 23452, 24571, 24783, 24378, 23854, 23763, 24492, 26054, 28030, 29834, 31054, 31663, 31843, 31776, 31656, 31725, 32089, 32521, 32537, 31821, 30611, 29528, 28945, 28672, 28263, 27358, 25626, 22642, 18150, 12635, 8191, 5943, 5269, 5462, 5593, 4732, 2613, -38, -2173, -3288, -3583, -3536, -3430, -3353, -3383, -3613, -3932, -3992, -3610, -3057, -2849, -3353, -4499, -5916, -7147, -7808, -7655, -6678, -5216, -3863, -3120, -3148, -3729, -4363, -4488, -3696, -1903, 566, 3085, 5060, 6206, 6558, 6346, 5933, 5732, 6010, 6667, 7248, 7268, 6608, 5574, 4506, 3489, 2493, 1534, 540, -799, -2893, -5758, -8645, -10508, -10941, -10460, -10038, -10513, -12565, -16694, -21293, -24519, -26281, -26986, -27072, -26914, -26960, -27636, -28958, -30373, -31255, -31505, -31502, -31644, -32032, -32477, -32748, -32671, -32058, -30761, -28909, -27001, -25624, -25065, -25197, -25565, -25630, -24971, -23414, -21091, -18492, -16376, -15085, -14677, -14882, -15211, -15114, -14202, -12453, -10268, -8217, -6699, -5736, -5141, -4744, -4367, -3778, -2894, -1957, -1456, -1714, -2480, -3123, -3256, -3045, -2920, -3233, -4307, -6570, -10299, -15013, -18639, -20068, -19931, -18942, -18028, -18114, -19461, -21332, -22670, -22963, -22416, -21509, -20530, -19566, -18709, -18056, -17494, -16676, -15412, -13970, -12858, -12430, -12629, -13075, -13319, -12991, -11850, -9887, -7431, -5071, -3321, -2347, -1933, -1572, -670};