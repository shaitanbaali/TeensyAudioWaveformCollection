/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1733 256 samples */
 
const int16_t AKWF_1733_256_DATA [256] = 
{3663, 9827, 16269, 23705, 29470, 31696, 31934, 32451, 32702, 30634, 26219, 21652, 18116, 14452, 9545, 4319, 391, -2234, -4806, -7675, -9789, -10471, -10382, -10448, -10512, -9826, -8359, -6883, -5825, -4784, -3365, -1828, -708, -16, 658, 1450, 2051, 2235, 2195, 2218, 2271, 2125, 1759, 1390, 1147, 921, 586, 211, -54, -206, -353, -543, -692, -734, -719, -723, -743, -716, -631, -545, -493, -447, -372, -286, -223, -191, -160, -114, -76, -65, -68, -63, -56, -57, -74, -91, -99, -103, -116, -133, -146, -150, -153, -162, -169, -170, -166, -165, -166, -165, -160, -155, -152, -150, -145, -140, -137, -135, -131, -128, -126, -123, -121, -121, -119, -118, -117, -117, -118, -114, -113, -114, -114, -112, -111, -112, -110, -109, -110, -108, -107, -108, -106, -106, -103, -101, -100, -100, -98, -97, -96, -95, -92, -91, -91, -89, -89, -88, -87, -88, -87, -83, -83, -84, -83, -81, -82, -81, -80, -79, -80, -78, -77, -78, -75, -73, -74, -72, -71, -72, -71, -69, -70, -69, -67, -67, -68, -67, -65, -65, -66, -64, -61, -62, -62, -61, -59, -59, -60, -59, -56, -55, -55, -56, -54, -53, -53, -54, -53, -51, -52, -52, -51, -49, -50, -49, -50, -49, -47, -48, -47, -48, -47, -44, -43, -44, -44, -43, -41, -42, -42, -41, -42, -41, -39, -40, -40, -39, -40, -38, -37, -38, -37, -37, -38, -36, -35, -36, -35, -35, -35, -36, -34, -31, -32, -32, -31, -32, -31, -31, -30, -35, -56, 20, -1948, -7020, -13010, -20105, -27320, -31342, -30959, -28701, -26475, -22459, -14674, -4847};