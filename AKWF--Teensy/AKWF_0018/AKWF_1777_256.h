/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1777 256 samples */
 
const int16_t AKWF_1777_256_DATA [256] = 
{29740, 29105, 28634, 28283, 28000, 27766, 27567, 27394, 27242, 27108, 26989, 26881, 26784, 26697, 26618, 26547, 26483, 26426, 26375, 26330, 26289, 26254, 26226, 26199, 26199, 26087, 26078, 26277, 26270, 26281, 26284, 26285, 26283, 26280, 26276, 26271, 26265, 26259, 26253, 26245, 26239, 26231, 26223, 26215, 26207, 26198, 26189, 26181, 26172, 26162, 26153, 26144, 26134, 26125, 26115, 26106, 26096, 26086, 26076, 26066, 26056, 26045, 26035, 26024, 26015, 26004, 25993, 25983, 25972, 25962, 25952, 25941, 25930, 25919, 25909, 25898, 25888, 25877, 25865, 25855, 25844, 25833, 25822, 25810, 25799, 25789, 25778, 25767, 25755, 25744, 25732, 25722, 25710, 25699, 25688, 25676, 25665, 25654, 25643, 25631, 25620, 25609, 25597, 25585, 25574, 25562, 25551, 25539, 25528, 25516, 25505, 25493, 25481, 25470, 25458, 25447, 25435, 25424, 25412, 25399, 25388, 25377, 25364, 25353, 25341, 25329, 25339, 25167, 26333, 24302, 20301, 16862, 13535, 10377, 7398, 4592, 1963, -505, -2815, -4987, -7003, -8877, -10636, -12266, -13785, -15199, -16517, -17737, -18871, -19927, -20903, -21810, -22664, -23442, -24176, -24852, -25481, -26059, -26601, -27103, -27564, -27995, -28398, -28765, -29107, -29425, -29722, -29992, -30241, -30474, -30691, -30890, -31072, -31238, -31392, -31538, -31666, -31788, -31896, -31995, -32087, -32172, -32247, -32316, -32377, -32433, -32484, -32528, -32567, -32604, -32635, -32663, -32685, -32707, -32722, -32736, -32748, -32755, -32762, -32766, -32767, -32768, -32767, -32764, -32760, -32754, -32747, -32740, -32731, -32721, -32711, -32700, -32688, -32676, -32663, -32650, -32636, -32622, -32608, -32594, -32579, -32564, -32549, -32534, -32519, -32504, -32489, -32474, -32459, -32443, -32428, -32413, -32398, -32382, -32367, -32352, -32337, -32322, -32307, -32292, -32277, -32261, -32246, -32231, -32216, -32201, -32186, -32170, -32156, -32141, -32125, -32110, -32096, -32080, -32065, -32050};