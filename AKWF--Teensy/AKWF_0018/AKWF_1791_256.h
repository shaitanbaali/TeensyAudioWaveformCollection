/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1791 256 samples */
 
const int16_t AKWF_1791_256_DATA [256] = 
{2005, 5325, 8209, 10784, 13088, 15130, 16973, 18620, 20097, 21436, 22618, 23696, 24652, 25572, 26015, 26051, 26319, 26616, 26960, 27344, 27748, 28173, 28613, 29051, 29503, 29951, 30397, 30830, 31316, 31752, 32043, 32342, 32570, 32636, 32691, 32732, 32756, 32767, 32767, 32754, 32732, 32698, 32656, 32605, 32548, 32481, 32408, 32332, 32247, 32155, 32058, 31961, 31859, 31748, 31639, 31522, 31403, 31280, 31154, 31029, 30899, 30767, 30633, 30497, 30361, 30221, 30077, 29941, 29770, 29462, 29147, 28833, 28549, 28284, 28048, 27829, 27618, 27432, 27245, 27067, 26909, 26738, 26591, 26397, 26336, 26118, 19851, 13533, 8807, 4469, 751, -2441, -5229, -7627, -9712, -11519, -13066, -14407, -15557, -16549, -17402, -18122, -18730, -19244, -19667, -20020, -20301, -20521, -20691, -20808, -20886, -20925, -20929, -20905, -20851, -20774, -20676, -20556, -20422, -20267, -20103, -19925, -19734, -19535, -19325, -19108, -18886, -18653, -18418, -18178, -17933, -17686, -17433, -17182, -16925, -16667, -16410, -16147, -15889, -15628, -15365, -15107, -14844, -14583, -14325, -14064, -13808, -13553, -13295, -13045, -12788, -12541, -12295, -12041, -11803, -11589, -11209, -11628, -13533, -14891, -16115, -17172, -18103, -18912, -19616, -20237, -20773, -21240, -21644, -21993, -22296, -22552, -22778, -22961, -23115, -23246, -23332, -23536, -22064, -20013, -18638, -17355, -16285, -15385, -14605, -13954, -13406, -12935, -12549, -12219, -11945, -11722, -11534, -11386, -11267, -11171, -11102, -11050, -11015, -10996, -10986, -10990, -11001, -11021, -11049, -11080, -11116, -11157, -11201, -11247, -11295, -11346, -11395, -11445, -11498, -11549, -11600, -11651, -11700, -11749, -11797, -11842, -11887, -11930, -11972, -12012, -12049, -12086, -12117, -12148, -12177, -12204, -12229, -12250, -12269, -12286, -12299, -12312, -12321, -12327, -12332, -12330, -12331, -12326, -12317, -12310, -12297, -12261, -12314, -12064, -10429, -9110, -7998, -7177, -5597, -1547};