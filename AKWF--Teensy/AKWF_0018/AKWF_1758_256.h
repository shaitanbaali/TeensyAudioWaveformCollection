/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1758 256 samples */
 
const int16_t AKWF_1758_256_DATA [256] = 
{1021, 3359, 5641, 7866, 9983, 11957, 13738, 15296, 16627, 17721, 18573, 19190, 19582, 19765, 19756, 19574, 19257, 18850, 18401, 17963, 17587, 17327, 17222, 17300, 17581, 18069, 18756, 19557, 20374, 21272, 22219, 23166, 24071, 24902, 25648, 26285, 26797, 27190, 27476, 27673, 27794, 27847, 27835, 27743, 27557, 27259, 26863, 26425, 25982, 25573, 25230, 24983, 24849, 24838, 24933, 25123, 25380, 25663, 25932, 26146, 26275, 26293, 26190, 25965, 25647, 25262, 24856, 24471, 24148, 23911, 23777, 23749, 23761, 23750, 23661, 23452, 23079, 22523, 21782, 20879, 19856, 18656, 17807, 17980, 17796, 17194, 16291, 15135, 13789, 12322, 10779, 9231, 7738, 6330, 5032, 3845, 2737, 1670, 607, -481, -1617, -2809, -4051, -5325, -6632, -7963, -9303, -10664, -12041, -13425, -14810, -16163, -17451, -18624, -19636, -20441, -20999, -21300, -21354, -21192, -20874, -20484, -20125, -19847, -19564, -19205, -18733, -18135, -17414, -16590, -15688, -14743, -13802, -12910, -12106, -11429, -10906, -10553, -10380, -10385, -10563, -10907, -11399, -12003, -12684, -13399, -14101, -14738, -15282, -15716, -16032, -16252, -16406, -16535, -16702, -16972, -17400, -18022, -18849, -19875, -21083, -22419, -23828, -25271, -26690, -28039, -29271, -30344, -31230, -31909, -32385, -32667, -32768, -32697, -32469, -32097, -31576, -30904, -30084, -29119, -28009, -26762, -25392, -23903, -22314, -20638, -18878, -17052, -15176, -13265, -11355, -9488, -7712, -6099, -4716, -3665, -2696, -4296, -8845, -11391, -12932, -14579, -15555, -15475, -15706, -16177, -16741, -17425, -17463, -16449, -15709, -15173, -14766, -14470, -14282, -14196, -14208, -14303, -14453, -14623, -14778, -14899, -14981, -15028, -15060, -15102, -15174, -15287, -15441, -15622, -15805, -15977, -16130, -16265, -16398, -16559, -16782, -17088, -17488, -17961, -18460, -18915, -19235, -19329, -19118, -18545, -17583, -16231, -14520, -12511, -10172, -8093, -6880, -5284, -3351, -1172};