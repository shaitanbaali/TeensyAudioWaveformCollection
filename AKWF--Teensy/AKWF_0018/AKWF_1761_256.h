/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1761 256 samples */
 
const int16_t AKWF_1761_256_DATA [256] = 
{561, 1393, 2086, 2693, 3226, 3696, 4113, 4479, 4805, 5096, 5357, 5593, 5811, 6016, 6212, 6402, 6589, 6776, 6958, 7137, 7312, 7481, 7645, 7801, 7951, 8095, 8235, 8371, 8504, 8639, 8774, 8910, 9049, 9188, 9328, 9468, 9605, 9741, 9875, 10007, 10135, 10262, 10389, 10514, 10640, 10766, 10893, 11023, 11151, 11282, 11412, 11541, 11670, 11798, 11925, 12051, 12175, 12299, 12423, 12547, 12672, 12796, 12923, 13048, 13175, 13302, 13428, 13555, 13680, 13806, 13931, 14054, 14178, 14302, 14426, 14550, 14674, 14798, 14923, 15048, 15173, 15299, 15424, 15548, 15672, 15797, 15920, 16044, 16168, 16292, 16415, 16539, 16663, 16788, 16912, 17036, 17161, 17285, 17409, 17533, 17657, 17781, 17905, 18028, 18152, 18276, 18400, 18524, 18648, 18771, 18896, 19020, 19144, 19268, 19392, 19515, 19639, 19763, 19886, 20011, 20134, 20258, 20382, 20506, 20629, 20324, 22726, 10595, -6599, -7896, -13726, -19799, -25479, -29870, -32344, -32635, -30863, -27464, -23119, -18580, -14586, -11728, -10343, -10521, -12076, -14623, -17645, -20584, -22959, -24402, -24743, -23995, -22352, -20140, -17738, -15540, -13864, -12916, -12772, -13365, -14519, -15977, -17456, -18698, -19494, -19737, -19411, -18599, -17452, -16164, -14938, -13947, -13311, -13085, -13250, -13727, -14391, -15099, -15712, -16116, -16246, -16081, -15654, -15034, -14320, -13616, -13012, -12580, -12356, -12337, -12489, -12753, -13056, -13325, -13499, -13536, -13424, -13170, -12808, -12387, -11957, -11570, -11265, -11063, -10967, -10965, -11027, -11119, -11200, -11238, -11210, -11105, -10925, -10685, -10409, -10120, -9850, -9616, -9433, -9304, -9226, -9183, -9158, -9133, -9087, -9008, -8890, -8731, -8537, -8320, -8094, -7870, -7661, -7474, -7311, -7172, -7049, -6933, -6814, -6679, -6522, -6335, -6118, -5871, -5596, -5297, -4979, -4642, -4287, -3908, -3498, -3043, -2528, -1928, -1223, -347};