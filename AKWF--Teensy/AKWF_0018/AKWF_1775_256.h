/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1775 256 samples */
 
const int16_t AKWF_1775_256_DATA [256] = 
{5645, 8265, 9338, 10202, 10877, 11441, 11932, 12366, 12760, 13122, 13457, 13774, 14074, 14360, 14633, 14896, 15150, 15396, 15636, 15869, 16095, 16318, 16535, 16746, 16953, 17154, 17351, 17544, 17735, 17899, 18219, 18737, 19232, 19724, 20210, 20691, 21164, 21632, 22092, 22544, 22990, 23428, 23858, 24279, 24694, 25098, 25494, 25882, 26259, 26628, 26988, 27336, 27676, 28006, 28325, 28635, 28933, 29222, 29501, 29771, 30029, 30278, 30517, 30747, 30969, 31182, 31390, 31602, 31740, 31847, 31951, 32046, 32134, 32216, 32290, 32358, 32419, 32474, 32523, 32566, 32604, 32637, 32666, 32690, 32709, 32727, 32739, 32749, 32756, 32761, 32766, 32767, 32763, 32776, 32659, 31992, 31162, 30434, 29726, 29032, 28352, 27680, 27014, 26356, 25699, 25046, 24395, 23745, 23097, 22449, 21800, 21148, 20495, 19835, 19171, 18500, 17818, 17124, 16414, 15681, 14920, 14122, 13270, 12347, 11315, 10018, 8890, 4636, -12536, -16251, -17347, -18527, -19438, -20224, -20922, -21546, -22116, -22641, -23126, -23578, -24001, -24395, -24767, -25117, -25447, -25760, -26056, -26338, -26603, -26858, -27101, -27332, -27553, -27765, -27969, -28165, -28350, -28551, -28586, -28412, -28249, -28081, -27911, -27737, -27560, -27383, -27203, -27023, -26844, -26664, -26486, -26309, -26133, -25959, -25786, -25618, -25454, -25292, -25133, -24978, -24829, -24682, -24541, -24406, -24276, -24151, -24031, -23918, -23811, -23710, -23616, -23529, -23450, -23379, -23319, -23277, -23178, -23064, -22962, -22866, -22778, -22696, -22622, -22555, -22494, -22439, -22390, -22346, -22308, -22275, -22246, -22223, -22203, -22186, -22173, -22163, -22155, -22151, -22148, -22146, -22148, -22126, -22292, -22317, -22144, -22076, -22025, -21987, -21956, -21929, -21903, -21877, -21845, -21810, -21768, -21717, -21658, -21589, -21507, -21411, -21301, -21173, -21027, -20860, -20667, -20447, -20198, -19910, -19578, -19195, -18741, -18200, -17533, -16648, -15598, -12540};