/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1710 256 samples */
 
const int16_t AKWF_1710_256_DATA [256] = 
{2408, 5936, 8788, 11156, 13095, 14670, 15940, 16949, 17743, 18362, 18836, 19194, 19460, 19651, 19787, 19878, 19936, 19971, 19986, 19988, 19981, 19967, 19947, 19921, 19890, 19855, 19814, 19766, 19714, 19654, 19588, 19514, 19433, 19345, 19248, 19143, 19031, 18913, 18786, 18653, 18515, 18369, 18221, 18066, 17906, 17742, 17574, 17405, 17231, 17055, 16877, 16695, 16513, 16329, 16144, 15957, 15767, 15578, 15386, 15194, 15002, 14806, 14611, 14415, 14218, 14021, 13823, 13623, 13422, 13221, 13020, 12818, 12614, 12411, 12207, 12000, 11795, 11590, 11382, 11174, 10967, 10757, 10549, 10339, 10129, 9918, 9709, 9497, 9286, 9074, 8862, 8650, 8436, 8223, 8010, 7797, 7583, 7369, 7154, 6940, 6724, 6509, 6295, 6078, 5863, 5647, 5431, 5215, 4999, 4782, 4565, 4349, 4132, 3915, 3697, 3481, 3264, 3046, 2829, 2612, 2394, 2177, 1959, 1742, 1524, 1306, 1088, 870, 652, 435, 217, -1, -218, -435, -653, -871, -1089, -1307, -1525, -1742, -1960, -2177, -2394, -2613, -2830, -3047, -3265, -3482, -3699, -3917, -4133, -4351, -4567, -4783, -5001, -5217, -5433, -5649, -5865, -6081, -6296, -6512, -6727, -6942, -7158, -7372, -7587, -7800, -8015, -8229, -8441, -8654, -8868, -9079, -9291, -9504, -9714, -9927, -10137, -10347, -10556, -10765, -10974, -11182, -11389, -11596, -11803, -12009, -12214, -12419, -12623, -12827, -13032, -13234, -13437, -13640, -13841, -14042, -14244, -14445, -14646, -14847, -15047, -15247, -15448, -15647, -15844, -16042, -16238, -16431, -16624, -16814, -17001, -17186, -17364, -17539, -17709, -17872, -18029, -18180, -18325, -18461, -18591, -18715, -18834, -18950, -19061, -19174, -19290, -19413, -19548, -19700, -19875, -20078, -20319, -20603, -20941, -21340, -21809, -22360, -23000, -23743, -24595, -25561, -26649, -27855, -29158, -30507, -31839, -32817, -30632, -24815, -18225, -11996, -6450, -1580};