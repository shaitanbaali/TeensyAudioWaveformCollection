/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1769 256 samples */
 
const int16_t AKWF_1769_256_DATA [256] = 
{551, 1368, 2169, 2971, 3773, 4576, 5380, 6182, 6984, 7788, 8588, 9391, 10194, 10994, 11796, 12599, 13399, 14200, 15002, 15801, 16602, 17403, 18202, 19003, 19803, 20601, 21401, 22201, 22998, 23799, 24597, 25394, 26193, 26990, 27787, 28587, 29383, 30181, 30799, 32360, 30469, -3118, -17949, -16638, -16611, -16393, -16166, -15938, -15711, -15481, -15252, -15023, -14793, -14563, -14333, -14102, -13871, -13641, -13409, -13178, -12947, -12715, -12483, -12252, -12020, -11788, -11556, -11323, -11092, -10861, -10628, -10397, -10165, -9932, -9700, -9469, -9236, -9004, -8772, -8541, -8309, -8077, -7842, -7623, -7320, -6821, -6325, -5828, -5331, -4834, -4336, -3839, -3343, -2846, -2350, -1859, -1337, -1058, -1079, -1073, -1072, -1071, -1070, -1069, -1069, -1068, -1067, -1066, -1065, -1065, -1065, -1064, -1062, -1063, -1062, -1061, -1062, -1061, -1060, -1061, -1060, -1058, -1059, -1032, -1180, -551, 2263, 2138, 2061, 1987, 1908, 1830, 1751, 1673, 1594, 1515, 1437, 1358, 1280, 1201, 1122, 1044, 965, 887, 808, 729, 650, 572, 493, 414, 336, 257, 179, 100, 21, -56, -135, -213, -292, -371, -448, -526, -605, -684, -762, -841, -918, -999, -1060, -1062, -1061, -1061, -1061, -1062, -1061, -1060, -1061, -1060, -1060, -1061, -1060, -1059, -1058, -1059, -1058, -1059, -1058, -1057, -1058, -1057, -1058, -1057, -1056, -1055, -1055, -1056, -1055, -1054, -1055, -1054, -1055, -1054, -1053, -1054, -1053, -1054, -1053, -1051, -1052, -1051, -1052, -1051, -1050, -1051, -1050, -1051, -1050, -1049, -1050, -1050, -1049, -1048, -1047, -1047, -1048, -1047, -1046, -1047, -1046, -1047, -1046, -1045, -1046, -1045, -1046, -1045, -1043, -1044, -1043, -1044, -1043, -1042, -1043, -1043, -1042, -1042, -1041, -1041, -1042, -1041, -1040, -1039, -1035, -1053, -976, -244};