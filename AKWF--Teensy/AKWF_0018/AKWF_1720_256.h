/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1720 256 samples */
 
const int16_t AKWF_1720_256_DATA [256] = 
{3886, 10112, 14747, 18336, 21123, 23308, 25048, 26440, 27575, 28508, 29281, 29928, 30472, 30927, 31311, 31634, 31903, 32126, 32309, 32455, 32572, 32658, 32718, 32755, 32768, 32764, 32742, 32702, 32647, 32579, 32496, 32400, 32293, 32175, 32046, 31908, 31758, 31602, 31434, 31260, 31076, 30884, 30686, 30478, 30263, 30038, 29808, 29571, 29323, 29069, 28806, 28535, 28255, 27967, 27671, 27365, 27051, 26728, 26396, 26052, 25698, 25334, 24960, 24575, 24178, 23769, 23348, 22915, 22469, 22011, 21537, 21051, 20550, 20033, 19504, 18959, 18398, 17824, 17229, 16617, 15992, 15349, 14687, 14009, 13310, 12593, 11862, 11107, 10336, 9546, 8734, 7907, 7060, 6194, 5307, 4404, 3479, 2537, 1575, 599, -395, -1409, -2440, -3486, -4551, -5632, -6725, -7832, -8955, -10088, -11236, -12396, -13563, -14741, -15932, -17125, -18329, -19538, -20749, -21967, -23189, -24409, -25630, -26836, -28138, -28863, -28198, -27501, -26817, -26133, -25456, -24783, -24120, -23465, -22816, -22181, -21556, -20942, -20339, -19749, -19174, -18613, -18064, -17529, -17014, -16513, -16025, -15557, -15104, -14667, -14249, -13847, -13461, -13093, -12743, -12410, -12094, -11794, -11513, -11249, -10999, -10768, -10554, -10355, -10172, -10006, -9854, -9718, -9597, -9490, -9398, -9321, -9257, -9206, -9169, -9144, -9133, -9133, -9145, -9169, -9203, -9249, -9305, -9373, -9449, -9536, -9631, -9736, -9849, -9971, -10100, -10238, -10384, -10536, -10696, -10862, -11035, -11214, -11400, -11590, -11787, -11990, -12196, -12408, -12625, -12846, -13070, -13300, -13534, -13771, -14011, -14256, -14502, -14753, -15006, -15263, -15522, -15783, -16047, -16312, -16580, -16850, -17122, -17396, -17672, -17948, -18226, -18506, -18786, -19069, -19353, -19636, -19921, -20208, -20494, -20781, -21070, -21358, -21647, -21934, -22225, -22517, -22803, -23072, -23446, -22331, -17954, -12968, -9534, -8689, -10921, -15735, -23381, -25068, -13495, -3646};