/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1765 256 samples */
 
const int16_t AKWF_1765_256_DATA [256] = 
{225, 586, 936, 1291, 1660, 2044, 2448, 2872, 3318, 3783, 4265, 4765, 5278, 5797, 6324, 6853, 7378, 7898, 8407, 8900, 9376, 9831, 10259, 10662, 11033, 11372, 11678, 11948, 12184, 12383, 12547, 12675, 12771, 12834, 12866, 12870, 12850, 12806, 12743, 12663, 12570, 12468, 12359, 12248, 12138, 12031, 11932, 11843, 11768, 11708, 11666, 11642, 11641, 11663, 11708, 11778, 11873, 11992, 12135, 12302, 12492, 12703, 12934, 13183, 13448, 13727, 14017, 14317, 14624, 14934, 15248, 15560, 15870, 16175, 16472, 16761, 17039, 17303, 17554, 17788, 18007, 18209, 18394, 18560, 18709, 18840, 18954, 19053, 19135, 19203, 19258, 19301, 19334, 19358, 19375, 19387, 19396, 19402, 19408, 19417, 19430, 19446, 19469, 19500, 19540, 19589, 19650, 19721, 19806, 19903, 20011, 20134, 20268, 20414, 20572, 20741, 20921, 21111, 21309, 21514, 21726, 21564, 23868, 3956, -5748, -3911, -4718, -5379, -6250, -7308, -8536, -9913, -11409, -13004, -14675, -16388, -18124, -19857, -21557, -23205, -24780, -26252, -27613, -28842, -29918, -30837, -31585, -32153, -32539, -32739, -32753, -32584, -32237, -31717, -31037, -30206, -29239, -28147, -26948, -25660, -24297, -22882, -21430, -19958, -18490, -17040, -15623, -14261, -12965, -11748, -10629, -9611, -8706, -7924, -7268, -6741, -6350, -6090, -5961, -5960, -6083, -6321, -6669, -7117, -7653, -8268, -8950, -9685, -10460, -11264, -12082, -12900, -13709, -14492, -15240, -15942, -16586, -17166, -17672, -18096, -18435, -18684, -18839, -18899, -18864, -18735, -18512, -18201, -17806, -17332, -16785, -16173, -15502, -14781, -14021, -13229, -12416, -11590, -10760, -9936, -9128, -8340, -7585, -6868, -6193, -5569, -5000, -4487, -4038, -3651, -3326, -3067, -2870, -2732, -2652, -2624, -2645, -2709, -2806, -2931, -3075, -3228, -3379, -3518, -3632, -3704, -3721, -3662, -3509, -3236, -2812, -2197, -1540, -1001, -546, -135};