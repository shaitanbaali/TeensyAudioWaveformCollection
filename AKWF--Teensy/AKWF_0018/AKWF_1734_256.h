/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1734 256 samples */
 
const int16_t AKWF_1734_256_DATA [256] = 
{10140, 23386, 32395, 32809, 32718, 32755, 32753, 32751, 32749, 32745, 32741, 32738, 32733, 32727, 32722, 32716, 32710, 32704, 32697, 32690, 32683, 32676, 32669, 32662, 32655, 32647, 32639, 32625, 32615, 32622, 30447, 27200, 24221, 21291, 18424, 15648, 12976, 10379, 7884, 5521, 3232, 1047, -1024, -2974, -4839, -6585, -8232, -9775, -11222, -12576, -13807, -14972, -16041, -17015, -17895, -18705, -19432, -20065, -20641, -21148, -21582, -21939, -22248, -22500, -22680, -22809, -22901, -22938, -22918, -22871, -22784, -22653, -22482, -22290, -22066, -21804, -21514, -21218, -20887, -20531, -20174, -19797, -19386, -18981, -18566, -18133, -17677, -17241, -16789, -16318, -15856, -15396, -14937, -14445, -13991, -13523, -13055, -12575, -12126, -11673, -11195, -10763, -10325, -9904, -9439, -9032, -8627, -8184, -7783, -7391, -7002, -6587, -6265, -5948, -5557, -5232, -4845, -6127, 28301, 33821, 32537, 32767, 32766, 32738, 32689, 32912, 23125, 5326, -9513, -22819, -32263, -32810, -32690, -32734, -32732, -32730, -32727, -32724, -32720, -32716, -32711, -32706, -32701, -32695, -32689, -32683, -32676, -32669, -32662, -32655, -32648, -32641, -32634, -32626, -32618, -32604, -32592, -32609, -30575, -27326, -24341, -21408, -18536, -15744, -13079, -10478, -7980, -5591, -3313, -1126, 948, 2904, 4769, 6526, 8187, 9721, 11174, 12534, 13787, 14938, 16010, 16994, 17874, 18684, 19417, 20061, 20637, 21146, 21581, 21952, 22255, 22507, 22694, 22824, 22918, 22957, 22939, 22892, 22812, 22684, 22510, 22318, 22093, 21837, 21548, 21254, 20931, 20565, 20218, 19834, 19442, 19016, 18601, 18179, 17724, 17278, 16828, 16379, 15894, 15435, 14978, 14505, 14024, 13558, 13105, 12618, 12167, 11714, 11268, 10798, 10365, 9945, 9491, 9072, 8670, 8232, 7821, 7435, 7071, 6628, 6292, 5972, 5623, 5142, 5025, 5220, -28625, -33721, -32526, -32746, -32745, -32728, -32611, -33163, -23962, -5493};