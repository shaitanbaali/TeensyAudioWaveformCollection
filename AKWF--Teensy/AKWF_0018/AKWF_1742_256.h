/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1742 256 samples */
 
const int16_t AKWF_1742_256_DATA [256] = 
{2637, 8759, 14216, 19191, 23469, 27017, 29731, 31579, 32572, 32736, 32127, 30817, 28892, 26460, 23614, 20489, 17159, 13734, 10314, 6989, 3834, 908, -1746, -4090, -6090, -7734, -9017, -9955, -10558, -10848, -10853, -10607, -10144, -9499, -8709, -7812, -6848, -5839, -4818, -3815, -2850, -1947, -1120, -373, 281, 835, 1293, 1650, 1913, 2088, 2182, 2201, 2155, 2053, 1907, 1724, 1516, 1288, 1053, 814, 580, 354, 142, -49, -221, -374, -504, -610, -692, -754, -793, -816, -822, -812, -790, -758, -717, -670, -620, -565, -511, -456, -404, -355, -310, -269, -233, -202, -175, -154, -136, -123, -114, -109, -107, -108, -112, -118, -124, -132, -140, -148, -157, -166, -173, -179, -184, -191, -195, -198, -200, -201, -201, -202, -201, -199, -198, -194, -191, -188, -185, -182, -178, -173, -170, -165, -162, -160, -154, -151, -149, -146, -144, -142, -139, -137, -136, -135, -134, -133, -131, -132, -130, -129, -129, -128, -128, -126, -123, -124, -122, -122, -121, -120, -117, -115, -115, -113, -113, -111, -110, -109, -108, -107, -106, -105, -104, -102, -99, -99, -97, -97, -96, -95, -93, -93, -91, -92, -90, -90, -88, -88, -87, -83, -84, -83, -81, -82, -80, -80, -79, -76, -76, -75, -73, -74, -72, -71, -71, -69, -70, -68, -67, -68, -66, -65, -66, -64, -63, -64, -62, -59, -60, -59, -57, -58, -58, -56, -55, -56, -55, -53, -53, -54, -52, -51, -52, -51, -49, -49, -50, -47, -45, -46, -46, -45, -43, -45, -60, -17, -911, -4024, -8656, -13907, -19098, -23663, -27202, -29459, -30316, -29734, -27777, -24582, -20360, -15328, -9706, -3669};