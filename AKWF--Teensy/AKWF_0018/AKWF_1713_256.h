/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1713 256 samples */
 
const int16_t AKWF_1713_256_DATA [256] = 
{428, 1850, 3256, 4690, 6154, 7656, 9202, 10783, 12404, 14061, 15737, 17433, 19131, 20814, 22473, 24087, 25632, 27095, 28448, 29666, 30724, 31596, 32244, 32647, 32768, 32583, 32060, 31177, 29920, 28275, 26248, 23852, 21109, 18074, 14795, 11344, 7814, 4285, 851, -2383, -5353, -7982, -10209, -12013, -13373, -14295, -14813, -14962, -14795, -14369, -13744, -12973, -12107, -11187, -10246, -9300, -8364, -7443, -6526, -5609, -4681, -3727, -2737, -1698, -601, 556, 1780, 3068, 4414, 5813, 7259, 8730, 10220, 11714, 13187, 14627, 16014, 17319, 18529, 19617, 20552, 21315, 21877, 22208, 22282, 22074, 21559, 20719, 19540, 18019, 16153, 13965, 11479, 8730, 5781, 2693, -467, -3607, -6658, -9549, -12206, -14591, -16671, -18427, -19870, -21020, -21899, -22554, -23028, -23359, -23594, -23761, -23883, -23978, -24048, -24089, -24087, -24029, -23893, -23662, -23317, -22847, -22241, -21499, -20623, -19614, -18490, -17261, -15939, -14547, -13099, -11609, -10101, -8583, -7069, -5582, -4122, -2707, -1354, -73, 1126, 2224, 3209, 4066, 4779, 5338, 5724, 5933, 5952, 5780, 5422, 4878, 4169, 3311, 2325, 1248, 105, -1070, -2243, -3392, -4497, -5542, -6523, -7445, -8316, -9159, -9992, -10832, -11701, -12610, -13558, -14551, -15566, -16578, -17561, -18474, -19277, -19935, -20413, -20680, -20721, -20523, -20091, -19431, -18563, -17511, -16301, -14967, -13536, -12035, -10489, -8918, -7339, -5768, -4206, -2662, -1145, 351, 1827, 3271, 4692, 6084, 7437, 8756, 10030, 11246, 12408, 13501, 14515, 15447, 16289, 17031, 17675, 18214, 18646, 18967, 19175, 19267, 19235, 19069, 18761, 18292, 17647, 16806, 15753, 14471, 12948, 11182, 9182, 6966, 4562, 2027, -593, -3230, -5802, -8243, -10476, -12420, -14032, -15267, -16098, -16528, -16568, -16252, -15623, -14729, -13630, -12371, -11008, -9583, -8123, -6659, -5207, -3771, -2358, -930};