/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1748 256 samples */
 
const int16_t AKWF_1748_256_DATA [256] = 
{2895, 6993, 10868, 14549, 17999, 21149, 23969, 26419, 28471, 30139, 31393, 32242, 32690, 32750, 32441, 31783, 30804, 29532, 27998, 26250, 24302, 22194, 19970, 17653, 15288, 12916, 10532, 8193, 5917, 3722, 1647, -308, -2130, -3800, -5310, -6657, -7823, -8829, -9662, -10326, -10831, -11176, -11374, -11434, -11364, -11178, -10885, -10499, -10029, -9488, -8893, -8252, -7573, -6873, -6158, -5438, -4726, -4030, -3347, -2694, -2074, -1487, -944, -446, 9, 416, 776, 1091, 1353, 1572, 1749, 1879, 1971, 2025, 2041, 2029, 1986, 1918, 1827, 1717, 1588, 1450, 1300, 1143, 980, 818, 653, 490, 331, 177, 33, -105, -234, -353, -463, -561, -647, -723, -789, -844, -888, -920, -944, -960, -966, -965, -957, -941, -924, -898, -868, -835, -801, -763, -724, -685, -645, -605, -565, -526, -490, -454, -421, -388, -357, -329, -303, -281, -261, -243, -227, -213, -201, -194, -186, -180, -176, -175, -176, -176, -175, -178, -178, -182, -186, -192, -196, -201, -205, -210, -215, -219, -222, -225, -229, -232, -235, -236, -236, -239, -240, -239, -240, -239, -235, -236, -233, -231, -229, -226, -224, -222, -217, -213, -210, -206, -203, -199, -196, -192, -188, -184, -182, -178, -174, -171, -169, -166, -164, -162, -158, -155, -153, -150, -148, -145, -145, -142, -142, -138, -137, -137, -133, -134, -132, -129, -130, -128, -125, -126, -125, -122, -121, -122, -119, -117, -116, -115, -111, -111, -112, -109, -107, -108, -106, -103, -104, -103, -100, -99, -103, -99, -127, -901, -2833, -5587, -8846, -12369, -15926, -19311, -22356, -24941, -26971, -28383, -29134, -29209, -28614, -27385, -25553, -23174, -20311, -17042, -13460, -9632, -5650, -1392};