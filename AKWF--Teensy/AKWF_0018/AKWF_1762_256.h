/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1762 256 samples */
 
const int16_t AKWF_1762_256_DATA [256] = 
{619, 1444, 2126, 2715, 3228, 3679, 4077, 4432, 4750, 5039, 5304, 5550, 5781, 6000, 6208, 6406, 6595, 6776, 6950, 7117, 7280, 7438, 7592, 7745, 7894, 8041, 8187, 8331, 8473, 8613, 8751, 8887, 9022, 9157, 9290, 9423, 9555, 9687, 9819, 9950, 10080, 10210, 10338, 10467, 10595, 10723, 10850, 10978, 11105, 11232, 11359, 11485, 11612, 11738, 11863, 11989, 12114, 12239, 12365, 12489, 12615, 12740, 12864, 12989, 13114, 13238, 13363, 13487, 13611, 13736, 13861, 13985, 14108, 14233, 14356, 14480, 14605, 14728, 14852, 14976, 15100, 15223, 15347, 15470, 15595, 15717, 15841, 15964, 16088, 16212, 16335, 16459, 16582, 16706, 16829, 16952, 17076, 17199, 17322, 17446, 17569, 17692, 17815, 17938, 18062, 18185, 18308, 18432, 18555, 18678, 18802, 18925, 19048, 19171, 19295, 19417, 19540, 19664, 19787, 19911, 20033, 20156, 20280, 20403, 20526, 20218, 22602, 10545, -7552, -11397, -19909, -27280, -31868, -32635, -29748, -24413, -18394, -13463, -10891, -11113, -13723, -17662, -21624, -24426, -25353, -24314, -21791, -18642, -15800, -14019, -13656, -14624, -16458, -18500, -20106, -20824, -20512, -19338, -17702, -16089, -14924, -14459, -14714, -15500, -16496, -17356, -17814, -17746, -17195, -16337, -15419, -14674, -14263, -14232, -14511, -14950, -15369, -15615, -15600, -15322, -14854, -14317, -13838, -13510, -13378, -13421, -13571, -13738, -13837, -13809, -13643, -13365, -13030, -12709, -12453, -12294, -12231, -12234, -12262, -12265, -12210, -12082, -11892, -11664, -11431, -11225, -11065, -10957, -10889, -10838, -10783, -10701, -10582, -10429, -10251, -10065, -9889, -9734, -9603, -9497, -9403, -9308, -9202, -9079, -8934, -8775, -8607, -8440, -8282, -8135, -7999, -7869, -7739, -7602, -7454, -7291, -7116, -6932, -6742, -6547, -6353, -6157, -5954, -5741, -5512, -5261, -4985, -4677, -4337, -3959, -3536, -3061, -2522, -1899, -1176, -293};