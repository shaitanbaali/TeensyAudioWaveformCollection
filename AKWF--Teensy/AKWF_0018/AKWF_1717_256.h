/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1717 256 samples */
 
const int16_t AKWF_1717_256_DATA [256] = 
{1100, 2887, 4573, 6186, 7733, 9240, 10644, 11929, 13160, 14291, 15362, 16385, 17392, 18313, 19181, 19999, 20699, 21351, 21941, 22495, 23004, 23466, 23885, 24289, 24703, 25120, 25540, 25913, 26337, 26841, 27369, 27994, 28640, 29239, 29773, 30266, 30888, 31376, 31814, 32149, 32396, 32603, 32674, 32756, 32687, 32533, 32311, 32115, 31896, 31662, 31452, 31193, 30876, 30475, 30128, 29661, 29146, 28605, 27878, 27065, 26140, 25256, 24298, 23376, 22491, 21592, 20751, 19968, 19253, 18555, 17864, 17201, 16483, 15641, 14802, 13888, 12882, 11891, 10742, 9577, 8314, 7050, 5727, 4185, 2614, 1009, -594, -2070, -3540, -4902, -6173, -7320, -8346, -9275, -10066, -10763, -11395, -11969, -12454, -12946, -13342, -13691, -14087, -14267, -14475, -14485, -14473, -14267, -14003, -13716, -13230, -12711, -12015, -11318, -10562, -9837, -9140, -8419, -7728, -7019, -6323, -5631, -4923, -4274, -3572, -2866, -2056, -1171, -228, 813, 1736, 2805, 3816, 4890, 5901, 6898, 7887, 8690, 9518, 10232, 10892, 11514, 12078, 12608, 13133, 13652, 14118, 14581, 14969, 15324, 15543, 15679, 15755, 15615, 15362, 14850, 14104, 13334, 12447, 11497, 10435, 9302, 8181, 6947, 5760, 4526, 3242, 2014, 857, -260, -1292, -2240, -3123, -3981, -4859, -5665, -6536, -7415, -8314, -9329, -10431, -11622, -12723, -13908, -15017, -16071, -17149, -18195, -19186, -20084, -20969, -21760, -22542, -23322, -24187, -25010, -25811, -26632, -27376, -28168, -28865, -29613, -30193, -30627, -31051, -31432, -31742, -31898, -31931, -31887, -31715, -31547, -31381, -31181, -30961, -30719, -30498, -30297, -30114, -29934, -29765, -29606, -29475, -29381, -29241, -29119, -28958, -28748, -28512, -28278, -28031, -27763, -27524, -27221, -26868, -26454, -26030, -25454, -24846, -24289, -23575, -22786, -21896, -20702, -19190, -17769, -16448, -14872, -13252, -11815, -10240, -8342, -6356, -4436, -2478, -566};