/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1722 256 samples */
 
const int16_t AKWF_1722_256_DATA [256] = 
{32727, 32578, 32431, 32282, 32133, 31981, 31829, 31676, 31522, 31366, 31207, 31049, 30889, 30727, 30562, 30396, 30228, 30058, 29886, 29711, 29536, 29356, 29175, 28991, 28804, 28615, 28422, 28226, 28027, 27824, 27618, 27409, 27195, 26977, 26755, 26530, 26300, 26065, 25826, 25582, 25332, 25078, 24819, 24553, 24281, 24004, 23722, 23432, 23135, 22833, 22523, 22205, 21882, 21549, 21210, 20862, 20507, 20143, 19769, 19388, 18997, 18598, 18189, 17770, 17340, 16902, 16454, 15992, 15521, 15039, 14547, 14043, 13528, 13000, 12462, 11912, 11349, 10777, 10189, 9590, 8979, 8356, 7719, 7071, 6407, 5733, 5046, 4346, 3634, 2912, 2176, 1426, 666, -107, -891, -1684, -2492, -3308, -4137, -4975, -5824, -6681, -7553, -8430, -9313, -10208, -11106, -12014, -12928, -13845, -14770, -15702, -16634, -17574, -18515, -19456, -20402, -21338, -22329, -23009, -22991, -22981, -22972, -22961, -22950, -22940, -22929, -22918, -22907, -22896, -22886, -22875, -22864, -22853, -22838, -22849, -22523, -21953, -21421, -20882, -20348, -19817, -19287, -18763, -18244, -17729, -17221, -16720, -16226, -15739, -15261, -14791, -14329, -13876, -13434, -13001, -12582, -12171, -11772, -11385, -11008, -10645, -10292, -9953, -9626, -9312, -9010, -8721, -8446, -8182, -7932, -7695, -7471, -7260, -7061, -6876, -6703, -6545, -6398, -6263, -6141, -6031, -5933, -5847, -5772, -5709, -5658, -5618, -5588, -5569, -5561, -5564, -5576, -5598, -5629, -5671, -5721, -5781, -5851, -5927, -6012, -6105, -6206, -6316, -6433, -6557, -6687, -6825, -6969, -7120, -7277, -7440, -7609, -7784, -7963, -8148, -8339, -8534, -8733, -8938, -9146, -9361, -9579, -9799, -10024, -10253, -10485, -10721, -10960, -11201, -11447, -11694, -11945, -12197, -12453, -12712, -12973, -13235, -13501, -13767, -14036, -14306, -14579, -14852, -15127, -15405, -15682, -15962, -16243, -16525, -16808, -17092, -17382, -17670, -17889, -21553};