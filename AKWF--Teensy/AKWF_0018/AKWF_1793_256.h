/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1793 256 samples */
 
const int16_t AKWF_1793_256_DATA [256] = 
{494, 1775, 3241, 4779, 6292, 7600, 8606, 9233, 9507, 9458, 9172, 8711, 8160, 7588, 7042, 6574, 6203, 5952, 5828, 5841, 5996, 6291, 6738, 7331, 8075, 8949, 9947, 11040, 12188, 13346, 14456, 15459, 16307, 16955, 17365, 17532, 17461, 17184, 16746, 16203, 15622, 15055, 14572, 14204, 13992, 13964, 14139, 14536, 15150, 16002, 17062, 18300, 19656, 21023, 22285, 23297, 23894, 23926, 23288, 21932, 19875, 17224, 14190, 11032, 8059, 5578, 3840, 3052, 3297, 4547, 6642, 9357, 12397, 15419, 18262, 20894, 23196, 25113, 26653, 27854, 28766, 29460, 29963, 30309, 30504, 30541, 30396, 30030, 29406, 28485, 27243, 25684, 23260, 24381, 7140, -26403, -20433, -18650, -16516, -14728, -13310, -12249, -11512, -11034, -10753, -10601, -10524, -10471, -10416, -10349, -10281, -10248, -10305, -10534, -11026, -11885, -13207, -15055, -17418, -20177, -23139, -26208, -29075, -31302, -32563, -32685, -31616, -29466, -26488, -23000, -19355, -15911, -12973, -10739, -9315, -8691, -8786, -9448, -10499, -11747, -13037, -14236, -15259, -16054, -16601, -16907, -16984, -16852, -16522, -16012, -15338, -14516, -13571, -12543, -11477, -10425, -9453, -8594, -7900, -7395, -7090, -6980, -7041, -7239, -7534, -7884, -8244, -8575, -8851, -9044, -9140, -9126, -9004, -8773, -8444, -8031, -7559, -7059, -6573, -6149, -5837, -5702, -5790, -6143, -6770, -7643, -8681, -9746, -10757, -11631, -12213, -12430, -12273, -11785, -11038, -10120, -9131, -8151, -7241, -6454, -5797, -5277, -4885, -4595, -4388, -4240, -4129, -4042, -3968, -3901, -3838, -3780, -3727, -3682, -3644, -3614, -3586, -3556, -3517, -3459, -3376, -3259, -3102, -2903, -2666, -2392, -2091, -1772, -1440, -1105, -771, -446, -127, 186, 494, 798, 1101, 1395, 1686, 1953, 2190, 2373, 2479, 2491, 2370, 2140, 1688, 1504, 1211, 599, 28, -517, -924, -1095, -958, -397};