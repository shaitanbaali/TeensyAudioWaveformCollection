/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1796 256 samples */
 
const int16_t AKWF_1796_256_DATA [256] = 
{145, 574, 992, 1410, 1821, 2222, 2611, 2983, 3343, 3688, 4017, 4332, 4634, 4920, 5197, 5464, 5722, 5975, 6223, 6467, 6713, 6956, 7202, 7452, 7705, 7964, 8231, 8504, 8785, 9076, 9375, 9686, 10007, 10338, 10679, 11031, 11392, 11764, 12146, 12537, 12933, 13336, 13746, 14161, 14577, 14995, 15409, 15827, 16239, 16647, 17044, 17435, 17817, 18186, 18543, 18886, 19210, 19520, 19811, 20084, 20335, 20566, 20777, 20966, 21133, 21280, 21406, 21511, 21598, 21669, 21724, 21764, 21794, 21814, 21825, 21833, 21838, 21842, 21848, 21854, 21867, 21886, 21911, 21947, 21992, 22048, 22115, 22194, 22287, 22392, 22509, 22641, 22786, 22943, 23113, 23293, 23485, 23687, 23898, 24115, 24339, 24567, 24797, 25028, 25254, 25478, 25696, 25904, 26102, 26284, 26449, 26597, 26724, 26825, 26901, 26952, 26972, 26961, 26916, 25856, 31054, 3237, -36268, -30035, -30378, -29656, -28907, -28131, -27319, -26473, -25594, -24676, -23729, -22747, -21728, -20678, -19603, -18509, -17418, -16325, -15249, -14213, -13227, -12320, -11512, -10816, -10256, -9857, -9631, -9599, -9766, -10149, -10756, -11579, -12634, -13907, -15391, -17101, -19004, -21095, -23395, -25535, -27296, -28741, -29899, -30815, -31524, -32054, -32424, -32653, -32757, -32748, -32641, -32441, -32153, -31788, -31351, -30842, -30270, -29640, -28955, -28226, -27455, -26645, -25806, -24948, -24079, -23206, -22333, -21467, -20617, -19788, -18986, -18212, -17464, -16742, -16051, -15386, -14743, -14120, -13508, -12909, -12323, -11737, -11158, -10586, -10015, -9456, -8908, -8371, -7857, -7365, -6900, -6469, -6071, -5713, -5393, -5113, -4874, -4673, -4507, -4375, -4272, -4195, -4142, -4104, -4082, -4070, -4065, -4064, -4065, -4067, -4066, -4062, -4054, -4040, -4020, -3992, -3957, -3913, -3859, -3794, -3713, -3619, -3504, -3366, -3197, -2988, -2744, -2466, -2155, -1817, -1457, -1075, -678, -259};