/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1794 256 samples */
 
const int16_t AKWF_1794_256_DATA [256] = 
{116, 450, 814, 1213, 1652, 2134, 2660, 3224, 3827, 4462, 5129, 5821, 6527, 7236, 7934, 8619, 9271, 9884, 10443, 10938, 11360, 11709, 11974, 12156, 12253, 12271, 12212, 12082, 11891, 11646, 11360, 11049, 10709, 10361, 10012, 9671, 9353, 9059, 8793, 8566, 8382, 8244, 8159, 8122, 8141, 8217, 8350, 8545, 8798, 9115, 9493, 9931, 10431, 10991, 11608, 12286, 13014, 13786, 14607, 15461, 16350, 17265, 18193, 19121, 20061, 20991, 21906, 22803, 23663, 24493, 25294, 26051, 26767, 27441, 28064, 28653, 29200, 29703, 30167, 30589, 30971, 31314, 31616, 31870, 32073, 32221, 32305, 32317, 32248, 32088, 31829, 31462, 30969, 30347, 29592, 28699, 27667, 26498, 25193, 22830, 26361, -3249, -35786, -28328, -27337, -25369, -23504, -21730, -20087, -18605, -17274, -16122, -15149, -14351, -13728, -13271, -12965, -12799, -12750, -12802, -12933, -13123, -13351, -13602, -13855, -14097, -14317, -14502, -14646, -14740, -14782, -14774, -14711, -14598, -14435, -14230, -13987, -13713, -13415, -13103, -12781, -12462, -12149, -11852, -11578, -11334, -11122, -10947, -10810, -10715, -10658, -10637, -10650, -10692, -10760, -10846, -10944, -11047, -11151, -11249, -11335, -11403, -11450, -11472, -11467, -11431, -11365, -11269, -11142, -10986, -10807, -10605, -10385, -10154, -9914, -9675, -9444, -9226, -9030, -8862, -8730, -8640, -8598, -8608, -8674, -8795, -8974, -9206, -9485, -9809, -10164, -10545, -10939, -11328, -11706, -12057, -12369, -12637, -12871, -13065, -13212, -13306, -13351, -13343, -13284, -13179, -13032, -12845, -12627, -12381, -12109, -11819, -11511, -11191, -10861, -10522, -10175, -9826, -9470, -9112, -8755, -8393, -8032, -7671, -7310, -6956, -6603, -6254, -5914, -5580, -5257, -4948, -4649, -4364, -4097, -3843, -3608, -3389, -3184, -2994, -2818, -2654, -2500, -2351, -2207, -2064, -1922, -1777, -1627, -1468, -1298, -1114, -914, -692, -447, -172};