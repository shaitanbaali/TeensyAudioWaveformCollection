/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1786 256 samples */
 
const int16_t AKWF_1786_256_DATA [256] = 
{2821, 19604, 32613, 28804, 25375, 21285, 4491, -6602, -7660, -15675, -25221, -25206, -21470, -22823, -23551, -14700, -5661, -3606, 3676, 14007, 15091, 16839, 22394, 20499, 13676, 10626, 10036, 4454, -5461, -11444, -13127, -15902, -17425, -14531, -14453, -16156, -9626, -263, 542, 834, 7397, 11244, 13377, 14520, 12271, 10018, 6590, 4958, 1797, -4224, -6599, -8865, -11133, -10389, -9999, -10538, -9503, -4753, -131, 1747, 3617, 5347, 8214, 9642, 7949, 6472, 6328, 5071, 1595, -1440, -2886, -5531, -8047, -6107, -5531, -8290, -5822, -2581, -3193, -682, 2903, 3624, 3700, 5270, 6042, 5174, 3886, 2766, 2191, -227, -1854, -1237, -3608, -6158, -4480, -3508, -4154, -3210, -1521, -1049, -785, 1380, 3475, 3246, 2769, 3232, 2397, 2038, 2857, 364, -1640, -787, -1521, -3006, -2877, -3433, -3829, -1492, -39, -2078, -2085, 1632, 2025, 769, 2292, 2422, 746, 1337, 2668, 717, -702, 101, -1111, -1942, -1473, -1346, -1343, -1707, -657, -61, -999, -694, 902, 2110, 1352, -157, 786, 1471, 596, 551, -45, -107, -50, -655, -124, -430, -1734, -718, 86, -698, -510, -290, 376, 710, 283, 939, 545, -62, 383, 719, 778, 100, -14, -6, -507, -435, -54, -342, -428, 49, 122, 91, -72, 15, 679, 39, -297, 781, 672, -63, 165, 158, -439, 274, 869, -160, -174, 86, -211, 90, 326, -68, -534, -247, 592, 206, -803, -141, 555, 131, 205, 74, -391, 217, 319, -202, -22, 92, 86, 57, -92, -69, -180, -137, 114, -138, -342, 300, 390, 119, 634, 334, -10, 616, 511, 449, 611, 94, 16, 396, 344, 87, 7, -17, 57, -32, -388, -327, 126, 420, 636, 468, -82, -1207, -1830, -657};