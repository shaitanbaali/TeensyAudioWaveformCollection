/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1721 256 samples */
 
const int16_t AKWF_1721_256_DATA [256] = 
{8577, 21088, 26014, 28685, 30272, 31274, 31921, 32333, 32582, 32715, 32766, 32755, 32701, 32612, 32498, 32365, 32219, 32059, 31893, 31720, 31539, 31355, 31167, 30975, 30781, 30582, 30382, 30178, 29970, 29760, 29546, 29329, 29109, 28888, 28661, 28429, 28195, 27957, 27713, 27466, 27214, 26958, 26697, 26430, 26157, 25880, 25595, 25305, 25009, 24706, 24397, 24081, 23757, 23425, 23087, 22739, 22384, 22021, 21647, 21267, 20876, 20476, 20068, 19648, 19217, 18777, 18326, 17865, 17392, 16907, 16411, 15903, 15385, 14851, 14309, 13752, 13180, 12599, 12005, 11395, 10775, 10139, 9490, 8830, 8154, 7466, 6764, 6046, 5320, 4578, 3823, 3054, 2273, 1478, 672, -146, -979, -1823, -2678, -3545, -4423, -5308, -6205, -7113, -8034, -8959, -9890, -10832, -11781, -12738, -13701, -14667, -15639, -16620, -17603, -18583, -19571, -20559, -21551, -22544, -23534, -24510, -25545, -26237, -25775, -25190, -24635, -24081, -23526, -22979, -22437, -21895, -21364, -20840, -20320, -19808, -19305, -18809, -18323, -17846, -17376, -16920, -16473, -16034, -15609, -15193, -14788, -14397, -14015, -13644, -13287, -12941, -12606, -12286, -11975, -11677, -11392, -11118, -10857, -10608, -10370, -10145, -9932, -9730, -9540, -9362, -9194, -9038, -8894, -8760, -8637, -8525, -8424, -8333, -8251, -8179, -8118, -8065, -8023, -7989, -7965, -7950, -7943, -7943, -7953, -7970, -7996, -8028, -8067, -8115, -8169, -8230, -8297, -8371, -8451, -8537, -8629, -8727, -8831, -8939, -9052, -9170, -9294, -9423, -9555, -9691, -9834, -9979, -10127, -10280, -10437, -10597, -10760, -10929, -11097, -11271, -11446, -11625, -11806, -11990, -12176, -12366, -12556, -12749, -12946, -13142, -13340, -13542, -13744, -13949, -14154, -14362, -14569, -14780, -14991, -15203, -15417, -15631, -15847, -16064, -16282, -16500, -16719, -16939, -17159, -17380, -17599, -17821, -18045, -18268, -18482, -18638, -19435, -12476, -11650, -16662};