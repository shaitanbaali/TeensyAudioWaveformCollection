/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1755 256 samples */
 
const int16_t AKWF_1755_256_DATA [256] = 
{1341, 3439, 5121, 6387, 7494, 8776, 10447, 12548, 14975, 17505, 19896, 22004, 23789, 25296, 26625, 27843, 28970, 29988, 30853, 31535, 32036, 32378, 32595, 32719, 32767, 32743, 32644, 32471, 32232, 31938, 31605, 31247, 30873, 30485, 30087, 29678, 29264, 28849, 28435, 28030, 27634, 27249, 26878, 26517, 26170, 25839, 25520, 25215, 24922, 24630, 24329, 24005, 23640, 23215, 22717, 22136, 21470, 20728, 19918, 19070, 18210, 17370, 16592, 15919, 15396, 15000, 14628, 14189, 13636, 12969, 12236, 11509, 10848, 10288, 9835, 9467, 9162, 8900, 8679, 8505, 8382, 8313, 8290, 8303, 8342, 8397, 8465, 8549, 8645, 8757, 8881, 9011, 9144, 9274, 9397, 9511, 9610, 9675, 9672, 9585, 9424, 9208, 8954, 8667, 8340, 7967, 7537, 7024, 6404, 5664, 4801, 3838, 2812, 1745, 664, -422, -1517, -2615, -3697, -4739, -5694, -6515, -7159, -7583, -7753, -7636, -7225, -6621, -5985, -5481, -5259, -5364, -5642, -5886, -5962, -5840, -5600, -5380, -5313, -5470, -5840, -6353, -6921, -7474, -7982, -8452, -8904, -9351, -9798, -10229, -10627, -10979, -11283, -11545, -11775, -11981, -12166, -12330, -12468, -12578, -12664, -12726, -12768, -12796, -12810, -12812, -12802, -12780, -12747, -12704, -12654, -12598, -12536, -12470, -12401, -12332, -12265, -12210, -12179, -12186, -12250, -12387, -12613, -12936, -13357, -13870, -14460, -15101, -15765, -16416, -17015, -17530, -17948, -18315, -18727, -19260, -19930, -20709, -21527, -22300, -22977, -23534, -23984, -24358, -24680, -24957, -25179, -25327, -25391, -25375, -25299, -25194, -25089, -25008, -24958, -24937, -24935, -24940, -24941, -24929, -24899, -24847, -24773, -24676, -24559, -24440, -24350, -24302, -24282, -24263, -24219, -24138, -24011, -23837, -23617, -23365, -23098, -22827, -22545, -22225, -21836, -21347, -20741, -20017, -19176, -18226, -17170, -15987, -14661, -13173, -11499, -9643, -7619, -5447, -3182, -840};