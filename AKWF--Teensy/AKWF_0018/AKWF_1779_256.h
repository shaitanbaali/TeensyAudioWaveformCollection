/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1779 256 samples */
 
const int16_t AKWF_1779_256_DATA [256] = 
{1692, 4024, 5942, 7599, 9049, 10327, 11470, 12489, 13414, 14253, 15018, 15720, 16367, 16962, 17516, 18028, 18504, 18950, 19366, 19757, 20122, 20465, 20785, 21089, 21372, 21640, 21893, 22130, 22354, 22565, 22763, 22951, 23126, 23290, 23445, 23591, 23728, 23856, 23973, 24084, 24187, 24282, 24369, 24448, 24521, 24587, 24647, 24700, 24745, 24785, 24818, 24845, 24867, 24882, 24891, 24894, 24927, 24730, 25494, 30024, 30685, 31002, 31260, 31453, 31608, 31742, 31853, 31952, 32038, 32115, 32184, 32244, 32301, 32351, 32397, 32439, 32476, 32511, 32543, 32571, 32598, 32622, 32644, 32662, 32680, 32695, 32710, 32722, 32732, 32741, 32749, 32755, 32760, 32765, 32768, 32767, 32767, 32768, 32767, 32765, 32762, 32755, 32751, 32744, 32737, 32728, 32718, 32709, 32697, 32686, 32674, 32661, 32647, 32633, 32617, 32600, 32584, 32565, 32546, 32527, 32508, 31754, 35763, 123, -26418, -20886, -19683, -18699, -18018, -17580, -17306, -17148, -17074, -17064, -17100, -17172, -17271, -17389, -17524, -17669, -17823, -17983, -18147, -18314, -18481, -18648, -18815, -18980, -19143, -19303, -19460, -19613, -19764, -19909, -20051, -20188, -20322, -20451, -20574, -20693, -20808, -20918, -21023, -21124, -21219, -21308, -21394, -21474, -21550, -21620, -21685, -21746, -21802, -21854, -21898, -21940, -21976, -22006, -22033, -22053, -22071, -22081, -22089, -22091, -22123, -21932, -22670, -27201, -28010, -28417, -28748, -29002, -29213, -29391, -29546, -29682, -29804, -29913, -30012, -30103, -30184, -30259, -30327, -30392, -30451, -30504, -30554, -30601, -30642, -30682, -30718, -30754, -30784, -30813, -30839, -30863, -30884, -30905, -30923, -30938, -30951, -30964, -30974, -30983, -30991, -30996, -31001, -31004, -31004, -31005, -31004, -31002, -30996, -30991, -30985, -30977, -30969, -30959, -30948, -30936, -30921, -30906, -30892, -30875, -30857, -30838, -30819, -30797, -30574, -31597, -24492, -21009, -15354, -8689, -4425, -982};