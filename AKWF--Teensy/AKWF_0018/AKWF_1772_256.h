/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1772 256 samples */
 
const int16_t AKWF_1772_256_DATA [256] = 
{269, 824, 883, 871, 875, 876, 877, 878, 878, 878, 879, 880, 880, 880, 880, 879, 881, 882, 882, 882, 882, 882, 882, 882, 882, 882, 882, 881, 879, 880, 880, 880, 880, 880, 880, 880, 880, 879, 878, 879, 879, 879, 879, 879, 878, 877, 878, 878, 878, 878, 878, 876, 875, 876, 876, 876, 876, 875, 874, 875, 875, 875, 875, 874, 873, 872, 873, 873, 873, 873, 872, 871, 872, 872, 872, 872, 872, 870, 871, 1209, 1683, 2133, 2587, 3041, 3496, 3950, 4404, 4858, 5312, 5765, 6220, 6673, 7127, 7581, 8034, 8487, 8940, 9393, 9846, 10300, 10753, 11206, 11658, 12110, 12562, 13016, 13467, 13920, 14371, 14823, 15275, 15726, 16177, 16630, 17081, 17531, 17982, 18433, 18871, 19284, 20150, 4978, 13435, 15478, 14587, 14306, 13955, 13604, 13252, 12902, 12551, 12200, 11850, 11499, 11148, 10798, 10447, 10095, 9746, 9395, 9044, 8695, 8344, 7994, 7644, 7294, 6944, 6594, 6245, 5894, 5546, 5196, 4846, 4497, 4148, 3799, 3450, 3101, 2752, 2404, 2054, 1706, 1360, 1002, 694, 662, 668, 665, 664, 664, 662, 661, 661, 660, 661, 659, 658, 659, 658, 657, 658, 658, 657, 656, 657, 657, 656, 655, 655, 655, 655, 655, 654, 653, 654, 654, 654, 654, 653, 648, 309, 2272, -24582, -33927, -31132, -30915, -30305, -29694, -29084, -28472, -27860, -27249, -26636, -26024, -25413, -24800, -24187, -23575, -22960, -22348, -21736, -21122, -20510, -19897, -19284, -18671, -18058, -17445, -16833, -16221, -15608, -14997, -14385, -13771, -13160, -12548, -11935, -11325, -10713, -10101, -9491, -8879, -8267, -7658, -7046, -6436, -5827, -5216, -4607, -3997, -3385, -2776, -2168, -1558, -951, -332};