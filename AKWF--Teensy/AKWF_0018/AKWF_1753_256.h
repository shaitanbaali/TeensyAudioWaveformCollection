/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1753 256 samples */
 
const int16_t AKWF_1753_256_DATA [256] = 
{5546, 6133, 9183, 8657, 8598, 8817, 8975, 8978, 8919, 8889, 8900, 8928, 8949, 8956, 8954, 8950, 8945, 8940, 8934, 8928, 8922, 8915, 8908, 8903, 8896, 8889, 8883, 8877, 8870, 8864, 8858, 8852, 8846, 8840, 8835, 8817, 8885, 7966, 15798, 16779, 15341, 14384, 14706, 15472, 16009, 16255, 16339, 16335, 16282, 16198, 16106, 16037, 15984, 15945, 15924, 15910, 15887, 15864, 15845, 15821, 15800, 15781, 15762, 15744, 15727, 15717, 15704, 15695, 15686, 15684, 15677, 15672, 15672, 15665, 15660, 15658, 15609, 15851, 14379, 13292, 13360, 13104, 13051, 13047, 13073, 13108, 13132, 13141, 13134, 13117, 13095, 13074, 13057, 13042, 13028, 13018, 13008, 12997, 12985, 12975, 12964, 12953, 12943, 12933, 12922, 12912, 12903, 12893, 12883, 12873, 12919, 12622, 14015, 17742, 17241, 16616, 16351, 16298, 16378, 16501, 16605, 16664, 16676, 16656, 16618, 16576, 16542, 16515, 16493, 16478, 16466, 16452, 16435, 16422, 16408, 16395, 16381, 16366, 16353, 16341, 16328, 16316, 16305, 16295, 15949, 17628, 10304, -28891, -31234, -26269, -24551, -23355, -23433, -24685, -26142, -27163, -27626, -27664, -27459, -27162, -26883, -26667, -26516, -26429, -26375, -26337, -26302, -26264, -26227, -26186, -26146, -26108, -26078, -26053, -26031, -26015, -25999, -25987, -25981, -25976, -25972, -25971, -25971, -25972, -25973, -25883, -26385, -24122, -16067, -16867, -18269, -18832, -18946, -18806, -18586, -18402, -18292, -18257, -18278, -18325, -18386, -18433, -18464, -18482, -18491, -18494, -18496, -18500, -18497, -18496, -18493, -18487, -18480, -18472, -18461, -18449, -18435, -18424, -18406, -18321, -18629, -17323, -7138, -6657, -8515, -9101, -9158, -8919, -8598, -8333, -8174, -8111, -8120, -8168, -8225, -8267, -8289, -8299, -8300, -8287, -8277, -8277, -8268, -8262, -8258, -8256, -8253, -8244, -8235, -8226, -8216, -8208, -8195, -8184, -8174, -8162};