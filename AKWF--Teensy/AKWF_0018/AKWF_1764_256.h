/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1764 256 samples */
 
const int16_t AKWF_1764_256_DATA [256] = 
{323, 1253, 2065, 2799, 3464, 4061, 4597, 5070, 5487, 5845, 6148, 6400, 6606, 6768, 6895, 6993, 7070, 7132, 7186, 7241, 7302, 7374, 7461, 7566, 7693, 7840, 8007, 8193, 8394, 8608, 8831, 9057, 9283, 9503, 9716, 9918, 10104, 10274, 10428, 10564, 10683, 10788, 10879, 10961, 11034, 11104, 11173, 11245, 11321, 11405, 11499, 11603, 11719, 11847, 11986, 12136, 12294, 12459, 12629, 12802, 12974, 13145, 13312, 13473, 13627, 13773, 13911, 14040, 14160, 14273, 14380, 14481, 14580, 14676, 14771, 14868, 14968, 15071, 15180, 15295, 15414, 15540, 15673, 15810, 15952, 16098, 16246, 16395, 16545, 16693, 16840, 16983, 17124, 17260, 17391, 17519, 17643, 17761, 17877, 17991, 18103, 18214, 18324, 18435, 18547, 18662, 18780, 18900, 19023, 19149, 19278, 19410, 19544, 19680, 19818, 19955, 20094, 20232, 20368, 20503, 20637, 20767, 20897, 21024, 21123, 21205, 21829, 462, -5212, -5486, -7854, -10567, -13661, -16969, -20311, -23503, -26398, -28859, -30772, -32068, -32703, -32670, -31996, -30737, -28980, -26823, -24389, -21809, -19203, -16699, -14416, -12438, -10852, -9710, -9039, -8846, -9111, -9794, -10834, -12158, -13682, -15310, -16954, -18528, -19946, -21140, -22058, -22656, -22918, -22838, -22431, -21725, -20762, -19600, -18292, -16907, -15515, -14172, -12940, -11870, -10995, -10347, -9943, -9782, -9855, -10142, -10611, -11225, -11941, -12712, -13490, -14230, -14892, -15439, -15844, -16087, -16157, -16052, -15780, -15355, -14799, -14138, -13407, -12633, -11855, -11105, -10410, -9795, -9285, -8887, -8614, -8465, -8435, -8515, -8687, -8934, -9231, -9556, -9884, -10193, -10460, -10667, -10801, -10851, -10813, -10683, -10466, -10170, -9805, -9385, -8925, -8444, -7957, -7479, -7027, -6613, -6246, -5932, -5676, -5475, -5329, -5227, -5161, -5119, -5087, -5050, -4991, -4894, -4742, -4519, -4207, -3791, -3252, -2572, -1728, -681};