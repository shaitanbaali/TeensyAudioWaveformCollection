/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1750 256 samples */
 
const int16_t AKWF_1750_256_DATA [256] = 
{567, 1633, 2626, 3596, 4527, 5440, 6331, 7190, 8035, 8858, 9668, 10458, 11240, 12003, 12755, 13499, 14226, 14946, 15653, 16353, 17042, 17725, 18394, 19063, 19717, 20367, 21014, 21647, 22278, 22898, 23516, 24125, 24731, 25329, 25922, 26509, 27090, 27667, 28239, 28809, 29369, 29929, 30479, 31029, 31399, 32868, 29690, 5000, 5151, 6295, 7078, 7915, 8732, 9539, 10323, 11102, 11859, 12609, 13347, 14074, 14759, 15416, 16698, -6528, -12506, -11641, -12316, -12779, -13251, -13741, -14255, -14796, -15370, -15997, -16648, -17708, -18309, -12735, -9993, -8107, -6449, -4991, -3647, -2407, -1243, -140, 918, 1931, 2911, 3853, 4773, 5672, 6541, 7392, 8220, 9033, 9834, 10615, 11387, 12142, 12889, 13621, 14346, 15054, 15759, 16451, 17135, 17809, 18279, 19998, 16421, -12767, -14187, -14392, -15026, -15611, -16265, -16859, -18480, -16825, -11411, -9440, -7566, -5986, -4575, -3285, -1983, -2851, -3536, -3774, -4115, -4446, -4779, -5117, -5459, -5804, -6153, -6508, -6865, -7228, -7593, -7965, -8341, -8724, -9110, -9504, -9903, -10311, -10729, -11150, -11583, -12025, -12481, -12950, -13435, -13939, -14471, -15034, -15638, -16316, -16982, -18678, -14550, -10423, -8604, -6834, -5319, -3945, -2671, -1482, -363, 710, 1686, 2943, 2830, -4516, -5131, -5386, -5752, -6102, -6457, -6818, -7181, -7550, -7923, -8300, -8685, -9073, -9455, -9835, -10527, 977, 3516, 2595, 2449, 2179, 1909, 1636, 1359, 1081, 798, 514, 227, -62, -354, -650, -950, -1250, -1556, -1862, -2174, -2486, -2804, -3126, -3447, -3774, -4105, -4437, -4775, -5115, -5460, -5806, -6160, -6515, -6878, -7241, -7613, -7986, -8367, -8752, -9144, -9540, -9946, -10361, -10780, -11209, -11650, -12099, -12566, -13044, -13541, -14063, -14616, -15202, -15856, -16450, -18070, -16416, -11003, -9032, -7158, -5578, -4167, -2859, -1649, -489};