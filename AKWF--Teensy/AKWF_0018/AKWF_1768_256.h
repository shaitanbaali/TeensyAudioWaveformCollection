/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1768 256 samples */
 
const int16_t AKWF_1768_256_DATA [256] = 
{328, 1187, 2028, 2873, 3716, 4560, 5405, 6248, 7092, 7936, 8779, 9622, 10466, 11308, 12151, 12995, 13835, 14678, 15522, 16361, 17203, 18046, 18885, 19727, 20568, 21408, 22249, 23089, 23928, 24769, 25608, 26446, 27287, 28125, 28963, 29802, 30638, 31048, 34240, 6235, -14247, -13509, -13416, -13400, -13304, -13209, -13112, -13015, -12916, -12819, -12721, -12622, -12523, -12425, -12326, -12226, -12125, -12025, -11926, -11826, -11726, -11625, -11525, -11424, -11323, -11223, -11122, -11021, -10921, -10820, -10719, -10618, -10517, -10416, -10315, -10215, -10114, -10013, -9912, -9811, -9708, -9613, -9483, -9020, -8484, -7964, -7443, -6920, -6396, -5875, -5352, -4830, -4308, -3790, -3248, -2828, -2810, -2812, -2809, -2807, -2806, -2805, -2803, -2802, -2801, -2800, -2799, -2798, -2796, -2795, -2795, -2793, -2792, -2792, -2790, -2789, -2789, -2788, -2786, -2786, -2785, -2770, -2721, -3173, 11880, 15300, 13985, 13723, 13299, 12877, 12454, 12030, 11607, 11184, 10759, 10336, 9912, 9487, 9064, 8639, 8215, 7791, 7367, 6942, 6519, 6094, 5670, 5247, 4823, 4398, 3975, 3552, 3127, 2705, 2281, 1857, 1433, 1010, 587, 165, -258, -680, -1103, -1526, -1946, -2374, -2777, -2851, -2837, -2840, -2840, -2840, -2840, -2840, -2840, -2841, -2840, -2839, -2840, -2839, -2837, -2838, -2837, -2836, -2837, -2835, -2834, -2834, -2833, -2833, -2833, -2832, -2831, -2830, -2830, -2829, -2827, -2827, -2827, -2826, -2826, -2825, -2823, -2823, -2823, -2822, -2820, -2820, -2820, -2818, -2817, -2817, -2816, -2816, -2816, -2814, -2813, -2813, -2813, -2811, -2810, -2810, -2809, -2809, -2808, -2807, -2806, -2806, -2805, -2803, -2803, -2802, -2802, -2802, -2800, -2799, -2799, -2798, -2797, -2796, -2795, -2795, -2795, -2794, -2792, -2792, -2792, -2790, -2789, -2789, -2787, -2783, -2800, -2230, -1345, -495};