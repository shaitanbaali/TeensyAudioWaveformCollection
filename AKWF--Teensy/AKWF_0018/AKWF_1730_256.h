/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1730 256 samples */
 
const int16_t AKWF_1730_256_DATA [256] = 
{873, 2925, 4789, 6530, 8138, 9623, 10992, 12244, 13396, 14451, 15411, 16290, 17093, 17823, 18490, 19098, 19649, 20156, 20616, 21035, 21420, 21771, 22090, 22385, 22654, 22900, 23126, 23334, 23525, 23700, 23862, 24011, 24147, 24272, 24387, 24494, 24589, 24677, 24757, 24829, 24895, 24952, 25004, 25048, 25087, 25120, 25145, 25166, 25181, 25190, 25192, 25190, 25183, 25170, 25150, 25125, 25095, 25060, 25016, 24970, 24916, 24857, 24791, 24719, 24640, 24554, 24462, 24362, 24255, 24139, 24015, 23880, 23736, 23582, 23416, 23237, 23045, 22839, 22616, 22376, 22117, 21836, 21531, 21201, 20842, 20451, 20027, 19563, 19058, 18506, 17903, 17242, 16521, 15731, 14869, 13926, 12895, 11772, 10547, 9213, 7768, 6200, 4503, 2679, 720, -1380, -3614, -5989, -8497, -11126, -13883, -16749, -19702, -22743, -25832, -28994, -32101, -31205, -28845, -26797, -24752, -22785, -20901, -19123, -17460, -15915, -14502, -13218, -12065, -11048, -10161, -9395, -8753, -8225, -7802, -7482, -7254, -7111, -7045, -7050, -7118, -7241, -7415, -7631, -7886, -8173, -8486, -8823, -9179, -9548, -9928, -10319, -10712, -11107, -11503, -11896, -12285, -12668, -13043, -13409, -13764, -14108, -14439, -14755, -15057, -15345, -15617, -15869, -16106, -16326, -16527, -16709, -16873, -17018, -17142, -17249, -17334, -17400, -17445, -17471, -17478, -17463, -17428, -17374, -17299, -17205, -17091, -16958, -16805, -16633, -16442, -16233, -16005, -15760, -15498, -15219, -14924, -14613, -14288, -13951, -13599, -13234, -12860, -12477, -12085, -11687, -11285, -10879, -10472, -10067, -9667, -9273, -8889, -8520, -8169, -7836, -7531, -7257, -7018, -6820, -6670, -6574, -6538, -6568, -6675, -6862, -7138, -7514, -7993, -8583, -9291, -10121, -11078, -12168, -13387, -14738, -16218, -17818, -19536, -21362, -23275, -25271, -27312, -29429, -31489, -29544, -26141, -23047, -19960, -16956, -14035, -11225, -8537, -5974, -3551, -1223};