/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1797 256 samples */
 
const int16_t AKWF_1797_256_DATA [256] = 
{432, 1113, 1762, 2390, 2988, 3547, 4066, 4535, 4950, 5308, 5602, 5833, 6002, 6119, 6188, 6215, 6215, 6199, 6176, 6157, 6162, 6183, 6237, 6336, 6467, 6652, 6873, 7134, 7438, 7773, 8142, 8520, 8939, 9370, 9839, 10306, 10796, 11313, 11821, 12363, 12892, 13483, 14044, 14606, 15199, 15808, 16419, 17048, 17667, 18306, 18957, 19609, 20287, 20978, 21655, 22357, 23055, 23766, 24498, 25213, 25925, 26663, 27402, 28143, 28894, 29635, 30379, 31135, 31925, 32069, 31853, 31686, 31495, 31278, 31053, 30828, 30566, 30294, 30035, 29752, 29454, 29167, 28869, 28541, 28221, 27885, 27537, 27190, 26837, 26465, 26083, 25703, 25304, 24902, 24505, 24098, 23684, 23271, 22845, 22411, 21967, 21513, 21079, 20614, 20133, 19659, 19190, 18689, 18189, 17681, 17158, 16638, 16101, 15557, 15004, 14435, 13858, 13269, 12666, 12061, 11434, 10799, 10146, 9481, 8802, 8112, 7406, 6685, 5949, 5199, 4440, 3661, 2869, 2059, 1233, 398, -452, -1323, -2204, -3103, -4018, -4940, -5881, -6835, -7798, -8778, -9767, -10759, -11768, -12789, -13810, -14835, -15865, -16898, -17925, -18962, -19978, -20988, -21986, -22965, -23937, -24883, -25794, -26692, -27546, -28350, -29132, -29849, -30512, -31112, -31635, -32075, -32409, -32650, -32749, -32736, -32577, -32286, -31866, -31295, -30577, -29770, -28857, -27891, -26870, -25829, -24887, -23998, -23230, -22627, -22165, -21873, -21768, -21835, -22073, -22443, -23012, -23106, -22991, -23025, -23074, -23122, -23193, -23249, -23279, -23309, -23284, -23242, -23171, -23039, -22863, -22684, -22442, -22177, -21899, -21572, -21242, -20892, -20528, -20151, -19762, -19358, -18937, -18520, -18083, -17647, -17202, -16748, -16294, -15818, -15336, -14846, -14336, -13832, -13316, -12792, -12258, -11709, -11155, -10581, -10010, -9423, -8821, -8207, -7590, -6959, -6321, -5665, -5006, -4342, -3664, -2985, -2298, -1608, -923, -225};