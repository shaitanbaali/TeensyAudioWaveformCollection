/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1707 256 samples */
 
const int16_t AKWF_1707_256_DATA [256] = 
{3311, 10278, 13033, 15310, 16411, 16663, 16517, 16222, 15953, 15661, 15370, 15071, 14851, 14503, 14055, 13642, 13188, 12678, 12210, 11777, 11339, 10956, 10599, 10249, 9807, 9255, 8615, 7951, 7240, 5907, 13260, 25456, 29122, 31009, 32320, 32773, 32484, 31784, 30928, 30117, 29347, 28545, 27704, 26860, 26008, 25114, 24205, 23242, 22251, 21173, 20044, 19088, 18095, 17025, 15943, 14897, 13963, 12965, 11962, 10991, 10080, 9235, 8316, 7554, 6766, 5931, 5067, 4212, 3280, 2363, 1527, 818, 173, -341, -1566, 656, 12062, 18158, 19810, 21083, 21567, 21330, 20632, 19857, 18977, 18173, 17358, 16443, 15595, 14783, 13980, 13206, 12543, 11841, 11152, 10662, 10273, 9706, 9076, 8331, 7561, 6779, 5949, 5083, 4251, 3460, 2727, 1989, 1326, 677, 64, -544, -1203, -1933, -2720, -3516, -4380, -5299, -6214, -7153, -8044, -8986, -9972, -10975, -11941, -12845, -13687, -14504, -14998, -15477, -15998, -16510, -17007, -17502, -18012, -18565, -19139, -19747, -20421, -21105, -21663, -22296, -22999, -23665, -24274, -24878, -25430, -25896, -26337, -26741, -27095, -27400, -27719, -28044, -28448, -28753, -29433, -27889, -21385, -13553, -6561, -3630, -1932, -1038, -783, -949, -1276, -1662, -1943, -2195, -2361, -2598, -2847, -3127, -3448, -3853, -4288, -4768, -5317, -5831, -6325, -6940, -7589, -8263, -8918, -9587, -10304, -11047, -11711, -12370, -12976, -13585, -14096, -14565, -15077, -15700, -16346, -16989, -17642, -18301, -18815, -19286, -19866, -16858, -5990, 673, 2696, 4095, 4863, 4887, 4438, 3864, 3332, 2771, 2290, 1804, 1303, 865, 428, 24, -330, -701, -980, -1181, -1480, -1824, -2320, -2950, -3658, -4314, -4977, -5712, -6420, -7068, -7679, -8275, -8877, -9375, -9861, -10402, -10989, -11629, -12251, -12909, -13618, -14323, -15053, -15725, -16364, -16956, -17669, -18394, -19032, -19537, -21039, -13435};