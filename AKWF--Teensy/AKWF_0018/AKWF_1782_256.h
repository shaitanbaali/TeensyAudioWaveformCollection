/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1782 256 samples */
 
const int16_t AKWF_1782_256_DATA [256] = 
{2540, 6674, 10029, 12618, 14397, 15394, 15688, 15387, 14615, 13503, 12181, 10767, 9367, 8068, 6909, 5903, 5021, 4192, 3335, 2376, 1259, -44, -1530, -3188, -4965, -6791, -8585, -10228, -11592, -12552, -12988, -12819, -12011, -10580, -8574, -6068, -3173, 4, 3338, 6686, 9925, 12933, 15600, 17868, 19699, 21085, 22061, 22664, 22939, 22938, 22709, 22307, 21785, 21194, 20568, 19923, 19261, 18568, 17815, 16978, 16031, 14961, 13777, 12488, 11109, 9677, 8232, 6823, 5521, 4385, 3480, 2864, 2569, 2607, 2968, 3635, 4575, 5739, 7080, 8532, 10018, 11469, 12813, 13987, 14961, 15710, 16233, 16543, 16658, 16598, 16385, 16043, 15605, 15093, 14537, 13946, 13317, 12637, 11888, 11051, 10120, 9095, 7984, 6808, 5576, 4307, 3029, 1768, 562, -542, -1513, -2320, -2943, -3382, -3643, -3739, -3688, -3505, -3207, -2813, -2353, -1860, -1362, -885, -448, -54, 286, 572, 801, 966, 1057, 1070, 1005, 862, 652, 381, 53, -340, -796, -1319, -1901, -2535, -3212, -3913, -4629, -5353, -6073, -6781, -7469, -8120, -8718, -9250, -9706, -10077, -10360, -10544, -10623, -10587, -10434, -10163, -9778, -9296, -8740, -8139, -7520, -6914, -6342, -5825, -5375, -5009, -4737, -4564, -4489, -4501, -4583, -4719, -4891, -5087, -5297, -5512, -5728, -5938, -6134, -6307, -6452, -6561, -6637, -6680, -6690, -6666, -6605, -6509, -6380, -6219, -6031, -5812, -5564, -5278, -4948, -4569, -4128, -3623, -3054, -2416, -1714, -958, -166, 633, 1412, 2138, 2778, 3296, 3657, 3835, 3812, 3579, 3139, 2504, 1694, 743, -313, -1433, -2566, -3667, -4704, -5649, -6488, -7214, -7814, -8280, -8613, -8841, -9047, -9350, -9878, -10744, -12017, -13716, -15828, -18273, -20939, -23707, -26412, -28869, -30887, -32251, -32780, -32355, -30925, -28528, -25249, -21252, -16719, -11847, -6866, -1906};