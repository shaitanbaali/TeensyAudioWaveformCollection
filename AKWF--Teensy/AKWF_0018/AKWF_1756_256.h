/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1756 256 samples */
 
const int16_t AKWF_1756_256_DATA [256] = 
{1160, 2845, 4487, 6122, 7737, 9333, 10905, 12439, 13941, 15406, 16826, 18200, 19525, 20794, 22009, 23166, 24260, 25292, 26260, 27160, 27993, 28759, 29457, 30085, 30645, 31135, 31559, 31915, 32209, 32437, 32605, 32714, 32764, 32762, 32709, 32606, 32460, 32271, 32045, 31785, 31496, 31179, 30840, 30483, 30111, 29729, 29340, 28949, 28560, 28174, 27797, 27433, 27083, 26753, 26442, 26158, 25897, 25666, 25466, 25296, 25162, 25062, 24998, 24969, 24977, 25021, 25100, 25215, 25364, 25547, 25761, 26005, 26276, 26572, 26892, 27230, 27587, 27957, 28337, 28726, 29116, 29507, 29893, 30271, 30637, 30988, 31316, 31623, 31900, 32146, 32357, 32528, 32655, 32738, 32769, 32749, 32675, 32541, 32348, 32092, 31771, 31387, 30934, 30415, 29826, 29167, 28441, 27647, 26784, 25856, 24860, 23800, 22680, 21498, 20258, 18966, 17620, 16225, 14787, 13305, 11787, 10239, 8655, 7049, 5426, 3783, 2132, 476, -1184, -2839, -4485, -6122, -7738, -9334, -10905, -12440, -13942, -15407, -16826, -18200, -19525, -20794, -22009, -23166, -24260, -25292, -26261, -27160, -27994, -28759, -29457, -30085, -30645, -31135, -31559, -31915, -32209, -32437, -32605, -32714, -32764, -32762, -32709, -32606, -32460, -32271, -32045, -31785, -31496, -31179, -30841, -30483, -30111, -29730, -29340, -28950, -28560, -28174, -27798, -27434, -27084, -26753, -26442, -26158, -25897, -25666, -25466, -25296, -25162, -25062, -24999, -24969, -24977, -25022, -25100, -25215, -25365, -25548, -25761, -26005, -26276, -26572, -26892, -27230, -27588, -27957, -28337, -28726, -29116, -29507, -29893, -30271, -30637, -30988, -31316, -31623, -31900, -32146, -32357, -32528, -32655, -32738, -32769, -32749, -32675, -32541, -32348, -32092, -31771, -31387, -30934, -30415, -29826, -29167, -28441, -27647, -26784, -25856, -24860, -23800, -22680, -21498, -20258, -18967, -17620, -16225, -14787, -13306, -11788, -10240, -8655, -7050, -5427, -3787, -2140, -454};