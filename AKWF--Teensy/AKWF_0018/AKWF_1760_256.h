/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1760 256 samples */
 
const int16_t AKWF_1760_256_DATA [256] = 
{735, 2300, 4019, 5917, 7968, 10162, 12470, 14845, 17251, 19649, 21982, 24210, 26273, 28122, 29715, 31010, 31969, 32562, 32767, 32570, 31979, 30998, 29654, 27977, 26013, 23810, 21415, 18886, 16270, 13606, 10945, 8320, 5749, 3262, 880, -1387, -3531, -5553, -7450, -9206, -10832, -12330, -13701, -14938, -16032, -16970, -17753, -18361, -18769, -18968, -18949, -18701, -18213, -17490, -16552, -15405, -14080, -12606, -10994, -9293, -7539, -5758, -3976, -2239, -600, 916, 2329, 3603, 4687, 5584, 6324, 6899, 7310, 7563, 7679, 7685, 7584, 7385, 7099, 6739, 6314, 5813, 5239, 4594, 3885, 3110, 2253, 1313, 309, -750, -1869, -3037, -4237, -5451, -6648, -7812, -8935, -9987, -10944, -11788, -12518, -13129, -13615, -13973, -14212, -14350, -14387, -14338, -14212, -14023, -13789, -13504, -13180, -12812, -12409, -11968, -11473, -10914, -10300, -9617, -8863, -8032, -7132, -6159, -5119, -4004, -2820, -1555, -201, 1241, 2782, 4425, 6161, 7980, 9868, 11790, 13722, 15632, 17473, 19217, 20814, 22219, 23407, 24339, 24980, 25303, 25295, 24945, 24251, 23227, 21897, 20282, 18431, 16384, 14176, 11862, 9487, 7080, 4678, 2309, -18, -2271, -4449, -6553, -8573, -10514, -12375, -14160, -15875, -17525, -19103, -20607, -22030, -23362, -24590, -25687, -26632, -27412, -28000, -28379, -28540, -28478, -28194, -27696, -26993, -26109, -25060, -23878, -22587, -21205, -19771, -18306, -16829, -15370, -13939, -12547, -11207, -9914, -8666, -7460, -6283, -5115, -3950, -2778, -1588, -384, 848, 2099, 3354, 4602, 5829, 7019, 8152, 9202, 10145, 10978, 11673, 12220, 12610, 12846, 12920, 12841, 12620, 12271, 11806, 11248, 10612, 9911, 9158, 8372, 7555, 6717, 5859, 4986, 4108, 3214, 2311, 1411, 517, -365, -1222, -2042, -2805, -3490, -4085, -4568, -4917, -5113, -5152, -5028, -4729, -4256, -3608, -2785, -1793, -591};