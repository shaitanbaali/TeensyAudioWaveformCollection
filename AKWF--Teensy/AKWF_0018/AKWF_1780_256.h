/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1780 256 samples */
 
const int16_t AKWF_1780_256_DATA [256] = 
{32476, 32368, 32428, 32455, 32488, 32521, 32552, 32583, 32612, 32641, 32668, 32694, 32717, 32735, 32752, 32763, 32767, 32767, 32759, 32742, 32715, 32675, 32621, 32342, 33206, 29761, -23883, -29022, -27543, -27755, -27692, -27626, -27559, -27493, -27424, -27356, -27286, -27217, -27147, -27075, -27004, -26931, -26608, -28080, -21056, -11286, -16082, -15072, -15219, -15221, -15217, -15211, -15212, -15208, -15202, -15199, -15186, -15175, -15171, -15169, -15157, -15148, -15140, -15133, -15128, -15111, -15321, -14121, -24014, -29381, -28278, -28410, -28351, -28293, -28235, -28174, -28114, -28056, -27994, -27931, -27869, -27805, -27743, -27697, -27517, -27932, -29352, -29167, -29100, -29013, -28918, -28820, -28719, -28613, -28506, -28394, -28279, -28162, -28042, -27919, -27794, -27668, -27537, -27404, -27268, -27128, -26986, -26841, -26693, -26530, -26403, -26071, -24633, -23012, -21480, -19976, -18508, -17077, -15699, -14277, -13411, -13423, -13402, -13385, -13374, -13360, -13349, -13336, -13323, -13312, -13300, -13286, -13275, -13267, -13252, -13240, -13230, -13220, -13209, -13194, -13186, -13168, -13163, -13151, -13142, -13129, -13116, -13105, -13089, -13085, -13071, -13064, -13050, -13040, -13034, -13020, -13015, -13000, -12988, -12976, -12961, -12957, -12943, -12937, -12925, -12910, -12905, -12889, -12886, -12872, -12860, -12853, -12835, -12829, -12818, -12808, -12798, -12784, -12779, -12762, -12753, -12745, -12732, -12727, -12713, -12703, -12693, -12683, -12676, -12658, -12651, -12640, -12627, -12622, -12609, -12602, -12591, -12575, -12568, -12554, -12551, -12537, -12525, -12519, -12501, -12497, -12486, -12475, -12470, -12452, -12444, -12431, -12426, -12417, -12400, -12395, -12381, -12371, -12364, -12351, -12346, -12332, -12321, -12315, -12296, -12290, -12280, -12271, -12262, -12245, -12241, -12227, -12221, -12214, -12196, -12191, -12177, -12167, -12160, -12147, -12141, -12129, -12435, -10731, -21097, -30856, -29168, -29465, -29445, -29421, -29396, -29367, -29337, -29301, -29280, -29174};