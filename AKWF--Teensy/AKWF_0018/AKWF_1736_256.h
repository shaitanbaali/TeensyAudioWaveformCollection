/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1736 256 samples */
 
const int16_t AKWF_1736_256_DATA [256] = 
{807, 2991, 5049, 7119, 9198, 11265, 13328, 15384, 17419, 19459, 21488, 23494, 25494, 27461, 29400, 31424, 32732, 32739, 32734, 32732, 32727, 32722, 32716, 32710, 32704, 32698, 32691, 32684, 32677, 32670, 32662, 32655, 32647, 32639, 32631, 32624, 32616, 32608, 32600, 32592, 32583, 32575, 32566, 32559, 32550, 32542, 32534, 32525, 32517, 32507, 32499, 32491, 32482, 32474, 32466, 32456, 32448, 32440, 32430, 32422, 32414, 32405, 32396, 32388, 32379, 32370, 32362, 32353, 32344, 32337, 32328, 32318, 32310, 32302, 32292, 32283, 32275, 32267, 32258, 32250, 32241, 32231, 32223, 32215, 32205, 32197, 32190, 32180, 32171, 32164, 32154, 32145, 32137, 32129, 32120, 32112, 32103, 32093, 32086, 32077, 32067, 32060, 32052, 32042, 32034, 32026, 32016, 32008, 31999, 31990, 31968, 32016, 31644, 29823, 27832, 25864, 23877, 21869, 19850, 17812, 15764, 13724, 11658, 9587, 7517, 5431, 3359, 1281, -809, -2896, -4976, -7058, -9121, -11192, -13255, -15307, -17354, -19387, -21412, -23423, -25418, -27395, -29338, -31349, -32733, -32765, -32753, -32754, -32748, -32743, -32737, -32731, -32724, -32718, -32711, -32704, -32697, -32690, -32683, -32675, -32668, -32660, -32652, -32644, -32635, -32628, -32620, -32612, -32604, -32595, -32587, -32579, -32570, -32562, -32553, -32546, -32537, -32528, -32520, -32511, -32502, -32494, -32485, -32477, -32469, -32459, -32450, -32443, -32433, -32424, -32417, -32408, -32399, -32391, -32382, -32373, -32364, -32356, -32347, -32339, -32331, -32321, -32312, -32304, -32295, -32286, -32278, -32270, -32261, -32252, -32244, -32235, -32226, -32218, -32209, -32200, -32192, -32184, -32174, -32166, -32157, -32148, -32139, -32132, -32123, -32114, -32106, -32097, -32087, -32080, -32071, -32062, -32055, -32045, -32036, -32028, -32019, -32010, -31988, -32032, -31731, -29941, -27945, -25977, -23982, -21973, -19965, -17928, -15877, -13825, -11761, -9705, -7637, -5554, -3476, -1360};