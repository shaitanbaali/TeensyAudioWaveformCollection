/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1776 256 samples */
 
const int16_t AKWF_1776_256_DATA [256] = 
{23, 83, 145, 210, 279, 352, 430, 511, 595, 684, 776, 872, 972, 1076, 1184, 1295, 1411, 1530, 1653, 1780, 1912, 2046, 2185, 2327, 2474, 2624, 2779, 2936, 3098, 3264, 3433, 3607, 3780, 4014, 4336, 4663, 4998, 5344, 5698, 6060, 6431, 6810, 7197, 7590, 7991, 8398, 8814, 9235, 9662, 10094, 10533, 10975, 11422, 11872, 12328, 12788, 13251, 13716, 14183, 14654, 15126, 15600, 16076, 16553, 17031, 17509, 17986, 18465, 18945, 19421, 19899, 20373, 20847, 21322, 21792, 22261, 22729, 23193, 23654, 24114, 24570, 25023, 25473, 25919, 26363, 26802, 27236, 27668, 28095, 28518, 28937, 29350, 29759, 30185, 30330, 32161, 27611, 15976, 14605, 12801, 11131, 9566, 8099, 6743, 5496, 4361, 3344, 2439, 1646, 968, 396, -70, -436, -709, -891, -987, -1014, -1069, -1211, -1438, -1757, -2173, -2692, -3317, -4050, -4896, -5856, -6927, -8114, -9410, -10814, -12324, -13926, -15618, -17398, -19244, -21152, -23124, -25055, -27365, -29575, -28977, -28414, -27875, -27334, -26791, -26252, -25717, -25183, -24652, -24125, -23602, -23081, -22565, -22051, -21544, -21039, -20537, -20042, -19552, -19066, -18583, -18108, -17635, -17171, -16710, -16257, -15809, -15365, -14927, -14498, -14073, -13654, -13244, -12837, -12436, -12045, -11660, -11280, -10909, -10541, -10184, -9831, -9486, -9148, -8818, -8494, -8176, -7867, -7564, -7268, -6979, -6697, -6423, -6155, -5893, -5640, -5392, -5152, -4919, -4692, -4472, -4259, -4052, -3852, -3659, -3471, -3290, -3117, -2949, -2787, -2632, -2482, -2339, -2201, -2070, -1944, -1824, -1710, -1600, -1496, -1397, -1305, -1217, -1134, -1056, -984, -916, -854, -795, -742, -692, -648, -607, -571, -539, -511, -486, -466, -451, -433, -419, -415, -406, -393, -377, -359, -337, -310, -280, -248, -211, -171, -128, -81, -29};