/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1757 256 samples */
 
const int16_t AKWF_1757_256_DATA [256] = 
{438, 2045, 3591, 5110, 6593, 8042, 9451, 10812, 12127, 13395, 14607, 15766, 16869, 17909, 18891, 19811, 20665, 21454, 22177, 22831, 23420, 23938, 24387, 24768, 25079, 25322, 25496, 25604, 25645, 25618, 25527, 25373, 25157, 24882, 24548, 24155, 23710, 23211, 22663, 22067, 21426, 20741, 20018, 19255, 18458, 17632, 16774, 15890, 14986, 14060, 13117, 12162, 11194, 10216, 9237, 8252, 7269, 6291, 5316, 4351, 3398, 2458, 1535, 631, -253, -1114, -1948, -2757, -3537, -4286, -5003, -5687, -6336, -6949, -7524, -8062, -8564, -9024, -9445, -9827, -10169, -10470, -10730, -10952, -11134, -11276, -11380, -11446, -11476, -11471, -11429, -11353, -11247, -11108, -10939, -10743, -10518, -10271, -10000, -9706, -9393, -9062, -8716, -8355, -7981, -7598, -7205, -6806, -6461, -6134, -5794, -5452, -5104, -4753, -4569, -4427, -4241, -4029, -3790, -3520, -3221, -2893, -2538, -2155, -1746, -1308, -845, -360, 148, 679, 1232, 1805, 2394, 2999, 3620, 4253, 4896, 5549, 6208, 6872, 7540, 8205, 8870, 9531, 10185, 10832, 11466, 12085, 12690, 13276, 13840, 14383, 14900, 15389, 15850, 16277, 16670, 17027, 17345, 17625, 17863, 18058, 18208, 18311, 18367, 18373, 18329, 18235, 18089, 17889, 17639, 17332, 16972, 16562, 16094, 15576, 15004, 14378, 13704, 12978, 12201, 11378, 10508, 9590, 8630, 7630, 6588, 5511, 4397, 3250, 2075, 872, -358, -1605, -2872, -4159, -5454, -6758, -8070, -9380, -10690, -11997, -13292, -14576, -15845, -17092, -18317, -19517, -20683, -21817, -22913, -23965, -24977, -25939, -26848, -27705, -28504, -29241, -29918, -30527, -31068, -31538, -31934, -32257, -32503, -32668, -32755, -32761, -32683, -32522, -32277, -31948, -31534, -31034, -30450, -29782, -29029, -28196, -27275, -26295, -25064, -23599, -22116, -20598, -19043, -17462, -15863, -14239, -12603, -10962, -9311, -7661, -6016, -4377, -2754, -1115};