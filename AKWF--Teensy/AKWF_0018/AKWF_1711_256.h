/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1711 256 samples */
 
const int16_t AKWF_1711_256_DATA [256] = 
{658, 1381, 1342, 1595, 1955, 2428, 3532, 4442, 5001, 5912, 6685, 6648, 7040, 8430, 9071, 9755, 11717, 12856, 12930, 14245, 14929, 14180, 14522, 15508, 15193, 15579, 17155, 17864, 17736, 18810, 19102, 18024, 17358, 17897, 17378, 17527, 19608, 20986, 21195, 22640, 23353, 22442, 22632, 23394, 23272, 23948, 25638, 26547, 27359, 28801, 29598, 29591, 29975, 30109, 29894, 29707, 29510, 29486, 30155, 30816, 31653, 32567, 32625, 32256, 31475, 30368, 28969, 28296, 28375, 28160, 28167, 29105, 29098, 28273, 28709, 27780, 25904, 25629, 25390, 24142, 25022, 26241, 25792, 25907, 26444, 24921, 23834, 23982, 23113, 22123, 22963, 22699, 21912, 22081, 21813, 20752, 20523, 19709, 18438, 17856, 16971, 16055, 15766, 14803, 14215, 14230, 12914, 12128, 12058, 10463, 9573, 9398, 8191, 7637, 8159, 7334, 7186, 7564, 6812, 5952, 5357, 3949, 2822, 2556, 1685, 1503, 1884, 1427, 898, 530, -691, -1869, -2202, -3560, -4173, -3713, -4274, -4709, -4123, -5045, -5854, -5705, -7104, -8188, -8366, -9583, -10458, -10657, -11470, -11921, -12456, -13685, -14264, -15046, -16337, -16886, -17411, -18969, -19050, -19101, -20195, -20032, -19231, -20382, -21145, -21226, -22822, -24226, -23493, -23721, -24088, -22844, -22403, -23663, -23460, -23936, -25768, -26439, -26758, -27735, -27720, -26965, -26853, -26880, -27096, -27836, -29313, -30707, -31526, -32251, -32175, -31672, -31237, -30778, -30304, -30323, -30291, -30698, -31294, -31200, -31030, -31395, -30828, -29629, -29073, -28094, -26161, -25569, -25777, -24859, -25127, -26135, -25231, -23859, -23708, -22141, -20352, -20168, -20540, -19891, -20423, -21552, -21289, -20462, -20679, -20073, -18484, -18226, -18527, -17396, -17272, -18045, -17320, -16445, -16477, -15196, -13446, -12756, -12014, -10874, -10508, -10500, -9785, -8868, -8196, -7127, -6354, -5935, -5395, -5325, -5349, -4691, -3818, -2639, -1289, -313};