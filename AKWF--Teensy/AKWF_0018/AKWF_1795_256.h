/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1795 256 samples */
 
const int16_t AKWF_1795_256_DATA [256] = 
{79, 314, 571, 848, 1139, 1440, 1750, 2061, 2372, 2683, 2986, 3287, 3585, 3877, 4165, 4450, 4731, 5013, 5293, 5573, 5854, 6134, 6415, 6697, 6977, 7253, 7523, 7782, 8031, 8262, 8471, 8651, 8799, 8907, 8968, 8978, 8933, 8829, 8662, 8433, 8145, 7802, 7422, 7010, 6556, 6065, 5550, 5031, 4531, 4053, 3618, 3241, 2928, 2693, 2539, 2465, 2477, 2572, 2746, 2989, 3302, 3672, 4090, 4548, 5032, 5534, 6050, 6566, 7073, 7564, 8028, 8464, 8866, 9226, 9538, 9799, 10007, 10159, 10249, 10275, 10237, 10133, 9961, 9724, 9420, 9059, 8643, 8173, 7665, 7131, 6585, 6055, 5547, 5095, 4724, 4468, 4355, 4418, 4685, 5188, 5944, 6975, 8266, 9833, 11646, 13662, 15804, 17991, 20240, 22544, 24780, 26856, 28694, 30225, 31424, 32251, 32692, 32744, 32424, 31762, 30782, 29536, 28065, 26423, 24149, 25352, 9375, -22014, -16913, -15677, -14049, -12582, -11298, -10191, -9256, -8474, -7838, -7323, -6918, -6606, -6368, -6190, -6056, -5955, -5876, -5813, -5757, -5705, -5655, -5609, -5565, -5529, -5503, -5497, -5514, -5564, -5651, -5788, -5980, -6235, -6560, -6956, -7428, -7980, -8604, -9304, -10072, -10892, -11765, -12667, -13590, -14519, -15436, -16316, -17153, -17920, -18612, -19212, -19706, -20084, -20349, -20493, -20518, -20427, -20226, -19923, -19531, -19058, -18525, -17938, -17317, -16671, -16015, -15363, -14725, -14106, -13518, -12963, -12447, -11979, -11551, -11170, -10833, -10540, -10291, -10085, -9915, -9782, -9685, -9619, -9580, -9567, -9571, -9591, -9619, -9649, -9674, -9687, -9678, -9644, -9574, -9462, -9302, -9090, -8822, -8499, -8119, -7689, -7212, -6693, -6142, -5571, -4991, -4416, -3854, -3316, -2815, -2361, -1960, -1618, -1334, -1110, -941, -825, -752, -714, -700, -700, -702, -697, -674, -626, -549, -440, -298, -119};