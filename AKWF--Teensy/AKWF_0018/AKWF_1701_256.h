/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1701 256 samples */
 
const int16_t AKWF_1701_256_DATA [256] = 
{929, 2445, 4076, 5743, 7325, 8949, 10618, 12047, 13205, 14354, 15373, 16311, 17369, 18397, 19317, 20060, 20787, 21607, 22393, 23079, 23617, 24111, 24630, 25091, 25540, 25893, 26092, 26040, 25815, 25569, 25379, 25215, 25168, 25162, 25093, 24999, 24804, 24560, 24238, 23893, 23406, 22829, 22141, 21545, 20924, 20271, 19711, 19096, 18311, 17429, 16400, 15354, 14414, 13517, 12541, 11377, 10122, 8911, 7745, 6594, 5473, 4409, 3288, 1915, 549, -742, -1890, -3010, -4100, -5247, -6374, -7378, -8324, -9211, -10081, -10743, -11179, -11590, -11941, -12294, -12546, -12793, -13032, -13214, -13276, -13243, -13128, -12841, -12327, -11845, -11244, -10708, -10287, -9832, -9349, -8866, -8537, -8334, -8069, -7775, -7470, -6988, -6505, -6320, -6118, -6015, -5992, -5722, -5125, -4325, -3504, -2650, -1780, -908, -52, 576, 1161, 1968, 2911, 3793, 4611, 5335, 6038, 6708, 7318, 7921, 8644, 9520, 10494, 11536, 12589, 13544, 14439, 15517, 16667, 17741, 18705, 19510, 20203, 20702, 21102, 21446, 21719, 21885, 21973, 22156, 22410, 22566, 22498, 22265, 22012, 21851, 21863, 21784, 21404, 20811, 20113, 19298, 18572, 17869, 17174, 16569, 16068, 15399, 14604, 13746, 12831, 12087, 11214, 10075, 8701, 7368, 6229, 5148, 3971, 2777, 1371, -83, -1534, -2925, -4193, -5395, -6735, -8159, -9581, -11099, -12661, -14143, -15620, -16952, -18125, -19290, -20630, -21836, -22836, -23924, -25005, -25921, -26846, -27791, -28726, -29629, -30410, -31058, -31409, -31608, -31737, -31889, -32092, -32327, -32519, -32671, -32767, -32673, -32383, -31929, -31385, -30809, -30223, -29713, -29173, -28549, -27876, -27222, -26652, -26034, -25411, -24898, -24339, -23630, -22870, -22197, -21680, -21352, -20995, -20542, -19991, -19227, -18254, -17202, -16070, -14994, -14119, -13219, -12303, -11324, -10216, -9119, -8008, -6863, -5767, -4657, -3620, -2531, -1467, -371};