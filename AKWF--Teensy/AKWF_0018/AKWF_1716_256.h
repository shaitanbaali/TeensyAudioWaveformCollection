/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1716 256 samples */
 
const int16_t AKWF_1716_256_DATA [256] = 
{927, 3657, 6385, 9126, 11825, 14419, 16849, 19038, 20954, 22555, 23828, 24773, 25401, 25722, 25768, 25569, 25165, 24590, 23884, 23073, 22179, 21242, 20286, 19332, 18407, 17547, 16787, 16144, 15648, 15309, 15144, 15153, 15320, 15637, 16056, 16514, 16949, 17292, 17492, 17506, 17295, 16834, 16126, 15178, 14020, 12697, 11244, 9716, 8156, 6592, 5055, 3576, 2152, 807, -446, -1605, -2651, -3587, -4418, -5148, -5772, -6292, -6710, -7027, -7250, -7391, -7464, -7475, -7437, -7365, -7280, -7199, -7132, -7097, -7105, -7154, -7241, -7367, -7516, -7683, -7857, -8042, -8230, -8423, -8624, -8831, -9050, -9288, -9552, -9841, -10150, -10467, -10770, -11055, -11304, -11505, -11653, -11730, -11742, -11694, -11596, -11453, -11276, -11070, -10848, -10626, -10414, -10218, -10035, -9862, -9697, -9528, -9346, -9132, -8880, -8576, -8218, -7817, -7375, -6903, -6404, -5881, -5347, -4802, -4254, -3700, -3126, -2535, -1914, -1266, -580, 134, 867, 1618, 2365, 3098, 3804, 4477, 5103, 5676, 6188, 6630, 7008, 7323, 7579, 7774, 7907, 7976, 7984, 7931, 7829, 7679, 7481, 7234, 6950, 6641, 6319, 6020, 5780, 5642, 5646, 5820, 6202, 6801, 7605, 8600, 9759, 11030, 12352, 13664, 14879, 15951, 16846, 17527, 17977, 18197, 18182, 17939, 17490, 16867, 16090, 15187, 14179, 13085, 11940, 10761, 9566, 8387, 7259, 6217, 5294, 4515, 3901, 3483, 3266, 3250, 3421, 3739, 4157, 4608, 5029, 5375, 5591, 5628, 5457, 5056, 4432, 3596, 2572, 1377, 50, -1378, -2886, -4440, -6021, -7633, -9262, -10901, -12544, -14174, -15786, -17395, -18989, -20569, -22117, -23619, -25072, -26462, -27790, -29032, -30141, -31071, -31807, -32339, -32663, -32770, -32645, -32288, -31709, -30915, -29933, -28766, -27432, -25956, -24349, -22633, -20845, -18989, -17078, -15116, -13085, -10987, -8813, -6536, -4157, -1610};