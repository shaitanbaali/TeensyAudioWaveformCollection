/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1739 256 samples */
 
const int16_t AKWF_1739_256_DATA [256] = 
{836, 4234, 7415, 10436, 13783, 17537, 21478, 25141, 28065, 29999, 31010, 31416, 31630, 31944, 32385, 32736, 32651, 31854, 30278, 28120, 25715, 23386, 21334, 19512, 17732, 15727, 13355, 10653, 7821, 5134, 2806, 897, -676, -2101, -3561, -5123, -6742, -8250, -9474, -10301, -10746, -10927, -11004, -11102, -11257, -11405, -11433, -11236, -10781, -10113, -9344, -8595, -7938, -7368, -6838, -6258, -5573, -4785, -3938, -3118, -2399, -1811, -1337, -922, -502, -53, 421, 882, 1267, 1547, 1714, 1797, 1843, 1889, 1957, 2031, 2080, 2075, 1998, 1857, 1684, 1506, 1350, 1225, 1113, 991, 844, 665, 467, 270, 92, -50, -161, -257, -349, -451, -564, -675, -773, -846, -889, -911, -921, -931, -945, -963, -979, -982, -968, -939, -897, -854, -815, -784, -757, -729, -696, -654, -605, -556, -510, -470, -441, -416, -392, -363, -334, -303, -274, -250, -234, -223, -215, -209, -200, -190, -181, -173, -169, -170, -176, -180, -184, -187, -189, -190, -192, -197, -203, -210, -216, -222, -224, -226, -227, -230, -233, -237, -241, -244, -243, -244, -242, -240, -239, -237, -238, -237, -233, -231, -228, -225, -221, -218, -215, -212, -208, -206, -201, -196, -193, -189, -184, -183, -180, -178, -174, -171, -168, -165, -161, -160, -157, -155, -154, -150, -148, -147, -144, -141, -140, -139, -138, -137, -135, -134, -132, -132, -129, -127, -126, -125, -124, -124, -122, -121, -120, -120, -117, -115, -114, -114, -112, -111, -108, -107, -106, -105, -104, -103, -102, -110, -80, -402, -1999, -4431, -7174, -10088, -13288, -16866, -20678, -24332, -27298, -29101, -29628, -29131, -28104, -26978, -25927, -24756, -23032, -20358, -16602, -11969, -7032, -2251};