/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1715 256 samples */
 
const int16_t AKWF_1715_256_DATA [256] = 
{1307, 3674, 5965, 8227, 10455, 12642, 14765, 16806, 18769, 20632, 22370, 23973, 25426, 26723, 27873, 28860, 29682, 30352, 30881, 31256, 31467, 31496, 31331, 30967, 30403, 29642, 28705, 27609, 26370, 24987, 23461, 21807, 20031, 18166, 16248, 14290, 12327, 10354, 8361, 6347, 4317, 2301, 327, -1603, -3485, -5297, -7031, -8670, -10199, -11615, -12915, -14095, -15162, -16113, -16949, -17676, -18278, -18747, -19091, -19311, -19427, -19453, -19393, -19270, -19096, -18873, -18582, -18208, -17741, -17160, -16459, -15642, -14736, -13768, -12762, -11729, -10675, -9606, -8525, -7442, -6381, -5356, -4372, -3433, -2534, -1672, -843, -34, 756, 1529, 2290, 3032, 3758, 4464, 5141, 5803, 6454, 7079, 7665, 8207, 8710, 9171, 9575, 9909, 10177, 10380, 10513, 10555, 10504, 10372, 10163, 9871, 9503, 9057, 8536, 7948, 7295, 6591, 5847, 5080, 4305, 3538, 2786, 2060, 1350, 651, -35, -705, -1351, -1968, -2557, -3136, -3732, -4364, -5036, -5736, -6453, -7166, -7846, -8469, -9026, -9515, -9940, -10299, -10599, -10855, -11070, -11243, -11360, -11420, -11418, -11352, -11229, -11053, -10825, -10552, -10231, -9858, -9428, -8934, -8374, -7756, -7075, -6315, -5465, -4522, -3515, -2471, -1398, -300, 827, 1998, 3219, 4482, 5785, 7109, 8438, 9774, 11119, 12473, 13840, 15198, 16529, 17825, 19043, 20162, 21164, 22055, 22830, 23479, 23998, 24388, 24654, 24786, 24774, 24605, 24279, 23795, 23148, 22330, 21348, 20210, 18938, 17527, 15991, 14358, 12633, 10828, 8950, 6996, 4980, 2923, 820, -1296, -3411, -5522, -7615, -9691, -11761, -13810, -15824, -17789, -19674, -21469, -23164, -24745, -26216, -27574, -28802, -29888, -30819, -31579, -32157, -32543, -32741, -32755, -32588, -32244, -31717, -30999, -30086, -28973, -27674, -26215, -24608, -22875, -21032, -19076, -17022, -14880, -12655, -10375, -8052, -5708, -3366, -975};