/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1740 256 samples */
 
const int16_t AKWF_1740_256_DATA [256] = 
{254, 765, 1235, 1679, 2096, 2484, 2848, 3189, 3507, 3802, 4076, 4327, 4559, 4774, 4971, 5150, 5312, 5460, 5592, 5711, 5816, 5910, 5991, 6061, 6123, 6172, 6213, 6246, 6270, 6288, 6297, 6300, 6299, 6289, 6276, 6257, 6234, 6206, 6175, 6140, 6103, 6063, 6019, 5974, 5926, 5876, 5826, 5773, 5721, 5667, 5611, 5555, 5498, 5441, 5383, 5326, 5270, 5213, 5157, 5101, 5047, 4991, 4938, 4884, 4832, 4781, 4730, 4680, 4632, 4585, 4539, 4495, 4452, 4411, 4370, 4332, 4296, 4259, 4226, 4193, 4161, 4132, 4105, 4081, 4057, 4034, 4015, 3996, 3979, 3964, 3951, 3941, 3932, 3924, 3918, 3914, 3912, 3912, 3914, 3917, 3923, 3930, 3939, 3949, 3962, 3977, 3992, 4010, 4030, 4050, 4074, 4100, 4126, 4153, 4183, 4215, 4246, 4282, 4317, 4354, 4392, 4433, 4475, 4515, 4560, 4605, 4649, 4698, 4746, 4795, 4843, 4893, 4943, 4994, 5046, 5097, 5149, 5201, 5252, 5303, 5354, 5404, 5455, 5504, 5552, 5599, 5644, 5687, 5728, 5768, 5805, 5839, 5872, 5902, 5926, 5946, 5964, 5977, 5985, 5987, 5984, 5974, 5960, 5937, 5906, 5868, 5822, 5766, 5700, 5625, 5538, 5437, 5327, 5202, 5065, 4913, 4747, 4561, 4361, 4146, 3908, 3651, 3375, 3077, 2758, 2416, 2047, 1655, 1238, 794, 323, -176, -708, -1268, -1857, -2478, -3132, -3819, -4539, -5293, -6076, -6899, -7754, -8645, -9571, -10525, -11510, -12535, -13589, -14673, -15790, -16927, -18099, -19296, -20515, -21760, -23020, -24291, -25595, -26903, -28219, -29554, -30834, -32399, -32342, -30751, -29441, -28084, -26748, -25416, -24096, -22796, -21514, -20257, -19024, -17808, -16619, -15465, -14341, -13240, -12176, -11142, -10141, -9180, -8247, -7349, -6486, -5659, -4866, -4112, -3387, -2697, -2041, -1416, -827, -258};