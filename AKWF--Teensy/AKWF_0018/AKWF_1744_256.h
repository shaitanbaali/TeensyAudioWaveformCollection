/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1744 256 samples */
 
const int16_t AKWF_1744_256_DATA [256] = 
{6606, 15624, 23319, 29733, 31441, 31238, 31287, 31287, 31285, 31282, 31278, 31275, 31270, 31265, 31260, 31256, 31250, 31245, 31239, 31233, 31226, 31219, 31212, 31206, 31173, 31281, 30408, 28163, 25991, 23829, 21685, 19587, 17531, 15520, 13556, 11651, 9820, 8050, 6342, 4710, 3148, 1644, 228, -1114, -2400, -3608, -4748, -5811, -6810, -7744, -8606, -9409, -10153, -10833, -11447, -12019, -12527, -12983, -13386, -13749, -14060, -14322, -14551, -14737, -14884, -14990, -15065, -15109, -15116, -15098, -15055, -14985, -14887, -14773, -14638, -14479, -14304, -14116, -13908, -13685, -13455, -13214, -12957, -12695, -12426, -12148, -11863, -11578, -11285, -10985, -10682, -10388, -10082, -9777, -9477, -9172, -8870, -8571, -8272, -7973, -7678, -7386, -7101, -6818, -6534, -6264, -5991, -5723, -5464, -5208, -4952, -4706, -4469, -4234, -4002, -3780, -3564, -3350, -3149, -2952, -2753, -2563, -2379, -2202, -2029, -1861, -1704, -1547, -1397, -1253, -1115, -981, -849, -730, -611, -498, -390, -291, -189, -95, -11, 77, 158, 234, 305, 375, 443, 502, 557, 611, 663, 709, 753, 793, 832, 864, 898, 929, 950, 975, 997, 1020, 1032, 1049, 1061, 1070, 1076, 1085, 1091, 1090, 1093, 1096, 1096, 1087, 1083, 1083, 1071, 1062, 1053, 1041, 1032, 1021, 1012, 995, 979, 964, 949, 929, 913, 896, 872, 856, 839, 822, 796, 778, 761, 733, 713, 692, 671, 644, 627, 608, 585, 563, 539, 519, 491, 472, 451, 422, 402, 383, 365, 339, 318, 303, 276, 248, 232, 217, 184, 168, 155, 136, 102, 95, 79, 48, 22, 14, 2, -33, -34, -48, -69, -85, -87, -111, -167, -157, -177, -274, 5, -283, -29741, -33484, -32595, -32761, -32757, -32636, -33143, -29906, -16698, -4302};