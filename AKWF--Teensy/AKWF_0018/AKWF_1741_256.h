/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1741 256 samples */
 
const int16_t AKWF_1741_256_DATA [256] = 
{4279, 12087, 18797, 24385, 28639, 31407, 32681, 32529, 31109, 28591, 25219, 21225, 16853, 12368, 7960, 3779, 16, -3248, -5934, -7992, -9449, -10319, -10645, -10496, -9948, -9090, -7991, -6748, -5428, -4098, -2828, -1650, -598, 294, 1021, 1578, 1963, 2198, 2292, 2264, 2136, 1932, 1672, 1376, 1062, 751, 452, 176, -66, -274, -441, -569, -659, -712, -735, -730, -702, -657, -600, -534, -465, -396, -330, -269, -213, -166, -127, -97, -77, -60, -53, -51, -54, -61, -71, -82, -94, -106, -119, -129, -138, -146, -153, -157, -160, -162, -162, -161, -158, -156, -153, -148, -145, -140, -135, -133, -130, -125, -123, -121, -119, -117, -116, -115, -112, -112, -111, -109, -109, -110, -109, -107, -108, -107, -106, -105, -106, -104, -103, -104, -102, -102, -100, -97, -97, -95, -94, -94, -91, -89, -88, -87, -86, -85, -84, -84, -83, -82, -81, -82, -80, -79, -80, -80, -78, -77, -78, -76, -73, -74, -73, -71, -72, -71, -70, -70, -69, -67, -68, -67, -65, -66, -65, -63, -64, -62, -60, -59, -60, -59, -57, -58, -58, -57, -56, -55, -56, -55, -52, -51, -52, -51, -49, -50, -50, -49, -48, -47, -47, -48, -47, -45, -46, -45, -46, -44, -43, -44, -44, -43, -42, -41, -41, -42, -41, -39, -40, -39, -40, -39, -36, -35, -36, -35, -36, -35, -34, -33, -34, -33, -34, -32, -31, -32, -31, -31, -31, -32, -30, -29, -30, -29, -30, -29, -27, -28, -28, -27, -28, -27, -27, -49, 11, -525, -4272, -10712, -17770, -24025, -28567, -30788, -30503, -27802, -23036, -16686, -9102, -1583};