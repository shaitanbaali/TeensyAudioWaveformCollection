/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1705 256 samples */
 
const int16_t AKWF_1705_256_DATA [256] = 
{1612, 4621, 7554, 10276, 12727, 15092, 17564, 20128, 22581, 24860, 27111, 29260, 30960, 32087, 32659, 32733, 32252, 31264, 29965, 28488, 26952, 25451, 23872, 22003, 19830, 17589, 15369, 13050, 10562, 7934, 5191, 2451, -142, -2466, -4495, -6368, -8174, -9741, -10858, -11614, -12295, -12964, -13303, -12997, -12203, -11353, -10531, -9400, -7914, -6559, -5754, -5438, -5421, -5717, -6325, -6963, -7325, -7315, -6916, -6224, -5498, -5098, -5233, -5815, -6535, -7060, -7312, -7538, -7971, -8539, -9055, -9402, -9450, -9181, -8806, -8475, -8077, -7454, -6517, -5241, -3608, -1809, -125, 1363, 2767, 4186, 5595, 6913, 7956, 8672, 9233, 9775, 10166, 10242, 10075, 9729, 9095, 7939, 6183, 4081, 2090, 408, -1162, -2725, -4138, -5299, -6326, -7455, -8842, -10424, -12006, -13397, -14567, -15530, -16204, -16460, -16219, -15646, -15128, -15003, -15212, -15475, -15645, -15667, -15438, -14838, -13890, -12810, -11875, -11152, -10501, -9809, -9070, -8229, -7193, -6007, -4798, -3541, -2074, -325, 1563, 3399, 5079, 6562, 7800, 8790, 9702, 10763, 12015, 13383, 14707, 15782, 16495, 16901, 17010, 16683, 15767, 14242, 12334, 10316, 8386, 6490, 4447, 2257, 44, -2140, -4198, -6072, -7900, -9822, -11702, -13173, -14070, -14582, -14882, -14865, -14504, -14122, -14045, -14319, -14882, -15728, -16766, -17672, -18000, -17498, -16212, -14316, -12113, -10017, -8380, -7159, -6023, -4722, -3276, -1879, -754, 34, 587, 992, 1190, 1138, 913, 598, 140, -473, -1085, -1505, -1639, -1536, -1385, -1297, -1220, -1186, -1451, -2072, -2640, -2651, -2060, -1177, -262, 794, 2176, 3831, 5576, 7214, 8715, 10289, 12152, 14178, 16024, 17548, 18841, 19884, 20389, 20066, 18736, 16437, 13473, 10250, 6833, 3103, -698, -4019, -6485, -8114, -9219, -10141, -10939, -11409, -11318, -10620, -9231, -7087, -4318, -1259};