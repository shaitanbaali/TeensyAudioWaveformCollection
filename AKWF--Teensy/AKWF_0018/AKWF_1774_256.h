/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1774 256 samples */
 
const int16_t AKWF_1774_256_DATA [256] = 
{4405, 6949, 8458, 9720, 10798, 11760, 12636, 13443, 14197, 14908, 15578, 16218, 16828, 17412, 17974, 18516, 19036, 19540, 20027, 20499, 20957, 21400, 21831, 22251, 22657, 23050, 23436, 23810, 24173, 24527, 24871, 25205, 25532, 25848, 26155, 26454, 26745, 27026, 27301, 27567, 27825, 28075, 28316, 28552, 28779, 28997, 29210, 29415, 29612, 29803, 29986, 30162, 30331, 30493, 30649, 30797, 30940, 31076, 31206, 31328, 31444, 31556, 31659, 31758, 31852, 31939, 32021, 32098, 32168, 32235, 32296, 32352, 32405, 32452, 32495, 32534, 32570, 32602, 32630, 32655, 32676, 32695, 32710, 32725, 32736, 32745, 32752, 32756, 32760, 32764, 32766, 32767, 32759, 32798, 32486, 31734, 31033, 30336, 29647, 28961, 28283, 27608, 26934, 26263, 25593, 24921, 24250, 23573, 22894, 22213, 21522, 20825, 20122, 19407, 18679, 17940, 17180, 16402, 15600, 14767, 13899, 12988, 12013, 10961, 9799, 8432, 6947, 3922, -4194, -7011, -8432, -9720, -10799, -11761, -12637, -13444, -14198, -14908, -15579, -16219, -16829, -17412, -17974, -18516, -19037, -19541, -20028, -20499, -20957, -21400, -21831, -22251, -22657, -23051, -23436, -23810, -24173, -24528, -24871, -25205, -25532, -25848, -26155, -26455, -26745, -27027, -27301, -27567, -27825, -28075, -28317, -28552, -28779, -28997, -29210, -29415, -29612, -29803, -29986, -30162, -30331, -30493, -30649, -30798, -30940, -31076, -31206, -31328, -31444, -31556, -31659, -31758, -31852, -31939, -32021, -32098, -32168, -32235, -32296, -32352, -32405, -32452, -32495, -32534, -32570, -32602, -32630, -32655, -32676, -32695, -32710, -32725, -32736, -32745, -32752, -32756, -32760, -32764, -32766, -32767, -32759, -32798, -32486, -31734, -31033, -30336, -29647, -28961, -28283, -27608, -26934, -26264, -25593, -24921, -24250, -23574, -22894, -22213, -21522, -20826, -20123, -19407, -18679, -17940, -17181, -16403, -15600, -14768, -13900, -12988, -12014, -10962, -9799, -8460, -6883, -4150};