/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1732 256 samples */
 
const int16_t AKWF_1732_256_DATA [256] = 
{416, 1610, 2658, 3596, 4429, 5164, 5811, 6373, 6859, 7278, 7633, 7931, 8179, 8381, 8543, 8669, 8763, 8830, 8872, 8893, 8896, 8884, 8858, 8822, 8776, 8723, 8664, 8600, 8532, 8464, 8392, 8323, 8252, 8183, 8115, 8050, 7987, 7928, 7871, 7819, 7770, 7726, 7687, 7651, 7621, 7596, 7576, 7560, 7550, 7546, 7546, 7551, 7562, 7576, 7597, 7622, 7652, 7687, 7725, 7768, 7815, 7866, 7919, 7975, 8035, 8095, 8157, 8220, 8283, 8346, 8406, 8464, 8518, 8566, 8608, 8642, 8666, 8678, 8676, 8656, 8618, 8557, 8470, 8355, 8206, 8018, 7789, 7513, 7183, 6796, 6342, 5816, 5213, 4522, 3740, 2859, 1868, 765, -458, -1811, -3292, -4907, -6662, -8550, -10574, -12730, -15006, -17402, -19902, -22484, -25147, -27807, -30796, -32178, -29577, -26986, -24459, -21985, -19600, -17303, -15119, -13061, -11126, -9325, -7664, -6136, -4746, -3490, -2360, -1357, -468, 309, 982, 1561, 2052, 2463, 2799, 3069, 3278, 3433, 3541, 3606, 3633, 3628, 3594, 3536, 3455, 3357, 3245, 3120, 2988, 2845, 2698, 2546, 2392, 2238, 2086, 1935, 1784, 1640, 1498, 1362, 1232, 1109, 991, 882, 780, 686, 599, 523, 455, 396, 346, 305, 274, 252, 240, 238, 244, 261, 286, 320, 365, 420, 481, 553, 634, 722, 819, 924, 1036, 1155, 1281, 1412, 1549, 1690, 1835, 1985, 2135, 2287, 2439, 2589, 2737, 2878, 3014, 3142, 3258, 3361, 3448, 3516, 3561, 3579, 3567, 3520, 3434, 3304, 3121, 2884, 2582, 2213, 1767, 1236, 614, -103, -928, -1864, -2920, -4105, -5414, -6857, -8438, -10152, -12000, -13981, -16079, -18297, -20619, -23023, -25507, -27988, -30796, -32000, -29220, -26450, -23743, -21091, -18527, -16053, -13694, -11460, -9350, -7377, -5543, -3845, -2289, -844};