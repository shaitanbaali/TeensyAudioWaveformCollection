/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1790 256 samples */
 
const int16_t AKWF_1790_256_DATA [256] = 
{1907, 4386, 6711, 10024, 12053, 12467, 12978, 13986, 15161, 15566, 15905, 16314, 16764, 17199, 17627, 18055, 18424, 18728, 19030, 19284, 19528, 19751, 19934, 20113, 20295, 20442, 20745, 21448, 22273, 23095, 24010, 24738, 25106, 25367, 25443, 25537, 25594, 25452, 25332, 25271, 25233, 25160, 25031, 24898, 24823, 24738, 24603, 23869, 24364, 10147, -1680, -393, -316, -123, 90, 307, 521, 734, 943, 1178, 1422, 1662, 1894, 2159, 2457, 2749, 3012, 3181, 3338, 3496, 3651, 3801, 3950, 4098, 4244, 4388, 4529, 4665, 4799, 4941, 5102, 5257, 5408, 5556, 5696, 5818, 5936, 6051, 6164, 6290, 6402, 6624, 6775, 6890, 6957, 6969, 7029, 7095, 7212, 7333, 7114, 7261, 7789, 7310, 7268, 9560, 10212, 10584, 11029, 11405, 12045, 13030, 13428, 13837, 14224, 14598, 14963, 15379, 15882, 16377, 16864, 17357, 17814, 18190, 18564, 18939, 19269, 19802, 20716, 21078, 21430, 21664, 21825, 21989, 22188, 22345, 22373, 22418, 22690, 23032, 23355, 23679, 23991, 24247, 24182, 23737, 23704, 23622, 22925, 21490, 20001, 17605, 15409, 11534, -2366, -5004, -5067, -6562, -8557, -10416, -11367, -12051, -13972, -17131, -17864, -18467, -19084, -21227, -25415, -28524, -29403, -30659, -32048, -32494, -32653, -32749, -32648, -32552, -32440, -32391, -32265, -32161, -32016, -31867, -31731, -31572, -31389, -31208, -31026, -30852, -30622, -30360, -30144, -29923, -29704, -29486, -29260, -29021, -28784, -28546, -28294, -28037, -27784, -27539, -27257, -26577, -26114, -25736, -25344, -24955, -24569, -24184, -23811, -23466, -23125, -22783, -22447, -22102, -21696, -21286, -20881, -20479, -20137, -19818, -19495, -19176, -18862, -18471, -18043, -17624, -17202, -16803, -16431, -16059, -15695, -15321, -14922, -14521, -14142, -13694, -12569, -11915, -11412, -10888, -10282, -9658, -8893, -7787, -7195, -6680, -5540, -4093, -3424, -2977, -2108, -661};