/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1751 256 samples */
 
const int16_t AKWF_1751_256_DATA [256] = 
{2274, 8414, 13392, 17411, 20574, 23017, 24880, 26267, 27277, 27978, 28421, 28650, 28695, 28581, 28328, 27952, 27469, 26891, 26233, 25508, 24729, 23911, 23070, 22216, 21367, 20537, 19736, 18976, 18268, 17616, 17029, 16507, 16054, 15667, 15347, 15087, 14886, 14739, 14638, 14578, 14553, 14560, 14587, 14633, 14693, 14761, 14832, 14903, 14973, 15038, 15093, 15140, 15176, 15202, 15216, 15216, 15205, 15183, 15148, 15103, 15046, 14981, 14907, 14824, 14734, 14640, 14540, 14436, 14328, 14219, 14105, 13994, 13880, 13766, 13652, 13541, 13431, 13323, 13216, 13111, 13007, 12907, 12807, 12710, 12616, 12524, 12432, 12342, 12253, 12167, 12081, 11994, 11909, 11826, 11743, 11661, 11579, 11497, 11414, 11332, 11252, 11169, 11086, 11003, 10922, 10839, 10755, 10670, 10587, 10502, 10419, 10332, 10247, 10156, 10082, 9907, 8441, 5247, 524, -5549, -12530, -19750, -26789, -32155, -31104, -28137, -24720, -21097, -17767, -15040, -13012, -11630, -10779, -10311, -10099, -10040, -10060, -10109, -10155, -10183, -10187, -10167, -10130, -10084, -10038, -10004, -9987, -9995, -10032, -10100, -10198, -10324, -10473, -10641, -10820, -11006, -11192, -11371, -11540, -11695, -11833, -11952, -12051, -12132, -12192, -12236, -12263, -12276, -12276, -12266, -12248, -12223, -12195, -12163, -12130, -12098, -12066, -12036, -12008, -11984, -11964, -11947, -11935, -11927, -11923, -11922, -11926, -11934, -11945, -11960, -11978, -11997, -12021, -12046, -12073, -12101, -12131, -12162, -12194, -12226, -12259, -12292, -12324, -12356, -12389, -12420, -12452, -12483, -12512, -12542, -12571, -12599, -12627, -12655, -12681, -12707, -12733, -12757, -12783, -12807, -12831, -12856, -12880, -12903, -12929, -12952, -12975, -13000, -13024, -13048, -13073, -13097, -13123, -13148, -13173, -13198, -13224, -13250, -13275, -13301, -13328, -13357, -13379, -13447, -14043, -15422, -17597, -20522, -23914, -27247, -30177, -31456, -26390, -19308, -11936, -4419};