/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1766 256 samples */
 
const int16_t AKWF_1766_256_DATA [256] = 
{220, 911, 1416, 1778, 2031, 2198, 2302, 2356, 2374, 2367, 2344, 2310, 2273, 2239, 2210, 2189, 2181, 2188, 2211, 2253, 2314, 2395, 2499, 2626, 2775, 2947, 3143, 3362, 3604, 3869, 4157, 4467, 4797, 5149, 5519, 5910, 6317, 6741, 7182, 7635, 8104, 8584, 9074, 9573, 10083, 10596, 11117, 11640, 12165, 12693, 13220, 13743, 14266, 14784, 15294, 15800, 16297, 16783, 17261, 17727, 18180, 18619, 19046, 19456, 19851, 20229, 20589, 20932, 21258, 21564, 21851, 22120, 22369, 22599, 22809, 23001, 23173, 23325, 23459, 23576, 23675, 23755, 23818, 23865, 23896, 23913, 23914, 23903, 23878, 23841, 23794, 23737, 23671, 23597, 23514, 23426, 23334, 23237, 23136, 23034, 22932, 22829, 22726, 22625, 22528, 22435, 22345, 22262, 22184, 22115, 22054, 22001, 21957, 21924, 21901, 21889, 21890, 21903, 21927, 21965, 22016, 22081, 22159, 22251, 22357, 22475, 22050, 25196, 5007, -10438, -7482, -8038, -8123, -8273, -8491, -8768, -9107, -9503, -9951, -10452, -11002, -11594, -12229, -12902, -13608, -14345, -15110, -15896, -16701, -17522, -18352, -19191, -20034, -20874, -21710, -22539, -23356, -24157, -24940, -25699, -26435, -27142, -27817, -28458, -29063, -29629, -30153, -30634, -31069, -31459, -31799, -32089, -32330, -32518, -32655, -32738, -32768, -32747, -32673, -32544, -32365, -32135, -31854, -31525, -31148, -30726, -30258, -29746, -29195, -28604, -27977, -27315, -26619, -25896, -25146, -24368, -23571, -22753, -21919, -21073, -20213, -19345, -18474, -17600, -16724, -15854, -14987, -14127, -13281, -12445, -11625, -10824, -10040, -9280, -8545, -7833, -7148, -6494, -5869, -5275, -4716, -4188, -3696, -3238, -2815, -2430, -2079, -1765, -1487, -1245, -1037, -864, -724, -617, -540, -493, -475, -484, -515, -568, -641, -730, -830, -941, -1055, -1171, -1279, -1376, -1453, -1502, -1511, -1469, -1359, -1164, -858, -397};