/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1749 256 samples */
 
const int16_t AKWF_1749_256_DATA [256] = 
{318, 1174, 1896, 2510, 3009, 3390, 3648, 3778, 3776, 3653, 3432, 3138, 2796, 2434, 2072, 1723, 1396, 1109, 881, 721, 644, 664, 781, 983, 1253, 1574, 1931, 2298, 2657, 2987, 3283, 3555, 3834, 4160, 4574, 5103, 5761, 6553, 7466, 8470, 9547, 10691, 11902, 13199, 14598, 16099, 17694, 19327, 20933, 22465, 23885, 25163, 26285, 27229, 27988, 28571, 28981, 29219, 29284, 29175, 28894, 28440, 27815, 27005, 25991, 24766, 23310, 21600, 19641, 17437, 15022, 12459, 9785, 7049, 4307, 1607, -1013, -3773, -6777, -9895, -12996, -15970, -18724, -21203, -23401, -25301, -26918, -28294, -29455, -30426, -31233, -31877, -32353, -32651, -32768, -32703, -32469, -32099, -31624, -31077, -30482, -29848, -29177, -28464, -27700, -26883, -26018, -25097, -24124, -23103, -22032, -20911, -19740, -18512, -17227, -15873, -14420, -12872, -11248, -9566, -7848, -6118, -4401, -2734, -1142, 350, 1786, 3187, 4514, 5727, 6803, 7732, 8504, 9107, 9518, 9714, 9687, 9442, 8994, 8366, 7603, 6753, 5840, 4884, 3905, 2916, 1937, 985, 80, -773, -1559, -2237, -2762, -3108, -3268, -3245, -3072, -2775, -2384, -1908, -1352, -737, -75, 626, 1391, 2224, 3116, 4056, 5023, 6007, 6995, 7977, 8941, 9896, 10866, 11860, 12856, 13851, 14845, 15822, 16776, 17681, 18511, 19244, 19852, 20333, 20660, 20813, 20808, 20646, 20311, 19763, 18971, 17931, 16645, 15146, 13507, 11805, 10121, 8517, 7012, 5622, 4341, 3157, 2079, 1130, 336, -271, -684, -882, -873, -700, -442, -181, 23, 124, 93, -76, -377, -813, -1398, -2162, -3124, -4299, -5695, -7277, -8990, -10759, -12500, -14150, -15643, -16936, -18019, -18891, -19553, -20007, -20259, -20306, -20146, -19769, -19176, -18372, -17385, -16266, -15053, -13789, -12499, -11191, -9871, -8519, -7118, -5693, -4288, -2950, -1721, -608};