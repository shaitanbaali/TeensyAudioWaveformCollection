/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1799 256 samples */
 
const int16_t AKWF_1799_256_DATA [256] = 
{147, 548, 932, 1314, 1687, 2055, 2418, 2771, 3118, 3459, 3796, 4127, 4454, 4775, 5094, 5408, 5723, 6033, 6343, 6653, 6963, 7270, 7581, 7888, 8196, 8506, 8819, 9131, 9441, 9754, 10067, 10379, 10691, 11002, 11306, 11618, 11927, 12231, 12531, 12825, 13120, 13406, 13686, 13964, 14234, 14493, 14748, 14991, 15224, 15451, 15668, 15869, 16058, 16244, 16403, 16555, 16684, 16798, 16897, 16959, 17013, 17043, 17043, 17028, 16985, 16909, 16807, 16655, 16099, 15449, 14821, 14197, 13580, 12978, 12396, 11836, 11306, 10815, 10350, 9924, 9536, 9189, 8876, 8617, 8453, 8401, 8530, 8924, 9680, 10874, 12491, 14433, 16520, 18520, 20185, 21368, 21983, 22028, 21599, 20811, 19793, 18688, 17574, 16528, 15582, 14739, 13982, 13311, 12699, 12128, 11592, 11069, 10553, 10035, 9510, 8986, 8463, 7933, 7407, 6880, 6361, 5848, 5337, 4834, 4338, 3849, 3367, 2890, 2416, 1949, 1485, 1028, 574, 124, -323, -766, -1203, -1635, -2065, -2488, -2906, -3316, -3716, -4113, -4498, -4877, -5245, -5603, -5949, -6284, -6613, -6930, -7234, -7527, -7810, -8087, -8358, -8618, -8871, -9114, -9355, -9584, -9805, -10020, -10228, -10433, -10621, -10811, -10988, -11160, -11318, -11469, -11611, -11737, -11858, -11964, -12047, -12116, -12173, -12208, -12231, -12230, -12212, -12188, -12143, -12081, -11990, -11913, -11803, -11669, -11534, -11411, -11341, -11350, -11547, -12034, -12644, -13763, -15532, -17902, -20762, -23854, -26854, -29448, -31360, -32480, -32776, -32351, -31370, -30050, -28598, -27150, -25792, -24571, -23484, -22505, -21622, -20821, -20066, -19359, -18673, -17995, -17321, -16655, -15981, -15316, -14657, -14001, -13368, -12745, -12137, -11546, -10963, -10398, -9852, -9317, -8793, -8284, -7782, -7293, -6813, -6337, -5873, -5409, -4953, -4506, -4061, -3619, -3181, -2749, -2320, -1897, -1476, -1061, -652, -239};