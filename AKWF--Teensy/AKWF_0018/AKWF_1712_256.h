/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1712 256 samples */
 
const int16_t AKWF_1712_256_DATA [256] = 
{683, 2056, 3008, 4012, 5319, 6814, 8246, 9400, 10283, 11200, 12194, 13147, 14062, 15018, 16022, 16699, 16845, 16571, 16230, 16195, 16392, 16621, 17058, 17573, 18028, 18348, 18576, 18716, 18724, 18399, 17867, 17265, 16630, 15893, 14840, 13699, 12776, 11884, 10725, 9405, 8212, 7154, 6076, 5456, 5156, 4853, 4711, 4861, 5035, 5051, 5086, 5485, 6168, 6939, 7750, 8474, 9094, 9754, 10415, 11004, 11645, 12390, 13293, 14204, 15164, 16173, 17342, 18822, 20546, 22205, 23785, 25268, 26932, 28241, 28871, 29461, 30184, 30628, 30758, 30778, 30895, 31062, 31299, 31527, 31373, 31571, 31861, 31253, 30394, 29830, 29321, 28831, 28385, 28034, 27785, 27546, 27044, 26341, 25790, 25319, 24778, 24066, 23268, 22542, 21802, 20772, 19569, 18276, 17041, 15614, 13855, 12059, 10330, 8880, 7746, 6697, 5714, 4830, 3988, 3270, 2606, 1878, 1345, 1139, 1198, 1438, 1759, 2049, 2213, 2365, 2385, 2036, 1414, 728, 40, -509, -1072, -1905, -2902, -4111, -5482, -6897, -8578, -10294, -11830, -13111, -14333, -15629, -16854, -17776, -18556, -19299, -20157, -20980, -21658, -22417, -23296, -24042, -24516, -24844, -25304, -26051, -27184, -27936, -28584, -29793, -30630, -30849, -31090, -31345, -31622, -31886, -32019, -32072, -32253, -32644, -32659, -32194, -31907, -31544, -30692, -29415, -27946, -26482, -24996, -23474, -22084, -20830, -19745, -18747, -17733, -16688, -15709, -14961, -14320, -13560, -12658, -11610, -10457, -9438, -8496, -7528, -6726, -6261, -5943, -5457, -4843, -4605, -4505, -4571, -5085, -5848, -6572, -7428, -8570, -9783, -10690, -11516, -12504, -13569, -14593, -15416, -16088, -16673, -17138, -17446, -17695, -17813, -17810, -17505, -17015, -16798, -16936, -17227, -17679, -18201, -18745, -18986, -18656, -17913, -17174, -16750, -16415, -15880, -15058, -14019, -12870, -11780, -10747, -9795, -9025, -8108, -6693, -4863, -2906, -1007};