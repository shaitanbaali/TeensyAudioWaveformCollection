/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1752 256 samples */
 
const int16_t AKWF_1752_256_DATA [256] = 
{1051, 3853, 6504, 9031, 11393, 13582, 15591, 17399, 19024, 20480, 21782, 22951, 24003, 24941, 25785, 26545, 27226, 27843, 28402, 28907, 29367, 29787, 30169, 30519, 30839, 31130, 31397, 31639, 31859, 32055, 32228, 32378, 32504, 32605, 32681, 32733, 32760, 32768, 32760, 32737, 32700, 32647, 32577, 32489, 32385, 32267, 32133, 31985, 31824, 31647, 31455, 31249, 31026, 30788, 30533, 30256, 29956, 29628, 29276, 28896, 28487, 28042, 27556, 27021, 26428, 25767, 25021, 24174, 23213, 22116, 20863, 19446, 17839, 16016, 13970, 11673, 9117, 6336, 3355, 234, -2951, -6141, -9245, -12197, -14958, -17468, -19860, -20764, -20003, -19120, -18039, -16815, -15490, -14104, -12709, -11353, -10079, -8926, -7916, -7062, -6369, -5829, -5433, -5172, -5033, -5006, -5080, -5239, -5472, -5759, -6090, -6453, -6835, -7227, -7618, -7997, -8363, -8708, -9026, -9317, -9568, -9782, -9960, -10100, -10203, -10265, -10283, -10260, -10204, -10122, -10017, -9893, -9755, -9600, -9437, -9266, -9092, -8916, -8734, -8543, -8342, -8134, -7914, -7684, -7446, -7198, -6942, -6678, -6406, -6130, -5855, -5587, -5337, -5112, -4924, -4787, -4714, -4720, -4814, -5009, -5316, -5744, -6306, -7005, -7831, -8772, -9806, -10901, -12037, -13144, -14128, -14944, -15597, -16115, -16524, -16833, -17044, -17165, -17210, -17195, -17133, -17032, -16901, -16744, -16569, -16386, -16198, -16002, -15805, -15612, -15430, -15262, -15103, -14949, -14795, -14642, -14494, -14352, -14224, -14102, -13982, -13861, -13739, -13626, -13523, -13429, -13331, -13226, -13111, -12989, -12862, -12733, -12602, -12468, -12329, -12185, -12043, -11912, -11797, -11704, -11634, -11584, -11560, -11557, -11583, -11634, -11714, -11825, -11966, -12140, -12342, -12573, -12833, -13119, -13437, -13792, -14181, -14603, -15058, -15546, -16067, -16614, -17177, -17743, -18291, -18792, -19275, -19479, -18183, -16350, -14365, -12158, -9759, -7190, -4498, -1674};