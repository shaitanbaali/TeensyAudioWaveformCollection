/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1789 256 samples */
 
const int16_t AKWF_1789_256_DATA [256] = 
{-194, 3452, 7797, 10345, 19692, 26343, 28661, 30474, 31113, 31649, 32069, 32184, 32335, 32508, 32655, 32709, 32726, 32747, 32704, 32652, 32636, 32580, 32481, 32438, 32328, 32248, 32167, 32068, 32018, 31924, 31806, 31692, 31578, 31464, 31351, 31254, 31160, 31064, 30968, 30861, 30749, 30637, 30522, 30408, 30293, 30179, 30065, 29951, 29836, 29721, 29607, 29492, 29378, 29264, 29150, 29035, 28921, 28806, 28693, 28578, 28464, 28349, 28234, 28121, 28006, 27888, 27773, 27655, 27520, 27386, 27251, 27130, 27017, 26902, 26789, 26675, 26561, 26447, 26333, 26218, 26106, 25979, 25838, 25699, 25581, 25469, 25354, 25240, 25127, 25013, 24900, 24785, 24671, 24558, 24429, 24290, 24156, 24041, 23928, 23815, 23693, 23568, 23442, 23317, 23192, 23073, 22961, 22848, 22734, 22621, 22508, 22395, 22282, 22169, 22055, 21943, 21829, 21715, 21603, 21490, 21377, 21263, 21149, 21037, 20924, 20810, 20700, 20562, 20405, 20249, 20114, 19984, 19843, 19701, 19523, 19249, 18739, 18007, 18403, 6848, -17893, -17820, -18190, -18177, -18111, -18019, -17928, -17861, -17781, -17696, -17612, -17532, -17441, -17365, -17292, -17194, -17116, -17014, -16900, -16788, -16678, -16582, -16487, -16392, -16297, -16200, -16104, -16009, -15904, -15799, -15704, -15605, -15493, -15380, -15267, -15153, -15040, -14927, -14815, -14701, -14587, -14474, -14361, -14249, -14135, -14022, -13909, -13796, -13683, -13569, -13456, -13344, -13230, -13117, -13004, -12891, -12778, -12664, -12551, -12438, -12325, -12211, -12098, -11985, -11873, -11760, -11645, -11532, -11413, -11292, -11170, -11051, -10939, -10825, -10713, -10600, -10487, -10374, -10262, -10148, -10036, -9923, -9811, -9698, -9584, -9471, -9359, -9240, -9111, -8991, -8858, -8729, -8607, -8478, -8366, -8220, -8090, -7969, -7860, -7730, -7615, -7486, -7358, -7245, -7024, -7029, -5197, -3461, -2935, -2455, -2134, -1678, -1091, -492, -341, -129};