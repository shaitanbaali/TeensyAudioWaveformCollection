/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1754 256 samples */
 
const int16_t AKWF_1754_256_DATA [256] = 
{11660, 11657, 11652, 11647, 11642, 11636, 11630, 11624, 11617, 11610, 11603, 11595, 11587, 11580, 11572, 11564, 11556, 11547, 11539, 11530, 11522, 11512, 11504, 11495, 11486, 11478, 11468, 11459, 11450, 11440, 11432, 11422, 11413, 11404, 11394, 11385, 11376, 11366, 11357, 11347, 11338, 11329, 11319, 11310, 11301, 11291, 11281, 11273, 11263, 11253, 11244, 11235, 11225, 11216, 11207, 11197, 11188, 11179, 11169, 11160, 11151, 11140, 11132, 11122, 11113, 11104, 11094, 11085, 11076, 11066, 11057, 11048, 11038, 11029, 11020, 11010, 11002, 10992, 10983, 10974, 10964, 10955, 10946, 10936, 10927, 10918, 10909, 10900, 10890, 10882, 10872, 10863, 10854, 10845, 10835, 10827, 10817, 10808, 10799, 10789, 10781, 10771, 10763, 10753, 10744, 10736, 10726, 10717, 10708, 10699, 10690, 10681, 10672, 10663, 10654, 10645, 10636, 10627, 10617, 10609, 10600, 10591, 10582, 10573, 10565, 10555, 10547, 10537, 10528, 10520, 10511, 10502, 10492, 10484, 10475, 10466, 10457, 10448, 10439, 10430, 10422, 10408, 10257, 11110, -3221, -7906, -6861, -7050, -7051, -7051, -7049, -7049, -7046, -7043, -7038, -7032, -7029, -7023, -7018, -7010, -7003, -6996, -6989, -6982, -6975, -6967, -6960, -6951, -6943, -6935, -6927, -6916, -6906, -6899, -6890, -6882, -7285, -5027, -23854, -34510, -32332, -32705, -32681, -32657, -32632, -32607, -32580, -32554, -32526, -32499, -32471, -32442, -32414, -32386, -32356, -32326, -32297, -32266, -32237, -32207, -32177, -32145, -32115, -32084, -32053, -32022, -31992, -31961, -31929, -31899, -31868, -31434, -33606, -14287, -3878, -5976, -5569, -5547, -5526, -5509, -5490, -5472, -5455, -5440, -5425, -5413, -5398, -5382, -5371, -5358, -5347, -5335, -5322, -5309, -5299, -5288, -5277, -5268, -5258, -5245, -5235, -5226, -5216, -5207, -5198, -5188, -5179, -5169, -5158, -5150, -5141, -5133, -5122, -5113, -5105, -5096};