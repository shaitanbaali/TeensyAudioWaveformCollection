/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1743 256 samples */
 
const int16_t AKWF_1743_256_DATA [256] = 
{4162, 10036, 15404, 20222, 24352, 27697, 30208, 31870, 32678, 32672, 31913, 30469, 28435, 25919, 23009, 19841, 16506, 13084, 9688, 6407, 3297, 443, -2138, -4402, -6322, -7884, -9092, -9953, -10487, -10716, -10667, -10374, -9872, -9198, -8388, -7476, -6501, -5495, -4486, -3494, -2546, -1660, -849, -131, 498, 1030, 1463, 1798, 2040, 2195, 2269, 2272, 2214, 2102, 1947, 1757, 1545, 1317, 1078, 839, 608, 385, 177, -13, -178, -327, -452, -554, -633, -692, -729, -748, -750, -739, -715, -680, -639, -594, -542, -489, -435, -383, -334, -285, -241, -201, -167, -138, -114, -93, -78, -67, -59, -56, -55, -57, -63, -69, -77, -85, -94, -103, -112, -119, -128, -135, -141, -146, -152, -150, -151, -122, 1282, 4877, 9734, 15007, 20065, 24389, 27595, 29507, 29995, 29060, 26782, 23325, 18904, 13691, 7981, 2014, -3993, -9759, -15153, -20013, -24176, -27566, -30124, -31812, -32662, -32692, -31963, -30545, -28542, -26051, -23158, -19987, -16652, -13233, -9853, -6563, -3444, -561, 2031, 4305, 6233, 7813, 9042, 9919, 10467, 10706, 10670, 10387, 9893, 9224, 8422, 7518, 6545, 5537, 4523, 3537, 2585, 1694, 880, 153, -476, -1012, -1450, -1790, -2035, -2195, -2273, -2278, -2222, -2113, -1960, -1772, -1560, -1331, -1093, -855, -623, -400, -191, -1, 168, 316, 442, 545, 626, 685, 723, 742, 746, 735, 712, 679, 638, 592, 540, 486, 433, 380, 330, 283, 239, 199, 165, 134, 109, 89, 73, 62, 54, 51, 50, 52, 58, 64, 71, 80, 87, 97, 107, 115, 123, 130, 136, 143, 147, 147, 144, 139, -1167, -4695, -9522, -14763, -19843, -24211, -27489, -29461, -30012, -29141, -26924, -23514, -19112, -13929, -8303, -2141};