/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1767 256 samples */
 
const int16_t AKWF_1767_256_DATA [256] = 
{68, 198, 322, 445, 569, 691, 812, 930, 1049, 1167, 1282, 1398, 1513, 1625, 1737, 1849, 1960, 2070, 2178, 2287, 2393, 2500, 2606, 2711, 2816, 2920, 3023, 3126, 3228, 3329, 3429, 3530, 3629, 3728, 3827, 3925, 4023, 4120, 4216, 4312, 4408, 4503, 4598, 4693, 4787, 4881, 4974, 5068, 5160, 5253, 5344, 5436, 5527, 5619, 5710, 5800, 5890, 5980, 6070, 6160, 6248, 6338, 6427, 6515, 6604, 6691, 6779, 6868, 6954, 7041, 7129, 7216, 7303, 7389, 7476, 7563, 7649, 7734, 7820, 7906, 7992, 8077, 8162, 8248, 8332, 8417, 8502, 8587, 8671, 8756, 8840, 8925, 9009, 9093, 9177, 9261, 9345, 9429, 9512, 9596, 9680, 9762, 9846, 9930, 10012, 10095, 10179, 10263, 10345, 10428, 10511, 10594, 10677, 10759, 10841, 10924, 11007, 11089, 11172, 11253, 11336, 11419, 11501, 11583, 11666, 11747, 11830, 11911, 11994, 12076, 12158, 12239, 12322, 12404, 12486, 12567, 12649, 12731, 12812, 12894, 12976, 13058, 13140, 13221, 13303, 13384, 13466, 13547, 13629, 13711, 13792, 13873, 13775, 14718, 11298, -14033, -23589, -28808, -31652, -32699, -32600, -31813, -30662, -29370, -28081, -26874, -25790, -24842, -24024, -23318, -22710, -22175, -21694, -21253, -20836, -20431, -20035, -19640, -19242, -18843, -18438, -18031, -17622, -17211, -16801, -16393, -15987, -15585, -15189, -14797, -14411, -14033, -13661, -13296, -12938, -12586, -12243, -11907, -11576, -11255, -10938, -10628, -10325, -10028, -9737, -9452, -9172, -8897, -8629, -8365, -8108, -7855, -7607, -7362, -7124, -6889, -6658, -6434, -6211, -5994, -5780, -5569, -5363, -5160, -4960, -4765, -4572, -4381, -4195, -4012, -3831, -3653, -3479, -3306, -3137, -2969, -2804, -2642, -2482, -2324, -2168, -2014, -1863, -1714, -1566, -1420, -1277, -1135, -994, -856, -718, -583, -450, -318, -187, -56};