/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1726 256 samples */
 
const int16_t AKWF_1726_256_DATA [256] = 
{577, 1665, 2718, 3761, 4788, 5798, 6791, 7763, 8715, 9648, 10557, 11447, 12316, 13162, 13989, 14796, 15581, 16348, 17095, 17821, 18531, 19224, 19896, 20552, 21190, 21810, 22416, 23002, 23572, 24127, 24664, 25185, 25689, 26177, 26648, 27103, 27540, 27961, 28365, 28752, 29122, 29475, 29810, 30127, 30428, 30710, 30975, 31222, 31451, 31662, 31855, 32029, 32185, 32324, 32442, 32543, 32625, 32689, 32733, 32760, 32768, 32757, 32726, 32678, 32611, 32525, 32421, 32298, 32157, 31998, 31819, 31624, 31409, 31177, 30927, 30659, 30373, 30071, 29750, 29412, 29058, 28685, 28296, 27890, 27467, 27028, 26573, 26101, 25613, 25109, 24588, 24052, 23500, 22930, 22346, 21746, 21128, 20495, 19846, 19178, 18496, 17795, 17076, 16342, 15588, 14814, 14025, 13215, 12384, 11536, 10666, 9774, 8866, 7934, 6983, 6014, 5024, 4017, 2994, 1953, 901, -162, -1237, -2310, -3422, -4333, -4822, -5323, -5829, -6337, -6853, -7378, -7910, -8453, -9005, -9567, -10139, -10720, -11309, -11908, -12513, -13123, -13740, -14360, -14981, -15605, -16229, -16851, -17472, -18089, -18701, -19308, -19908, -20499, -21084, -21658, -22222, -22776, -23317, -23847, -24363, -24866, -25354, -25829, -26287, -26730, -27158, -27569, -27962, -28339, -28698, -29039, -29363, -29668, -29954, -30222, -30471, -30700, -30910, -31100, -31271, -31423, -31552, -31664, -31755, -31825, -31876, -31906, -31915, -31906, -31875, -31823, -31753, -31662, -31550, -31418, -31268, -31097, -30905, -30695, -30465, -30215, -29947, -29660, -29355, -29031, -28688, -28327, -27951, -27555, -27142, -26714, -26269, -25808, -25333, -24841, -24335, -23816, -23283, -22738, -22181, -21611, -21032, -20442, -19842, -19235, -18621, -17999, -17373, -16742, -16106, -15470, -14831, -14193, -13557, -12923, -12293, -11668, -11049, -10436, -9834, -9239, -8653, -8079, -7514, -6960, -6417, -5882, -5357, -4840, -4328, -3816, -3342, -2665, -1571, -470};