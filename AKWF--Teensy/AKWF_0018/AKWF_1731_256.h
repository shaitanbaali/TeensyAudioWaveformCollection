/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1731 256 samples */
 
const int16_t AKWF_1731_256_DATA [256] = 
{549, 2123, 3530, 4817, 5985, 7043, 7999, 8854, 9621, 10306, 10913, 11452, 11928, 12346, 12713, 13034, 13312, 13554, 13762, 13941, 14093, 14223, 14332, 14421, 14496, 14557, 14606, 14645, 14673, 14695, 14711, 14719, 14723, 14723, 14721, 14716, 14707, 14697, 14688, 14676, 14664, 14651, 14639, 14627, 14615, 14604, 14593, 14583, 14573, 14565, 14557, 14551, 14544, 14539, 14535, 14531, 14529, 14526, 14525, 14523, 14522, 14520, 14519, 14517, 14514, 14509, 14503, 14495, 14484, 14469, 14452, 14429, 14400, 14365, 14322, 14270, 14208, 14133, 14044, 13940, 13817, 13675, 13508, 13316, 13095, 12840, 12548, 12214, 11834, 11404, 10916, 10364, 9746, 9050, 8273, 7406, 6441, 5376, 4200, 2902, 1485, -61, -1742, -3555, -5509, -7602, -9821, -12175, -14653, -17236, -19925, -22700, -25534, -28366, -31554, -31737, -29036, -26706, -24371, -22100, -19917, -17838, -15865, -14018, -12302, -10713, -9262, -7949, -6765, -5713, -4787, -3978, -3284, -2695, -2204, -1806, -1490, -1250, -1079, -970, -917, -914, -955, -1033, -1144, -1284, -1449, -1633, -1835, -2050, -2275, -2510, -2750, -2992, -3238, -3481, -3724, -3965, -4199, -4427, -4650, -4864, -5069, -5268, -5453, -5630, -5796, -5950, -6092, -6221, -6339, -6443, -6535, -6613, -6678, -6729, -6767, -6791, -6801, -6798, -6781, -6750, -6707, -6648, -6576, -6491, -6394, -6283, -6160, -6024, -5876, -5716, -5545, -5363, -5171, -4968, -4757, -4539, -4312, -4080, -3840, -3597, -3352, -3104, -2856, -2611, -2368, -2133, -1905, -1689, -1485, -1300, -1135, -995, -883, -804, -764, -769, -823, -933, -1104, -1344, -1660, -2060, -2551, -3140, -3834, -4641, -5565, -6616, -7796, -9105, -10551, -12132, -13839, -15676, -17636, -19700, -21867, -24118, -26430, -28738, -31400, -31060, -27835, -24981, -22126, -19333, -16632, -14036, -11548, -9189, -6965, -4872, -2923, -1082};