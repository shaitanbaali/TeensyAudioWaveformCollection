/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1785 256 samples */
 
const int16_t AKWF_1785_256_DATA [256] = 
{1693, 3904, 5788, 7687, 9567, 11225, 12665, 14011, 15218, 16195, 17077, 17880, 18430, 18872, 19356, 19630, 19534, 19325, 19155, 19091, 19278, 19231, 18216, 16900, 16574, 16788, 16283, 15249, 14458, 13903, 13340, 12699, 11904, 11085, 10636, 10363, 9538, 8370, 7877, 8000, 7761, 7202, 6849, 6378, 5794, 5753, 5938, 5678, 5495, 5868, 6178, 6052, 5936, 6136, 6668, 7421, 8016, 8318, 8729, 9270, 9581, 9847, 10408, 11156, 12110, 13114, 13059, 11618, 10886, 12716, 15217, 15480, 14963, 16563, 17148, 12059, 6047, 7393, 13578, 15822, 13252, 10811, 9850, 9315, 9764, 11384, 13355, 15240, 15997, 14021, 10176, 8393, 10813, 14167, 13588, 7769, 892, -1774, -3491, -6237, -8467, -10225, -12933, -17017, -21862, -25814, -26808, -25225, -24385, -26369, -29613, -31704, -32169, -31608, -30414, -29353, -29435, -30578, -31864, -32698, -32290, -30092, -27603, -26699, -26990, -27051, -26331, -24559, -21601, -18402, -15919, -13941, -12304, -9863, -5867, -2522, 1026, 5060, 8249, 10091, 11289, 12927, 15656, 18941, 21345, 22100, 21793, 21275, 21078, 21728, 22843, 23066, 22209, 21081, 19561, 17687, 16070, 13590, 11727, 10826, 8441, 4411, 739, -1488, -3123, -5206, -7758, -10295, -12760, -15246, -17124, -18074, -18852, -19617, -20025, -20812, -22147, -22529, -21529, -20581, -20338, -19941, -18887, -17933, -17639, -17186, -15456, -12954, -10870, -8141, -6009, -4565, -2066, 754, 2854, 4830, 7401, 9956, 11699, 12886, 14367, 16429, 18107, 18461, 18352, 19204, 20636, 21233, 20853, 20444, 20256, 20018, 19675, 18952, 17787, 16960, 16449, 15043, 12800, 10768, 8066, 5966, 4904, 2632, -356, -2610, -4366, -6285, -8540, -10737, -11924, -12516, -14080, -16170, -17262, -17639, -18052, -18398, -18840, -19354, -19258, -18705, -18411, -18224, -17685, -16863, -15888, -14870, -13961, -12926, -11441, -8818, -5773, -4268, -2998, -748};