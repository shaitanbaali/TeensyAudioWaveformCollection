/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1704 256 samples */
 
const int16_t AKWF_1704_256_DATA [256] = 
{2520, 6285, 9819, 12976, 15545, 17435, 18688, 19427, 19899, 20397, 21206, 22520, 24358, 26574, 28857, 30817, 32171, 32751, 32532, 31754, 30752, 29871, 29272, 28875, 28322, 27272, 25522, 23262, 20824, 18604, 16820, 15506, 14499, 13600, 12596, 11344, 9883, 8214, 6355, 4251, 1861, -826, -3746, -6852, -10012, -13045, -15657, -17549, -18592, -18936, -18930, -18963, -19155, -19307, -18943, -17743, -15605, -12804, -9580, -6126, -2452, 1398, 5231, 8692, 11529, 13640, 15210, 16446, 17489, 18246, 18595, 18474, 17987, 17352, 16878, 16631, 16541, 16363, 15874, 14893, 13427, 11488, 9158, 6459, 3502, 502, -2208, -4416, -5980, -6973, -7476, -7644, -7690, -7817, -8172, -8781, -9530, -10186, -10518, -10433, -10012, -9516, -9159, -9055, -9078, -8995, -8515, -7488, -5965, -4251, -2618, -1329, -434, 170, 661, 1205, 1789, 2298, 2528, 2451, 2137, 1798, 1580, 1591, 1815, 2228, 2776, 3449, 4172, 4869, 5448, 5812, 5863, 5528, 4794, 3744, 2585, 1603, 1082, 1221, 2040, 3390, 4969, 6424, 7407, 7720, 7357, 6510, 5509, 4700, 4293, 4136, 3951, 3366, 2240, 677, -960, -2381, -3398, -4076, -4569, -5084, -5771, -6723, -7955, -9385, -10911, -12450, -13992, -15586, -17271, -19028, -20710, -22091, -22925, -23056, -22522, -21629, -20765, -20235, -19991, -19740, -19032, -17519, -15183, -12227, -8945, -5543, -2168, 1066, 3958, 6290, 7863, 8678, 8924, 8917, 8867, 8885, 8933, 8972, 8966, 8954, 8954, 8981, 8939, 8704, 8131, 7178, 5851, 4180, 2158, -186, -2803, -5472, -7886, -9753, -10944, -11463, -11484, -11221, -10973, -11043, -11564, -12477, -13530, -14438, -15020, -15313, -15440, -15566, -15745, -16000, -16253, -16374, -16287, -15959, -15470, -14916, -14430, -14164, -14177, -14417, -14656, -14704, -14441, -14037, -13609, -13285, -12989, -12634, -12045, -11083, -9569, -7368, -4496, -1046};