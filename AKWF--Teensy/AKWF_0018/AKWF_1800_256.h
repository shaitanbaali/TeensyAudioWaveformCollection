/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1800 256 samples */
 
const int16_t AKWF_1800_256_DATA [256] = 
{151, 635, 1058, 1425, 1741, 2009, 2249, 2497, 2732, 2893, 2976, 3001, 2978, 2929, 2865, 2803, 2784, 2862, 3060, 3378, 3812, 4357, 4967, 5606, 6252, 6918, 7643, 8502, 9553, 10691, 11854, 13083, 14369, 15637, 16815, 17783, 18704, 19649, 20494, 21217, 21836, 22399, 22973, 23441, 23741, 23986, 24245, 24545, 24952, 25536, 26271, 27127, 28089, 29118, 30074, 30822, 31300, 31525, 31580, 31619, 31763, 31884, 31944, 32093, 32339, 31962, 31380, 30889, 30412, 29944, 29475, 29000, 28516, 28038, 27568, 27121, 26727, 26394, 26091, 25791, 25564, 25470, 25485, 25533, 25564, 25518, 25313, 24901, 24278, 23510, 22694, 21959, 21372, 20806, 20225, 19701, 19243, 18820, 18394, 17927, 17392, 16789, 16123, 15419, 14704, 14017, 13400, 12762, 12077, 11410, 10784, 10192, 9661, 9199, 8780, 8363, 7914, 7397, 6790, 6090, 5316, 4497, 3675, 2891, 2162, 1486, 866, 320, -185, -645, -1045, -1388, -1678, -1922, -2137, -2361, -2582, -2736, -2815, -2833, -2810, -2759, -2698, -2643, -2631, -2718, -2929, -3260, -3714, -4277, -4916, -5594, -6280, -6974, -7733, -8617, -9694, -10879, -12072, -13332, -14640, -15926, -17070, -18051, -19098, -20132, -21053, -21847, -22519, -23130, -23756, -24272, -24604, -24857, -25127, -25438, -25844, -26435, -27204, -28084, -29068, -30112, -31080, -31840, -32306, -32483, -32487, -32455, -32516, -32546, -32517, -32565, -32713, -32236, -31580, -31033, -30508, -29987, -29461, -28930, -28395, -27860, -27335, -26820, -26330, -25877, -25460, -25065, -24738, -24550, -24490, -24486, -24473, -24408, -24218, -23841, -23264, -22548, -21775, -21068, -20511, -19987, -19447, -18959, -18533, -18148, -17761, -17338, -16859, -16310, -15699, -15045, -14374, -13732, -13156, -12565, -11925, -11292, -10695, -10135, -9625, -9186, -8786, -8391, -7964, -7470, -6884, -6198, -5430, -4616, -3797, -3004, -2264, -1571, -932, -351};