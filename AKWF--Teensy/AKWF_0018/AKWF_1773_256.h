/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1773 256 samples */
 
const int16_t AKWF_1773_256_DATA [256] = 
{227, 868, 937, 922, 926, 927, 929, 929, 928, 929, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 930, 929, 928, 929, 929, 929, 929, 929, 929, 929, 927, 926, 927, 927, 927, 927, 927, 926, 924, 925, 925, 925, 925, 925, 924, 923, 924, 924, 924, 924, 924, 923, 922, 922, 922, 922, 922, 922, 921, 919, 920, 920, 920, 919, 920, 919, 917, 918, 918, 918, 918, 918, 917, 916, 917, 917, 917, 917, 917, 915, 914, 915, 915, 915, 915, 914, 913, 912, 913, 913, 913, 913, 912, 912, 912, 912, 912, 911, 912, 911, 909, 910, 910, 910, 910, 910, 909, 908, 908, 908, 908, 908, 908, 907, 906, 907, 907, 907, 906, 907, 906, 904, 905, 905, 905, 904, 905, 903, 902, 903, 903, 903, 903, 903, 902, 901, 902, 902, 902, 901, 902, 900, 899, 900, 900, 900, 899, 900, 898, 897, 898, 898, 898, 898, 898, 897, 896, 897, 903, 875, 1117, 1669, 2190, 2715, 3241, 3768, 4293, 4819, 5346, 5870, 6396, 6922, 7447, 7972, 8499, 9022, 9547, 10072, 10596, 11122, 11646, 12170, 12696, 13219, 13743, 14267, 14790, 15314, 15838, 16361, 16884, 17408, 17926, 18056, 20852, -9719, -20014, -16257, -15483, -14254, -13437, -9740, -23151, -22860, -13337, -14863, -14299, -13997, -13694, -13391, -13089, -12784, -12480, -12178, -11874, -11570, -11266, -10962, -10658, -10354, -10050, -9747, -9444, -9140, -8836, -8533, -8228, -7924, -7621, -7317, -7014, -6710, -6407, -6105, -5800, -5497, -5193, -4891, -4587, -4285, -3982, -3679, -3377, -3072, -2769, -2475, -1901, -1179, -467};