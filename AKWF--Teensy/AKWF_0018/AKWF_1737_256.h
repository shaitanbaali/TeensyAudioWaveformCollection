/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1737 256 samples */
 
const int16_t AKWF_1737_256_DATA [256] = 
{1129, 4597, 8349, 12021, 15709, 19397, 23065, 26675, 30468, 32815, 32719, 32736, 32738, 32735, 32732, 32727, 32722, 32718, 32711, 32706, 32701, 32694, 32688, 32681, 32674, 32667, 32660, 32653, 32645, 32638, 32631, 32623, 32615, 32607, 32599, 32590, 32582, 32574, 32567, 32558, 32550, 32541, 32533, 32524, 32516, 32507, 32500, 32491, 32482, 32473, 32465, 32456, 32447, 32440, 32430, 32422, 32414, 32404, 32396, 32388, 32378, 32370, 32363, 32353, 32344, 32336, 32327, 32317, 32310, 32302, 32292, 32284, 32276, 32266, 32257, 32249, 32241, 32232, 32224, 32215, 32206, 32197, 32189, 32180, 32171, 32164, 32155, 32145, 32137, 32129, 32119, 32111, 32104, 32094, 32086, 32077, 32068, 32059, 32051, 32042, 32034, 32026, 32016, 32008, 32000, 31990, 31982, 31975, 31965, 31957, 31949, 31939, 31931, 31923, 31913, 31905, 31897, 31862, 31952, 31364, 28036, 24338, 20688, 17010, 13323, 9611, 5930, 2235, -1485, -5192, -8887, -12589, -16257, -19938, -23611, -27219, -31018, -32876, -32733, -32761, -32761, -32758, -32754, -32749, -32744, -32740, -32734, -32728, -32722, -32716, -32709, -32703, -32696, -32689, -32682, -32675, -32667, -32659, -32652, -32644, -32637, -32629, -32621, -32612, -32604, -32596, -32588, -32579, -32571, -32563, -32555, -32546, -32538, -32529, -32520, -32512, -32503, -32495, -32487, -32477, -32469, -32461, -32451, -32443, -32436, -32426, -32417, -32410, -32400, -32391, -32383, -32375, -32366, -32357, -32349, -32340, -32331, -32323, -32313, -32305, -32298, -32289, -32279, -32271, -32262, -32253, -32244, -32237, -32228, -32218, -32210, -32202, -32192, -32184, -32176, -32167, -32158, -32151, -32141, -32132, -32124, -32115, -32107, -32099, -32090, -32080, -32073, -32064, -32054, -32046, -32039, -32029, -32021, -32013, -32003, -31995, -31986, -31978, -31970, -31961, -31952, -31943, -31935, -31926, -31917, -31874, -32013, -31082, -27495, -23829, -20157, -16496, -12821, -9118, -5431, -1642};