/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1706 256 samples */
 
const int16_t AKWF_1706_256_DATA [256] = 
{1251, 4544, 7717, 10551, 12793, 14243, 14979, 15319, 15570, 15940, 16589, 17543, 18769, 20155, 21566, 22853, 23882, 24558, 24817, 24625, 24026, 23057, 21804, 20393, 18906, 17468, 16152, 15050, 14177, 13556, 13198, 13047, 13056, 13188, 13361, 13511, 13567, 13491, 13232, 12790, 12172, 11390, 10474, 9476, 8445, 7406, 6407, 5508, 4709, 4047, 3520, 3107, 2807, 2582, 2411, 2265, 2110, 1934, 1696, 1382, 973, 682, 765, 1445, 2786, 4778, 7284, 10074, 12856, 15354, 17332, 18595, 19054, 18689, 17543, 15751, 13499, 11029, 8511, 6183, 4204, 2664, 1659, 1190, 1209, 1664, 2427, 3361, 4335, 5228, 5925, 6317, 6349, 6013, 5335, 4351, 3141, 1800, 419, -919, -2130, -3160, -3952, -4504, -4811, -4910, -4830, -4631, -4367, -4116, -3924, -3823, -3859, -4059, -4401, -4894, -5495, -6165, -6886, -7595, -8259, -8842, -9316, -9849, -10717, -12075, -14013, -16497, -19402, -22501, -25550, -28269, -30504, -32071, -32765, -32260, -30388, -27128, -22697, -17491, -12022, -6722, -1990, 1821, 4365, 5484, 5183, 3593, 971, -2343, -5992, -9691, -13077, -15877, -17858, -18882, -18923, -18047, -16405, -14194, -11665, -9095, -6710, -4713, -3267, -2462, -2319, -2817, -3865, -5343, -7100, -8975, -10807, -12427, -13719, -14599, -15002, -14957, -14496, -13706, -12701, -11565, -10458, -9461, -8671, -8149, -7924, -8036, -8301, -8501, -8391, -7761, -6509, -4654, -2318, 297, 2934, 5387, 7431, 8902, 9700, 9782, 9203, 8065, 6502, 4681, 2799, 1005, -554, -1759, -2539, -2861, -2748, -2250, -1468, -512, 488, 1424, 2186, 2712, 2935, 2830, 2426, 1762, 875, -147, -1231, -2293, -3269, -4100, -4724, -5141, -5345, -5357, -5209, -4938, -4600, -4272, -3959, -3756, -3680, -3732, -3920, -4249, -4683, -5198, -5765, -6336, -6866, -7349, -7766, -7886, -7440, -6268, -4344, -1696};