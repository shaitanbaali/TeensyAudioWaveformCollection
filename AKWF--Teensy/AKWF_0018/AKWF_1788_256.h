/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1788 256 samples */
 
const int16_t AKWF_1788_256_DATA [256] = 
{-152, 2473, 5295, 6020, 9939, 12122, 11675, 11209, 10373, 9645, 9023, 8433, 7952, 7572, 7254, 6979, 6747, 6560, 6396, 6262, 6158, 6070, 5989, 5934, 5878, 5838, 5805, 5776, 5760, 5743, 5724, 5710, 5697, 5687, 5679, 5675, 5673, 5671, 5671, 5670, 5668, 5666, 5663, 5662, 5661, 5660, 5659, 5658, 5658, 5658, 5657, 5657, 5657, 5657, 5656, 5656, 5656, 5656, 5656, 5656, 5656, 5656, 5656, 5656, 5656, 5655, 5655, 5654, 5650, 5646, 5641, 5640, 5641, 5641, 5641, 5641, 5641, 5641, 5641, 5641, 5641, 5638, 5632, 5626, 5624, 5625, 5625, 5625, 5625, 5625, 5625, 5625, 5993, 3952, 24830, 34396, 32340, 32703, 32704, 32704, 32694, 32677, 32660, 32644, 32627, 32619, 32620, 32619, 32619, 32619, 32619, 32619, 32619, 32619, 32619, 32619, 32537, 32896, 31698, 7852, 5003, 5737, 5596, 5596, 5596, 5595, 5597, 5590, 5578, 5566, 5560, 5555, 5547, 5539, 5522, 5477, 5367, 5202, 5295, 2505, -5038, -5276, -5385, -5418, -5431, -5437, -5442, -5455, -5465, -5472, -5481, -5490, -5497, -5507, -5520, -5525, -5535, -5539, -5538, -5538, -5539, -5544, -5550, -5556, -5561, -5567, -5573, -5579, -5582, -5585, -5591, -5596, -5597, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5596, -5597, -5594, -5590, -5585, -5895, -4141, -12129, -33851, -32255, -32532, -32534, -32534, -32534, -32534, -32534, -32534, -32534, -32535, -32534, -32538, -32520, -32456, -32432, -32360, -32295, -32260, -32195, -32192, -32064, -31989, -31938, -31946, -31875, -31854, -31777, -31694, -31689, -31201, -31770, -24584, -16273, -14047, -11890, -10548, -8471, -5742, -2631, -1821, -771};