/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1725 256 samples */
 
const int16_t AKWF_1725_256_DATA [256] = 
{724, 3036, 5163, 7164, 9036, 10786, 12417, 13930, 15335, 16642, 17846, 18966, 20001, 20958, 21847, 22670, 23430, 24138, 24794, 25403, 25971, 26501, 26992, 27452, 27882, 28284, 28659, 29012, 29341, 29651, 29940, 30212, 30466, 30705, 30926, 31134, 31328, 31507, 31674, 31828, 31968, 32098, 32215, 32321, 32414, 32497, 32569, 32629, 32678, 32717, 32746, 32762, 32767, 32762, 32747, 32719, 32682, 32635, 32576, 32507, 32425, 32334, 32233, 32120, 31994, 31859, 31710, 31550, 31379, 31195, 30998, 30789, 30566, 30328, 30076, 29809, 29525, 29225, 28907, 28569, 28213, 27832, 27428, 27000, 26543, 26055, 25537, 24981, 24388, 23754, 23071, 22341, 21555, 20708, 19798, 18818, 17759, 16621, 15394, 14068, 12645, 11113, 9465, 7703, 5815, 3797, 1654, -621, -3031, -5559, -8216, -10990, -13862, -16836, -19888, -22997, -26107, -29540, -30121, -28075, -26379, -24676, -23032, -21470, -19999, -18628, -17373, -16233, -15213, -14317, -13542, -12889, -12351, -11927, -11609, -11391, -11266, -11228, -11270, -11382, -11559, -11794, -12081, -12413, -12782, -13187, -13618, -14073, -14547, -15035, -15533, -16041, -16551, -17061, -17572, -18078, -18577, -19069, -19550, -20021, -20479, -20920, -21347, -21759, -22150, -22524, -22880, -23214, -23528, -23822, -24092, -24341, -24567, -24770, -24951, -25106, -25239, -25349, -25433, -25492, -25530, -25541, -25528, -25491, -25430, -25343, -25235, -25101, -24944, -24763, -24558, -24331, -24080, -23808, -23513, -23197, -22861, -22504, -22126, -21730, -21316, -20885, -20438, -19976, -19498, -19009, -18509, -18000, -17484, -16960, -16433, -15908, -15383, -14862, -14351, -13849, -13363, -12897, -12454, -12040, -11660, -11319, -11024, -10782, -10597, -10478, -10431, -10463, -10582, -10795, -11108, -11528, -12060, -12708, -13475, -14365, -15378, -16507, -17754, -19113, -20567, -22116, -23741, -25423, -27101, -29104, -28256, -24781, -21656, -18529, -15462, -12483, -9603, -6830, -4183, -1615};