/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1798 256 samples */
 
const int16_t AKWF_1798_256_DATA [256] = 
{337, 1079, 1791, 2494, 3179, 3843, 4488, 5108, 5704, 6272, 6808, 7312, 7785, 8223, 8627, 8994, 9327, 9621, 9882, 10109, 10301, 10459, 10589, 10691, 10762, 10811, 10843, 10855, 10849, 10831, 10805, 10772, 10739, 10708, 10682, 10667, 10669, 10681, 10706, 10758, 10835, 10930, 11055, 11216, 11407, 11627, 11886, 12180, 12501, 12862, 13267, 13707, 14179, 14690, 15239, 15828, 16452, 17110, 17806, 18537, 19303, 20101, 20936, 21809, 22710, 23639, 24608, 25608, 26624, 27704, 28460, 28749, 29044, 29331, 29602, 29842, 30060, 30260, 30434, 30589, 30726, 30834, 30914, 30973, 31010, 31016, 31001, 30970, 30910, 30819, 30707, 30573, 30407, 30216, 30004, 29764, 29496, 29210, 28897, 28556, 28193, 27803, 27385, 26948, 26492, 26008, 25501, 24971, 24421, 23844, 23244, 22626, 21986, 21325, 20647, 19946, 19221, 18479, 17723, 16938, 16138, 15321, 14483, 13633, 12764, 11874, 10968, 10046, 9106, 8157, 7187, 6203, 5208, 4198, 3179, 2149, 1104, 48, -1014, -2085, -3159, -4244, -5336, -6431, -7528, -8625, -9719, -10816, -11913, -13002, -14083, -15156, -16221, -17269, -18311, -19336, -20330, -21303, -22265, -23195, -24093, -24964, -25790, -26577, -27329, -28047, -28706, -29315, -29898, -30417, -30869, -31287, -31663, -31963, -32210, -32433, -32585, -32668, -32738, -32767, -32712, -32643, -32584, -32435, -32239, -32121, -31955, -31624, -31438, -31651, -31878, -31700, -31346, -31173, -31066, -30865, -30705, -30706, -30186, -29075, -28140, -27261, -26411, -25652, -24974, -24323, -23720, -23204, -22721, -22256, -21856, -21503, -21149, -20817, -20527, -20243, -19966, -19713, -19466, -19210, -18961, -18717, -18454, -18182, -17911, -17626, -17319, -17000, -16665, -16304, -15929, -15538, -15119, -14677, -14218, -13735, -13221, -12696, -12148, -11571, -10975, -10364, -9731, -9082, -8413, -7729, -7026, -6310, -5591, -4859, -4115, -3372, -2626, -1876, -1135, -378};