/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1738 256 samples */
 
const int16_t AKWF_1738_256_DATA [256] = 
{2473, 8913, 15044, 21187, 27573, 32530, 32791, 32735, 32758, 32756, 32754, 32752, 32749, 32744, 32740, 32735, 32730, 32726, 32719, 32714, 32707, 32701, 32695, 32688, 32681, 32674, 32666, 32659, 32651, 32643, 32636, 32629, 32621, 32613, 32605, 32596, 32588, 32579, 32572, 32563, 32556, 32546, 32539, 32530, 32521, 32513, 32504, 32496, 32488, 32478, 32470, 32462, 32452, 32443, 32436, 32427, 32418, 32411, 32401, 32392, 32384, 32375, 32367, 32359, 32350, 32340, 32332, 32324, 32314, 32306, 32298, 32289, 32280, 32272, 32263, 32254, 32245, 32238, 32228, 32220, 32212, 32202, 32193, 32185, 32177, 32168, 32159, 32151, 32142, 32133, 32125, 32116, 32107, 32100, 32091, 32081, 32074, 32064, 32055, 32048, 32039, 32030, 32022, 32013, 32004, 31996, 31987, 31978, 31971, 31962, 31952, 31944, 31936, 31926, 31918, 31911, 31901, 31893, 31885, 31875, 31863, 31809, 32003, 28803, 22367, 16211, 10015, 3844, -2372, -8584, -14787, -20943, -27314, -32384, -32824, -32739, -32768, -32767, -32766, -32763, -32759, -32756, -32752, -32747, -32742, -32736, -32731, -32725, -32718, -32712, -32705, -32699, -32692, -32685, -32678, -32670, -32663, -32655, -32647, -32639, -32632, -32624, -32615, -32607, -32599, -32591, -32582, -32574, -32566, -32558, -32549, -32541, -32532, -32523, -32515, -32506, -32499, -32491, -32481, -32472, -32464, -32455, -32446, -32439, -32430, -32420, -32413, -32404, -32394, -32386, -32378, -32369, -32360, -32352, -32343, -32334, -32326, -32317, -32308, -32301, -32292, -32282, -32274, -32266, -32256, -32247, -32240, -32231, -32222, -32213, -32205, -32196, -32186, -32179, -32171, -32161, -32154, -32144, -32135, -32127, -32118, -32109, -32102, -32093, -32084, -32075, -32067, -32058, -32049, -32042, -32032, -32024, -32016, -32006, -31998, -31990, -31980, -31973, -31965, -31955, -31947, -31939, -31929, -31920, -31913, -31904, -31895, -31887, -31874, -31811, -32052, -29102, -22670, -16522, -10346, -4042};