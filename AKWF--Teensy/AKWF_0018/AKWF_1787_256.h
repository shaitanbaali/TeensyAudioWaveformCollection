/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1787 256 samples */
 
const int16_t AKWF_1787_256_DATA [256] = 
{2060, 4615, 6324, 7380, 7915, 8023, 7765, 7163, 6213, 4929, 3344, 1460, -680, -3195, -4947, -1489, -1609, -1939, -2106, -2192, -2182, -2075, -1879, -1606, -1280, -926, -569, -228, 85, 362, 592, 774, 903, 983, 1012, 994, 934, 840, 719, 585, 437, 273, 101, -80, -261, -427, -572, -690, -773, -810, -794, -727, -621, -488, -340, -176, -6, 165, 332, 483, 609, 704, 756, 770, 748, 699, 633, 560, 481, 393, 300, 203, 103, 2, -96, -188, -268, -325, -354, -353, -321, -259, -176, -84, 5, 89, 169, 247, 322, 390, 438, 456, 442, 395, 323, 230, 126, 23, -72, -153, -218, -269, -307, -330, -336, -327, -302, -271, -162, -387, -692, -450, -437, -538, -724, -962, -1229, -1483, -1692, -1812, -1794, -1631, -1333, -927, -459, 5, 416, 666, 688, 475, 86, -388, -812, -1106, -1257, -1284, -1250, -1191, -1091, -937, -748, -555, -425, -395, -446, -507, -534, -493, -407, -322, -241, -135, 102, 353, 454, 464, 423, 372, 342, 359, 427, 531, 649, 760, 839, 881, 876, 815, 700, 551, 393, 257, 164, 113, 98, 109, 140, 193, 268, 357, 458, 556, 644, 714, 763, 790, 797, 785, 758, 723, 693, 677, 698, 762, 863, 991, 1128, 1257, 1363, 1440, 1483, 1492, 1473, 1440, 1412, 1400, 1415, 1457, 1523, 1601, 1677, 1738, 1770, 1766, 1723, 1640, 1527, 1394, 1257, 1131, 1024, 943, 889, 861, 855, 868, 892, 908, 898, 847, 748, 610, 458, 316, 190, 57, -134, -441, -896, -1504, -2226, -3006, -3784, -4507, -5241, -4577, -27462, -33517, -30167, -27385, -23452, -18965, -14202, -9495, -5076, -1085};