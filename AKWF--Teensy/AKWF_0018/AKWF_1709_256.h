/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1709 256 samples */
 
const int16_t AKWF_1709_256_DATA [256] = 
{2295, 6713, 11106, 15330, 19295, 22962, 26187, 28896, 30953, 32273, 32763, 32486, 31463, 29834, 27659, 25170, 22540, 19935, 17515, 15342, 13484, 12045, 11071, 10489, 10315, 10474, 10900, 11497, 12193, 12906, 13540, 14034, 14372, 14461, 14323, 13951, 13350, 12562, 11639, 10609, 9534, 8436, 7409, 6454, 5660, 4990, 4448, 4036, 3751, 3605, 3562, 3577, 3626, 3688, 3707, 3693, 3640, 3492, 3259, 2994, 2634, 2241, 1800, 1350, 901, 443, 6, -404, -783, -1126, -1412, -1663, -1855, -2040, -2206, -2327, -2465, -2609, -2743, -2908, -3093, -3280, -3498, -3718, -3966, -4222, -4472, -4780, -5037, -5308, -5562, -5796, -6008, -6251, -6442, -6611, -6771, -6911, -7023, -7135, -7291, -7372, -7505, -7618, -7743, -7867, -8008, -8177, -8338, -8515, -8681, -8854, -9021, -9184, -9347, -9478, -9650, -9786, -9956, -10104, -10152, -10015, -9509, -8609, -7317, -5710, -3873, -1969, -112, 1579, 2937, 4011, 4906, 5759, 6603, 7472, 8383, 9260, 10090, 10773, 11330, 11627, 11745, 11579, 11215, 10633, 9865, 8977, 7945, 6891, 5824, 4782, 3840, 3028, 2300, 1727, 1274, 947, 780, 731, 765, 854, 975, 1119, 1210, 1280, 1318, 1263, 1119, 904, 647, 326, -82, -514, -976, -1453, -1954, -2434, -2871, -3277, -3640, -3950, -4220, -4476, -4662, -4801, -4907, -4952, -5027, -5066, -5115, -5150, -5197, -5266, -5357, -5474, -5603, -5774, -5953, -6133, -6367, -6556, -6788, -7030, -7227, -7444, -7652, -7853, -8049, -8199, -8378, -8514, -8650, -8782, -8900, -9031, -9141, -9254, -9365, -9483, -9583, -9699, -9812, -9909, -10024, -10136, -10232, -10344, -10437, -10528, -10630, -10704, -10786, -10885, -10975, -11045, -11153, -11257, -11329, -11425, -11528, -11618, -11709, -11812, -11898, -11965, -12028, -12108, -12194, -12122, -11757, -10890, -9603, -7677, -5056, -1584};