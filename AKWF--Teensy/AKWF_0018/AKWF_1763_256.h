/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1763 256 samples */
 
const int16_t AKWF_1763_256_DATA [256] = 
{307, 1157, 1845, 2434, 2944, 3401, 3817, 4199, 4557, 4893, 5208, 5502, 5774, 6023, 6251, 6458, 6643, 6814, 6971, 7118, 7260, 7401, 7542, 7688, 7839, 7992, 8151, 8312, 8472, 8632, 8788, 8939, 9082, 9221, 9353, 9480, 9603, 9724, 9844, 9964, 10088, 10214, 10343, 10476, 10612, 10750, 10888, 11026, 11162, 11296, 11428, 11555, 11681, 11804, 11926, 12047, 12167, 12287, 12411, 12535, 12661, 12789, 12917, 13048, 13179, 13309, 13438, 13568, 13694, 13820, 13945, 14068, 14191, 14313, 14435, 14556, 14680, 14804, 14929, 15055, 15182, 15308, 15436, 15564, 15690, 15817, 15942, 16067, 16191, 16315, 16438, 16561, 16684, 16807, 16931, 17055, 17180, 17305, 17431, 17557, 17682, 17808, 17934, 18058, 18184, 18308, 18432, 18555, 18680, 18803, 18927, 19051, 19175, 19299, 19423, 19548, 19673, 19798, 19923, 20048, 20173, 20298, 20422, 20547, 20671, 20694, 21299, 19643, -2366, -6074, -9195, -14014, -19180, -24147, -28327, -31254, -32667, -32489, -30844, -28011, -24400, -20488, -16733, -13559, -11292, -10112, -10069, -11072, -12914, -15299, -17887, -20350, -22385, -23766, -24365, -24149, -23191, -21638, -19709, -17642, -15672, -14020, -12839, -12219, -12182, -12673, -13584, -14757, -16024, -17213, -18169, -18787, -18999, -18796, -18215, -17340, -16282, -15159, -14099, -13209, -12563, -12209, -12152, -12361, -12779, -13326, -13914, -14454, -14869, -15109, -15139, -14956, -14583, -14064, -13454, -12817, -12218, -11708, -11326, -11095, -11014, -11068, -11226, -11447, -11684, -11894, -12037, -12087, -12030, -11864, -11602, -11266, -10886, -10495, -10125, -9803, -9546, -9367, -9264, -9229, -9245, -9290, -9341, -9376, -9374, -9322, -9215, -9051, -8836, -8584, -8308, -8026, -7754, -7503, -7286, -7104, -6956, -6839, -6743, -6653, -6558, -6447, -6306, -6129, -5908, -5643, -5334, -4983, -4593, -4168, -3705, -3206, -2663, -2061, -1384, -577};