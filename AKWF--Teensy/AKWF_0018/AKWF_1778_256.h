/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1778 256 samples */
 
const int16_t AKWF_1778_256_DATA [256] = 
{875, 2797, 4592, 6301, 7920, 9455, 10907, 12272, 13564, 14782, 15926, 17009, 18028, 18986, 19891, 20745, 21548, 22306, 23022, 23696, 24336, 24940, 25509, 26050, 26561, 27044, 27500, 27930, 28336, 28720, 29079, 29416, 29732, 30027, 30306, 30566, 30807, 31032, 31241, 31434, 31616, 31781, 31931, 32070, 32195, 32307, 32405, 32492, 32566, 32629, 32679, 32718, 32745, 32762, 32767, 32760, 32742, 32711, 32670, 32618, 32554, 32477, 32390, 32291, 32178, 32054, 31918, 31770, 31610, 31436, 31247, 31046, 30833, 30605, 30361, 30105, 29831, 29543, 29240, 28917, 28578, 28220, 27843, 27448, 27031, 26590, 26128, 25639, 25124, 24582, 24009, 23402, 22763, 22081, 21360, 20594, 19775, 18896, 17947, 16923, 15827, 14640, 13358, 11990, 10529, 8977, 7338, 5602, 3777, 1869, -131, -2213, -4368, -6598, -8889, -11227, -13610, -15994, -18515, -20381, -19846, -18990, -18231, -17493, -16800, -16162, -15585, -15074, -14630, -14259, -13961, -13731, -13574, -13483, -13457, -13492, -13583, -13727, -13919, -14155, -14431, -14740, -15080, -15448, -15837, -16245, -16669, -17103, -17549, -17998, -18451, -18907, -19361, -19810, -20256, -20692, -21119, -21536, -21940, -22329, -22704, -23062, -23407, -23736, -24047, -24343, -24623, -24884, -25130, -25360, -25574, -25770, -25950, -26112, -26259, -26388, -26502, -26600, -26681, -26745, -26793, -26826, -26842, -26841, -26823, -26791, -26742, -26676, -26594, -26495, -26380, -26249, -26102, -25938, -25758, -25563, -25350, -25122, -24878, -24618, -24343, -24052, -23747, -23426, -23092, -22744, -22381, -22008, -21620, -21220, -20811, -20392, -19962, -19525, -19081, -18632, -18179, -17724, -17270, -16815, -16365, -15921, -15485, -15062, -14653, -14261, -13892, -13549, -13242, -12977, -12761, -12602, -12509, -12487, -12539, -12669, -12880, -13171, -13540, -13989, -14509, -15098, -15747, -16449, -17193, -17943, -18835, -19074, -16921, -14455, -12090, -9757, -7483, -5273, -3140, -1049};