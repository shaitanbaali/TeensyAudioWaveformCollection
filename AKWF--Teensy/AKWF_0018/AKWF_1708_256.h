/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1708 256 samples */
 
const int16_t AKWF_1708_256_DATA [256] = 
{91, 392, 705, 1023, 1344, 1680, 2018, 2354, 2678, 3001, 3323, 3622, 3895, 4153, 4376, 4590, 4764, 4908, 5022, 5097, 5131, 5123, 5067, 4966, 4832, 4674, 4496, 4333, 4187, 4051, 3962, 3939, 3998, 4141, 4390, 4762, 5262, 5876, 6621, 7481, 8456, 9537, 10725, 12010, 13354, 14758, 16206, 17680, 19135, 20570, 21974, 23312, 24580, 25755, 26818, 27769, 28587, 29269, 29812, 30194, 30430, 30519, 30435, 30199, 29806, 29272, 28588, 27763, 26807, 25723, 24524, 23224, 21826, 20342, 18796, 17191, 15535, 13850, 12155, 10455, 8778, 7116, 5492, 3927, 2401, 942, -447, -1760, -2990, -4135, -5185, -6150, -7023, -7796, -8464, -9050, -9542, -9931, -10232, -10452, -10588, -10649, -10634, -10567, -10436, -10253, -10032, -9775, -9479, -9166, -8831, -8497, -8157, -7815, -7484, -7181, -6878, -6595, -6366, -6173, -6055, -6020, -6068, -6225, -6476, -6850, -7335, -7927, -8626, -9428, -10317, -11309, -12379, -13516, -14725, -15974, -17265, -18587, -19911, -21240, -22550, -23817, -25039, -26199, -27285, -28295, -29214, -30037, -30760, -31370, -31887, -32294, -32580, -32738, -32741, -32594, -32284, -31815, -31181, -30355, -29327, -28106, -26675, -25053, -23228, -21201, -19011, -16667, -14185, -11606, -8945, -6238, -3510, -793, 1905, 4583, 7201, 9760, 12229, 14581, 16785, 18825, 20684, 22343, 23788, 24997, 25979, 26729, 27248, 27526, 27580, 27406, 27014, 26402, 25593, 24602, 23441, 22123, 20655, 19083, 17405, 15650, 13841, 11985, 10098, 8210, 6333, 4463, 2626, 827, -929, -2611, -4224, -5745, -7163, -8480, -9675, -10745, -11682, -12491, -13163, -13702, -14118, -14392, -14545, -14570, -14484, -14296, -14004, -13629, -13169, -12641, -12044, -11406, -10728, -10009, -9284, -8545, -7805, -7075, -6364, -5674, -5023, -4415, -3855, -3361, -2916, -2521, -2170, -1848, -1556, -1276, -998, -738, -471, -192};