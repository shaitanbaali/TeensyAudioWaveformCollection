/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1719 256 samples */
 
const int16_t AKWF_1719_256_DATA [256] = 
{1876, 5873, 9371, 12507, 15264, 17697, 19825, 21680, 23311, 24746, 25990, 27088, 28054, 28899, 29637, 30278, 30836, 31313, 31718, 32047, 32311, 32510, 32652, 32734, 32767, 32756, 32698, 32600, 32473, 32309, 32111, 31887, 31638, 31362, 31063, 30733, 30380, 30010, 29618, 29195, 28742, 28254, 27723, 27137, 26489, 25772, 24961, 24044, 23012, 21863, 20581, 19173, 17654, 16051, 14392, 12690, 11016, 9391, 7869, 6437, 5088, 3792, 2509, 1236, -84, -1494, -3005, -4620, -6319, -8103, -9897, -11703, -13371, -14873, -16191, -17228, -17966, -18409, -18531, -18370, -17956, -17331, -16528, -15577, -14552, -13464, -12317, -11246, -10212, -9199, -8285, -7448, -6727, -6146, -5672, -5300, -5087, -5035, -5123, -5341, -5658, -6090, -6590, -7166, -7760, -8390, -9037, -9716, -10399, -11123, -11944, -12868, -13918, -15130, -16516, -18073, -19898, -20123, -18893, -17752, -16561, -15395, -14263, -13170, -12144, -11175, -10292, -9478, -8714, -8021, -7393, -6826, -6321, -5871, -5477, -5149, -4871, -4643, -4458, -4318, -4212, -4139, -4097, -4079, -4081, -4103, -4139, -4187, -4239, -4291, -4338, -4373, -4393, -4394, -4372, -4326, -4266, -4196, -4128, -4074, -4046, -4054, -4110, -4218, -4376, -4571, -4797, -5046, -5300, -5538, -5757, -5949, -6107, -6240, -6343, -6429, -6513, -6604, -6691, -6799, -6930, -7084, -7266, -7473, -7696, -7927, -8159, -8368, -8545, -8674, -8749, -8741, -8665, -8524, -8307, -8026, -7702, -7344, -6962, -6569, -6185, -5811, -5457, -5128, -4832, -4577, -4362, -4191, -4061, -3970, -3916, -3895, -3901, -3930, -3982, -4054, -4141, -4241, -4352, -4469, -4582, -4687, -4784, -4860, -4906, -4923, -4902, -4841, -4744, -4616, -4462, -4302, -4146, -4007, -3905, -3849, -3854, -3925, -4068, -4289, -4594, -4992, -5513, -6159, -6977, -7989, -9237, -10760, -12570, -14637, -17023, -19462, -16828, -11643, -6941, -2302};