/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1747 256 samples */
 
const int16_t AKWF_1747_256_DATA [256] = 
{19234, 32730, 32267, 32318, 32346, 32344, 32341, 32339, 32336, 32331, 32328, 32321, 32264, 32470, 30281, 24528, 18956, 13785, 9020, 4699, 779, -2699, -5749, -8414, -10688, -12572, -14156, -15423, -16399, -17103, -17588, -17863, -17943, -17862, -17652, -17312, -16868, -16345, -15746, -15091, -14378, -13659, -12911, -12135, -11360, -10595, -9831, -9076, -8350, -7634, -6940, -6272, -5639, -5038, -4457, -3912, -3398, -2911, -2461, -2039, -1648, -1268, -945, -639, -347, -88, 140, 348, 543, 710, 862, 995, 1117, 1213, 1298, 1377, 1431, 1477, 1516, 1545, 1561, 1572, 1579, 1576, 1564, 1553, 1533, 1504, 1480, 1450, 1414, 1377, 1342, 1307, 1263, 1219, 1180, 1135, 1089, 1047, 1005, 957, 915, 876, 838, 791, 750, 716, 673, 633, 599, 567, 527, 492, 462, 431, 398, 371, 343, 310, 284, 259, 235, 201, 181, 164, 142, 125, 112, 91, 75, 55, 43, 23, 10, 0, -13, -30, -43, -48, -66, -75, -81, -86, -100, -108, -114, -123, -134, -138, -139, -151, -156, -158, -164, -168, -172, -176, -183, -186, -188, -193, -195, -200, -198, -206, -209, -202, -205, -213, -212, -212, -220, -219, -217, -214, -223, -222, -220, -225, -229, -228, -227, -231, -229, -226, -225, -231, -227, -228, -234, -232, -228, -234, -235, -233, -226, -232, -231, -229, -228, -237, -234, -224, -240, -234, -231, -224, -233, -230, -227, -234, -234, -228, -223, -240, -232, -223, -225, -232, -227, -223, -234, -235, -227, -240, -232, -227, -217, -230, -228, -214, -230, -236, -227, -217, -243, -227, -211, -207, -239, -220, -195, -231, -239, -211, -183, -234, -151, -189, 394, -30631, -33276, -32529, -33518, -13958};