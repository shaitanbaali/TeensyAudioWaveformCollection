/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1784 256 samples */
 
const int16_t AKWF_1784_256_DATA [256] = 
{1437, 4170, 6623, 9035, 11146, 12834, 14406, 15891, 17206, 18125, 18972, 19787, 20251, 20673, 21152, 21479, 21488, 21244, 20972, 20578, 20018, 19386, 18602, 17746, 16985, 16150, 15208, 14291, 13427, 12544, 11582, 10692, 9856, 8986, 8207, 7429, 6567, 5812, 5187, 4619, 4060, 3511, 3031, 2755, 2527, 2240, 2291, 2623, 2994, 3338, 3598, 3815, 4080, 4388, 4713, 5098, 5618, 6377, 7416, 8582, 9780, 11140, 12496, 13689, 14654, 15383, 15870, 16060, 16033, 15862, 15569, 15334, 15224, 15133, 15127, 15192, 15233, 15261, 15205, 14916, 14456, 13876, 13186, 12338, 11427, 10670, 10047, 9584, 9331, 9221, 9138, 9007, 8882, 8575, 7824, 6650, 4902, 1155, -2377, -3705, -5801, -9405, -12916, -15636, -18175, -20794, -23230, -25396, -27266, -28819, -30122, -31141, -31811, -32161, -32457, -32764, -32560, -32003, -31333, -30398, -29197, -27811, -26374, -24757, -22945, -21186, -19301, -17143, -14792, -12628, -10691, -8472, -6343, -4485, -2476, 872, 4132, 5407, 7031, 9744, 12208, 14250, 16244, 18127, 19658, 20824, 21811, 22526, 22919, 23042, 22819, 22346, 21802, 21048, 20042, 18874, 17611, 16251, 14051, 10711, 8598, 7172, 5010, 2332, -252, -2581, -4804, -6929, -8919, -10769, -12437, -13746, -14819, -15806, -16398, -16644, -16732, -16691, -16584, -16445, -16225, -15887, -15442, -14867, -14095, -13052, -11658, -9981, -8098, -5948, -3063, 815, 3028, 4217, 6167, 8381, 10056, 11285, 12379, 13500, 14591, 15520, 16402, 17259, 17993, 18597, 18981, 18977, 18679, 18172, 17477, 16533, 15446, 14445, 13495, 12599, 11824, 11123, 10392, 9503, 8487, 6851, 3930, 1938, 682, -1529, -4376, -7029, -9442, -11834, -14078, -16003, -17757, -19364, -20757, -21999, -23000, -23683, -24099, -24223, -24045, -23633, -23222, -22847, -21992, -20830, -19598, -18138, -16479, -14734, -13034, -11178, -8924, -5795, -2831, -808};