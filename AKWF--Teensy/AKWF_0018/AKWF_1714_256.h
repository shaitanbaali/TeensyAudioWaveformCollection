/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1714 256 samples */
 
const int16_t AKWF_1714_256_DATA [256] = 
{536, 1708, 2879, 4066, 5259, 6451, 7635, 8799, 9938, 11044, 12106, 13123, 14087, 14989, 15830, 16605, 17310, 17948, 18518, 19021, 19460, 19838, 20157, 20422, 20637, 20803, 20925, 21007, 21051, 21061, 21038, 20985, 20904, 20799, 20670, 20520, 20349, 20160, 19953, 19730, 19492, 19240, 18975, 18698, 18409, 18110, 17800, 17480, 17153, 16816, 16470, 16118, 15757, 15390, 15018, 14637, 14250, 13859, 13462, 13059, 12652, 12239, 11823, 11402, 10977, 10548, 10115, 9676, 9233, 8784, 8328, 7868, 7402, 6931, 6458, 5984, 5515, 5054, 4603, 4170, 3760, 3377, 3027, 2715, 2444, 2219, 2042, 1915, 1842, 1818, 1847, 1927, 2055, 2231, 2450, 2712, 3010, 3342, 3708, 4103, 4521, 4962, 5422, 5895, 6380, 6869, 7359, 7845, 8318, 8769, 9189, 9567, 9889, 10140, 10305, 10366, 10310, 10119, 9779, 9278, 8610, 7772, 6761, 5588, 4265, 2806, 1237, -418, -2135, -3876, -5617, -7329, -8977, -10540, -11995, -13317, -14495, -15517, -16368, -17049, -17555, -17888, -18053, -18051, -17893, -17585, -17138, -16564, -15867, -15062, -14160, -13165, -12092, -10954, -9753, -8508, -7232, -5931, -4627, -3337, -2074, -868, 263, 1295, 2197, 2941, 3505, 3857, 3974, 3837, 3432, 2749, 1788, 560, -927, -2649, -4572, -6668, -8895, -11204, -13561, -15917, -18225, -20457, -22568, -24526, -26313, -27902, -29275, -30428, -31350, -32039, -32500, -32735, -32754, -32564, -32179, -31609, -30866, -29964, -28914, -27729, -26425, -25009, -23495, -21903, -20238, -18516, -16759, -14971, -13177, -11398, -9644, -7943, -6321, -4791, -3381, -2116, -1011, -86, 642, 1168, 1487, 1597, 1508, 1233, 787, 193, -522, -1334, -2212, -3126, -4048, -4955, -5815, -6615, -7333, -7952, -8465, -8858, -9130, -9279, -9302, -9204, -8985, -8654, -8216, -7674, -7039, -6317, -5514, -4641, -3703, -2709, -1666, -557};