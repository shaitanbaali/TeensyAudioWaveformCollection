/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1727 256 samples */
 
const int16_t AKWF_1727_256_DATA [256] = 
{737, 2107, 3415, 4691, 5929, 7130, 8293, 9411, 10492, 11535, 12537, 13503, 14432, 15324, 16186, 17014, 17810, 18578, 19319, 20030, 20718, 21381, 22019, 22637, 23232, 23805, 24360, 24893, 25408, 25904, 26382, 26841, 27284, 27708, 28114, 28504, 28876, 29231, 29571, 29892, 30196, 30484, 30755, 31008, 31246, 31466, 31668, 31854, 32023, 32175, 32309, 32426, 32526, 32609, 32675, 32723, 32754, 32768, 32764, 32743, 32704, 32648, 32575, 32485, 32377, 32253, 32111, 31952, 31777, 31583, 31373, 31147, 30904, 30643, 30366, 30072, 29761, 29435, 29091, 28730, 28354, 27961, 27550, 27124, 26679, 26218, 25741, 25244, 24730, 24199, 23648, 23078, 22491, 21880, 21250, 20599, 19924, 19227, 18504, 17755, 16982, 16178, 15345, 14482, 13585, 12655, 11691, 10690, 9650, 8574, 7459, 6303, 5111, 3878, 2610, 1308, -28, -1394, -2782, -4196, -5622, -7068, -8486, -8881, -8938, -9070, -9201, -9349, -9518, -9710, -9927, -10172, -10446, -10748, -11080, -11440, -11827, -12241, -12678, -13138, -13618, -14116, -14631, -15159, -15698, -16247, -16802, -17363, -17927, -18493, -19056, -19619, -20178, -20731, -21279, -21818, -22348, -22869, -23377, -23874, -24359, -24830, -25286, -25729, -26155, -26565, -26959, -27335, -27693, -28034, -28357, -28661, -28946, -29212, -29458, -29684, -29890, -30076, -30242, -30387, -30512, -30617, -30700, -30762, -30803, -30824, -30823, -30802, -30760, -30696, -30612, -30507, -30381, -30235, -30068, -29881, -29673, -29446, -29198, -28931, -28645, -28340, -28016, -27673, -27312, -26934, -26538, -26125, -25696, -25251, -24790, -24315, -23825, -23323, -22809, -22281, -21743, -21196, -20639, -20076, -19506, -18930, -18351, -17770, -17188, -16607, -16029, -15455, -14890, -14333, -13787, -13255, -12738, -12240, -11762, -11304, -10872, -10466, -10087, -9736, -9414, -9121, -8857, -8623, -8414, -8230, -8067, -7922, -7787, -7676, -7531, -6367, -4866, -3441, -2024, -601};