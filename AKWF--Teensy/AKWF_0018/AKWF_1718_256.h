/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1718 256 samples */
 
const int16_t AKWF_1718_256_DATA [256] = 
{786, 2435, 4047, 5580, 7115, 8045, 8409, 8710, 8836, 9347, 10052, 10478, 10651, 11205, 12017, 12679, 13304, 13726, 13921, 13956, 13693, 13242, 12601, 11907, 11452, 10807, 9851, 9228, 8995, 8861, 9314, 9692, 9407, 9284, 9364, 9244, 9222, 9417, 9730, 10154, 10558, 11163, 12039, 13303, 14805, 16321, 17811, 19117, 20316, 21275, 22055, 22910, 23649, 24618, 26031, 27327, 28261, 28894, 29294, 29640, 29874, 29963, 30019, 30111, 30412, 30717, 31065, 31187, 31187, 30915, 30470, 30529, 30662, 30381, 30326, 30265, 30299, 30494, 30643, 30792, 31020, 31395, 32243, 32761, 32707, 32584, 32518, 32350, 31971, 31282, 30228, 29289, 28767, 28351, 28195, 27787, 27180, 26306, 25570, 24920, 24268, 23334, 21999, 20683, 19408, 18086, 17115, 16085, 14677, 13551, 12884, 12413, 12060, 11282, 10728, 10362, 9688, 8644, 7277, 6094, 5381, 4607, 3460, 2493, 1749, 829, 249, 140, -141, -250, -830, -1750, -2494, -3461, -4608, -5382, -6094, -7277, -8645, -9689, -10362, -10728, -11283, -12060, -12413, -12885, -13552, -14678, -16086, -17115, -18086, -19408, -20684, -22000, -23335, -24268, -24920, -25570, -26306, -27180, -27787, -28195, -28351, -28768, -29289, -30228, -31282, -31971, -32350, -32518, -32584, -32707, -32761, -32243, -31395, -31020, -30792, -30643, -30494, -30299, -30265, -30326, -30381, -30662, -30530, -30470, -30915, -31187, -31187, -31065, -30718, -30412, -30111, -30020, -29964, -29874, -29640, -29294, -28894, -28261, -27327, -26031, -24619, -23649, -22911, -22056, -21275, -20316, -19117, -17812, -16322, -14806, -13304, -12040, -11163, -10559, -10155, -9731, -9417, -9223, -9245, -9364, -9285, -9407, -9693, -9314, -8862, -8995, -9229, -9852, -10808, -11452, -11907, -12602, -13243, -13693, -13956, -13922, -13726, -13304, -12680, -12017, -11205, -10652, -10479, -10052, -9348, -8837, -8711, -8410, -8045, -7116, -5581, -4048, -2436, -787};