/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1703 256 samples */
 
const int16_t AKWF_1703_256_DATA [256] = 
{1027, 3110, 5361, 7529, 9356, 10799, 12030, 13136, 14141, 15021, 15783, 16552, 17394, 18267, 19119, 19842, 20436, 21183, 22292, 23642, 25029, 26309, 27272, 27853, 28105, 28173, 28292, 28545, 28846, 29104, 29313, 29319, 29005, 28339, 27329, 26045, 24611, 23133, 21749, 20417, 19073, 17615, 16024, 14381, 12710, 10984, 9293, 7800, 6444, 5164, 3982, 2795, 1512, 118, -1089, -1788, -2004, -1833, -1396, -833, -329, 63, 353, 604, 858, 1114, 1336, 1446, 1383, 1184, 1131, 1364, 1826, 2424, 3153, 3960, 4812, 5592, 6062, 6182, 5981, 5505, 4838, 4112, 3459, 3025, 2755, 2582, 2493, 2609, 3009, 3590, 4287, 5106, 5990, 6900, 7792, 8631, 9273, 9576, 9410, 8672, 7588, 6534, 5713, 5252, 5124, 5196, 5497, 5943, 6429, 7111, 8084, 9295, 10614, 11872, 12987, 13985, 14866, 15660, 16393, 16983, 17458, 17836, 18184, 18506, 18807, 19420, 20499, 21896, 23272, 24367, 24889, 24893, 24565, 23994, 23185, 22153, 20999, 19775, 18512, 17301, 16190, 15134, 14062, 12862, 11532, 10056, 8299, 6160, 3590, 631, -2533, -5686, -8480, -10757, -12533, -14032, -15512, -17123, -18826, -20595, -22499, -24448, -26377, -28083, -29409, -30483, -31369, -32061, -32492, -32653, -32720, -32759, -32678, -32354, -31833, -31336, -30986, -30825, -30787, -30599, -30130, -29442, -28612, -27558, -26348, -25168, -24153, -23338, -22679, -22001, -21255, -20496, -19882, -19497, -19279, -19044, -18583, -17976, -17411, -16988, -16649, -16376, -16308, -16420, -16593, -16854, -17166, -17471, -17805, -18114, -18318, -18461, -18643, -18817, -18879, -18841, -18693, -18488, -18263, -17954, -17519, -16992, -16392, -15820, -15343, -14906, -14443, -13934, -13385, -12774, -12117, -11347, -10355, -9211, -8075, -7126, -6356, -5650, -4994, -4514, -4284, -4329, -4507, -4589, -4510, -4352, -4203, -3992, -3683, -3260, -2629, -1960, -1612, -600};