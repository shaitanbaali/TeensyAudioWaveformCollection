/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1724 256 samples */
 
const int16_t AKWF_1724_256_DATA [256] = 
{2076, 4863, 6974, 8371, 9045, 9068, 8552, 7616, 6366, 4880, 3681, -329, 5687, 33659, 31251, 30508, 29373, 27977, 26242, 24064, 21310, 17885, 13737, 8923, 3314, -1361, -1619, -1554, -1576, -1576, -1575, -1576, -1574, -1573, -1573, -1571, -1572, -1570, -1569, -1569, -1568, -1568, -1566, -1565, -1565, -1564, -1564, -1563, -1561, -1562, -1561, -1561, -1560, -1558, -1559, -1557, -1556, -1556, -1554, -1555, -1553, -1552, -1552, -1551, -1551, -1549, -1548, -1549, -1547, -1546, -1546, -1545, -1546, -1544, -1543, -1543, -1542, -1542, -1541, -1539, -1539, -1538, -1538, -1537, -1535, -1536, -1534, -1533, -1533, -1532, -1532, -1531, -1530, -1530, -1529, -1529, -1528, -1526, -1527, -1525, -1524, -1524, -1523, -1523, -1522, -1520, -1521, -1519, -1518, -1518, -1517, -1517, -1516, -1515, -1516, -1514, -1514, -1513, -1511, -1512, -1511, -1509, -1509, -1508, -1508, -1507, -1505, -1506, -1504, -1503, -1503, -1503, -1503, -1502, -1500, -1501, -1499, -1498, -1499, -1497, -1497, -1496, -1494, -1495, -1493, -1492, -1492, -1491, -1491, -1490, -1488, -1489, -1488, -1487, -1487, -1486, -1486, -1485, -1483, -1484, -1482, -1481, -1482, -1480, -1479, -1479, -1478, -1478, -1477, -1475, -1476, -1474, -1473, -1474, -1473, -1473, -1472, -1470, -1471, -1469, -1468, -1469, -1467, -1466, -1466, -1465, -1465, -1464, -1462, -1463, -1461, -1460, -1460, -1459, -1458, -1458, -1457, -1458, -1457, -1455, -1456, -1454, -1453, -1453, -1452, -1452, -1451, -1449, -1450, -1448, -1447, -1448, -1446, -1445, -1445, -1444, -1443, -1443, -1443, -1443, -1442, -1440, -1441, -1439, -1438, -1439, -1437, -1436, -1436, -1435, -1435, -1434, -1432, -1433, -1431, -1430, -1431, -1429, -1428, -1429, -1428, -1427, -1427, -1426, -1426, -1425, -1423, -1424, -1423, -1421, -1422, -1420, -1419, -1396, -1520, -844};