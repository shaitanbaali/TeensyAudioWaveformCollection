/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1781 256 samples */
 
const int16_t AKWF_1781_256_DATA [256] = 
{17592, 32249, 28681, 25750, 26333, 26269, 26282, 26280, 26219, 26526, 24699, 16439, 14495, 15075, 15172, 15364, 15558, 15760, 15963, 16170, 16381, 16595, 16812, 17032, 17252, 17476, 17699, 17892, 18297, 17672, 15354, 15810, 16172, 16534, 16892, 17248, 17598, 17942, 18283, 18617, 18945, 19269, 19588, 19902, 20212, 20515, 20814, 21108, 21396, 21678, 21957, 22229, 22496, 22759, 23015, 23269, 23515, 23756, 23993, 24224, 24449, 24660, 24879, 25161, 20909, 19773, 20090, 20092, 20141, 20189, 20239, 20287, 20334, 20381, 20427, 20470, 20513, 20554, 20595, 20632, 20670, 20704, 20738, 20769, 20797, 20825, 20850, 20873, 20893, 20911, 20926, 20906, 21099, 20253, 17715, 17947, 18083, 18215, 18343, 18463, 18577, 18683, 18783, 18875, 18962, 19041, 19114, 19180, 19240, 19295, 19344, 19386, 19423, 19455, 19481, 19502, 19517, 19526, 19530, 19530, 19527, 19517, 19503, 19484, 19460, 19242, 20257, 14761, 6470, 7049, 7958, 5091, 462, -3165, -5646, -7673, -9487, -11075, -12423, -13554, -14492, -15316, -15688, -18431, -20201, -20332, -20719, -21014, -21274, -21500, -21700, -21877, -22032, -22169, -22288, -22425, -22333, -23262, -25870, -25695, -25601, -25499, -25386, -25270, -25149, -25024, -24894, -24760, -24623, -24481, -24337, -24188, -24036, -23881, -23722, -23559, -23394, -23216, -23078, -22794, -19908, -19369, -19274, -19068, -18876, -18681, -18483, -18282, -18078, -17881, -17669, -17383, -21622, -22739, -22396, -22358, -22265, -22165, -22056, -21941, -21817, -21744, -21309, -22881, -24578, -24122, -24015, -23848, -23675, -23495, -23310, -23120, -22926, -22726, -22520, -22311, -22097, -21878, -21655, -21461, -21049, -21667, -23973, -23503, -23123, -22740, -22356, -21973, -21592, -21213, -20835, -20460, -20085, -19712, -19341, -18971, -18604, -18238, -17874, -17512, -17152, -16793, -16436, -16083, -15730, -15378, -15030, -14682, -14337, -13994, -13650, -13308, -12969, -12580, -12470, -10754};