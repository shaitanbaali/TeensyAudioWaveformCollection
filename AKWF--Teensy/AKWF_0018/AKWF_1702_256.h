/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1702 256 samples */
 
const int16_t AKWF_1702_256_DATA [256] = 
{905, 3901, 6901, 9857, 12787, 15595, 18201, 20469, 22383, 23967, 25411, 26845, 28390, 30020, 31443, 32319, 32314, 31510, 30156, 28760, 27586, 26878, 26351, 25951, 25452, 25011, 24682, 24649, 24868, 25232, 25411, 25403, 25178, 24962, 24903, 25134, 25563, 26120, 26653, 27130, 27513, 27782, 27865, 27749, 27438, 27049, 26678, 26452, 26446, 26632, 26882, 26948, 26727, 26138, 25351, 24473, 23682, 23080, 22570, 21889, 20931, 19643, 18169, 16622, 15043, 13301, 11276, 8836, 5984, 2845, -482, -3709, -6828, -9755, -12529, -15055, -17260, -18920, -20094, -20868, -21481, -22024, -22509, -22818, -22947, -22850, -22535, -22057, -21511, -21030, -20637, -20317, -19857, -19165, -18190, -17093, -16021, -15221, -14605, -14132, -13559, -13069, -12751, -12869, -13425, -14405, -15540, -16622, -17417, -17759, -17610, -17004, -16100, -14982, -13841, -12738, -11743, -10862, -10127, -9450, -8720, -7890, -6924, -5857, -4655, -3257, -1529, 456, 2613, 4700, 6508, 7887, 8805, 9330, 9486, 9336, 8920, 8288, 7520, 6562, 5329, 3726, 1647, -968, -4037, -7557, -11330, -15155, -18858, -22139, -25289, -27745, -29859, -31347, -32274, -32677, -32737, -32633, -32521, -32369, -32107, -31531, -30588, -29198, -27361, -25138, -22655, -20056, -17453, -14981, -12750, -10763, -8986, -7358, -5842, -4425, -3069, -1699, -252, 1175, 2459, 3402, 4072, 4518, 4964, 5391, 5816, 6120, 6340, 6473, 6604, 6661, 6559, 6086, 5260, 4087, 2737, 1260, -242, -1817, -3302, -4605, -5627, -6269, -6525, -6537, -6408, -6232, -5901, -5509, -5084, -4780, -4553, -4325, -3884, -3226, -2369, -1417, -443, 458, 1212, 1773, 2120, 2351, 2494, 2509, 2514, 2489, 2387, 2066, 1432, 406, -943, -2524, -4162, -5822, -7394, -8695, -9598, -10029, -10047, -9881, -9821, -9947, -10276, -10632, -10827, -10772, -10415, -9873, -9176, -8387, -7316, -5902, -4056, -1703};