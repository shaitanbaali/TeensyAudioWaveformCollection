/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1745 256 samples */
 
const int16_t AKWF_1745_256_DATA [256] = 
{5506, 18828, 29383, 32365, 32087, 32156, 32161, 32159, 32157, 32154, 32150, 32147, 32143, 32138, 32132, 32127, 32121, 32115, 32110, 32102, 32096, 32089, 32082, 32075, 32068, 32061, 32054, 32046, 32004, 32154, 30826, 27819, 25064, 22348, 19690, 17105, 14601, 12210, 9881, 7651, 5524, 3484, 1546, -295, -2040, -3696, -5257, -6724, -8084, -9365, -10556, -11653, -12675, -13617, -14467, -15251, -15959, -16596, -17162, -17657, -18095, -18469, -18783, -19049, -19260, -19418, -19533, -19600, -19629, -19609, -19564, -19478, -19356, -19203, -19030, -18827, -18591, -18345, -18074, -17783, -17476, -17154, -16815, -16461, -16100, -15730, -15351, -14961, -14572, -14177, -13770, -13366, -12963, -12550, -12137, -11734, -11325, -10918, -10518, -10116, -9720, -9324, -8939, -8558, -8177, -7804, -7440, -7080, -6721, -6379, -6040, -5703, -5374, -5061, -4750, -4443, -4151, -3862, -3591, -3321, -3054, -2799, -2544, -2301, -2070, -1842, -1624, -1415, -1215, -1013, -826, -649, -472, -300, -144, 6, 155, 297, 431, 556, 682, 793, 901, 1010, 1113, 1203, 1292, 1377, 1453, 1523, 1592, 1656, 1712, 1771, 1829, 1877, 1916, 1955, 1996, 2024, 2054, 2083, 2104, 2123, 2138, 2161, 2168, 2176, 2186, 2189, 2190, 2188, 2193, 2181, 2176, 2172, 2165, 2151, 2136, 2127, 2106, 2092, 2076, 2055, 2035, 2013, 1999, 1977, 1950, 1928, 1899, 1871, 1843, 1826, 1792, 1763, 1738, 1715, 1682, 1652, 1627, 1591, 1558, 1533, 1507, 1470, 1438, 1417, 1388, 1347, 1318, 1298, 1259, 1229, 1198, 1180, 1138, 1113, 1093, 1056, 1018, 989, 977, 931, 910, 887, 866, 832, 808, 795, 738, 721, 724, 676, 641, 617, 629, 568, 551, 564, 536, 445, 403, 577, -257, 2662, -22311, -34753, -32335, -32762, -32760, -32755, -32580, -33357, -26467, -9467};