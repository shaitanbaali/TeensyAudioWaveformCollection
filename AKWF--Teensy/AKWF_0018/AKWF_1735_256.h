/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1735 256 samples */
 
const int16_t AKWF_1735_256_DATA [256] = 
{1258, 3447, 5535, 7647, 9720, 11792, 13885, 15959, 18017, 20064, 22095, 24130, 26150, 28123, 30098, 32086, 32815, 32728, 32743, 32738, 32732, 32727, 32721, 32714, 32707, 32701, 32695, 32688, 32681, 32673, 32666, 32658, 32651, 32643, 32635, 32627, 32620, 32611, 32603, 32595, 32587, 32578, 32570, 32561, 32554, 32545, 32537, 32528, 32520, 32512, 32502, 32493, 32486, 32477, 32468, 32460, 32451, 32442, 32434, 32424, 32416, 32409, 32400, 32390, 32383, 32373, 32364, 32357, 32347, 32339, 32331, 32322, 32313, 32304, 32296, 32287, 32277, 32270, 32262, 32252, 32244, 32236, 32226, 32217, 32209, 32200, 32192, 32184, 32175, 32166, 32158, 32149, 32139, 32132, 32124, 32114, 32106, 32098, 32088, 32080, 32071, 32062, 32055, 32046, 32037, 32029, 32020, 32011, 32002, 31994, 31969, 32025, 31570, 29691, 27682, 25703, 23685, 21647, 19607, 17554, 15476, 13427, 11331, 9249, 7158, 5046, 2956, 844, -1263, -3350, -5466, -7563, -9639, -11727, -13816, -15872, -17935, -19989, -22021, -24054, -26065, -28048, -30016, -32033, -32832, -32741, -32757, -32752, -32746, -32741, -32735, -32728, -32722, -32715, -32708, -32701, -32695, -32688, -32680, -32673, -32665, -32657, -32649, -32641, -32633, -32626, -32618, -32610, -32601, -32593, -32584, -32576, -32567, -32559, -32552, -32542, -32534, -32525, -32516, -32509, -32499, -32490, -32483, -32474, -32465, -32458, -32448, -32439, -32431, -32422, -32413, -32406, -32397, -32387, -32379, -32371, -32361, -32352, -32345, -32336, -32327, -32319, -32310, -32301, -32293, -32284, -32275, -32267, -32259, -32249, -32240, -32232, -32223, -32214, -32206, -32198, -32189, -32180, -32172, -32162, -32154, -32146, -32136, -32128, -32121, -32111, -32102, -32095, -32085, -32076, -32068, -32060, -32051, -32043, -32034, -32025, -32017, -32008, -31982, -32037, -31642, -29788, -27779, -25813, -23794, -21760, -19708, -17647, -15591, -13521, -11434, -9358, -7263, -5148, -3079, -935};