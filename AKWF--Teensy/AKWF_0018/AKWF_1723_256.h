/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1723 256 samples */
 
const int16_t AKWF_1723_256_DATA [256] = 
{32720, 32543, 32367, 32188, 32007, 31825, 31640, 31452, 31260, 31066, 30868, 30668, 30464, 30256, 30043, 29825, 29603, 29376, 29143, 28905, 28660, 28409, 28151, 27886, 27613, 27333, 27042, 26744, 26436, 26119, 25791, 25453, 25102, 24739, 24365, 23978, 23578, 23163, 22731, 22287, 21827, 21349, 20857, 20344, 19815, 19268, 18700, 18113, 17507, 16878, 16231, 15564, 14872, 14157, 13423, 12664, 11883, 11081, 10256, 9407, 8537, 7642, 6727, 5791, 4833, 3857, 2861, 1843, 809, -243, -1311, -2392, -3489, -4599, -5716, -6845, -7983, -9126, -10272, -11417, -12606, -13026, -12960, -12968, -12961, -12955, -12950, -12944, -12936, -12931, -12925, -12919, -12913, -12907, -12901, -12895, -12889, -12882, -12876, -12870, -12865, -12859, -12852, -12846, -12840, -12835, -12829, -12822, -12816, -12810, -12805, -12799, -12792, -12786, -12780, -12774, -12768, -12763, -12757, -12750, -12744, -12739, -12733, -12727, -12721, -12714, -12708, -12702, -12697, -12691, -12685, -12680, -12673, -12667, -12661, -12655, -12649, -12643, -12637, -12632, -12626, -12619, -12613, -12608, -12602, -12596, -12590, -12584, -12578, -12573, -12567, -12560, -12554, -12549, -12543, -12537, -12531, -12525, -12520, -12514, -12508, -12502, -12496, -12490, -12485, -12478, -12472, -12466, -12461, -12455, -12449, -12443, -12431, -12453, -12289, -11646, -11000, -10360, -9723, -9095, -8474, -7864, -7266, -6679, -6108, -5552, -5013, -4490, -3987, -3505, -3041, -2600, -2179, -1779, -1403, -1049, -719, -411, -128, 132, 370, 585, 778, 947, 1095, 1222, 1326, 1410, 1474, 1517, 1541, 1546, 1532, 1501, 1452, 1388, 1307, 1210, 1099, 973, 834, 682, 516, 339, 150, -48, -258, -477, -708, -946, -1193, -1449, -1712, -1982, -2259, -2543, -2833, -3129, -3429, -3737, -4047, -4363, -4683, -5007, -5335, -5667, -6000, -6338, -6679, -7020, -7366, -7713, -8065, -8419, -8721, -11779};