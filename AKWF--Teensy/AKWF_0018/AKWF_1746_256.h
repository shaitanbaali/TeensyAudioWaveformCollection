/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1746 256 samples */
 
const int16_t AKWF_1746_256_DATA [256] = 
{5899, 25047, 32983, 32675, 32746, 32767, 32767, 32766, 32764, 32761, 32756, 32753, 32749, 32744, 32737, 32732, 32726, 32721, 32714, 32708, 32701, 32694, 32687, 32679, 32672, 32665, 32658, 32649, 32642, 32634, 32625, 32599, 32651, 32306, 29442, 25682, 22190, 18780, 15507, 12365, 9353, 6478, 3730, 1113, -1343, -3683, -5896, -7983, -9920, -11735, -13421, -14991, -16436, -17773, -19003, -20102, -21113, -22022, -22841, -23550, -24176, -24718, -25174, -25559, -25865, -26107, -26265, -26372, -26426, -26417, -26345, -26234, -26084, -25870, -25626, -25354, -25040, -24689, -24312, -23912, -23479, -23023, -22556, -22075, -21563, -21045, -20520, -19978, -19431, -18871, -18307, -17736, -17164, -16592, -16020, -15442, -14874, -14314, -13739, -13177, -12623, -12071, -11515, -10982, -10456, -9922, -9410, -8903, -8409, -7920, -7440, -6976, -6510, -6060, -5624, -5206, -4783, -4378, -3992, -3611, -3239, -2879, -2528, -2178, -1851, -1534, -1222, -923, -641, -371, -97, 160, 399, 640, 867, 1084, 1288, 1493, 1677, 1856, 2028, 2199, 2349, 2491, 2640, 2772, 2895, 3015, 3127, 3225, 3316, 3415, 3495, 3571, 3649, 3720, 3782, 3835, 3892, 3935, 3974, 4007, 4047, 4076, 4092, 4120, 4140, 4147, 4152, 4169, 4165, 4165, 4164, 4166, 4148, 4136, 4134, 4114, 4094, 4070, 4059, 4031, 4002, 3983, 3957, 3924, 3894, 3869, 3829, 3790, 3751, 3725, 3681, 3638, 3614, 3571, 3531, 3494, 3453, 3407, 3359, 3333, 3281, 3233, 3195, 3159, 3115, 3062, 3036, 2986, 2934, 2890, 2855, 2805, 2760, 2734, 2691, 2643, 2609, 2567, 2517, 2471, 2437, 2395, 2349, 2311, 2293, 2250, 2206, 2182, 2141, 2082, 2041, 2030, 1975, 1927, 1915, 1922, 1845, 1814, 1823, 1730, 1674, 1716, 805, 5747, -13443, -34442, -30865, -31497, -31495, -31492, -31464, -31348, -32127, -16959};