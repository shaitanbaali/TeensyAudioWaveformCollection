/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1771 256 samples */
 
const int16_t AKWF_1771_256_DATA [256] = 
{215, 802, 866, 853, 857, 857, 858, 858, 859, 860, 860, 860, 859, 860, 861, 861, 861, 861, 861, 861, 861, 861, 861, 861, 861, 861, 861, 860, 859, 860, 860, 860, 860, 860, 859, 860, 859, 857, 858, 858, 858, 858, 858, 858, 857, 856, 857, 857, 857, 856, 857, 856, 854, 855, 855, 855, 855, 855, 854, 854, 854, 854, 854, 853, 854, 853, 851, 852, 852, 852, 851, 852, 851, 849, 850, 850, 850, 850, 849, 849, 849, 849, 849, 849, 849, 848, 846, 847, 847, 847, 847, 847, 846, 845, 846, 846, 846, 845, 846, 844, 843, 844, 844, 844, 844, 844, 843, 842, 843, 843, 843, 843, 842, 841, 840, 841, 841, 841, 841, 840, 840, 840, 840, 840, 839, 840, 839, 837, 838, 838, 838, 838, 838, 837, 836, 837, 837, 837, 836, 837, 835, 834, 835, 835, 835, 835, 835, 834, 833, 834, 834, 834, 833, 834, 832, 831, 832, 832, 832, 831, 833, 832, 824, 1162, 1667, 2144, 2625, 3107, 3589, 4071, 4552, 5034, 5516, 5997, 6478, 6960, 7441, 7921, 8402, 8882, 9365, 9846, 10325, 10806, 11285, 11765, 12247, 12726, 13205, 13686, 14164, 14643, 15124, 15603, 16081, 16562, 17040, 17518, 17997, 18472, 18591, 21151, -6855, -16446, -11986, -27796, -19401, -15671, -16162, -15785, -15508, -15231, -14954, -14677, -14399, -14122, -13844, -13566, -13288, -13009, -12731, -12453, -12174, -11895, -11617, -11338, -11059, -10781, -10502, -10224, -9945, -9667, -9388, -9109, -8830, -8552, -8273, -7996, -7717, -7439, -7161, -6882, -6604, -6326, -6047, -5771, -5491, -5219, -4910, -4311, -3654, -3011, -2367, -1721, -1078, -421};