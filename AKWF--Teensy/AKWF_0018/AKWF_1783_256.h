/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1783 256 samples */
 
const int16_t AKWF_1783_256_DATA [256] = 
{1153, 3862, 6258, 8226, 10006, 11827, 13332, 14608, 15756, 16749, 17462, 17799, 18026, 18245, 18498, 18626, 18601, 18586, 18486, 18252, 17887, 17585, 17452, 17284, 17135, 16990, 16703, 16449, 16128, 15752, 15487, 15125, 14747, 14382, 13957, 13477, 12900, 12448, 12066, 11480, 10654, 9857, 9151, 8462, 7710, 5816, 3238, 1170, -994, -2831, -4073, -4980, -5316, -5694, -6112, -6175, -5869, -5122, -3818, -1905, 173, 2219, 4144, 5896, 7663, 9218, 10724, 12397, 13928, 15082, 15727, 15983, 15842, 15347, 14775, 14186, 13753, 13227, 12445, 11705, 10881, 10043, 9282, 8847, 8814, 8853, 9072, 9349, 9683, 10127, 10428, 10947, 11715, 12227, 12356, 11999, 10364, 6777, 5136, 4632, 2354, -1027, -4083, -6830, -9791, -12933, -15978, -18754, -21241, -23479, -25549, -27462, -29186, -30543, -31555, -32355, -32749, -32705, -32356, -31757, -30925, -29817, -28526, -27097, -25503, -23666, -21680, -19700, -17617, -15627, -13665, -11796, -9916, -7845, -5296, -1385, 1107, 2415, 4641, 7343, 9667, 11640, 13643, 15549, 17217, 18742, 20007, 20968, 21599, 22063, 22483, 22667, 22696, 22579, 22131, 21510, 20688, 19604, 17138, 14277, 13084, 11770, 9388, 6774, 4336, 2080, -128, -2436, -4830, -7060, -9057, -10833, -12470, -15128, -18417, -21094, -23710, -25817, -27183, -28164, -28521, -28818, -29066, -28878, -28264, -27172, -25393, -22811, -19885, -16783, -12331, -7924, -5462, -2987, 621, 4518, 7799, 10522, 12758, 14498, 15638, 16238, 16631, 16901, 17205, 17275, 16920, 16440, 15754, 14963, 14153, 13564, 13297, 13023, 12817, 12554, 12251, 11993, 11514, 11089, 10755, 9210, 7213, 6751, 6143, 4410, 2293, 402, -1333, -3117, -4980, -6895, -8845, -10777, -12684, -14447, -15943, -17179, -18227, -19131, -19930, -20448, -20663, -20697, -20371, -19656, -18683, -17511, -16199, -14735, -13162, -11441, -8941, -5348, -2848, -1162};