/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1770 256 samples */
 
const int16_t AKWF_1770_256_DATA [256] = 
{317, 1230, 1328, 1307, 1314, 1316, 1316, 1318, 1317, 1318, 1321, 1321, 1321, 1321, 1321, 1320, 1321, 1323, 1323, 1323, 1323, 1323, 1323, 1323, 1322, 1320, 1321, 1321, 1321, 1321, 1321, 1321, 1321, 1321, 1321, 1321, 1318, 1317, 1318, 1318, 1318, 1318, 1318, 1317, 1316, 1316, 1316, 1316, 1316, 1316, 1316, 1315, 1313, 1314, 1314, 1314, 1313, 1314, 1312, 1310, 1311, 1311, 1311, 1311, 1311, 1309, 1308, 1309, 1309, 1309, 1309, 1309, 1306, 1305, 1306, 1306, 1306, 1306, 1306, 1304, 1303, 1304, 1304, 1304, 1304, 1304, 1302, 1301, 1302, 1302, 1302, 1302, 1301, 1299, 1298, 1299, 1299, 1299, 1299, 1298, 1296, 1297, 1297, 1297, 1297, 1297, 1296, 1294, 1295, 1295, 1295, 1294, 1295, 1293, 1291, 1292, 1292, 1292, 1292, 1292, 1290, 1289, 1290, 1290, 1290, 1290, 1290, 1287, 1286, 1287, 1287, 1287, 1287, 1287, 1285, 1284, 1285, 1285, 1285, 1285, 1285, 1283, 1282, 1283, 1283, 1283, 1283, 1282, 1280, 1279, 1280, 1280, 1280, 1280, 1280, 1278, 1278, 1285, 1251, 1670, 2459, 3197, 3945, 4694, 5441, 6189, 6938, 7684, 8433, 9180, 9927, 10673, 11422, 12168, 12915, 13662, 14406, 15154, 15900, 16645, 17392, 18138, 18882, 19628, 20374, 21117, 21863, 22607, 23350, 24095, 24840, 25583, 26326, 27070, 27813, 28556, 29298, 30041, 30784, 30971, 34370, 14799, -24489, -30440, -28516, -28451, -28024, -27597, -27171, -26741, -26309, -25881, -25450, -25019, -24589, -24157, -23726, -23295, -22860, -22428, -21997, -21563, -21130, -20698, -20264, -19831, -19398, -18964, -18531, -18099, -17665, -17233, -16800, -16366, -15932, -15500, -15067, -14636, -14202, -13769, -13338, -12904, -12469, -12040, -11601, -10731, -9705, -8707, -7703, -6700, -5695, -4693, -3691, -2689, -1690, -670};