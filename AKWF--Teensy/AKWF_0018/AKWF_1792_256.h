/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1792 256 samples */
 
const int16_t AKWF_1792_256_DATA [256] = 
{78, 351, 624, 901, 1182, 1468, 1756, 2045, 2339, 2637, 2943, 3254, 3570, 3894, 4226, 4566, 4912, 5332, 5722, 6100, 6448, 7429, 8931, 9554, 10125, 10724, 11213, 11643, 12073, 12510, 12950, 13400, 13838, 14274, 14710, 15137, 15561, 15986, 16410, 16816, 17229, 17647, 18041, 18435, 18784, 19144, 19493, 19828, 20108, 20288, 20339, 20584, 20920, 21211, 21097, 20634, 20028, 19441, 19425, 19361, 19247, 19084, 18941, 18868, 18746, 18566, 18461, 18341, 18248, 18233, 18246, 18392, 18446, 18485, 18617, 18754, 18908, 19118, 19220, 19459, 19708, 19956, 20204, 20453, 20703, 20952, 21202, 21450, 21701, 21950, 22200, 22450, 22700, 22949, 23182, 23354, 24233, 10749, 6131, 7160, 7058, 7127, 7197, 7268, 7417, 7112, 8796, 25378, 27024, 26890, 27226, 27486, 27743, 28002, 28254, 28496, 28743, 28987, 29232, 29480, 29689, 29906, 30102, 30283, 30532, 29695, 35975, 4113, -37647, -31259, -32193, -31933, -31675, -31415, -31154, -30894, -30633, -30373, -30119, -29863, -29608, -29354, -29097, -28840, -28579, -28313, -28048, -27784, -27517, -27251, -26987, -26722, -26458, -26193, -25929, -25665, -25400, -25137, -24876, -24613, -24349, -24086, -23823, -23561, -23300, -23037, -22774, -22512, -22248, -21988, -21725, -21466, -21208, -20954, -20698, -20441, -20186, -19930, -19652, -19544, -18618, -17462, -18810, -18365, -18142, -17886, -17631, -17376, -17121, -16866, -16612, -16357, -16102, -15847, -15592, -15337, -15083, -14828, -14574, -14320, -14064, -13812, -13558, -13300, -13042, -12811, -12415, -12848, -13905, -13453, -13183, -12889, -12600, -12283, -12134, -10799, -9876, -9760, -9482, -9228, -8975, -8722, -8471, -8218, -7986, -7736, -7474, -7223, -6971, -6718, -6466, -6214, -5961, -5709, -5458, -5209, -4959, -4710, -4460, -4212, -3961, -3708, -3455, -3206, -2958, -2710, -2466, -2220, -1973, -1724, -1473, -1219, -963, -706, -447, -181};