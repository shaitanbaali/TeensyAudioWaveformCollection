/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1728 256 samples */
 
const int16_t AKWF_1728_256_DATA [256] = 
{1209, 2929, 4543, 6092, 7569, 8975, 10316, 11584, 12788, 13931, 15008, 16032, 17002, 17918, 18788, 19613, 20395, 21138, 21844, 22513, 23153, 23762, 24340, 24894, 25421, 25924, 26405, 26864, 27302, 27721, 28118, 28499, 28861, 29206, 29533, 29843, 30137, 30415, 30676, 30923, 31152, 31367, 31566, 31750, 31918, 32071, 32210, 32332, 32439, 32531, 32609, 32671, 32718, 32749, 32765, 32767, 32754, 32724, 32680, 32622, 32547, 32458, 32353, 32234, 32100, 31950, 31785, 31605, 31412, 31201, 30975, 30735, 30480, 30209, 29922, 29619, 29300, 28967, 28615, 28247, 27863, 27460, 27039, 26601, 26141, 25662, 25163, 24640, 24095, 23525, 22929, 22304, 21652, 20967, 20249, 19496, 18703, 17871, 16995, 16070, 15099, 14074, 12991, 11853, 10652, 9384, 8054, 6655, 5182, 3647, 2036, 358, -1379, -3183, -5044, -6950, -8903, -10892, -12872, -15038, -16035, -15406, -14913, -14424, -13965, -13542, -13165, -12839, -12567, -12353, -12199, -12104, -12071, -12096, -12178, -12314, -12502, -12739, -13019, -13340, -13698, -14087, -14507, -14951, -15416, -15900, -16399, -16907, -17426, -17950, -18477, -19007, -19534, -20058, -20579, -21091, -21596, -22092, -22578, -23051, -23511, -23957, -24387, -24803, -25203, -25585, -25949, -26296, -26623, -26932, -27218, -27487, -27736, -27963, -28170, -28355, -28519, -28662, -28783, -28881, -28958, -29013, -29046, -29057, -29046, -29012, -28957, -28879, -28780, -28659, -28515, -28351, -28166, -27958, -27730, -27481, -27211, -26922, -26612, -26284, -25936, -25568, -25185, -24782, -24362, -23928, -23478, -23012, -22535, -22043, -21539, -21025, -20501, -19970, -19435, -18892, -18347, -17801, -17255, -16714, -16180, -15652, -15137, -14636, -14151, -13690, -13252, -12842, -12466, -12124, -11823, -11566, -11356, -11196, -11092, -11044, -11055, -11124, -11255, -11446, -11694, -11998, -12352, -12752, -13192, -13664, -14130, -14776, -14257, -12114, -10106, -8105, -6140, -4215, -2346, -500};