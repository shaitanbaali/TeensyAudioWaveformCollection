/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1863 256 samples */
 
const int16_t AKWF_1863_256_DATA [256] = 
{1018, 2612, 4278, 6003, 7760, 9534, 11313, 13077, 14829, 16563, 18259, 19911, 21502, 22991, 24320, 25447, 26370, 27078, 27547, 27800, 27885, 27832, 27668, 27413, 27078, 26667, 26159, 25537, 24820, 24026, 23163, 22244, 21272, 20231, 19092, 17832, 16452, 14941, 13290, 11505, 9585, 7547, 5422, 3232, 1002, -1236, -3461, -5653, -7797, -9878, -11856, -13733, -15544, -17297, -19012, -20707, -22313, -23774, -25075, -26203, -27165, -27975, -28619, -29127, -29552, -29913, -30243, -30587, -30948, -31292, -31598, -31868, -32114, -32333, -32523, -32664, -32746, -32768, -32743, -32667, -32539, -32358, -32121, -31832, -31496, -31099, -30627, -30075, -29449, -28737, -27922, -27024, -26045, -24971, -23807, -22560, -21248, -19881, -18454, -16984, -15483, -13939, -12341, -10696, -9015, -7298, -5545, -3745, -1907, -55, 1790, 3608, 5389, 7132, 8812, 10406, 11930, 13381, 14742, 16017, 17213, 18321, 19340, 20261, 21071, 21758, 22319, 22747, 23030, 23171, 23182, 23058, 22797, 22401, 21878, 21246, 20522, 19719, 18846, 17903, 16887, 15802, 14650, 13451, 12228, 10997, 9772, 8569, 7399, 6280, 5225, 4224, 3276, 2388, 1559, 794, 102, -503, -1014, -1443, -1802, -2087, -2280, -2377, -2393, -2339, -2212, -2020, -1767, -1473, -1142, -772, -366, 62, 506, 963, 1438, 1929, 2421, 2900, 3366, 3808, 4214, 4581, 4905, 5177, 5407, 5600, 5752, 5863, 5947, 6013, 6051, 6057, 6040, 6002, 5929, 5803, 5631, 5425, 5186, 4912, 4595, 4243, 3868, 3477, 3076, 2672, 2273, 1880, 1486, 1096, 714, 345, -12, -357, -690, -1001, -1280, -1515, -1714, -1885, -2023, -2127, -2195, -2236, -2255, -2250, -2235, -2231, -2235, -2240, -2259, -2303, -2380, -2494, -2649, -2835, -3054, -3311, -3606, -3929, -4258, -4580, -4883, -5138, -5319, -5407, -5380, -5212, -4874, -4353, -3643, -2745, -1665, -374};