/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1889 256 samples */
 
const int16_t AKWF_1889_256_DATA [256] = 
{683, 2363, 4051, 5774, 7518, 9277, 11042, 12795, 14535, 16249, 17922, 19550, 21121, 22621, 24049, 25391, 26638, 27786, 28827, 29752, 30561, 31248, 31808, 32242, 32546, 32721, 32768, 32689, 32484, 32158, 31716, 31161, 30498, 29735, 28878, 27932, 26907, 25810, 24647, 23432, 22168, 20865, 19537, 18186, 16823, 15460, 14101, 12754, 11433, 10139, 8880, 7668, 6500, 5387, 4336, 3344, 2422, 1570, 788, 81, -550, -1107, -1587, -1992, -2325, -2584, -2772, -2893, -2948, -2942, -2875, -2756, -2585, -2368, -2111, -1815, -1488, -1134, -758, -363, 41, 455, 871, 1284, 1692, 2089, 2472, 2836, 3180, 3498, 3791, 4053, 4284, 4483, 4647, 4775, 4869, 4925, 4946, 4930, 4878, 4792, 4671, 4519, 4335, 4122, 3882, 3615, 3326, 3018, 2689, 2344, 1989, 1621, 1245, 866, 483, 101, -278, -651, -1018, -1374, -1719, -2050, -2365, -2664, -2945, -3206, -3447, -3665, -3864, -4040, -4193, -4324, -4434, -4522, -4588, -4633, -4659, -4666, -4655, -4626, -4583, -4525, -4455, -4374, -4283, -4185, -4081, -3973, -3863, -3752, -3643, -3537, -3435, -3341, -3254, -3176, -3108, -3053, -3011, -2981, -2968, -2968, -2985, -3018, -3067, -3133, -3217, -3317, -3435, -3570, -3722, -3889, -4073, -4273, -4488, -4718, -4962, -5219, -5489, -5770, -6062, -6363, -6673, -6991, -7316, -7646, -7980, -8319, -8660, -9002, -9347, -9690, -10035, -10378, -10720, -11060, -11398, -11733, -12065, -12394, -12718, -13040, -13357, -13669, -13976, -14280, -14576, -14866, -15150, -15426, -15697, -15959, -16213, -16459, -16695, -16922, -17140, -17344, -17540, -17722, -17889, -18044, -18182, -18302, -18403, -18484, -18541, -18572, -18576, -18550, -18489, -18391, -18255, -18075, -17848, -17573, -17244, -16859, -16413, -15903, -15327, -14683, -13966, -13175, -12307, -11353, -10317, -9200, -7998, -6720, -5368, -3945, -2460, -880};