/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1803 256 samples */
 
const int16_t AKWF_1803_256_DATA [256] = 
{282, 748, 1188, 1604, 1992, 2348, 2674, 2966, 3237, 3495, 3738, 3975, 4210, 4441, 4650, 4835, 4993, 5111, 5180, 5217, 5241, 5263, 5270, 5263, 5276, 5338, 5475, 5685, 5994, 6432, 7000, 7691, 8462, 9304, 10282, 11366, 12530, 13727, 14960, 16208, 17439, 18622, 19744, 20825, 21889, 22937, 23977, 24994, 25956, 26870, 27759, 28588, 29344, 30038, 30721, 31434, 32223, 32713, 32397, 32022, 31612, 31159, 30649, 30120, 29510, 28845, 28165, 27541, 26983, 26450, 25910, 25327, 24703, 24053, 23371, 22706, 22063, 21469, 20919, 20359, 19792, 19241, 18716, 18237, 17780, 17316, 16832, 16290, 15711, 15117, 14510, 13930, 13409, 12945, 12529, 12115, 11700, 11271, 10835, 10403, 9970, 9534, 9097, 8660, 8219, 7770, 7318, 6860, 6403, 5949, 5504, 5063, 4629, 4198, 3766, 3336, 2901, 2461, 2013, 1555, 1083, 606, 127, -354, -834, -1323, -1821, -2332, -2854, -3376, -3901, -4431, -4964, -5501, -6037, -6558, -7070, -7574, -8072, -8567, -9071, -9588, -10112, -10637, -11140, -11617, -12072, -12504, -12932, -13361, -13788, -14221, -14651, -15064, -15448, -15804, -16145, -16492, -16879, -17337, -17854, -18401, -18934, -19422, -19844, -20204, -20528, -20840, -21164, -21502, -21860, -22212, -22547, -22864, -23206, -23564, -23949, -24336, -24715, -25098, -25462, -25779, -26033, -26239, -26477, -26444, -25759, -25075, -24431, -23855, -23343, -22874, -22408, -21948, -21512, -21098, -20682, -20256, -19819, -19412, -19032, -18711, -18451, -18226, -18022, -17831, -17647, -17481, -17322, -17148, -16953, -16717, -16431, -16087, -15693, -15282, -14878, -14492, -14127, -13764, -13381, -12976, -12534, -12051, -11524, -10952, -10347, -9707, -9013, -8249, -7414, -6520, -5585, -4626, -3665, -2721, -1814, -953, -140, 632, 1356, 2037, 2664, 3246, 3785, 4280, 4728, 5106, 5789, -1677, -3198, -2128, -1678, -1167, -670, -176};