/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1899 256 samples */
 
const int16_t AKWF_1899_256_DATA [256] = 
{124, 363, 584, 818, 1086, 1404, 1784, 2219, 2701, 3226, 3776, 4342, 4909, 5460, 5997, 6527, 7046, 7561, 8071, 8577, 9086, 9597, 10112, 10629, 11144, 11655, 12172, 12687, 13201, 13718, 14230, 14742, 15257, 15770, 16283, 16797, 17310, 17826, 18345, 18872, 19405, 19936, 20459, 20972, 21466, 21939, 22365, 22688, 22931, 23167, 23464, 23888, 24505, 25347, 26479, 28007, 29762, 31578, 32751, 32759, 32731, 32797, 31602, 28542, 24621, 20031, 15069, 10045, 5304, 1055, -2522, -5556, -8096, -10130, -11689, -12824, -13569, -13980, -14055, -13696, -12943, -11898, -10676, -9391, -8153, -7056, -6158, -5448, -4901, -4486, -4158, -3868, -3567, -3208, -2777, -2314, -1828, -1320, -797, -262, 274, 817, 1347, 1834, 2294, 2749, 3228, 3761, 4365, 5048, 5851, 6839, 7935, 8984, 9824, 10295, 10249, 9567, 8158, 5992, 3219, 49, -3273, -6532, -9467, -11878, -13638, -14815, -15479, -15708, -15589, -15232, -14742, -14227, -13721, -13147, -12500, -11808, -11093, -10374, -9664, -8982, -8340, -7757, -7234, -6751, -6296, -5855, -5409, -4947, -4456, -3951, -3439, -2919, -2397, -1870, -1342, -816, -293, 227, 751, 1274, 1795, 2313, 2826, 3330, 3829, 4313, 4788, 5263, 5741, 6233, 6752, 7300, 7863, 8390, 8884, 9385, 9918, 10510, 11185, 11939, 12825, 13981, 15260, 16430, 17240, 17446, 16819, 15176, 12375, 8362, 3366, -2211, -8056, -13721, -18801, -22960, -25984, -27984, -29096, -29447, -29227, -28640, -27879, -27144, -26510, -25847, -25141, -24410, -23671, -22938, -22218, -21515, -20850, -20249, -19720, -19245, -18805, -18384, -17956, -17502, -17016, -16513, -15997, -15476, -14945, -14411, -13878, -13348, -12824, -12303, -11780, -11259, -10739, -10218, -9702, -9182, -8662, -8146, -7633, -7121, -6608, -6089, -5564, -5031, -4489, -3933, -3363, -2798, -2248, -1727, -1246, -818, -446, -130};