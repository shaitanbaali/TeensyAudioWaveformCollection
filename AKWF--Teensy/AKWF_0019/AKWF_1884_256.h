/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1884 256 samples */
 
const int16_t AKWF_1884_256_DATA [256] = 
{71, 292, 509, 726, 943, 1160, 1378, 1596, 1813, 2032, 2250, 2467, 2686, 2903, 3122, 3339, 3557, 3775, 3993, 4211, 4428, 4646, 4864, 5082, 5298, 5511, 5720, 5927, 6130, 6332, 6531, 6724, 6916, 7102, 7286, 7467, 7645, 7823, 8003, 8183, 8366, 8549, 8732, 8915, 9097, 9270, 9441, 9606, 9767, 9925, 10081, 10241, 10408, 10582, 10760, 10944, 11123, 11295, 11461, 11622, 11777, 11928, 12081, 12235, 12391, 12551, 12710, 12870, 13030, 13190, 13358, 13531, 13708, 13887, 14063, 14237, 14412, 14590, 14774, 14961, 15146, 15329, 15508, 15687, 15872, 16057, 16233, 16392, 16537, 16676, 16818, 16962, 17107, 17250, 17391, 17530, 17669, 17809, 17950, 18095, 18243, 18399, 18561, 18713, 18849, 18970, 19088, 19208, 19322, 19430, 19533, 19632, 19727, 19818, 19906, 19988, 20064, 20136, 20206, 20276, 20323, 20461, 19799, 16016, 9738, 3639, -1685, -6425, -10614, -14278, -17491, -20309, -22767, -24912, -26776, -28382, -29761, -30930, -31912, -32612, -32725, -32253, -31388, -30138, -28648, -27020, -25422, -23835, -22293, -20860, -19522, -18322, -17290, -16395, -15628, -14965, -14384, -13873, -13427, -13036, -12693, -12393, -12130, -11899, -11697, -11520, -11363, -11226, -11107, -11001, -10909, -10827, -10755, -10693, -10636, -10587, -10545, -10506, -10471, -10438, -10407, -10378, -10349, -10322, -10296, -10270, -10243, -10218, -10192, -10163, -10133, -10093, -10040, -9978, -9907, -9828, -9743, -9653, -9558, -9460, -9357, -9249, -9135, -9014, -8890, -8762, -8629, -8494, -8359, -8224, -8088, -7952, -7815, -7679, -7539, -7397, -7250, -7102, -6952, -6798, -6645, -6492, -6339, -6188, -6036, -5884, -5734, -5584, -5434, -5285, -5136, -4980, -4816, -4645, -4469, -4287, -4099, -3909, -3714, -3516, -3316, -3113, -2908, -2702, -2493, -2284, -2074, -1861, -1648, -1436, -1220, -1005, -791, -575, -359, -139};