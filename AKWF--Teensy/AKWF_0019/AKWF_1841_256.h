/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1841 256 samples */
 
const int16_t AKWF_1841_256_DATA [256] = 
{5354, 14633, 20571, 24586, 27283, 29093, 30308, 31118, 31664, 32030, 32273, 32437, 32547, 32620, 32669, 32703, 32725, 32740, 32749, 32756, 32760, 32764, 32765, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32757, 32813, 32572, 31218, 31575, 32007, 32250, 32422, 32536, 32614, 32666, 32699, 32722, 32738, 32749, 32755, 32760, 32763, 32764, 32766, 32767, 32564, 33493, 26658, 7444, -6337, -11576, -7863, -5241, -3543, -2373, -1588, -1066, -715, -479, -322, -216, -144, -97, -64, -44, -29, -19, -13, -10, -7, -4, -3, -3, 0, -1, -1, 0, 0, 0, 0, 0, 0, 65, -192, 1369, 10027, 17774, 22658, 25989, 28229, 29727, 30730, 31403, 31855, 32156, 32359, 32494, 32586, 32646, 32687, 32714, 32732, 32745, 32753, 32758, 32762, 32764, 32765, 32768, 32767, 32767, 32768, 32768, 32768, 32768, 32768, 32623, 33193, 30181, 12064, -3194, -12823, -19410, -23810, -26770, -28749, -30075, -30965, -31561, -31959, -32227, -32405, -32525, -32606, -32660, -32696, -32720, -32694, -32811, -32455, -21801, -13534, -9375, -6023, -5306, -12876, -19520, -24564, -22681, -5047, -528, -2320, -1208, -850, -569, -382, -255, -171, -114, -76, -52, -35, -22, -16, -11, -8, -5, -3, -4, -1, 0, -1, 0, 0, 0, 0, -5, -100, 455, -4763, -11905, -8547, -5588, -3790, -2541, -1703, -1140, -765, -512, -343, -230, -154, -103, -69, -47, -31, -20, -14, -10, -7, -5, -3, -3, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};