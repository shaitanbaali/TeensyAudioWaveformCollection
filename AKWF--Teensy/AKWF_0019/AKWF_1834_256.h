/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1834 256 samples */
 
const int16_t AKWF_1834_256_DATA [256] = 
{491, 2156, 3899, 5734, 7636, 9589, 11570, 13549, 15515, 17444, 19308, 21099, 22798, 24398, 25895, 27274, 28521, 29632, 30591, 31388, 32014, 32456, 32708, 32762, 32613, 32261, 31709, 30964, 30037, 28935, 27675, 26269, 24731, 23085, 21349, 19542, 17696, 15829, 13962, 12126, 10340, 8623, 7004, 5486, 4086, 2815, 1671, 657, -222, -973, -1599, -2099, -2483, -2762, -2948, -3047, -3066, -3014, -2901, -2744, -2554, -2348, -2150, -1979, -1859, -1811, -1857, -2017, -2304, -2734, -3312, -4040, -4919, -5942, -7092, -8365, -9739, -11193, -12710, -14267, -15834, -17390, -18912, -20367, -21738, -22998, -24129, -25122, -25954, -26615, -27104, -27414, -27537, -27469, -27211, -26780, -26196, -25462, -24580, -23557, -22408, -21143, -19770, -18309, -16771, -15170, -13531, -11860, -10178, -8512, -6869, -5270, -3736, -2275, -908, 355, 1520, 2577, 3521, 4352, 5070, 5674, 6170, 6555, 6834, 7013, 7096, 7089, 7002, 6842, 6619, 6343, 6023, 5668, 5285, 4887, 4483, 4080, 3692, 3321, 2981, 2678, 2415, 2197, 2025, 1899, 1817, 1776, 1773, 1805, 1866, 1951, 2054, 2167, 2286, 2405, 2517, 2619, 2705, 2774, 2822, 2846, 2844, 2814, 2758, 2670, 2549, 2396, 2208, 1987, 1731, 1440, 1117, 763, 383, -21, -441, -876, -1320, -1765, -2208, -2643, -3068, -3478, -3869, -4237, -4580, -4895, -5182, -5440, -5671, -5874, -6054, -6208, -6336, -6445, -6537, -6613, -6676, -6725, -6761, -6782, -6789, -6783, -6767, -6739, -6699, -6648, -6584, -6508, -6420, -6324, -6217, -6104, -5986, -5862, -5739, -5618, -5503, -5394, -5297, -5212, -5141, -5090, -5057, -5044, -5053, -5084, -5140, -5222, -5331, -5466, -5628, -5816, -6027, -6260, -6509, -6767, -7028, -7284, -7522, -7733, -7907, -8030, -8092, -8077, -7973, -7761, -7431, -6967, -6361, -5604, -4688, -3614, -2392, -985};