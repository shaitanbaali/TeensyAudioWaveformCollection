/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1808 256 samples */
 
const int16_t AKWF_1808_256_DATA [256] = 
{60, 224, 386, 311, 212, 383, 409, 352, 724, 913, 802, 946, 1079, 1160, 1594, 1951, 2058, 2265, 2485, 2575, 2726, 2940, 3274, 3689, 4061, 4205, 4576, 5755, 6486, 6851, 7698, 8421, 8957, 9909, 10599, 15215, 31141, 24673, 14735, 23437, 24825, 21595, 24532, 26005, 25297, 26267, 26390, 26050, 26702, 27071, 27121, 27338, 27319, 27121, 27045, 26909, 26637, 26314, 25799, 25172, 24526, 23747, 22902, 22124, 21249, 20243, 19281, 18172, 16894, 15666, 14427, 13084, 11793, 10561, 9209, 7809, 6459, 5095, 3705, 2371, 1019, -409, -1743, -2947, -4122, -5279, -6391, -7584, -8770, -9958, -11097, -12151, -13067, -13897, -14718, -15541, -16339, -17139, -17831, -18448, -19039, -19548, -19945, -20429, -20997, -21478, -21808, -22050, -22205, -22242, -22282, -22361, -22352, -22319, -22333, -22255, -22152, -22085, -21959, -21829, -21561, -21149, -20705, -20228, -19733, -19153, -18596, -18135, -17583, -16995, -16403, -15744, -15080, -14437, -13760, -12995, -12214, -11426, -10639, -9911, -9219, -8623, -8014, -7374, -6682, -5880, -5078, -4349, -3558, -2756, -1970, -1250, -502, 311, 943, 793, 1105, 1942, 2220, 2417, 2759, 2640, 2816, -842, -16039, -8841, 2250, -5387, -5975, -2014, -4247, -5099, -3834, -4302, -3903, -3080, -3349, -3343, -3033, -3035, -3010, -2796, -2607, -2408, -2226, -2054, -1863, -1700, -1500, -1265, -1003, -760, -553, -311, -66, 104, 304, 466, 532, 672, 985, 1272, 1395, 1574, 1690, 1756, 1855, 1989, 2024, 2043, 1980, 2029, 2326, 2434, 2346, 2303, 2160, 2018, 2031, 1822, 1626, 1756, 1704, 1314, 1128, 1001, 881, 852, 805, 622, 555, 658, 731, 678, 937, 1128, 1153, 1176, 1017, 677, 615, 625, 822, 1118, 1157, 945, 708, 487, 497, 633, 610, 415, 214, -112, -258, -131};