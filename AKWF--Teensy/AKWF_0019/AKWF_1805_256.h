/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1805 256 samples */
 
const int16_t AKWF_1805_256_DATA [256] = 
{-214, 2752, 8584, 8321, 8690, 8943, 9184, 9410, 9622, 9821, 10006, 10182, 10346, 10500, 10650, 10797, 10945, 11096, 11251, 11414, 11585, 11762, 11943, 12125, 12304, 12480, 12652, 12817, 12974, 13127, 13278, 13428, 13578, 13729, 13883, 14037, 14193, 14350, 14510, 14673, 14842, 15019, 15205, 15404, 15612, 15828, 16050, 16277, 16504, 16732, 16958, 17185, 17418, 17658, 17911, 18181, 18467, 18770, 19092, 19429, 19781, 20150, 20532, 20930, 21351, 21794, 21935, 21909, 21916, 21920, 21922, 21912, 21885, 21836, 21759, 21653, 21519, 21358, 21175, 20970, 20746, 20508, 20260, 20005, 19747, 19490, 19242, 19006, 18787, 18587, 18406, 18243, 18096, 17960, 17832, 17706, 17572, 17431, 17279, 17111, 16929, 16729, 16509, 16275, 16020, 15750, 15466, 15166, 14852, 14529, 14196, 13858, 13516, 13167, 12816, 12465, 12110, 11752, 11395, 11037, 10677, 10322, 9965, 9608, 9254, 8899, 8546, 8099, 8267, 5434, -319, -160, -621, -989, -1360, -1732, -2103, -2473, -2835, -3194, -3544, -3880, -4202, -4506, -4792, -5061, -5313, -5549, -5773, -5984, -6185, -6378, -6566, -6758, -6957, -7166, -7392, -7640, -7911, -8209, -8533, -8883, -9257, -9655, -10072, -10506, -10958, -11428, -11914, -12420, -12941, -13487, -14050, -14627, -15217, -15810, -16409, -17015, -17626, -18243, -18875, -19527, -20212, -20936, -21705, -22522, -23391, -24312, -25289, -26320, -27398, -28520, -29685, -30898, -31494, -31730, -31999, -32236, -32437, -32596, -32707, -32761, -32760, -32703, -32590, -32424, -32210, -31947, -31642, -31291, -30894, -30454, -29967, -29439, -28875, -28274, -27643, -26990, -26324, -25645, -24956, -24260, -23557, -22843, -22123, -21387, -20636, -19871, -19091, -18303, -17503, -16695, -15880, -15061, -14244, -13430, -12612, -11798, -10990, -10188, -9403, -8632, -7874, -7145, -6436, -5754, -5105, -4476, -3872, -3294, -2735, -2196, -1681, -1177, -695, -216};