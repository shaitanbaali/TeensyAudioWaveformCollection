/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1802 256 samples */
 
const int16_t AKWF_1802_256_DATA [256] = 
{350, 990, 1602, 2198, 2784, 3357, 3917, 4461, 4990, 5505, 6007, 6495, 6970, 7429, 7872, 8303, 8720, 9123, 9374, 10490, 6299, 2510, 3711, 4018, 4450, 4865, 5270, 5660, 6036, 6399, 6746, 7082, 7404, 7713, 8009, 8290, 8560, 8816, 9062, 9293, 9512, 9719, 9916, 10100, 10273, 10436, 10587, 10728, 10860, 10980, 11093, 11197, 11291, 11378, 11457, 11528, 11594, 11653, 11706, 11754, 11798, 11837, 11873, 11906, 11937, 11967, 11996, 12024, 12053, 12081, 12111, 12143, 12179, 12218, 12259, 12306, 12357, 12416, 12479, 12551, 12629, 12716, 12811, 12920, 13015, 12950, 12850, 12768, 12691, 12624, 12565, 12512, 12464, 12423, 12387, 12356, 12328, 12306, 12286, 12267, 12249, 12232, 12211, 12188, 12162, 12134, 12104, 12072, 12038, 12004, 11970, 11936, 11901, 11866, 11829, 11791, 11751, 11708, 11661, 11609, 11551, 11487, 11416, 11339, 11254, 11161, 11058, 10948, 10830, 10701, 10563, 10415, 10258, 10090, 9911, 9721, 9520, 9306, 9083, 8846, 8597, 8336, 8062, 7775, 7476, 7162, 6836, 6498, 6146, 5782, 5404, 5013, 4609, 4192, 3765, 3324, 2870, 2402, 1924, 1435, 936, 423, -99, -635, -1180, -1734, -2297, -2871, -3457, -4049, -4651, -5258, -5876, -6501, -7135, -7776, -8420, -9071, -9730, -10394, -11064, -11735, -12413, -13096, -13784, -14473, -15165, -15859, -16557, -17257, -17958, -18660, -19358, -20061, -20763, -21464, -22162, -22858, -23553, -24245, -24935, -25621, -26300, -26974, -27646, -28311, -28970, -29624, -30267, -30907, -31540, -32195, -32713, -32234, -31498, -30800, -30085, -29364, -28632, -27892, -27146, -26384, -25615, -24837, -24048, -23260, -22461, -21654, -20847, -20035, -19221, -18414, -17599, -16785, -15974, -15168, -14360, -13559, -12757, -11960, -11172, -10388, -9607, -8836, -8070, -7310, -6565, -5823, -5090, -4370, -3658, -2958, -2272, -1595, -931, -267};