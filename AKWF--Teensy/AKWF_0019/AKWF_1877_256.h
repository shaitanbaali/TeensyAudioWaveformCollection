/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1877 256 samples */
 
const int16_t AKWF_1877_256_DATA [256] = 
{345, 1357, 2301, 3156, 4233, 5758, 7317, 8661, 10012, 11325, 12092, 12298, 12793, 13786, 15030, 17119, 20461, 23836, 25945, 26950, 27362, 26986, 26293, 26404, 27133, 27784, 28704, 30366, 32009, 32737, 32700, 32320, 31276, 29472, 27422, 25525, 23974, 22901, 22373, 21921, 20814, 18972, 16856, 14795, 12782, 10702, 8666, 6762, 4822, 2768, 748, -1084, -2708, -4064, -5063, -5951, -7033, -8111, -8932, -9652, -10550, -11577, -12523, -13354, -13864, -13654, -12740, -11517, -10284, -9175, -8425, -8238, -8367, -8309, -7894, -7179, -6145, -4779, -3244, -1776, -432, 740, 1503, 1735, 1597, 1331, 1078, 972, 1188, 1639, 1988, 2010, 1709, 1135, 326, -595, -1528, -2524, -3649, -4835, -6032, -7231, -8360, -9308, -10111, -10908, -11756, -12634, -13498, -14326, -15118, -15892, -16692, -17480, -18090, -18362, -18250, -17809, -17112, -16294, -15587, -15136, -14867, -14605, -14213, -13608, -12711, -11535, -10192, -8728, -7147, -5578, -4202, -3066, -2134, -1398, -801, -156, 673, 1688, 2796, 3867, 4779, 5492, 6046, 6370, 6425, 6335, 6171, 5830, 5353, 4995, 4776, 4482, 4091, 3679, 3097, 2226, 1257, 379, -444, -1296, -2183, -3102, -4007, -4816, -5525, -6152, -6648, -7059, -7490, -7954, -8360, -8655, -8842, -8888, -8790, -8575, -8255, -7801, -7171, -6357, -5457, -4620, -3906, -3285, -2691, -2052, -1304, -373, 732, 1963, 3168, 4176, 5008, 5698, 6189, 6435, 6637, 6946, 7252, 7525, 7957, 8569, 9037, 9200, 9212, 9013, 8391, 7478, 6620, 5802, 4878, 4002, 3252, 2457, 1569, 733, -117, -1202, -2409, -3691, -5151, -6711, -8114, -9295, -10369, -11211, -11710, -12096, -12567, -12982, -13294, -13716, -14275, -14713, -14972, -15123, -15100, -14626, -13838, -13014, -12080, -11002, -9932, -9081, -8332, -7525, -6672, -5740, -4754, -3974, -3126, -2061, -1132, -418};