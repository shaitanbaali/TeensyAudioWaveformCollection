/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1891 256 samples */
 
const int16_t AKWF_1891_256_DATA [256] = 
{356, 1069, 1779, 2425, 2902, 3372, 3853, 4407, 5018, 5636, 6239, 6829, 7405, 7972, 8537, 9098, 9659, 10222, 10786, 11350, 11907, 12651, 13608, 14553, 15451, 16307, 17131, 17931, 18720, 19510, 20299, 21090, 21882, 22677, 23460, 24311, 25329, 26187, 26868, 27445, 27930, 28360, 28767, 29172, 29583, 29998, 30415, 30835, 31256, 31672, 32099, 32454, 32692, 32748, 32550, 32218, 31831, 31449, 31085, 30738, 30398, 30060, 29723, 29384, 29043, 28702, 28371, 27978, 27395, 26545, 25545, 24594, 23709, 22866, 22047, 21227, 20404, 19581, 18754, 17928, 17103, 16275, 15462, 14520, 13442, 12562, 11922, 11389, 10911, 10429, 9931, 9426, 8919, 8411, 7906, 7403, 6899, 6395, 5882, 5434, 5153, 5052, 5103, 5114, 5068, 4997, 4922, 4855, 4791, 4730, 4668, 4604, 4539, 4475, 4401, 4397, 4525, 4467, 4184, 3851, 3514, 3202, 2903, 2609, 2313, 2011, 1707, 1401, 1095, 789, 495, 133, -394, -932, -1458, -1910, -2304, -2696, -3098, -3515, -3939, -4365, -4790, -5215, -5636, -6058, -6478, -6896, -7322, -7561, -7586, -7625, -7711, -7835, -7981, -8129, -8274, -8415, -8551, -8683, -8815, -8943, -9083, -9156, -9059, -9125, -9368, -9714, -10120, -10527, -10919, -11298, -11665, -12023, -12377, -12731, -13084, -13439, -13785, -14200, -14735, -15458, -16376, -17260, -18096, -18890, -19655, -20396, -21131, -21864, -22597, -23329, -24064, -24799, -25522, -26317, -27257, -27950, -28469, -28889, -29227, -29515, -29781, -30045, -30314, -30583, -30853, -31125, -31395, -31663, -31944, -32093, -32124, -31985, -31607, -31116, -30573, -30034, -29508, -28992, -28478, -27963, -27446, -26928, -26410, -25891, -25385, -24810, -24071, -23152, -22079, -21050, -20076, -19125, -18180, -17228, -16270, -15312, -14353, -13396, -12443, -11488, -10543, -9534, -8386, -7428, -6697, -6012, -5332, -4630, -3909, -3186, -2468, -1755, -1047, -329};