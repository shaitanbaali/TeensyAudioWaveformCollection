/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1857 256 samples */
 
const int16_t AKWF_1857_256_DATA [256] = 
{1229, 3970, 6175, 7978, 9407, 10503, 11295, 11812, 12083, 12130, 11976, 11639, 11139, 10493, 9709, 8818, 7954, 7178, 6476, 5844, 5272, 4757, 4293, 3873, 3494, 3153, 2845, 2567, 2317, 2090, 1886, 1701, 1535, 1385, 1250, 1128, 1018, 917, 828, 748, 674, 608, 548, 495, 446, 403, 363, 328, 296, 266, 241, 218, 196, 176, 159, 143, 129, 116, 105, 94, 85, 77, 70, 62, 57, 51, 46, 41, 37, 34, 30, 27, 24, 21, 19, 18, 16, 14, 13, 11, 10, 9, 9, 7, 5, 6, 5, 4, 3, 4, 3, 4, 2, 1, 2, 2, 2, 2, 2, 2, 1, 2, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 1, -25, -138, -339, -620, -971, -1386, -1860, -2384, -2957, -3572, -4225, -4913, -5632, -6379, -7152, -7947, -8762, -9598, -10449, -11316, -12197, -13089, -13994, -14908, -15829, -16761, -17702, -18645, -19597, -20555, -21515, -22482, -23454, -24426, -25404, -26384, -27365, -28351, -29339, -30326, -31279, -32393, -32331, -27644, -20880, -15084, -10029, -5665, -1872};