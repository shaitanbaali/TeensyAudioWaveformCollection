/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1865 256 samples */
 
const int16_t AKWF_1865_256_DATA [256] = 
{1034, 2771, 4593, 6217, 7688, 9000, 10279, 11856, 13376, 14707, 16065, 17706, 19225, 20582, 21811, 22921, 23918, 24820, 25633, 26363, 27024, 27620, 28155, 28639, 29074, 29466, 29818, 30136, 30422, 30679, 30910, 31118, 31305, 31472, 31622, 31758, 31879, 31987, 32084, 32171, 32248, 32317, 32378, 32432, 32481, 32524, 32562, 32595, 32624, 32649, 32671, 32691, 32707, 32721, 32732, 32742, 32750, 32756, 32761, 32764, 32767, 32767, 32768, 32767, 32766, 32764, 32761, 32758, 32754, 32750, 32744, 32739, 32734, 32729, 32722, 32711, 32724, 32572, 32017, 31507, 30887, 29912, 29001, 28187, 27466, 26507, 25334, 24294, 23352, 22500, 21745, 20744, 19557, 18425, 16984, 15537, 13856, 12034, 10019, 7873, 5601, 3175, 778, -1689, -4201, -6448, -8447, -10479, -12693, -14685, -16485, -18117, -19233, -19984, -20687, -21313, -21898, -22118, -22006, -21922, -21852, -21757, -21263, -20644, -20114, -19628, -19194, -18777, -18666, -18914, -19124, -19315, -19487, -19641, -19781, -19905, -20015, -20126, -19880, -19383, -18986, -18459, -17569, -16737, -15977, -14887, -13712, -12682, -11745, -10900, -10140, -9451, -8828, -8638, -8685, -8833, -9368, -10169, -11231, -12545, -13953, -15338, -17012, -18573, -19966, -21227, -22367, -23391, -24316, -25151, -25902, -26580, -27192, -27741, -28238, -28685, -29087, -29450, -29775, -30065, -30346, -30291, -29928, -29637, -29066, -28214, -27060, -25841, -24395, -22863, -21188, -19379, -17767, -16311, -14996, -13807, -12736, -11769, -10899, -10091, -9563, -9477, -9391, -9531, -10040, -10499, -10912, -11292, -11604, -12123, -12968, -13367, -13476, -13602, -13710, -13808, -13896, -13975, -14045, -14109, -14165, -14217, -14267, -14287, -14570, -15173, -15707, -16186, -16627, -17408, -18329, -19129, -19855, -20512, -21103, -21636, -22116, -22545, -22950, -23208, -23009, -22770, -22462, -21728, -20611, -19311, -17765, -16041, -14165, -12289, -10193, -8282, -6193, -4070, -2188, -456};