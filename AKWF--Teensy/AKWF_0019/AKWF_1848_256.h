/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1848 256 samples */
 
const int16_t AKWF_1848_256_DATA [256] = 
{1320, 4141, 6759, 9213, 11469, 13527, 15381, 17030, 18485, 19756, 20846, 21773, 22544, 23164, 23648, 24000, 24229, 24342, 24346, 24248, 24052, 23764, 23391, 22935, 22402, 21796, 21124, 20387, 19597, 18752, 17861, 16930, 15964, 14969, 13952, 12918, 11876, 10833, 9788, 8751, 7727, 6715, 4141, -114, -4066, -7830, -11710, -16271, -20720, -24378, -27527, -30135, -31864, -32659, -32714, -32187, -31190, -29804, -28087, -26092, -23864, -21429, -18835, -16112, -13284, -10395, -7471, -4575, -1805, 792, 3192, 5372, 7338, 9090, 10631, 11978, 13141, 14128, 14953, 15630, 16163, 16568, 16854, 17021, 17195, 17601, 18215, 18931, 19681, 20419, 21123, 21780, 22373, 22902, 23361, 23745, 24054, 24286, 24437, 24508, 24500, 24410, 24240, 23987, 23654, 23240, 22750, 22180, 21533, 20813, 20021, 19158, 18231, 17241, 16206, 15057, 14800, 16393, 18335, 20374, 22390, 23970, 24866, 24920, 24212, 23085, 21839, 20571, 20118, 21018, 21941, 22786, 23677, 24492, 25789, 26800, 26587, 25268, 23026, 19979, 16233, 11889, 7157, 2387, -2174, -6417, -10266, -13685, -16701, -19319, -21564, -23483, -25100, -26443, -27548, -28436, -29130, -29651, -30013, -30231, -30319, -30286, -30140, -29891, -29547, -29110, -28590, -27991, -27317, -26573, -25769, -24904, -23985, -23022, -22017, -20971, -19968, -19227, -18767, -18494, -18342, -18266, -18238, -18242, -18261, -18284, -18305, -18312, -18296, -18253, -18181, -18073, -17923, -17731, -17495, -17212, -16882, -16502, -16075, -15602, -15082, -14515, -13906, -13257, -12569, -11847, -11093, -10310, -9505, -8677, -7836, -6984, -6124, -5263, -4406, -3553, -2711, -1887, -1085, -319, 413, 1106, 1752, 2358, 2920, 3438, 3912, 4342, 4731, 5080, 5386, 5643, 5940, 4661, 958, -2528, -5328, -7621, -9506, -11106, -12550, -13922, -15195, -16287, -17110, -17589, -17675, -17347, -16601, -15446, -13898, -11983, -9729, -7168, -4390, -1466};