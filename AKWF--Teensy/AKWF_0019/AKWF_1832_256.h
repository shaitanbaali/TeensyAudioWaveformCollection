/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1832 256 samples */
 
const int16_t AKWF_1832_256_DATA [256] = 
{278, 789, 1306, 1842, 2391, 2956, 3536, 4143, 4794, 5487, 6214, 6977, 7767, 8577, 9404, 10237, 11068, 11892, 12696, 13473, 14216, 14913, 15557, 16143, 16662, 17105, 17504, 17903, 18301, 18692, 19078, 19462, 19847, 20238, 20637, 21046, 21465, 21897, 22340, 22789, 23246, 23713, 24185, 24662, 25144, 25628, 26114, 26601, 27085, 27568, 28044, 28513, 28974, 29423, 29855, 30272, 30670, 31047, 31401, 31726, 32013, 32260, 32460, 32614, 32716, 32764, 32757, 32694, 32571, 32391, 32148, 31847, 31485, 31060, 30577, 30033, 29427, 28765, 28044, 27267, 26439, 25558, 24627, 23653, 22640, 21628, 20629, 19635, 18666, 17755, 16898, 16097, 15348, 14642, 13982, 13361, 12774, 12221, 11695, 11195, 10720, 10264, 9826, 9407, 9001, 8609, 8229, 7861, 7503, 7156, 6816, 6484, 6160, 5840, 5525, 5213, 4897, 4566, 4219, 3856, 3478, 3087, 2681, 2261, 1831, 1387, 934, 470, -3, -485, -976, -1475, -1980, -2493, -3010, -3531, -4055, -4581, -5105, -5628, -6149, -6664, -7172, -7671, -8157, -8630, -9085, -9518, -9930, -10313, -10669, -10993, -11289, -11585, -11884, -12185, -12486, -12786, -13083, -13374, -13664, -13950, -14237, -14527, -14817, -15111, -15408, -15708, -16013, -16319, -16627, -16936, -17246, -17553, -17861, -18164, -18464, -18762, -19056, -19347, -19637, -19923, -20207, -20491, -20774, -21055, -21339, -21622, -21906, -22191, -22474, -22756, -23034, -23308, -23576, -23834, -24083, -24319, -24540, -24743, -24925, -25080, -25205, -25299, -25356, -25374, -25351, -25283, -25168, -25006, -24794, -24532, -24219, -23854, -23439, -22973, -22458, -21897, -21289, -20637, -19944, -19207, -18435, -17643, -16846, -16045, -15236, -14419, -13592, -12777, -12006, -11281, -10595, -9949, -9343, -8771, -8232, -7726, -7244, -6786, -6351, -5933, -5529, -5137, -4752, -4368, -3987, -3602, -3211, -2816, -2410, -1994, -1567, -1127, -673, -195};