/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1801 256 samples */
 
const int16_t AKWF_1801_256_DATA [256] = 
{273, 1071, 1844, 2599, 3315, 3990, 4609, 5162, 5642, 6048, 6375, 6633, 6825, 6960, 7048, 7103, 7136, 7162, 7189, 7227, 7284, 7362, 7466, 7592, 7739, 7900, 8074, 8251, 8426, 8596, 8753, 8897, 9029, 9145, 9251, 9349, 9438, 9526, 9617, 9711, 9812, 9922, 10040, 10167, 10304, 10449, 10603, 10765, 10938, 11125, 11328, 11545, 11787, 12060, 12367, 12707, 13085, 13498, 13945, 14417, 14914, 15424, 15933, 16431, 16908, 17356, 17764, 18128, 18440, 18707, 18933, 19121, 19303, 19266, 18993, 18753, 18546, 18380, 18261, 18190, 18163, 18177, 18223, 18292, 18372, 18455, 18529, 18584, 18616, 18620, 18593, 18535, 18447, 18334, 18191, 18037, 17874, 17701, 17524, 17343, 17159, 16974, 16786, 16595, 16398, 16197, 15991, 15780, 15564, 15347, 15131, 14916, 14708, 14507, 14311, 14122, 13935, 13751, 13560, 13358, 13137, 12889, 12609, 12291, 11928, 11519, 11066, 10572, 10042, 9484, 8906, 8321, 7742, 7181, 6647, 6148, 5691, 5280, 4915, 4594, 4307, 4048, 3806, 3569, 3328, 3068, 2780, 2455, 2087, 1676, 1222, 720, 180, -393, -994, -1613, -2239, -2877, -3512, -4144, -4771, -5385, -5996, -6604, -7205, -7808, -8411, -9013, -9624, -10241, -10861, -11484, -12114, -12744, -13379, -14017, -14654, -15297, -15953, -16611, -17287, -17993, -18715, -19473, -20259, -21073, -21919, -22785, -23665, -24559, -25449, -26326, -27183, -27999, -28780, -29517, -30204, -30846, -31446, -31998, -32589, -32583, -31889, -31265, -30672, -30121, -29615, -29156, -28744, -28371, -28032, -27712, -27400, -27088, -26764, -26419, -26046, -25637, -25192, -24711, -24197, -23647, -23064, -22462, -21840, -21207, -20560, -19900, -19234, -18559, -17876, -17188, -16487, -15778, -15062, -14338, -13613, -12888, -12160, -11439, -10729, -10028, -9347, -8675, -8015, -7368, -6729, -6093, -5453, -4804, -4137, -3453, -2745, -2019, -1268, -482};