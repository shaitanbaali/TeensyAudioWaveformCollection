/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1870 256 samples */
 
const int16_t AKWF_1870_256_DATA [256] = 
{830, 2579, 4325, 6098, 7883, 9672, 11455, 13216, 14951, 16650, 18297, 19890, 21419, 22871, 24246, 25533, 26724, 27819, 28812, 29696, 30471, 31136, 31686, 32123, 32447, 32659, 32760, 32752, 32640, 32427, 32116, 31712, 31222, 30650, 30004, 29286, 28510, 27677, 26795, 25874, 24919, 23938, 22941, 21930, 20915, 19905, 18904, 17917, 16956, 16021, 15121, 14262, 13445, 12675, 11961, 11300, 10698, 10158, 9680, 9267, 8921, 8639, 8424, 8275, 8192, 8172, 8214, 8317, 8477, 8692, 8960, 9276, 9637, 10040, 10479, 10953, 11456, 11982, 12530, 13094, 13668, 14250, 14836, 15418, 15997, 16565, 17119, 17657, 18174, 18666, 19133, 19568, 19972, 20341, 20672, 20964, 21217, 21426, 21592, 21714, 21790, 21820, 21803, 21736, 21620, 21452, 21230, 20949, 20602, 20184, 19696, 19147, 18538, 17866, 17135, 16340, 15463, 14498, 13443, 12299, 11076, 9783, 8430, 7029, 5573, 4053, 2476, 847, -833, -2551, -4299, -6073, -7857, -9645, -11428, -13187, -14922, -16622, -18269, -19862, -21393, -22845, -24221, -25510, -26702, -27799, -28794, -29679, -30457, -31123, -31675, -32115, -32442, -32655, -32759, -32753, -32644, -32433, -32123, -31723, -31234, -30664, -30019, -29304, -28529, -27697, -26817, -25898, -24945, -23963, -22966, -21957, -20943, -19933, -18931, -17945, -16984, -16049, -15148, -14289, -13470, -12701, -11985, -11323, -10721, -10180, -9700, -9286, -8938, -8656, -8440, -8290, -8205, -8183, -8224, -8325, -8484, -8699, -8964, -9279, -9639, -10042, -10480, -10953, -11454, -11980, -12527, -13091, -13664, -14246, -14831, -15413, -15991, -16560, -17113, -17652, -18169, -18661, -19128, -19564, -19968, -20337, -20669, -20962, -21215, -21426, -21593, -21715, -21792, -21822, -21805, -21740, -21624, -21457, -21237, -20956, -20607, -20190, -19704, -19154, -18545, -17873, -17141, -16344, -15466, -14500, -13444, -12298, -11073, -9778, -8423, -7021, -5562, -4042, -2468, -805};