/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1900 256 samples */
 
const int16_t AKWF_1900_256_DATA [256] = 
{4370, 11220, 17472, 22797, 26896, 29805, 31745, 32647, 32675, 32688, 32533, 32071, 31733, 31466, 31138, 30780, 30415, 30053, 29705, 29379, 29076, 28831, 28696, 28638, 28606, 28547, 28397, 28110, 27634, 26939, 26033, 24955, 23758, 22519, 21286, 20133, 19127, 18304, 17655, 17156, 16789, 16537, 16377, 16282, 16223, 16181, 16145, 16120, 16102, 16087, 16068, 16041, 15998, 15926, 15853, 15829, 15785, 15626, 15250, 14569, 13491, 11942, 9872, 7225, 4097, 692, -2843, -6286, -9426, -12099, -14157, -15604, -16523, -16981, -17083, -16950, -16704, -16457, -16317, -16276, -16273, -16309, -16381, -16482, -16601, -16728, -16854, -16975, -17099, -17250, -17449, -17724, -18096, -18591, -19224, -20009, -20974, -22089, -23286, -24516, -25700, -26775, -27682, -28371, -28815, -29040, -29096, -29052, -28977, -28944, -29017, -29249, -29637, -30132, -30698, -31288, -31850, -32323, -32651, -32770, -32716, -32602, -32349, -31826, -30907, -29459, -27363, -24549, -20923, -16372, -11087, -5298, 605, 6285, 11394, 15600, 18671, 20588, 21442, 21416, 20731, 19651, 18416, 17278, 16456, 15961, 15662, 15535, 15532, 15601, 15679, 15704, 15618, 15415, 15176, 14903, 14577, 14181, 13698, 13113, 12419, 11606, 10658, 9581, 8438, 7279, 6160, 5144, 4278, 3593, 3109, 2804, 2647, 2602, 2626, 2675, 2709, 2690, 2613, 2502, 2357, 2189, 2004, 1812, 1625, 1451, 1290, 1134, 978, 824, 673, 521, 369, 218, 67, -82, -230, -377, -526, -675, -831, -988, -1152, -1326, -1516, -1710, -1901, -2082, -2243, -2377, -2480, -2545, -2574, -2583, -2589, -2615, -2680, -2804, -3007, -3295, -3648, -4068, -4555, -5117, -5754, -6464, -7246, -8096, -9047, -10092, -11177, -12246, -13254, -14137, -14863, -15389, -15630, -15569, -15315, -14979, -14688, -14564, -14715, -15208, -16174, -17689, -19503, -21309, -22763, -23529, -23293, -21806, -18875, -14469, -8849, -2313};