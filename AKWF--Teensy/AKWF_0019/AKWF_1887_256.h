/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1887 256 samples */
 
const int16_t AKWF_1887_256_DATA [256] = 
{267, 1041, 1781, 2508, 3223, 3934, 4639, 5334, 6021, 6703, 7377, 8055, 8733, 9405, 10070, 10725, 11372, 12019, 12662, 13299, 13932, 14559, 15177, 15794, 16401, 16996, 17575, 18133, 18672, 19195, 19700, 20192, 20675, 21150, 21623, 22100, 22582, 23062, 23537, 24002, 24461, 24916, 25363, 25804, 26235, 26657, 27073, 27485, 27893, 28293, 28679, 29048, 29405, 29748, 30077, 30393, 30691, 30972, 31238, 31483, 31710, 31915, 32095, 32252, 32387, 32500, 32596, 32671, 32726, 32759, 32768, 32754, 32713, 32648, 32556, 32436, 32285, 32101, 31881, 31630, 31354, 31049, 30710, 30331, 29908, 29453, 28980, 28489, 27967, 27401, 26783, 26128, 25455, 24768, 24066, 23343, 22588, 21805, 20988, 20137, 19262, 18365, 17450, 16519, 15562, 14581, 13584, 12574, 11558, 10543, 9524, 8506, 7495, 6490, 5500, 4523, 3552, 2591, 1647, 723, -174, -1046, -1903, -2739, -3554, -4345, -5106, -5840, -6551, -7237, -7898, -8531, -9135, -9710, -10262, -10788, -11294, -11781, -12245, -12688, -13104, -13490, -13855, -14205, -14543, -14876, -15201, -15516, -15827, -16130, -16428, -16725, -17022, -17326, -17636, -17951, -18268, -18588, -18904, -19215, -19527, -19845, -20171, -20511, -20860, -21218, -21584, -21950, -22316, -22684, -23055, -23432, -23812, -24189, -24559, -24923, -25280, -25631, -25975, -26305, -26620, -26914, -27186, -27435, -27663, -27875, -28077, -28264, -28429, -28569, -28680, -28763, -28820, -28851, -28859, -28845, -28812, -28762, -28695, -28609, -28498, -28358, -28189, -27994, -27775, -27537, -27284, -27021, -26744, -26452, -26142, -25819, -25490, -25166, -24842, -24510, -24164, -23799, -23413, -23006, -22581, -22138, -21687, -21229, -20765, -20300, -19829, -19347, -18853, -18341, -17808, -17248, -16669, -16079, -15490, -14897, -14288, -13657, -13001, -12329, -11649, -10962, -10269, -9571, -8863, -8144, -7408, -6655, -5896, -5139, -4378, -3614, -2841, -2060, -1279, -485};