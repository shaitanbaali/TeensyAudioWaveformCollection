/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1842 256 samples */
 
const int16_t AKWF_1842_256_DATA [256] = 
{2552, 8429, 13237, 17224, 20472, 23092, 25188, 26846, 28157, 29188, 29992, 30620, 31108, 31487, 31781, 32008, 32183, 32318, 32424, 32503, 32565, 32612, 32648, 32676, 32698, 32714, 32728, 32737, 32743, 32749, 32755, 32757, 32760, 32762, 32762, 32764, 32766, 32765, 32766, 32768, 32767, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32761, 32777, 32510, 31190, 29047, 26719, 24493, 22482, 20737, 19265, 18046, 17052, 16250, 15609, 15100, 14698, 14382, 14135, 13942, 13791, 13675, 13584, 13515, 13461, 13420, 13388, 13363, 13344, 13330, 13318, 13310, 13304, 13298, 13294, 13291, 13289, 13287, 13285, 13285, 13285, 13282, 13282, 13282, 13282, 13282, 13282, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13280, 13281, 13287, 13274, 13645, 15112, 17299, 19649, 21400, 20631, 17451, 13405, 9275, 5416, 1985, -960, -3419, -5447, -7095, -8418, -9474, -10311, -10968, -11485, -11891, -12205, -12451, -12641, -12787, -12901, -12989, -13057, -13108, -13149, -13180, -13205, -13222, -13236, -13246, -13254, -13261, -13266, -13269, -13272, -13275, -13276, -13277, -13278, -13281, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13280, -13281, -13287, -13272, -13540, -14859, -17003, -19330, -21555, -23566, -25314, -26785, -28002, -28997, -29798, -30440, -30950, -31352, -31667, -31914, -32107, -32257, -32375, -32464, -32535, -32588, -32630, -32662, -32687, -32706, -32720, -32731, -32740, -32747, -32752, -32756, -32758, -32760, -32762, -32763, -32766, -32766, -32765, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32764, -32746, -32781, -31511, -26589, -19220, -11432, -3922};