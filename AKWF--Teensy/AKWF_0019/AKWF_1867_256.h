/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1867 256 samples */
 
const int16_t AKWF_1867_256_DATA [256] = 
{302, 980, 1577, 2117, 2604, 3044, 3441, 3799, 4122, 4413, 4675, 4912, 5125, 5317, 5490, 5646, 5786, 5913, 6026, 6128, 6220, 6304, 6378, 6444, 6504, 6558, 6606, 6649, 6688, 6722, 6753, 6780, 6804, 6826, 6845, 6862, 6877, 6890, 6908, 6900, 7002, 8041, 9301, 10383, 11372, 12259, 13062, 13786, 14437, 15025, 15554, 16030, 16460, 16847, 17194, 17508, 17790, 18042, 18269, 18474, 18657, 18822, 18969, 19101, 19220, 19326, 19419, 19504, 19579, 19645, 19704, 19757, 19803, 19843, 19879, 19910, 19937, 19960, 19981, 19997, 20012, 20023, 20033, 20041, 20046, 20052, 20063, 20028, 20703, 22000, 23119, 24135, 25050, 25876, 26620, 27288, 27891, 28433, 28921, 29360, 29754, 30107, 30426, 30711, 30967, 31197, 31402, 31585, 31749, 31896, 32027, 32142, 32246, 32337, 32417, 32488, 32551, 32605, 32653, 32691, 32673, 32950, 30317, 23901, 18212, 13064, 8417, 4224, 432, -2982, -6063, -8849, -11356, -13619, -15664, -17503, -19164, -20664, -22013, -23231, -24329, -25316, -26208, -27012, -27734, -28385, -28972, -29498, -29973, -30400, -30783, -31127, -31436, -31710, -31959, -32180, -31536, -30423, -29485, -28625, -27846, -27143, -26507, -25931, -25411, -24939, -24513, -24127, -23778, -23460, -23174, -22914, -22678, -22464, -22269, -22093, -21933, -21787, -21654, -21533, -21423, -21322, -21230, -21146, -21069, -20999, -20934, -20875, -20820, -20769, -20723, -20680, -20640, -20602, -20567, -20535, -20505, -20476, -20450, -20425, -20400, -20367, -20396, -19914, -18621, -17448, -16393, -15436, -14574, -13793, -13089, -12454, -11879, -11359, -10891, -10466, -10084, -9738, -9424, -9142, -8887, -8655, -8446, -8257, -8086, -7931, -7791, -7664, -7550, -7445, -7351, -7265, -7188, -7118, -7053, -6996, -6943, -6896, -6852, -6812, -6776, -6743, -6713, -6686, -6660, -6637, -6615, -6591, -6585, -6512, -5522, -4240, -3144, -2142, -1241, -413};