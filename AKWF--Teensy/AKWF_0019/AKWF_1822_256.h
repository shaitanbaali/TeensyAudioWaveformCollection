/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1822 256 samples */
 
const int16_t AKWF_1822_256_DATA [256] = 
{8082, 25131, 32296, 32436, 30367, 27956, 25753, 23875, 22296, 20970, 19858, 18908, 18093, 17389, 16770, 16227, 15747, 15316, 14931, 14582, 14266, 13978, 13715, 13473, 13249, 13041, 12850, 12671, 12287, 13458, -349, 8388, 13317, 12405, 12706, 12874, 13054, 13250, 13465, 13698, 13955, 14237, 14550, 14897, 15286, 15720, 16212, 16773, 17412, 18152, 19014, 20023, 21223, 22656, 24366, 26400, 28718, 31022, 32191, 28825, 15790, -2855, -14260, -16537, -15028, -12658, -10357, -8365, -6631, -5503, -5476, -5480, -5474, -5472, -5470, -5467, -5464, -5461, -5459, -5456, -5453, -5449, -5446, -5443, -5439, -5436, -5433, -5429, -5425, -5422, -5419, -5415, -5411, -5408, -5404, -5400, -5396, -5392, -5388, -5385, -5382, -5377, -5374, -5370, -5366, -5363, -5358, -5354, -5351, -5347, -5343, -5339, -5336, -5331, -5328, -5324, -5319, -5316, -5312, -5308, -5304, -5301, -5296, -5293, -5289, -5285, -5281, -5278, -5273, -5269, -5266, -5262, -5258, -5255, -5251, -5246, -5243, -5239, -5235, -5231, -5228, -5223, -5220, -5216, -5212, -5208, -5205, -5200, -5197, -5193, -5189, -5185, -5182, -5178, -5173, -5170, -5166, -5162, -5159, -5155, -5151, -5147, -5144, -5140, -5136, -5133, -5128, -5124, -5121, -5118, -5113, -5110, -5106, -5102, -5098, -5095, -5091, -5087, -5084, -5079, -5076, -5072, -5068, -5064, -5061, -5057, -5053, -5049, -5046, -5042, -5039, -5035, -5031, -5027, -5024, -5020, -5016, -5013, -5009, -5005, -5002, -4998, -4994, -4990, -4987, -4983, -4979, -4976, -4971, -4968, -4965, -4961, -4957, -4953, -4950, -4946, -4942, -4939, -4935, -4931, -4928, -4924, -4920, -4917, -4913, -4909, -4906, -4902, -4898, -4895, -4892, -4887, -4884, -4881, -4876, -4873, -4869, -4866, -4862, -4858, -4855, -4851, -4847, -4844, -4840, -4836, -4850, -4773, -5326, -6924, -8768, -10937, -13321, -15424, -15445, -8122};