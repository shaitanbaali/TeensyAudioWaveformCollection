/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1843 256 samples */
 
const int16_t AKWF_1843_256_DATA [256] = 
{5477, 14731, 20653, 24659, 27348, 29155, 30367, 31175, 31718, 32081, 32324, 32485, 32591, 32661, 32707, 32735, 32753, 32762, 32767, 32768, 32767, 32764, 32760, 32754, 32748, 32741, 32736, 32728, 32721, 32713, 32706, 32698, 32690, 32682, 32674, 32666, 32658, 32650, 32641, 32633, 32625, 32617, 32608, 32600, 32591, 32583, 32574, 32566, 32557, 32548, 32541, 32531, 32523, 32515, 32505, 32497, 32489, 32480, 32471, 32463, 32454, 32445, 32437, 32428, 32419, 32411, 32402, 32393, 32385, 32377, 32367, 32358, 32350, 32342, 32332, 32324, 32316, 32306, 32297, 32289, 32281, 32272, 32264, 32255, 32246, 32238, 32229, 32220, 32211, 32203, 32194, 32185, 32178, 32168, 32159, 32152, 32142, 32133, 32125, 32117, 32108, 32100, 32091, 32082, 32074, 32065, 32056, 32047, 32039, 32030, 32021, 32014, 32004, 31996, 31988, 31979, 31971, 31962, 31953, 31945, 31936, 31927, 31919, 31910, 31898, 31687, 32631, 24281, 5211, -7287, -15661, -21327, -25112, -27652, -29357, -30495, -31259, -31771, -32112, -32340, -32493, -32593, -32657, -32699, -32726, -32742, -32750, -32755, -32756, -32753, -32751, -32746, -32740, -32734, -32728, -32720, -32713, -32706, -32699, -32691, -32684, -32675, -32667, -32659, -32650, -32642, -32634, -32627, -32618, -32610, -32601, -32593, -32584, -32576, -32568, -32559, -32551, -32542, -32533, -32525, -32516, -32507, -32499, -32490, -32482, -32473, -32464, -32455, -32448, -32438, -32429, -32422, -32412, -32403, -32395, -32387, -32378, -32369, -32361, -32352, -32343, -32334, -32326, -32317, -32308, -32301, -32291, -32282, -32274, -32265, -32256, -32248, -32240, -32230, -32222, -32214, -32204, -32196, -32187, -32179, -32170, -32162, -32153, -32144, -32136, -32127, -32118, -32110, -32101, -32092, -32084, -32076, -32066, -32058, -32050, -32041, -32033, -32023, -32015, -32007, -31998, -31990, -31981, -31972, -31964, -31956, -31946, -31938, -31929, -31921, -31913, -31903, -31704, -32585, -26705, -7614};