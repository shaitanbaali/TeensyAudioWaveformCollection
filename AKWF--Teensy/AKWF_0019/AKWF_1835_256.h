/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1835 256 samples */
 
const int16_t AKWF_1835_256_DATA [256] = 
{582, 1816, 2960, 4045, 5065, 6016, 6895, 7696, 8424, 9078, 9656, 10164, 10602, 10976, 11291, 11548, 11750, 11900, 12002, 12057, 12065, 12033, 11964, 11857, 11719, 11551, 11354, 11133, 10893, 10631, 10356, 10074, 9790, 9500, 9199, 8888, 8574, 8252, 7925, 7598, 7268, 6939, 6615, 6298, 5989, 5692, 5408, 5136, 4877, 4632, 4395, 4168, 3971, 3810, 3684, 3594, 3543, 3529, 3559, 3630, 3748, 3914, 4129, 4394, 4704, 5057, 5460, 5919, 6435, 7016, 7663, 8375, 9156, 10004, 10915, 11891, 12924, 14004, 15127, 16281, 17453, 18644, 19844, 21040, 22229, 23392, 24521, 25610, 26647, 27621, 28525, 29351, 30093, 30750, 31318, 31791, 32171, 32457, 32649, 32749, 32762, 32693, 32550, 32338, 32063, 31728, 31335, 30889, 30392, 29853, 29271, 28649, 27994, 27303, 26582, 25837, 25073, 24289, 23495, 22688, 21867, 21036, 20186, 19321, 18445, 17554, 16658, 15756, 14849, 13953, 13068, 12192, 11333, 10484, 9645, 8824, 8015, 7219, 6441, 5676, 4928, 4198, 3479, 2769, 2071, 1380, 701, 34, -620, -1263, -1893, -2511, -3118, -3717, -4312, -4901, -5487, -6068, -6643, -7207, -7760, -8295, -8812, -9311, -9792, -10250, -10689, -11108, -11508, -11891, -12254, -12599, -12928, -13244, -13546, -13835, -14111, -14376, -14655, -14954, -15275, -15620, -15986, -16373, -16783, -17215, -17668, -18143, -18636, -19145, -19667, -20201, -20743, -21287, -21832, -22385, -22939, -23502, -24074, -24649, -25223, -25791, -26348, -26899, -27445, -27977, -28498, -29001, -29481, -29938, -30366, -30763, -31126, -31448, -31725, -31958, -32138, -32268, -32348, -32372, -32341, -32257, -32119, -31927, -31685, -31397, -31057, -30667, -30225, -29735, -29201, -28624, -27999, -27326, -26604, -25827, -24992, -24101, -23148, -22137, -21069, -19940, -18757, -17525, -16233, -14892, -13510, -12087, -10638, -9173, -7701, -6237, -4795, -3379, -2005, -656};