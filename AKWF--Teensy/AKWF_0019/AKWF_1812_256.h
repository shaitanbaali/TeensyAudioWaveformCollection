/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1812 256 samples */
 
const int16_t AKWF_1812_256_DATA [256] = 
{15794, 15788, 15781, 15774, 15765, 15758, 16056, 14408, 23646, 34071, 32387, 32680, 32661, 32641, 32357, 33784, 26509, 14331, 15831, 15540, 15529, 15516, 15504, 15492, 15480, 15468, 15360, 15805, 14150, -8737, -10906, -10326, -10439, -10437, -10433, -10429, -10425, -10421, -10416, -10412, -10406, -10371, -10526, -9885, -5084, -4889, -4946, -4928, -4925, -4921, -4918, -4915, -4911, -4908, -4904, -4901, -4897, -4894, -4890, -4887, -4883, -4880, -4876, -4873, -4869, -4866, -4862, -4859, -4855, -4852, -4848, -4845, -4841, -4838, -4834, -4831, -4827, -4824, -4820, -4817, -4813, -4809, -4806, -4802, -4799, -4795, -4792, -4788, -4785, -4781, -4778, -4774, -4770, -4766, -4763, -4759, -4756, -4813, -4483, -6761, -8419, -8100, -8152, -8147, -8142, -8137, -8130, -8125, -8120, -8058, -8357, -5903, -4438, -4725, -4668, -4664, -4660, -4656, -4653, -4649, -4646, -4641, -4658, -4558, -4901, -9713, -10164, -10035, -10052, -10047, -10041, -10033, -10027, -10020, -10013, -10004, -9731, -11255, 9598, 17260, 15571, 15865, 15857, 15849, 15841, 15833, 15824, 15816, 15806, 15797, 16040, 14643, 27363, 33849, 32485, 32711, 32690, 32671, 32651, 32630, 32608, 32587, 32360, 33489, 20066, 14531, 15601, 15929, 13762, -4268, -5177, -4957, -4726, -9160, -10696, -10339, -10467, -10181, -8405, -8366, -8377, -8369, -8365, -8361, -8357, -8304, -8568, -5965, -4702, -4962, -4911, -4907, -4904, -4901, -4897, -4895, -4891, -4888, -4884, -4881, -4877, -4874, -4870, -4867, -4863, -4860, -4857, -4853, -4849, -4846, -4842, -4839, -4835, -4832, -4828, -4825, -4821, -4818, -4827, -4763, -4977, -7999, -8281, -8200, -8209, -8204, -8199, -8194, -8187, -8183, -8176, -8171, -8165, -8159, -8154, -8147, -8080, -8408, -6443, -4431, -4762, -4696, -4692, -4687, -4684, -4680, -4676, -4672, -4710, -4477, -5433, -10137, -10099, -10082, -10083, -10076};