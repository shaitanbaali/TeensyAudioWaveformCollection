/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1875 256 samples */
 
const int16_t AKWF_1875_256_DATA [256] = 
{348, 1270, 2160, 3018, 3839, 4628, 5379, 6081, 6713, 7247, 7700, 8086, 8405, 8659, 8834, 8927, 8949, 8906, 8800, 8635, 8416, 8151, 7849, 7521, 7180, 6823, 6443, 6048, 5645, 5267, 4941, 4652, 4389, 4145, 3922, 3750, 3635, 3560, 3525, 3550, 3632, 3778, 3966, 4173, 4411, 4697, 5030, 5411, 5815, 6226, 6636, 7038, 7439, 7839, 8225, 8597, 8952, 9298, 9649, 10004, 10349, 10686, 11022, 11355, 11687, 12005, 12300, 12569, 12813, 13034, 13235, 13418, 13582, 13713, 13808, 13881, 13941, 14000, 14062, 14125, 14199, 14297, 14408, 14514, 14624, 14744, 14871, 14998, 15069, 15059, 14990, 14875, 14737, 14578, 14382, 14175, 14035, 13919, 13730, 13313, 12444, 11152, 9483, 7503, 5247, 2732, -11, -2856, -5714, -8542, -11322, -13990, -16484, -18725, -20704, -22469, -24078, -25590, -27011, -28345, -29557, -30614, -31485, -32137, -32564, -32759, -32697, -32352, -31676, -30658, -29304, -27641, -25749, -23681, -21506, -19288, -17080, -14893, -12735, -10604, -8511, -6510, -4630, -2867, -1216, 358, 1866, 3300, 4653, 5874, 6928, 7755, 8335, 8676, 8780, 8652, 8289, 7677, 6849, 5826, 4633, 3293, 1860, 376, -1098, -2542, -3970, -5382, -6786, -8169, -9488, -10737, -11904, -12981, -13968, -14848, -15600, -16217, -16687, -16991, -17114, -17030, -16727, -16223, -15538, -14709, -13754, -12666, -11461, -10158, -8792, -7408, -6013, -4613, -3222, -1851, -511, 810, 2131, 3460, 4746, 5945, 7038, 8022, 8899, 9666, 10291, 10770, 11122, 11345, 11419, 11344, 11109, 10754, 10331, 9834, 9253, 8592, 7846, 7030, 6151, 5208, 4216, 3214, 2220, 1232, 248, -754, -1759, -2747, -3699, -4594, -5417, -6138, -6762, -7304, -7781, -8201, -8534, -8752, -8850, -8822, -8695, -8474, -8156, -7748, -7273, -6737, -6140, -5487, -4779, -4013, -3193, -2334, -1448, -532};