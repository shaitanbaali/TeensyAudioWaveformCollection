/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1872 256 samples */
 
const int16_t AKWF_1872_256_DATA [256] = 
{763, 3448, 6040, 8584, 11057, 13447, 15740, 17916, 19971, 21893, 23668, 25292, 26759, 28056, 29186, 30144, 30924, 31529, 31958, 32212, 32296, 32211, 31964, 31560, 31005, 30311, 29480, 28526, 27460, 26288, 25025, 23682, 22266, 20794, 19277, 17722, 16149, 14562, 12972, 11396, 9835, 8301, 6789, 5233, 3592, 1877, 92, -1750, -3629, -5543, -7473, -9401, -11324, -13224, -15084, -16902, -18659, -20345, -21957, -23477, -24900, -26223, -27433, -28528, -29504, -30354, -31078, -31675, -32141, -32478, -32687, -32768, -32726, -32565, -32287, -31899, -31406, -30816, -30134, -29367, -28527, -27617, -26646, -25627, -24563, -23465, -22344, -21203, -20054, -18904, -17756, -16620, -15498, -14352, -13114, -11767, -10318, -8784, -7174, -5498, -3776, -2016, -231, 1559, 3351, 5129, 6876, 8587, 10252, 11851, 13386, 14845, 16214, 17495, 18676, 19751, 20720, 21575, 22316, 22941, 23447, 23836, 24108, 24264, 24306, 24238, 24064, 23787, 23410, 22942, 22388, 21752, 21043, 20267, 19430, 18542, 17606, 16633, 15631, 14605, 13562, 12515, 11465, 10421, 9393, 8382, 7398, 6449, 5536, 4666, 3846, 3076, 2364, 1712, 1122, 595, 136, -255, -579, -834, -1021, -1141, -1194, -1183, -1109, -975, -783, -538, -240, 105, 493, 924, 1390, 1886, 2411, 2960, 3527, 4110, 4703, 5301, 5903, 6503, 7095, 7680, 8251, 8806, 9342, 9854, 10342, 10803, 11232, 11631, 11996, 12324, 12615, 12867, 13079, 13248, 13372, 13432, 13370, 13135, 12721, 12132, 11376, 10461, 9395, 8188, 6856, 5405, 3850, 2208, 486, -1298, -3128, -4998, -6887, -8781, -10675, -12548, -14386, -16188, -17932, -19610, -21217, -22737, -24166, -25497, -26718, -27829, -28826, -29698, -30449, -31075, -31572, -31944, -32190, -32317, -32307, -32071, -31568, -30806, -29799, -28564, -27110, -25458, -23627, -21624, -19475, -17200, -14808, -12327, -9776, -7168, -4532, -1826};