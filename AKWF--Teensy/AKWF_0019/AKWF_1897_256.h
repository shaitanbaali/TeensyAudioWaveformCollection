/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1897 256 samples */
 
const int16_t AKWF_1897_256_DATA [256] = 
{1422, 4086, 6786, 9528, 12220, 14840, 17327, 19627, 21768, 23746, 25521, 27102, 28448, 29547, 30394, 30978, 31266, 31280, 31080, 30734, 30317, 29902, 29550, 29313, 29164, 29087, 29088, 29173, 29339, 29579, 29884, 30251, 30717, 31274, 31851, 32393, 32747, 32758, 32764, 32610, 31998, 31128, 30022, 28703, 27175, 25481, 23646, 21691, 19563, 17274, 14927, 12651, 10551, 8755, 7342, 6391, 5935, 5925, 6267, 6853, 7566, 8285, 8900, 9331, 9603, 9756, 9807, 9786, 9728, 9670, 9646, 9680, 9747, 9828, 9922, 10025, 10132, 10241, 10347, 10447, 10542, 10637, 10731, 10824, 10917, 11010, 11103, 11197, 11290, 11383, 11477, 11571, 11663, 11758, 11853, 11949, 12047, 12148, 12249, 12348, 12444, 12534, 12616, 12689, 12743, 12782, 12815, 12855, 12914, 13006, 13137, 13312, 13495, 13675, 13859, 14054, 14266, 14495, 14731, 14984, 15360, 15823, 16207, 16335, 16031, 15125, 13487, 11008, 7580, 3381, -1368, -6359, -11233, -15685, -19423, -22209, -24109, -25207, -25629, -25541, -25133, -24584, -24072, -23724, -23461, -23219, -23015, -22839, -22681, -22531, -22374, -22203, -22053, -21942, -21859, -21796, -21744, -21691, -21629, -21550, -21460, -21365, -21264, -21157, -21049, -20939, -20832, -20728, -20625, -20522, -20420, -20318, -20217, -20116, -20013, -19912, -19809, -19707, -19605, -19502, -19399, -19297, -19194, -19092, -18991, -18889, -18787, -18686, -18583, -18481, -18380, -18277, -18176, -18073, -17971, -17870, -17767, -17665, -17564, -17462, -17360, -17259, -17157, -17055, -16954, -16853, -16751, -16649, -16548, -16446, -16346, -16245, -16145, -16043, -15941, -15839, -15737, -15635, -15532, -15429, -15327, -15226, -15128, -15032, -14941, -14857, -14776, -14689, -14593, -14483, -14354, -14203, -14001, -13752, -13490, -13248, -13061, -12963, -12977, -13122, -13421, -13839, -14303, -14727, -15033, -15131, -14946, -14422, -13589, -12475, -11080, -9439, -7581, -5531, -3351, -978};