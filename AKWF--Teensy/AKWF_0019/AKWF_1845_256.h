/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1845 256 samples */
 
const int16_t AKWF_1845_256_DATA [256] = 
{348, 849, 1339, 1825, 2308, 2786, 3262, 3732, 4200, 4664, 5122, 5576, 6027, 6471, 6911, 7349, 7779, 8205, 8626, 9042, 9453, 9859, 10260, 10655, 11045, 11429, 11810, 12183, 12551, 12915, 13273, 13622, 13970, 14310, 14644, 14974, 15297, 15614, 15927, 16232, 16533, 16826, 17115, 17398, 17674, 17945, 18210, 18470, 18723, 18971, 19213, 19450, 19681, 19905, 20124, 20337, 20544, 20746, 20943, 21133, 21318, 21498, 21671, 21839, 22002, 22160, 22311, 22458, 22599, 22736, 22865, 22991, 23111, 23227, 23336, 23441, 23542, 23636, 23727, 23812, 23892, 23968, 24039, 24104, 24165, 24224, 24276, 24324, 24369, 24408, 24442, 24473, 24500, 24523, 24542, 24554, 24566, 24573, 24576, 24575, 24570, 24562, 24550, 24534, 24515, 24493, 24467, 24439, 24407, 24371, 24333, 24292, 24247, 24200, 24149, 24097, 24042, 23983, 23922, 23858, 23792, 23723, 23653, 23569, 23534, 23286, 21385, 19826, 18860, 17777, 16173, 14359, 12368, 10203, 7898, 5507, 3069, 634, -1753, -4072, -6299, -8413, -10416, -12300, -14061, -15709, -17244, -18667, -19988, -21212, -22343, -23390, -24356, -25245, -26065, -26819, -27511, -28147, -28729, -29260, -29744, -30182, -30580, -30938, -31258, -31543, -31794, -32012, -32201, -32360, -32492, -32596, -32676, -32730, -32762, -32768, -32757, -32721, -32665, -32592, -32497, -32384, -32255, -32106, -31943, -31763, -31566, -31354, -31128, -30888, -30633, -30365, -30085, -29790, -29485, -29167, -28839, -28499, -28147, -27788, -27417, -27034, -26645, -26247, -25839, -25423, -24999, -24567, -24130, -23684, -23230, -22772, -22307, -21835, -21361, -20878, -20391, -19901, -19406, -18907, -18403, -17895, -17384, -16872, -16355, -15837, -15316, -14792, -14267, -13741, -13211, -12683, -12152, -11622, -11091, -10558, -10026, -9495, -8962, -8431, -7901, -7372, -6842, -6316, -5791, -5266, -4743, -4222, -3703, -3188, -2673, -2161, -1653, -1148, -645, -137};