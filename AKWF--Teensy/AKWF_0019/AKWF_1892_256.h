/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1892 256 samples */
 
const int16_t AKWF_1892_256_DATA [256] = 
{963, 2460, 3834, 5097, 6239, 7271, 8201, 9058, 9860, 10631, 11389, 12153, 12928, 13699, 14466, 15224, 15964, 16676, 17364, 18014, 18631, 19223, 19783, 20313, 20806, 21255, 21657, 22007, 22301, 22542, 22730, 22884, 23013, 23130, 23254, 23398, 23570, 23770, 23994, 24242, 24519, 24826, 25162, 25528, 25923, 26345, 26803, 27287, 27789, 28296, 28805, 29304, 29785, 30240, 30671, 31077, 31456, 31800, 32108, 32373, 32600, 32754, 32763, 32752, 32744, 32735, 32730, 32713, 32532, 32250, 31909, 31508, 31039, 30500, 29898, 29225, 28482, 27676, 26797, 25851, 24844, 23774, 22654, 21483, 20262, 18999, 17703, 16367, 15010, 13621, 12206, 10778, 9338, 7894, 6452, 5008, 3570, 2150, 748, -622, -1966, -3273, -4539, -5751, -6922, -8039, -9088, -10064, -10955, -11749, -12450, -13049, -13547, -13946, -14244, -14443, -14544, -14549, -14462, -14284, -14014, -13657, -13223, -12725, -12170, -11575, -10949, -10298, -9623, -8930, -8226, -7527, -6833, -6160, -5515, -4908, -4343, -3820, -3339, -2902, -2509, -2157, -1848, -1574, -1342, -1155, -1011, -909, -844, -815, -817, -848, -906, -991, -1105, -1247, -1418, -1617, -1847, -2108, -2401, -2719, -3062, -3429, -3822, -4243, -4693, -5168, -5669, -6201, -6759, -7336, -7922, -8501, -9062, -9600, -10100, -10562, -10990, -11383, -11744, -12075, -12375, -12653, -12905, -13134, -13336, -13514, -13683, -13859, -14055, -14286, -14571, -14914, -15314, -15770, -16273, -16829, -17435, -18081, -18766, -19484, -20232, -21023, -21839, -22671, -23504, -24335, -25149, -25937, -26691, -27412, -28097, -28741, -29332, -29867, -30336, -30737, -31055, -31112, -31093, -31088, -31082, -31075, -31064, -31066, -31005, -30718, -30368, -29955, -29476, -28932, -28317, -27629, -26873, -26036, -25127, -24156, -23120, -22040, -20920, -19759, -18571, -17366, -16146, -14919, -13662, -12373, -11049, -9681, -8267, -6802, -5278, -3709, -2124, -519};