/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1874 256 samples */
 
const int16_t AKWF_1874_256_DATA [256] = 
{1150, 3162, 5217, 7334, 9481, 11635, 13773, 15867, 17908, 19875, 21745, 23515, 25171, 26692, 28072, 29299, 30358, 31243, 31933, 32422, 32702, 32766, 32618, 32263, 31713, 30983, 30081, 29028, 27844, 26547, 25158, 23702, 22200, 20683, 19162, 17664, 16234, 14884, 13630, 12499, 11497, 10625, 9872, 9218, 8652, 8160, 7721, 7323, 6962, 6639, 6355, 6113, 5913, 5759, 5647, 5567, 5509, 5461, 5412, 5348, 5259, 5135, 4969, 4744, 4458, 4105, 3682, 3186, 2621, 1986, 1288, 538, -257, -1094, -1958, -2844, -3742, -4637, -5524, -6391, -7234, -8047, -8818, -9547, -10237, -10882, -11476, -12021, -12514, -12953, -13335, -13650, -13895, -14069, -14164, -14179, -14121, -13995, -13803, -13548, -13237, -12870, -12449, -11977, -11451, -10876, -10261, -9604, -8912, -8198, -7467, -6728, -5990, -5253, -4525, -3810, -3110, -2435, -1784, -1165, -581, -40, 456, 898, 1281, 1604, 1863, 2058, 2185, 2240, 2230, 2158, 2023, 1834, 1605, 1348, 1070, 785, 498, 218, -47, -299, -540, -768, -982, -1187, -1380, -1558, -1722, -1868, -1986, -2076, -2137, -2165, -2164, -2138, -2086, -2012, -1924, -1825, -1720, -1616, -1517, -1426, -1348, -1281, -1232, -1199, -1180, -1179, -1200, -1241, -1303, -1382, -1481, -1594, -1718, -1852, -1998, -2157, -2327, -2513, -2717, -2943, -3190, -3455, -3738, -4038, -4351, -4674, -5007, -5345, -5687, -6026, -6366, -6708, -7035, -7348, -7648, -7935, -8206, -8450, -8661, -8839, -8994, -9128, -9241, -9342, -9432, -9509, -9572, -9627, -9675, -9711, -9733, -9743, -9736, -9716, -9686, -9643, -9589, -9528, -9470, -9416, -9367, -9322, -9284, -9254, -9238, -9243, -9270, -9321, -9398, -9501, -9626, -9771, -9935, -10116, -10304, -10482, -10639, -10771, -10858, -10873, -10803, -10642, -10368, -9954, -9393, -8677, -7787, -6716, -5464, -4038, -2453, -676};