/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1846 256 samples */
 
const int16_t AKWF_1846_256_DATA [256] = 
{682, 2503, 4240, 5923, 7534, 9072, 10537, 11920, 13228, 14463, 15626, 16722, 17755, 18725, 19639, 20501, 21310, 22073, 22793, 23468, 24107, 24707, 25273, 25807, 26308, 26779, 27224, 27640, 28032, 28400, 28743, 29064, 29363, 29641, 29899, 30139, 30359, 30560, 30745, 30912, 31063, 31198, 31316, 31418, 31506, 31579, 31638, 31684, 31715, 31733, 31738, 31731, 31712, 31680, 31636, 31582, 31514, 31437, 31349, 31251, 31141, 31023, 30894, 30756, 30608, 30451, 30288, 30114, 29932, 29741, 29543, 29338, 29125, 28905, 28679, 28444, 28203, 27958, 27704, 27444, 27180, 26911, 26634, 26355, 26070, 25778, 25484, 25185, 24880, 24573, 24263, 23947, 23630, 23308, 22984, 22656, 22326, 21993, 21658, 21320, 20980, 20639, 20297, 19951, 19605, 19258, 18908, 18557, 18207, 17857, 17504, 17151, 16799, 16446, 16092, 15739, 15386, 15033, 14682, 14322, 14014, 13162, 12575, 11484, 10387, 9088, 7622, 6070, 4431, 2720, 949, -852, -2648, -4426, -6163, -7838, -9446, -10982, -12438, -13819, -15124, -16350, -17506, -18594, -19615, -20575, -21476, -22322, -23118, -23866, -24565, -25224, -25844, -26425, -26971, -27482, -27962, -28412, -28834, -29227, -29595, -29940, -30259, -30556, -30829, -31083, -31317, -31531, -31725, -31902, -32059, -32199, -32325, -32433, -32525, -32601, -32663, -32710, -32743, -32762, -32767, -32758, -32739, -32705, -32659, -32601, -32532, -32451, -32360, -32257, -32143, -32019, -31884, -31742, -31588, -31425, -31253, -31074, -30884, -30685, -30480, -30267, -30046, -29816, -29581, -29336, -29087, -28832, -28570, -28300, -28026, -27745, -27459, -27168, -26872, -26570, -26264, -25955, -25640, -25321, -24999, -24672, -24342, -24009, -23671, -23332, -22992, -22646, -22299, -21949, -21597, -21243, -20887, -20530, -20172, -19812, -19450, -19088, -18725, -18360, -17997, -17632, -17262, -16908, -16494, -15593, -14984, -13764, -12659, -11272, -9762, -8168, -6491, -4741, -2944, -1089};