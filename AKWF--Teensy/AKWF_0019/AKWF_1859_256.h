/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1859 256 samples */
 
const int16_t AKWF_1859_256_DATA [256] = 
{909, 4083, 6873, 9401, 11680, 13740, 15601, 17276, 18789, 20156, 21386, 22498, 23502, 24407, 25224, 25961, 26625, 27226, 27767, 28254, 28696, 29094, 29451, 29776, 30068, 30331, 30570, 30784, 30977, 31153, 31311, 31453, 31581, 31697, 31802, 31897, 31981, 32058, 32128, 32189, 32246, 32297, 32343, 32384, 32422, 32456, 32485, 32514, 32539, 32561, 32581, 32600, 32615, 32630, 32644, 32656, 32667, 32676, 32686, 32693, 32701, 32707, 32713, 32718, 32724, 32728, 32732, 32734, 32739, 32741, 32744, 32746, 32748, 32750, 32752, 32753, 32755, 32755, 32756, 32758, 32759, 32759, 32761, 32762, 32762, 32762, 32763, 32762, 32763, 32765, 32764, 32765, 32765, 32765, 32764, 32766, 32767, 32766, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32766, 32764, 32735, 32843, 31377, 26172, 20380, 15219, 10527, 6300, 2487, -961, -4066, -6868, -9402, -11681, -13741, -15602, -17276, -18789, -20156, -21387, -22498, -23503, -24407, -25224, -25962, -26625, -27226, -27767, -28255, -28697, -29094, -29452, -29776, -30068, -30331, -30570, -30784, -30977, -31153, -31311, -31453, -31581, -31697, -31802, -31897, -31981, -32058, -32128, -32189, -32246, -32297, -32343, -32384, -32422, -32456, -32485, -32514, -32539, -32561, -32581, -32600, -32615, -32630, -32644, -32656, -32667, -32676, -32686, -32693, -32701, -32707, -32713, -32718, -32724, -32728, -32732, -32734, -32739, -32741, -32744, -32746, -32748, -32750, -32752, -32753, -32755, -32755, -32756, -32758, -32759, -32759, -32761, -32762, -32762, -32762, -32763, -32762, -32763, -32765, -32764, -32764, -32765, -32765, -32764, -32766, -32767, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32767, -32766, -32764, -32735, -32843, -31377, -26172, -20381, -15219, -10534, -6314, -2444};