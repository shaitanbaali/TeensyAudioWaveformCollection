/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1882 256 samples */
 
const int16_t AKWF_1882_256_DATA [256] = 
{846, 2662, 4577, 6047, 7258, 8637, 9918, 10715, 11396, 12179, 12663, 12737, 13147, 14004, 14650, 15222, 16017, 16602, 16571, 16319, 16002, 15432, 14871, 14739, 14909, 14957, 14911, 14833, 14614, 14240, 13833, 13465, 13163, 13054, 13206, 13580, 14078, 14663, 15417, 16021, 16411, 16874, 17259, 17375, 17490, 17888, 18268, 18504, 18801, 19344, 19848, 20267, 20815, 21181, 21323, 21585, 21982, 22177, 22274, 22457, 22511, 22354, 22306, 22353, 22161, 21796, 21667, 21832, 21955, 22111, 22496, 22868, 23066, 23347, 23789, 24203, 24678, 25432, 26324, 27020, 27559, 28020, 28199, 28201, 28208, 28175, 27957, 27687, 27445, 27109, 26666, 26063, 25190, 23979, 22576, 20939, 19031, 17011, 14972, 12868, 10709, 8561, 6293, 3894, 1502, -890, -3345, -5847, -8233, -10458, -12652, -14779, -16744, -18684, -20722, -22673, -24442, -26133, -27738, -29055, -30033, -30894, -31589, -32009, -32326, -32629, -32766, -32704, -32551, -32197, -31539, -30682, -29686, -28506, -27235, -25995, -24645, -23208, -21852, -20516, -19073, -17625, -16276, -14879, -13454, -12252, -11286, -10357, -9520, -8963, -8595, -8233, -7974, -7922, -7951, -8030, -8336, -8882, -9504, -10266, -11299, -12467, -13634, -14911, -16289, -17618, -18936, -20366, -21870, -23275, -24610, -25945, -27153, -28151, -28962, -29603, -30078, -30413, -30586, -30608, -30491, -30170, -29562, -28666, -27628, -26431, -24963, -23308, -21602, -19796, -17766, -15611, -13466, -11198, -8674, -6061, -3309, -159, 3122, 6199, 9101, 11672, 13561, 14966, 16293, 17375, 18059, 18728, 19487, 19845, 19821, 19828, 19618, 18819, 17778, 16685, 15139, 13165, 11189, 9142, 6803, 4447, 2269, -35, -2443, -4511, -6272, -7999, -9561, -10860, -12229, -13838, -15455, -16925, -18348, -19664, -20544, -20901, -20928, -20634, -19951, -18973, -17811, -16502, -15109, -13801, -12659, -11592, -10470, -9177, -7669, -6200, -4875, -3450, -1984, -560};