/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1888 256 samples */
 
const int16_t AKWF_1888_256_DATA [256] = 
{467, 1177, 1796, 2340, 2808, 3209, 3553, 3851, 4116, 4357, 4579, 4784, 4977, 5168, 5379, 5626, 5912, 6236, 6587, 6963, 7359, 7763, 8173, 8589, 9007, 9416, 9808, 10177, 10522, 10849, 11160, 11460, 11754, 12048, 12346, 12653, 12975, 13316, 13674, 14047, 14442, 14866, 15320, 15799, 16296, 16804, 17327, 17859, 18395, 18929, 19457, 19975, 20485, 20985, 21470, 21937, 22381, 22802, 23210, 23613, 24021, 24439, 24863, 25288, 25708, 26114, 26513, 26921, 27348, 27793, 28250, 28709, 29172, 29640, 30110, 30571, 31001, 31385, 31722, 32019, 32280, 32497, 32657, 32747, 32767, 32725, 32629, 32477, 32261, 31976, 31622, 31204, 30730, 30196, 29602, 28954, 28260, 27528, 26759, 25958, 25141, 24312, 23475, 22634, 21787, 20938, 20096, 19259, 18434, 17631, 16851, 16099, 15378, 14677, 13987, 13295, 12582, 11834, 11036, 10181, 9277, 8337, 7374, 6392, 5386, 4359, 3332, 2320, 1338, 396, -499, -1350, -2160, -2932, -3671, -4375, -5046, -5677, -6263, -6815, -7344, -7852, -8332, -8778, -9195, -9597, -9986, -10363, -10733, -11097, -11458, -11814, -12164, -12505, -12840, -13165, -13483, -13799, -14121, -14453, -14795, -15145, -15506, -15873, -16240, -16605, -16969, -17333, -17694, -18046, -18379, -18703, -19023, -19352, -19686, -20013, -20320, -20611, -20902, -21210, -21562, -21958, -22388, -22828, -23262, -23684, -24103, -24524, -24954, -25395, -25839, -26279, -26709, -27125, -27519, -27878, -28186, -28438, -28635, -28777, -28862, -28895, -28898, -28890, -28878, -28851, -28795, -28705, -28592, -28474, -28367, -28270, -28171, -28056, -27919, -27766, -27608, -27448, -27284, -27106, -26900, -26653, -26349, -25979, -25542, -25048, -24515, -23956, -23374, -22764, -22124, -21458, -20770, -20065, -19344, -18608, -17861, -17102, -16314, -15489, -14627, -13729, -12801, -11851, -10881, -9896, -8904, -7906, -6911, -5913, -4907, -3907, -2932, -1995, -1114, -276};