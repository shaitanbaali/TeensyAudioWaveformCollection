/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1871 256 samples */
 
const int16_t AKWF_1871_256_DATA [256] = 
{968, 3157, 5314, 7474, 9613, 11721, 13785, 15786, 17718, 19570, 21324, 22979, 24525, 25949, 27251, 28422, 29456, 30354, 31111, 31725, 32197, 32527, 32716, 32768, 32685, 32471, 32131, 31673, 31101, 30421, 29643, 28774, 27820, 26794, 25702, 24552, 23358, 22125, 20863, 19585, 18295, 17002, 15722, 14456, 13214, 12007, 10837, 9714, 8647, 7635, 6688, 5812, 5006, 4277, 3629, 3060, 2576, 2175, 1858, 1627, 1480, 1414, 1429, 1523, 1692, 1933, 2244, 2620, 3054, 3545, 4089, 4677, 5306, 5970, 6664, 7382, 8120, 8868, 9627, 10387, 11142, 11893, 12628, 13345, 14041, 14711, 15349, 15956, 16525, 17053, 17539, 17982, 18376, 18724, 19022, 19271, 19469, 19617, 19716, 19765, 19765, 19719, 19627, 19492, 19314, 19098, 18846, 18558, 18240, 17892, 17520, 17125, 16714, 16285, 15843, 15395, 14939, 14482, 14026, 13572, 13125, 12689, 12263, 11854, 11462, 11088, 10735, 10406, 10104, 9778, 9302, 8660, 7867, 6930, 5856, 4662, 3355, 1947, 456, -1114, -2748, -4426, -6144, -7888, -9639, -11394, -13135, -14848, -16532, -18168, -19745, -21263, -22704, -24062, -25336, -26513, -27588, -28561, -29424, -30175, -30814, -31336, -31742, -32036, -32226, -32316, -32307, -32204, -32008, -31723, -31355, -30907, -30384, -29794, -29140, -28428, -27669, -26863, -26020, -25148, -24250, -23335, -22412, -21481, -20555, -19638, -18733, -17850, -16993, -16164, -15374, -14624, -13915, -13256, -12647, -12090, -11592, -11150, -10764, -10428, -10138, -9897, -9706, -9562, -9466, -9417, -9416, -9459, -9546, -9675, -9844, -10049, -10291, -10564, -10867, -11197, -11552, -11925, -12318, -12724, -13141, -13568, -13997, -14428, -14861, -15287, -15706, -16116, -16514, -16896, -17263, -17610, -17935, -18240, -18518, -18771, -19000, -19199, -19371, -19514, -19630, -19638, -19429, -19003, -18369, -17536, -16518, -15322, -13965, -12461, -10819, -9059, -7198, -5245, -3225, -1103};