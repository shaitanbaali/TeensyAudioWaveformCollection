/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1827 256 samples */
 
const int16_t AKWF_1827_256_DATA [256] = 
{292, 806, 1263, 1705, 2105, 2466, 2913, 2817, 4214, 19960, 27563, 27747, 27008, 25847, 24614, 23409, 22256, 21153, 20105, 19112, 18166, 17268, 16416, 15606, 14836, 14107, 13411, 12753, 12129, 11534, 10971, 10436, 9928, 9446, 8989, 8555, 8144, 7755, 7384, 7034, 6702, 6387, 6088, 5805, 5537, 5285, 5046, 4818, 4604, 4401, 4211, 4029, 3859, 3699, 3548, 3406, 3271, 3145, 3028, 2918, 2814, 2716, 2627, 2544, 2465, 2393, 2326, 2265, 2208, 2158, 2110, 2068, 2030, 1996, 1966, 1941, 1835, 2294, 329, -4568, -1577, -849, -598, -483, -412, -357, -308, -260, -214, -171, -129, -88, -48, -9, 27, 64, 100, 134, 168, 203, 236, 268, 299, 331, 363, 393, 424, 454, 485, 513, 543, 574, 602, 632, 663, 693, 723, 753, 783, 814, 845, 877, 909, 941, 973, 1007, 1041, 1076, 1110, 1145, 1182, 1218, 1257, 1294, 1333, 1374, 1415, 1458, 1503, 1547, 1593, 1642, 1690, 1740, 1791, 1844, 1899, 1956, 2015, 2075, 2136, 2199, 2264, 2332, 2403, 2475, 2547, 2625, 2707, 2789, 2874, 2960, 3049, 3143, 3240, 3338, 3440, 3545, 3652, 3762, 3876, 3993, 4114, 4235, 4361, 4487, 4613, 4742, 4873, 5004, 5133, 5261, 5383, 5504, 5613, 5712, 5801, 5872, 5926, 5957, 5956, 5921, 5841, 5711, 5521, 5259, 4917, 4482, 3935, 3270, 2466, 1514, 400, -893, -2358, -3994, -5818, -7800, -9923, -12195, -14529, -16889, -19275, -21588, -23792, -25801, -27627, -29203, -30456, -31462, -32195, -32620, -32766, -32642, -32286, -31730, -30978, -30071, -29041, -27896, -26674, -25391, -24059, -22703, -21338, -19969, -18611, -17277, -15965, -14689, -13451, -12248, -11091, -9981, -8915, -7896, -6926, -6002, -5126, -4296, -3517, -2773, -2078, -1430, -815, -232};