/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1810 256 samples */
 
const int16_t AKWF_1810_256_DATA [256] = 
{2139, 5367, 6644, 8082, 12019, 17758, 23493, 26866, 25453, 20617, 17228, 18655, 23200, 25871, 24038, 20803, 20025, 21456, 22796, 22366, 20133, 16737, 12939, 9424, 7576, 9296, 14744, 22919, 30005, 31552, 30342, 28332, 24675, 23277, 23989, 21702, 16070, 10610, 8186, 8952, 10790, 12114, 12546, 11887, 10302, 9323, 10005, 11402, 12786, 14161, 15078, 14830, 14908, 16509, 18757, 20676, 21050, 19126, 16371, 13408, 8756, 2971, -618, -456, 934, 2109, 4222, 6541, 7402, 6737, 4695, 2176, 499, -514, -1437, -2345, -3383, -4987, -7314, -9808, -12342, -15209, -17837, -20067, -22117, -22958, -22848, -22681, -22234, -21378, -20659, -20342, -19784, -18759, -17514, -16488, -16308, -16482, -16488, -16255, -15564, -15175, -14804, -14045, -14091, -13651, -12224, -11349, -10110, -9080, -8638, -7195, -5284, -3456, -1945, -605, 1134, 2879, 4772, 6404, 7201, 7663, 8140, 9262, 10927, 12205, 13562, 15068, 15914, 16446, 16989, 17240, 17772, 18657, 19238, 19759, 19916, 20210, 21329, 21753, 21940, 21964, 20911, 19897, 19024, 18679, 18001, 16353, 15947, 15807, 14834, 14108, 13272, 13092, 13039, 11812, 10420, 9394, 9543, 9536, 8305, 8225, 8150, 7502, 7409, 5939, 4452, 4907, 4732, 4481, 5580, 4237, 2464, 3632, 4308, 5003, 3583, -247, 50, 362, -1343, -1378, -2139, -2118, -1526, -4313, -7038, -6687, -5753, -6732, -7461, -5969, -6145, -9048, -11767, -13484, -12270, -9001, -9270, -11860, -14593, -19468, -19716, -14919, -14312, -16934, -22509, -27435, -23431, -18812, -19052, -20790, -24579, -27184, -28716, -31818, -31521, -26095, -21593, -22296, -26450, -30451, -31778, -29695, -26268, -23144, -21363, -23811, -29714, -32794, -31869, -29902, -25772, -21427, -19778, -19744, -21322, -21149, -16918, -14850, -17862, -21388, -22029, -18753, -13210, -7963, -2720, 1132, 52, -4136, -6645, -7181, -8765, -9983, -7026, -1983};