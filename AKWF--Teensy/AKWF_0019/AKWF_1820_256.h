/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1820 256 samples */
 
const int16_t AKWF_1820_256_DATA [256] = 
{24470, 32822, 26973, 23282, 20768, 19004, 17721, 16759, 16007, 15405, 14911, 14389, 14790, 1827, 11438, 14993, 14628, 15175, 15719, 16396, 17266, 18413, 19979, 22210, 25387, 30729, 30454, 1570, -13178, -7484, -3411, -2118, -2282, -2243, -2244, -2246, -2245, -2245, -2245, -2245, -2245, -2246, -2244, -2243, -2244, -2243, -2241, -2241, -2240, -2239, -2238, -2237, -2235, -2234, -2233, -2232, -2231, -2229, -2228, -2227, -2225, -2224, -2222, -2221, -2219, -2218, -2216, -2215, -2213, -2212, -2210, -2209, -2207, -2206, -2204, -2203, -2201, -2199, -2198, -2196, -2195, -2193, -2192, -2190, -2188, -2187, -2185, -2184, -2182, -2181, -2179, -2178, -2176, -2174, -2173, -2171, -2170, -2168, -2167, -2165, -2163, -2162, -2160, -2159, -2157, -2156, -2154, -2153, -2151, -2149, -2148, -2146, -2145, -2143, -2141, -2139, -2137, -2136, -2134, -2133, -2131, -2130, -2128, -2127, -2125, -2124, -2122, -2121, -2119, -2117, -2116, -2114, -2113, -2111, -2110, -2108, -2107, -2105, -2104, -2102, -2101, -2099, -2098, -2096, -2094, -2093, -2091, -2090, -2088, -2087, -2085, -2084, -2082, -2081, -2079, -2077, -2076, -2075, -2073, -2072, -2070, -2068, -2067, -2065, -2064, -2062, -2061, -2060, -2058, -2056, -2055, -2054, -2052, -2050, -2049, -2047, -2046, -2044, -2043, -2041, -2040, -2038, -2037, -2036, -2034, -2032, -2031, -2029, -2028, -2026, -2025, -2023, -2022, -2020, -2019, -2017, -2015, -2013, -2012, -2011, -2009, -2008, -2006, -2005, -2003, -2001, -2000, -1999, -1997, -1996, -1994, -1993, -1991, -1990, -1988, -1987, -1985, -1984, -1982, -1981, -1979, -1978, -1977, -1975, -1974, -1972, -1971, -1969, -1968, -1966, -1965, -1963, -1962, -1960, -1959, -1958, -1956, -1955, -1953, -1952, -1950, -1949, -1947, -1946, -1944, -1943, -1941, -1940, -1939, -1937, -1964, -1865, -2365, -5739, -11525, -6334};