/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1816 256 samples */
 
const int16_t AKWF_1816_256_DATA [256] = 
{16835, 11580, 11528, 10945, 10816, 10781, 10820, 10903, 11017, 11156, 11314, 11492, 11687, 11899, 12131, 12384, 12658, 12958, 13284, 13640, 14030, 14458, 14927, 15445, 16016, 16646, 17344, 18118, 18977, 19928, 20984, 22149, 23438, 24844, 26360, 27951, 29555, 31050, 32232, 32771, 32221, 30050, 25867, 19633, 11933, 3877, -3481, -9490, -13935, -17014, -18996, -20168, -20784, -21018, -20998, -20810, -20518, -20155, -19748, -19314, -18863, -18401, -17932, -17459, -16981, -16502, -16017, -15530, -15040, -14549, -14057, -13567, -13074, -12587, -12102, -11625, -11154, -10689, -10234, -9791, -9365, -8925, -8644, -8973, -9407, -9848, -10314, -10807, -11320, -11853, -12409, -12984, -13570, -14173, -14780, -15391, -15998, -16596, -17175, -17733, -18257, -18743, -19182, -19561, -19884, -20138, -20323, -20435, -20475, -20442, -20336, -20162, -19923, -19622, -19262, -18850, -18377, -17851, -17276, -16640, -15957, -15211, -14375, -13572, -12375, -10727, -9160, -7423, -5594, -3708, -1803, 121, 2019, 3840, 5577, 7211, 8723, 10087, 11290, 12360, 13250, 13985, 14578, 15026, 15308, 15451, 15481, 15355, 15109, 14761, 14304, 13740, 13093, 12342, 11565, 10726, 9862, 8964, 8068, 7184, 6359, 5603, 4907, 4323, 3811, 3439, 3175, 3073, 3086, 3278, 3622, 4134, 4817, 5646, 6647, 7815, 9090, 10520, 12062, 13678, 15348, 17032, 18685, 20304, 21824, 23247, 24550, 25718, 26741, 27610, 28354, 28971, 29466, 29845, 30128, 30317, 30416, 30420, 30349, 30172, 29890, 29465, 28883, 28102, 27066, 25725, 24014, 21845, 19194, 15987, 12247, 8077, 3616, -982, -5413, -9488, -12968, -15786, -17922, -19410, -20347, -20842, -20996, -20909, -20655, -20296, -19881, -19444, -19007, -18593, -18212, -17870, -17578, -17333, -17145, -17012, -16933, -16910, -16939, -17024, -17161, -17348, -17580, -17857, -18175, -18522, -18889, -19269, -19641, -19987, -20285, -20505, -20619, -20599, -20419, -20040};