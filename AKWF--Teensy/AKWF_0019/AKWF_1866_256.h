/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1866 256 samples */
 
const int16_t AKWF_1866_256_DATA [256] = 
{1665, 4479, 6955, 9197, 11218, 13043, 14693, 16177, 17517, 18726, 19813, 20796, 21681, 22477, 23196, 23844, 24425, 24949, 25422, 25846, 26227, 26571, 26879, 27155, 27403, 27625, 27825, 28004, 28163, 28306, 28433, 28547, 28648, 28738, 28816, 28887, 28949, 29002, 29050, 29090, 29126, 29156, 29183, 29205, 29223, 29238, 29250, 29260, 29266, 29273, 29275, 29276, 29276, 29274, 29270, 29264, 29260, 29254, 29245, 29237, 29227, 29217, 29207, 29196, 29185, 29173, 29162, 29149, 29136, 29123, 29110, 29097, 29084, 29063, 28969, 29356, 25318, 15672, 8804, 3584, 134, -3188, -6151, -8818, -11230, -13405, -15362, -17134, -18729, -20165, -21463, -22632, -23684, -24635, -25491, -26261, -26955, -27580, -28144, -28650, -29105, -29514, -29882, -30211, -30509, -30775, -31012, -31227, -31418, -31589, -31741, -31877, -31998, -32106, -32201, -32286, -32361, -32426, -32483, -32534, -32578, -32614, -32647, -32675, -32697, -32717, -32732, -32745, -32753, -32760, -32765, -32767, -32768, -32767, -32764, -32759, -32753, -32746, -32739, -32730, -32721, -32710, -32698, -32687, -32674, -32661, -32648, -32635, -32619, -32553, -32770, -30364, -24411, -19116, -14327, -10001, -6101, -2572, 607, 3473, 6066, 8399, 10505, 12409, 14121, 15668, 17064, 18320, 19454, 20477, 21397, 22228, 22977, 23650, 24257, 24804, 25295, 25739, 26136, 26492, 26814, 27104, 27362, 27594, 27804, 27989, 28156, 28305, 28438, 28555, 28661, 28755, 28839, 28911, 28977, 29034, 29084, 29129, 29166, 29199, 29225, 29245, 29224, 29438, 26599, 20626, 15421, 10696, 6437, 2581, -895, -4023, -6856, -9409, -11708, -13787, -15659, -17348, -18873, -20247, -21483, -22600, -23607, -24513, -25332, -26066, -26729, -27327, -27863, -28347, -28782, -29171, -29522, -29837, -30121, -30374, -30601, -30806, -30987, -31150, -31295, -31424, -31540, -31641, -31732, -31812, -31869, -31932, -31995, -28215, -22287, -17245, -12645, -8487, -4743, -1311};