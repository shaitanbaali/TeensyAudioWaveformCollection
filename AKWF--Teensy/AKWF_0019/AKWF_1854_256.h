/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1854 256 samples */
 
const int16_t AKWF_1854_256_DATA [256] = 
{574, 1619, 2694, 3815, 4973, 6162, 7377, 8604, 9842, 11083, 12317, 13543, 14755, 15946, 17117, 18264, 19382, 20474, 21536, 22563, 23559, 24517, 25433, 26311, 27144, 27927, 28661, 29339, 29962, 30527, 31029, 31472, 31851, 32167, 32416, 32599, 32717, 32766, 32746, 32656, 32493, 32258, 31948, 31562, 31100, 30564, 29951, 29266, 28512, 27688, 26799, 25856, 24858, 23816, 22739, 21626, 20494, 19349, 18195, 17043, 15900, 14766, 13652, 12557, 11480, 10428, 9395, 8379, 7379, 6393, 5416, 4449, 3487, 2531, 1584, 643, -290, -1209, -2119, -3015, -3890, -4749, -5588, -6402, -7195, -7962, -8704, -9422, -10114, -10776, -11410, -12011, -12579, -13113, -13609, -14066, -14486, -14865, -15203, -15503, -15762, -15985, -16174, -16330, -16458, -16560, -16641, -16702, -16748, -16782, -16806, -16823, -16835, -16841, -16844, -16841, -16833, -16817, -16791, -16751, -16693, -16617, -16519, -16395, -16247, -16072, -15872, -15648, -15401, -15137, -14856, -14561, -14254, -13937, -13609, -13272, -12924, -12563, -12187, -11792, -11378, -10943, -10484, -10004, -9504, -8983, -8446, -7898, -7342, -6782, -6226, -5674, -5134, -4610, -4099, -3608, -3137, -2687, -2256, -1844, -1450, -1073, -712, -367, -38, 278, 577, 855, 1111, 1342, 1543, 1708, 1834, 1915, 1949, 1932, 1861, 1740, 1567, 1348, 1087, 790, 466, 122, -232, -591, -946, -1290, -1622, -1937, -2234, -2513, -2779, -3031, -3275, -3516, -3756, -3998, -4248, -4505, -4774, -5054, -5342, -5641, -5950, -6264, -6586, -6914, -7245, -7581, -7922, -8266, -8616, -8969, -9325, -9685, -10045, -10403, -10756, -11102, -11435, -11750, -12040, -12301, -12527, -12712, -12850, -12937, -12972, -12951, -12873, -12739, -12552, -12316, -12034, -11711, -11354, -10971, -10563, -10137, -9697, -9244, -8783, -8313, -7827, -7327, -6808, -6264, -5689, -5081, -4427, -3728, -2979, -2173, -1313, -375};