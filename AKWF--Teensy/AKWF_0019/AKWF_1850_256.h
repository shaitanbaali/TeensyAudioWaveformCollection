/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1850 256 samples */
 
const int16_t AKWF_1850_256_DATA [256] = 
{545, 1501, 4511, 7714, 9862, 11441, 12580, 13398, 13989, 14414, 14719, 14938, 15096, 15208, 15289, 15346, 15386, 15415, 15434, 15476, 15361, 16158, 19141, 21496, 23141, 24337, 25199, 25817, 26262, 26581, 26808, 26971, 27086, 27161, 27215, 27287, 25215, 22331, 20417, 19010, 17993, 17259, 16730, 16345, 16068, 15867, 15720, 15614, 15535, 15477, 15435, 15403, 15409, 15245, 16395, 19430, 21623, 23187, 24325, 25141, 25726, 26146, 26447, 26663, 26817, 26925, 27002, 27056, 27092, 27117, 27133, 27142, 27116, 27257, 26234, 23198, 20937, 19335, 18166, 17322, 16715, 16274, 15955, 15726, 15558, 15436, 15347, 15281, 15232, 15196, 15168, 15146, 15130, 15116, 15106, 15097, 15090, 15078, 15069, 15095, 12991, 10085, 8156, 6739, 5714, 4974, 4443, 4059, 3780, 3580, 3436, 3331, 3254, 3199, 3160, 3129, 3106, 3114, 3011, 3466, 6447, 7743, 6402, 5461, 4802, 4290, 4021, 6151, 8756, 10469, 11731, 12613, 13414, 12539, 9828, 7933, 6563, 5569, 4855, 4338, 3965, 3697, 3503, 3363, 3263, 3189, 3135, 3098, 3069, 3048, 3033, 3006, 3037, 2808, 326, -4361, -9102, -12384, -14772, -16523, -17631, -19445, -23100, -25860, -27810, -29225, -30246, -30977, -31503, -31880, -32150, -32343, -32480, -32577, -32646, -32692, -32723, -32744, -32757, -32765, -32767, -32768, -32766, -32762, -32758, -32752, -32728, -32776, -32497, -29830, -27186, -25407, -24093, -23149, -22464, -21970, -21612, -21353, -21164, -21026, -20924, -20850, -20794, -20752, -20720, -20697, -20678, -20662, -20648, -20638, -20627, -20620, -20611, -20605, -20597, -20590, -20584, -20578, -20572, -20566, -20560, -20554, -20548, -20543, -20539, -20532, -20526, -20521, -20514, -20508, -20504, -20499, -20493, -20487, -20481, -20477, -20471, -20438, -20549, -19815, -16853, -14465, -12800, -11588, -10711, -10079, -9623, -9292, -9054, -8880, -8723, -8778, -7476, -4379, -2168, -565};