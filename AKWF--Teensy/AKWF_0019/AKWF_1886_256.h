/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1886 256 samples */
 
const int16_t AKWF_1886_256_DATA [256] = 
{624, 2575, 4213, 5637, 6860, 7913, 8837, 9640, 10333, 10929, 11437, 11882, 12270, 12609, 12887, 13105, 13281, 13417, 13517, 13589, 13649, 13701, 13746, 13785, 13819, 13846, 13857, 13852, 13836, 13810, 13772, 13722, 13664, 13600, 13536, 13474, 13415, 13358, 13303, 13250, 13197, 13146, 13093, 13039, 12984, 12928, 12873, 12823, 12780, 12736, 12689, 12639, 12585, 12532, 12484, 12442, 12405, 12373, 12344, 12316, 12285, 12251, 12214, 12176, 12136, 12093, 12047, 11997, 11944, 11889, 11830, 11771, 11710, 11648, 11586, 11526, 11468, 11411, 11355, 11300, 11248, 11200, 11158, 11121, 11088, 11059, 11032, 11008, 10982, 10953, 10922, 10888, 10853, 10817, 10779, 10739, 10697, 10654, 10611, 10565, 10519, 10473, 10427, 10381, 10334, 10288, 10241, 10195, 10148, 10102, 10055, 10009, 9962, 9916, 9869, 9824, 9779, 9734, 9690, 9646, 9602, 9558, 9510, 9459, 9402, 9344, 9282, 9219, 9153, 9086, 9022, 8960, 8900, 8843, 8786, 8730, 8674, 8612, 8548, 8480, 8409, 8336, 8261, 8181, 8097, 8008, 7916, 7820, 7721, 7619, 7516, 7410, 7303, 7197, 7094, 6996, 6901, 6808, 6711, 6612, 6471, 6298, 6119, 5932, 5739, 5541, 5333, 5086, 4808, 4548, 4308, 4033, 3680, 3284, 2849, 2379, 1883, 1353, 710, 48, -548, -1171, -2003, -2912, -3726, -4451, -5188, -6120, -7207, -8467, -9862, -11346, -12869, -14302, -15641, -16905, -18095, -19218, -20343, -21487, -22527, -23474, -24383, -25222, -25983, -26686, -27358, -27960, -28482, -28939, -29340, -29722, -30093, -30420, -30704, -30961, -31199, -31419, -31613, -31781, -31928, -32055, -32165, -32260, -32343, -32414, -32475, -32527, -32571, -32610, -32643, -32670, -32692, -32711, -32727, -32739, -32749, -32756, -32762, -32765, -32767, -32768, -32767, -32766, -32764, -32754, -32719, -32875, -29594, -23620, -18647, -14231, -10377, -7016, -4093, -1524};