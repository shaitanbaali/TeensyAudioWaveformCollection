/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1876 256 samples */
 
const int16_t AKWF_1876_256_DATA [256] = 
{243, 668, 1094, 1531, 1954, 2370, 2807, 3248, 3620, 3859, 3981, 4083, 4250, 4481, 4726, 4943, 5096, 5198, 5323, 5512, 5707, 5849, 5998, 6217, 6442, 6612, 6812, 7091, 7351, 7577, 7903, 8375, 8857, 9280, 9748, 10319, 10907, 11459, 12060, 12745, 13415, 14050, 14786, 15671, 16530, 17238, 17894, 18613, 19327, 19908, 20362, 20835, 21381, 21843, 22109, 22252, 22324, 22288, 22203, 22176, 22116, 21846, 21432, 21048, 20656, 20168, 19669, 19173, 18454, 17426, 16400, 15588, 14836, 14222, 14069, 13813, 12142, 8869, 5213, 1850, -1596, -5061, -7858, -10069, -12482, -15376, -18609, -22168, -25747, -28617, -30468, -31686, -32524, -32771, -32487, -32222, -32204, -32014, -31211, -29786, -27916, -25660, -23107, -20528, -18188, -16166, -14450, -13020, -11731, -10319, -8733, -7263, -6165, -5464, -5165, -5325, -5888, -6640, -7370, -7966, -8439, -8890, -9417, -10084, -10938, -11904, -12771, -13389, -13717, -13703, -13374, -12901, -12447, -12025, -11568, -11026, -10298, -9262, -7931, -6468, -5073, -3853, -2803, -1896, -1104, -346, 446, 1248, 1959, 2505, 2872, 3069, 3105, 2989, 2736, 2406, 2087, 1827, 1583, 1259, 800, 222, -380, -883, -1222, -1413, -1499, -1517, -1478, -1373, -1264, -1205, -1108, -843, -401, 142, 717, 1240, 1680, 2109, 2573, 2972, 3258, 3554, 3917, 4186, 4194, 4005, 3804, 3666, 3518, 3297, 3053, 2866, 2700, 2422, 1978, 1464, 976, 543, 197, -59, -306, -568, -750, -873, -1114, -1491, -1766, -1801, -1726, -1666, -1580, -1438, -1288, -1122, -946, -869, -882, -806, -579, -355, -231, -135, -33, -7, -89, -218, -386, -601, -779, -868, -972, -1160, -1386, -1637, -1925, -2188, -2387, -2585, -2787, -2917, -2948, -2943, -2945, -2936, -2869, -2731, -2568, -2369, -2084, -1714, -1334, -987, -615, -179};