/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1807 256 samples */
 
const int16_t AKWF_1807_256_DATA [256] = 
{3337, 3206, 3034, 2834, 2598, 2421, 2514, 2635, 2749, 2869, 2990, 3112, 3238, 3365, 3494, 3626, 3748, 3947, 3669, 3505, 3699, 3822, 3952, 4082, 4210, 4337, 4465, 4592, 4719, 4845, 4970, 5096, 5223, 5348, 5474, 5599, 5724, 5849, 5974, 6099, 6225, 6349, 6473, 6599, 6724, 6849, 6972, 7096, 7222, 7345, 7469, 7592, 7717, 7841, 7964, 8089, 8211, 8334, 8458, 8581, 8704, 8827, 8947, 9077, 9046, 8912, 8790, 8667, 8545, 8420, 8296, 8172, 8047, 7923, 7799, 7674, 7549, 7425, 7301, 7301, 6535, 8925, 31059, 31923, 31010, 30586, 30057, 29518, 28971, 28420, 27863, 27298, 26729, 26156, 25578, 24999, 24412, 23823, 23229, 22630, 22030, 21427, 20817, 20206, 19589, 18974, 18355, 17731, 17105, 16479, 15853, 15225, 14597, 13966, 13336, 12708, 12082, 11455, 10831, 10206, 9584, 8968, 8351, 7736, 7120, 6495, 5923, 4218, -4355, -4992, -4773, -4733, -4626, -4502, -4370, -4227, -4093, -3958, -3849, -3753, -3668, -3686, -3823, -3960, -4083, -4317, -3865, -3564, -3780, -3895, -4024, -4152, -4279, -4406, -4533, -4658, -4784, -4909, -5035, -5159, -5284, -5409, -5534, -5659, -5783, -5907, -6032, -6155, -6279, -6404, -6527, -6650, -6776, -6899, -7023, -7147, -7269, -7393, -7516, -7639, -7763, -7886, -8009, -8132, -8255, -8378, -8500, -8621, -8744, -8866, -8988, -9116, -9085, -8952, -8831, -8709, -8585, -8463, -8339, -8216, -8092, -7968, -7845, -7721, -7597, -7473, -7349, -7227, -7331, -5929, -11447, -32161, -31049, -30599, -30112, -29580, -29039, -28492, -27938, -27380, -26815, -26244, -25668, -25087, -24505, -23916, -23322, -22722, -22121, -21513, -20906, -20291, -19674, -19052, -18427, -17802, -17174, -16543, -15909, -15274, -14639, -14007, -13371, -12737, -12101, -11466, -10835, -10205, -9573, -8940, -8318, -7648, -6500, -5327, -4331, -3454};