/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1893 256 samples */
 
const int16_t AKWF_1893_256_DATA [256] = 
{415, 1027, 1583, 2090, 2550, 2967, 3351, 3712, 4060, 4404, 4754, 5114, 5489, 5868, 6253, 6641, 7031, 7422, 7812, 8197, 8582, 8968, 9348, 9733, 10118, 10500, 10884, 11266, 11650, 12034, 12416, 12800, 13182, 13565, 13947, 14331, 14713, 15094, 15473, 15852, 16232, 16614, 16997, 17383, 17773, 18176, 18594, 19014, 19427, 19824, 20196, 20530, 20829, 21039, 21135, 21174, 21227, 21362, 21651, 22149, 22893, 23947, 25324, 26904, 28521, 29973, 31090, 31684, 31595, 30731, 29183, 27032, 24275, 20990, 17246, 13141, 8714, 4077, -946, -6338, -11831, -17205, -22230, -26598, -30165, -32520, -32802, -32733, -32817, -32189, -30375, -28428, -26600, -25099, -24047, -23322, -22872, -22647, -22573, -22564, -22540, -22420, -22162, -21838, -21478, -21088, -20674, -20245, -19817, -19397, -18990, -18593, -18199, -17806, -17420, -17032, -16643, -16256, -15866, -15476, -15086, -14696, -14305, -13915, -13524, -13135, -12746, -12356, -11965, -11578, -11189, -10799, -10411, -10021, -9631, -9246, -8857, -8467, -8078, -7689, -7301, -6914, -6525, -6136, -5748, -5360, -4973, -4585, -4197, -3808, -3421, -3034, -2648, -2261, -1874, -1487, -1100, -716, -329, 56, 443, 830, 1215, 1600, 1986, 2372, 2760, 3146, 3529, 3915, 4298, 4683, 5067, 5450, 5835, 6223, 6612, 7008, 7411, 7819, 8224, 8620, 8999, 9358, 9696, 9987, 10211, 10396, 10583, 10812, 11128, 11561, 12142, 12892, 13829, 14893, 15993, 17022, 17873, 18440, 18633, 18390, 17766, 16794, 15478, 13847, 11913, 9695, 7249, 4600, 1666, -1533, -4901, -8248, -11390, -14170, -16417, -18001, -18864, -19004, -18537, -17601, -16376, -15024, -13710, -12600, -11769, -11148, -10703, -10397, -10190, -10032, -9871, -9655, -9356, -9006, -8634, -8242, -7838, -7428, -7020, -6621, -6237, -5873, -5522, -5176, -4826, -4458, -4065, -3638, -3165, -2644, -2072, -1464, -837, -189};