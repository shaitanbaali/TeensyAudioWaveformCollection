/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1811 256 samples */
 
const int16_t AKWF_1811_256_DATA [256] = 
{1616, 1618, 1619, 1619, 1619, 1726, 1121, 8693, 11639, 11039, 10898, 11880, 19321, 19608, 19616, 19010, 22094, 27269, 26649, 26525, 27431, 32723, 32762, 32709, 32700, 32680, 32657, 32637, 32536, 32953, 30739, 26563, 22826, 16169, 10386, -3806, -6451, -3246, -2997, -3161, -4294, -4323, -5179, -6837, -6833, -5926, -4267, -4457, -4463, -4281, -3144, -3117, -3138, -3042, -2945, -3132, -4078, -3989, -4355, -6181, -6201, -5998, -6918, -9030, -8785, -9041, -8188, 792, 1198, 1918, 10391, 10668, 11408, 18938, 19088, 19811, 26248, 26294, 26977, 32325, 32467, 32392, 32386, 32367, 32327, 32388, 32010, 27081, 24227, 18398, 10476, -6398, -7399, -4267, -3622, -3246, -4156, -4832, -4494, -6037, -7143, -6900, -7117, -6241, -4531, -4714, -4666, -4738, -4405, -3329, -3383, -3371, -3382, -3301, -3223, -3234, -3233, -3216, -3263, -4210, -4321, -4289, -4292, -4290, -4314, -4159, -4872, -6515, -6360, -6383, -6379, -6374, -6371, -6367, -6362, -6358, -6354, -6349, -6391, -6140, -8047, -9239, -8998, -9036, -9030, -9023, -9018, -9011, -9005, -8998, -8993, -8986, -8980, -8974, -8967, -8962, -8954, -8949, -8942, -8935, -8930, -8922, -8917, -8910, -8903, -8897, -8890, -8884, -8878, -8871, -8865, -8859, -8851, -8845, -8839, -8832, -8827, -8819, -8763, -9024, -7386, -5864, -6123, -6068, -6063, -6059, -6053, -6049, -6044, -6039, -6035, -6030, -6025, -6020, -6016, -6011, -6006, -6002, -5998, -5993, -5988, -5984, -5979, -5975, -5971, -5966, -5962, -5957, -5952, -5915, -6094, -5157, -3666, -3854, -3816, -3813, -3809, -3806, -3803, -3800, -3797, -3794, -3791, -3788, -3785, -3781, -3779, -3776, -3810, -3609, -5041, -6032, -5838, -5868, -5865, -5861, -5857, -5853, -5848, -5844, -5840, -5836, -5832, -5827, -5823, -5869, -5599, -7263, -8734, -8467, -8510, -8505, -8499, -8493, -8487, -8481};