/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1838 256 samples */
 
const int16_t AKWF_1838_256_DATA [256] = 
{17511, 20264, 19754, 19639, 12044, 10432, 10653, 11637, 12996, 12854, 12885, 12828, 12338, 12305, 12180, 12999, 14288, 14164, 14158, 14214, 16348, 16812, 16637, 17103, 16907, 16731, 16779, 16689, 15959, 15874, 15876, 15945, 15558, 15447, 15433, 15520, 18837, 19609, 19110, 20773, 28424, 28816, 28681, 28730, 28963, 28983, 28942, 29073, 29320, 29248, 29375, 28970, 15188, 12214, 12864, 12835, 12639, 12426, 12812, 11310, -2217, -3605, -3769, -1278, 11091, 12147, 11851, 11948, 12899, 12972, 13687, 8136, 2828, 4076, 3801, 3979, 5433, 5587, 5574, 5426, 4932, 4906, 4917, 4903, 4428, 4306, 4413, 3999, 1031, 530, 582, 826, 3244, 3468, 3594, 2786, -4055, -4958, -4715, -4814, -6709, -7157, -6841, -8436, -11178, -11114, -11323, -10445, -2466, -1611, -1665, -2816, -578, 385, 194, 176, -1721, -2159, -1954, -2475, -7809, -8941, -8517, -9282, -15801, -16394, -16708, -14943, 12674, 17077, 16105, 16088, 8493, 6845, 7259, 6834, 6376, 6416, 6417, 6358, 5870, 5808, 5843, 5681, 5182, 5160, 5144, 5199, 7332, 7754, 7814, 7027, 3509, 3345, 3408, 3310, 2583, 2485, 2565, 2277, 439, 238, 255, 337, 3657, 4407, 4057, 4666, 10956, 11488, 11334, 11388, 11623, 11635, 11667, 11381, 10863, 10839, 10964, 10563, -3213, -6286, -5089, -8045, -15996, -16179, -15754, -17273, -30797, -32267, -31980, -31662, -28140, -27654, -27772, -27711, -26751, -26525, -26616, -26256, -23936, -23445, -23582, -23391, -21932, -21748, -21868, -21306, -20514, -20605, -20574, -20580, -21048, -21123, -21220, -20476, -20389, -20892, -20846, -20585, -18162, -17892, -17950, -17823, -20883, -21535, -21359, -21433, -23322, -23714, -23660, -23311, -23545, -23729, -23890, -23006, -15023, -14071, -14624, -12688, -4820, -4176, -4320, -4328, -6221, -6605, -6651, -5809, -7539, -8680, -8270, -9023, -15540, -16215, -16235, -15193};