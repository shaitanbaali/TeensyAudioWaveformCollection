/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1844 256 samples */
 
const int16_t AKWF_1844_256_DATA [256] = 
{1283, 2829, 3818, 4488, 4937, 5238, 5441, 5577, 5667, 5728, 5768, 5796, 5814, 5830, 5852, 5788, 7278, 10730, 13330, 15017, 16165, 16934, 17447, 17790, 18020, 18172, 18272, 18339, 18383, 18411, 18428, 18439, 18443, 18445, 18445, 18445, 18442, 18439, 18436, 18433, 18428, 18423, 18420, 18416, 18410, 18406, 18402, 18397, 18392, 18388, 18385, 18401, 18305, 19476, 22846, 25595, 27359, 28556, 29358, 29893, 30248, 30485, 30641, 30745, 30810, 30852, 30878, 30893, 30901, 30903, 30902, 30900, 30894, 30888, 30882, 30876, 30869, 30862, 30854, 30846, 30839, 30831, 30823, 30814, 30807, 30799, 30791, 30782, 30774, 30766, 30758, 30750, 30742, 30734, 30726, 30717, 30709, 30700, 30692, 30684, 30676, 30668, 30660, 30651, 30643, 30635, 30627, 30619, 30611, 30600, 30576, 30637, 29140, 25684, 23076, 21380, 20223, 19447, 18925, 18572, 18334, 18173, 18062, 17986, 17933, 17897, 17869, 17849, 17835, 17783, 17869, 17278, 9789, -239, -6787, -11191, -14179, -16096, -18842, -23173, -26406, -28511, -29940, -30896, -31534, -31960, -32246, -32434, -32561, -32642, -32695, -32728, -32749, -32761, -32766, -32768, -32766, -32763, -32758, -32752, -32745, -32740, -32733, -32725, -32717, -32710, -32702, -32694, -32686, -32678, -32670, -32661, -32653, -32644, -32636, -32628, -32619, -32611, -32602, -32594, -32585, -32577, -32568, -32560, -32551, -32543, -32534, -32526, -32517, -32508, -32500, -32491, -32482, -32474, -32460, -32442, -32471, -30717, -27242, -24752, -23111, -21997, -21248, -20745, -20404, -20175, -20018, -19911, -19838, -19786, -19749, -19722, -19702, -19687, -19674, -19665, -19656, -19649, -19641, -19635, -19628, -19623, -19617, -19610, -19605, -19598, -19594, -19589, -19583, -19577, -19571, -19567, -19561, -19532, -19613, -18875, -15711, -12717, -10808, -9505, -8634, -8045, -7652, -7386, -7206, -7085, -7003, -6947, -6909, -6881, -6863, -6837, -6855, -6689, -4255, -864};