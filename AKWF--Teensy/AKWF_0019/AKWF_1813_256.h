/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1813 256 samples */
 
const int16_t AKWF_1813_256_DATA [256] = 
{9923, 9921, 9931, 9931, 9928, 9925, 9921, 9917, 9913, 9908, 9902, 9899, 9884, 9871, 9868, 9855, 9846, 9839, 9819, 9815, 9800, 9787, 9775, 9760, 9746, 9737, 9722, 9709, 9691, 9679, 9661, 9653, 9634, 9623, 9610, 9595, 9580, 9563, 9550, 9533, 9521, 9508, 9492, 9473, 9459, 9443, 9429, 9412, 9400, 9388, 9371, 9358, 9341, 9322, 9309, 9291, 9279, 9266, 9251, 9236, 9221, 9201, 9188, 9174, 9163, 9145, 9131, 9116, 9101, 9081, 9067, 9054, 9043, 9025, 9012, 8996, 8981, 8964, 8953, 8937, 8923, 8907, 8893, 8877, 8863, 8845, 8833, 8819, 8804, 8788, 8775, 8758, 8747, 8731, 8715, 8701, 8686, 8670, 8657, 8640, 8629, 8614, 8597, 8584, 8569, 8553, 8540, 8523, 8512, 8499, 8485, 8467, 8451, 8437, 8423, 8411, 8399, 8382, 8369, 8350, 8334, 8321, 8306, 8294, 8283, 8266, 8253, 8238, 8223, 8209, 8197, 8180, 8167, 8151, 8138, 8122, 8108, 8094, 8082, 8071, 8054, 7659, 9696, -6789, -16606, -14627, -15036, -13989, -13663, -13729, -13991, -12426, -26703, -33986, -32453, -32702, -32675, -32648, -32619, -32588, -32556, -32527, -32467, -32467, -32541, -16073, -12705, -13490, -13328, -13319, -13259, -13411, -14682, -14728, -14706, -14703, -14696, -14624, -14883, -14037, 6978, 9774, 9076, 9219, 9223, 9230, 9235, 9239, 9234, 9230, 9226, 9222, 9217, 9212, 9207, 9202, 9197, 9184, 9169, 9167, 9153, 8704, 11021, -2334, -16675, -14324, -14756, -14749, -14742, -14735, -14726, -14719, -14710, -14701, -14694, -14686, -14677, -14669, -14662, -14652, -14645, -14636, -14628, -14618, -14610, -14601, -14593, -14584, -14576, -14567, -14559, -14550, -14541, -14532, -14523, -14514, -14505, -14497, -14488, -14479, -14470, -14461, -14453, -14444, -14435, -14427, -14417, -14408, -14399, -14391, -14383, -14373, -14365, -14356, -14347, -14338};