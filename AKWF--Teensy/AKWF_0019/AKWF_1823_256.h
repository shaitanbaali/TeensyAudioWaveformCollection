/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1823 256 samples */
 
const int16_t AKWF_1823_256_DATA [256] = 
{3405, 10763, 16328, 20153, 22403, 23438, 23612, 23222, 22489, 21563, 20546, 19497, 18456, 17450, 16487, 15573, 14720, 13916, 13160, 12455, 11795, 11177, 10600, 10056, 9547, 9070, 8621, 8198, 7800, 7423, 7068, 6732, 6412, 6111, 5825, 5553, 5293, 5046, 4811, 4588, 4372, 4166, 3971, 3782, 3602, 3430, 3265, 3107, 2955, 2807, 2666, 2531, 2400, 2274, 2154, 2037, 1924, 1814, 1711, 1610, 1512, 1418, 1327, 1240, 1156, 1075, 997, 922, 850, 781, 713, 650, 591, 532, 477, 426, 377, 332, 289, 251, 216, 184, 158, 136, 119, 107, 101, 103, 111, 128, 156, 193, 245, 314, 401, 511, 652, 831, 1053, 1408, 2731, 4981, 18621, -1867, -28028, -28118, 2019, 17497, 4643, 2578, 1359, 1035, 814, 637, 499, 390, 303, 235, 184, 147, 119, 102, 94, 94, 100, 112, 129, 152, 177, 209, 244, 281, 323, 369, 416, 468, 522, 578, 638, 701, 766, 833, 905, 978, 1055, 1135, 1217, 1301, 1390, 1484, 1578, 1677, 1778, 1885, 1995, 2108, 2227, 2349, 2475, 2608, 2746, 2888, 3035, 3190, 3351, 3518, 3693, 3875, 4065, 4265, 4474, 4692, 4920, 5161, 5413, 5677, 5956, 6250, 6560, 6888, 7235, 7601, 7990, 8403, 8842, 9308, 9806, 10337, 10903, 11509, 12155, 12848, 13591, 14379, 15219, 16116, 17060, 18050, 19069, 20092, 21082, 21972, 22659, 22986, 22730, 21591, 19199, 15208, 9471, 2155, -6062, -14101, -21038, -26323, -29828, -31822, -32666, -32712, -32240, -31459, -30508, -29473, -28420, -27380, -26375, -25418, -24510, -23655, -22857, -22106, -21403, -20754, -20104, -20128, -20761, -21380, -22057, -22778, -23549, -24375, -25253, -26181, -27154, -28158, -29175, -30166, -31069, -31793, -32193, -32057, -31094, -28960, -25283, -19841, -12797, -4545};