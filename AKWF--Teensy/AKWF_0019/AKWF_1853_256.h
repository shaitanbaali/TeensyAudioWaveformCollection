/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1853 256 samples */
 
const int16_t AKWF_1853_256_DATA [256] = 
{357, 1275, 2309, 3466, 4735, 6103, 7546, 9038, 10562, 12090, 13596, 15068, 16485, 17829, 19097, 20276, 21366, 22365, 23269, 24076, 24792, 25412, 25929, 26343, 26642, 26825, 26883, 26811, 26608, 26269, 25798, 25195, 24462, 23613, 22650, 21583, 20430, 19190, 17875, 16501, 15056, 13546, 11996, 10397, 8749, 7057, 5310, 3508, 1659, -250, -2212, -4217, -6271, -8359, -10466, -12584, -14691, -16765, -18793, -20747, -22604, -24346, -25948, -27393, -28667, -29753, -30641, -31326, -31798, -32060, -32109, -31946, -31577, -31008, -30248, -29301, -28176, -26891, -25447, -23863, -22155, -20330, -18414, -16425, -14372, -12287, -10190, -8092, -6021, -3998, -2038, -158, 1627, 3318, 4897, 6366, 7731, 8987, 10144, 11205, 12173, 13057, 13859, 14577, 15211, 15755, 16206, 16562, 16813, 16951, 16976, 16887, 16690, 16393, 16009, 15554, 15051, 14525, 13998, 13492, 13031, 12632, 12313, 12084, 11950, 11911, 11964, 12103, 12330, 12633, 13002, 13439, 13936, 14487, 15091, 15741, 16434, 17159, 17900, 18647, 19377, 20068, 20693, 21227, 21639, 21904, 21998, 21896, 21585, 21057, 20310, 19343, 18167, 16798, 15244, 13535, 11695, 9739, 7694, 5580, 3408, 1210, -1006, -3234, -5452, -7656, -9837, -11980, -14081, -16131, -18106, -20007, -21816, -23517, -25107, -26567, -27882, -29052, -30065, -30912, -31600, -32125, -32488, -32702, -32768, -32696, -32495, -32179, -31753, -31225, -30603, -29892, -29095, -28216, -27255, -26213, -25087, -23876, -22582, -21210, -19758, -18232, -16649, -15010, -13332, -11639, -9934, -8245, -6596, -4997, -3471, -2040, -713, 493, 1569, 2515, 3324, 3996, 4540, 4962, 5268, 5473, 5585, 5615, 5573, 5465, 5297, 5074, 4797, 4472, 4098, 3680, 3224, 2733, 2219, 1686, 1145, 607, 84, -415, -878, -1299, -1672, -1988, -2251, -2453, -2595, -2674, -2690, -2638, -2508, -2295, -1991, -1583, -1062, -400};