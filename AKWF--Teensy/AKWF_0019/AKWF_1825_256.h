/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1825 256 samples */
 
const int16_t AKWF_1825_256_DATA [256] = 
{1232, 4970, 8409, 11550, 14322, 16757, 18834, 20538, 21956, 23078, 23952, 24626, 25116, 25456, 25671, 25780, 25797, 25732, 25596, 25393, 25126, 24794, 24403, 23952, 23450, 22901, 22299, 21662, 21002, 20327, 19649, 18976, 18331, 17718, 17152, 16642, 16194, 15817, 15513, 15297, 15175, 15149, 15222, 15408, 15707, 16121, 16659, 17307, 18053, 18873, 19721, 20542, 21260, 21795, 22077, 22030, 21600, 20703, 19322, 17518, 15447, 13294, 11239, 9385, 7777, 6428, 5314, 4407, 3685, 3116, 2693, 2393, 2188, 2087, 2047, 2090, 1024, 13981, 4281, 1231, 2123, 2042, 2113, 2277, 2545, 2918, 3433, 4099, 4936, 5972, 7238, 8751, 10516, 12505, 14619, 16714, 18599, 20092, 21111, 21650, 21779, 21562, 21066, 20370, 19542, 18669, 17810, 17010, 16307, 15711, 15234, 14877, 14635, 14505, 14478, 14549, 14713, 14969, 15300, 15703, 16170, 16692, 17271, 17878, 18515, 19170, 19814, 20452, 21067, 21651, 22186, 22672, 23107, 23485, 23800, 24054, 24244, 24369, 24424, 24400, 24288, 24077, 23744, 23274, 22630, 21789, 20724, 19373, 17737, 15758, 13417, 10725, 7688, 4313, 699, -3065, -6915, -10694, -14311, -17702, -20762, -23444, -25776, -27707, -29254, -30481, -31400, -32045, -32469, -32699, -32768, -32708, -32536, -32283, -31959, -31580, -31161, -30716, -30245, -29762, -29267, -28767, -28264, -27766, -27275, -26788, -26306, -25839, -25376, -24924, -24486, -24057, -23641, -23236, -22842, -22456, -22087, -21726, -21374, -21034, -20708, -20387, -20077, -19777, -19477, -19220, -19353, -19632, -19898, -20176, -20461, -20754, -21059, -21375, -21700, -22034, -22381, -22738, -23107, -23484, -23874, -24274, -24683, -25108, -25538, -25977, -26426, -26876, -27332, -27794, -28257, -28712, -29158, -29592, -30005, -30389, -30741, -31040, -31273, -31429, -31484, -31416, -31197, -30794, -30180, -29310, -28146, -26660, -24823, -22581, -19972, -17007, -13692, -10113, -6387, -2461};