/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1855 256 samples */
 
const int16_t AKWF_1855_256_DATA [256] = 
{424, 1317, 2162, 2981, 3773, 4536, 5275, 5984, 6669, 7330, 7965, 8579, 9172, 9743, 10294, 10827, 11341, 11839, 12322, 12788, 13240, 13679, 14103, 14516, 14917, 15306, 15685, 16055, 16414, 16764, 17106, 17440, 17764, 18080, 18392, 18696, 18991, 19282, 19568, 19846, 20118, 20387, 20651, 20908, 21161, 21410, 21654, 21894, 22130, 22363, 22590, 22815, 23038, 23255, 23469, 23680, 23888, 24094, 24296, 24495, 24691, 24886, 25077, 25266, 25453, 25636, 25817, 25998, 26173, 26348, 26521, 26691, 26860, 27027, 27191, 27354, 27514, 27673, 27830, 27986, 28140, 28292, 28442, 28591, 28736, 28882, 29027, 29169, 29309, 29449, 29589, 29725, 29859, 29993, 30125, 30255, 30383, 30509, 30633, 30754, 30874, 30991, 31108, 31222, 31332, 31442, 31550, 31654, 31756, 31857, 31956, 32052, 32147, 32240, 32330, 32419, 32505, 32589, 32652, 32768, 32436, 28326, 21444, 15724, 10753, 6148, 2062, -1593, -4880, -7810, -10431, -12777, -14864, -16725, -18385, -19856, -21164, -22325, -23348, -24251, -25047, -25744, -26354, -26885, -27343, -27739, -28078, -28365, -28604, -28804, -28965, -29093, -29191, -29261, -29309, -29334, -29340, -29326, -29298, -29255, -29197, -29129, -29049, -28959, -28860, -28754, -28638, -28517, -28389, -28254, -28114, -27970, -27821, -27669, -27512, -27351, -27188, -27021, -26850, -26677, -26502, -26323, -26144, -25961, -25776, -25589, -25400, -25209, -25016, -24820, -24624, -24425, -24224, -24022, -23818, -23612, -23404, -23194, -22983, -22769, -22553, -22335, -22116, -21894, -21671, -21444, -21215, -20985, -20753, -20517, -20279, -20040, -19796, -19550, -19300, -19049, -18794, -18536, -18275, -18009, -17742, -17469, -17192, -16911, -16625, -16336, -16042, -15741, -15435, -15123, -14805, -14482, -14149, -13810, -13463, -13107, -12741, -12365, -11977, -11577, -11162, -10730, -10280, -9812, -9317, -8792, -8232, -7621, -6937, -6136, -5224, -4265, -3300, -2340, -1395, -453};