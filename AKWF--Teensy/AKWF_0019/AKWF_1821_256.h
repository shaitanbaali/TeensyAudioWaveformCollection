/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1821 256 samples */
 
const int16_t AKWF_1821_256_DATA [256] = 
{3854, 16500, 25881, 30961, 32690, 32458, 31281, 29735, 28112, 26546, 25098, 23781, 22589, 21521, 20559, 19692, 18909, 18199, 17554, 16968, 16429, 15935, 15482, 15063, 14675, 14314, 13978, 13666, 13374, 13099, 12842, 12600, 12372, 12157, 11954, 11761, 11579, 11405, 11240, 11083, 10933, 10790, 10653, 10522, 10397, 10277, 10162, 10051, 9646, 11350, -3600, 4472, 11078, 9763, 10053, 10151, 10252, 10360, 10471, 10588, 10712, 10842, 10979, 11122, 11274, 11434, 11604, 11783, 11974, 12177, 12392, 12622, 12868, 13131, 13412, 13714, 14040, 14391, 14772, 15185, 15633, 16124, 16660, 17247, 17896, 18612, 19404, 20286, 21269, 22361, 23578, 24925, 26396, 27966, 29544, 30936, 31741, 31205, 28095, 21044, 9905, -2837, -13319, -19536, -22034, -22218, -21228, -19749, -18134, -16556, -15080, -13734, -12520, -11435, -10411, -9965, -10006, -9989, -9982, -9976, -9969, -9963, -9956, -9950, -9943, -9936, -9929, -9923, -9915, -9908, -9902, -9895, -9888, -9881, -9874, -9867, -9860, -9852, -9846, -9838, -9831, -9824, -9817, -9810, -9803, -9796, -9789, -9782, -9775, -9767, -9761, -9753, -9746, -9739, -9732, -9725, -9718, -9710, -9703, -9696, -9689, -9682, -9675, -9668, -9661, -9654, -9647, -9640, -9632, -9625, -9618, -9611, -9604, -9598, -9591, -9583, -9576, -9569, -9562, -9555, -9548, -9541, -9533, -9527, -9520, -9513, -9506, -9499, -9492, -9485, -9478, -9471, -9464, -9457, -9450, -9443, -9436, -9429, -9422, -9415, -9408, -9401, -9394, -9387, -9381, -9374, -9366, -9359, -9352, -9346, -9339, -9332, -9325, -9318, -9311, -9305, -9297, -9291, -9283, -9277, -9270, -9263, -9256, -9250, -9242, -9235, -9228, -9222, -9215, -9208, -9201, -9195, -9188, -9181, -9174, -9167, -9161, -9154, -9147, -9140, -9138, -9118, -9171, -9959, -11002, -12129, -13386, -14774, -16285, -17872, -19434, -20731, -21279, -20212, -16215, -7725};