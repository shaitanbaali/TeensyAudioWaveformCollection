/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1829 256 samples */
 
const int16_t AKWF_1829_256_DATA [256] = 
{19987, 32669, 28318, 26863, 25233, 23712, 22276, 20922, 19656, 18058, 19277, 9163, -7930, -15689, -18602, -20137, -20941, -21579, -21990, -22218, -22369, -22345, -22216, -21991, -21661, -21259, -20774, -20220, -19617, -18965, -18283, -17568, -16826, -16066, -15293, -14515, -13738, -12960, -12186, -11423, -10670, -9930, -9208, -8501, -7811, -7144, -6495, -5868, -5266, -4683, -4121, -3581, -3065, -2574, -2101, -1651, -1223, -814, -429, -64, 284, 609, 919, 1212, 1489, 1747, 1986, 2211, 2421, 2621, 2806, 2978, 3129, 3274, 3412, 3533, 3643, 3747, 3841, 3921, 3996, 4058, 4115, 4163, 4204, 4242, 4273, 4300, 4320, 4332, 4340, 4336, 4335, 4332, 4322, 4307, 4293, 4276, 4256, 4229, 4196, 4164, 4134, 4099, 4064, 4024, 3982, 3942, 3897, 3850, 3802, 3755, 3710, 3666, 3615, 3565, 3515, 3461, 3408, 3356, 3307, 3258, 3205, 3151, 3101, 3049, 2996, 2945, 2894, 2845, 2800, 2748, 2697, 2650, 2598, 2548, 2498, 2445, 2393, 2341, 2293, 2243, 2194, 2145, 2100, 2056, 2016, 1974, 1927, 1881, 1839, 1799, 1759, 1718, 1677, 1637, 1595, 1559, 1521, 1483, 1448, 1410, 1376, 1342, 1305, 1268, 1233, 1200, 1170, 1141, 1106, 1073, 1043, 1010, 982, 955, 925, 896, 869, 840, 813, 786, 760, 735, 711, 686, 663, 640, 619, 595, 571, 551, 529, 508, 485, 467, 448, 429, 407, 385, 366, 349, 330, 316, 299, 281, 262, 245, 230, 215, 200, 186, 170, 153, 140, 128, 113, 101, 88, 75, 64, 52, 40, 28, 17, 4, -6, -16, -27, -38, -44, -55, -66, -77, -88, -97, -107, -114, -123, -133, -140, -148, -156, -164, -175, -183, -190, -198, -201, -208, -214, -216, -225, -219, -185, -346};