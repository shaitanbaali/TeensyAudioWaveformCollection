/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1806 256 samples */
 
const int16_t AKWF_1806_256_DATA [256] = 
{207, 906, 1581, 2247, 2903, 3636, 3718, 6906, 12252, 11784, 11975, 12048, 12108, 12157, 12199, 12236, 12267, 12295, 12320, 12345, 12369, 12392, 12417, 12442, 12469, 12498, 12528, 12561, 12597, 12634, 12675, 12718, 12763, 12811, 12862, 12915, 12970, 13028, 13088, 13151, 13215, 13282, 13351, 13421, 13494, 13567, 13645, 14031, 12454, 22381, 33629, 31552, 31421, 30848, 30153, 29303, 28367, 27483, 26667, 25913, 25212, 24565, 23970, 23423, 22921, 22457, 22034, 21647, 21292, 20970, 20685, 20387, 19868, 19338, 18858, 18414, 17999, 17614, 17255, 16920, 16609, 16318, 16041, 15782, 15539, 15307, 15089, 14881, 14682, 14492, 14309, 14135, 13967, 13804, 13647, 13496, 13347, 13203, 13063, 12925, 12791, 12659, 12529, 12403, 12276, 12152, 12031, 11909, 11790, 11672, 11554, 11437, 11321, 11207, 11093, 10979, 10865, 10753, 10642, 10529, 10418, 10307, 10196, 10085, 9976, 9866, 9756, 9646, 9536, 9428, 9318, 9209, 9141, 8631, 10512, 9927, 307, 649, -135, -754, -1371, -1985, -2603, -3221, -3837, -4454, -5067, -5682, -6297, -6912, -7527, -8139, -8750, -9362, -9975, -10586, -11196, -11802, -12413, -13020, -13628, -14230, -14834, -15438, -16039, -16640, -17238, -17831, -18426, -19018, -19606, -20194, -20776, -21353, -21929, -22502, -23067, -23629, -24183, -24731, -25274, -25810, -26335, -26850, -27354, -27849, -28331, -28800, -29251, -29683, -30099, -30491, -30863, -31209, -31524, -31808, -32059, -32265, -32456, -32471, -31609, -30536, -29469, -28357, -27209, -26025, -24803, -23529, -22212, -20842, -19413, -17942, -16399, -14789, -13115, -11498, -10031, -8693, -7666, -5500, -19888, -24500, -22706, -22266, -21615, -20964, -20314, -19661, -19005, -18348, -17687, -17024, -16363, -15695, -15026, -14354, -13678, -13004, -12325, -11641, -10957, -10268, -9577, -8889, -8192, -7494, -6794, -6091, -5387, -4687, -3980, -3275, -2571, -1867, -1171, -463};