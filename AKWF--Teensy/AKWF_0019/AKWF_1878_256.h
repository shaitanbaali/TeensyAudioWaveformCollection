/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1878 256 samples */
 
const int16_t AKWF_1878_256_DATA [256] = 
{559, 1525, 2393, 3143, 4140, 5487, 6821, 7889, 8886, 10151, 11417, 12567, 13881, 15447, 16862, 17403, 17602, 18288, 19550, 20485, 20636, 20257, 19622, 18664, 17531, 16449, 15284, 13283, 10333, 7117, 4273, 1561, -1556, -4937, -8306, -11655, -15040, -18237, -20919, -23291, -25636, -27868, -29593, -30809, -31774, -32528, -32772, -32447, -31861, -31222, -30290, -28917, -27210, -25308, -23148, -20706, -18271, -16004, -13688, -11061, -8271, -5677, -3395, -1252, 755, 2568, 4232, 5870, 7329, 8339, 8907, 9319, 9760, 10072, 10102, 9939, 9653, 9217, 8594, 7980, 7453, 6914, 6265, 5595, 5029, 4575, 4165, 3850, 3686, 3694, 3770, 3951, 4306, 4798, 5351, 5928, 6684, 7520, 8360, 9120, 9920, 10773, 11608, 12378, 13136, 13990, 14819, 15332, 15456, 15509, 15730, 15964, 15938, 15577, 14840, 13835, 12701, 11625, 10569, 9280, 7585, 5565, 3548, 1672, -133, -1960, -3797, -5658, -7554, -9305, -10765, -11924, -12895, -13752, -14482, -15036, -15422, -15654, -15658, -15392, -14947, -14456, -13910, -13246, -12481, -11616, -10654, -9536, -8403, -7368, -6449, -5490, -4420, -3365, -2375, -1475, -692, -33, 512, 1164, 1867, 2462, 2841, 3104, 3486, 3799, 4003, 4149, 4392, 4620, 4653, 4591, 4551, 4600, 4674, 4726, 4889, 5077, 5249, 5312, 5340, 5529, 5887, 6318, 6652, 6879, 6995, 7044, 7164, 7376, 7587, 7559, 7259, 6843, 6468, 6136, 5701, 5103, 4403, 3570, 2606, 1572, 642, -300, -1330, -2467, -3592, -4645, -5661, -6615, -7479, -8197, -8869, -9538, -10096, -10449, -10594, -10670, -10629, -10421, -10051, -9542, -8863, -7980, -7014, -6041, -5065, -4049, -3027, -2007, -984, 52, 936, 1561, 1960, 2369, 2820, 3138, 3209, 3089, 2915, 2629, 2193, 1664, 1319, 1036, 560, -133, -688, -933, -1091, -1165, -1209, -1044, -791, -237};