/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1860 256 samples */
 
const int16_t AKWF_1860_256_DATA [256] = 
{1396, 3563, 5810, 8189, 10685, 13246, 15801, 18288, 20657, 22841, 24807, 26561, 28092, 29388, 30467, 31338, 32000, 32461, 32719, 32762, 32560, 32102, 31385, 30410, 29218, 27824, 26205, 24376, 22439, 20491, 18569, 16712, 14974, 13363, 11865, 10478, 9221, 8114, 7174, 6395, 5753, 5269, 4954, 4795, 4782, 4899, 5109, 5368, 5675, 6021, 6360, 6653, 6879, 7024, 7088, 7053, 6910, 6650, 6267, 5749, 5080, 4260, 3314, 2244, 1044, -268, -1686, -3201, -4766, -6353, -7977, -9632, -11278, -12866, -14390, -15855, -17227, -18471, -19551, -20450, -21172, -21702, -22024, -22168, -22169, -22017, -21675, -21144, -20475, -19693, -18789, -17757, -16606, -15338, -13955, -12482, -10941, -9335, -7671, -5994, -4347, -2721, -1115, 445, 1960, 3431, 4855, 6246, 7585, 8839, 10037, 11195, 12272, 13251, 14135, 14919, 15593, 16143, 16594, 16955, 17211, 17354, 17391, 17314, 17120, 16815, 16406, 15896, 15278, 14569, 13814, 13026, 12180, 11268, 10309, 9338, 8353, 7329, 6267, 5176, 4073, 2970, 1875, 805, -210, -1176, -2103, -2995, -3845, -4644, -5411, -6143, -6823, -7471, -8097, -8668, -9189, -9676, -10126, -10553, -10968, -11368, -11745, -12098, -12429, -12758, -13101, -13435, -13734, -13997, -14235, -14460, -14662, -14814, -14906, -14947, -14946, -14907, -14827, -14710, -14543, -14315, -14024, -13668, -13244, -12756, -12205, -11590, -10924, -10221, -9503, -8765, -7998, -7219, -6437, -5668, -4920, -4190, -3483, -2817, -2211, -1667, -1187, -782, -450, -182, 21, 157, 221, 210, 126, -24, -236, -494, -789, -1122, -1494, -1882, -2275, -2690, -3135, -3605, -4096, -4607, -5129, -5654, -6173, -6688, -7209, -7748, -8292, -8826, -9358, -9898, -10429, -10927, -11386, -11804, -12170, -12473, -12724, -12913, -13019, -13005, -12846, -12546, -12104, -11494, -10692, -9698, -8523, -7207, -5760, -4169, -2450, -553};