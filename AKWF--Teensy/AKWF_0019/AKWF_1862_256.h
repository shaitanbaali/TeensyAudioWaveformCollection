/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1862 256 samples */
 
const int16_t AKWF_1862_256_DATA [256] = 
{280, 1286, 2305, 3372, 4511, 5733, 7021, 8324, 9587, 10757, 11803, 12714, 13472, 14064, 14491, 14766, 14907, 14939, 14884, 14763, 14600, 14428, 14280, 14179, 14160, 14273, 14566, 15052, 15718, 16541, 17496, 18574, 19765, 21041, 22376, 23733, 25060, 26316, 27476, 28534, 29504, 30380, 31139, 31767, 32244, 32566, 32736, 32763, 32669, 32481, 32238, 31968, 31681, 31377, 31048, 30698, 30326, 29922, 29492, 29051, 28596, 28092, 27514, 26879, 26213, 25533, 24836, 24113, 23391, 22704, 22090, 21571, 21159, 20850, 20638, 20513, 20472, 20512, 20630, 20807, 21016, 21223, 21398, 21512, 21524, 21407, 21152, 20759, 20237, 19592, 18826, 17953, 16998, 15968, 14880, 13751, 12602, 11442, 10274, 9109, 7977, 6894, 5873, 4923, 4037, 3226, 2504, 1868, 1316, 829, 362, -115, -604, -1092, -1551, -1968, -2347, -2691, -2995, -3246, -3432, -3548, -3610, -3639, -3657, -3672, -3697, -3738, -3802, -3891, -4006, -4146, -4311, -4493, -4692, -4933, -5265, -5741, -6390, -7227, -8236, -9383, -10629, -11933, -13270, -14623, -15963, -17251, -18436, -19459, -20287, -20914, -21357, -21628, -21756, -21776, -21701, -21539, -21316, -21068, -20830, -20617, -20420, -20229, -20047, -19875, -19683, -19448, -19181, -18907, -18651, -18431, -18273, -18191, -18175, -18203, -18247, -18278, -18277, -18228, -18118, -17949, -17734, -17485, -17216, -16943, -16675, -16426, -16211, -16064, -16021, -16123, -16399, -16862, -17518, -18357, -19364, -20535, -21852, -23277, -24764, -26237, -27624, -28875, -29946, -30794, -31352, -31538, -31280, -30553, -29384, -27845, -26009, -23952, -21743, -19444, -17155, -15014, -13179, -11790, -10902, -10484, -10452, -10699, -11115, -11609, -12130, -12636, -13084, -13459, -13770, -14045, -14308, -14552, -14749, -14864, -14862, -14703, -14341, -13753, -12951, -11974, -10892, -9796, -8759, -7828, -7008, -6269, -5582, -4928, -4296, -3669, -3017, -2308, -1524, -635};