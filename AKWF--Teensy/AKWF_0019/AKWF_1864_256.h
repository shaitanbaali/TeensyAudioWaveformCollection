/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1864 256 samples */
 
const int16_t AKWF_1864_256_DATA [256] = 
{225, 903, 1499, 2038, 2526, 2965, 3362, 3719, 4042, 4333, 4596, 4832, 5045, 5237, 5410, 5566, 5706, 5833, 5947, 6049, 6141, 6225, 6299, 6365, 6425, 6479, 6527, 6570, 6610, 6644, 6675, 6702, 6726, 6747, 6767, 6784, 6799, 6812, 6824, 6833, 6842, 6850, 6858, 6863, 6867, 6871, 6874, 6876, 6878, 6879, 6880, 6880, 6880, 6880, 6880, 6879, 6878, 6876, 6875, 6872, 6871, 6869, 6866, 6864, 6862, 6859, 6856, 6854, 6850, 6847, 6844, 6841, 6837, 6834, 6831, 6827, 6824, 6821, 6817, 6814, 6811, 6808, 6804, 6801, 6798, 6794, 6790, 6787, 6783, 6780, 6777, 6773, 6770, 6767, 6763, 6760, 6755, 6752, 6748, 6744, 6741, 6737, 6734, 6730, 6727, 6723, 6720, 6716, 6713, 6709, 6706, 6702, 6699, 6695, 6692, 6688, 6685, 6681, 6677, 6674, 6670, 6667, 6663, 6660, 6656, 6653, 6649, 6645, 6641, 6638, 6635, 6631, 6627, 6624, 6620, 6617, 6614, 6610, 6607, 6603, 6600, 6596, 6593, 6589, 6586, 6583, 6579, 6576, 6571, 6568, 6564, 6561, 6557, 6553, 6550, 6546, 6516, 6637, 5834, 2750, 1061, -180, -1424, -3061, -3406, -4210, -5078, -5497, -5876, -7092, -7548, -7925, -8960, -10386, -10519, -10637, -11120, -11470, -10980, -11173, -11343, -10882, -11218, -11667, -11664, -11666, -12789, -14671, -16248, -17696, -18998, -20172, -21233, -22186, -23045, -23822, -24519, -25147, -25731, -26190, -26859, -30345, -32636, -31132, -25258, -20362, -17907, -15454, -13278, -11309, -9531, -7932, -6485, -5178, -4001, -2938, -1977, -1120, -317, 305, -635, -1322, -2391, -3763, -4481, -5196, -6457, -6549, -6898, -7465, -7733, -7688, -8709, -9006, -9214, -9900, -10163, -9838, -10083, -10438, -10992, -10469, -10635, -10828, -10470, -10581, -11241, -10165, -8404, -6920, -5557, -4328, -3220, -2219, -1318, -491};