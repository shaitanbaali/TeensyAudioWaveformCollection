/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1814 256 samples */
 
const int16_t AKWF_1814_256_DATA [256] = 
{2520, 6311, 9560, 12635, 15407, 17967, 20223, 22077, 23798, 25314, 26606, 27696, 28721, 29533, 30180, 30804, 31290, 31728, 32092, 32332, 32516, 32692, 32748, 32762, 32746, 32715, 32689, 32504, 32338, 32184, 31914, 31669, 31362, 30930, 30474, 30020, 29472, 28889, 28218, 27394, 26592, 25650, 24557, 23492, 22323, 20951, 19616, 18130, 16491, 14887, 13179, 11463, 9654, 7816, 5962, 4185, 2456, 752, -954, -2643, -4154, -5597, -7089, -8442, -9702, -11007, -12188, -13098, -14009, -15025, -15794, -16436, -16949, -17377, -17700, -17772, -17614, -17394, -17072, -16408, -15634, -14679, -13596, -12260, -10781, -9295, -7621, -5866, -4042, -2133, -253, 1503, 3374, 5202, 6813, 8225, 9701, 11172, 12274, 13275, 14111, 14848, 15595, 16037, 16321, 16539, 16693, 16679, 16498, 16273, 15890, 15479, 15034, 14542, 13998, 13415, 12769, 12170, 11574, 10937, 10376, 9767, 9295, 8752, 8176, 7699, 7097, 6438, 5797, 5044, 4205, 3435, 2439, 1246, -9, -1474, -3014, -4805, -6975, -9185, -11552, -14122, -16916, -17886, -16915, -16071, -15239, -14490, -13792, -13175, -12677, -12262, -11960, -11774, -11652, -11598, -11597, -11623, -11665, -11717, -11758, -11790, -11808, -11813, -11797, -11778, -11762, -11716, -11667, -11632, -11600, -11569, -11540, -11515, -11499, -11483, -11471, -11463, -11458, -11460, -11473, -11489, -11503, -11533, -11583, -11647, -11722, -11804, -11898, -12015, -12138, -12261, -12388, -12514, -12633, -12717, -12814, -12896, -12963, -13003, -12991, -12979, -12968, -12924, -12845, -12803, -12720, -12624, -12528, -12459, -12382, -12317, -12237, -12147, -12089, -12053, -12037, -11998, -11990, -12004, -12002, -12043, -12074, -12120, -12147, -12201, -12256, -12284, -12339, -12368, -12354, -12308, -12261, -12177, -12037, -11895, -11711, -11513, -11319, -11123, -10964, -10858, -10838, -10924, -11144, -11524, -12068, -12732, -13608, -14608, -15729, -16848, -14153, -9627, -5423, -1209};