/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1873 256 samples */
 
const int16_t AKWF_1873_256_DATA [256] = 
{997, 2559, 4119, 5702, 7299, 8908, 10522, 12127, 13720, 15297, 16843, 18356, 19828, 21245, 22608, 23905, 25129, 26280, 27346, 28322, 29211, 30002, 30695, 31290, 31783, 32175, 32468, 32661, 32757, 32759, 32672, 32499, 32244, 31914, 31515, 31051, 30531, 29962, 29349, 28701, 28022, 27320, 26605, 25879, 25149, 24422, 23700, 22989, 22295, 21615, 20956, 20319, 19702, 19108, 18535, 17981, 17442, 16919, 16403, 15895, 15387, 14873, 14349, 13807, 13242, 12651, 12028, 11371, 10681, 9955, 9193, 8397, 7568, 6707, 5823, 4913, 3983, 3043, 2089, 1131, 176, -775, -1714, -2636, -3536, -4411, -5252, -6061, -6831, -7556, -8237, -8871, -9453, -9985, -10463, -10889, -11262, -11580, -11845, -12061, -12225, -12340, -12409, -12432, -12412, -12350, -12249, -12112, -11939, -11733, -11495, -11224, -10927, -10596, -10239, -9853, -9436, -8988, -8510, -7997, -7451, -6867, -6241, -5576, -4866, -4109, -3311, -2470, -1587, -670, 280, 1259, 2259, 3277, 4305, 5332, 6357, 7369, 8356, 9319, 10243, 11120, 11948, 12715, 13413, 14042, 14592, 15056, 15433, 15719, 15909, 16004, 16000, 15899, 15699, 15404, 15017, 14537, 13971, 13322, 12595, 11798, 10935, 10013, 9040, 8022, 6966, 5883, 4775, 3653, 2526, 1396, 272, -835, -1931, -3000, -4041, -5055, -6032, -6972, -7876, -8742, -9567, -10358, -11113, -11833, -12525, -13190, -13832, -14460, -15076, -15685, -16296, -16908, -17527, -18157, -18796, -19446, -20108, -20779, -21459, -22145, -22831, -23518, -24200, -24872, -25531, -26172, -26788, -27377, -27933, -28449, -28925, -29355, -29733, -30057, -30325, -30532, -30678, -30761, -30780, -30731, -30616, -30436, -30191, -29881, -29508, -29075, -28583, -28034, -27430, -26777, -26074, -25326, -24536, -23703, -22834, -21931, -20992, -20022, -19026, -17998, -16943, -15863, -14754, -13619, -12456, -11263, -10040, -8787, -7495, -6169, -4807, -3406, -1973, -471};