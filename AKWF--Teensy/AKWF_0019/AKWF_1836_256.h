/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1836 256 samples */
 
const int16_t AKWF_1836_256_DATA [256] = 
{3496, 3865, 3792, 3738, 4917, 5444, 5363, 5257, 6714, 7753, 7898, 7748, 9136, 10088, 9922, 9892, 11515, 12268, 11425, 10419, 29596, 32047, 31373, 31466, 31827, 32022, 31969, 31949, 32657, 32290, 31315, 31349, 31531, 31586, 31554, 31525, 31702, 31750, 31847, 30555, 29687, 30030, 29942, 29929, 30122, 30159, 30124, 30084, 30728, 29050, 28013, 28107, 29230, 29718, 29265, 31223, 8566, -3990, -1987, -6240, -3621, -2432, -2691, -2657, -2453, -2380, -2427, -2255, -2794, -6457, -6837, -6673, -5389, -5117, -5179, -5156, -3930, -3291, -5076, -8592, -7244, -6813, -6901, -6902, -6504, -6321, -6396, -6143, -7555, -9537, -9330, -9355, -7647, -7184, -7279, -7264, -7061, -6900, -8687, -9802, -9415, -9354, -9380, -9324, -8234, -8016, -8047, -8083, -8884, -9155, -9092, -9104, -8893, -8816, -8827, -8826, -8803, -8867, -9216, -9247, -9014, -8965, -8975, -8965, -7683, -7332, -7401, -7411, -6586, -6287, -6333, -6392, -5212, -4681, -4760, -4869, -3384, -2553, -2680, -2803, -1415, -460, -622, -647, 993, 1574, 1455, 1439, 2022, 2284, 2231, 2205, 2571, 2773, 2726, 2731, 3364, 3531, 3486, 3480, 3680, 3745, 3725, 3709, 3903, 4126, 3265, 11543, 19805, 18986, 19115, 19112, 19315, 19360, 19311, 19273, 20164, 9735, 4133, 5064, 6033, 6533, 6089, 8058, -14564, -27194, -24864, -25284, -21667, -20686, -20892, -20847, -20630, -20548, -20548, -20558, -20151, -19953, -19993, -19918, -18599, -18316, -18371, -18341, -17051, -16690, -16750, -16760, -15508, -15064, -15139, -15135, -14728, -14541, -14572, -14532, -14087, -13987, -14001, -13979, -12270, -11801, -11888, -11868, -11654, -11571, -11574, -11577, -11372, -11270, -11295, -11237, -10143, -9917, -9963, -9943, -9724, -9662, -9667, -9664, -9453, -9374, -9383, -9376, -9368, -9360, -9358, -9344, -9120, -9067, -9078, -9066, -7785, -7347, -7885, -5038};