/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1896 256 samples */
 
const int16_t AKWF_1896_256_DATA [256] = 
{2009, 8233, 13684, 18197, 21569, 23942, 25439, 26209, 26462, 26416, 26290, 26287, 26532, 26914, 27370, 27891, 28453, 29028, 29578, 30070, 30479, 30840, 31182, 31502, 31795, 32054, 32280, 32465, 32607, 32706, 32761, 32767, 32751, 32689, 32585, 32444, 32269, 32055, 31806, 31521, 31200, 30845, 30459, 30037, 29584, 29100, 28585, 28045, 27476, 26880, 26258, 25615, 24949, 24266, 23563, 22841, 22104, 21354, 20593, 19822, 19042, 18254, 17463, 16668, 15876, 15081, 14289, 13500, 12718, 11948, 11188, 10437, 9699, 8976, 8274, 7586, 6918, 6274, 5651, 5055, 4485, 3939, 3422, 2935, 2479, 2057, 1666, 1307, 984, 695, 443, 228, 49, -89, -189, -247, -259, -230, -164, -65, 60, 208, 377, 555, 719, 881, 1071, 1317, 1655, 2106, 2694, 3434, 4337, 5375, 6487, 7594, 8628, 9507, 10160, 10537, 10662, 10579, 10267, 9705, 8880, 7776, 6400, 4762, 2818, 500, -2062, -4713, -7273, -9566, -11436, -12751, -13409, -13408, -12835, -11819, -10495, -9029, -7569, -6266, -5230, -4418, -3772, -3286, -2921, -2638, -2399, -2157, -1883, -1593, -1322, -1074, -852, -657, -499, -380, -303, -269, -276, -323, -407, -529, -690, -886, -1120, -1388, -1692, -2033, -2405, -2811, -3249, -3719, -4217, -4743, -5299, -5881, -6490, -7122, -7770, -8444, -9137, -9844, -10570, -11309, -12055, -12819, -13589, -14366, -15150, -15931, -16716, -17505, -18287, -19067, -19843, -20604, -21362, -22107, -22838, -23556, -24253, -24933, -25597, -26239, -26857, -27451, -28017, -28558, -29071, -29556, -30009, -30430, -30818, -31174, -31496, -31781, -32030, -32241, -32415, -32554, -32656, -32721, -32751, -32745, -32709, -32641, -32535, -32386, -32188, -31936, -31629, -31250, -30743, -30119, -29438, -28764, -28164, -27692, -27393, -27297, -27545, -28104, -28753, -29247, -29325, -28741, -27267, -24742, -21023, -16198, -10494, -4141};