/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1885 256 samples */
 
const int16_t AKWF_1885_256_DATA [256] = 
{1979, 6107, 9616, 12702, 15401, 17765, 19835, 21642, 23225, 24611, 25819, 26879, 27805, 28614, 29321, 29939, 30478, 30951, 31363, 31722, 32035, 32307, 32512, 32856, 31838, 27973, 24132, 20583, 17502, 14795, 12438, 10379, 8579, 7013, 5646, 4453, 3418, 2516, 1731, 1051, 459, -53, -495, -879, -1209, -1492, -1736, -1945, -2121, -2270, -2395, -2496, -2575, -2637, -2682, -2713, -2734, -2749, -2762, -2774, -2785, -2794, -2801, -2806, -2804, -2796, -2785, -2769, -2750, -2727, -2703, -2676, -2646, -2615, -2589, -2565, -2545, -2526, -2511, -2496, -2484, -2473, -2463, -2454, -2447, -2441, -2435, -2430, -2425, -2420, -2417, -2414, -2411, -2408, -2406, -2404, -2401, -2400, -2398, -2396, -2395, -2394, -2392, -2391, -2389, -2389, -2388, -2387, -2386, -2384, -2384, -2383, -2382, -2382, -2382, -2381, -2379, -2379, -2377, -2378, -2377, -2377, -2376, -2374, -2375, -2373, -2372, -2372, -2371, -2371, -2370, -2369, -2370, -2368, -2367, -2368, -2366, -2366, -2365, -2363, -2364, -2363, -2362, -2363, -2361, -2361, -2360, -2358, -2359, -2358, -2357, -2358, -2356, -2355, -2355, -2353, -2354, -2352, -2351, -2352, -2351, -2350, -2350, -2349, -2349, -2348, -2347, -2350, -2364, -2386, -2417, -2454, -2496, -2543, -2591, -2641, -2693, -2747, -2802, -2854, -2900, -2941, -2976, -3008, -3034, -3058, -3078, -3095, -3110, -3124, -3136, -3146, -3154, -3162, -3168, -3174, -3178, -3182, -3186, -3189, -3191, -3194, -3196, -3196, -3198, -3199, -3201, -3209, -3226, -3247, -3275, -3307, -3343, -3380, -3411, -3463, -3542, -3614, -3691, -3771, -3854, -3938, -4012, -4075, -4131, -4180, -4213, -4232, -4236, -4230, -4211, -4178, -4129, -4071, -4053, -4978, -7794, -11512, -14958, -17964, -20091, -20998, -19576, -17294, -15443, -13814, -12404, -11178, -10120, -9209, -8421, -7745, -7157, -6690, -6253, -2666};