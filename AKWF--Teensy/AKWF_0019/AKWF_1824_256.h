/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1824 256 samples */
 
const int16_t AKWF_1824_256_DATA [256] = 
{4656, 10777, 15657, 19275, 21706, 23154, 23821, 23917, 23618, 23053, 22324, 21498, 20629, 19744, 18864, 18007, 17180, 16387, 15633, 14915, 14233, 13589, 12982, 12405, 11858, 11344, 10855, 10392, 9955, 9538, 9143, 8769, 8412, 8074, 7751, 7444, 7149, 6868, 6600, 6343, 6097, 5861, 5636, 5420, 5210, 5012, 4820, 4634, 4457, 4286, 4120, 3961, 3808, 3658, 3516, 3377, 3242, 3112, 2987, 2865, 2748, 2633, 2522, 2416, 2311, 2209, 2110, 2016, 1922, 1831, 1743, 1658, 1575, 1494, 1415, 1338, 1263, 1189, 1117, 1049, 981, 914, 850, 786, 725, 664, 605, 549, 493, 439, 388, 341, 300, 271, 257, 275, 359, 272, 2947, -2312, -18730, 6273, -185, 524, 310, 266, 265, 287, 322, 365, 414, 466, 519, 574, 631, 689, 749, 810, 873, 937, 1002, 1069, 1138, 1208, 1279, 1353, 1430, 1508, 1587, 1669, 1753, 1839, 1928, 2019, 2111, 2208, 2308, 2411, 2516, 2624, 2736, 2850, 2969, 3093, 3218, 3350, 3486, 3627, 3771, 3921, 4077, 4239, 4406, 4580, 4762, 4949, 5145, 5350, 5561, 5783, 6014, 6255, 6507, 6771, 7047, 7338, 7641, 7958, 8293, 8645, 9016, 9408, 9819, 10254, 10713, 11198, 11710, 12255, 12827, 13432, 14075, 14755, 15468, 16218, 17008, 17826, 18671, 19533, 20388, 21216, 21978, 22614, 23043, 23150, 22786, 21756, 19853, 16867, 12621, 7171, 759, -6210, -12998, -19094, -24100, -27837, -30365, -31895, -32618, -32757, -32485, -31938, -31219, -30396, -29525, -28633, -27751, -26887, -26050, -25250, -24488, -23760, -23070, -22420, -21802, -21217, -20672, -20110, -19883, -20340, -20854, -21387, -21955, -22556, -23191, -23865, -24577, -25319, -26102, -26917, -27753, -28604, -29453, -30266, -31008, -31617, -32011, -32070, -31644, -30536, -28526, -25424, -21062, -15500, -9019, -1952};