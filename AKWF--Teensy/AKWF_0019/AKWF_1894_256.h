/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1894 256 samples */
 
const int16_t AKWF_1894_256_DATA [256] = 
{3408, 12244, 20227, 27074, 31955, 32863, 32731, 32767, 32747, 32837, 32100, 30124, 28610, 27733, 27269, 27140, 27288, 27626, 28056, 28475, 28785, 28927, 28985, 29012, 29008, 28981, 28941, 28898, 28860, 28838, 28825, 28815, 28807, 28801, 28797, 28792, 28787, 28782, 28775, 28768, 28760, 28753, 28745, 28737, 28730, 28723, 28715, 28707, 28700, 28692, 28685, 28678, 28670, 28662, 28654, 28646, 28639, 28632, 28624, 28616, 28608, 28601, 28593, 28586, 28578, 28570, 28563, 28555, 28547, 28540, 28532, 28524, 28517, 28509, 28501, 28494, 28486, 28479, 28471, 28463, 28455, 28448, 28440, 28433, 28426, 28418, 28410, 28403, 28395, 28385, 28375, 28366, 28357, 28350, 28345, 28341, 28346, 28359, 28378, 28394, 28399, 28386, 28350, 28291, 28164, 27917, 27596, 27272, 27022, 26914, 27015, 27361, 28015, 29080, 30460, 31771, 32040, 31985, 31972, 32025, 30632, 27264, 22927, 17773, 12104, 6195, 334, -5166, -10075, -14389, -18221, -21600, -24484, -26890, -28838, -30346, -31459, -32129, -32257, -32001, -31364, -30531, -29613, -28742, -28033, -27558, -27303, -27239, -27328, -27528, -27782, -28036, -28241, -28354, -28408, -28434, -28432, -28410, -28376, -28338, -28305, -28283, -28271, -28261, -28253, -28247, -28241, -28237, -28231, -28225, -28218, -28211, -28203, -28196, -28188, -28180, -28174, -28167, -28159, -28151, -28144, -28136, -28129, -28122, -28114, -28106, -28099, -28091, -28084, -28077, -28069, -28062, -28054, -28046, -28038, -28031, -28024, -28017, -28009, -28001, -27994, -27987, -27979, -27972, -27964, -27956, -27949, -27941, -27935, -27927, -27919, -27911, -27904, -27895, -27888, -27879, -27872, -27865, -27858, -27852, -27848, -27845, -27843, -27840, -27834, -27826, -27813, -27795, -27767, -27728, -27684, -27639, -27601, -27575, -27568, -27588, -27603, -27544, -27434, -27323, -27258, -27289, -27457, -27777, -28292, -29207, -30476, -31427, -31460, -31442, -31432, -29594, -25805, -20364, -13371, -5048};