/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1880 256 samples */
 
const int16_t AKWF_1880_256_DATA [256] = 
{2063, 7846, 13684, 19212, 22914, 24228, 23539, 20704, 16733, 12187, 7353, 2573, -2259, -7407, -12758, -18332, -23841, -28356, -31673, -32749, -31331, -27770, -21979, -15336, -8462, -2118, 2842, 6654, 9260, 10991, 12350, 13335, 13831, 13799, 12681, 10421, 7295, 3307, -511, -3707, -5792, -6106, -5150, -2957, -189, 2290, 4335, 5366, 5492, 5066, 4183, 3236, 2332, 1175, -317, -2399, -5375, -8744, -12391, -15675, -17774, -18645, -17677, -15190, -11639, -7297, -3061, 865, 4228, 6910, 9202, 11223, 12929, 14376, 15232, 15080, 13959, 11525, 8122, 4214, 91, -3380, -6054, -7644, -8075, -7820, -7004, -6035, -5192, -4405, -3690, -2944, -1963, -882, 163, 1039, 1260, 823, -373, -2297, -4353, -6391, -7853, -8402, -8151, -6962, -5229, -3215, -1092, 860, 2673, 4388, 6003, 7623, 9213, 10449, 11264, 11252, 10203, 8303, 5480, 2276, -996, -4024, -6338, -8001, -8868, -9091, -8967, -8568, -8015, -7344, -6341, -4929, -3196, -1098, 936, 2648, 3853, 4192, 3861, 2889, 1522, 212, -942, -1621, -1795, -1621, -1129, -554, 0, 590, 1222, 1978, 3004, 4152, 5376, 6491, 7120, 7230, 6527, 5081, 3117, 723, -1585, -3650, -5279, -6312, -6918, -7132, -7061, -6812, -6337, -5535, -4420, -2865, -971, 1029, 3044, 4659, 5777, 6290, 6103, 5495, 4544, 3503, 2593, 1811, 1211, 728, 239, -238, -673, -1039, -1139, -945, -426, 450, 1391, 2295, 2911, 2991, 2629, 1747, 567, -670, -1879, -2806, -3462, -3894, -4123, -4285, -4420, -4403, -4208, -3673, -2648, -1297, 390, 2148, 3700, 4984, 5763, 6104, 6055, 5678, 5170, 4589, 4008, 3466, 2893, 2257, 1591, 872, 242, -165, -312, -18, 612, 1484, 2489, 3275, 3783, 3891, 3558, 3055, 2462, 1832, 1241, 465, -815, -2264, -3783, -4820, -4183, -1932};