/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1804 256 samples */
 
const int16_t AKWF_1804_256_DATA [256] = 
{105, 292, 448, 584, 709, 827, 949, 1077, 1219, 1381, 1568, 1788, 2044, 2340, 2682, 3077, 3529, 4043, 4623, 5273, 5995, 6803, 7691, 8667, 9729, 10869, 12101, 13417, 14805, 16261, 17764, 19296, 20855, 22406, 23924, 25390, 26770, 28041, 29192, 30190, 31031, 31704, 32204, 32543, 32724, 32767, 32684, 32489, 32203, 31840, 31410, 30934, 30400, 29806, 29212, 28157, 26484, 24867, 23261, 21671, 20108, 18574, 17089, 15656, 14274, 12966, 11743, 10615, 9598, 8691, 7903, 7246, 6719, 6326, 6069, 5939, 5933, 6045, 6260, 6565, 6947, 7393, 7882, 8400, 8928, 9451, 9958, 10439, 10875, 11255, 11584, 11843, 12033, 12150, 12188, 12151, 12041, 11857, 11601, 11277, 10891, 10449, 9950, 9407, 8822, 8201, 7559, 6892, 6208, 5520, 4829, 4145, 3476, 2817, 2182, 1577, 1002, 465, -33, -491, -905, -1274, -1598, -1875, -2109, -2300, -2451, -2566, -2647, -2701, -2732, -2747, -2754, -2759, -2770, -2795, -2842, -2920, -3032, -3188, -3393, -3651, -3966, -4341, -4779, -5275, -5835, -6453, -7129, -7853, -8627, -9452, -10318, -11220, -12158, -13126, -14134, -15172, -16241, -17334, -18446, -19578, -20721, -21863, -22992, -24092, -25151, -26161, -27104, -27973, -28755, -29445, -30042, -30546, -30955, -31270, -31494, -31624, -31664, -31610, -31457, -31197, -30891, -30048, -28496, -26947, -25378, -23820, -22293, -20795, -19358, -18005, -16743, -15592, -14566, -13659, -12888, -12251, -11739, -11351, -11069, -10884, -10779, -10737, -10746, -10785, -10844, -10907, -10962, -11007, -11034, -11040, -11025, -10986, -10925, -10846, -10746, -10624, -10479, -10304, -10103, -9863, -9582, -9255, -8876, -8446, -7964, -7424, -6835, -6197, -5515, -4806, -4065, -3308, -2546, -1787, -1042, -326, 361, 1008, 1604, 2147, 2630, 3050, 3384, 3791, 3645, -3034, -3207, -2393, -1902, -1431, -1023, -668, -365, -104};