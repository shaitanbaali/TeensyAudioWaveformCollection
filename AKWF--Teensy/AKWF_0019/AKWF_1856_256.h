/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1856 256 samples */
 
const int16_t AKWF_1856_256_DATA [256] = 
{1111, 4374, 7206, 9740, 11992, 13993, 15768, 17332, 18713, 19927, 20986, 21910, 22712, 23399, 23988, 24486, 24902, 25243, 25520, 25734, 25897, 26009, 26076, 26104, 26096, 26056, 25988, 25892, 25772, 25630, 25469, 25292, 25097, 24889, 24668, 24436, 24192, 23939, 23678, 23410, 23134, 22852, 22565, 22272, 21974, 21673, 21367, 21059, 20748, 20432, 20115, 19797, 19475, 19152, 18828, 18501, 18173, 17845, 17514, 17184, 16853, 16520, 16187, 15852, 15518, 15183, 14848, 14512, 14176, 13839, 13502, 13166, 12827, 12489, 12152, 11813, 11474, 11137, 10798, 10459, 10121, 9781, 9443, 9104, 8764, 8425, 8086, 7746, 7407, 7067, 6728, 6388, 6049, 5709, 5370, 5030, 4689, 4350, 4011, 3671, 3331, 3006, 2712, 2447, 2208, 1992, 1797, 1621, 1462, 1321, 1191, 1074, 970, 875, 789, 712, 641, 579, 523, 472, 426, 383, 346, 312, 282, 254, 229, 206, 187, 168, 151, 137, 124, 111, 101, 91, 82, 74, 66, 59, 53, 49, 45, 31, -10, -82, -180, -300, -444, -606, -785, -981, -1190, -1411, -1645, -1889, -2142, -2403, -2673, -2949, -3231, -3520, -3813, -4111, -4412, -4718, -5027, -5339, -5653, -5971, -6290, -6612, -6934, -7259, -7586, -7913, -8241, -8572, -8903, -9234, -9567, -9901, -10235, -10569, -10904, -11239, -11575, -11912, -12248, -12585, -12922, -13259, -13597, -13935, -14274, -14613, -14951, -15289, -15628, -15966, -16305, -16645, -16984, -17323, -17662, -18001, -18341, -18681, -19020, -19360, -19699, -20038, -20378, -20718, -21057, -21398, -21737, -22076, -22416, -22756, -23096, -23436, -23776, -24115, -24455, -24795, -25134, -25475, -25814, -26154, -26495, -26834, -27173, -27514, -27853, -28194, -28534, -28872, -29213, -29554, -29892, -30233, -30573, -30912, -31253, -31592, -31931, -32239, -32680, -32132, -27677, -21401, -15863, -10881, -6422, -2370};