/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1839 256 samples */
 
const int16_t AKWF_1839_256_DATA [256] = 
{8051, 9204, 8984, 8949, 6182, 5627, 5536, 7140, 9244, 9031, 9069, 9047, 8870, 8886, 8680, 9970, 12248, 12099, 12111, 12134, 12910, 13112, 12866, 14020, 16559, 16486, 16491, 16464, 16196, 16170, 16135, 16327, 16867, 16870, 16848, 16881, 18088, 18381, 18112, 19337, 22929, 22988, 22951, 22966, 23047, 23057, 23012, 23223, 23614, 23567, 23612, 23462, 18436, 17353, 17564, 17672, 17926, 17843, 17978, 17430, 12496, 12102, 11462, 15190, 31159, 32284, 31952, 32042, 32382, 32244, 33401, 24828, 14439, 15738, 15490, 15545, 16072, 16117, 16136, 15912, 15427, 15429, 15426, 15417, 15239, 15173, 15300, 14650, 12255, 12074, 12094, 12175, 13052, 13106, 13268, 12382, 7489, 7001, 7133, 7082, 6386, 6173, 6544, 4089, 673, 936, 816, 1132, 4038, 4294, 4568, 2329, -170, 368, 272, 260, -433, -615, -430, -1235, -4816, -5224, -5063, -5347, -7724, -7944, -8041, -7482, 2240, 3824, 3475, 3469, 701, 90, 298, -272, -975, -906, -915, -937, -1113, -1140, -1099, -1323, -1805, -1797, -1803, -1783, -1006, -868, -752, -1532, -4120, -4175, -4146, -4185, -4449, -4494, -4412, -4769, -6467, -6605, -6578, -6553, -5340, -5082, -5121, -5522, -4031, -3753, -3822, -3803, -3714, -3718, -3650, -4084, -4873, -4846, -4803, -4948, -9967, -11202, -10147, -14556, -26271, -26309, -26114, -26689, -31616, -32138, -32081, -31708, -29394, -29148, -29206, -29174, -28819, -28722, -28809, -28257, -26871, -26742, -26777, -26704, -26167, -26075, -26222, -25351, -23850, -23948, -23922, -23918, -24084, -24077, -24267, -23126, -20806, -20992, -20981, -20875, -19987, -19863, -19984, -19428, -18484, -18586, -18557, -18569, -19254, -19383, -19416, -18871, -18417, -18535, -18581, -18256, -15343, -14938, -15433, -12905, -6719, -6671, -6695, -6690, -7379, -7482, -7680, -6383, -4398, -4822, -4683, -4946, -7320, -7546, -7658, -6705};