/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1819 256 samples */
 
const int16_t AKWF_1819_256_DATA [256] = 
{4367, 10669, 15765, 19648, 22331, 23981, 24814, 25037, 24828, 24324, 23636, 22833, 21969, 21087, 20200, 19333, 18495, 17684, 16909, 16175, 15476, 14813, 14186, 13591, 13030, 12499, 11993, 11515, 11064, 10633, 10225, 9837, 9469, 9119, 8784, 8464, 8160, 7870, 7592, 7326, 7072, 6829, 6594, 6370, 6154, 5948, 5748, 5556, 5373, 5195, 5024, 4859, 4700, 4544, 4396, 4253, 4115, 3979, 3849, 3723, 3601, 3482, 3367, 3255, 3147, 3042, 2940, 2840, 2744, 2651, 2560, 2470, 2384, 2300, 2218, 2137, 2060, 1984, 1910, 1838, 1767, 1698, 1630, 1565, 1501, 1438, 1378, 1318, 1259, 1202, 1146, 1092, 1038, 632, 2841, -9328, -9323, 2847, 637, 1041, 1092, 1145, 1200, 1255, 1312, 1370, 1429, 1489, 1551, 1614, 1678, 1745, 1813, 1882, 1953, 2026, 2101, 2179, 2256, 2337, 2419, 2505, 2592, 2682, 2774, 2869, 2966, 3066, 3170, 3277, 3387, 3500, 3616, 3737, 3862, 3990, 4122, 4259, 4401, 4548, 4701, 4858, 5021, 5191, 5368, 5551, 5742, 5939, 6145, 6360, 6584, 6816, 7061, 7315, 7582, 7860, 8152, 8459, 8781, 9118, 9472, 9845, 10239, 10654, 11088, 11549, 12037, 12552, 13094, 13670, 14277, 14921, 15598, 16310, 17062, 17849, 18665, 19507, 20368, 21223, 22060, 22837, 23497, 23971, 24155, 23903, 23043, 21369, 18664, 14751, 9622, 3445, -3445, -10389, -16812, -22235, -26459, -29456, -31367, -32393, -32757, -32645, -32204, -31553, -30769, -29914, -29023, -28129, -27254, -26398, -25573, -24785, -24034, -23320, -22642, -21997, -21389, -20816, -20273, -19735, -19504, -19514, -19495, -19480, -19465, -19450, -19442, -19402, -19603, -20111, -20625, -21166, -21743, -22356, -23001, -23681, -24398, -25153, -25943, -26763, -27600, -28457, -29310, -30127, -30870, -31483, -31884, -31956, -31552, -30490, -28543, -25512, -21260, -15827, -9403, -2331};