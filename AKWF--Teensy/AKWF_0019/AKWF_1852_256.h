/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1852 256 samples */
 
const int16_t AKWF_1852_256_DATA [256] = 
{788, 2265, 3758, 5293, 6853, 8435, 10028, 11619, 13205, 14780, 16332, 17859, 19354, 20809, 22225, 23591, 24897, 26141, 27312, 28397, 29388, 30270, 31032, 31668, 32162, 32514, 32716, 32768, 32672, 32434, 32059, 31559, 30947, 30233, 29434, 28558, 27624, 26640, 25618, 24569, 23496, 22405, 21310, 20208, 19106, 18012, 16929, 15862, 14822, 13811, 12837, 11909, 11024, 10190, 9409, 8676, 7990, 7347, 6737, 6153, 5586, 5026, 4467, 3901, 3322, 2731, 2124, 1506, 887, 271, -330, -907, -1451, -1950, -2395, -2783, -3109, -3374, -3582, -3737, -3846, -3919, -3963, -3987, -4003, -4014, -4026, -4042, -4058, -4073, -4082, -4081, -4062, -4019, -3946, -3839, -3697, -3517, -3302, -3056, -2788, -2503, -2210, -1917, -1634, -1370, -1132, -924, -750, -617, -523, -471, -457, -486, -555, -662, -809, -997, -1225, -1494, -1804, -2155, -2548, -2978, -3448, -3951, -4482, -5037, -5611, -6195, -6783, -7373, -7957, -8536, -9105, -9666, -10222, -10774, -11325, -11880, -12441, -13011, -13591, -14178, -14766, -15354, -15930, -16481, -17000, -17474, -17886, -18226, -18484, -18649, -18716, -18683, -18550, -18318, -17995, -17589, -17108, -16567, -15973, -15340, -14677, -13992, -13289, -12578, -11860, -11137, -10409, -9674, -8934, -8191, -7442, -6692, -5944, -5201, -4469, -3756, -3066, -2408, -1786, -1207, -674, -188, 251, 644, 995, 1311, 1595, 1854, 2090, 2312, 2520, 2716, 2899, 3065, 3210, 3329, 3416, 3459, 3456, 3397, 3277, 3092, 2836, 2508, 2110, 1640, 1098, 491, -179, -913, -1703, -2552, -3449, -4392, -5379, -6401, -7451, -8526, -9606, -10685, -11749, -12780, -13764, -14684, -15518, -16255, -16880, -17380, -17745, -17970, -18053, -17997, -17805, -17489, -17055, -16518, -15894, -15190, -14423, -13606, -12741, -11837, -10902, -9930, -8924, -7882, -6794, -5661, -4480, -3243, -1954, -578};