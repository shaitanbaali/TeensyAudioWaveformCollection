/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1830 256 samples */
 
const int16_t AKWF_1830_256_DATA [256] = 
{6267, 15582, 22416, 26530, 28280, 28327, 27304, 25689, 23803, 21844, 19949, 18145, 16475, 14946, 13551, 12288, 11142, 10094, 9142, 8278, 7488, 6770, 6108, 5503, 4946, 4434, 3962, 3529, 3127, 2754, 2411, 2094, 1800, 1527, 1275, 1040, 821, 620, 432, 258, 96, -51, -189, -317, -437, -548, -651, -745, -831, -912, -989, -1056, -1118, -1176, -1228, -1277, -1321, -1359, -1397, -1430, -1458, -1484, -1507, -1527, -1545, -1560, -1571, -1583, -1591, -1599, -1604, -1606, -1608, -1608, -1607, -1604, -1600, -1595, -1590, -1583, -1576, -1568, -1558, -1548, -1537, -1526, -1514, -1502, -1488, -1475, -1460, -1447, -1431, -1416, -1399, -1385, -1369, -1354, -1337, -1319, -1304, -1287, -1267, -1242, -1213, -1182, -1148, -1112, -1075, -1038, -1001, -965, -928, -891, -854, -818, -782, -744, -710, -675, -639, -603, -568, -534, -498, -464, -432, -397, -366, -334, -301, -268, -237, -206, -175, -144, -113, -82, -50, -20, 8, 37, 67, 98, 128, 158, 187, 218, 249, 279, 310, 340, 370, 401, 433, 464, 497, 528, 560, 593, 626, 660, 694, 727, 763, 799, 835, 873, 910, 951, 991, 1032, 1076, 1120, 1165, 1211, 1260, 1310, 1361, 1415, 1470, 1529, 1589, 1651, 1718, 1788, 1861, 1938, 2018, 2102, 2193, 2288, 2389, 2495, 2609, 2730, 2860, 2998, 3148, 3307, 3481, 3667, 3869, 4088, 4328, 4587, 4871, 5185, 5531, 5913, 6338, 6805, 7330, 7917, 8574, 9307, 10127, 11039, 12037, 13098, 14160, 15082, 15597, 15190, 13068, 8366, 827, -8618, -17993, -25440, -30185, -32396, -32718, -31804, -30181, -28211, -26125, -24076, -22126, -20292, -18633, -17403, -16855, -16830, -17106, -17596, -18245, -19018, -19864, -20692, -21338, -21458, -20465, -17497, -11838, -3210};