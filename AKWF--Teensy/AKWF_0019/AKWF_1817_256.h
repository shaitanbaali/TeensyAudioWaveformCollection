/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1817 256 samples */
 
const int16_t AKWF_1817_256_DATA [256] = 
{7316, 17704, 22452, 23987, 23898, 22979, 21594, 19953, 18212, 16496, 14907, 13483, 12241, 11176, 10262, 9477, 8801, 8205, 7671, 7177, 6698, 6225, 5753, 5292, 4857, 4468, 4140, 3880, 3680, 3524, 3387, 3238, 3056, 2830, 2575, 2310, 2064, 1856, 1697, 1582, 1494, 1412, 1312, 1178, 1013, 831, 656, 514, 425, 401, 441, 541, 686, 856, 1028, 1179, 1303, 1402, 1490, 1589, 1715, 1877, 2077, 2305, 2547, 2786, 3011, 3217, 3412, 3607, 3817, 4050, 4316, 4613, 4944, 5309, 5715, 6172, 6694, 7290, 7971, 8741, 9594, 10519, 11515, 12574, 13708, 14935, 16263, 17694, 19222, 20793, 22285, 23423, 23570, 21322, 14366, 1427, -13920, -25384, -30959, -32669, -32549, -31633, -30332, -28799, -27129, -25422, -23809, -22400, -21251, -20314, -19942, -20409, -20835, -21258, -21789, -22518, -23534, -24895, -26603, -28565, -30545, -32051, -32313, -30272, -24813, -15341, -2917, 9307, 18146, 22717, 24088, 23690, 22497, 21015, 19454, 17894, 16377, 14911, 13532, 12277, 11155, 10179, 9349, 8641, 8034, 7503, 7018, 6562, 6124, 5701, 5301, 4927, 4585, 4277, 4003, 3754, 3518, 3288, 3056, 2825, 2594, 2370, 2160, 1969, 1797, 1645, 1506, 1374, 1246, 1117, 991, 871, 768, 687, 636, 620, 640, 693, 775, 881, 999, 1124, 1251, 1377, 1506, 1644, 1796, 1966, 2157, 2365, 2587, 2815, 3041, 3266, 3492, 3724, 3971, 4243, 4548, 4888, 5258, 5656, 6073, 6503, 6953, 7434, 7963, 8572, 9284, 10122, 11105, 12235, 13495, 14868, 16323, 17829, 19371, 20907, 22344, 23439, 23626, 21855, 16688, 7283, -5153, -17285, -26228, -31158, -32742, -32175, -30517, -28508, -26581, -24922, -23588, -22554, -21740, -21077, -20446, -19934, -20406, -21302, -22355, -23613, -25031, -26564, -28141, -29700, -31155, -32229, -32180, -29327, -21135, -6978};