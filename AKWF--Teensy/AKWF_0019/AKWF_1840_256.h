/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1840 256 samples */
 
const int16_t AKWF_1840_256_DATA [256] = 
{28406, 31044, 30462, 30499, 28089, 27573, 27667, 27743, 28441, 28546, 28522, 28509, 28353, 28295, 28517, 27173, 24663, 24790, 24766, 24782, 25459, 25554, 25779, 24416, 20350, 20307, 20339, 20299, 20066, 19972, 20312, 18674, 11807, 11336, 11461, 11454, 12508, 12722, 12711, 12519, 10884, 10453, 10548, 10536, 10610, 10561, 10855, 9017, 5672, 5846, 5861, 5729, 1349, 377, 729, -60, -2188, -2248, -2114, -2598, -6896, -7396, -7153, -7801, -9722, -9765, -9745, -9743, -9440, -9401, -9282, -9883, -13491, -13954, -13847, -13819, -13357, -13354, -13093, -14763, -17881, -17719, -17737, -17746, -17895, -17964, -17768, -18763, -21990, -22140, -22112, -22041, -21273, -21242, -20990, -22277, -28641, -29198, -29039, -29093, -29694, -29838, -29739, -30043, -32360, -32721, -32699, -32435, -29898, -29532, -30063, -27270, -20799, -20820, -20838, -20835, -21437, -21552, -21609, -21111, -21049, -21415, -21287, -21524, -23596, -23755, -23999, -22733, -11100, -9516, -9879, -9872, -12285, -12734, -12944, -11508, -1358, 167, -204, -142, -296, -296, -400, 260, 1396, 1315, 1319, 1337, 2015, 2173, 2074, 2456, 3009, 2952, 2964, 2938, 2706, 2689, 2648, 2879, 3609, 3628, 3608, 3640, 4695, 4945, 4776, 5287, 8553, 8858, 8774, 8796, 8871, 8902, 8761, 9593, 11111, 11008, 11061, 10936, 6556, 5649, 5657, 6734, 9554, 9479, 9590, 9120, 4821, 4381, 4329, 5127, 9078, 9415, 9322, 9357, 9662, 9749, 9645, 10048, 13437, 14026, 13875, 13958, 14421, 14512, 14285, 15619, 17979, 17828, 17852, 17851, 17700, 17597, 17976, 15987, 10122, 9980, 10021, 10086, 10855, 10863, 11220, 9420, 981, 289, 489, 428, -174, -386, 28, -1685, -13806, -15640, -15257, -15070, -12533, -12305, -12076, -13955, -15999, -15534, -15617, -15627, -16229, -16380, -16253, -16751, -19320, -19679, -19539, -19785, -21857, -21833, -23120, -15921};