/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1898 256 samples */
 
const int16_t AKWF_1898_256_DATA [256] = 
{183, 567, 931, 1274, 1586, 1869, 2126, 2361, 2581, 2792, 2997, 3207, 3422, 3645, 3873, 4104, 4335, 4571, 4805, 5039, 5272, 5504, 5735, 5964, 6195, 6425, 6656, 6888, 7117, 7348, 7579, 7810, 8041, 8272, 8501, 8732, 8962, 9192, 9424, 9652, 9882, 10112, 10341, 10570, 10799, 11029, 11257, 11487, 11717, 11945, 12175, 12403, 12633, 12862, 13091, 13319, 13548, 13777, 14006, 14235, 14463, 14691, 14919, 15148, 15377, 15607, 15833, 16063, 16291, 16520, 16747, 16975, 17203, 17431, 17658, 17886, 18114, 18340, 18568, 18796, 19023, 19250, 19478, 19704, 19931, 20158, 20385, 20612, 20837, 21059, 21285, 21508, 21735, 21964, 22194, 22431, 22683, 22947, 23211, 23466, 23705, 23914, 24088, 24219, 24247, 24167, 24045, 23951, 23956, 24127, 24526, 25185, 26170, 27483, 28968, 30429, 31736, 32358, 32342, 32246, 31097, 29065, 26400, 23145, 19393, 15230, 10810, 6183, 1428, -3599, -8856, -14102, -19131, -23746, -27701, -30895, -32714, -32769, -32741, -32815, -32217, -30544, -28832, -27270, -26069, -25272, -24774, -24538, -24501, -24592, -24731, -24838, -24838, -24713, -24533, -24321, -24076, -23812, -23538, -23261, -22995, -22745, -22501, -22261, -22024, -21788, -21552, -21319, -21083, -20846, -20609, -20371, -20133, -19895, -19657, -19419, -19182, -18945, -18707, -18470, -18233, -17995, -17758, -17521, -17284, -17048, -16810, -16574, -16338, -16099, -15863, -15627, -15391, -15154, -14918, -14681, -14445, -14210, -13975, -13738, -13501, -13267, -13030, -12794, -12558, -12322, -12086, -11850, -11614, -11378, -11142, -10906, -10672, -10436, -10202, -9967, -9731, -9497, -9263, -9028, -8793, -8558, -8322, -8090, -7855, -7621, -7386, -7150, -6917, -6683, -6449, -6215, -5981, -5745, -5513, -5279, -5044, -4807, -4569, -4331, -4097, -3862, -3633, -3407, -3186, -2975, -2768, -2558, -2339, -2106, -1852, -1576, -1269, -933, -572, -191};