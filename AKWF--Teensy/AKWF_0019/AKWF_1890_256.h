/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1890 256 samples */
 
const int16_t AKWF_1890_256_DATA [256] = 
{160, 423, 680, 935, 1199, 1399, 1470, 1576, 1766, 2031, 2335, 2637, 2924, 3195, 3458, 3717, 3973, 4223, 4487, 4699, 4415, 4213, 4306, 4592, 4995, 5379, 5710, 5998, 6262, 6519, 6771, 7017, 7236, 7630, 6528, 5166, 5144, 5480, 6198, 6821, 7258, 7577, 7840, 8089, 8327, 8554, 8763, 9085, 8907, 7872, 8141, 8543, 10218, 11591, 12246, 12615, 12854, 13073, 13282, 13460, 13628, 13813, 14022, 14256, 14563, 14473, 18440, 22597, 23445, 23853, 23976, 24100, 24254, 24310, 24317, 24379, 24518, 24713, 24990, 24967, 26489, 29911, 29960, 30212, 29931, 29734, 29808, 29592, 29143, 28872, 28837, 28954, 29148, 29378, 29625, 29880, 30112, 30518, 29424, 28045, 28129, 27448, 25623, 24428, 23995, 23956, 24088, 24291, 24528, 24782, 25029, 25382, 25228, 24144, 24674, 23873, 17846, 13883, 12662, 12370, 12400, 12556, 12774, 13029, 13301, 13575, 13844, 14089, 14183, 15487, -2008, -16116, -17786, -18341, -18456, -18394, -18214, -17952, -17649, -17346, -17059, -16788, -16788, -15093, -22027, -33829, -32061, -32122, -32403, -32604, -32509, -32222, -31819, -31435, -31104, -30816, -30551, -30293, -30037, -29782, -29551, -29147, -30241, -31599, -31618, -31282, -30562, -29938, -29502, -29183, -28919, -28670, -28420, -28168, -27927, -27579, -27737, -28762, -28486, -28082, -26405, -25032, -24377, -24009, -23769, -23550, -23318, -23072, -22820, -22563, -22306, -22047, -21726, -21810, -17842, -13683, -12835, -12427, -12302, -12182, -11994, -11766, -11519, -11264, -11007, -10752, -10447, -10458, -8932, -5508, -5458, -5208, -5485, -5684, -5592, -5392, -5152, -4899, -4643, -4391, -4142, -3889, -3634, -3377, -3144, -2737, -3830, -5191, -5189, -5017, -4781, -4528, -4273, -4029, -3793, -3553, -3304, -3046, -2799, -2445, -2600, -3630, -3318, -3066, -2810, -2551, -2294, -2068, -1874, -1668, -1435, -1177, -904, -631, -362, -94};