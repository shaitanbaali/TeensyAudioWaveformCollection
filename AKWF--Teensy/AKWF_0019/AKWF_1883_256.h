/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1883 256 samples */
 
const int16_t AKWF_1883_256_DATA [256] = 
{64, 207, 378, 567, 798, 1059, 1323, 1574, 1795, 1987, 2154, 2294, 2408, 2491, 2531, 2507, 2449, 2374, 2290, 2211, 2134, 2062, 1991, 1922, 1857, 1801, 1729, 1691, 4378, 8325, 11579, 14473, 17019, 19250, 21211, 22939, 24450, 25776, 26940, 27957, 28848, 29630, 30304, 30894, 31446, 29983, 27338, 25180, 23279, 21612, 20139, 20826, 22713, 24200, 25524, 26683, 27694, 28575, 29345, 30014, 30596, 31105, 31546, 31929, 32237, 32580, 32552, 28025, 21628, 15824, 10264, 5242, 785, -3121, -6530, -9519, -12136, -14420, -16423, -18176, -19705, -21047, -22224, -23256, -24163, -24955, -25646, -26251, -26781, -27237, -27643, -27988, -27167, -25795, -24693, -23639, -23537, -24449, -25198, -25860, -26439, -26944, -27387, -27772, -28109, -28403, -28659, -28879, -29063, -29219, -29348, -29460, -29550, -29622, -29686, -29740, -29777, -29797, -29812, -29825, -29835, -29833, -29822, -29805, -28947, -26815, -24588, -22255, -19616, -16898, -14469, -12347, -10487, -8842, -7394, -6126, -5012, -4031, -3169, -2409, -1737, -1147, -623, -162, 245, 607, 927, 1209, 1458, 1677, 1871, 2043, 2195, 2327, 2443, 2545, 2634, 2711, 2796, 2793, 3195, 5431, 7769, 9786, 10057, 9105, 8393, 7751, 7187, 6691, 6254, 5868, 5529, 5231, 4970, 4742, 4542, 4366, 4213, 4079, 3960, 3856, 3767, 3688, 3621, 3564, 3517, 3476, 3443, 3416, 3393, 3377, 3364, 3350, 3359, 3255, 2663, 2025, 1827, 2029, 2184, 2325, 2450, 2561, 2661, 2750, 2829, 2900, 2964, 3022, 3075, 3122, 3164, 3201, 3233, 3262, 3286, 3307, 3326, 3342, 3356, 3368, 3378, 3388, 3395, 3403, 3591, 3723, 3679, 3651, 3626, 3603, 3583, 3566, 3549, 3534, 3518, 3504, 3489, 3476, 3461, 3426, 3371, 3263, 3053, 2783, 2488, 2170, 1840, 1498, 1122, 750, 432, 175, 18, -12};