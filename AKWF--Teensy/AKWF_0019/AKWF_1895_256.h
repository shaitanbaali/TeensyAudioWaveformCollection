/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1895 256 samples */
 
const int16_t AKWF_1895_256_DATA [256] = 
{159, 525, 880, 1271, 1724, 2266, 2905, 3624, 4412, 5249, 6117, 6996, 7865, 8703, 9510, 10304, 11079, 11842, 12591, 13328, 14061, 14793, 15517, 16234, 16941, 17632, 18317, 18989, 19649, 20299, 20934, 21554, 22166, 22761, 23342, 23911, 24460, 24997, 25520, 26026, 26516, 26990, 27443, 27884, 28307, 28711, 29098, 29465, 29815, 30148, 30461, 30755, 31031, 31284, 31522, 31739, 31937, 32114, 32272, 32410, 32526, 32623, 32703, 32747, 32740, 32732, 32723, 32714, 32709, 32670, 32583, 32478, 32351, 32204, 32040, 31853, 31647, 31421, 31176, 30913, 30630, 30326, 30005, 29665, 29306, 28931, 28537, 28123, 27693, 27246, 26782, 26303, 25806, 25292, 24763, 24220, 23663, 23088, 22502, 21898, 21282, 20656, 20016, 19361, 18695, 18016, 17327, 16631, 15919, 15200, 14470, 13735, 12990, 12232, 11468, 10700, 9922, 9143, 8355, 7561, 6762, 5960, 5155, 4348, 3535, 2720, 1906, 1089, 275, -542, -1358, -2178, -2993, -3804, -4614, -5421, -6226, -7029, -7825, -8614, -9402, -10182, -10957, -11725, -12484, -13234, -13980, -14715, -15442, -16161, -16863, -17560, -18246, -18919, -19583, -20233, -20868, -21494, -22105, -22703, -23289, -23854, -24408, -24949, -25473, -25980, -26470, -26946, -27404, -27847, -28272, -28677, -29066, -29437, -29790, -30125, -30439, -30736, -31015, -31273, -31513, -31733, -31930, -32110, -32270, -32411, -32531, -32630, -32711, -32763, -32762, -32753, -32745, -32736, -32731, -32701, -32616, -32512, -32390, -32247, -32082, -31898, -31695, -31471, -31228, -30967, -30686, -30385, -30067, -29730, -29376, -29002, -28608, -28198, -27773, -27328, -26865, -26388, -25892, -25380, -24857, -24314, -23756, -23185, -22596, -22000, -21386, -20759, -20119, -19467, -18802, -18130, -17441, -16743, -16036, -15316, -14589, -13854, -13111, -12366, -11616, -10858, -10091, -9308, -8505, -7687, -6842, -5970, -5089, -4214, -3370, -2580, -1859, -1224, -680, -219};