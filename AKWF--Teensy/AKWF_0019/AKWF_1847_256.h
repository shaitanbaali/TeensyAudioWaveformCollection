/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1847 256 samples */
 
const int16_t AKWF_1847_256_DATA [256] = 
{165, 564, 945, 1320, 1684, 2041, 2388, 2727, 3056, 3377, 3690, 3996, 4301, 4576, 5273, 7681, 11706, 16162, 20306, 23825, 26655, 28820, 30398, 31497, 32204, 32601, 32760, 32737, 32574, 32305, 31958, 31555, 31107, 30629, 30126, 29606, 29078, 28538, 27993, 27446, 26895, 26342, 25792, 25241, 24690, 24143, 23596, 23050, 22510, 21970, 21435, 20903, 20373, 19846, 19325, 18806, 18291, 17780, 17273, 16771, 16274, 15780, 15292, 14809, 14329, 13855, 13386, 12921, 12462, 12008, 11559, 11118, 10681, 10247, 9821, 9399, 8975, 8577, 7780, 5335, 1291, -3196, -7390, -10976, -13890, -16151, -17839, -19057, -19889, -20420, -20719, -20838, -20822, -20705, -20513, -20264, -19973, -19655, -19316, -18959, -18593, -18220, -17839, -17460, -17078, -16694, -16312, -15930, -15550, -15173, -14796, -14423, -14053, -13684, -13319, -12957, -12598, -12240, -11888, -11538, -11193, -10851, -10511, -10176, -9846, -9518, -9195, -8875, -8559, -8248, -7942, -7638, -7339, -7045, -6754, -6468, -6187, -5910, -5638, -5372, -5110, -4857, -5216, -6330, -7222, -7722, -7961, -8017, -7949, -7794, -7582, -7331, -7055, -6762, -6458, -6149, -5838, -5526, -5216, -4906, -4600, -4299, -4002, -3708, -3419, -3136, -2857, -2581, -2313, -2049, -1790, -1537, -1288, -1044, -805, -572, -344, -122, 95, 307, 514, 717, 914, 1107, 1296, 1477, 1655, 1827, 1997, 2160, 2319, 2473, 2622, 2767, 2908, 3043, 3175, 3303, 3426, 3544, 3658, 3768, 3875, 3975, 4066, 4171, 3832, 1791, -1826, -5860, -9595, -12732, -15207, -17046, -18326, -19150, -19603, -19767, -19709, -19484, -19132, -18689, -18181, -17625, -17035, -16425, -15805, -15172, -14540, -13907, -13277, -12653, -12034, -11422, -10818, -10221, -9633, -9055, -8485, -7922, -7372, -6830, -6296, -5774, -5260, -4755, -4260, -3774, -3299, -2833, -2375, -1927, -1490, -1060, -642, -225};