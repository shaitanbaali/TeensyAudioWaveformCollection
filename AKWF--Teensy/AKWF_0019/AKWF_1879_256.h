/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1879 256 samples */
 
const int16_t AKWF_1879_256_DATA [256] = 
{848, 2886, 5298, 7706, 9662, 11373, 13408, 15494, 16847, 17758, 18716, 19724, 20627, 21428, 21968, 22447, 23119, 23548, 23354, 22798, 22042, 20877, 19284, 17266, 14902, 12398, 9682, 6628, 3400, 159, -3229, -6708, -10063, -13237, -16278, -19132, -21739, -24034, -25954, -27592, -29071, -30304, -31176, -31777, -32243, -32586, -32759, -32706, -32388, -31872, -31206, -30311, -29134, -27715, -26107, -24335, -22394, -20191, -17703, -15153, -12684, -10149, -7445, -4748, -2255, 40, 2296, 4566, 6733, 8635, 10344, 12060, 13813, 15454, 16941, 18402, 19850, 21119, 22041, 22669, 23122, 23347, 23201, 22728, 22053, 21256, 20324, 19273, 18164, 17065, 15921, 14691, 13430, 12215, 10996, 9678, 8281, 6885, 5511, 4132, 2737, 1320, -96, -1476, -2803, -4078, -5315, -6475, -7529, -8481, -9401, -10232, -10900, -11427, -11770, -11910, -11947, -11891, -11622, -11115, -10550, -9907, -9034, -7952, -6704, -5295, -3644, -1742, 395, 2766, 5188, 7527, 9822, 12071, 13978, 15467, 16886, 18118, 18956, 19603, 20242, 20739, 21130, 21466, 21572, 21501, 21362, 20912, 20032, 18916, 17571, 15925, 14010, 11792, 9317, 6741, 4011, 1033, -1998, -4979, -7980, -10927, -13744, -16428, -18938, -21216, -23250, -25039, -26572, -27870, -28960, -29818, -30458, -30933, -31232, -31312, -31183, -30839, -30245, -29401, -28288, -26899, -25297, -23506, -21507, -19338, -17061, -14655, -12085, -9494, -6995, -4495, -1960, 463, 2656, 4679, 6575, 8370, 10052, 11485, 12765, 14013, 15251, 16343, 17314, 18320, 19314, 20089, 20507, 20655, 20720, 20649, 20350, 19806, 19150, 18470, 17736, 16875, 15904, 14882, 13837, 12641, 11295, 9808, 8246, 6610, 4954, 3317, 1723, 163, -1348, -2760, -4075, -5316, -6445, -7449, -8290, -8923, -9340, -9692, -10015, -10190, -10063, -9819, -9526, -9231, -8873, -8390, -7737, -7009, -6383, -5669, -4616, -3389, -2139, -803};