/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1837 256 samples */
 
const int16_t AKWF_1837_256_DATA [256] = 
{1422, 1929, 1697, 2273, 6812, 7310, 6896, 8205, 18008, 19028, 18607, 19313, 23836, 24195, 23877, 24823, 30882, 31489, 31295, 31322, 32132, 32274, 32325, 31793, 28028, 27479, 27599, 27476, 25219, 24745, 24736, 25139, 25511, 25239, 25296, 25153, 22599, 22100, 22242, 21968, 19391, 18983, 19092, 18926, 16932, 16536, 16941, 15289, 7542, 6936, 7111, 6967, 5822, 5782, 5184, 8182, 18769, 19031, 18965, 18816, 17102, 16995, 16549, 19009, 26554, 26539, 26511, 26419, 25560, 25403, 25598, 25066, 8415, 3513, 4535, 4329, 2409, 1913, 1988, 2032, 6939, 8549, 8222, 8277, 7724, 7535, 7721, 7265, -8610, -13082, -12100, -12299, -12850, -13027, -12760, -13532, -28342, -32062, -31212, -31408, -32519, -32693, -32677, -32468, -29535, -28868, -28993, -28923, -28615, -28545, -28548, -28458, -27572, -27399, -27438, -27292, -25854, -25608, -25751, -25266, -20414, -19752, -19983, -19522, -15528, -15060, -15195, -14993, -13353, -13273, -13418, -12847, -8300, -7791, -8225, -6794, 3598, 4680, 4252, 4969, 9502, 9844, 9645, 10095, 12931, 13150, 13070, 13080, 13899, 13992, 14328, 12612, 2429, 1246, 1542, 1392, -853, -1247, -1583, 387, 8412, 8702, 8619, 8525, 5983, 5503, 5617, 5545, 3853, 3513, 3616, 3463, 1478, 1158, 1234, 1213, -205, -469, -391, -498, -1633, -1789, -1769, -1696, -1412, -1416, -1377, -1551, -3259, -3454, -3383, -3493, -4071, -4056, -4029, -4133, -4979, -5081, -4950, -5405, -8807, -9091, -9002, -9016, -10925, -11428, -11303, -11325, -12678, -12972, -12889, -12899, -13442, -13561, -13514, -13522, -14584, -14717, -14663, -14670, -15215, -15308, -15292, -15182, -13983, -13496, -13563, -13579, -14689, -14859, -14863, -14595, -10787, -9936, -10106, -10032, -9734, -9686, -9624, -9822, -12763, -13376, -13241, -13138, -11709, -11494, -11545, -11454, -10400, -10455, -10527, -10105, -6116, -5647, -5844, -5358};