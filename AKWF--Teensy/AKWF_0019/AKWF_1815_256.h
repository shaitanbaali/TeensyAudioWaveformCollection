/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1815 256 samples */
 
const int16_t AKWF_1815_256_DATA [256] = 
{295, 837, 1334, 1852, 2392, 2966, 3561, 4179, 4815, 5472, 6154, 6855, 7581, 8339, 9122, 9948, 10805, 11724, 12704, 13752, 14866, 16054, 17275, 18572, 19881, 21200, 22532, 23821, 25047, 26272, 27386, 28424, 29388, 30214, 30959, 31580, 32074, 32449, 32686, 32768, 32720, 32523, 32159, 31652, 30935, 30055, 28990, 27733, 26363, 24820, 23165, 21464, 19757, 18080, 16491, 15005, 13639, 12393, 11244, 10208, 9246, 8345, 7484, 6676, 5903, 5157, 4426, 3723, 3040, 2369, 1742, 1122, 514, -63, -757, -1531, -2273, -2997, -3708, -4411, -5076, -5739, -6385, -7013, -7628, -8210, -8752, -9283, -9757, -10214, -10615, -10964, -11279, -11551, -11764, -11940, -12083, -12183, -12258, -12314, -12333, -12350, -12341, -12322, -12295, -12259, -12218, -12162, -12090, -12006, -11914, -11802, -11664, -11533, -11392, -11232, -11063, -10905, -10744, -10601, -10463, -10336, -10240, -10158, -10088, -10036, -10001, -9967, -9939, -9912, -9864, -9807, -9721, -9612, -9469, -9293, -9099, -8867, -8606, -8323, -8027, -7718, -7413, -7103, -6801, -6519, -6236, -5973, -5726, -5493, -5243, -5011, -4776, -4537, -4272, -3999, -3704, -3372, -3030, -2672, -2297, -1910, -1512, -1116, -751, -394, -63, 218, 411, 561, 681, 771, 814, 833, 817, 772, 700, 597, 477, 342, 170, -63, -339, -617, -907, -1223, -1563, -1903, -2255, -2610, -2984, -3336, -3687, -4029, -4338, -4629, -4887, -5108, -5298, -5435, -5554, -5609, -5559, -5615, -5660, -5698, -5733, -5782, -5840, -5938, -6061, -6220, -6417, -6638, -6888, -7169, -7456, -7754, -8041, -8327, -8576, -8794, -8972, -9101, -9187, -9229, -9213, -9153, -9052, -8910, -8726, -8526, -8305, -8073, -7824, -7566, -7315, -7068, -6808, -6544, -6289, -6027, -5758, -5484, -5185, -4875, -4542, -4185, -3803, -3405, -2972, -2500, -2007, -1484, -926, -318};