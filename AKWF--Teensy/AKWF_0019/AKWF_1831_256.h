/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1831 256 samples */
 
const int16_t AKWF_1831_256_DATA [256] = 
{1007, 2908, 4763, 6609, 8429, 10218, 11972, 13672, 15320, 16907, 18421, 19865, 21236, 22528, 23747, 24891, 25955, 26944, 27852, 28680, 29431, 30102, 30692, 31208, 31646, 32008, 32297, 32516, 32665, 32748, 32768, 32728, 32631, 32482, 32282, 32035, 31748, 31418, 31049, 30643, 30202, 29726, 29221, 28686, 28126, 27545, 26941, 26317, 25680, 25026, 24364, 23697, 23022, 22346, 21671, 20996, 20325, 19658, 18993, 18333, 17679, 17025, 16375, 15724, 15070, 14414, 13753, 13081, 12401, 11708, 10999, 10275, 9531, 8766, 7981, 7171, 6334, 5474, 4587, 3675, 2742, 1783, 800, -200, -1222, -2260, -3309, -4370, -5432, -6491, -7546, -8585, -9603, -10596, -11552, -12466, -13332, -14139, -14899, -15612, -16269, -16871, -17411, -17885, -18292, -18626, -18885, -19067, -19169, -19187, -19124, -18977, -18748, -18436, -18039, -17561, -17000, -16360, -15644, -14855, -13999, -13079, -12101, -11071, -9997, -8881, -7738, -6571, -5386, -4194, -3003, -1818, -650, 496, 1614, 2693, 3730, 4720, 5653, 6530, 7350, 8106, 8804, 9441, 10013, 10521, 10961, 11332, 11636, 11869, 12033, 12129, 12155, 12115, 12009, 11839, 11608, 11317, 10971, 10574, 10127, 9636, 9104, 8534, 7933, 7301, 6642, 5960, 5255, 4530, 3789, 3034, 2268, 1497, 720, -60, -837, -1613, -2380, -3135, -3877, -4603, -5309, -5996, -6661, -7301, -7919, -8514, -9084, -9634, -10162, -10670, -11162, -11637, -12101, -12555, -13000, -13440, -13878, -14314, -14753, -15196, -15644, -16101, -16570, -17049, -17540, -18043, -18555, -19081, -19619, -20167, -20725, -21289, -21857, -22427, -22994, -23551, -24096, -24623, -25124, -25595, -26028, -26415, -26752, -27033, -27266, -27448, -27574, -27639, -27637, -27565, -27417, -27190, -26879, -26483, -25997, -25421, -24752, -23991, -23140, -22195, -21157, -20030, -18809, -17502, -16115, -14645, -13103, -11496, -9824, -8100, -6333, -4527, -2698, -810};