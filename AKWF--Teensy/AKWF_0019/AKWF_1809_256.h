/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1809 256 samples */
 
const int16_t AKWF_1809_256_DATA [256] = 
{2488, 5984, 9184, 11384, 12594, 14983, 18882, 23000, 26324, 27349, 26116, 24500, 22018, 17299, 12466, 11320, 13742, 16454, 19448, 23825, 27813, 29944, 30272, 29069, 27936, 27894, 28197, 28273, 28110, 27584, 26357, 24588, 22717, 20366, 17472, 14884, 12412, 10328, 9613, 9286, 8904, 8960, 9291, 9102, 8490, 8141, 8044, 7949, 7256, 5747, 4452, 3588, 3280, 3272, 2794, 2870, 3052, 2402, 2861, 3610, 4075, 5490, 6229, 6673, 7906, 9169, 10589, 11826, 12949, 13709, 13956, 14592, 15472, 16353, 17047, 17329, 17960, 18669, 19321, 20675, 21862, 22052, 22110, 22225, 22380, 23137, 23765, 23799, 23672, 23133, 23396, 24051, 23641, 23392, 22529, 20965, 19794, 18896, 18658, 17363, 15843, 15909, 15296, 14118, 13170, 12212, 12242, 11594, 9794, 8022, 6894, 6961, 5872, 4311, 4242, 3335, 2535, 1821, -508, -1518, -1311, -2838, -3517, -3933, -7309, -8521, -7280, -6942, -6285, -9244, -11716, -9643, -10361, -11853, -12039, -13074, -11911, -12019, -15556, -16984, -15289, -14259, -15271, -14756, -13001, -14575, -17832, -20042, -20332, -16571, -12663, -13455, -14964, -17798, -21559, -17649, -12123, -12319, -15138, -21407, -22403, -14436, -10052, -9694, -11119, -14357, -15469, -17409, -20026, -16730, -9458, -5830, -8209, -12948, -16125, -15368, -11293, -6913, -3528, -3033, -8085, -14657, -16287, -14933, -12527, -7799, -4669, -4510, -6397, -9792, -9406, -6121, -7629, -13382, -17843, -18319, -14536, -9410, -4794, -293, 699, -4409, -11091, -15007, -18025, -22628, -24861, -22278, -18885, -16568, -16065, -17364, -17172, -13903, -9292, -5648, -6015, -11802, -19188, -22308, -19391, -14595, -13670, -17207, -20189, -19836, -17962, -17302, -18920, -22095, -25852, -29432, -32231, -32381, -28253, -20136, -9792, -3090, -2567, -3575, -6098, -9094, -8153, -6804, -9971, -15767, -19897, -19856, -16607, -12724, -9517, -7354, -6513, -6234, -4523, -1057};