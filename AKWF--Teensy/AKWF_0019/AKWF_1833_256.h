/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1833 256 samples */
 
const int16_t AKWF_1833_256_DATA [256] = 
{1038, 2560, 4056, 5556, 7046, 8523, 9983, 11413, 12815, 14181, 15504, 16787, 18026, 19213, 20352, 21441, 22476, 23463, 24398, 25279, 26110, 26889, 27614, 28287, 28909, 29477, 29994, 30460, 30875, 31241, 31562, 31836, 32068, 32259, 32412, 32534, 32625, 32690, 32733, 32757, 32767, 32767, 32756, 32734, 32701, 32656, 32600, 32534, 32456, 32367, 32267, 32154, 32028, 31887, 31733, 31562, 31373, 31166, 30937, 30686, 30411, 30112, 29789, 29438, 29059, 28651, 28212, 27740, 27235, 26695, 26118, 25507, 24857, 24169, 23446, 22682, 21881, 21045, 20171, 19260, 18317, 17340, 16330, 15296, 14231, 13145, 12042, 10918, 9784, 8645, 7500, 6360, 5229, 4103, 2988, 1882, 783, -299, -1365, -2414, -3436, -4431, -5392, -6312, -7190, -8021, -8795, -9512, -10169, -10759, -11284, -11740, -12126, -12443, -12688, -12859, -12960, -12991, -12957, -12862, -12711, -12508, -12259, -11971, -11652, -11305, -10940, -10565, -10184, -9807, -9433, -9061, -8694, -8332, -7980, -7639, -7311, -6997, -6706, -6437, -6191, -5973, -5783, -5623, -5494, -5395, -5328, -5292, -5287, -5312, -5366, -5448, -5558, -5697, -5870, -6075, -6314, -6588, -6893, -7230, -7597, -7988, -8401, -8834, -9278, -9730, -10185, -10636, -11078, -11507, -11916, -12300, -12657, -12981, -13270, -13522, -13731, -13903, -14035, -14128, -14186, -14209, -14203, -14173, -14128, -14072, -14009, -13943, -13878, -13816, -13759, -13712, -13677, -13653, -13643, -13646, -13664, -13696, -13742, -13803, -13881, -13975, -14085, -14211, -14353, -14510, -14681, -14866, -15064, -15275, -15495, -15725, -15965, -16212, -16464, -16725, -16990, -17257, -17527, -17795, -18061, -18322, -18574, -18816, -19043, -19253, -19440, -19604, -19737, -19836, -19898, -19918, -19889, -19805, -19661, -19452, -19174, -18823, -18396, -17891, -17307, -16641, -15896, -15075, -14176, -13207, -12173, -11073, -9912, -8698, -7425, -6103, -4737, -3332, -1897, -406};