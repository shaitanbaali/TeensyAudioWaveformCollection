/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1828 256 samples */
 
const int16_t AKWF_1828_256_DATA [256] = 
{151, 607, 1024, 1414, 1781, 2124, 2448, 2749, 3029, 3288, 3530, 3757, 3965, 4153, 4328, 4490, 4638, 4775, 4897, 5005, 5105, 5190, 5265, 5336, 5400, 5452, 5497, 5533, 5564, 5585, 5599, 5609, 5616, 5615, 5610, 5600, 5589, 5571, 5550, 5526, 5499, 5469, 5433, 5396, 5360, 5317, 5277, 5232, 5185, 5142, 5093, 5044, 4995, 4943, 4890, 4838, 4784, 4729, 4676, 4621, 4567, 4510, 4454, 4400, 4344, 4289, 4232, 4174, 4120, 4062, 4006, 3950, 3894, 3839, 3785, 3730, 3678, 3622, 3569, 3516, 3464, 3414, 3361, 3312, 3265, 3214, 3169, 3125, 3075, 3032, 2985, 2944, 2912, 2840, 3197, 1205, 8076, 21439, 22938, 22609, 21643, 20528, 19410, 18336, 17310, 16333, 15409, 14531, 13696, 12908, 12158, 11447, 10774, 10135, 9529, 8957, 8413, 7898, 7411, 6948, 6511, 6105, 5861, 4586, 12301, 19906, 14408, 12781, 11885, 11206, 10638, 10116, 9628, 9176, 8745, 8344, 7969, 7615, 7288, 6981, 6690, 6423, 6173, 5945, 5733, 5534, 5355, 5189, 5040, 4906, 4779, 4669, 4572, 4484, 4409, 4342, 4282, 4234, 4192, 4159, 4135, 4113, 4099, 4090, 4080, 4077, 4072, 4069, 4064, 4057, 4047, 4033, 4009, 3976, 3930, 3873, 3795, 3696, 3577, 3429, 3249, 3035, 2779, 2476, 2122, 1711, 1236, 693, 75, -623, -1409, -2291, -3270, -4339, -5516, -6790, -8137, -9596, -11129, -12721, -14392, -16075, -17808, -19544, -21244, -22870, -24457, -25969, -27352, -28584, -29692, -30628, -31370, -31964, -32410, -32680, -32766, -32672, -32441, -32058, -31553, -30925, -30182, -29366, -28471, -27504, -26483, -25416, -24310, -23180, -22034, -20884, -19730, -18585, -17454, -16336, -15237, -14166, -13118, -12099, -11113, -10158, -9235, -8348, -7492, -6673, -5889, -5137, -4421, -3736, -3084, -2467, -1883, -1331, -807, -301};