/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1826 256 samples */
 
const int16_t AKWF_1826_256_DATA [256] = 
{502, 2219, 3694, 5004, 6138, 7117, 7953, 8653, 9234, 9695, 10055, 10335, 10529, 10655, 10723, 10729, 10694, 10617, 10500, 10358, 10193, 10005, 9799, 9581, 9353, 9112, 8867, 8619, 8372, 8114, 7902, 7328, 6276, 5357, 4541, 3814, 3166, 2592, 2067, 1602, 1181, 798, 449, 133, -153, -418, -663, -883, -1090, -1285, -1454, -1616, -1757, -1879, -1993, -2085, -2155, -2197, -2207, -2192, -2123, -2020, -1853, -1613, -1289, -868, -325, 357, 1206, 2247, 3500, 5005, 6779, 8805, 11130, 13721, 16461, 19347, 22279, 25046, 27581, 29749, 31354, 32370, 32757, 32428, 31520, 30097, 28206, 25997, 23573, 20990, 18380, 15781, 13245, 10826, 8528, 6388, 4396, 2550, 853, -708, -2148, -3474, -4702, -5831, -6860, -7804, -8671, -9429, -10091, -10639, -11091, -11413, -11614, -11699, -11652, -11490, -11216, -10835, -10356, -9771, -9092, -8330, -7491, -6569, -5578, -4524, -3422, -2303, -1193, -158, 733, 1397, 1728, 1666, 1141, 124, -1422, -3518, -6041, -8747, -11319, -13470, -15028, -15959, -16311, -16179, -15670, -14885, -13907, -12798, -11589, -10366, -9121, -7896, -6413, -8173, 4316, 10418, -9356, -4693, -4344, -3553, -2756, -1899, -1005, -32, 1035, 2202, 3488, 4924, 6526, 8282, 10152, 12019, 13681, 14886, 15390, 15076, 13996, 12317, 10261, 7963, 5603, 3295, 1169, -674, -2192, -3366, -4199, -4724, -4968, -4982, -4800, -4459, -3997, -3441, -2806, -2122, -1414, -695, 18, 719, 1385, 1998, 2561, 3037, 3429, 3728, 3938, 4038, 4035, 3944, 3771, 3517, 3191, 2805, 2363, 1870, 1327, 723, 57, -690, -1530, -2497, -3616, -4892, -6384, -8110, -10047, -12268, -14703, -17289, -20037, -22791, -25399, -27760, -29738, -31133, -31972, -32149, -31635, -30549, -28935, -26836, -24425, -21784, -18999, -16178, -13381, -10666, -8083, -5653, -3407, -1320};