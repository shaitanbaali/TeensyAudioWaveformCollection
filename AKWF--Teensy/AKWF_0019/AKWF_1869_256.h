/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1869 256 samples */
 
const int16_t AKWF_1869_256_DATA [256] = 
{910, 3355, 5576, 7543, 9250, 10694, 11872, 12778, 13417, 13803, 13960, 13914, 13686, 13299, 12781, 12189, 11581, 10977, 10393, 9843, 9336, 8886, 8502, 8189, 7958, 7816, 7769, 7822, 7982, 8243, 8601, 9050, 9587, 10203, 10894, 11653, 12470, 13341, 14260, 15214, 16200, 17211, 18233, 19267, 20302, 21328, 22343, 23340, 24307, 25245, 26146, 27001, 27812, 28571, 29273, 29918, 30501, 31018, 31473, 31858, 32175, 32425, 32606, 32719, 32766, 32747, 32666, 32522, 32321, 32063, 31752, 31393, 30988, 30542, 30059, 29543, 28997, 28428, 27838, 27233, 26618, 25996, 25373, 24752, 24136, 23531, 22941, 22367, 21815, 21287, 20786, 20315, 19877, 19472, 19103, 18772, 18480, 18227, 18015, 17842, 17711, 17620, 17569, 17556, 17574, 17613, 17664, 17718, 17769, 17807, 17825, 17814, 17768, 17676, 17530, 17314, 16980, 16482, 15813, 14960, 13919, 12687, 11247, 9612, 7797, 5813, 3685, 1433, -938, -3342, -5571, -7545, -9254, -10700, -11880, -12787, -13429, -13816, -13974, -13929, -13703, -13318, -12799, -12209, -11602, -10998, -10414, -9864, -9357, -8907, -8522, -8209, -7978, -7835, -7787, -7840, -7998, -8258, -8615, -9063, -9599, -10213, -10903, -11661, -12476, -13346, -14263, -15216, -16201, -17211, -18232, -19264, -20299, -21323, -22337, -23332, -24298, -25236, -26135, -26990, -27801, -28559, -29261, -29905, -30488, -31005, -31460, -31845, -32162, -32412, -32594, -32707, -32755, -32737, -32655, -32513, -32311, -32054, -31745, -31387, -30982, -30537, -30055, -29539, -28993, -28426, -27837, -27233, -26620, -25998, -25374, -24754, -24139, -23534, -22945, -22371, -21820, -21293, -20792, -20322, -19884, -19479, -19111, -18780, -18487, -18235, -18022, -17849, -17718, -17627, -17576, -17562, -17580, -17619, -17669, -17724, -17773, -17810, -17828, -17817, -17770, -17678, -17532, -17315, -16980, -16483, -15812, -14959, -13918, -12685, -11245, -9609, -7794, -5814, -3693, -1394};