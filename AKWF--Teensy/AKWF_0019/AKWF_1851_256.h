/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1851 256 samples */
 
const int16_t AKWF_1851_256_DATA [256] = 
{1301, 3235, 4570, 5540, 6238, 6743, 7107, 7369, 7557, 7693, 7790, 7859, 7909, 7945, 7969, 7988, 8002, 8010, 8016, 8019, 8021, 8023, 8023, 8023, 8022, 8020, 8020, 8019, 8017, 8015, 8014, 8011, 8010, 8008, 8007, 8004, 8002, 8001, 7998, 7995, 7994, 7991, 7989, 7987, 7985, 7983, 7981, 7979, 7977, 7975, 7973, 7971, 7969, 7967, 7965, 7962, 7961, 7958, 7955, 7954, 7951, 7949, 7948, 7945, 7943, 7941, 7939, 7937, 7935, 7933, 7931, 7929, 7926, 7925, 7923, 7920, 7919, 7916, 7913, 7911, 7909, 7907, 7905, 7903, 7900, 7899, 7896, 7894, 7892, 7890, 7888, 7887, 7884, 7882, 7880, 7878, 7876, 7873, 7871, 7869, 7867, 7864, 7863, 7861, 7858, 7910, 7710, 8714, 16018, 22504, 23742, 23526, 23557, 23541, 23529, 23518, 23509, 23502, 23494, 23489, 23484, 23476, 23472, 23443, 23410, 23610, 15621, 4120, -3521, -9131, -13176, -16098, -18197, -19709, -20802, -21583, -22148, -22555, -22847, -23075, -23176, -23505, -26860, -30579, -32489, -27558, -21756, -17955, -15134, -13104, -11642, -10585, -9823, -9275, -8879, -8592, -8385, -8234, -8127, -8047, -7987, -7946, -7914, -7891, -7873, -7859, -7849, -7842, -7835, -7830, -7825, -7820, -7818, -7815, -7812, -7810, -7806, -7804, -7802, -7799, -7797, -7794, -7792, -7790, -7788, -7785, -7783, -7781, -7779, -7777, -7775, -7773, -7771, -7769, -7766, -7765, -7762, -7760, -7758, -7756, -7753, -7751, -7749, -7747, -7745, -7742, -7741, -7739, -7737, -7735, -7733, -7730, -7728, -7727, -7724, -7722, -7721, -7718, -7716, -7714, -7712, -7709, -7708, -7705, -7703, -7702, -7699, -7697, -7696, -7693, -7691, -7690, -7687, -7685, -7684, -7681, -7679, -7677, -7675, -7673, -7671, -7668, -7666, -7664, -7662, -7660, -7658, -7656, -7654, -7652, -7650, -7641, -7630, -7701, -5040, -1174};