/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1868 256 samples */
 
const int16_t AKWF_1868_256_DATA [256] = 
{74, 331, 567, 878, 1201, 1488, 1749, 1976, 2236, 2565, 2863, 3131, 3371, 3672, 4010, 4308, 4578, 4817, 5061, 5385, 5695, 5971, 6216, 6456, 6776, 7093, 7374, 7627, 7862, 8174, 8498, 8783, 9040, 9273, 9577, 9905, 10193, 10454, 10687, 10979, 11310, 11603, 11866, 12104, 12316, 12592, 12906, 13182, 13429, 13666, 13983, 14299, 14580, 14831, 15064, 15373, 15694, 15977, 16233, 16463, 16761, 17087, 17373, 17633, 17860, 18099, 18419, 18717, 18982, 19219, 19454, 19769, 20075, 20346, 20588, 20819, 21130, 21442, 21717, 21965, 22192, 22489, 22807, 23086, 23340, 23562, 23805, 24122, 24413, 24673, 24902, 25139, 25456, 25755, 26021, 26256, 26488, 26801, 27106, 27377, 27617, 27844, 28151, 28461, 28735, 28981, 29204, 29500, 29817, 30093, 30344, 30562, 30798, 31112, 31400, 31657, 31884, 32106, 32377, 32864, 29531, 22847, 17078, 11914, 7327, 3170, -570, -3951, -6942, -9549, -11905, -14034, -15950, -17671, -19121, -20388, -21540, -22577, -23507, -24249, -24869, -25431, -25938, -26394, -26718, -26946, -27157, -27343, -27516, -27593, -27586, -27584, -27578, -27578, -27517, -27372, -27239, -27117, -27007, -26898, -26697, -26474, -26277, -26098, -25933, -25688, -25413, -25170, -24948, -24749, -24484, -24176, -23904, -23656, -23435, -23162, -22837, -22546, -22280, -22043, -21811, -21497, -21183, -20903, -20649, -20413, -20098, -19770, -19480, -19215, -18976, -18671, -18333, -18035, -17763, -17521, -17267, -16934, -16620, -16339, -16087, -15835, -15503, -15181, -14892, -14633, -14386, -14057, -13727, -13434, -13169, -12924, -12603, -12267, -11971, -11700, -11457, -11146, -10806, -10505, -10233, -9988, -9688, -9345, -9041, -8764, -8518, -8275, -7952, -7634, -7351, -7093, -6865, -6589, -6259, -5964, -5698, -5453, -5135, -4799, -4503, -4233, -3992, -3685, -3345, -3046, -2774, -2534, -2239, -1899, -1596, -1322, -1078, -839, -518, -198};