/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1861 256 samples */
 
const int16_t AKWF_1861_256_DATA [256] = 
{601, 1930, 3272, 4645, 6032, 7409, 8735, 9970, 11130, 12237, 13299, 14319, 15261, 16111, 16914, 17692, 18435, 19146, 19835, 20508, 21173, 21843, 22537, 23269, 24046, 24855, 25679, 26507, 27334, 28129, 28852, 29499, 30061, 30493, 30773, 30917, 30959, 30945, 30895, 30794, 30628, 30402, 30117, 29773, 29374, 28940, 28458, 27910, 27307, 26670, 26029, 25406, 24813, 24256, 23725, 23206, 22695, 22190, 21700, 21225, 20737, 20222, 19710, 19225, 18774, 18352, 17940, 17547, 17213, 16957, 16758, 16607, 16490, 16396, 16303, 16189, 16031, 15808, 15507, 15109, 14606, 14025, 13400, 12735, 12018, 11249, 10433, 9581, 8716, 7856, 7018, 6236, 5531, 4915, 4399, 3991, 3699, 3527, 3461, 3480, 3569, 3717, 3906, 4114, 4296, 4418, 4490, 4540, 4599, 4685, 4797, 4935, 5090, 5255, 5417, 5570, 5718, 5855, 5965, 6020, 5989, 5864, 5654, 5367, 5005, 4571, 4073, 3518, 2913, 2273, 1609, 937, 270, -388, -1032, -1639, -2203, -2735, -3249, -3746, -4230, -4719, -5208, -5663, -6054, -6358, -6619, -6928, -7302, -7684, -8042, -8376, -8735, -9189, -9772, -10477, -11292, -12205, -13186, -14206, -15246, -16275, -17245, -18110, -18842, -19415, -19785, -19929, -19838, -19500, -18881, -17976, -16832, -15524, -14147, -12769, -11435, -10211, -9182, -8387, -7832, -7517, -7432, -7556, -7863, -8312, -8873, -9535, -10297, -11159, -12117, -13163, -14289, -15470, -16681, -17889, -19053, -20141, -21142, -22072, -22945, -23766, -24541, -25283, -25991, -26653, -27284, -27903, -28522, -29148, -29770, -30379, -30982, -31567, -32078, -32466, -32697, -32770, -32725, -32592, -32376, -32075, -31688, -31198, -30576, -29827, -28990, -28067, -27048, -25934, -24746, -23532, -22341, -21190, -20087, -19036, -18050, -17148, -16324, -15542, -14770, -13993, -13204, -12384, -11527, -10656, -9781, -8889, -7974, -7034, -6064, -5071, -4046, -2977, -1850, -627};