/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1818 256 samples */
 
const int16_t AKWF_1818_256_DATA [256] = 
{30244, 30282, 30312, 30347, 30371, 30393, 30415, 30427, 30442, 30460, 30471, 30480, 30490, 30499, 30508, 30509, 30512, 30514, 30541, 30446, 28061, 27711, 27756, 27709, 27678, 27654, 27632, 27602, 27580, 27569, 27556, 27533, 27522, 27509, 27497, 27299, 28248, 24575, -9653, -11734, -11133, -11262, -11259, -11255, -11250, -11246, -11239, -11233, -11227, -11219, -11211, -11204, -11196, -11188, -11179, -11170, -11160, -11151, -11141, -11133, -11121, -11112, -11103, -11092, -11080, -11071, -11062, -11050, -11038, -11027, -11018, -11008, -10998, -10986, -10974, -10962, -10950, -10941, -10930, -10920, -10910, -10898, -10886, -10875, -10863, -10852, -10841, -10831, -10820, -10810, -10798, -10787, -10775, -10764, -10753, -10741, -10729, -10718, -10709, -10697, -10686, -10677, -10665, -10653, -10641, -10630, -10618, -10606, -10596, -10586, -10574, -10565, -10554, -10542, -10530, -10519, -10508, -10496, -10486, -10475, -10464, -10454, -10442, -10431, -10420, -10408, -10397, -10388, -10376, -10364, -9836, -12736, 21123, 35088, 32113, 32676, 32692, 32708, 32724, 32731, 32739, 32749, 32753, 32757, 32760, 32763, 32628, 33357, 28864, 24662, 25350, 25182, 25156, 25134, 25112, 25084, 25066, 25046, 25033, 25024, 25004, 24668, 26464, 18664, -12159, -11204, -11311, -11336, -11333, -11328, -11324, -11318, -11312, -11306, -11298, -11291, -11284, -11276, -11268, -11260, -11249, -11241, -11232, -11223, -11212, -11202, -11193, -11183, -11172, -11162, -11153, -11141, -11129, -11119, -11110, -11100, -11088, -11077, -11065, -11054, -11045, -11033, -11023, -11012, -11000, -10989, -10977, -10965, -10955, -10945, -10934, -10925, -10913, -10901, -10889, -10878, -10866, -10855, -10843, -10833, -10822, -10811, -10800, -10790, -10778, -10767, -10756, -10744, -10732, -10721, -10712, -10700, -10688, -10679, -10668, -10656, -10645, -10633, -10621, -10609, -10600, -10589, -10577, -10567, -10557, -10545, -10533, -10522, -10511, -10499, -10488, -10478, -10469, -10457, -10446, -10434};