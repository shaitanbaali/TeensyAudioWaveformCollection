/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0024 256 samples */
 
const int16_t AKWF_altosax_0024_256_DATA [256] = 
{965, 2343, 3671, 5018, 6409, 7844, 9294, 10776, 12303, 13852, 15437, 17069, 18698, 20281, 21804, 23254, 24614, 25896, 27078, 28173, 29171, 30052, 30806, 31425, 31941, 32368, 32647, 32761, 32743, 32602, 32325, 31913, 31367, 30708, 29949, 29103, 28157, 27119, 26028, 24891, 23695, 22439, 21128, 19868, 18671, 17462, 16247, 15055, 13891, 12781, 11751, 10824, 9950, 9088, 8267, 7518, 6868, 6272, 5636, 4958, 4286, 3657, 3036, 2356, 1636, 898, 129, -679, -1517, -2384, -3331, -4365, -5427, -6507, -7656, -8853, -10065, -11303, -12535, -13759, -14979, -16170, -17337, -18481, -19598, -20658, -21656, -22605, -23504, -24316, -25024, -25635, -26156, -26570, -26848, -27005, -27052, -26982, -26786, -26454, -25986, -25371, -24641, -23807, -22828, -21716, -20497, -19182, -17772, -16278, -14726, -13152, -11524, -9813, -8060, -6306, -4537, -2786, -1032, 741, 2459, 4105, 5716, 7274, 8774, 10188, 11495, 12698, 13789, 14766, 15653, 16406, 17000, 17462, 17858, 18148, 18292, 18312, 18249, 18114, 17887, 17547, 17093, 16544, 15945, 15285, 14507, 13642, 12741, 11786, 10797, 9788, 8739, 7649, 6577, 5545, 4525, 3498, 2488, 1527, 635, -166, -904, -1633, -2323, -2903, -3355, -3748, -4125, -4453, -4702, -4876, -4987, -5058, -5100, -5126, -5126, -5090, -5051, -5010, -4977, -4961, -4948, -4947, -4981, -5067, -5184, -5323, -5491, -5692, -5929, -6181, -6454, -6771, -7120, -7478, -7847, -8230, -8636, -9057, -9479, -9888, -10288, -10703, -11118, -11508, -11878, -12236, -12577, -12895, -13192, -13459, -13701, -13919, -14097, -14235, -14337, -14413, -14449, -14439, -14378, -14292, -14202, -14078, -13914, -13733, -13543, -13350, -13126, -12885, -12657, -12441, -12210, -11972, -11756, -11558, -11365, -11180, -10997, -10806, -10619, -10448, -10262, -10036, -9776, -9472, -9084, -8595, -7968, -7181, -6288, -5306, -4217, -3024, -1752, -380};