/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0019 256 samples */
 
const int16_t AKWF_altosax_0019_256_DATA [256] = 
{463, 1539, 2616, 3694, 4860, 6193, 7695, 9330, 10957, 12493, 13981, 15427, 16770, 17912, 18602, 18940, 19346, 19887, 20513, 21057, 21198, 21203, 21541, 22037, 22416, 22771, 23199, 23677, 24195, 24842, 25662, 26630, 27686, 28673, 29498, 30283, 31003, 31407, 31455, 31400, 31191, 30491, 29443, 28464, 27687, 27237, 26919, 26388, 25705, 25016, 24282, 23477, 22693, 22010, 21217, 20165, 19145, 18342, 17752, 17360, 17099, 16898, 16637, 16278, 15879, 15473, 15178, 14900, 14333, 13633, 13217, 13036, 12922, 12783, 12480, 12286, 12521, 12928, 13231, 13472, 13663, 13744, 13670, 13387, 12863, 12131, 11220, 10053, 8722, 7596, 6702, 5764, 4727, 3606, 2476, 1462, 594, -141, -673, -900, -874, -679, -309, 227, 925, 1759, 2579, 3277, 3927, 4533, 5038, 5371, 5306, 4879, 4526, 4422, 4548, 4860, 5194, 5504, 5792, 6021, 6128, 6176, 6272, 6315, 6177, 5768, 5007, 4103, 3240, 2357, 1417, 447, -531, -1489, -2416, -3276, -4045, -4705, -5252, -5759, -6205, -6445, -6553, -6776, -7101, -7391, -7712, -8207, -8644, -8753, -8548, -8067, -7937, -8715, -9593, -9952, -10052, -10114, -10662, -11926, -13492, -15124, -16773, -18355, -19777, -20987, -22058, -22882, -23222, -23091, -22649, -21829, -20471, -18697, -16726, -14371, -11468, -8335, -5349, -2862, -1152, 40, 881, 996, 252, -981, -2484, -4179, -5983, -7808, -9577, -11133, -12512, -13926, -15426, -17004, -18648, -20313, -21931, -23444, -24746, -25768, -26441, -26728, -26889, -27156, -27458, -27743, -28077, -28477, -28796, -29003, -29307, -29778, -30342, -30943, -31460, -31878, -32371, -32751, -32582, -31864, -30752, -29516, -28532, -27708, -26824, -25866, -24832, -23540, -21866, -20164, -18728, -17224, -15492, -13730, -12079, -10801, -9987, -9316, -8697, -8225, -7900, -7780, -7718, -7356, -6708, -6004, -5198, -4187, -3134, -2261, -1457, -511};