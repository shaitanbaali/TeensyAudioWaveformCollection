/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0003 256 samples */
 
const int16_t AKWF_altosax_0003_256_DATA [256] = 
{741, 1812, 2868, 3999, 5199, 6423, 7635, 8816, 9970, 11101, 12201, 13292, 14387, 15459, 16505, 17517, 18484, 19399, 20262, 21110, 21991, 22878, 23732, 24541, 25295, 26001, 26661, 27273, 27858, 28415, 28914, 29348, 29721, 30050, 30345, 30609, 30862, 31110, 31327, 31481, 31580, 31656, 31736, 31819, 31899, 31972, 32039, 32092, 32124, 32154, 32205, 32273, 32345, 32403, 32455, 32511, 32578, 32647, 32708, 32757, 32764, 32712, 32591, 32427, 32243, 32034, 31805, 31550, 31262, 30923, 30527, 30068, 29533, 28928, 28256, 27530, 26750, 25894, 24948, 23936, 22900, 21851, 20778, 19663, 18516, 17352, 16208, 15078, 13938, 12789, 11646, 10531, 9469, 8483, 7613, 6866, 6220, 5669, 5207, 4832, 4546, 4335, 4184, 4083, 4045, 4095, 4223, 4389, 4558, 4706, 4788, 4769, 4645, 4436, 4136, 3727, 3204, 2561, 1793, 887, -120, -1129, -2076, -3000, -3992, -5078, -6184, -7237, -8238, -9195, -10121, -11028, -11918, -12796, -13685, -14602, -15561, -16513, -17385, -18179, -18925, -19642, -20340, -21017, -21673, -22323, -22968, -23611, -24234, -24800, -25314, -25810, -26324, -26849, -27346, -27794, -28213, -28647, -29105, -29570, -30038, -30498, -30905, -31227, -31466, -31651, -31801, -31918, -32004, -32059, -32088, -32101, -32091, -32022, -31867, -31621, -31293, -30878, -30397, -29891, -29366, -28832, -28279, -27707, -27096, -26422, -25693, -24973, -24286, -23641, -23051, -22520, -22041, -21607, -21207, -20808, -20379, -19917, -19455, -18999, -18553, -18124, -17712, -17318, -16945, -16591, -16224, -15815, -15378, -14967, -14625, -14340, -14090, -13871, -13639, -13326, -12922, -12492, -12105, -11763, -11453, -11179, -10928, -10658, -10349, -10042, -9797, -9630, -9498, -9364, -9228, -9103, -8983, -8877, -8812, -8793, -8780, -8712, -8570, -8390, -8201, -7999, -7780, -7546, -7281, -6948, -6532, -6056, -5557, -5043, -4481, -3849, -3140, -2322, -1372, -308};