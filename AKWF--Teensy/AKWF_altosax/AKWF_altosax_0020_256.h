/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0020 256 samples */
 
const int16_t AKWF_altosax_0020_256_DATA [256] = 
{1672, 4033, 6221, 8397, 10560, 12646, 14650, 16619, 18554, 20379, 22085, 23647, 25069, 26407, 27677, 28815, 29796, 30648, 31374, 31949, 32366, 32631, 32754, 32758, 32668, 32501, 32281, 31983, 31588, 31124, 30625, 30108, 29598, 29121, 28698, 28335, 28020, 27752, 27532, 27331, 27103, 26848, 26581, 26295, 25999, 25648, 25137, 24475, 23765, 23016, 22176, 21245, 20261, 19233, 18195, 17161, 16131, 15128, 14187, 13333, 12568, 11891, 11327, 10890, 10586, 10425, 10387, 10457, 10617, 10854, 11205, 11695, 12238, 12743, 13215, 13658, 14094, 14555, 15003, 15378, 15671, 15883, 16016, 16079, 16076, 16002, 15876, 15730, 15586, 15480, 15398, 15280, 15105, 14862, 14559, 14249, 13944, 13630, 13297, 12926, 12513, 12095, 11672, 11206, 10668, 10051, 9362, 8613, 7831, 7008, 6139, 5266, 4424, 3613, 2851, 2110, 1355, 571, -268, -1163, -2097, -3030, -3914, -4725, -5456, -6132, -6814, -7479, -8084, -8625, -9121, -9595, -10080, -10591, -11123, -11668, -12216, -12760, -13286, -13799, -14296, -14782, -15293, -15838, -16402, -16983, -17536, -18041, -18509, -18941, -19352, -19750, -20089, -20337, -20541, -20737, -20871, -20892, -20784, -20536, -20215, -19905, -19579, -19198, -18775, -18322, -17887, -17535, -17238, -16937, -16582, -16091, -15490, -14876, -14297, -13819, -13439, -13075, -12708, -12326, -11927, -11560, -11229, -10904, -10581, -10251, -9917, -9615, -9360, -9149, -8986, -8872, -8810, -8827, -8940, -9113, -9315, -9567, -9875, -10228, -10612, -11032, -11492, -11992, -12529, -13104, -13714, -14353, -15010, -15675, -16343, -17001, -17637, -18261, -18904, -19553, -20163, -20729, -21291, -21843, -22333, -22775, -23223, -23684, -24133, -24556, -24953, -25311, -25594, -25789, -25896, -25924, -25895, -25822, -25706, -25542, -25296, -24943, -24502, -23984, -23381, -22685, -21866, -20903, -19790, -18532, -17166, -15719, -14200, -12637, -10980, -9169, -7235, -5213, -3084, -698};