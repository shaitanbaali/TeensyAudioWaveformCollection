/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0004 256 samples */
 
const int16_t AKWF_altosax_0004_256_DATA [256] = 
{425, 1076, 1608, 2072, 2558, 3132, 3780, 4461, 5167, 5890, 6593, 7257, 7902, 8563, 9265, 9989, 10706, 11407, 12104, 12802, 13504, 14229, 15016, 15886, 16777, 17588, 18298, 18949, 19593, 20250, 20957, 21779, 22723, 23709, 24644, 25520, 26335, 27101, 27815, 28489, 29148, 29789, 30413, 31027, 31618, 32114, 32460, 32658, 32752, 32765, 32748, 32698, 32639, 32590, 32568, 32592, 32644, 32666, 32617, 32515, 32400, 32290, 32186, 32089, 32002, 31915, 31803, 31654, 31478, 31296, 31116, 30942, 30776, 30622, 30480, 30346, 30215, 30079, 29919, 29727, 29500, 29236, 28934, 28590, 28196, 27752, 27277, 26796, 26307, 25776, 25180, 24509, 23732, 22828, 21792, 20637, 19384, 18049, 16668, 15281, 13888, 12525, 11213, 9950, 8674, 7345, 5980, 4609, 3258, 1957, 778, -246, -1108, -1824, -2391, -2829, -3205, -3549, -3824, -3948, -3892, -3704, -3442, -3148, -2853, -2593, -2393, -2314, -2442, -2806, -3343, -3957, -4630, -5383, -6226, -7148, -8192, -9420, -10822, -12256, -13570, -14734, -15801, -16828, -17803, -18747, -19681, -20594, -21452, -22216, -22890, -23544, -24223, -24908, -25564, -26160, -26686, -27116, -27431, -27648, -27823, -27987, -28146, -28308, -28479, -28652, -28796, -28897, -28951, -28947, -28887, -28779, -28647, -28495, -28359, -28298, -28338, -28424, -28470, -28452, -28387, -28292, -28170, -28057, -28014, -28049, -28121, -28183, -28222, -28203, -28087, -27871, -27579, -27234, -26843, -26486, -26240, -26086, -25888, -25525, -24999, -24372, -23682, -22944, -22259, -21715, -21285, -20878, -20434, -19955, -19443, -18890, -18325, -17846, -17502, -17269, -17085, -16912, -16741, -16551, -16332, -16054, -15667, -15154, -14560, -13990, -13471, -13014, -12650, -12377, -12140, -11846, -11465, -11000, -10445, -9790, -9102, -8469, -7903, -7373, -6835, -6290, -5745, -5201, -4658, -4173, -3791, -3506, -3245, -2947, -2600, -2216, -1803, -1353, -841, -222};