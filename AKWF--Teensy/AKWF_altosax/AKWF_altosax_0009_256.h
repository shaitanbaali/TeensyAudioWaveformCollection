/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0009 256 samples */
 
const int16_t AKWF_altosax_0009_256_DATA [256] = 
{823, 2233, 3488, 4623, 5854, 7410, 9084, 10843, 12708, 14540, 16247, 17843, 19380, 20819, 22141, 23373, 24441, 25345, 25929, 26268, 26434, 26482, 26782, 27658, 28919, 30026, 30761, 31244, 31767, 32370, 32725, 32751, 32578, 32260, 31690, 30955, 30312, 29723, 29188, 28692, 28347, 28006, 27398, 26781, 26221, 25606, 24891, 23956, 22719, 21099, 19292, 17740, 16337, 15029, 13673, 12211, 10589, 8963, 7253, 5781, 4542, 3204, 1576, -381, -2378, -3844, -4772, -5541, -6520, -7712, -8909, -10046, -11115, -11995, -12650, -13115, -13718, -14409, -15010, -15437, -15825, -16388, -17137, -17871, -18351, -18529, -18594, -18848, -19386, -19820, -20038, -20089, -19846, -19473, -19225, -19020, -18738, -18377, -17991, -17571, -16994, -16274, -15474, -14674, -13775, -12647, -11493, -10436, -9361, -8345, -7477, -6824, -6212, -5557, -4830, -4142, -3476, -2727, -1951, -1117, -397, 296, 1076, 1844, 2575, 3158, 3421, 3618, 3843, 4216, 4508, 4604, 4677, 4890, 5166, 5293, 5220, 5150, 5107, 4991, 4718, 4241, 3667, 3134, 2496, 1778, 1238, 919, 576, 97, -437, -929, -1406, -2081, -2905, -3734, -4371, -4902, -5467, -5975, -6515, -7163, -7793, -8207, -8376, -8395, -8439, -8713, -9255, -9743, -9884, -9949, -10098, -10211, -10268, -10242, -10379, -10693, -10806, -10532, -10122, -9751, -9404, -9131, -9007, -8958, -8757, -8345, -7791, -7360, -7167, -7018, -6768, -6479, -6171, -5924, -5687, -5384, -5074, -4848, -4664, -4494, -4285, -4128, -4104, -4023, -3881, -3808, -3787, -3956, -4074, -4145, -4180, -4131, -4180, -4227, -4255, -4289, -4418, -4697, -5064, -5408, -5764, -6079, -6307, -6503, -6782, -7086, -7333, -7576, -7783, -7936, -7942, -7917, -8009, -8200, -8344, -8409, -8409, -8283, -8167, -8208, -8232, -8085, -7786, -7344, -6832, -6400, -6010, -5522, -4946, -4359, -3654, -2756, -1744, -575};