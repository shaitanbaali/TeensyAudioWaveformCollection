/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0002 256 samples */
 
const int16_t AKWF_altosax_0002_256_DATA [256] = 
{293, 769, 1257, 1788, 2365, 2992, 3661, 4332, 4988, 5638, 6298, 6961, 7612, 8244, 8854, 9446, 10018, 10576, 11122, 11660, 12215, 12797, 13383, 13959, 14520, 15063, 15595, 16115, 16628, 17136, 17625, 18089, 18543, 19006, 19485, 19975, 20463, 20955, 21463, 21991, 22513, 22998, 23447, 23885, 24325, 24780, 25265, 25792, 26340, 26898, 27459, 28003, 28521, 29028, 29525, 30014, 30489, 30949, 31378, 31746, 32043, 32283, 32476, 32620, 32719, 32765, 32763, 32720, 32611, 32425, 32149, 31784, 31333, 30798, 30167, 29425, 28596, 27726, 26827, 25901, 24942, 23953, 22951, 21947, 20948, 19974, 19022, 18087, 17168, 16270, 15397, 14555, 13747, 12980, 12270, 11638, 11085, 10598, 10147, 9727, 9361, 9045, 8753, 8456, 8131, 7767, 7351, 6868, 6311, 5684, 4981, 4210, 3386, 2537, 1690, 851, 19, -793, -1591, -2370, -3122, -3835, -4508, -5167, -5834, -6512, -7201, -7900, -8601, -9306, -10001, -10652, -11233, -11772, -12319, -12878, -13418, -13920, -14388, -14831, -15260, -15680, -16105, -16537, -16998, -17495, -18015, -18537, -19054, -19547, -20009, -20439, -20836, -21202, -21554, -21911, -22266, -22595, -22890, -23166, -23437, -23710, -23968, -24208, -24425, -24614, -24776, -24921, -25059, -25190, -25318, -25442, -25538, -25569, -25544, -25499, -25456, -25413, -25374, -25336, -25266, -25139, -24967, -24766, -24542, -24298, -24039, -23764, -23461, -23129, -22759, -22332, -21855, -21384, -20944, -20517, -20072, -19602, -19098, -18553, -17982, -17415, -16867, -16346, -15854, -15391, -14916, -14413, -13906, -13425, -12976, -12571, -12213, -11903, -11634, -11397, -11179, -10960, -10741, -10537, -10358, -10193, -10041, -9901, -9753, -9591, -9423, -9271, -9145, -9058, -9032, -9043, -9030, -8965, -8853, -8699, -8504, -8279, -8032, -7756, -7434, -7063, -6681, -6308, -5938, -5551, -5141, -4702, -4240, -3748, -3208, -2615, -1996, -1372, -765, -190};