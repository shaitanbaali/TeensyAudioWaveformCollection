/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0018 256 samples */
 
const int16_t AKWF_altosax_0018_256_DATA [256] = 
{5148, 12737, 20447, 27145, 30900, 32577, 32224, 31259, 28814, 27429, 27089, 26577, 25547, 23229, 19759, 16718, 13794, 10474, 7236, 4493, 869, -1210, -783, 1840, 4922, 7999, 10715, 11972, 11162, 8818, 5604, 2452, -275, -4292, -9534, -15147, -19303, -21735, -22879, -18825, -9666, -4239, -5523, -9209, -12157, -14897, -16507, -16726, -18023, -19397, -19971, -22614, -24422, -23200, -23177, -21976, -20352, -18242, -16555, -16402, -16318, -13991, -9006, -2725, 5707, 13163, 20795, 27034, 29942, 31050, 31175, 30569, 29379, 28921, 28816, 27743, 26053, 22959, 18863, 16030, 13352, 10558, 8605, 5212, 734, -1208, -746, 2218, 5358, 8360, 10906, 12154, 11098, 8075, 4387, 1695, -411, -4029, -8962, -14910, -20150, -22645, -22255, -16872, -7539, -2986, -5899, -10598, -13236, -15754, -16931, -16745, -17984, -19596, -20660, -23536, -25453, -23740, -22398, -21517, -20068, -18738, -17926, -17489, -16155, -13466, -8162, -1677, 5978, 13165, 20271, 26414, 29831, 31038, 30604, 29570, 28162, 28017, 28764, 28950, 27929, 25291, 21039, 16620, 12763, 9403, 5823, 3962, 547, -1512, -432, 2285, 5429, 9140, 11740, 12739, 11784, 8457, 4481, 1746, -825, -4408, -9626, -15620, -19670, -21544, -21945, -17442, -8229, -2657, -4851, -9657, -12762, -15880, -17387, -17368, -18150, -19321, -20036, -22717, -25024, -23836, -22512, -21484, -20212, -18401, -17611, -17373, -16288, -14337, -9613, -3058, 5418, 13143, 20719, 26779, 30132, 31048, 31033, 30148, 28280, 27999, 28152, 27473, 27016, 24779, 20731, 16774, 13321, 9815, 7100, 4367, 536, -1480, -1096, 1525, 4809, 8157, 10994, 12757, 11779, 9075, 5353, 2264, -210, -3703, -8987, -15149, -20315, -22874, -22911, -17923, -8565, -2988, -5115, -9913, -12628, -15149, -16648, -16713, -17997, -19537, -20248, -23095, -24864, -23036, -22020, -21229, -20194, -19183, -17517, -17009, -16333, -14113, -9611, -3330};