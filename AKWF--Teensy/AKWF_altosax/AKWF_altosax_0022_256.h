/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0022 256 samples */
 
const int16_t AKWF_altosax_0022_256_DATA [256] = 
{666, 1896, 3134, 4375, 5583, 6802, 8062, 9382, 10809, 12342, 13952, 15624, 17329, 19037, 20743, 22412, 24037, 25572, 26980, 28242, 29345, 30288, 31080, 31719, 32212, 32563, 32751, 32758, 32589, 32238, 31721, 31022, 30150, 29179, 28170, 27149, 26140, 25168, 24289, 23534, 22912, 22429, 22072, 21821, 21654, 21509, 21378, 21323, 21383, 21526, 21713, 21978, 22392, 22960, 23659, 24456, 25263, 25985, 26576, 27007, 27240, 27243, 27012, 26588, 26004, 25311, 24587, 23839, 23012, 22110, 21234, 20468, 19756, 19024, 18312, 17719, 17269, 16915, 16626, 16359, 16056, 15751, 15529, 15397, 15304, 15222, 15118, 14951, 14709, 14384, 13961, 13389, 12664, 11859, 11031, 10177, 9272, 8309, 7264, 6128, 4946, 3754, 2524, 1251, -34, -1263, -2406, -3490, -4537, -5530, -6476, -7380, -8223, -9028, -9843, -10678, -11445, -12056, -12522, -12878, -13121, -13257, -13299, -13272, -13199, -13098, -12999, -12913, -12835, -12774, -12761, -12813, -12909, -13022, -13147, -13268, -13381, -13495, -13616, -13753, -13912, -14107, -14362, -14676, -15017, -15374, -15745, -16130, -16504, -16828, -17105, -17372, -17636, -17875, -18075, -18247, -18404, -18555, -18722, -18908, -19076, -19208, -19316, -19414, -19507, -19609, -19717, -19793, -19819, -19841, -19908, -19981, -19997, -19953, -19868, -19757, -19664, -19625, -19638, -19687, -19761, -19831, -19881, -19882, -19818, -19692, -19520, -19295, -18996, -18628, -18220, -17792, -17355, -16926, -16505, -16107, -15738, -15418, -15153, -14898, -14616, -14295, -13920, -13502, -13092, -12713, -12364, -12048, -11765, -11510, -11274, -11032, -10785, -10577, -10432, -10358, -10366, -10424, -10446, -10420, -10401, -10424, -10485, -10598, -10740, -10853, -10940, -11061, -11237, -11443, -11661, -11847, -11921, -11893, -11863, -11862, -11835, -11746, -11604, -11424, -11184, -10823, -10329, -9772, -9195, -8617, -8057, -7515, -6981, -6431, -5767, -4939, -3969, -2875, -1692, -480};