/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0006 256 samples */
 
const int16_t AKWF_altosax_0006_256_DATA [256] = 
{1241, 3336, 5288, 7496, 9747, 12054, 14559, 17121, 19655, 22298, 25100, 27624, 29595, 31155, 32251, 32719, 32762, 32616, 32279, 31666, 30951, 30183, 29269, 28215, 27049, 25646, 23851, 21757, 19440, 16884, 14428, 11991, 9269, 6310, 3835, 2233, 894, -210, -737, -1076, -1436, -1732, -1845, -1715, -1268, -719, -284, 395, 1330, 2309, 3294, 4336, 5223, 5802, 6319, 6934, 7221, 7199, 6921, 6476, 5996, 5322, 4477, 3499, 2363, 1098, -450, -2138, -3749, -5393, -7209, -9028, -10812, -12679, -14328, -15679, -17103, -18675, -19950, -20780, -21512, -22241, -22714, -22873, -22598, -22030, -21398, -20528, -19309, -18135, -17120, -16042, -14515, -12731, -11204, -9818, -8353, -6665, -4936, -3209, -1334, 483, 2117, 3770, 5525, 6959, 8036, 9100, 10205, 11141, 11955, 12757, 13524, 14364, 15078, 15470, 15905, 16567, 16911, 16963, 16978, 16929, 16706, 16253, 15871, 15561, 15048, 14383, 13680, 12876, 11898, 10904, 9858, 8779, 7607, 6328, 5380, 4603, 3607, 2414, 1334, 449, -336, -1346, -2467, -3505, -4437, -5323, -6107, -6779, -7243, -7586, -8001, -8484, -8839, -9065, -9440, -9779, -9933, -10164, -10516, -10633, -10623, -10772, -10838, -10981, -11219, -11437, -11557, -11680, -11760, -11936, -12306, -12577, -12585, -12494, -12501, -12575, -12611, -12431, -12076, -11736, -11439, -11154, -10803, -10469, -10036, -9446, -8786, -8090, -7302, -6468, -5630, -4717, -3819, -3010, -2335, -1658, -886, -153, 474, 987, 1415, 1846, 2256, 2511, 2584, 2571, 2505, 2322, 2050, 1805, 1529, 1170, 742, 218, -353, -944, -1525, -2092, -2564, -3054, -3643, -4098, -4388, -4835, -5394, -5927, -6447, -6991, -7464, -7907, -8283, -8611, -9022, -9579, -10055, -10402, -10756, -11217, -11639, -11801, -11872, -11931, -11888, -11666, -11503, -11263, -10816, -10060, -8949, -7738, -6447, -4907, -3007, -859};