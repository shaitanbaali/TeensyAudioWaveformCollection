/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0010 256 samples */
 
const int16_t AKWF_altosax_0010_256_DATA [256] = 
{635, 1686, 2622, 3779, 5297, 6851, 8255, 9655, 10969, 12399, 14113, 16008, 17850, 19486, 20799, 21685, 22421, 23249, 24224, 25345, 26431, 27162, 27665, 28289, 28979, 29536, 30064, 30629, 31218, 31720, 32049, 32294, 32440, 32543, 32706, 32770, 32550, 32146, 31507, 30717, 30112, 29668, 29240, 28622, 27793, 26860, 25979, 25033, 23941, 22873, 21769, 20500, 19045, 17481, 15862, 14188, 12565, 11067, 9630, 8151, 6497, 4626, 2613, 721, -501, -1300, -2141, -3398, -4954, -6524, -7569, -8290, -9041, -10010, -11132, -12300, -13196, -13772, -14302, -14840, -15453, -16034, -16823, -17633, -18188, -18655, -19050, -19493, -19867, -20145, -20481, -20723, -20752, -20671, -20555, -20507, -20434, -20201, -19788, -19211, -18373, -17451, -16780, -16279, -15673, -14681, -13305, -11882, -10777, -10030, -9449, -8674, -7518, -6209, -5177, -4455, -3783, -3042, -2198, -1364, -425, 533, 1489, 2149, 2601, 2937, 3538, 4342, 5104, 5632, 6053, 6543, 7022, 7368, 7471, 7534, 7546, 7575, 7612, 7481, 7028, 6345, 5800, 5522, 5496, 5376, 4796, 3883, 3067, 2555, 2216, 1687, 872, -177, -1181, -1981, -2565, -3000, -3440, -4095, -4874, -5523, -5965, -6303, -6695, -7261, -8031, -8733, -9190, -9401, -9609, -9984, -10441, -10939, -11270, -11371, -11432, -11641, -12006, -12219, -12135, -11894, -11748, -11808, -11843, -11681, -11294, -10875, -10599, -10532, -10279, -9855, -9409, -8964, -8565, -8248, -8086, -7909, -7718, -7368, -6903, -6462, -6174, -5984, -5924, -5954, -5881, -5799, -5765, -5698, -5589, -5487, -5455, -5575, -5657, -5580, -5534, -5548, -5644, -5824, -6044, -6210, -6309, -6448, -6710, -7091, -7482, -7783, -7962, -8077, -8143, -8187, -8281, -8337, -8333, -8358, -8370, -8320, -8238, -8184, -8160, -8093, -7957, -7698, -7342, -7090, -6849, -6353, -5813, -5337, -4823, -4088, -3270, -2467, -1472, -400};