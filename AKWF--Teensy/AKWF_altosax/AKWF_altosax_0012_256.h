/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0012 256 samples */
 
const int16_t AKWF_altosax_0012_256_DATA [256] = 
{606, 1844, 3219, 4676, 6016, 7164, 8112, 8995, 9751, 10227, 10539, 10811, 11103, 11365, 11513, 11538, 11516, 11582, 11615, 11573, 11631, 11727, 11740, 11705, 11722, 11948, 12325, 12743, 13079, 13406, 13879, 14488, 15179, 15877, 16351, 16493, 16509, 16663, 17182, 17923, 18672, 19218, 19662, 20211, 20985, 21943, 22939, 23766, 24353, 24885, 25444, 26045, 26639, 27186, 27688, 28142, 28566, 29018, 29514, 29986, 30090, 29669, 28825, 27770, 26720, 25768, 24962, 24274, 23536, 22671, 21771, 20967, 20416, 20345, 20674, 21102, 21436, 21621, 21826, 22015, 22141, 22423, 22815, 23063, 23035, 22756, 22545, 22531, 22706, 22746, 22684, 22925, 23262, 23436, 23362, 23074, 22689, 22181, 21620, 21171, 20897, 20785, 20728, 20699, 20715, 20767, 20812, 20757, 20634, 20487, 20278, 20012, 19720, 19260, 18500, 17363, 15888, 14208, 12386, 10459, 8473, 6330, 3983, 1518, -876, -2986, -4664, -5991, -7183, -8270, -9104, -9231, -8503, -7056, -5399, -3945, -2872, -1967, -951, 161, 1160, 1686, 1126, -722, -3376, -6112, -8264, -9856, -11054, -12104, -13253, -14574, -15799, -16830, -17716, -18794, -20180, -21743, -23105, -23998, -24603, -24948, -25025, -24795, -24355, -23976, -23861, -24150, -24925, -25996, -27042, -27805, -28227, -28497, -28837, -29372, -29806, -29958, -29793, -29450, -29125, -28985, -28994, -28972, -28556, -27719, -26771, -26050, -25793, -25988, -26384, -26673, -26944, -27318, -27913, -28652, -29396, -30057, -30645, -31210, -31777, -32299, -32627, -32760, -32773, -32550, -31843, -30753, -29586, -28534, -27600, -26594, -25316, -23870, -22389, -21041, -19917, -19028, -18330, -17610, -16671, -15636, -14703, -14102, -13768, -13563, -13374, -13156, -12912, -12621, -12237, -11696, -11076, -10503, -10119, -9835, -9424, -9043, -8731, -8303, -7811, -7394, -7382, -7612, -7541, -7175, -6695, -6476, -6409, -6175, -5559, -4585, -3498, -2431, -1436, -427};