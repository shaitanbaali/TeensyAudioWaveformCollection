/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0021 256 samples */
 
const int16_t AKWF_altosax_0021_256_DATA [256] = 
{740, 2314, 3572, 4835, 6137, 7352, 8454, 9474, 10425, 11335, 12228, 13094, 13926, 14706, 15396, 16006, 16554, 17041, 17428, 17711, 17956, 18205, 18449, 18690, 18940, 19199, 19487, 19815, 20196, 20643, 21150, 21691, 22269, 22893, 23578, 24411, 25457, 26597, 27647, 28596, 29462, 30245, 30969, 31617, 32107, 32408, 32593, 32714, 32766, 32766, 32705, 32520, 32256, 31987, 31717, 31426, 31096, 30680, 30149, 29525, 28826, 28095, 27378, 26728, 26197, 25748, 25278, 24748, 24119, 23380, 22640, 21949, 21265, 20565, 19827, 19001, 18111, 17193, 16239, 15248, 14224, 13154, 12068, 11043, 10110, 9253, 8447, 7655, 6832, 5988, 5128, 4274, 3466, 2717, 2007, 1345, 777, 336, -21, -325, -600, -887, -1167, -1411, -1610, -1754, -1842, -1868, -1842, -1830, -1862, -1869, -1804, -1701, -1596, -1510, -1463, -1458, -1487, -1543, -1610, -1689, -1815, -2010, -2313, -2750, -3256, -3759, -4272, -4844, -5455, -6057, -6642, -7211, -7774, -8397, -9115, -9886, -10675, -11458, -12221, -12966, -13734, -14493, -15166, -15756, -16332, -16923, -17519, -18106, -18661, -19153, -19556, -19840, -20055, -20295, -20559, -20788, -20956, -21009, -20926, -20753, -20521, -20257, -19989, -19728, -19476, -19212, -18893, -18522, -18136, -17744, -17326, -16881, -16413, -15928, -15407, -14818, -14219, -13687, -13208, -12736, -12268, -11784, -11289, -10797, -10319, -9885, -9515, -9186, -8893, -8618, -8343, -8071, -7805, -7559, -7378, -7269, -7174, -7079, -7033, -7068, -7192, -7408, -7711, -8090, -8512, -8913, -9294, -9719, -10210, -10754, -11358, -12051, -12834, -13687, -14564, -15432, -16265, -17045, -17773, -18465, -19150, -19832, -20460, -21004, -21470, -21853, -22200, -22565, -22882, -23048, -23065, -22961, -22734, -22378, -21896, -21283, -20546, -19756, -18969, -18162, -17323, -16413, -15382, -14247, -13046, -11799, -10533, -9258, -7963, -6640, -5351, -4134, -2797, -1045};