/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0005 256 samples */
 
const int16_t AKWF_altosax_0005_256_DATA [256] = 
{1059, 3451, 5414, 7110, 9101, 11922, 15584, 19471, 22563, 24825, 26612, 27956, 28609, 28758, 29054, 29797, 30785, 31756, 32472, 32745, 32735, 32359, 31775, 31156, 30356, 29351, 28349, 27259, 26024, 24814, 23608, 21909, 19774, 17626, 15652, 13658, 11721, 9896, 8270, 6986, 5927, 4830, 3614, 2718, 2167, 2141, 2465, 2688, 2707, 2754, 2920, 3092, 3336, 3655, 4084, 4791, 5711, 6380, 6765, 6924, 6830, 6614, 6373, 5971, 5454, 5028, 4526, 3871, 3348, 2735, 1730, 633, -701, -2230, -3652, -4932, -6074, -7059, -7916, -8870, -9930, -10923, -11943, -13091, -14169, -15225, -16278, -16978, -17463, -17984, -18465, -18757, -19021, -19340, -19590, -19711, -19534, -19199, -18712, -18121, -17329, -16512, -15625, -14676, -13604, -12250, -10905, -9566, -8126, -6617, -5073, -3615, -2382, -1029, 503, 2041, 3408, 4623, 5798, 6958, 8246, 9413, 10283, 10926, 11519, 12139, 12748, 13249, 13621, 13832, 14062, 14298, 14311, 13858, 13084, 12365, 11832, 11134, 10222, 9389, 8805, 8143, 7220, 6248, 5233, 4097, 2911, 1756, 513, -590, -1420, -2063, -2637, -3187, -3847, -4573, -5271, -6074, -6837, -7185, -7463, -7975, -8229, -8171, -8256, -8551, -8901, -9051, -9048, -9116, -9178, -9125, -9131, -9362, -9437, -9325, -9469, -9835, -9949, -9762, -9673, -9625, -9607, -9723, -9752, -9734, -9680, -9584, -9698, -9904, -9829, -9528, -9386, -9316, -9163, -8866, -8573, -8280, -7950, -7633, -7209, -6766, -6189, -5625, -5103, -4513, -3885, -3257, -2592, -1922, -1303, -805, -419, -131, 60, 125, 10, -116, -282, -543, -856, -1289, -1787, -2300, -2758, -3203, -3670, -4133, -4625, -5080, -5492, -5949, -6564, -7282, -8046, -8858, -9690, -10627, -11667, -12748, -13830, -14811, -15730, -16554, -17168, -17516, -17625, -17449, -16854, -15965, -14589, -12581, -10184, -7538, -4608, -1555};