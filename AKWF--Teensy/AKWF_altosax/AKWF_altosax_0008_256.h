/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0008 256 samples */
 
const int16_t AKWF_altosax_0008_256_DATA [256] = 
{851, 2659, 4267, 5969, 7798, 9718, 11669, 13618, 15640, 17568, 19457, 21311, 22927, 24016, 24737, 25625, 26451, 26916, 27428, 28181, 28974, 29754, 30481, 31039, 31571, 31796, 31765, 31931, 32215, 32446, 32668, 32773, 32562, 32036, 31269, 30486, 29626, 28548, 27324, 25940, 24475, 23084, 21763, 20402, 18992, 17741, 16433, 15020, 13785, 12820, 11742, 10373, 8875, 7163, 5417, 4362, 3864, 3414, 2844, 2109, 1294, 854, 388, -423, -1299, -2277, -3576, -4813, -5610, -6173, -6891, -7860, -8913, -9901, -10647, -11204, -11822, -12604, -13372, -14095, -14743, -15257, -15810, -16418, -16889, -17136, -17337, -17565, -17652, -17534, -17494, -17406, -17153, -16744, -16289, -16021, -15611, -15056, -14586, -14027, -13342, -12437, -11465, -10648, -9728, -8667, -7439, -6147, -4947, -3980, -3043, -1999, -873, 120, 956, 1848, 2819, 3663, 4431, 5325, 6101, 6780, 7376, 7840, 8119, 8393, 8578, 8529, 8445, 8388, 8148, 7776, 7259, 6693, 6166, 5657, 5121, 4472, 3697, 2762, 1758, 736, -213, -1064, -1834, -2685, -3527, -4303, -4977, -5565, -6237, -6971, -7620, -8194, -8720, -9136, -9381, -9540, -9799, -10146, -10400, -10320, -10092, -9996, -9962, -9837, -9627, -9357, -9155, -8924, -8612, -8229, -7875, -7602, -7255, -6791, -6323, -5907, -5623, -5353, -5024, -4800, -4607, -4398, -4307, -4164, -3929, -3820, -3766, -3586, -3391, -3282, -3292, -3239, -3116, -3173, -3434, -3635, -3753, -3823, -3985, -4353, -4678, -4909, -5117, -5307, -5518, -5722, -5935, -6223, -6539, -6746, -6913, -7136, -7355, -7610, -7801, -7819, -7754, -7798, -7930, -8008, -7970, -7882, -7871, -7862, -7797, -7859, -8048, -8177, -8197, -8280, -8520, -8827, -9201, -9601, -9904, -10244, -10700, -11244, -11763, -12081, -12348, -12577, -12634, -12518, -12274, -11840, -11158, -10208, -9022, -7699, -6289, -4691, -2973, -1034};