/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0014 256 samples */
 
const int16_t AKWF_altosax_0014_256_DATA [256] = 
{603, 1456, 2267, 3122, 4008, 4951, 5927, 7019, 8068, 9031, 10064, 11079, 12049, 13072, 14163, 15293, 16411, 17408, 18344, 19324, 20290, 21257, 22249, 23091, 24013, 24901, 25727, 26534, 27306, 28093, 28787, 29455, 30084, 30606, 31085, 31556, 31946, 32260, 32494, 32617, 32680, 32761, 32707, 32594, 32468, 32270, 32022, 31778, 31520, 31168, 30765, 30329, 29814, 29303, 28683, 27946, 27171, 26339, 25401, 24509, 23594, 22664, 21699, 20704, 19769, 18836, 17904, 16984, 15997, 14988, 14061, 12980, 11919, 10885, 9830, 8783, 7728, 6653, 5578, 4516, 3442, 2361, 1332, 357, -641, -1616, -2497, -3330, -4167, -4904, -5639, -6364, -7039, -7695, -8313, -8862, -9405, -9896, -10356, -10836, -11259, -11691, -11983, -12187, -12403, -12632, -12847, -12894, -12836, -12817, -12837, -12799, -12733, -12776, -12696, -12517, -12364, -12187, -12000, -11821, -11548, -11188, -10806, -10411, -10020, -9693, -9314, -8928, -8593, -8235, -7858, -7489, -7210, -6943, -6681, -6425, -6009, -5644, -5348, -5131, -4954, -4756, -4585, -4369, -4133, -3947, -3807, -3697, -3665, -3676, -3686, -3733, -3774, -3736, -3746, -3789, -3937, -4105, -4205, -4287, -4328, -4435, -4636, -4826, -4996, -5236, -5514, -5779, -6006, -6268, -6557, -6819, -7179, -7574, -7953, -8282, -8585, -8902, -9193, -9496, -9782, -10076, -10381, -10686, -11071, -11384, -11667, -11954, -12197, -12429, -12705, -12922, -13102, -13299, -13483, -13630, -13803, -13993, -14139, -14262, -14405, -14541, -14683, -14819, -14919, -15012, -15124, -15236, -15360, -15508, -15594, -15597, -15590, -15606, -15635, -15579, -15487, -15417, -15338, -15266, -15237, -15113, -14952, -14844, -14736, -14597, -14495, -14365, -14165, -13948, -13732, -13483, -13227, -12881, -12531, -12225, -11914, -11583, -11151, -10706, -10283, -9815, -9311, -8828, -8331, -7785, -7180, -6509, -5760, -4987, -4275, -3575, -2852, -2054, -1176, -290};