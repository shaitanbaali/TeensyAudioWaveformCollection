/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0015 256 samples */
 
const int16_t AKWF_altosax_0015_256_DATA [256] = 
{636, 1560, 2441, 3358, 4248, 5086, 5955, 6876, 7787, 8727, 9688, 10642, 11570, 12480, 13378, 14225, 15076, 16023, 16956, 17809, 18686, 19634, 20524, 21355, 22164, 22946, 23684, 24480, 25233, 25926, 26605, 27231, 27891, 28498, 29045, 29638, 30171, 30655, 31104, 31500, 31849, 32127, 32386, 32609, 32712, 32759, 32768, 32712, 32571, 32393, 32167, 31911, 31622, 31268, 30864, 30401, 29884, 29319, 28713, 28096, 27461, 26772, 26011, 25194, 24344, 23441, 22461, 21457, 20503, 19518, 18454, 17392, 16344, 15279, 14178, 13045, 11838, 10682, 9628, 8566, 7407, 6339, 5362, 4352, 3300, 2346, 1336, 361, -523, -1484, -2399, -3307, -4209, -5080, -5984, -6818, -7612, -8391, -9116, -9852, -10578, -11281, -11954, -12564, -13233, -13915, -14499, -14999, -15541, -16070, -16573, -17067, -17452, -17840, -18250, -18585, -18775, -18825, -18919, -19013, -18986, -19004, -19030, -19031, -19000, -18933, -18886, -18785, -18634, -18502, -18326, -18176, -17996, -17724, -17418, -17075, -16716, -16325, -15875, -15404, -15021, -14603, -14073, -13571, -13027, -12438, -11906, -11476, -11027, -10476, -9888, -9365, -8910, -8381, -7834, -7348, -6901, -6481, -6092, -5710, -5298, -4876, -4495, -4133, -3821, -3591, -3324, -3046, -2796, -2616, -2534, -2416, -2350, -2346, -2295, -2257, -2271, -2351, -2474, -2600, -2786, -3022, -3232, -3403, -3647, -3945, -4231, -4519, -4874, -5223, -5526, -5815, -6157, -6598, -7003, -7388, -7813, -8215, -8640, -9055, -9444, -9841, -10217, -10593, -10984, -11369, -11712, -12032, -12343, -12663, -12984, -13276, -13533, -13755, -13958, -14160, -14331, -14544, -14757, -14841, -14888, -14927, -14952, -14951, -14917, -14922, -14880, -14748, -14582, -14361, -14141, -13911, -13623, -13283, -12944, -12585, -12168, -11713, -11262, -10811, -10300, -9767, -9320, -8776, -8110, -7448, -6863, -6258, -5589, -4882, -4148, -3382, -2603, -1837, -1080, -255};