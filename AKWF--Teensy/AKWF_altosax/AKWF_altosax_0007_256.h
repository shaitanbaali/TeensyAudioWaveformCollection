/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0007 256 samples */
 
const int16_t AKWF_altosax_0007_256_DATA [256] = 
{1534, 4090, 6294, 8320, 10174, 11823, 13284, 14559, 15307, 15615, 15991, 16765, 18108, 19687, 21482, 23552, 25537, 27458, 29402, 31054, 32167, 32680, 32752, 32465, 32090, 31658, 31376, 31244, 31102, 30854, 30377, 29748, 29312, 28620, 27396, 25947, 24473, 22898, 21266, 19581, 17943, 16421, 15090, 13763, 12323, 11007, 9821, 8587, 7308, 5758, 4588, 4234, 3853, 3271, 2694, 2015, 1442, 1130, 1204, 1463, 1352, 980, 668, 654, 840, 524, -458, -1663, -2573, -3190, -4052, -5119, -6097, -7074, -8078, -9112, -10065, -11219, -12855, -14489, -15790, -17182, -18695, -19911, -21102, -22062, -22763, -23466, -24034, -24498, -25037, -25641, -26135, -26460, -26679, -26920, -26975, -26681, -26122, -25477, -24757, -23754, -22586, -21425, -20268, -19032, -17674, -16137, -14390, -12545, -10843, -8973, -6917, -4832, -2841, -921, 989, 2776, 4190, 5514, 7139, 8927, 10568, 12124, 13476, 14684, 16094, 17285, 18007, 18632, 19202, 19762, 20163, 20310, 20237, 20014, 19585, 19278, 18864, 18099, 17074, 16348, 15847, 15075, 14086, 13130, 12377, 11637, 10682, 9463, 8052, 6774, 5720, 4452, 2867, 1574, 380, -735, -1598, -2430, -3464, -4338, -4833, -5221, -5745, -6353, -6874, -7115, -7011, -6659, -6597, -6842, -6841, -6280, -5619, -5354, -5314, -5168, -4869, -4457, -4054, -3782, -3652, -3659, -3542, -3499, -3545, -3647, -3893, -4123, -4303, -4589, -5081, -5680, -6189, -6658, -7090, -7565, -7971, -8270, -8695, -9262, -9761, -10176, -10568, -10984, -11461, -11889, -12163, -12311, -12533, -12862, -13061, -13159, -13240, -13335, -13377, -13396, -13375, -13296, -13233, -13093, -12845, -12528, -12248, -11963, -11581, -11087, -10602, -10355, -10166, -9845, -9553, -9300, -9170, -8959, -8596, -8378, -8320, -8208, -7993, -7888, -7920, -7932, -7930, -7884, -7712, -7457, -7306, -7121, -6667, -6033, -5284, -4206, -2765, -856};