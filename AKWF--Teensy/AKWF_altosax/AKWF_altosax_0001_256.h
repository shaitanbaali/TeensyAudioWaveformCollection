/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0001 256 samples */
 
const int16_t AKWF_altosax_0001_256_DATA [256] = 
{149, 471, 731, 1010, 1362, 1761, 1893, 1688, 1295, 880, 670, 837, 1171, 1457, 1609, 1725, 1902, 2136, 2303, 2352, 2380, 2447, 2528, 2468, 2444, 2625, 2950, 3298, 3540, 3599, 3575, 3573, 3480, 3250, 2903, 2545, 2215, 1868, 1292, 636, 255, 120, 132, 160, 111, 64, 209, 511, 815, 938, 1014, 1287, 1998, 2880, 3702, 4567, 5413, 6196, 6903, 7777, 8925, 9938, 10585, 10917, 11434, 12224, 13085, 13695, 14020, 14234, 14508, 14815, 14963, 14727, 14103, 13293, 12472, 11750, 11144, 10598, 10063, 9533, 8950, 8357, 7928, 7648, 7463, 7317, 7151, 6963, 6830, 6813, 6967, 7333, 7793, 8229, 8683, 9287, 10120, 10897, 11694, 12740, 13910, 14992, 15803, 16444, 17107, 17956, 18757, 19468, 20298, 21160, 22042, 23036, 24263, 25523, 26237, 26561, 26774, 27009, 27358, 27852, 28494, 29138, 29656, 30116, 30500, 30754, 30811, 30691, 30440, 29997, 29339, 28459, 27326, 26058, 24804, 23525, 22053, 20125, 17742, 15059, 12320, 9750, 7451, 5395, 3433, 1642, 411, -290, -687, -1133, -1546, -1621, -962, 332, 1950, 3630, 5042, 5865, 5778, 4886, 3530, 1973, 389, -1141, -2636, -3749, -4091, -3969, -3894, -4360, -5307, -6603, -8145, -9693, -11079, -12284, -13114, -13495, -13528, -13567, -13848, -14285, -15008, -16116, -17553, -19104, -20565, -21773, -22728, -23493, -24030, -24443, -24896, -25479, -26263, -27240, -28149, -28822, -29240, -29392, -29428, -29575, -29780, -29980, -30170, -30610, -31326, -32028, -32529, -32744, -32772, -32623, -32197, -31644, -31094, -30551, -29762, -28859, -28043, -27420, -26815, -25942, -24631, -22968, -21219, -19737, -18533, -17428, -16496, -15705, -14985, -14333, -13760, -13276, -12892, -12519, -12008, -11424, -10899, -10555, -10162, -9586, -8925, -8181, -7322, -6307, -5303, -4460, -3780, -3145, -2420, -1599, -831, -256};