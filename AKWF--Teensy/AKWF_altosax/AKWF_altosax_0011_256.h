/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0011 256 samples */
 
const int16_t AKWF_altosax_0011_256_DATA [256] = 
{626, 1697, 2799, 4097, 5425, 6679, 7963, 9332, 10830, 12400, 13948, 15396, 16661, 17910, 19358, 20962, 22479, 23770, 24850, 25865, 26940, 27896, 28644, 29230, 29710, 30150, 30611, 30968, 31247, 31477, 31621, 31829, 32182, 32529, 32744, 32735, 32447, 31952, 31406, 30935, 30513, 30057, 29463, 28720, 27886, 26936, 25968, 25156, 24435, 23669, 22773, 21668, 20441, 19137, 17833, 16523, 15165, 13717, 12161, 10568, 8914, 7258, 5723, 4346, 3080, 1966, 924, -161, -1261, -2436, -3552, -4540, -5375, -6170, -7043, -8179, -9380, -10409, -11251, -11987, -12709, -13537, -14511, -15370, -15796, -15838, -15775, -15872, -16147, -16551, -16853, -16857, -16727, -16607, -16462, -16331, -16075, -15615, -15057, -14408, -13753, -13092, -12407, -11662, -10785, -9843, -9143, -8694, -8214, -7522, -6727, -5964, -5421, -5039, -4517, -3842, -3132, -2421, -1751, -1242, -756, -244, 301, 809, 1266, 1635, 1902, 2063, 2206, 2394, 2469, 2353, 2245, 2237, 2286, 2416, 2360, 2141, 1879, 1651, 1478, 1356, 1139, 770, 332, -197, -755, -1196, -1603, -2057, -2532, -3071, -3592, -4116, -4578, -5025, -5435, -5887, -6445, -7054, -7591, -8022, -8391, -8675, -8968, -9388, -9851, -10166, -10325, -10400, -10478, -10667, -10877, -10997, -11056, -11150, -11259, -11280, -11198, -11083, -11057, -11119, -11101, -10936, -10593, -10184, -9923, -9823, -9707, -9491, -9197, -8909, -8644, -8332, -8061, -7867, -7621, -7350, -7094, -6875, -6748, -6622, -6421, -6262, -6212, -6122, -6005, -5916, -5852, -5867, -5951, -6048, -6161, -6316, -6475, -6679, -6920, -7103, -7221, -7405, -7675, -7928, -8092, -8191, -8311, -8571, -8863, -9057, -9255, -9428, -9594, -9765, -9915, -10065, -10178, -10183, -10147, -10122, -10036, -9897, -9716, -9492, -9250, -8960, -8613, -8200, -7701, -7087, -6414, -5748, -5024, -4221, -3358, -2482, -1537, -450};