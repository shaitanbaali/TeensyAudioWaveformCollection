/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0016 256 samples */
 
const int16_t AKWF_altosax_0016_256_DATA [256] = 
{508, 1444, 2256, 3129, 4066, 4948, 5771, 6589, 7517, 8561, 9448, 10397, 11435, 12377, 13416, 14462, 15460, 16516, 17479, 18403, 19391, 20373, 21336, 22232, 23038, 23811, 24532, 25235, 25985, 26729, 27369, 27989, 28703, 29357, 29927, 30439, 30899, 31311, 31652, 31929, 32184, 32385, 32572, 32735, 32767, 32761, 32720, 32572, 32402, 32238, 32045, 31783, 31451, 31105, 30741, 30307, 29834, 29349, 28830, 28255, 27610, 26958, 26310, 25582, 24846, 24074, 23224, 22342, 21435, 20475, 19489, 18549, 17670, 16772, 15788, 14830, 13879, 12891, 11877, 10907, 9941, 8947, 7949, 6993, 6060, 5091, 4050, 3048, 2082, 1067, 7, -982, -1897, -2833, -3770, -4695, -5608, -6511, -7384, -8242, -9064, -9846, -10668, -11448, -12150, -12852, -13530, -14215, -14897, -15493, -16020, -16510, -16980, -17405, -17815, -18203, -18547, -18874, -19167, -19420, -19631, -19757, -19871, -19992, -20036, -20060, -20047, -20005, -19997, -19927, -19805, -19678, -19503, -19315, -19121, -18892, -18597, -18268, -17940, -17594, -17145, -16746, -16390, -15916, -15394, -14910, -14450, -13929, -13489, -13078, -12619, -12165, -11663, -11155, -10696, -10225, -9769, -9343, -8920, -8457, -8044, -7668, -7248, -6873, -6511, -6151, -5840, -5565, -5323, -5094, -4845, -4677, -4537, -4385, -4328, -4218, -4064, -3974, -3934, -3944, -3946, -3921, -4015, -4105, -4180, -4373, -4572, -4725, -4893, -5158, -5456, -5759, -6063, -6364, -6682, -6956, -7180, -7489, -7768, -8037, -8378, -8699, -9009, -9320, -9615, -9888, -10214, -10553, -10802, -11116, -11409, -11631, -11911, -12194, -12450, -12690, -12913, -13098, -13248, -13386, -13531, -13695, -13866, -14002, -14053, -14009, -13950, -13939, -13816, -13660, -13536, -13372, -13172, -12944, -12662, -12287, -11930, -11649, -11419, -11163, -10823, -10463, -10139, -9755, -9354, -8885, -8249, -7549, -6705, -5792, -4969, -4022, -3026, -2120, -1269, -383};