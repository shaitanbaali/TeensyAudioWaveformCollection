/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0017 256 samples */
 
const int16_t AKWF_altosax_0017_256_DATA [256] = 
{2369, 6158, 10220, 14262, 17175, 19327, 21408, 22908, 24018, 24347, 23975, 23839, 23822, 23959, 24585, 25356, 25821, 25697, 25523, 26233, 26974, 27139, 27277, 27782, 28098, 28429, 29593, 31066, 31971, 32374, 32389, 31757, 30802, 29603, 28132, 25837, 22689, 19937, 18057, 16521, 15284, 14067, 12684, 11558, 10760, 10085, 9338, 8460, 7450, 6270, 5181, 4691, 5073, 6026, 6467, 5630, 4408, 3473, 2425, 1855, 2175, 2387, 1079, -1427, -4251, -7365, -10340, -13514, -17098, -20247, -21560, -20827, -18390, -14328, -10440, -7209, -2128, 4764, 7663, 4503, -721, -4611, -6810, -8353, -10079, -12637, -16316, -19954, -23018, -25468, -26546, -26961, -27031, -27439, -29381, -31796, -32746, -32030, -30566, -29509, -28406, -26785, -24798, -21940, -19058, -17376, -16545, -16443, -16580, -16720, -18056, -19896, -21821, -24796, -27015, -26237, -23718, -23126, -24137, -23826, -21972, -20039, -18049, -15582, -12854, -9862, -6127, -1497, 2713, 6242, 10136, 14265, 17444, 19684, 21778, 23573, 24763, 24845, 24104, 23749, 23706, 23843, 24439, 25204, 25689, 25687, 25647, 26508, 27473, 27567, 27724, 28359, 28730, 28948, 30089, 31508, 32197, 32533, 32765, 32259, 31247, 29872, 28098, 25738, 22666, 19979, 17980, 16266, 14876, 13503, 11939, 10714, 9958, 9403, 8919, 8157, 7142, 6144, 5314, 4868, 5206, 6174, 6695, 6043, 4889, 3919, 2827, 2310, 2559, 2613, 1413, -1084, -4008, -7077, -9874, -12996, -16581, -19810, -21130, -20583, -18462, -14844, -11040, -7741, -3123, 3209, 6175, 3609, -1279, -5184, -7392, -8700, -10113, -12367, -15868, -19556, -22694, -25119, -26218, -26386, -26253, -26696, -28628, -31095, -32330, -31915, -30648, -29633, -28585, -27134, -25159, -22095, -19050, -17342, -16812, -17023, -17606, -18190, -19672, -21771, -23917, -25815, -26305, -24822, -22762, -22217, -22784, -22452, -21164, -19850, -18456, -16352, -13732, -10611, -6593, -1739};