/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0013 256 samples */
 
const int16_t AKWF_altosax_0013_256_DATA [256] = 
{261, 1182, 1999, 2908, 3884, 4893, 5854, 6909, 7967, 8945, 10038, 11164, 12329, 13407, 14503, 15613, 16682, 17757, 18865, 20011, 21176, 22261, 23297, 24238, 25110, 25948, 26806, 27722, 28508, 29229, 29914, 30453, 30985, 31540, 31980, 32331, 32561, 32719, 32770, 32756, 32715, 32649, 32588, 32447, 32125, 31830, 31475, 30997, 30522, 30013, 29320, 28525, 27719, 26792, 25750, 24591, 23268, 21797, 20330, 18926, 17527, 16127, 14690, 13433, 12415, 11605, 10884, 10114, 9293, 8410, 7512, 6468, 5303, 4018, 2687, 1385, 18, -1365, -2745, -3958, -5007, -6026, -6937, -7750, -8591, -9325, -9970, -10549, -11097, -11547, -11971, -12416, -12793, -13158, -13544, -13885, -14185, -14379, -14475, -14487, -14466, -14490, -14440, -14329, -14219, -14056, -13921, -13760, -13521, -13332, -13123, -12884, -12659, -12423, -12113, -11788, -11488, -11135, -10743, -10405, -10028, -9553, -8985, -8349, -7753, -7153, -6444, -5776, -5156, -4543, -4030, -3541, -3126, -2818, -2449, -2133, -1823, -1540, -1216, -975, -837, -736, -685, -628, -641, -659, -701, -824, -956, -1097, -1316, -1566, -1820, -2060, -2260, -2485, -2747, -3018, -3314, -3646, -4002, -4289, -4647, -4981, -5309, -5690, -6075, -6493, -6909, -7257, -7596, -7934, -8256, -8595, -8943, -9277, -9595, -9857, -10131, -10410, -10671, -10908, -11107, -11265, -11385, -11501, -11562, -11586, -11574, -11613, -11684, -11691, -11684, -11680, -11652, -11589, -11611, -11621, -11539, -11432, -11328, -11288, -11256, -11184, -11071, -10971, -10900, -10823, -10743, -10711, -10737, -10760, -10766, -10761, -10705, -10597, -10535, -10561, -10567, -10516, -10482, -10400, -10255, -10172, -10161, -10134, -10094, -10020, -9999, -9964, -9844, -9697, -9570, -9473, -9407, -9299, -9178, -8941, -8668, -8453, -8259, -8016, -7669, -7294, -6837, -6396, -5939, -5515, -5074, -4509, -3997, -3510, -2838, -2098, -1332, -548};