/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0026 256 samples */
 
const int16_t AKWF_altosax_0026_256_DATA [256] = 
{1372, 3637, 6026, 8540, 11127, 13741, 16171, 18269, 20136, 21904, 23526, 25060, 26477, 27886, 29197, 30340, 31347, 32111, 32336, 31876, 31101, 30200, 28845, 27222, 25816, 24610, 23485, 22506, 21558, 20614, 19571, 18163, 16685, 15358, 14029, 12718, 11499, 10155, 8523, 6584, 4425, 2158, -321, -2962, -5684, -8456, -11157, -13668, -16007, -18228, -20178, -21856, -23485, -24946, -25998, -26834, -27772, -28808, -29925, -31296, -32379, -32759, -32690, -32406, -31927, -31437, -30786, -29977, -29503, -29285, -29149, -29363, -29896, -30247, -30262, -30183, -30181, -30188, -30155, -30002, -29653, -29186, -28768, -28331, -27812, -27271, -26647, -25951, -25299, -24575, -23630, -22527, -21411, -20195, -18740, -17214, -15741, -14144, -12414, -10591, -8894, -7275, -5513, -3841, -2268, -630, 1120, 3007, 4805, 6536, 8375, 10272, 12222, 14101, 15770, 17190, 18526, 19792, 20889, 21723, 22439, 23164, 23779, 24179, 24594, 24977, 25189, 25273, 25218, 24918, 24440, 23865, 23046, 22027, 21013, 19907, 18621, 17233, 15752, 14284, 12866, 11510, 10172, 8815, 7388, 5879, 4332, 2828, 1443, 250, -821, -1808, -2628, -3284, -3765, -4176, -4609, -4976, -5232, -5438, -5553, -5481, -5208, -4886, -4629, -4370, -3919, -3233, -2555, -1956, -1297, -585, 139, 786, 1370, 1981, 2627, 3254, 3783, 4265, 4824, 5392, 5902, 6299, 6575, 6835, 6998, 7003, 6981, 6869, 6670, 6553, 6415, 6154, 5966, 5868, 5739, 5503, 5251, 5081, 4848, 4371, 3819, 3329, 2866, 2398, 1805, 1156, 620, 125, -333, -739, -1089, -1382, -1688, -2045, -2355, -2567, -2791, -3010, -3205, -3386, -3429, -3310, -3165, -3092, -2995, -2822, -2587, -2389, -2234, -2025, -1856, -1874, -1965, -2001, -2045, -2233, -2526, -2882, -3335, -3788, -4204, -4699, -5253, -5829, -6259, -6531, -6727, -6719, -6414, -5866, -5071, -3956, -2495, -649};