/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0025 256 samples */
 
const int16_t AKWF_altosax_0025_256_DATA [256] = 
{258, 685, 639, 468, 429, 585, 886, 1211, 1661, 2366, 3346, 4564, 5904, 7201, 8364, 9422, 10592, 12053, 13664, 15213, 16443, 17183, 17431, 17391, 17112, 16591, 15850, 14959, 14036, 13151, 12355, 11652, 11054, 10591, 10365, 10408, 10675, 11216, 12270, 13829, 15676, 17574, 19403, 21167, 22962, 24745, 26452, 27994, 29255, 30157, 30650, 30845, 30976, 31086, 31104, 30891, 30400, 29688, 28794, 27789, 26743, 25746, 24889, 24257, 23830, 23501, 23125, 22654, 22228, 21773, 21192, 20659, 20216, 19756, 19030, 17982, 17014, 16252, 15610, 14908, 14139, 13523, 13205, 13242, 13531, 13981, 14512, 15067, 15617, 16193, 16833, 17516, 18126, 18546, 18705, 18632, 18299, 17570, 16507, 15266, 13939, 12557, 11103, 9598, 8084, 6668, 5319, 3963, 2739, 1678, 644, -365, -1284, -1999, -2494, -2840, -3122, -3353, -3441, -3392, -3249, -3050, -2954, -3160, -3612, -4142, -4516, -4679, -4706, -4721, -4752, -4704, -4523, -4191, -3767, -3381, -3165, -3078, -3078, -3162, -3319, -3535, -3786, -4070, -4389, -4703, -4980, -5237, -5710, -6643, -8060, -9887, -11947, -14066, -16066, -17798, -19297, -20655, -21858, -22861, -23574, -23791, -23421, -22648, -21663, -20626, -19567, -18579, -17784, -17037, -16245, -15579, -15168, -15057, -15068, -15049, -14936, -14842, -14809, -14510, -13986, -13529, -13237, -13145, -13235, -13544, -14050, -14560, -14926, -15079, -15029, -14801, -14398, -13866, -13280, -12746, -12302, -11924, -11647, -11491, -11409, -11474, -11820, -12549, -13696, -15188, -16962, -18928, -20964, -23050, -25205, -27356, -29379, -31059, -32193, -32710, -32713, -32268, -31347, -29698, -27120, -23629, -19534, -15274, -11206, -7527, -4176, -1189, 1328, 3200, 3971, 3214, 1066, -1979, -5180, -8092, -10424, -12034, -13050, -13693, -13987, -13958, -13697, -13444, -13393, -13514, -13617, -13425, -12931, -12099, -10811, -9041, -6879, -4596, -2479, -775};