/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_altosax_0023 256 samples */
 
const int16_t AKWF_altosax_0023_256_DATA [256] = 
{298, 865, 1429, 2025, 2660, 3327, 4017, 4736, 5502, 6315, 7131, 7916, 8677, 9421, 10153, 10915, 11735, 12571, 13358, 14091, 14840, 15631, 16457, 17318, 18206, 19079, 19922, 20750, 21570, 22400, 23239, 24091, 24947, 25792, 26619, 27428, 28205, 28959, 29691, 30379, 31009, 31568, 32037, 32400, 32667, 32768, 32768, 32678, 32274, 31713, 31076, 30364, 29557, 28666, 27712, 26701, 25658, 24627, 23621, 22635, 21680, 20791, 20035, 19411, 18869, 18394, 18010, 17737, 17562, 17452, 17392, 17379, 17415, 17467, 17499, 17493, 17451, 17371, 17240, 17051, 16794, 16449, 16011, 15499, 14936, 14342, 13762, 13214, 12643, 11989, 11275, 10549, 9824, 9106, 8398, 7694, 6988, 6281, 5548, 4782, 4039, 3397, 2857, 2384, 1959, 1572, 1215, 885, 583, 314, 103, -21, -91, -162, -249, -376, -562, -780, -978, -1163, -1375, -1636, -1951, -2332, -2763, -3202, -3629, -4033, -4390, -4742, -5208, -5800, -6451, -7109, -7751, -8332, -8857, -9394, -9985, -10605, -11232, -11850, -12425, -12943, -13396, -13786, -14114, -14391, -14625, -14826, -15001, -15149, -15244, -15304, -15406, -15604, -15871, -16158, -16465, -16795, -17143, -17527, -17969, -18454, -18945, -19420, -19897, -20385, -20880, -21393, -21914, -22412, -22860, -23256, -23605, -23912, -24184, -24430, -24625, -24739, -24771, -24731, -24629, -24453, -24184, -23862, -23565, -23325, -23085, -22794, -22487, -22217, -21992, -21807, -21656, -21522, -21375, -21205, -21007, -20772, -20539, -20361, -20207, -19961, -19584, -19144, -18697, -18244, -17793, -17343, -16866, -16342, -15787, -15246, -14721, -14151, -13503, -12846, -12239, -11694, -11204, -10766, -10319, -9794, -9207, -8642, -8127, -7645, -7205, -6777, -6304, -5788, -5287, -4835, -4457, -4179, -3998, -3853, -3704, -3561, -3435, -3316, -3192, -3058, -2930, -2825, -2728, -2616, -2476, -2274, -1982, -1637, -1329, -1054, -713, -233};