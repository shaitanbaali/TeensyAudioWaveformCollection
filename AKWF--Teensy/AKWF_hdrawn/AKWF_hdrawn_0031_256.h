/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0031 256 samples */
 
const int16_t AKWF_hdrawn_0031_256_DATA [256] = 
{-402, -460, -127, 507, 616, 774, 1302, 1965, 2218, 2379, 2676, 2853, 3151, 3465, 3895, 4499, 5461, 6436, 7408, 8378, 9352, 10324, 11295, 12268, 13241, 14211, 15185, 16157, 17128, 18102, 19073, 20045, 21019, 21990, 22961, 23962, 24774, 26635, 27958, 27749, 27791, 27703, 27572, 27470, 27218, 26722, 26238, 25751, 25268, 24764, 24209, 23654, 23098, 22541, 21992, 21398, 20702, 20008, 19313, 18620, 17924, 17242, 16595, 15947, 15299, 14651, 14003, 13354, 12707, 12059, 11409, 10763, 10113, 9469, 8783, 8053, 7309, 6656, 6424, 6237, 6041, 5845, 5553, 5224, 4901, 4579, 4246, 4134, 4150, 4147, 4147, 4147, 4147, 4147, 4147, 4147, 4147, 4147, 4147, 4150, 4137, 4207, 4527, 4846, 5263, 6109, 7123, 7971, 9723, 11913, 13081, 14546, 16976, 18422, 19699, 20835, 21792, 22768, 23739, 24712, 25682, 26658, 27617, 28087, 28343, 28921, 29478, 29218, 32455, 18072, -15688, -14280, -17666, -19625, -20906, -21358, -22136, -23137, -24091, -25114, -25742, -25706, -25733, -26368, -26811, -27052, -27156, -27293, -27352, -27560, -27873, -27971, -28101, -28201, -28167, -28146, -28086, -22690, -16398, -25970, -27793, -27449, -27654, -27776, -27931, -28094, -28256, -28418, -28580, -28684, -28761, -28844, -28924, -29006, -29074, -29134, -29195, -29256, -29317, -29378, -29438, -29506, -29575, -29645, -29714, -29783, -29853, -29931, -30013, -30094, -30175, -30256, -30348, -30446, -30542, -30644, -30699, -30692, -30701, -30832, -31008, -31112, -31107, -31109, -31107, -31116, -31172, -31234, -31294, -31356, -31417, -31476, -31544, -31632, -31721, -31810, -31898, -31986, -32074, -32163, -32252, -32339, -32400, -32452, -32507, -32561, -32615, -32669, -32725, -32766, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32769, -32757, -32619, -32421, -32450, -31808, -30946, -31137, -31110, -31098, -31202, -31460};