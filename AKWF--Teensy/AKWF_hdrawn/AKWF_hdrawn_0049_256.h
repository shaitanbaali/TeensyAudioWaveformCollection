/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0049 256 samples */
 
const int16_t AKWF_hdrawn_0049_256_DATA [256] = 
{32707, 31343, 29649, 28751, 27710, 26439, 25596, 24574, 23086, 22956, 22980, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22971, 22929, 22872, 22818, 22758, 22688, 22637, 22698, 20825, 19570, 18755, 17730, 16641, 15494, 14215, 13174, 12525, 11862, 11156, 10377, 9603, 8826, 8052, 7274, 6501, 5713, 4660, 3735, 2746, 1957, 1180, 433, -196, -1435, -2992, -4288, -5452, -6615, -7781, -8943, -10106, -11272, -12433, -13610, -14800, -16003, -17078, -19070, -20423, -20708, -21496, -22160, -22561, -22989, -23430, -23770, -23851, -23961, -24037, -23982, -23863, -23747, -23631, -23518, -23316, -23066, -22824, -22580, -22336, -22093, -21840, -21584, -21328, -21072, -20815, -20565, -20265, -19875, -19487, -19097, -18719, -18196, -17572, -16975, -16213, -15350, -14485, -13531, -12568, -11615, -10570, -9473, -8385, -7297, -6354, -5462, -4558, -3659, -2767, -1874, -985, -83, 738, 1393, 2052, 2710, 3380, 3884, 4264, 4661, 5053, 5452, 5824, 6073, 6306, 6553, 6737, 6762, 6782, 6821, 6739, 6473, 6218, 5966, 5687, 5298, 4900, 4505, 4106, 3720, 3271, 2599, 1913, 1234, 545, -274, -1131, -1996, -2741, -3346, -3963, -4587, -5090, -5507, -5935, -6364, -6774, -7151, -7527, -7924, -8125, -8131, -8159, -8184, -8158, -8098, -8059, -7924, -7572, -7224, -6875, -6529, -6138, -5707, -5281, -4856, -4426, -4017, -3631, -3243, -2855, -2467, -2142, -1848, -1550, -1243, -1019, -885, -741, -596, -513, -470, -422, -374, -345, -322, -298, -276, -273, -274, -271, -240, -204, -161, -107, -61, -20, 33, 95, 156, 222, 294, 365, 437, 419, 361, 315, 267, 219, 177, 150, 123, 96, 63, 29, -19, -107, -179, -183, -182, -182, -182, -186, -144, -90, -94, -21, 31, -371, 65};