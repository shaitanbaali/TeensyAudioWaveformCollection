/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0023 256 samples */
 
const int16_t AKWF_hdrawn_0023_256_DATA [256] = 
{-426, 102, -343, -992, -1500, -1941, -2398, -2884, -3520, -4143, -4703, -5120, -5662, -6871, -8819, -9896, -11116, -12272, -12745, -13682, -15915, -17460, -18443, -19473, -20357, -21067, -22462, -24171, -24705, -25333, -25949, -26562, -27176, -27797, -28323, -28776, -29238, -29699, -30160, -30620, -31081, -31543, -31997, -32482, -32778, -32764, -32767, -32767, -32767, -32767, -32767, -32764, -32778, -32717, -32339, -32164, -32081, -31935, -31667, -31461, -31257, -31048, -30858, -30538, -30099, -28135, -24475, -20613, -14707, -3325, 4445, 8609, 13109, 17288, 20047, 22202, 24610, 25509, 26056, 26760, 27586, 28402, 28951, 29412, 29783, 30877, 31806, 31699, 31718, 31725, 31523, 31321, 31170, 31050, 30611, 29763, 28951, 28199, 27466, 26725, 25995, 25184, 24318, 23458, 22605, 21701, 20715, 19734, 18746, 17781, 16913, 16053, 15194, 14333, 13379, 12392, 11413, 10411, 9623, 9027, 8408, 7793, 7184, 6518, 5778, 5040, 4300, 3587, 2969, 2350, 1823, 1372, 900, 494, 284, 78, -66, -164, -267, -368, -476, -528, -523, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -524, -527, -502, -437, -377, -315, -255, -204, -152, -102, -49, -4, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 2, -18, -71, -122, -173, -224, -278, -340, -401, -449, -582, -175};