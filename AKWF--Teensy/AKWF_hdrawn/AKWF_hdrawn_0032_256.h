/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0032 256 samples */
 
const int16_t AKWF_hdrawn_0032_256_DATA [256] = 
{-402, -460, -127, 507, 616, 774, 1302, 1965, 2218, 2379, 2676, 2853, 3151, 3465, 3895, 4499, 5461, 6436, 7408, 8378, 9352, 10324, 11295, 12268, 13241, 14211, 15185, 16157, 17128, 18102, 19073, 20045, 21019, 21990, 22961, 23962, 24774, 26635, 27958, 27749, 27791, 27703, 27572, 27470, 27218, 26722, 26238, 25193, 27695, 9330, -8244, -5242, -5821, -5882, -5943, -6003, -6065, -6125, -6188, -6223, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6221, -6222, -6222, -6221, -6232, -6249, -6264, -6282, -6298, -6314, -6330, -6346, -6363, -6378, -6395, -6411, -6427, -6443, -6459, -6476, -6491, -6508, -6525, -6541, -6557, -6573, -6590, -6606, -6620, -6642, -6691, -6742, -6794, -6845, -6896, -6948, -6998, -7050, -7101, -7152, -7203, -7254, -7306, -7357, -7407, -7461, -7569, -7935, -6699, -22590, -29241, -28006, -28418, -28580, -28684, -28761, -28844, -28924, -29006, -29074, -29134, -29195, -29256, -29317, -29378, -29438, -29506, -29575, -29645, -29714, -29783, -29853, -29931, -30013, -30094, -30175, -30256, -30348, -30446, -30542, -30644, -30699, -30692, -30701, -30832, -31008, -31112, -31107, -31109, -31107, -31116, -31172, -31234, -31294, -31356, -31417, -31476, -31544, -31632, -31721, -31810, -31898, -31986, -32074, -32163, -32252, -32339, -32400, -32452, -32507, -32561, -32615, -32669, -32725, -32766, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32769, -32757, -32619, -32421, -32450, -31808, -30946, -31137, -31110, -31098, -31202, -31460};