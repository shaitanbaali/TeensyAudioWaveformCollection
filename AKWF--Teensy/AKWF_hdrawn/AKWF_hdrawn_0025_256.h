/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0025 256 samples */
 
const int16_t AKWF_hdrawn_0025_256_DATA [256] = 
{1006, 1366, 2201, 3315, 3525, 3825, 5547, 7097, 8836, 10539, 11547, 13434, 15414, 16390, 15979, 15763, 15504, 15358, 15284, 15198, 15114, 15031, 14947, 14863, 14782, 14725, 14672, 14618, 14564, 14510, 14456, 14403, 14348, 14295, 14241, 14188, 14127, 14008, 13880, 13756, 13630, 13504, 13379, 13253, 13128, 13003, 12877, 12846, 12851, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12850, 12848, 12854, 12826, 12648, 12465, 12037, 12319, 6695, -7954, -6876, -7073, -6974, -6777, -6584, -6432, -6424, -6426, -6426, -6423, -6439, -6353, -7731, -2022, 10013, 8769, 8995, 8988, 9008, 8969, 6032, 5667, 5976, 6140, 6338, 6436, 6408, 6865, 5375, 17774, 29295, 27007, 26844, 27310, 24225, 14541, -1566, -15510, -20732, -23890, -24914, -26499, -28120, -29300, -31027, -31720, -32759, -31493, -26553, -23162, -20202, -17536, -15314, -13041, -10807, -8687, -6579, -4473, -2363, -281, 1334, 5609, 4198, -3572, -7088, -10601, -15494, -16188, -16035, -16024, -16275, -16793, -15391, -13523, -11575, -9479, -8317, -8611, -8687, -10176, -11388, -11654, -11826, -15151, -23292, -26187, -27224, -28156, -28924, -28909, -28911, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28912, -28913, -28845, -28747, -28654, -28559, -28465, -28371, -28277, -28184, -28090, -27996, -27900, -27807, -27713, -27615, -27501, -27384, -27269, -27152, -27037, -26922, -26805, -26689, -26575, -26456, -26352, -26341, -26343, -26342, -26342, -26342, -26342, -26342, -26342, -26342, -26342, -26342, -26179, -27054, -20095, -14985, -14856, -14411, -14107, -13818, -13452, -12433, -11281, -10140, -9227, -7322, -5071, -4986, -3482, -1309, 499};