/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0017 256 samples */
 
const int16_t AKWF_hdrawn_0017_256_DATA [256] = 
{244, -53, 275, 953, 3046, 4347, 5403, 6290, 10274, 13342, 14696, 16336, 18077, 20054, 22023, 23848, 25679, 27174, 27804, 28427, 29059, 29677, 30348, 31221, 32152, 32772, 32419, 31851, 31334, 30730, 29976, 29224, 28476, 27703, 26757, 25784, 24820, 23854, 22810, 21728, 20674, 19474, 18034, 16603, 15166, 13752, 12230, 10439, 8657, 6756, 4765, 2857, 1223, -385, -1987, -3776, -5663, -7566, -9277, -10560, -11846, -13143, -14410, -15506, -16577, -17651, -18726, -19708, -20636, -21598, -22403, -22929, -23471, -23671, -23712, -23795, -23807, -23353, -22799, -22263, -21740, -20948, -19981, -19070, -17998, -16566, -15126, -13928, -12866, -11815, -10584, -8967, -7356, -5835, -4357, -2914, -1227, 929, 3090, 4487, 5508, 6598, 7655, 8892, 10346, 11758, 12879, 13989, 14747, 14879, 15159, 14560, 13392, 12851, 12237, 11633, 11028, 10423, 9823, 9162, 8467, 7778, 7086, 6395, 5710, 4879, 3974, 3083, 2186, 1294, 359, -613, -1582, -2526, -3648, -5090, -6524, -7543, -8375, -9239, -10105, -10910, -11657, -12409, -13168, -13866, -14404, -14940, -15474, -15742, -15882, -16194, -16516, -16495, -16496, -16391, -16247, -16132, -15858, -15384, -14926, -14466, -14004, -13551, -13025, -12414, -11811, -11208, -10603, -9996, -9404, -8623, -7712, -6822, -5928, -5022, -4218, -3511, -2792, -2076, -1366, -594, 269, 1128, 1987, 2851, 3751, 4622, 5805, 7284, 8634, 9386, 10039, 10721, 11315, 11831, 12435, 12422, 11669, 11078, 10463, 9847, 9235, 8621, 7965, 7292, 6620, 5948, 5278, 4606, 3933, 3247, 2555, 1864, 1172, 488, -234, -1260, -2345, -3416, -4490, -5562, -6653, -7880, -9166, -10197, -10925, -11683, -12437, -13171, -13845, -14515, -15187, -15760, -16300, -16775, -17080, -16727, -16033, -15357, -14420, -12423, -9800, -6497, -3199, 102, 950, 896, 917, 891, 1067, 947, 534, 335, -239, 37};