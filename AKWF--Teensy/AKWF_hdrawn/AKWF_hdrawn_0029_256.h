/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0029 256 samples */
 
const int16_t AKWF_hdrawn_0029_256_DATA [256] = 
{32768, 32768, 32768, 32759, 32802, 32576, 31925, 31710, 31495, 31237, 30457, 29541, 28648, 27769, 26846, 24718, 23562, 22298, 19514, 17549, 16104, 13555, 13368, 12775, 10087, 8690, 7362, 5906, 4478, 2341, 1161, -84, -571, 168, 198, 232, 270, 307, 344, 381, 416, 450, 484, 518, 553, 588, 622, 656, 690, 724, 760, 813, 869, 925, 981, 1037, 1094, 1140, 1143, 1142, 1143, 1143, 1143, 1142, 1167, 1206, 1243, 1280, 1317, 1355, 1392, 1429, 1466, 1505, 1525, 1523, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1523, 1523, 1526, 1481, 1403, 1329, 1255, 1179, 1114, 1060, 1004, 947, 891, 836, 779, 759, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 762, 761, 764, 743, 685, 630, 573, 518, 463, 404, 373, 406, 120, -23, -52, -152, -239, -333, -385, -381, -381, -384, -368, -296, -220, -146, -73, 10, 150, 258, 406, -93, -9644, -24123, -29735, -30014, -29624, -25078, -17234, 346, 1981, 1327, 1365, 1273, 1183, 1094, 1004, 915, 828, 721, 571, 421};