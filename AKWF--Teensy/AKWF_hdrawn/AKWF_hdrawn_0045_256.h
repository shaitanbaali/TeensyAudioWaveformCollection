/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0045 256 samples */
 
const int16_t AKWF_hdrawn_0045_256_DATA [256] = 
{2399, 5572, 8320, 10771, 12949, 14887, 16613, 18139, 19492, 20695, 21761, 22711, 23556, 24304, 24971, 25570, 26080, 26696, 28611, 31524, 28746, 23017, 21081, 18603, 16509, 14646, 12986, 11512, 10204, 9038, 8003, 7085, 6268, 5545, 4905, 4336, 3833, 3387, 2993, 2646, 2339, 2069, 1832, 1622, 1439, 1279, 1137, 1010, 899, 796, 721, 788, 886, 893, 797, 720, 560, 409, 88, -396, -1487, -1691, -1676, -1710, -1743, -1789, -1835, -1881, -1927, -1973, -2019, -2065, -2112, -2158, -2204, -2250, -2296, -2342, -2388, -2436, -2463, -2470, -2478, -2487, -2495, -2503, -2512, -2520, -2529, -2537, -2545, -2554, -2562, -2571, -2579, -2587, -2596, -2604, -2612, -2621, -2629, -2637, -2640, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2639, -2641, -2648, -2609, -3383, -4408, -5287, -6152, -6983, -7782, -8634, -9541, -10404, -11238, -12056, -12848, -13613, -14356, -15076, -15808, -16493, -17048, -17541, -17679, -17612, -17533, -17504, -17468, -17438, -17407, -17376, -17341, -17304, -17282, -17317, -17153, -16473, -15846, -15110, -14327, -13487, -12555, -11567, -10587, -9615, -8630, -7631, -6635, -5646, -4658, -3652, -2623, -1585, -541, 504, 1549, 2583, 3676, 4922, 6142, 7377, 8570, 9597, 9774, 9750, 9826, 9886, 9944, 9996, 10051, 10097, 10101, 10101, 10100, 10119, 10151, 10182, 10193, 10191, 10192, 10192, 10192, 10192, 10190, 10205, 10242, 10277, 10344, 10370, 10402, 10064, 9647, 9365, 9060, 8756, 8466, 8197, 7943, 7704, 7468, 7229, 6985, 6733, 6473, 6206, 5934, 5663, 5406, 5163, 4931, 4662, 4391, 4141, 3887, 3629, 3362, 3092, 2823, 2546, 2275, 2013, 1775, 1559, 1363};