/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0019 256 samples */
 
const int16_t AKWF_hdrawn_0019_256_DATA [256] = 
{247, -64, 441, 1260, 1721, 2101, 2480, 3287, 4408, 5061, 10316, 14372, 15656, 17242, 17673, 18009, 18946, 19767, 20103, 20514, 20923, 21281, 22108, 23209, 23673, 23981, 24322, 24656, 24979, 25749, 26304, 26679, 27044, 27308, 27574, 27894, 28195, 28712, 29431, 29615, 29816, 30018, 30217, 30417, 30618, 30817, 31017, 31218, 31417, 31616, 31823, 31954, 32014, 32081, 32133, 32183, 32234, 32275, 32307, 32341, 32374, 32407, 32441, 32474, 32508, 32541, 32574, 32607, 32641, 32674, 32707, 32742, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32770, 32745, 32675, 32611, 32593, 32565, 32535, 32471, 32405, 32377, 32335, 32249, 32179, 32113, 32046, 31982, 31900, 31713, 31510, 31311, 31111, 30863, 30591, 30339, 30142, 29935, 29195, 28840, 28618, 27884, 27004, 26172, 25141, 24944, 9805, 4330, 4377, 3122, 1475, 707, 257, -592, -1847, -4322, -18599, -23621, -26514, -29237, -30716, -30714, -30716, -30720, -30716, -30736, -30545, -29822, -31302, -19355, 1249, 657, 1257, 1045, 538, -163, -1364, -2475, -3227, -3531, -3719, -4148, -4292, -4395, -4454, -4475, -4502, -4521, -4524, -4472, -4365, -4068, -3818, -3329, -2701, -2156, -1921, -1456, -1186, -1121, -1084, -743, -364, -312, -290, -211, -16, 82, 84, 93, 119, 145, 167, 170, 169, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 168, 176, 209, 243, 257, 255, 256, 256, 256, 256, 256, 256, 256, 256, 256, 255, 256, 254, 241, 227, 213, 199, 184, 170, 156, 142, 127, 112, 98, 84, 72, 59, 46, 34, 22, 9, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 12, 33, 52, 77, 75, 14};