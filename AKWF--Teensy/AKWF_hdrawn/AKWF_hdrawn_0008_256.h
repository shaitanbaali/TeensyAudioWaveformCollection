/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0008 256 samples */
 
const int16_t AKWF_hdrawn_0008_256_DATA [256] = 
{177, 750, 2178, 3649, 4380, 5132, 5898, 6662, 7447, 8103, 8537, 8983, 9430, 9863, 10362, 11026, 11692, 12356, 12891, 13374, 13870, 14355, 14910, 15534, 16140, 16789, 17599, 18427, 19168, 19848, 20518, 21076, 21630, 22094, 22445, 22802, 23182, 23709, 24266, 24756, 25123, 25688, 27291, 28781, 30197, 30991, 31333, 32074, 32710, 31892, 29706, 28487, 27841, 27011, 26113, 25284, 22612, 18858, 15974, 12900, 11470, 10495, 8317, 6162, 5260, 3888, 1549, 304, -839, -1914, -2727, -4319, -7713, -10216, -11221, -11822, -12501, -13206, -13963, -14709, -15414, -16019, -17213, -18402, -18785, -19350, -20673, -22034, -23650, -25065, -26316, -27713, -28486, -28850, -29281, -30438, -32163, -30892, -28431, -27596, -26548, -25571, -24600, -23621, -22764, -21995, -21216, -20436, -19658, -18881, -18098, -17335, -16481, -15221, -13889, -12867, -12126, -11350, -10592, -9871, -9154, -8442, -7622, -6717, -5972, -4375, -1147, 548, 1260, 2095, 2867, 3535, 4937, 6115, 6552, 6783, 5673, 4908, 4206, 3487, 2875, 2308, 1707, 1254, -462, -3562, -4836, -5622, -5598, -2769, -983, -551, 53, 614, 1261, 2065, 2949, 3815, 3345, 2702, 2092, 1504, 951, 393, -161, -715, -1278, -1778, -2207, -2644, -3079, -3514, -3950, -4384, -4829, -5280, -5730, -6182, -6616, -7014, -7473, -7303, -5696, -4868, -4180, -3455, -2834, -2267, -1693, -1118, -549, 21, 524, 1370, 1914, 1148, 688, 212, -267, -745, -1217, -1668, -2117, -2570, -3015, -3378, -3722, -4037, -4573, -3108, -1357, -777, -32, 573, 1222, 1529, 1152, 733, 346, 6, -334, -676, -1018, -1352, -1661, -1961, -2299, -2472, -2092, -1679, -1254, -794, -330, 119, 387, 605, 856, 945, 743, 537, 335, 88, -190, -451, -656, -880, -872, -634, -522, -476, -209, -82, -36, 5, -2, 0};