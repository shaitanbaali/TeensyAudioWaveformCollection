/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0009 256 samples */
 
const int16_t AKWF_hdrawn_0009_256_DATA [256] = 
{114, 129, 33, 166, 469, 38, 352, 1757, 1998, 2279, 2564, 2806, 3311, 3889, 4136, 4418, 4681, 4942, 5198, 5502, 5854, 6200, 6545, 6896, 7215, 7489, 7768, 8051, 8295, 8770, 9372, 9625, 9903, 10083, 10235, 10388, 10574, 10704, 10761, 10857, 11117, 11399, 11674, 11953, 12216, 12444, 12353, 12132, 12175, 12129, 11526, 10534, 9343, 7623, 6131, 1893, -8164, -8683, -9157, -10404, -11984, -13344, -14037, -14646, -16558, -18803, -19282, -19857, -20503, -22641, -26144, -28306, -29058, -30291, -31424, -31822, -32099, -32280, -32337, -32400, -32463, -32567, -32603, -32670, -32689, -32721, -32757, -32769, -32767, -32767, -32767, -32772, -32714, -32651, -32621, -32586, -32550, -32517, -32472, -32419, -32368, -32312, -32243, -32173, -32100, -32050, -31890, -31407, -31184, -30981, -30771, -30563, -30356, -30145, -29951, -29779, -29605, -29431, -29261, -29066, -28816, -28567, -28315, -28073, -27890, -27718, -27544, -27372, -27194, -26926, -26631, -26340, -26047, -25780, -25533, -25282, -25035, -24770, -24478, -24178, -23930, -23433, -22301, -21806, -21348, -20875, -20280, -19699, -18805, -17696, -17181, -16611, -15157, -13644, -13038, -12540, -11387, -9632, -6101, -3300, -35, 4124, 6223, 6732, 7519, 9062, 10503, 11023, 11582, 12239, 12938, 13631, 14324, 15022, 15630, 16181, 16726, 17216, 17704, 18154, 18567, 18984, 19409, 19783, 20528, 21850, 23283, 24825, 26403, 27735, 28430, 29121, 29419, 29902, 30167, 30206, 30296, 30490, 30708, 30852, 30913, 30991, 31170, 31322, 31216, 30597, 29643, -1332, -16551, -14183, -14242, -13979, -13696, -13405, -13113, -12823, -12525, -12161, -11783, -11409, -11037, -10564, -10039, -9508, -9068, -8813, -8552, -8291, -8031, -7771, -7511, -7248, -6980, -6712, -6445, -6176, -5913, -5607, -5256, -4910, -4564, -4214, -3887, -3599, -3306, -3016, -2716, -2370, -2031, -1322, -935, -560, -394, -357, -106, 173};