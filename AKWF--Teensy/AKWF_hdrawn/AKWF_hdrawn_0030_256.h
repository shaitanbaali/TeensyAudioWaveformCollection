/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0030 256 samples */
 
const int16_t AKWF_hdrawn_0030_256_DATA [256] = 
{32384, 32345, 32557, 32736, 32448, 32396, 32149, 31935, 31761, 31521, 31297, 31162, 30830, 30814, 30818, 30732, 30614, 30495, 30424, 30426, 30437, 30385, 30070, 29914, 29731, 29550, 29358, 29251, 29259, 29258, 29257, 29256, 29264, 29197, 29034, 28898, 28800, 28646, 28494, 28342, 28186, 28067, 28020, 27969, 27918, 27867, 27816, 27765, 27715, 27648, 27571, 27495, 27420, 27339, 27303, 27308, 27300, 27220, 27126, 27036, 26943, 26913, 26917, 26916, 26916, 26916, 26917, 26871, 26803, 26738, 26673, 26608, 26542, 26458, 26365, 26274, 26183, 26092, 26000, 25909, 25816, 25733, 25677, 25620, 25562, 25504, 25448, 25388, 25354, 25357, 25356, 25356, 25356, 25356, 25358, 25326, 25266, 25210, 25152, 25094, 25038, 24981, 24918, 24852, 24787, 24721, 24656, 24591, 24532, 24475, 24418, 24360, 24303, 24246, 24189, 24132, 24075, 24018, 23960, 23903, 23846, 23790, 23739, 23688, 23637, 23587, 23536, 23484, 23436, 23363, 23260, 23158, 23056, 22955, 22854, 22752, 22650, 22581, 22526, 22468, 22410, 22353, 22297, 22236, 22131, 22014, 21900, 21787, 21672, 21558, 21438, 21287, 21135, 20982, 20830, 20678, 20525, 20373, 20220, 20068, 19918, 19814, 19725, 19632, 19544, 19411, 19281, 19011, 18298, 17969, 17672, 17364, 17063, 16737, 16331, 15455, 15113, 14995, 14801, 13671, 12635, 11748, 10831, 9900, 9075, 7724, 5761, 5450, 5231, 3170, -79, -683, -857, -954, -3163, -6336, -9132, -12517, -15287, -18089, -19744, -20563, -21498, -22414, -23336, -24188, -26231, -27272, -27381, -28096, -28878, -29153, -29422, -30012, -30470, -30417, -30433, -30410, -30539, -31022, -31228, -31200, -31220, -31355, -31519, -31603, -31596, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597, -31597};