/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0039 256 samples */
 
const int16_t AKWF_hdrawn_0039_256_DATA [256] = 
{5013, 31839, 30858, 30440, 29858, 29192, 28536, 27878, 27220, 26560, 25908, 25290, 24675, 24062, 23447, 22702, 21902, 21168, 20474, 19730, 18923, 18222, 17666, 17105, 16491, 15796, 15110, 14394, 13638, 12892, 12083, 11217, 10242, 9098, 8182, 7365, 5790, 4641, 3130, 2161, 1251, 889, 436, 10, -36, -58, -88, -111, -131, -131, -294, 2334, 3145, 2962, 2995, 2981, 3055, 2929, -44, -245, -4055, -5056, -4789, -5047, -4122, -201, -292, -285, -280, -236, -480, 701, 2905, 3246, 392, -5008, -4413, -4544, -4562, -4582, -4601, -4621, -4639, -4590, -4980, -1737, 12, -346, -280, -310, -169, -1233, -2954, -11172, -20456, -31371, -32970, -32593, -32675, -32473, -33518, -28988, -774, 543, 179, 284, 264, 454, 887, 1033, 1212, 1654, 2081, 2436, 2792, 3214, 3657, 4368, 4825, 5226, 5537, 5860, 6105, 6199, 6259, 5381, 4575, 3859, 3125, 2338, 936, -1460, -2583, -3407, -4310, -5129, -5619, -5953, -6074, -6087, -6082, -6046, -5999, -5665, -5196, -4678, -4151, -3636, -3134, -2549, -1832, -1181, -652, -142, 301, 735, 1192, 1513, 1577, 1536, 1217, 869, 507, 134, -646, -1252, -1102, -1018, -879, -686, -601, -552, -497, -399, -281, -158, -97, -12, 188, 115, 173, 188, 258, 302, 371, 443, 577, 747, 904, 1108, 1402, 1693, 2029, 2371, 2871, 3505, 4070, 4576, 5096, 5731, 6370, 6920, 7467, 8018, 8563, 9128, 9773, 10473, 11250, 11879, 12408, 12950, 13296, 13208, 13088, 12936, 12838, 12357, 11657, 11190, 10608, 10226, 9164, 8112, 5974, 3589, 1459, -68, -1849, -2683, -4254, -4849, -5402, -6006, -6532, -6711, -7060, -7537, -7563, -7233, -6874, -6347, -5739, -5026, -4339, -3927, -2367, -187, 689, 668, -102, 95, 232, 371, 508, 667};