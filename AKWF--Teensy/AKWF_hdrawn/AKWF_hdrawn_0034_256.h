/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0034 256 samples */
 
const int16_t AKWF_hdrawn_0034_256_DATA [256] = 
{-412, 155, 440, 147, -60, 500, 443, 125, 723, 1169, 746, 888, 1170, 915, 619, 163, 520, 752, 282, 517, 64, -806, 3454, 8427, 8030, 8091, 8099, 8099, 8131, 7978, 8647, 13830, 14488, 14325, 14364, 14426, 14035, 19424, 22531, 21990, 22090, 22090, 22090, 22093, 22114, 22010, 23772, 26886, 29306, 29813, 29820, 29817, 29874, 29942, 31192, 32959, 32723, 32768, 32768, 32768, 32768, 32768, 32727, 32951, 31999, 27849, 27629, 27531, 27460, 27376, 27343, 27080, 25581, 23890, 22459, 19740, 18433, 18855, 18770, 18781, 18737, 18646, 18386, 19236, 13424, 8080, 9010, 8836, 8836, 8835, 8840, 8800, 8700, 8605, 8509, 8413, 8315, 8217, 8137, 7226, 6180, 3682, 1546, 6479, 7548, 4562, 2370, 2178, 2222, 2209, 2207, 2212, 2189, 2041, 1882, 1681, 1852, -655, -72, 2819, -1186, -1112, -1098, -1115, -1070, -1348, -2286, -3207, -4132, -5123, -5675, -8848, -13340, -13234, -13243, -13254, -13254, -13295, -13079, -14125, -18030, -18051, -18030, -18040, -18043, -18032, -18076, -18379, -18415, -18407, -18408, -18408, -18408, -18409, -18406, -18429, -18485, -18538, -18593, -18647, -18704, -18741, -19016, -19168, -19193, -19261, -19322, -19384, -19446, -19507, -19546, -19582, -19618, -19654, -19690, -19726, -19762, -19797, -19834, -19869, -19910, -19953, -19997, -20040, -20083, -20126, -20147, -20296, -19956, -14749, -14254, -14386, -14359, -14359, -14355, -14380, -14354, -13115, -17175, -33251, -32822, -30337, -28848, -29141, -29086, -29086, -29086, -29086, -29086, -29073, -29133, -28525, -27214, -26383, -26133, -26145, -26141, -26140, -26140, -26140, -26140, -26038, -26586, -23645, -19765, -20052, -19634, -19495, -19491, -19611, -19102, -15475, -14207, -14221, -14046, -13955, -13780, -13856, -12682, -6759, -6382, -6166, -6022, -5888, -5911, -5770, -4176, -2241, -554, -359, -201, 126, 381, 363, 368, 368};