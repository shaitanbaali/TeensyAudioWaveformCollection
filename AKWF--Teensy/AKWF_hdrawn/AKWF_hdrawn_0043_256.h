/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0043 256 samples */
 
const int16_t AKWF_hdrawn_0043_256_DATA [256] = 
{49, 125, 199, 300, 462, 638, 1128, 1266, 1108, 904, 642, 369, 89, -225, -706, -1216, -1629, -1952, -2286, -2619, -2902, -3155, -3411, -3667, -3927, -4194, -4461, -4725, -4972, -5214, -5154, -7129, 3816, 12700, 11556, 12837, 13532, 14612, 15602, 16742, 18064, 18629, 19043, 20047, 21229, 22018, 22651, 23836, 24898, 26023, 26690, 27225, 28108, 29030, 29621, 30504, 31241, 31738, 32617, 32005, 30484, 28992, 25859, 24092, 22588, 20847, 20006, 20041, 20367, 20946, 21979, 23963, 25679, 27679, 29567, 30012, 30304, 30844, 29012, 26722, 25411, 24101, 22387, 20286, 17898, 15283, 12302, 9824, 7756, 5943, 4372, 3264, 274, -1122, -1643, -2509, -3380, -4230, -4995, -5734, -6477, -5827, -5294, -4919, -4620, -4334, -4083, -3874, -3655, -3467, -3419, -3386, -3350, -3314, -3280, -3262, -3247, -3231, -3216, -3201, -3188, -3200, -3216, -3231, -3248, -3256, -3306, -3637, -4000, -4416, -5215, -6118, -7065, -8195, -9594, -11125, -12430, -13298, -13949, -14592, -15195, -15775, -16374, -16882, -17248, -17622, -18001, -18408, -18882, -19327, -19407, -19576, -20010, -20407, -20578, -20520, -20516, -20266, -19926, -19607, -19280, -18905, -18515, -18128, -17735, -17415, -17150, -16886, -16581, -16151, -15719, -15288, -14856, -14426, -13993, -13510, -12998, -12529, -12158, -11790, -11417, -11039, -10663, -10282, -9797, -9272, -8813, -8386, -7953, -7521, -7090, -6661, -6153, -5613, -5105, -4615, -3999, -3229, -2629, -2105, -1498, -650, -63, 508, 1191, 1914, 2640, 3404, 4109, 5024, 6024, 6606, 7009, 7192, 7584, 7772, 7936, 7629, 7207, 7076, 6785, 6400, 6055, 5569, 5161, 4880, 4647, 4419, 4417, 4420, 4407, 4369, 4334, 4285, 4231, 4176, 4126, 4084, 4038, 3981, 3957, 3939, 3851, 3768, 3719, 3613, 3517, 3374, 3229, 3147, 3046, 2775, 2256, 1864, 1743, 1071};