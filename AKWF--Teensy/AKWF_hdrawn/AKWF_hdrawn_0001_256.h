/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0001 256 samples */
 
const int16_t AKWF_hdrawn_0001_256_DATA [256] = 
{-392, -398, -66, 629, 1017, 1221, 1435, 1880, 2593, 3295, 3927, 4195, 4424, 4633, 5294, 6257, 7173, 8099, 9025, 9948, 10870, 11816, 12638, 13000, 13172, 14865, 16131, 16279, 16655, 17059, 18030, 19072, 20249, 21157, 22118, 22929, 23597, 24299, 24745, 24904, 25900, 27784, 28036, 28350, 28558, 28663, 29041, 29735, 30026, 30326, 30781, 31671, 31287, 30807, 31214, 31242, 31557, 31987, 32429, 32565, 32723, 32773, 32766, 32768, 32768, 32768, 32768, 32768, 32764, 32780, 32677, 32362, 32054, 31801, 31574, 31339, 31124, 30941, 30750, 30587, 30292, 29413, 28478, 27550, 26773, 26088, 25403, 24645, 23716, 22794, 21861, 20697, 19438, 18298, 17367, 16481, 15407, 12515, 10930, 9789, 8404, 6843, 5319, 4096, 2926, 1916, -541, -2868, -3945, -5206, -6465, -7558, -10104, -12373, -13461, -14672, -15634, -16461, -18391, -20095, -22295, -23890, -25471, -27088, -28335, -29920, -31190, -32087, -32635, -32783, -32765, -32728, -32019, -30569, -27668, -25832, -24011, -21121, -19228, -18400, -17435, -16224, -15093, -13028, -9312, -4997, -2069, -937, 392, 1974, 2836, 3827, 4331, 4813, 5180, 5112, 5458, 5542, 5521, 5534, 5211, 4742, 4417, 4143, 3557, 2602, 1683, 765, -534, -1315, -1600, -1861, -3621, -6547, -8375, -9369, -11415, -13782, -14499, -15586, -17951, -19393, -21541, -23294, -24244, -24940, -25962, -27227, -28136, -28660, -29113, -29254, -29579, -29613, -29285, -28505, -27114, -22948, -18918, -15464, -10570, -5352, -2180, 93, 1148, 2603, 5388, 7402, 9241, 10957, 11766, 12715, 13623, 14252, 14856, 15305, 15411, 15392, 15397, 15390, 15423, 15192, 14796, 14468, 13886, 13425, 12933, 11949, 11036, 10110, 9184, 8259, 7334, 6407, 5484, 4562, 3618, 2902, 2007, 1570, 1586, 1563, 1654, 2302, 2788, 3162, 3151, 2763, 2264, 1650, 1451, 1071, 745, 448, 114, -353};