/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0003 256 samples */
 
const int16_t AKWF_hdrawn_0003_256_DATA [256] = 
{245, 487, 584, 1746, 2719, 3276, 3785, 4013, 4118, 4173, 4282, 4440, 4573, 4812, 5248, 5457, 5700, 5855, 6092, 6225, 6267, 6316, 6383, 6529, 6682, 6830, 7059, 7336, 7591, 7794, 8001, 8132, 8170, 8341, 8949, 9183, 9377, 9552, 9701, 9850, 10013, 10214, 10415, 10617, 10819, 11020, 11221, 11423, 11624, 11826, 12028, 12229, 12433, 12615, 12765, 12914, 13076, 13328, 13607, 13826, 13974, 14114, 14324, 14801, 15027, 15222, 15424, 15627, 15823, 15979, 16130, 16277, 16489, 16747, 16999, 17240, 17445, 17626, 18201, 18639, 18881, 19126, 19277, 19428, 19580, 19770, 19974, 20175, 20377, 20578, 20779, 20986, 21245, 21522, 21740, 21887, 22038, 22195, 22391, 22594, 22795, 22997, 23199, 23400, 23601, 23803, 24004, 24206, 24371, 24525, 24653, 24968, 25605, 25870, 25899, 26019, 26530, 27163, 27696, 27918, 28115, 28317, 28522, 28711, 28800, 28831, 29149, 29523, 29650, 29784, 30048, 30511, 30708, 30905, 31059, 31308, 30781, 34809, -17081, -35894, -31234, -31466, -31110, -30766, -30476, -30241, -29846, -29302, -29055, -28799, -28561, -28064, -27331, -26993, -26736, -26491, -26293, -26090, -25889, -25687, -25485, -25286, -25056, -24802, -24547, -24312, -24138, -23965, -23793, -23619, -23448, -23268, -23067, -22865, -22664, -22462, -22261, -22059, -21857, -21656, -21454, -21253, -21052, -20850, -20648, -20447, -20243, -20051, -19799, -19340, -18859, -18496, -18223, -17939, -17657, -17374, -17092, -16810, -16527, -16246, -15964, -15680, -15399, -15117, -14747, -14332, -13970, -13727, -13485, -13245, -12995, -12658, -12302, -11949, -11597, -11245, -10890, -10549, -10264, -9982, -9701, -9418, -9135, -8854, -8571, -8290, -7996, -7692, -7391, -7088, -6785, -6484, -6181, -5850, -5539, -5064, -4454, -4200, -3934, -3390, -2661, -2224, -1854, -1686, -1536, -1340, -1170, -1048, -868, -714, -472, -279, -179, 6, 76, 158};