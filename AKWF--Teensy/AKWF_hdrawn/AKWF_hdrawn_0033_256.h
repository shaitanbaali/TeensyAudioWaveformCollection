/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0033 256 samples */
 
const int16_t AKWF_hdrawn_0033_256_DATA [256] = 
{-359, -377, 861, 1132, 1068, 1080, 1080, 1080, 1078, 1306, 1674, 1829, 3182, 8498, 9657, 9684, 9722, 9713, 9882, 9507, 13651, 17463, 16800, 16924, 16925, 16922, 16992, 17102, 17211, 17287, 17311, 17180, 18448, 21585, 22046, 21941, 21965, 21965, 21965, 21965, 21965, 21965, 21965, 21965, 21965, 21965, 21975, 21985, 22112, 24673, 27576, 27319, 27363, 27366, 27366, 27366, 27366, 27367, 27412, 27161, 28997, 30833, 30556, 30607, 30607, 30607, 30610, 30608, 30615, 31181, 32461, 32783, 32762, 32765, 32762, 32775, 32138, 29611, 29068, 29192, 29167, 29167, 29167, 29167, 29167, 29167, 29167, 29076, 29570, 27006, 23018, 23492, 23407, 23340, 23691, 21659, 16590, 16928, 16937, 16925, 16917, 16853, 16781, 16696, 16668, 16422, 13517, 9748, 7105, 7153, 7402, 7409, 6963, 3263, 2782, 2903, 2880, 2851, 3008, 2359, -1080, -1088, -1074, -1091, -1047, -1318, -2235, -3137, -4041, -5011, -5550, -8654, -13047, -12943, -12952, -12963, -12963, -13003, -12792, -13815, -17634, -17655, -17635, -17644, -17645, -17659, -17608, -18031, -20875, -22418, -22304, -22323, -22325, -22329, -22314, -22436, -22713, -23036, -24403, -24849, -24259, -24102, -24140, -24121, -25144, -28355, -29308, -29132, -29165, -29186, -29248, -29308, -29368, -29428, -29487, -29556, -29642, -29729, -29809, -29882, -31426, -32108, -32034, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32047, -32043, -32010, -32194, -29682, -28213, -28500, -28446, -28446, -28446, -28446, -28446, -28433, -28492, -27899, -26616, -25804, -25559, -25571, -25567, -25566, -25566, -25566, -25566, -25467, -26003, -23125, -19330, -19611, -19203, -19066, -19062, -19180, -18682, -15135, -13895, -13909, -13737, -13649, -13476, -13552, -12403, -6610, -6241, -6031, -5889, -5759, -5782, -5644, -4085, -2192, -542, -351, -196, 124, 373, 355, 360, 360};