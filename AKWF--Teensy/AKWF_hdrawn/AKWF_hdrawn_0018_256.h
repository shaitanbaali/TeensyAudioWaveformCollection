/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0018 256 samples */
 
const int16_t AKWF_hdrawn_0018_256_DATA [256] = 
{247, -64, 441, 1260, 1721, 2101, 2480, 3287, 4408, 5061, 10316, 14372, 15656, 17242, 17673, 18009, 18946, 19767, 20103, 20514, 20923, 21281, 22108, 23209, 23673, 23981, 24322, 24656, 24979, 25749, 26304, 26679, 27044, 27308, 27574, 27894, 28195, 28712, 29431, 29615, 29816, 30018, 30217, 30417, 30618, 30817, 31017, 31218, 31417, 31616, 31823, 31954, 32014, 32081, 32133, 32183, 32234, 32275, 32307, 32341, 32374, 32407, 32441, 32474, 32508, 32541, 32574, 32607, 32641, 32674, 32707, 32742, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32770, 32745, 32675, 32611, 32593, 32565, 32535, 32471, 32405, 32377, 32335, 32249, 32179, 32113, 32046, 31982, 31900, 31713, 31510, 31311, 31111, 30863, 30591, 30339, 30142, 29935, 29195, 28840, 28618, 27884, 27004, 26180, 25251, 24372, 23192, 21913, 20336, 19156, 17818, 16426, 14941, 13665, 13143, 12617, 11410, 9440, 7279, 5902, 1174, -5509, -9067, -11814, -14558, -15387, -16096, -16846, -17558, -18384, -20449, -21675, -22089, -22631, -23097, -23567, -23940, -24253, -24574, -24893, -25220, -25549, -25896, -26408, -26722, -26982, -27223, -27419, -27621, -27816, -27980, -28140, -28300, -28460, -28648, -28850, -29049, -29250, -29449, -29649, -29896, -30174, -30391, -30459, -30526, -30573, -30601, -30650, -30720, -30721, -30720, -30720, -30720, -30722, -30714, -30688, -30664, -30638, -30607, -30573, -30542, -30517, -30492, -30467, -30435, -30402, -30368, -30335, -30301, -30223, -30175, -30149, -30088, -30018, -29988, -29955, -29919, -29895, -29798, -29592, -29395, -29322, -29297, -29253, -29186, -29122, -28969, -28866, -28812, -28704, -28502, -28303, -28103, -27903, -27701, -27517, -27367, -27218, -27063, -26818, -26544, -26298, -26113, -25853, -25039, -23892, -22752, -21382, -20019, -19428, -19086, -18505, -17257, -15666, -14265, -13117, -11721, -10315, -8208, -6804, -5018, -2783, -581, 35};