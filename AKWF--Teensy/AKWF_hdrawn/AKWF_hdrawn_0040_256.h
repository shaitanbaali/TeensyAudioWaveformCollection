/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0040 256 samples */
 
const int16_t AKWF_hdrawn_0040_256_DATA [256] = 
{-7400, -3764, -4946, -5497, -4892, -531, 4634, 5062, 6102, 6531, 9005, 6670, 6149, 15618, 16746, 18514, 19749, 20939, 22319, 22165, 17766, 13139, 8418, 7200, 8042, 8556, 9133, 9707, 10282, 10856, 11430, 12005, 12581, 13155, 13729, 14307, 14949, 15609, 16266, 16923, 17581, 18239, 18894, 19552, 20210, 20866, 21524, 22181, 22841, 23437, 23992, 24552, 25113, 25672, 26232, 26792, 27352, 27911, 28471, 29030, 29593, 30010, 30348, 30699, 31048, 31395, 31742, 32098, 32414, 32504, 32564, 32628, 32702, 32724, 32078, 31292, 30336, 29039, 27760, 26476, 25207, 23696, 22034, 20398, 18754, 17112, 15473, 13828, 12186, 10545, 8950, 7387, 5820, 4251, 2684, 1118, -450, -2016, -3585, -4998, -6320, -7708, -8865, -8959, -9066, -9213, -9353, -9362, -9368, -9322, -9055, -8516, -8329, -8367, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8359, -8362, -8315, -8241, -8170, -8101, -8023, -7877, -7718, -7564, -7402, -7350, -7357, -7360, -7331, -7230, -7133, -7034, -6910, -6778, -6642, -6483, -6332, -6200, -6068, -5959, -5861, -5763, -5665, -5567, -5469, -5371, -5289, -5211, -5127, -5065, -4827, -4418, -4029, -3642, -3235, -2950, -2829, -2697, -2566, -2432, -2319, -2242, -2161, -2084, -2003, -1893, -1783, -1658, -1433, -1195, -962, -727, -491, -256, -22, 213, 448, 683, 919, 1153, 1388, 1624, 1859, 2094, 2329, 2564, 2800, 3034, 3269, 3504, 3740, 3973, 4217, 4366, 4497, 4657, 4680, 4763, 4924, 5137, 4500, 4197, 3829, 3549, 3364, 3166, 2971, 2772, 2595, 2447, 2237, 1904, 1671, 1671, 1666, 1693, 1445, 1322, 1171, 944, 821, 688, 504, 315, 159, -7, -262};