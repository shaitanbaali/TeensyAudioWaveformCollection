/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0035 256 samples */
 
const int16_t AKWF_hdrawn_0035_256_DATA [256] = 
{400, -123, 212, 199, -650, -314, -34, 252, 428, 127, -896, -706, -1570, -1479, -1332, -2446, -3556, -2849, -2305, -1954, -2520, -3286, -3496, -1404, -2313, -2166, -2346, -2881, -3452, -3871, -2483, -2149, -2211, -2332, -1699, -2348, -3979, -3173, -2820, -2343, -2586, -3410, -3864, -3370, -498, 337, -674, -1251, -2325, -867, 1404, 537, -497, -1852, -1461, -676, -3873, -2607, -1635, -693, 635, -244, -2328, -1045, 201, 329, -3371, -3219, -2872, -148, 1308, 1001, 1351, -552, -3016, -2533, -1978, 789, 1152, 1166, 221, -1838, -2178, -341, 1145, 1234, 1341, 1451, 1475, 1472, 1467, 1512, 1624, 1734, 1830, 1841, 1840, 1837, 1886, 1977, 2063, 2149, 2235, 2322, 2407, 2496, 2571, 2578, 2576, 2577, 2577, 2682, 2840, 2940, 2981, 3092, 3201, 3301, 3320, 3292, 3547, 3923, 4253, 4533, 4822, 5112, 5394, 5748, 6515, 7147, 7395, 7725, 8414, 8998, 9839, 10702, 11590, 12285, 12897, 13827, 15011, 15885, 16745, 17610, 18471, 19334, 20194, 21074, 21572, 21830, 22118, 23526, 25436, 26225, 27101, 27964, 28827, 29691, 30553, 31346, 32353, 32336, 19930, 8258, 5647, -14715, -31896, -28432, -28324, -27687, -27220, -26795, -26360, -25931, -25498, -24746, -23864, -23006, -22142, -21281, -20417, -19553, -18692, -17827, -16965, -16103, -15239, -14376, -13514, -12647, -11797, -10776, -9586, -8539, -7309, -4604, -3596, -3410, -3105, -2763, -2404, -2050, -1657, -1273, -1101, -906, -708, -765, -610, -322, 149, 400, 696, 744, 733, 736, 740, 715, 862, 1119, 1100, 1103, 1104, 1104, 1104, 1103, 1104, 1099, 983, 827, 733, 736, 735, 737, 726, 646, 558, 473, 386, 311, 239, 167, 96, 22, -3, 0, 0, 0, 0, -3, 9, -41, -368, -242, 18, -4};