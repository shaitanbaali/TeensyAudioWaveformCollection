/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0037 256 samples */
 
const int16_t AKWF_hdrawn_0037_256_DATA [256] = 
{621, -185, 301, 426, -606, -542, -698, 347, 1660, -499, 6, 851, 1645, 2447, 3250, 4080, 4916, 5753, 6591, 7427, 8264, 9105, 9990, 10884, 11777, 12668, 13562, 14455, 15345, 16252, 17189, 18127, 19065, 20001, 20937, 21876, 22813, 23751, 24595, 25390, 26196, 27000, 27298, 30817, 10730, -3067, -1438, -2792, -3685, -4570, -5521, -6565, -7607, -8648, -9688, -10731, -11771, -12818, -13663, -14391, -15138, -15883, -16626, -17370, -18114, -18866, -19694, -20534, -21369, -22206, -23043, -23882, -24702, -25470, -26233, -26999, -27759, -28549, -29167, -29338, -29504, -29661, -29754, -29137, -28175, -27330, -26463, -25595, -24729, -23864, -22995, -22130, -21264, -20397, -19531, -18664, -17796, -16935, -16008, -15027, -14056, -13082, -12107, -11135, -10160, -9186, -8212, -7243, -6285, -5330, -4373, -3407, -2489, -1319, 446, 2304, 3447, 2857, 1583, 235, -1099, -2436, -3777, -5115, -6453, -7794, -9132, -10470, -11811, -13149, -14487, -15828, -17165, -18504, -19838, -21203, -22391, -23073, -23738, -24410, -25080, -25748, -26419, -27090, -27752, -28543, -29414, -30272, -31120, -32020, -32681, -31707, -30307, -28986, -27646, -26303, -24988, -23764, -22548, -21333, -20113, -18897, -17680, -16461, -15246, -14029, -12724, -11381, -10043, -8702, -7365, -6026, -4685, -3349, -2008, -668, 667, 2008, 3348, 4684, 6025, 7365, 8701, 10042, 11386, 12674, 14216, 15133, 13982, 12344, 10753, 9135, 7609, 6276, 4937, 3596, 2258, 915, -405, -1920, -3660, -5379, -7098, -8819, -10548, -12211, -13813, -15415, -17054, -18456, -19262, -20079, -20797, -21995, -24853, -25516, -26793, -28147, -28412, -35528, -6343, 34625, 27738, 28021, 27720, 27540, 27033, 26089, 25525, 24750, 24026, 22930, 22486, 22170, 21856, 21114, 20075, 19072, 18116, 17311, 16507, 15711, 14869, 13607, 12252, 10918, 9572, 8450, 7463, 6456, 5450, 4448, 3449, 2407, 1871, 3009};