/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0013 256 samples */
 
const int16_t AKWF_hdrawn_0013_256_DATA [256] = 
{71, 400, 480, 781, 1446, 1597, 1829, 2076, 2290, 2452, 2546, 2610, 2716, 2903, 3145, 3270, 3455, 3722, 3936, 4654, 5276, 5513, 5821, 6184, 6495, 7374, 8147, 8502, 9051, 10170, 11468, 12757, 14797, 16832, 19772, 22694, 26702, 27805, 28136, 28749, 28868, 28935, 29006, 29146, 29297, 29327, 29364, 29428, 29495, 29602, 29682, 29706, 29768, 29834, 29828, 29897, 29927, 29921, 29922, 29922, 29922, 29922, 29922, 29924, 29913, 29876, 29841, 29826, 29738, 29642, 29605, 29570, 29529, 29486, 29443, 29400, 29359, 29324, 29289, 29114, 28943, 28864, 28805, 28670, 28398, 28133, 27846, 27538, 27179, 26831, 26146, 25591, 25224, 24557, 23772, 23482, 22967, 21914, 21537, 20918, 19090, 17127, 14245, 9925, 7075, 3849, -354, -4438, -7711, -15434, -28890, -30004, -31218, -32013, -32136, -32329, -32582, -32735, -32787, -32564, -32224, -31626, -30647, -27583, -23636, -17314, -13737, -11473, -2541, 11808, 13581, 16809, 19391, 20607, 22151, 23580, 24596, 25419, 26308, 26820, 27076, 27369, 27656, 27946, 28197, 28409, 28625, 28839, 29055, 29270, 29486, 29666, 29825, 29983, 30169, 30311, 30338, 30377, 30441, 30514, 30586, 30657, 30729, 30781, 30822, 30866, 30909, 30952, 30995, 31039, 31081, 31126, 31180, 31234, 31287, 31328, 31363, 31397, 31425, 31452, 31478, 31483, 31482, 31482, 31482, 31482, 31483, 31480, 31457, 31430, 31402, 31390, 31393, 31385, 31321, 31245, 31190, 31157, 31116, 31004, 30871, 30743, 30615, 30467, 30303, 30143, 29981, 29819, 29659, 29496, 29295, 29077, 28862, 28646, 28441, 27950, 27559, 27296, 26984, 26625, 26267, 25908, 25550, 25191, 24832, 24474, 24115, 23758, 23391, 22968, 22533, 22129, 21754, 21380, 20988, 20484, 20039, 19013, 18069, 17654, 16993, 15132, 11393, 7582, 2794, 1884, 1641, 1420, 1188, 519, 178, -4, 3, -6, 44, 96};