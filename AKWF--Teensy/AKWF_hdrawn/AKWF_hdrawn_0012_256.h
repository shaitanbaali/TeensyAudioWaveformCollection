/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0012 256 samples */
 
const int16_t AKWF_hdrawn_0012_256_DATA [256] = 
{-85, 17, -15, 72, 233, 173, 89, 102, 100, 100, 101, 92, 162, 207, 198, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 417, -741, 7116, 13709, 13455, 14696, 15753, 16807, 17702, 18071, 18239, 18753, 19449, 19811, 20203, 20512, 20804, 21093, 21435, 21833, 22218, 22546, 22831, 23322, 23797, 23998, 24270, 24949, 25929, 26575, 26778, 27021, 27320, 27632, 27969, 28365, 28725, 29454, 29944, 29750, 29761, 28975, 28177, 27917, 27620, 27325, 26988, 26633, 26284, 25910, 25494, 25095, 24637, 23540, 22531, 22068, 21600, 21122, 20678, 20074, 18996, 18065, 16777, 15580, 16167, 8398, -1047, 662, 399, 426, 469, 500, 501, 500, 502, 491, 460, 431, 403, 399, 399, 401, 386, 355, 325, 301, 299, 299, 300, 299, 263, 214, 167, 119, 87, 69, 49, 30, 10, -9, -28, -48, -67, -87, -101, -100, -100, -100, -100, -100, -100, -101, -151, 88, -1123, -6210, -8564, -10148, -11802, -13471, -15288, -16884, -18298, -19589, -20707, -21677, -22766, -23131, -23315, -23723, -24447, -24753, -25064, -25634, -25975, -26189, -26428, -26663, -26899, -27127, -27402, -27705, -27957, -28276, -28507, -28742, -28979, -29199, -29376, -29551, -29729, -30009, -30331, -30622, -30856, -31090, -31328, -31549, -31645, -31720, -31799, -31875, -31963, -32146, -32211, -32242, -32301, -32378, -32469, -32622, -32739, -32772, -32766, -32767, -32769, -32754, -32724, -32694, -32669, -32667, -32667, -32669, -32619, -32536, -32465, -32423, -32387, -32326, -32246, -32168, -32088, -32019, -31870, -31687, -31406, -31120, -30634, -29626, -28706, -28441, -28144, -27838, -27453, -27067, -26602, -26048, -25496, -24868, -24288, -23243, -20632, -16563, -11556, -8443, -6426, -5269, -3306, -2499, -2021, -1660, -1435, -1094, -685, -318, -127, -13};