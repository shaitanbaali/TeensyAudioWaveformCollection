/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0022 256 samples */
 
const int16_t AKWF_hdrawn_0022_256_DATA [256] = 
{-187, -255, -321, -331, -318, -46, 414, 697, 878, 1081, 1275, 1545, 1870, 2185, 2506, 2804, 3066, 3331, 3603, 3831, 4301, 4891, 5376, 5987, 6271, 6453, 6655, 6854, 7052, 7251, 7449, 7647, 7846, 8044, 8243, 8441, 8640, 8838, 9037, 9235, 9433, 9633, 9827, 10000, 10169, 10339, 10510, 10679, 10853, 11050, 11249, 11447, 11645, 11846, 12034, 12179, 12320, 12462, 12574, 12836, 12375, 9219, 6283, 6341, 7066, 7367, 7698, 7961, 8187, 8420, 8654, 8878, 9208, 9614, 10007, 10411, 10761, 11022, 11287, 11552, 11815, 12088, 12386, 12683, 12982, 13279, 13579, 13896, 14214, 14531, 14851, 15230, 15632, 16018, 16500, 17104, 17698, 18290, 18898, 19414, 19754, 20104, 20449, 20755, 21051, 21350, 21647, 21945, 22242, 22544, 22872, 23208, 23496, 23743, 23979, 24260, 24941, 24245, 20764, 20024, 20773, 21070, 21281, 21516, 21747, 21982, 22313, 22675, 23030, 23392, 23690, 23941, 24197, 24452, 24708, 24960, 25252, 25574, 25890, 26209, 26519, 26816, 27113, 27413, 27742, 28057, 28505, 28941, 28902, 30296, 25539, -7244, -29856, -32705, -32363, -32263, -32072, -31778, -31649, -31884, -31290, -30188, -29354, -28527, -27679, -27512, -27513, -26978, -26366, -26194, -25894, -25610, -25123, -24557, -24289, -24151, -23882, -23657, -23482, -23311, -23147, -23092, -23029, -23030, -22802, -23769, -25182, -24920, -24843, -24523, -24188, -23877, -23580, -23284, -22976, -22631, -22283, -21935, -21665, -21433, -21193, -20955, -20717, -20479, -20238, -20008, -19730, -19334, -18937, -18540, -18105, -17656, -17217, -16713, -16112, -15520, -15078, -14689, -14294, -13869, -13404, -12942, -12532, -12138, -11739, -11344, -10949, -10163, -9728, -9529, -9053, -8492, -8255, -7983, -7664, -7327, -7026, -6780, -6533, -6279, -5956, -5649, -5134, -4422, -3853, -3522, -3027, -2726, -2415, -2135, -1815, -1565, -958, -587, -142, 38};