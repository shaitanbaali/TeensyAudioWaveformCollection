/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0024 256 samples */
 
const int16_t AKWF_hdrawn_0024_256_DATA [256] = 
{294, 957, 956, 1875, 2825, 3728, 4789, 7074, 8545, 9601, 12139, 14490, 15582, 16857, 18124, 19295, 21316, 24212, 26988, 28509, 29373, 30326, 31261, 32199, 32734, 32771, 32764, 32766, 32773, 32556, 32252, 31819, 30912, 30222, 29612, 28984, 28360, 27736, 27110, 26486, 25862, 25232, 24630, 23673, 22435, 21455, 19288, 15548, 13437, 11248, 9647, 8273, 6883, 5295, 3405, 1539, -127, -1482, -4136, -7429, -8516, -9834, -12324, -15191, -17976, -20851, -22771, -23922, -25251, -27106, -28093, -28466, -28713, -28949, -29177, -29368, -29555, -29742, -29929, -30064, -30177, -30301, -30374, -30370, -30370, -30370, -30370, -30370, -30372, -30362, -30313, -30260, -30208, -30156, -30104, -30049, -30013, -29829, -29464, -29115, -28765, -28414, -28064, -27706, -27470, -27325, -27166, -27008, -26860, -26626, -26312, -25974, -25291, -24527, -23781, -23033, -22264, -21481, -20702, -19921, -19140, -18361, -17579, -16799, -16021, -15233, -14501, -13837, -13166, -12498, -11824, -11178, -10304, -9159, -8040, -6910, -5829, -4887, -3953, -3016, -1907, -733, 460, 1459, 2142, 2856, 3526, 3825, 4046, 4287, 4480, 4635, 4778, 4798, 4794, 4795, 4795, 4788, 4814, 4677, 3997, 3290, 2584, 2209, 1992, 1777, 1386, 674, -32, -709, -1021, -1241, -1476, -1746, -2066, -2364, -2510, -2623, -2739, -2875, -3036, -3179, -3200, -3195, -3196, -3196, -3196, -3198, -3187, -3132, -3073, -3014, -2955, -2893, -2850, -2697, -2339, -1989, -1638, -1288, -935, -589, -183, 291, 758, 1225, 1697, 2141, 2539, 2941, 3343, 3741, 4156, 4462, 4608, 4766, 4921, 5084, 5195, 5193, 5193, 5194, 5194, 5194, 5194, 5194, 5194, 5194, 5194, 5193, 5198, 5154, 5056, 4952, 4907, 4541, 3305, 2051, 853, -312, -1492, -2603, -3544, -4458, -5468, -6704, -6587, -6006, -5452, -4882, -4370, -3432, -2564, -1394, -378, -449};