/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0042 256 samples */
 
const int16_t AKWF_hdrawn_0042_256_DATA [256] = 
{49, 125, 199, 300, 462, 638, 1128, 1266, 1108, 904, 642, 369, 89, -225, -706, -1216, -1629, -1952, -2286, -2619, -2902, -3155, -3411, -3667, -3927, -4194, -4461, -4725, -4972, -5214, -5154, -7129, 3816, 12700, 11556, 12837, 13532, 14612, 15602, 16742, 18064, 18629, 19043, 20047, 21229, 22018, 22651, 23836, 24898, 26023, 26690, 27225, 28108, 29030, 29621, 30504, 31241, 31759, 32533, 32722, 32537, 32490, 32391, 32330, 32169, 32073, 31968, 31902, 31829, 31646, 31483, 31383, 31300, 31208, 31181, 31051, 30882, 30895, 29001, 26725, 25411, 24101, 22387, 20286, 17898, 15283, 12302, 9824, 7756, 5943, 4372, 3264, 274, -1122, -1643, -2509, -3380, -4230, -4997, -5740, -6452, -7100, -7781, -8545, -9209, -9808, -10382, -10920, -11377, -11855, -12398, -13194, -13908, -14429, -15105, -15846, -16483, -16938, -17596, -18935, -20148, -21142, -22092, -23547, -24690, -26488, -27653, -28609, -29890, -30307, -29839, -29413, -28998, -28678, -28372, -28066, -27776, -27489, -27201, -26915, -26618, -26211, -25772, -25361, -24986, -24608, -24232, -23883, -23538, -23192, -22849, -22473, -22078, -21687, -21293, -20907, -20576, -20253, -19929, -19607, -19280, -18905, -18515, -18128, -17735, -17415, -17150, -16886, -16581, -16151, -15719, -15288, -14856, -14426, -13993, -13510, -12998, -12529, -12158, -11790, -11417, -11039, -10663, -10282, -9797, -9272, -8813, -8386, -7953, -7521, -7090, -6661, -6153, -5613, -5105, -4615, -3999, -3229, -2629, -2105, -1498, -650, -63, 508, 1191, 1914, 2640, 3404, 4109, 5024, 6024, 6606, 7009, 7192, 7584, 7772, 7936, 7629, 7207, 7076, 6785, 6400, 6055, 5569, 5161, 4880, 4647, 4419, 4417, 4420, 4407, 4369, 4334, 4285, 4231, 4176, 4126, 4084, 4038, 3981, 3957, 3939, 3851, 3768, 3719, 3613, 3517, 3374, 3229, 3147, 3046, 2775, 2256, 1864, 1743, 1071};