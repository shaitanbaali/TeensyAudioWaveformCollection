/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0038 256 samples */
 
const int16_t AKWF_hdrawn_0038_256_DATA [256] = 
{841, 1141, 1840, 2771, 2947, 3198, 4637, 5933, 7387, 8811, 9654, 11249, 12825, 14033, 15286, 16150, 16968, 17604, 18181, 18376, 18560, 18876, 18485, 18122, 18862, 19507, 19831, 20249, 20445, 20405, 20412, 20412, 20412, 20412, 20412, 20412, 20412, 20412, 20412, 20412, 20420, 20376, 20590, 20987, 20940, 20956, 20827, 20578, 20509, 19861, 18760, 18283, 17167, 16039, 14948, 13633, 12551, 11721, 10906, 10708, 9976, 10699, 12905, 15287, 18594, 20460, 21661, 22165, 22560, 22558, 22707, 22935, 23095, 23099, 23098, 23100, 23092, 23168, 23333, 23494, 23627, 23637, 23634, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23635, 23636, 23483, 23260, 23073, 22946, 22822, 22693, 22576, 22559, 22553, 22586, 22394, 21710, 20331, 18604, 18220, 18278, 18264, 18264, 17812, 20241, 6106, -21072, -23477, -26231, -27419, -28553, -29320, -29710, -30357, -30658, -31275, -31711, -31907, -32265, -32198, -32348, -32790, -32763, -32767, -32767, -32754, -32815, -32148, -30850, -29219, -27269, -22622, -11328, -4752, -777, 2378, 2686, 2658, 2727, 2003, 1089, 27, -2306, -4656, -6392, -9415, -15709, -18470, -20112, -21723, -22801, -23542, -24177, -24242, -24412, -24561, -24759, -25162, -25596, -25903, -26106, -26300, -26325, -26320, -26321, -26321, -26321, -26321, -26321, -26321, -26321, -26321, -26321, -26323, -26315, -26368, -26529, -26688, -26837, -26863, -26858, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26859, -26857, -26867, -26753, -26527, -26341, -26318, -26321, -26327, -26237, -26066, -25930, -25662, -25083, -24383, -22854, -21640, -19943, -18562, -17165, -15774, -15004, -14039, -13069, -12302, -12048, -11794, -11552, -11247, -10395, -9431, -8478, -7714, -6122, -4240, -4169, -2911, -1094, 417};