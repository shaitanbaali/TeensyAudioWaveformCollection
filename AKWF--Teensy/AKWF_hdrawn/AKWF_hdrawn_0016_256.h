/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0016 256 samples */
 
const int16_t AKWF_hdrawn_0016_256_DATA [256] = 
{7577, 13986, 12791, 13014, 13005, 12986, 12968, 12950, 12932, 12913, 12895, 12877, 12859, 12840, 12823, 12809, 12795, 12782, 12768, 12754, 12740, 12725, 12707, 12688, 12671, 12651, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12639, 12638, 12646, 12673, 12701, 12728, 12755, 12782, 12811, 12831, 12840, 12850, 12860, 12870, 12880, 12889, 12900, 12910, 12920, 12930, 12940, 12950, 12959, 12970, 12979, 12989, 13000, 13009, 13020, 13031, 13042, 13053, 13064, 13075, 13086, 13097, 13111, 13137, 13165, 13192, 13220, 13247, 13275, 13298, 13310, 13322, 13334, 13346, 13358, 13370, 13383, 13394, 13405, 13416, 13427, 13438, 13449, 13460, 13471, 13482, 13493, 13504, 13515, 13526, 13536, 13548, 13558, 13570, 13582, 13596, 13610, 13623, 13637, 13691, 13479, 14446, 18525, 18432, 18435, 18473, 18550, 18685, 18470, 19873, 30934, 30837, 34359, 18058, -35125, -32296, -32744, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32734, -32917, -32024, -30367, -30556, -30521, -30521, -30521, -30521, -30522, -30518, -30565, -30498, -31139, -32868, -32565, -32463, -32337, -32153, -31929, -31711, -31490, -31270, -31055, -30531, -29797, -28867, -22563, -18839, -18113, -17875, -17889, -17883, -18041, -18744, -20074, -21065, -22232, -24109, -25664, -27100, -28413, -29945, -31208, -31986, -32308, -32478, -32568, -32646, -32680, -32673, -32408, -33957, -27774, 480, 62, 85, 151, 179, 188, 186, 187, 187, 187, 187, 187, 187, 187, 187, 187, 187, 187, 186, 189, 200, 211, 222, 233, 243, 255, 265, 277, 280, 279, 280, 280, 280, 280};