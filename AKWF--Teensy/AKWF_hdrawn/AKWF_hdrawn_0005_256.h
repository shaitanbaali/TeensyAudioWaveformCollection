/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0005 256 samples */
 
const int16_t AKWF_hdrawn_0005_256_DATA [256] = 
{232, 2479, 5630, 9001, 11610, 13024, 14113, 15395, 16102, 16396, 16759, 17176, 17542, 18386, 19154, 19517, 19929, 20276, 20623, 20941, 21163, 21665, 22555, 22786, 23069, 23343, 23623, 23874, 24050, 24374, 25112, 25301, 25542, 26181, 26476, 26643, 26992, 27483, 27570, 27612, 28013, 28413, 28668, 28931, 29138, 29348, 29472, 29522, 29650, 29864, 30071, 30179, 30281, 30331, 30363, 30398, 30433, 30465, 30548, 30639, 30715, 30828, 30841, 30867, 30893, 30919, 30952, 30989, 31008, 31006, 31006, 31006, 31006, 31006, 31006, 31006, 31006, 31006, 31006, 31006, 31007, 30986, 30948, 30920, 30917, 30921, 30885, 30812, 30746, 30702, 30661, 30619, 30580, 30461, 30302, 30145, 30015, 29949, 29884, 29445, 29135, 28950, 28739, 28533, 28326, 28121, 27906, 27632, 27372, 26932, 26193, 25388, 24458, 23394, 21971, 21147, 20011, 19107, 17664, 15903, 13880, 10960, 7757, 5171, 2545, -357, -2961, -5705, -8638, -9957, -11314, -12596, -13792, -15339, -16928, -18329, -19523, -20315, -20715, -21131, -21550, -21939, -22479, -23127, -23447, -23823, -24616, -25596, -25948, -26190, -26813, -27192, -27428, -27894, -28510, -29231, -29825, -30263, -30636, -30899, -31141, -31293, -31447, -31607, -31788, -31931, -32092, -32246, -32429, -32568, -32671, -32705, -32769, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32740, -32708, -32650, -32575, -32544, -32509, -32474, -32442, -32396, -32327, -32258, -32213, -32180, -32147, -32121, -32095, -32070, -32011, -31947, -31846, -31642, -31430, -31305, -31264, -31094, -30615, -30399, -30197, -29989, -29783, -29576, -29370, -29163, -28957, -28747, -28558, -28259, -27759, -27484, -27210, -26934, -26659, -26383, -26101, -25858, -25140, -24197, -23256, -22025, -20414, -18711, -16210, -14482, -12914, -11668, -10141, -8906, -7702, -6228, -5295, -4456, -3460, -3029, -2460, -2157, -1953, -1628, -1351, -1116, -888, -616, -238};