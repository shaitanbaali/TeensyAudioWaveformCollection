/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0002 256 samples */
 
const int16_t AKWF_hdrawn_0002_256_DATA [256] = 
{-386, -262, 329, 477, 579, 905, 1553, 1828, 2113, 2304, 2408, 2719, 3560, 4439, 4894, 5072, 5298, 5479, 5565, 5650, 5734, 5826, 5985, 6159, 6329, 6499, 6670, 6841, 7019, 7150, 7624, 8440, 8775, 8871, 8981, 9088, 9194, 9303, 9404, 9560, 9779, 9989, 10212, 10487, 10788, 10933, 10919, 10920, 10933, 11013, 11100, 11184, 11270, 11400, 11543, 11685, 11828, 11970, 12089, 12194, 12301, 12408, 12514, 12621, 12729, 12864, 13007, 13150, 13291, 13434, 13576, 13718, 13861, 14003, 14144, 14288, 14429, 14571, 14715, 14855, 15011, 15183, 15358, 15512, 15775, 16288, 16797, 17316, 17799, 18011, 18173, 18346, 18517, 18688, 18858, 19034, 19180, 19557, 20218, 20854, 21493, 22133, 22771, 23427, 23813, 24010, 24201, 24565, 25407, 26286, 26699, 26799, 26971, 27246, 27533, 27816, 28103, 28376, 28541, 28661, 28933, 29218, 29343, 29489, 29632, 29767, 29969, 30267, 30514, 30697, 31261, 31385, 31674, 31705, 30831, 37428, 2081, -37966, -31566, -32789, -32556, -32277, -31854, -31586, -31130, -30720, -30664, -31006, -30886, -30806, -30719, -30641, -30503, -30285, -30072, -29860, -29646, -29433, -29219, -29006, -28792, -28582, -28349, -28041, -27730, -27420, -27110, -26800, -26490, -26179, -25869, -25559, -25225, -24883, -24542, -24200, -23860, -23518, -23177, -22833, -22507, -22223, -21939, -21654, -21369, -21085, -20799, -20521, -20159, -19724, -19299, -18873, -18446, -18020, -17592, -17239, -16925, -16604, -16284, -15963, -15645, -15316, -14858, -14364, -13877, -13392, -12899, -12434, -12258, -12147, -12022, -11900, -11779, -11653, -11489, -11317, -11146, -10978, -10726, -10457, -10069, -9243, -8355, -7863, -7680, -7471, -7196, -6692, -6180, -5665, -5166, -4900, -4699, -4476, -4324, -4244, -4157, -4077, -3960, -3747, -3534, -3321, -3189, -3083, -2990, -2831, -2471, -2081, -1676, -977, -375, -122, 316, 395, 109, -328};