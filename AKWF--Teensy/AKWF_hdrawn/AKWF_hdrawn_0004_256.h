/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0004 256 samples */
 
const int16_t AKWF_hdrawn_0004_256_DATA [256] = 
{39, 4305, 7628, 10857, 20473, 25255, 27611, 29093, 29746, 30356, 30809, 30985, 31275, 31523, 31773, 31912, 32044, 32163, 32224, 32286, 32391, 32424, 32456, 32513, 32519, 32555, 32584, 32604, 32672, 32679, 32677, 32677, 32678, 32677, 32681, 32700, 32720, 32740, 32759, 32764, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32763, 32763, 32754, 32729, 32704, 32681, 32677, 32678, 32677, 32677, 32677, 32677, 32677, 32677, 32677, 32678, 32657, 32621, 32594, 32592, 32593, 32592, 32592, 32592, 32592, 32592, 32592, 32593, 32592, 32566, 32530, 32508, 32509, 32509, 32508, 32495, 32478, 32461, 32445, 32428, 32424, 32425, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32424, 32427, 32376, 32306, 32241, 32209, 32182, 32127, 32086, 31939, 31631, 30923, 29634, 30957, 1946, -32515, -30213, -31285, -31411, -31482, -31500, -31549, -31623, -31668, -31722, -31762, -31824, -31859, -31929, -31995, -32016, -32083, -32090, -32088, -32087, -32097, -32131, -32164, -32196, -32229, -32262, -32295, -32329, -32342, -32363, -32399, -32424, -32425, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32424, -32425, -32423, -32402, -32377, -32351, -32340, -32341, -32341, -32340, -32340, -32340, -32340, -32340, -32340, -32340, -32340, -32340, -32340, -32340, -32339, -32345, -32307, -32258, -32223, -32149, -32094, -32048, -32004, -31976, -31847, -31782, -31749, -31745, -31672, -31657, -31557, -31504, -31456, -30996, -31084, -21447, -15600, -13270, -11501, -10025, -7863, -4796, -2250, -1648, -420};