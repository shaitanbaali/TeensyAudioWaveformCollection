/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0015 256 samples */
 
const int16_t AKWF_hdrawn_0015_256_DATA [256] = 
{398, 18, -83, 175, 254, 414, 446, 606, 707, 856, 893, 972, 1094, 1459, 1510, 1484, 1621, 1722, 1738, 1827, 1911, 1996, 2069, 2212, 2364, 2352, 2346, 2603, 2542, 1921, 774, 117, -352, -860, -1369, -1837, -2494, -3691, -4236, -4725, -5230, -5823, -6458, -7073, -7775, -8617, -9453, -10167, -10824, -11517, -12271, -13022, -13776, -14595, -15426, -16309, -17313, -18325, -19063, -19644, -20252, -20849, -21495, -22201, -22903, -23612, -24273, -24781, -25281, -25783, -26288, -26779, -27204, -27622, -28040, -28459, -28875, -29257, -29633, -30010, -30386, -30761, -31145, -31481, -31622, -31744, -31871, -31980, -32079, -32180, -32280, -32381, -32480, -32581, -32684, -32765, -32768, -32767, -32766, -32774, -32699, -32524, -32359, -32187, -32038, -31754, -31243, -30743, -30241, -29738, -29245, -28680, -28007, -27337, -26523, -25778, -24397, -22585, -22089, -20982, -17819, -16799, -15802, -14661, -13493, -12271, -10931, -9594, -8252, -6921, -5549, -4053, -2513, -1496, -870, -193, 479, 1137, 1916, 2832, 3730, 4647, 5470, 6046, 6618, 7193, 7767, 8340, 8914, 9488, 10061, 10635, 11208, 11785, 12338, 12840, 13341, 13844, 14345, 14850, 15327, 15743, 16161, 16580, 17001, 17401, 17738, 18072, 18405, 18747, 19048, 19151, 19231, 19316, 19399, 19485, 19605, 19731, 19859, 19953, 20012, 20077, 20129, 20132, 20131, 20131, 20130, 20127, 19991, 19385, 18470, 17596, 16890, 16276, 15640, 15052, 14554, 14051, 13551, 13034, 12417, 11789, 11154, 10678, 10317, 9929, 9603, 9432, 9277, 8897, 8377, 7881, 7378, 6876, 6375, 5872, 5371, 4865, 4392, 3990, 3589, 3189, 2778, 2287, 1785, 1270, 959, 813, 622, 434, 255, 118, 26, -76, -177, -243, -281, -324, -365, -409, -430, -428, -428, -428, -431, -406, -340, -279, -214, -135, -46, 4, -23, 76, -718, -2134};