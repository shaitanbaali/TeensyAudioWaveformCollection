/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0046 256 samples */
 
const int16_t AKWF_hdrawn_0046_256_DATA [256] = 
{2399, 5572, 8320, 10771, 12949, 14887, 16613, 18139, 19492, 20695, 21761, 22711, 23556, 24304, 24971, 25570, 26080, 26696, 28611, 31524, 28746, 23017, 21081, 18603, 16509, 14646, 12986, 11512, 10204, 9038, 8003, 7085, 6268, 5545, 4905, 4336, 3833, 3387, 2993, 2646, 2339, 2069, 1832, 1622, 1439, 1279, 1137, 1010, 894, 818, 617, 242, 201, 179, 182, 182, 182, 182, 182, 181, 180, 184, -72, -543, -1106, -1732, -2375, -3009, -3710, -4463, -5366, -6538, -7677, -8075, -8082, -8142, -8200, -8254, -8285, -8281, -8281, -8281, -8281, -8281, -8281, -8281, -8281, -8281, -8281, -8281, -8281, -8277, -8242, -8426, -5286, -1148, 154, -49, 0, 0, -1, 205, -936, 4397, 14954, 13805, 14014, 14014, 14014, 13788, 15015, 5157, -781, 323, 64, -4, -56, -126, -157, -40, -313, -1623, -2572, -3581, -4612, -5438, -6154, -6890, -7539, -8142, -8750, -9470, -10250, -10941, -11576, -12212, -12876, -13622, -14368, -15114, -15993, -16919, -17867, -18891, -19913, -20937, -21990, -22917, -24763, -27265, -29408, -30849, -32429, -32594, -31492, -30449, -29787, -29177, -28564, -27817, -27035, -26024, -24976, -24028, -23125, -22458, -21822, -21187, -20457, -19656, -18864, -18109, -17380, -16651, -15888, -15100, -14334, -13646, -12962, -12214, -11527, -11021, -10483, -9806, -9129, -8522, -7930, -7466, -7036, -6665, -5664, -4854, -4334, -3765, -3168, -2335, -1861, -1111, -512, 213, 1726, 3809, 5660, 6704, 8230, 9246, 9876, 11985, 8216, -1085, -107, -270, -273, -273, -273, -273, -273, -273, -273, -273, -273, -273, -273, -273, -273, -273, -273, -274, -273, -276, -286, -297, -307, -318, -329, -339, -350, -361, -365, -364, -364, -364, -364, -364, -364, -364, -364, -364, -364, -364, -364, -365, -354, -331, -310, -288};