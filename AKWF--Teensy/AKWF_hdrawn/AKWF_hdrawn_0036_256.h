/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0036 256 samples */
 
const int16_t AKWF_hdrawn_0036_256_DATA [256] = 
{429, -127, 208, 294, -418, -374, -482, 240, 1147, -344, 4, 588, 1136, 1690, 2245, 2818, 3397, 3976, 4554, 5132, 5710, 6291, 6903, 7522, 8138, 8754, 9372, 9989, 10604, 11231, 11878, 12526, 13175, 13821, 14469, 15118, 15765, 16413, 16996, 17545, 18102, 18658, 19213, 19767, 20324, 20875, 21446, 22056, 22709, 23260, 23440, 24099, 24488, 24476, 24473, 24574, 24741, 24866, 24873, 24872, 24872, 24874, 24862, 24759, 24639, 24529, 24348, 24111, 23878, 23663, 23507, 23352, 23221, 23099, 23017, 22711, 21791, 20634, 20849, 13666, -6798, -9158, -10650, -11498, -12493, -13057, -13020, -13031, -13211, -13451, -13683, -13895, -14077, -14262, -14454, -14602, -14608, -14607, -14607, -14607, -14607, -14608, -14605, -14619, -14725, -14843, -14962, -15002, -15018, -14799, -14288, -13597, -12948, -12173, -11303, -10497, -9810, -9486, -9187, -8772, -7927, -7067, -6583, -6147, -5430, -4480, -3562, -2626, -2114, -1888, -1305, -299, 1077, 2153, 3045, 3993, 4635, 5426, 6189, 6635, 7021, 7682, 7892, 8046, 8611, 8437, 8469, 8576, 8666, 8688, 8684, 8685, 8685, 8685, 8685, 8685, 8682, 8686, 8665, 8138, 6843, 6091, 5605, 5208, 4932, -27227, -33450, -31382, -31417, -30970, -30265, -29576, -28871, -27973, -27097, -26404, -25710, -25018, -24615, -24323, -24008, -23702, -23388, -22359, -21064, -20007, -19112, -18173, -17291, -16585, -15901, -15186, -13968, -13069, -12706, -12429, -11943, -11233, -10533, -9887, -9539, -9272, -8659, -7757, -7066, -6375, -5679, -4813, -3883, -2935, -2119, -1518, -580, 387, 826, 778, 794, 766, 925, 1200, 1180, 1183, 1184, 1184, 1184, 1183, 1184, 1178, 1054, 887, 786, 789, 788, 790, 778, 693, 598, 507, 414, 333, 257, 179, 103, 23, -4, 0, 0, 0, 0, -3, 10, -44, -394, -259, 19, -4};