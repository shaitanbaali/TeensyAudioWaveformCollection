/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0050 256 samples */
 
const int16_t AKWF_hdrawn_0050_256_DATA [256] = 
{31487, 31484, 31570, 31666, 31677, 31626, 31597, 31684, 31341, 33086, 11773, -1344, 33, -94, -470, 1406, 3951, 3683, 3730, 3731, 3731, 3731, 3728, 3728, 3874, 3707, -76, -444, -363, -421, -454, -479, -503, -527, -550, -573, -598, -620, -654, -708, -761, -814, -868, -921, -974, -1028, -1081, -1135, -1183, -1205, -1224, -1243, -1262, -1282, -1301, -1321, -1340, -1360, -1374, -1385, -1397, -1409, -1422, -1433, -1445, -1456, -1457, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1456, -1457, -1456, -1435, -1407, -1380, -1365, -1366, -1366, -1365, -1367, -1353, -1310, -1266, -1210, -1182, -1184, -1183, -1185, -1176, -1141, -1105, -1073, -1043, -1012, -1000, -1002, -1002, -980, -941, -912, -910, -911, -910, -910, -910, -910, -910, -910, -910, -910, -910, -911, -915, -894, -732, -9478, -23072, -32497, -32589, -32543, -32578, -32578, -32579, -32575, -32594, -32750, -32772, -32766, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32759, -32748, -32527, -31638, -9601, 1058, -237, -12, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 18, 50, 81, 111, 141, 172, 194, 211, 229, 247, 265, 273, 272, 273, 273, 273, 273, 273, 272, 281, 304, 325, 347, 363, 364, 363, 364, 364, 364, 364, 364, 364, 364, 364, 363, 364, 361, 335, 303, 275, 272, 273, 273, 273, 273, 273, 273, 273, 273, 273, 273, 273, 272, 273, 270, 248, 224, 199, 182, 181, 182, 182, 182, 181, 182, 173, 149, 125, 101, 79, 58, 36, 14, -1, 0, 0};