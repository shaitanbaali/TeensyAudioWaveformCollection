/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0014 256 samples */
 
const int16_t AKWF_hdrawn_0014_256_DATA [256] = 
{-140, 257, 1397, 4576, 8014, 8991, 10295, 13302, 15911, 16839, 17761, 18520, 19146, 19794, 20412, 20956, 21498, 22041, 22473, 22860, 23257, 23654, 24040, 24611, 25266, 26014, 26786, 27515, 28620, 29860, 31419, 32626, 32692, 32674, 32738, 32772, 32766, 32620, 33286, 27436, 14004, 1917, -5058, -20575, -25410, -26935, -28487, -29514, -29989, -30394, -30662, -30837, -31094, -31279, -31365, -31494, -31607, -31732, -31835, -31878, -31982, -32012, -32021, -32057, -32090, -32122, -32157, -32179, -32178, -32178, -32178, -32178, -32178, -32178, -32178, -32178, -32178, -32178, -32178, -32180, -32171, -32045, -31908, -31882, -31847, -31726, -31573, -31425, -31283, -31153, -31021, -30888, -30761, -30609, -30410, -30213, -30016, -29818, -29621, -29423, -29226, -29030, -28692, -28290, -27890, -27541, -27281, -27017, -26755, -26487, -26250, -26091, -25933, -25778, -25607, -25516, -25526, -25522, -25543, -25584, -25623, -25664, -25698, -25717, -25737, -25755, -25785, -25892, -26013, -26131, -26250, -26313, -26349, -26390, -26429, -26473, -26522, -26572, -26621, -26670, -26720, -26771, -26790, -26787, -26787, -26787, -26787, -26788, -26787, -26757, -26716, -26674, -26641, -26539, -26374, -26218, -26057, -25921, -25837, -25753, -25668, -25584, -25496, -25433, -25414, -25415, -25276, -26740, -27256, -27023, -26862, -26680, -26561, -26443, -26326, -26199, -25972, -25722, -25473, -25252, -25057, -24860, -24655, -24410, -24162, -23917, -23637, -23339, -23042, -22760, -22513, -22268, -22014, -21597, -21123, -20701, -20352, -20030, -19590, -18213, -17453, -16975, -15617, -13426, -10571, -6981, -4134, -533, 2517, 3478, 3986, 4634, 5283, 5992, 7537, 9002, 9587, 10149, 11532, 13196, 14573, 15565, 16081, 16613, 16983, 17267, 17566, 17862, 18158, 18454, 18752, 19073, 19411, 19694, 19887, 20086, 20281, 20382, 20385, 20385, 20384, 20388, 20356, 20201, 20002, 19791, 19151, 18532, 16882, 15098, 12339, 8788, 6243, 2710, 749, 112};