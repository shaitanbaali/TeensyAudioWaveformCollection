/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0047 256 samples */
 
const int16_t AKWF_hdrawn_0047_256_DATA [256] = 
{32752, 32673, 32598, 32428, 32247, 31967, 31854, 31783, 31334, 31035, 30884, 30347, 28787, 27703, 27168, 26559, 25723, 24979, 24337, 23598, 22503, 21659, 19880, 18697, 18019, 17438, 16876, 16269, 15632, 14869, 14134, 13435, 12763, 12151, 11561, 11046, 10543, 9974, 9361, 8716, 7996, 7410, 7045, 6672, 6275, 5837, 5402, 4965, 4529, 4092, 3657, 3214, 2621, 2101, 1545, 1101, 664, 243, -111, -807, -1683, -2413, -3067, -3721, -4377, -5031, -5686, -6341, -6994, -7656, -8325, -8991, -9659, -10327, -10993, -11664, -12305, -12894, -13487, -14080, -14670, -15269, -15816, -16284, -16758, -17231, -17705, -18168, -18604, -19039, -19477, -19913, -20349, -20786, -21220, -21660, -22086, -22267, -22375, -22494, -22620, -22705, -22672, -22635, -22598, -22565, -22511, -22342, -22159, -21980, -21801, -21621, -21442, -21262, -21053, -20833, -20616, -20397, -20179, -19961, -19742, -19527, -19290, -19007, -18725, -18442, -18160, -17876, -17601, -17282, -16698, -16072, -15456, -14839, -14215, -13508, -12777, -12050, -11324, -10596, -9797, -8971, -8142, -7342, -6848, -6425, -5980, -5567, -5268, -4979, -4688, -4395, -4112, -3900, -3701, -3498, -3299, -3088, -2965, -2957, -2938, -2922, -2904, -2895, -3070, -3297, -3517, -3716, -4220, -4945, -5640, -6320, -7150, -8227, -9289, -10369, -11308, -12174, -12874, -13406, -13832, -14159, -14648, -15268, -15907, -16627, -17213, -17518, -17841, -18082, -18151, -18226, -18248, -18244, -18248, -18230, -18174, -18121, -18061, -17908, -17729, -17555, -17382, -17196, -17000, -16807, -16613, -16401, -16181, -15965, -15737, -15494, -15250, -15014, -14699, -14310, -13930, -13547, -13159, -12772, -12382, -12008, -11670, -11330, -10993, -10634, -10251, -9870, -9482, -9051, -8614, -8175, -7790, -7446, -7096, -6749, -6385, -5997, -5607, -5225, -4778, -4261, -3758, -3316, -2864, -2555, -2458, -2350, -2224, -1913, -1639, -1472, -1064, -651, -334, 61};