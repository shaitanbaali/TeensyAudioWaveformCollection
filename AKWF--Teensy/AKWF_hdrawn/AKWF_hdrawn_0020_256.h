/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0020 256 samples */
 
const int16_t AKWF_hdrawn_0020_256_DATA [256] = 
{-195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -195, -196, -195, -183, -165, -149, -133, -116, -100, -79, -55, -33, -10, 21, 58, 107, 236, 376, 512, 650, 783, 914, 1044, 1175, 1306, 1438, 1593, 1758, 1922, 2086, 2249, 2413, 2561, 2703, 2847, 2990, 3133, 3276, 3422, 3590, 3763, 3935, 4107, 4279, 4451, 4619, 4773, 4926, 5078, 5231, 5384, 5537, 5690, 5843, 5995, 6152, 6369, 6601, 6830, 7058, 7288, 7517, 7747, 7976, 8205, 8434, 8663, 8893, 9122, 9352, 9581, 9810, 10039, 10268, 10498, 10727, 10956, 11185, 11415, 11644, 11873, 12103, 12331, 12561, 12790, 13020, 13249, 13478, 13707, 13936, 14166, 14395, 14625, 14854, 15083, 15312, 15541, 15771, 16000, 16229, 16458, 16688, 16917, 17146, 17377, 17592, 17787, 17984, 18180, 18377, 18574, 18760, 18931, 19103, 19275, 19447, 19619, 19790, 19979, 20181, 20382, 20583, 20783, 20983, 21184, 21342, 21482, 21626, 21769, 21913, 22055, 22205, 22423, 22655, 22883, 23113, 23340, 23491, 23619, 23751, 23881, 24012, 24145, 24319, 24504, 24687, 24871, 25047, 25219, 25389, 25574, 25803, 26032, 26262, 26448, 26618, 26788, 26981, 27212, 27442, 27667, 27846, 28018, 28187, 28389, 28624, 28837, 28914, 28969, 29022, 29144, 29321, 29493, 29658, 29797, 29934, 30071, 30211, 30376, 30550, 30719, 30917, 31152, 31369, 31430, 31454, 31473, 31607, 31750, 31816, 31894, 31971, 32047, 32123, 32201, 32274, 32317, 32352, 32406, 32485, 32561, 32305, 33844, 24998, -6032, -28773, -29880, -30319, -30903, -31111, -31153, -31208, -31201, -31203, -31110, -30996, -30800, -30578, -30205, -29992, -28327, -23555, -18943, -15234, -11050, -7866, -5312, -4085, -2329, -1257, -599, 164, 208, 63, 20};