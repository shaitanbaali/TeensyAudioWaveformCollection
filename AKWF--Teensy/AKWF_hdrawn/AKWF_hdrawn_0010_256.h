/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0010 256 samples */
 
const int16_t AKWF_hdrawn_0010_256_DATA [256] = 
{-75, 15, -14, 66, 195, 212, 239, 266, 306, 348, 390, 431, 468, 501, 536, 571, 606, 628, 641, 656, 671, 686, 701, 706, 705, 706, 706, 706, 706, 706, 706, 706, 706, 706, 706, 706, 706, 705, 706, 697, 675, 655, 633, 618, 618, 618, 618, 618, 618, 618, 618, 618, 617, 618, 631, 646, 661, 676, 690, 705, 722, 740, 757, 774, 791, 794, 793, 794, 794, 793, 794, 807, 822, 837, 852, 866, 881, 896, 911, 925, 940, 955, 969, 971, 970, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 971, 962, 950, 939, 927, 916, 904, 893, 882, 871, 861, 850, 840, 830, 819, 809, 799, 782, 759, 736, 713, 690, 666, 644, 619, 565, 501, 440, 377, 316, 253, 192, 128, 77, 48, 19, -10, -40, -69, -101, -135, -169, -204, -238, -277, -330, -353, -298, -1316, 24526, 33183, 31793, 32157, 32257, 32326, 32395, 32464, 32534, 32593, 32616, 32636, 32657, 32677, 32680, 32679, 32679, 32679, 32679, 32679, 32679, 32679, 32681, 32660, 32618, 32576, 32534, 32500, 32485, 32470, 32455, 32440, 32426, 32411, 32396, 32381, 32366, 32352, 31774, 34768, 20778, -22628, -24901, -29106, -31620, -32432, -32601, -32585, -32591, -32591, -32591, -32591, -32592, -32592, -32590, -32607, -32644, -32675, -32680, -32679, -32679, -32679, -32680, -32679, -32683, -32703, -32723, -32744, -32764, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32772, -32699, -32681, -32625, -32588, -32584, -32505, -32502, -32507, -32489, -32378, -32321, -32327, -32329, -32314, -32196, -32224, -31586, -19639, -12157, -10712, -6508, -1682};