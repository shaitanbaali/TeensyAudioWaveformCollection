/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0011 256 samples */
 
const int16_t AKWF_hdrawn_0011_256_DATA [256] = 
{-75, 15, -14, 66, 195, 212, 239, 266, 306, 348, 390, 431, 468, 501, 536, 571, 606, 628, 641, 656, 671, 686, 701, 706, 705, 706, 706, 706, 706, 1061, -851, 9402, 22720, 21126, 19790, 1729, 418, 782, 706, 697, 675, 655, 633, 618, 618, 618, 618, 618, 618, 618, 618, 618, 617, 618, 631, 646, 661, 676, 690, 705, 722, 740, 757, 774, 694, 1216, -1599, -5111, -4536, 33, 980, 765, 822, 837, 852, 866, 881, 896, 911, 925, 940, 955, 969, 971, 970, 971, 971, 971, 971, 971, 971, 971, 971, 971, 988, 889, 1299, 3061, 1274, 894, 987, 971, 971, 971, 971, 962, 950, 939, 927, 914, 912, 854, 626, 439, -315, -1252, -1767, -2245, -2696, -3093, -3562, -4241, -4293, -4223, -3909, -3231, -2296, -1548, -1044, -770, -394, 230, 553, 825, 891, 879, 885, 861, 789, 723, 546, 183, -293, -468, -701, -763, -813, -866, -918, -969, -1020, -1074, -879, -2343, 3468, 32256, 32177, 32211, 32326, 32395, 32464, 32534, 32593, 32616, 32636, 32657, 32677, 32680, 32679, 32538, 33287, 30334, 8150, 7299, 7576, 7739, 6893, 10383, 32256, 32659, 32446, 32485, 32470, 32455, 32440, 32426, 32411, 32396, 32381, 32366, 32352, 31774, 34768, 20778, -22628, -24901, -29106, -31620, -32432, -32601, -32585, -32591, -32591, -32591, -32591, -32592, -32592, -32590, -32607, -32644, -32675, -32680, -32679, -32679, -32679, -32680, -32574, -33157, -30760, -18908, -18998, -19043, -18751, -30525, -33303, -32651, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32772, -32699, -32681, -32625, -32588, -32584, -32505, -32502, -32507, -32489, -32378, -32321, -32327, -32329, -32314, -32196, -32224, -31586, -19639, -12157, -10712, -6508, -1682};