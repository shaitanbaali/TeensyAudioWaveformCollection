/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0007 256 samples */
 
const int16_t AKWF_hdrawn_0007_256_DATA [256] = 
{95, 3046, 6981, 9120, 12519, 16342, 20167, 22734, 28933, 33058, 32483, 32595, 32597, 32596, 32602, 32627, 32652, 32678, 32703, 32728, 32754, 32768, 32767, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 31807, 37075, 11311, -36553, -31077, -32006, -31994, -32004, -31967, -31906, -31914, -31911, -31918, -31873, -31822, -31828, -31827, -31826, -31826, -31828, -31756, -31738, -31742, -31741, -31741, -31741, -31741, -31741, -31742, -31742, -31674, -31652, -31656, -31655, -31655, -31655, -31655, -31655, -31655, -31655, -31655, -31655, -31655, -31657, -31650, -31713, -31748, -31735, -31799, -31832, -31825, -31827, -31823, -31840, -31912, -31984, -32114, -32172, -32245, -32221, -32228, -32272, -32295, -32320, -32345, -32370, -32395, -32420, -32426, -32425, -32426, -32425, -32433, -32451, -32468, -32484, -32501, -32517, -32531, -32546, -32560, -32574, -32589, -32597, -32596, -32596, -32596, -32596, -32596, -32596, -32596, -32596, -32596, -32596, -32597, -32597, -32597, -32608, -32622, -32636, -32650, -32665, -32679, -32683, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32682, -32683, -32683, -32682, -32692, -32709, -32726, -32742, -32760, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32764, -32734, -32698, -32683, -32675, -32599, -32596, -32597, -32596, -32599, -32536, -32512, -32487, -32375, -32335, -32336, -32123, -33303, -20497, -9561, -8157, -4947, -2683, -1104, -65};