/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0026 256 samples */
 
const int16_t AKWF_hdrawn_0026_256_DATA [256] = 
{32333, 21589, 32476, 32545, 32713, 32774, 32766, 32768, 32768, 32768, 32597, 33388, 30106, 3181, -723, 188, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, 9, 45, 82, 119, 156, 193, 230, 266, 303, 340, 376, 411, 445, 479, 512, 547, 581, 615, 648, 682, 716, 752, 804, 859, 914, 970, 1025, 1081, 1127, 1129, 1128, 1129, 1129, 1129, 1128, 1153, 1192, 1229, 1265, 1302, 1339, 1376, 1412, 1449, 1488, 1507, 1505, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1505, 1505, 1508, 1464, 1386, 1313, 1240, 1165, 1101, 1047, 992, 937, 881, 826, 770, 750, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 753, 752, 755, 734, 677, 623, 567, 512, 458, 400, 373, 376, 376, 375, 375, 379, 330, 237, 151, 59, -30, -219, 1059, -16087, -31119, -29452, -29747, -29754, -29754, -29754, -29754, -29754, -29754, -29754, -29724, -29814, -29285, -24792, -17036, 342, 1958, 1312, 1350, 1258, 1170, 1081, 993, 904, 819, 713, 565, 416};