/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0048 256 samples */
 
const int16_t AKWF_hdrawn_0048_256_DATA [256] = 
{23421, 23306, 23294, 23297, 23296, 23299, 23199, 23141, 23060, 22959, 22975, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22972, 22971, 22929, 22872, 22818, 22758, 22688, 22637, 22698, 20825, 19570, 18755, 17730, 16641, 15494, 14215, 13174, 12525, 11862, 11156, 10377, 9603, 8826, 8052, 7274, 6501, 5713, 4660, 3735, 2746, 1957, 1180, 433, -196, -1435, -2992, -4288, -5452, -6615, -7781, -8943, -10106, -11272, -12433, -13610, -14800, -15984, -17171, -18359, -19542, -20736, -21875, -22923, -23977, -25031, -26079, -27144, -28117, -28949, -29791, -30632, -30881, -34960, -5850, 8788, 5025, 4870, 4113, 3149, 2076, 976, -165, -1305, -2416, -3433, -4442, -5452, -6468, -7460, -8339, -9204, -10070, -10936, -11808, -12650, -13363, -14061, -14760, -15462, -16159, -16887, -17650, -18408, -19165, -19926, -20678, -21464, -22426, -23219, -23767, -24462, -25253, -26263, -26669, -27800, -29466, -28625, -27459, -26380, -25270, -24013, -22713, -21421, -20131, -18837, -17416, -15948, -14474, -13051, -12174, -11421, -10631, -9897, -9365, -8850, -8334, -7813, -7309, -6933, -6578, -6219, -5864, -5489, -5271, -5256, -5223, -5194, -5161, -5146, -5457, -5861, -6252, -6605, -7501, -8790, -10026, -11235, -12711, -14625, -16513, -18434, -20102, -21641, -22887, -23833, -24590, -25170, -26040, -27142, -28278, -29558, -30600, -31142, -31716, -32145, -32268, -32400, -32440, -32433, -32439, -32408, -32309, -32214, -32108, -31835, -31518, -31208, -30900, -30569, -30222, -29878, -29534, -29157, -28766, -28381, -27977, -27545, -27110, -26691, -26131, -25439, -24763, -24083, -23394, -22704, -22012, -21347, -20746, -20141, -19542, -18905, -18222, -17546, -16857, -16090, -15313, -14533, -13849, -13236, -12613, -11997, -11350, -10660, -9968, -9289, -8494, -7575, -6680, -5895, -5090, -4541, -4369, -4177, -3953, -3400, -2912, -2616, -1890, -1157, -593, 109};