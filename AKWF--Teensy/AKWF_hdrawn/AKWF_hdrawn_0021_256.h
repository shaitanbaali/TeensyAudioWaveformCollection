/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hdrawn_0021 256 samples */
 
const int16_t AKWF_hdrawn_0021_256_DATA [256] = 
{-190, -258, -326, -337, -320, -309, -296, -283, -271, -259, -257, -258, -257, -257, -257, -258, -256, -242, -227, -213, -199, -184, -170, -158, -145, -132, -120, -108, -94, -82, -72, -61, -49, -38, -27, -16, -5, 7, 19, 32, 44, 57, 69, 82, 85, 84, 85, 85, 85, 85, 85, 161, -302, 3695, 1435, -224, 135, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 84, 87, 98, 108, 63, 413, -5299, -7096, -6647, -6692, -6690, -6641, -6914, -5840, 166, 184, 159, 171, 171, 171, 169, 178, 140, 8, 81, 86, 84, 85, 85, 85, 84, 84, 85, 70, 43, 19, -7, -40, -75, -87, -84, -95, -159, -221, -358, -566, -766, -966, -1167, -1369, -1569, -1774, -2081, -2423, -2746, -3047, -3348, -3654, -4036, -4446, -4814, -5114, -5414, -5722, -6107, -6509, -6935, -7405, -7875, -8405, -8884, -9748, -10976, -11550, -12200, -13489, -23247, -28589, -29572, -30956, -31940, -32114, -32171, -32245, -32333, -32465, -32595, -32654, -32742, -32771, -32766, -32766, -32773, -32741, -32656, -32634, -32568, -32433, -32258, -31938, -31722, -31421, -31024, -30413, -29225, -28212, -27914, -27696, -26887, -24379, -21564, -18025, -16142, -15066, -13799, -12401, -10973, -9795, -8682, -7411, -6178, -5153, -4050, -3247, -2477, -2073, -1695, -1129, -690, -469, -147, -73, 180, 381, 341, 340, 326, 314, 302, 289, 276, 264, 252, 239, 226, 214, 201, 189, 175, 602, -1821, 9612, 34506, 32071, 32510, 32510, 32510, 32510, 32510, 31921, 35075, 16951, -2554, 611, -5, -24, -44, -65, -83, -86, -85, -85, -85, -88, -75, -10, 25, 128, 181, 128, 81, 18};