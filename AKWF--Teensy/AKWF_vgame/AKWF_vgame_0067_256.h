/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0067 256 samples */
 
const int16_t AKWF_vgame_0067_256_DATA [256] = 
{17252, 32889, 26601, 27472, 28535, 27807, 27879, 28048, 28005, 28009, 28005, 28001, 27996, 27992, 27987, 27981, 27976, 27970, 27965, 27959, 27953, 27947, 27940, 27935, 27928, 27921, 27914, 27906, 27918, 27640, 27546, 27564, 27552, 27549, 27514, 27755, 27869, 27832, 27830, 27823, 27812, 27827, 27745, 27576, 27812, 27548, 27742, 27790, 27524, 27744, 27573, 27645, 27942, 27324, 27851, 27392, 27395, 27911, 26890, 28355, 27436, 25993, 29980, 27199, 1133, -14109, -7647, -9235, -9599, -9068, -9836, -8947, -9581, -9378, -9132, -9697, -9227, -9340, -9464, -9432, -9438, -9437, -9436, -9435, -9434, -9432, -9431, -9430, -9428, -9426, -9425, -9423, -9422, -9419, -9417, -9415, -9413, -9411, -9409, -9406, -9408, -9379, -9610, -9465, -9375, -9397, -9390, -9389, -9386, -9384, -9381, -9379, -9376, -9374, -9371, -9369, -9367, -9364, -9362, -9360, -9357, -9354, -9352, -9349, -9346, -9351, -9310, -9521, -9448, -9306, -9338, -9329, -9327, -9325, -9322, -9320, -9317, -9315, -9312, -9310, -9307, -9305, -9302, -9300, -9297, -9295, -9292, -9290, -9287, -9285, -9282, -9280, -9277, -9274, -9279, -9238, -9452, -9598, -9235, -9436, -9370, -9226, -9258, -9250, -9247, -9245, -9242, -9240, -9238, -9235, -9233, -9229, -9221, -9452, -9253, -9195, -9445, -9257, -9199, -9213, -9208, -9205, -9203, -9200, -9198, -9195, -9193, -9190, -9188, -9185, -9183, -9181, -9178, -9176, -9173, -9170, -9168, -9165, -9163, -9161, -9158, -9155, -9153, -9151, -9148, -9146, -9143, -9141, -9138, -9136, -9134, -9131, -9129, -9126, -9124, -9122, -9119, -9116, -9114, -9112, -9109, -9106, -9104, -9102, -9100, -9097, -9094, -9092, -9090, -9087, -9085, -9082, -9080, -9077, -9075, -9072, -9076, -9038, -9177, -9262, -8767, -9161, -9076, -8932, -9266, -8647, -9193, -8961, -8715, -9483, -8200, -9721, -9373, -6992, -11274, -10251};