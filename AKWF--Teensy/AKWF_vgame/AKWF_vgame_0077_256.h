/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0077 256 samples */
 
const int16_t AKWF_vgame_0077_256_DATA [256] = 
{2741, 4476, 4391, 4434, 4437, 4466, 4311, 4841, 8343, 8304, 8171, 8224, 8222, 8076, 8271, 8748, 12100, 12323, 12244, 12257, 12256, 12273, 12187, 12381, 16124, 16480, 16361, 16381, 16379, 16391, 16333, 16403, 19874, 20476, 20493, 20492, 20495, 20497, 20487, 20372, 23595, 24491, 24342, 24143, 24126, 24288, 24303, 24209, 27572, 28446, 28209, 28247, 28240, 28232, 28280, 27928, 31132, 32590, 32296, 32341, 32334, 32328, 32254, 32626, 29600, 27891, 28197, 28133, 28128, 28059, 28359, 27676, 24255, 24086, 24057, 24109, 23974, 23978, 24208, 23615, 20105, 20199, 20200, 20188, 20181, 20148, 20269, 19731, 16144, 15944, 16017, 15995, 15988, 15963, 16041, 15841, 12105, 11716, 11840, 11809, 11803, 11791, 11810, 11839, 8397, 7795, 7830, 7718, 7586, 7691, 7793, 7877, 4458, 3769, 3959, 3919, 3913, 3932, 3803, 3828, 471, -425, -194, -239, -239, -246, -268, -111, -3201, -4607, -4339, -4389, -4389, -4387, -4454, -4083, -7056, -8624, -8324, -8374, -8306, -8425, -8216, -8933, -12417, -12192, -12210, -12209, -12214, -12211, -12237, -12805, -16310, -16377, -16324, -16334, -16331, -16355, -16223, -16735, -20332, -20526, -20435, -20451, -20445, -20471, -20337, -20415, -24024, -24509, -24388, -24405, -24589, -24481, -24348, -24358, -27836, -28341, -28171, -28198, -28191, -28193, -28176, -28150, -31632, -32493, -32256, -32293, -32285, -32276, -32230, -32474, -29013, -27865, -28145, -28084, -28076, -28070, -28009, -28498, -25276, -24000, -24230, -24202, -24105, -23964, -24207, -23138, -19851, -20199, -20143, -20139, -20127, -20117, -20118, -19373, -16038, -16010, -15943, -15948, -15941, -15892, -16110, -15542, -11900, -11812, -11763, -11769, -11739, -11807, -12002, -11559, -8157, -7894, -7955, -7924, -7881, -7882, -7693, -7530, -4066, -3784, -3900, -3872, -3865, -3880, -3791, -3610, -266, 398, 257, 286, 287, 280, 326, 109};