/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0123 256 samples */
 
const int16_t AKWF_vgame_0123_256_DATA [256] = 
{6439, 6537, 6512, 6519, 6519, 6519, 6519, 6519, 6519, 6519, 6517, 6517, 6516, 6516, 6514, 6513, 6513, 6511, 6510, 6509, 6507, 6507, 6505, 6504, 6502, 6501, 6500, 6498, 6496, 6495, 6493, 6492, 6490, 6490, 6584, 6066, 8133, 19065, 19131, 19055, 19082, 19079, 19076, 19073, 19070, 19067, 19062, 19058, 19055, 19051, 19046, 19042, 19038, 19034, 19029, 19024, 19170, 18343, 22104, 32230, 31478, 31605, 31598, 31592, 31586, 31579, 31573, 31566, 31559, 31552, 31548, 30870, 34576, 17946, -33574, -31097, -31501, -31535, -31537, -31538, -31538, -31537, -31536, -31534, -31531, -31528, -31517, -31448, -31869, -21461, -18317, -19021, -18889, -18885, -18879, -18875, -18870, -18865, -18860, -18855, -18850, -18845, -18840, -18835, -18830, -18825, -18820, -18815, -18810, -18803, -18655, -19431, -16026, -5675, -6266, -6180, -6164, -6160, -6157, -6153, -6150, -6146, -6144, -6141, -6138, -6135, -6133, -6130, -6128, -6125, -6123, -6121, -6119, -6117, -6114, -6113, -6111, -6108, -6107, -6105, -6103, -6102, -6099, -6097, -6096, -6094, -6095, -5908, -6918, -2006, 7376, 6327, 6530, 6524, 6525, 6525, 6525, 6525, 6525, 6525, 6523, 6523, 6522, 6522, 6520, 6519, 6519, 6517, 6516, 6515, 6513, 6512, 6511, 6510, 6508, 6507, 6505, 6504, 6502, 6501, 6499, 6498, 6496, 6494, 6492, 6492, 6490, 6488, 6486, 6485, 6482, 6481, 6480, 6478, 6476, 6474, 6472, 6471, 6473, 6243, 7439, 1002, -7113, -5924, -6153, -6147, -6146, -6147, -6149, -6147, -6146, -6147, -6147, -6146, -6146, -6144, -6143, -6143, -6142, -6140, -6140, -6138, -6137, -6135, -6135, -6133, -6132, -6130, -6129, -6128, -6126, -6125, -6123, -6122, -6120, -6119, -6117, -6116, -6114, -6113, -6111, -6109, -6108, -6107, -6105, -6103, -6102, -6100, -6099, -6097, -6096, -6094, -6092, -6097, -6061, -6217};