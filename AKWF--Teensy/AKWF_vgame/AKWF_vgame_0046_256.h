/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0046 256 samples */
 
const int16_t AKWF_vgame_0046_256_DATA [256] = 
{1210, 1860, 1766, 1540, 3138, 4532, 4455, 6808, 7095, 6739, 8789, 10351, 9676, 12196, 15555, 15235, 15285, 15336, 15133, 17172, 19613, 21123, 20927, 21001, 20833, 22989, 23539, 25218, 26396, 26186, 26149, 27986, 28502, 28338, 30224, 30693, 30462, 31186, 32004, 31859, 32016, 31508, 31444, 31460, 31450, 31480, 31264, 30732, 30101, 30160, 30133, 30212, 29586, 29277, 28839, 28330, 28403, 28456, 27798, 27455, 27588, 26898, 26588, 26701, 25985, 25720, 25830, 25057, 23683, 23566, 23598, 23590, 23592, 22912, 22457, 21392, 21410, 21385, 21513, 20728, 20058, 19791, 19160, 19213, 19326, 18475, 17790, 18037, 17122, 16491, 16687, 16049, 15645, 15824, 14896, 13269, 13067, 13119, 13089, 13175, 12175, 11604, 10552, 10456, 9322, 9137, 9166, 9246, 8828, 7791, 7855, 7962, 7294, 6416, 6712, 5739, 4639, 4938, 4132, 3366, 3600, 2864, 1180, 809, 892, 849, 968, 84, -544, -1562, -1788, -1757, -1658, -2633, -3098, -3232, -4375, -4390, -4274, -5668, -6248, -5945, -7581, -8897, -8701, -8738, -8741, -8731, -9716, -10852, -11445, -11336, -11384, -11253, -12004, -12721, -13672, -14044, -13991, -13877, -14708, -15369, -15352, -16534, -16643, -16498, -17406, -18036, -17763, -18768, -20216, -20071, -20098, -20114, -20032, -20960, -21869, -22334, -22266, -22291, -22232, -23313, -23598, -24151, -24527, -24475, -24351, -25731, -26788, -26618, -26650, -26665, -26582, -27083, -27616, -27410, -28094, -29336, -29262, -29271, -29289, -29219, -29730, -30489, -31063, -31009, -31029, -30990, -31321, -31417, -31923, -32399, -32322, -32307, -32643, -32786, -32789, -32095, -31841, -31957, -30867, -30498, -30695, -28712, -25874, -25747, -25790, -25738, -25915, -24934, -22727, -20015, -20122, -20052, -20300, -18659, -17462, -16466, -14647, -14850, -15087, -13037, -11521, -12041, -10151, -8943, -9401, -7450, -6327, -6772, -4454, -1129, -809, -901, -856, -950};