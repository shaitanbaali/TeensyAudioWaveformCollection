/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0053 256 samples */
 
const int16_t AKWF_vgame_0053_256_DATA [256] = 
{966, 1725, 2511, 3430, 4068, 5185, 6197, 7211, 8218, 9289, 10140, 11788, 12283, 12388, 13511, 14923, 15768, 16562, 18649, 18794, 19303, 20310, 21023, 21780, 23070, 24929, 24925, 25586, 26580, 27470, 28060, 29012, 29724, 29813, 30559, 31265, 31708, 32038, 32348, 32325, 32339, 32298, 31936, 31604, 31236, 30994, 31023, 30679, 30304, 30112, 30183, 29890, 29353, 29209, 28861, 28521, 28176, 27832, 27494, 27122, 27090, 27043, 26295, 25918, 25584, 25240, 24899, 24564, 24191, 23993, 23684, 23335, 22992, 22649, 22310, 21968, 21626, 21260, 21024, 20539, 19926, 19630, 19274, 18973, 18424, 17818, 17176, 17028, 16971, 16597, 15893, 15467, 15131, 14444, 14449, 13771, 13447, 13159, 12479, 11922, 11343, 11337, 11017, 10357, 9804, 9668, 9093, 8232, 8304, 7241, 6964, 6769, 6424, 5892, 5703, 5429, 4673, 3989, 3611, 3328, 2483, 2118, 1840, 1460, 1254, 549, 148, -710, -965, -1304, -1602, -2222, -2796, -3105, -3411, -3746, -4457, -4731, -5424, -5910, -6222, -6569, -7299, -7539, -7893, -8614, -9021, -9333, -9747, -10464, -10803, -11175, -11394, -11643, -12271, -12839, -13167, -13903, -14279, -14621, -14906, -15936, -16195, -16234, -16631, -16922, -17565, -18126, -18758, -18779, -19114, -19300, -19631, -20309, -20862, -21428, -21426, -21793, -22127, -22508, -22668, -23275, -24091, -24088, -24483, -24815, -25164, -25474, -26011, -26216, -26345, -26732, -27062, -27402, -27737, -28282, -28426, -28371, -28503, -28884, -29207, -29580, -30083, -30227, -30580, -30952, -31040, -31005, -31435, -31865, -32037, -32363, -32306, -32650, -32790, -32756, -32787, -32585, -32101, -31388, -30676, -30353, -29627, -28609, -27989, -27291, -26839, -25763, -24717, -23976, -23175, -22113, -21073, -20405, -19431, -18725, -17948, -16600, -15426, -14807, -13761, -12725, -11786, -10107, -10111, -9603, -8393, -6992, -6416, -5139, -3412, -3424, -2295, -1553, -1158, -107};