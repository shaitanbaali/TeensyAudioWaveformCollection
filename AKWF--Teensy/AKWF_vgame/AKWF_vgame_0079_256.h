/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0079 256 samples */
 
const int16_t AKWF_vgame_0079_256_DATA [256] = 
{5619, 11368, 13760, 13424, 11508, 9714, 8552, 8382, 8444, 8779, 9497, 10590, 10968, 10983, 10686, 9891, 9076, 9005, 9427, 9972, 10473, 10466, 10187, 9777, 9412, 9370, 9683, 9965, 9908, 9911, 9940, 9820, 9353, 9495, 9927, 9900, 9899, 9897, 9914, 9470, 9365, 9339, 9628, 9929, 9871, 9877, 9896, 9463, 9334, 9366, 9332, 9762, 9889, 9846, 9877, 9782, 9330, 9342, 9316, 9399, 9835, 9884, 9612, 9278, 9340, 9273, 9532, 9867, 9810, 9813, 9847, 9426, 9267, 9311, 9261, 9664, 9848, 9741, 9292, 9276, 9281, 9276, 9274, 9271, 9269, 9266, 9264, 9261, 9258, 9256, 9254, 9251, 9249, 9246, 9243, 9241, 9238, 9236, 9234, 9231, 9228, 9235, 9183, 9564, 9778, 9695, 9244, 9200, 9211, 9215, 9162, 9532, 9749, 9695, 9713, 9684, 9223, 9174, 9187, 9190, 9136, 9499, 9725, 9673, 9672, 9711, 9539, 9128, 9173, 9123, 9285, 9694, 9654, 9647, 9699, 9349, 9095, 9156, 9088, 9425, 9683, 9626, 9635, 9632, 9629, 9627, 9624, 9621, 9619, 9616, 9614, 9612, 9608, 9606, 9604, 9601, 9599, 9596, 9593, 9591, 9588, 9585, 9583, 9581, 9579, 9565, 9617, 9322, 8966, 9318, 9607, 9549, 9558, 9554, 9549, 9581, 9088, 9260, 9548, 9776, 9717, 9330, 8127, 7391, 8011, 10163, 12413, 13970, 12821, 6863, -2595, -13238, -23057, -29774, -32489, -32315, -30295, -28598, -27881, -27756, -28134, -28543, -28497, -28737, -29083, -29023, -29029, -29012, -29058, -28812, -28452, -28497, -28488, -28439, -28831, -29007, -28954, -28973, -28911, -28448, -28428, -28384, -28767, -28952, -28896, -28914, -28865, -28396, -28367, -28325, -28701, -28896, -28832, -28881, -28492, -28277, -28326, -28269, -28595, -28997, -29314, -29331, -28922, -28301, -27904, -27233, -27204, -27288, -28332, -30066, -31991, -32778, -31053, -25529, -16753, -3329};