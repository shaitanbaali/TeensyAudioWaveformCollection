/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0011 256 samples */
 
const int16_t AKWF_vgame_0011_256_DATA [256] = 
{1084, 2464, 8484, 8811, 8712, 8734, 8883, 8087, 12917, 20212, 19540, 19655, 19659, 19712, 19418, 20849, 23841, 23535, 23640, 23387, 25142, 26187, 27479, 29514, 29218, 29274, 29311, 29101, 30202, 31386, 30948, 31029, 31021, 31021, 31028, 30991, 31321, 31486, 31414, 31620, 30614, 29090, 29399, 27162, 26531, 26675, 26585, 26917, 25450, 21066, 17896, 17381, 17499, 17475, 17443, 17609, 16970, 12380, 12139, 12436, 11430, 8116, 8524, 7451, 3798, 3952, 3912, 4018, 3586, 260, -592, -1848, -1720, -1764, -1672, -2048, -3570, -3296, -3022, -3067, -3058, -3059, -3074, -2990, -3557, -3998, -3915, -3923, -3963, -3748, -3461, -3502, -3494, -3494, -3495, -3461, -3632, -2027, 251, 479, 419, 436, 444, 408, 520, 2832, 3118, 3081, 2890, 3824, 6159, 6492, 9569, 9630, 9601, 9626, 9564, 9769, 12650, 14527, 14392, 14414, 14416, 14423, 14386, 14564, 14884, 14845, 14865, 14816, 14407, 14513, 13802, 13001, 13130, 13102, 13109, 13068, 12137, 10436, 9456, 9648, 9610, 9609, 9585, 9729, 8023, 7295, 7452, 7450, 6326, 6063, 6133, 5749, 5661, 5682, 5653, 5788, 4464, 3784, 3142, 3041, 3062, 3058, 3009, 3270, 1838, -1009, -847, -869, -873, -905, -729, -1510, -3622, -3468, -3550, -3248, -5094, -6643, -7263, -8890, -8703, -8737, -8777, -8602, -9449, -12803, -14145, -13934, -13982, -13979, -14040, -13717, -16118, -17734, -17447, -17336, -18160, -19842, -19440, -22240, -23358, -23109, -23187, -23017, -23752, -26702, -28859, -29368, -29252, -29273, -29281, -29246, -29370, -30914, -31051, -31032, -30939, -31942, -32397, -32378, -32770, -32767, -32767, -32753, -32805, -32403, -31273, -29611, -29733, -29711, -29708, -29630, -30068, -25918, -22755, -23245, -23155, -23157, -23074, -23507, -20848, -18757, -17257, -14095, -14493, -14306, -14895, -10217, -7398, -7968, -7860, -7815, -8064, -6944};