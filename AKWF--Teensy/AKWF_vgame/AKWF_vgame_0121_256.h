/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0121 256 samples */
 
const int16_t AKWF_vgame_0121_256_DATA [256] = 
{5131, 6610, 6266, 6331, 6331, 6331, 6331, 6331, 6331, 6331, 6329, 6329, 6326, 6542, 5379, 13915, 19609, 18509, 18708, 18704, 18702, 18699, 18696, 18693, 18690, 18687, 18683, 18679, 18674, 18887, 17714, 24989, 32040, 30813, 31041, 31033, 31026, 31020, 31015, 31008, 31002, 30995, 30988, 30981, 30974, 30982, 30522, 33038, 16392, 12850, 19774, 18342, 18529, 18522, 18516, 18509, 18503, 18499, 18493, 18486, 18480, 18475, 18469, 18464, 18459, 18453, 18448, 18443, 18438, 18432, 18427, 18422, 18416, 18411, 18406, 18400, 18624, 17402, 23147, 35933, 9700, -35263, -30693, -21369, -18213, -18930, -18804, -18803, -18804, -18802, -18801, -18799, -18797, -18795, -18792, -18790, -18787, -18785, -18781, -18778, -18774, -18770, -18767, -18763, -18759, -18754, -18750, -18746, -18742, -18738, -18834, -18309, -20426, -30747, -31175, -31057, -31090, -31085, -31079, -31072, -31066, -31059, -31052, -31046, -31039, -31031, -31023, -31014, -30836, -31757, -26495, -17814, -18760, -18587, -18577, -18571, -18564, -18558, -18551, -18546, -18541, -18533, -18405, -19089, -9046, -5477, -6258, -6113, -6109, -6105, -6101, -6097, -6094, -6090, -6087, -6084, -6081, -5995, -6432, -4679, 6156, 6383, 6291, 6321, 6322, 6323, 6324, 6324, 6324, 6324, 6324, 6324, 6324, 6322, 6218, 6769, 4510, -6135, -6085, -6044, -6068, -6068, -6068, -6068, -6069, -6066, -6065, -6066, -6064, -6064, -6063, -6061, -6061, -6060, -6059, -6057, -6056, -6055, -6053, -6052, -6051, -6050, -6048, -6047, -6045, -6044, -6017, -6097, -5906, 4983, 6698, 6272, 6351, 6353, 6353, 6353, 6353, 6352, 6351, 6351, 6351, 6350, 6349, 6349, 6347, 6347, 6345, 6344, 6342, 6341, 6340, 6339, 6338, 6336, 6334, 6333, 6315, 6281, 6671, -3726, -6616, -5934, -6061, -6064, -6063, -6063, -6063, -6064, -6063, -6061, -6061, -6062, -6061, -6082, -5960, -6486};