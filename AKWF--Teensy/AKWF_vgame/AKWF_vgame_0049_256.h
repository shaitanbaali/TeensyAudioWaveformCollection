/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0049 256 samples */
 
const int16_t AKWF_vgame_0049_256_DATA [256] = 
{1464, 1631, 3461, 4412, 5190, 6240, 6120, 8076, 8261, 10357, 10925, 12037, 12624, 13730, 15016, 14850, 16435, 16535, 18629, 19238, 20322, 21066, 21037, 23546, 25440, 25331, 25268, 26701, 27117, 27341, 28405, 28554, 30094, 30168, 31307, 31440, 31739, 32394, 32315, 32342, 32293, 31901, 31924, 31305, 30973, 31024, 31062, 30846, 30112, 30181, 29190, 28771, 28846, 28867, 28684, 28404, 28258, 27170, 27068, 27077, 27156, 26671, 26206, 25947, 24903, 24902, 24891, 24970, 24356, 24054, 23568, 22250, 22286, 22274, 22328, 21613, 21463, 20727, 19572, 19675, 19662, 19663, 18887, 18857, 17873, 16932, 17059, 17056, 16974, 16190, 16219, 15021, 14317, 14430, 14453, 14257, 13534, 13511, 11772, 11274, 11366, 11412, 11083, 10472, 10326, 8501, 8288, 8158, 7407, 7415, 7481, 7180, 5381, 5202, 5266, 5189, 4394, 4444, 3907, 2179, 2173, 2222, 2042, 1266, 1431, 604, -961, -866, -818, -1124, -1831, -1602, -2740, -4063, -3917, -3864, -4314, -4808, -5095, -6566, -7042, -6990, -6921, -7504, -7844, -8333, -9777, -10091, -10046, -9993, -10675, -10919, -11349, -12470, -12710, -12661, -12640, -13762, -13983, -14563, -15625, -15757, -15699, -15791, -16951, -17042, -17778, -18353, -18358, -18316, -18481, -19215, -19261, -20564, -21435, -21409, -21380, -21532, -21831, -21990, -23268, -23618, -23598, -23527, -23950, -24499, -24606, -25730, -26271, -26206, -26194, -26392, -27292, -27505, -27981, -28472, -28369, -28456, -28845, -28816, -29010, -29900, -30202, -30111, -30255, -30621, -30522, -31157, -31868, -31909, -31859, -32063, -32367, -32314, -32666, -32389, -32301, -32404, -31876, -31386, -31503, -30446, -28825, -28808, -28964, -27648, -27090, -26290, -24788, -23540, -23589, -23691, -21493, -20935, -19998, -18288, -16897, -17094, -16985, -15052, -14845, -13272, -11658, -10791, -11030, -10620, -8353, -8202, -6880, -5066, -4205, -4515, -3859, -2159, -1933, -86};