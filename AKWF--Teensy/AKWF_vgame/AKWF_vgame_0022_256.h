/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0022 256 samples */
 
const int16_t AKWF_vgame_0022_256_DATA [256] = 
{944, 3201, 4270, 5295, 7662, 9333, 10191, 11618, 12504, 14429, 16481, 17148, 18837, 19726, 20235, 21642, 22965, 23532, 24354, 25279, 25642, 26500, 26896, 27270, 28540, 29437, 29666, 30510, 31448, 31463, 31447, 31486, 31320, 30993, 31031, 31010, 31056, 31460, 31155, 30372, 30182, 29741, 28311, 27871, 27200, 26559, 24939, 24294, 22959, 21862, 20897, 19338, 18481, 16847, 16348, 15340, 14070, 12297, 11705, 10621, 8742, 8560, 7263, 6205, 5236, 4032, 2434, 1766, 1391, 269, -171, -660, -941, -1615, -2352, -3021, -3413, -3505, -3522, -3326, -3027, -3064, -3059, -3523, -3943, -3929, -3922, -3964, -3749, -3463, -3494, -3524, -3905, -3959, -3487, -2649, -2349, -1777, -999, -716, -414, 166, 892, 1359, 2161, 2814, 3453, 4689, 5206, 5878, 6754, 7002, 8317, 9118, 10243, 10976, 11474, 12002, 12476, 12811, 13149, 14177, 14460, 14774, 14871, 14843, 14887, 14592, 14379, 14443, 14331, 13952, 13624, 13271, 12736, 12677, 12418, 12044, 11760, 11169, 10445, 10042, 9598, 9312, 8737, 7635, 7409, 7339, 6422, 6106, 6057, 5674, 5673, 5695, 5389, 5032, 4721, 4235, 3889, 3435, 3031, 3089, 2805, 2248, 2203, 2032, 1123, 839, 275, -822, -860, -1144, -1985, -2641, -3627, -4353, -5607, -5912, -6632, -6895, -7606, -8213, -8699, -9587, -9981, -10570, -11162, -11907, -12071, -13486, -14494, -14849, -16310, -16831, -17211, -18052, -18597, -18766, -19477, -20850, -21243, -22452, -22917, -23982, -24860, -25450, -26410, -27180, -27819, -28562, -29576, -29958, -30261, -30785, -31025, -31129, -31518, -31841, -32215, -32706, -32778, -32764, -32762, -32792, -32618, -32296, -32382, -31659, -31043, -30777, -30343, -29012, -28304, -27502, -26495, -26273, -25203, -23579, -23113, -21819, -20882, -20340, -19123, -18205, -16596, -15957, -14619, -13466, -11243, -10487, -9367, -5951, -5381, -4386, -2335, -489};