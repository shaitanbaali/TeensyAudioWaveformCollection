/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0058 256 samples */
 
const int16_t AKWF_vgame_0058_256_DATA [256] = 
{29697, 29364, 31775, 31381, 31441, 31439, 31439, 31439, 31439, 31439, 31439, 31460, 31348, 31939, 32857, 32747, 32767, 32768, 32768, 32738, 32385, 34689, -14556, -29333, -25968, -26569, -26550, -26608, -26463, -19877, -18827, -19089, -19039, -19021, -19118, -18750, -15628, -15456, -15509, -15496, -15463, -15642, -14893, -11887, -11962, -11960, -11955, -11954, -11954, -11954, -11954, -11954, -11935, -12038, -11625, -9311, -9288, -9304, -9299, -9298, -9299, -9267, -9438, -8428, -7383, -7560, -7518, -7566, -6844, -6628, -6380, -6166, -6206, -6199, -6199, -6187, -6249, -5549, -5262, -5324, -5312, -5311, -5306, -5353, -3856, -3470, -3559, -3542, -3542, -3542, -3542, -3542, -3542, -3532, -3590, -3318, -2664, -2475, -920, -871, -890, -885, -875, -925, -709, 29, -7, 45, -203, 1230, 2896, 2471, 2184, 2218, 2211, 2211, 2272, 1945, 3699, 6031, 5692, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5760, 5735, 6096, 6221, 6192, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6203, 6175, 6307, 6662, 6635, 6640, 6640, 6633, 6670, 6483, 6166, 6205, 6198, 6198, 6165, 6337, 5358, 4286, 4458, 4426, 4426, 4426, 4426, 4426, 4426, 4413, 4480, 4172, 3488, 3553, 3542, 3542, 3542, 3542, 3524, 3611, 3236, 1427, 1301, 1337, 1328, 1328, 1328, 1328, 1328, 1328, 1328, 1328, 1296, 1466, 486, -584, -410, -443, -442, -455, -386, -676, -1806, -1764, -1770, -1771, -1860, -1367, -3656, -8817, -8324, -8412, -8412, -8474, -8149, -9793, -12216, -11896, -11959, -12032, -11546, -20410, -22640, -21514, -21713, -21697, -21697, -21697, -21697, -21697, -21697, -21697, -21695, -21322, -23304, -14645};