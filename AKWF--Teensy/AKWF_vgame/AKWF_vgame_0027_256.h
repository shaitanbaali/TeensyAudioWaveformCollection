/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0027 256 samples */
 
const int16_t AKWF_vgame_0027_256_DATA [256] = 
{5259, 11295, 10473, 10629, 10621, 10737, 10141, 14187, 17295, 16727, 16813, 16876, 19798, 21047, 23099, 23008, 23022, 23027, 23037, 22963, 24609, 26525, 26582, 26559, 26567, 26572, 26545, 26666, 27029, 27013, 26994, 27070, 28290, 28163, 29493, 31207, 30950, 31002, 30986, 30977, 32755, 30769, 29447, 29717, 29669, 29659, 29677, 29684, 24736, 23681, 24064, 23498, 19579, 19527, 19151, 16837, 16815, 16817, 16880, 16544, 14309, 11683, 7131, 7618, 7522, 7505, 7533, 7594, -377, -3093, -2555, -2658, -2656, -2666, -2610, -3312, -3592, -3530, -3585, -3380, -5240, -6616, -11843, -12532, -12366, -12434, -12290, -12767, -19602, -23219, -22983, -23022, -23025, -23018, -23058, -22828, -22631, -21650, -21173, -21271, -21246, -21286, -20976, -20780, -20819, -20810, -20758, -20997, -18793, -11249, -9926, -10252, -10185, -10136, -10386, -9380, -2806, -2591, -2658, -2795, 2441, 3655, 4207, 6349, 6164, 6199, 6206, 6157, 6869, 7131, 7073, 7084, 7084, 7084, 7078, 7110, 6767, 6607, 6657, 6624, 4302, 3931, 3918, 403, -107, 24, -2, 14, -742, -919, -877, -885, -884, -885, -993, -405, -4445, -8922, -8299, -8412, -8413, -8474, -8145, -10536, -12217, -11897, -11949, -11972, -12761, -12785, -14601, -15158, -15032, -15057, -15052, -15050, -16193, -16431, -16378, -16361, -16480, -16844, -16822, -16825, -16825, -16824, -16833, -16799, -16401, -16411, -16182, -15906, -15949, -15937, -15950, -15905, -15165, -14729, -14586, -14617, -14610, -14606, -14618, -14601, -13060, -12787, -12790, -13117, -10158, -8683, -8525, -6180, -6196, -6204, -6175, -6292, -5407, -4622, -4416, -4433, -4427, -4426, -4443, -4355, -4924, -5381, -5297, -5313, -5313, -5321, -5272, -5998, -6244, -6188, -6198, -6200, -6192, -6223, -6614, -6648, -6639, -6641, -6621, -6728, -6256, -4797, -4886, -4871, -4873, -4787, -5240, -2778, 384, -93, 21, -71};