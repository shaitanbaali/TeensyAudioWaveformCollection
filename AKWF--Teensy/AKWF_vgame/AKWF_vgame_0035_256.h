/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0035 256 samples */
 
const int16_t AKWF_vgame_0035_256_DATA [256] = 
{276, 1894, 3713, 5288, 7655, 8916, 11131, 12392, 13896, 15210, 16929, 17657, 18319, 19251, 19985, 21271, 21737, 22203, 22831, 23223, 23851, 24308, 24824, 25433, 25779, 26068, 26285, 26564, 26839, 27055, 26948, 27401, 27958, 27834, 28133, 28758, 29274, 29627, 31466, 32479, 32260, 32506, 32798, 32437, 32312, 29581, 28588, 28979, 27418, 26358, 24356, 23440, 20262, 19916, 19634, 18605, 18198, 17448, 16756, 15597, 15567, 14941, 14164, 12980, 12231, 8917, 5614, 5974, 4184, 2882, 1325, 450, -1823, -2738, -2615, -2999, -3128, -3078, -3187, -4057, -4389, -4960, -5751, -6916, -7809, -9778, -12480, -13219, -15050, -16616, -18486, -19614, -21739, -22839, -23064, -23026, -22983, -22592, -22592, -22533, -22154, -22109, -21375, -20938, -20782, -20844, -20680, -20413, -19873, -19428, -18125, -17162, -15285, -13636, -11884, -9460, -7879, -5252, -3775, -1776, -142, 1114, 2751, 3485, 4363, 5104, 5834, 6401, 6915, 7109, 7076, 7084, 7084, 7084, 7084, 7084, 7077, 7112, 6919, 6736, 5852, 4308, 4530, 4026, 2775, 1554, 328, -375, -959, -868, -878, -922, -549, -589, -928, -863, -954, -1638, -2211, -3030, -4260, -7131, -7517, -7964, -9674, -10581, -11610, -12164, -12838, -12843, -12851, -12785, -13423, -13799, -15047, -15966, -15952, -16349, -16393, -16381, -16383, -16383, -16383, -16391, -16350, -16584, -16854, -16852, -16619, -16347, -16385, -16416, -16100, -15909, -15948, -15933, -15975, -15703, -15474, -15146, -15033, -15064, -14704, -14518, -14200, -13960, -13755, -12799, -12163, -10834, -10019, -8833, -8052, -7405, -6807, -6406, -5795, -5316, -4796, -4902, -4811, -4427, -4425, -4427, -4427, -4427, -4428, -4426, -4425, -5108, -5360, -5271, -5579, -5790, -6133, -6213, -6195, -6198, -6201, -6186, -6249, -6634, -6643, -6639, -6640, -6640, -6641, -6617, -6744, -6002, -4764, -4986, -4111, -3425, -2112, -1401};