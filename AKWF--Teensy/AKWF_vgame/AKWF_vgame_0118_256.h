/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0118 256 samples */
 
const int16_t AKWF_vgame_0118_256_DATA [256] = 
{1600, 3046, 2792, 3630, 4749, 5921, 6659, 8309, 9187, 9063, 10338, 11379, 11895, 12699, 13892, 15004, 15646, 16281, 17421, 18594, 19437, 20393, 20874, 21780, 22983, 24066, 24554, 25504, 26991, 27877, 27312, 6170, 4294, 5861, 7234, 8365, 8411, 9350, 10539, 11597, 12392, 13700, 14526, 14760, 16094, 16996, 17475, 18290, 20208, 21224, 21063, 21967, 23135, 24245, 24995, 26747, 27310, 27363, 28690, 29652, 30106, 30130, 35989, 7313, -22472, -16577, -17018, -15917, -14714, -13821, -13355, -12375, -11148, -10191, -9291, -8357, -7565, -6878, -5602, -4808, -4376, -2695, -1579, -900, -217, 407, 1144, 2341, 3370, 4743, 5345, 5748, 7076, 7805, 8854, 7728, -12427, -13444, -12517, -11894, -11220, -10060, -8981, -7191, -6912, -6626, -5284, -4440, -3442, -2917, -2119, -927, 202, 842, 1474, 2606, 3792, 4643, 5603, 6085, 6988, 8204, 9215, 10135, 10514, 13157, 6222, -15167, -12920, -12189, -10514, -9882, -9110, -8563, -7733, -6516, -5521, -4095, -3712, -3080, -1817, -979, -5, 347, 2507, 2919, 3579, 4188, 4953, 6134, 7252, 9020, 9078, 9442, 10496, 11700, 12695, 12898, 15261, -3738, -10121, -7562, -7091, -6530, -5531, -3860, -3139, -2936, -1902, -679, 267, 1235, 1853, 2802, 3929, 4813, 5668, 6072, 7829, 8538, 9336, 9836, 10744, 11971, 12956, 14396, 14633, 15186, 16296, 16786, 21424, 4667, -33577, -30730, -30441, -29465, -28850, -28220, -26894, -24939, -25092, -24556, -23475, -22266, -21331, -20868, -19911, -18681, -17710, -16750, -16057, -15451, -14315, -13118, -12291, -11794, -10759, -9528, -8616, -7631, -7047, -6626, -3867, -9635, -29335, -27567, -25975, -25407, -24586, -23584, -23059, -22247, -21000, -19420, -19327, -18615, -17465, -16293, -15552, -14842, -12710, -12673, -11804, -10822, -10245, -9553, -8040, -6302, -6641, -5504, -3647, -3643, -2761, -1334, -96, -318};