/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0082 256 samples */
 
const int16_t AKWF_vgame_0082_256_DATA [256] = 
{19685, 29410, 29967, 31288, 31035, 31068, 31066, 31062, 31058, 31053, 31049, 31044, 31039, 31033, 31028, 31021, 31015, 31009, 31002, 30995, 30989, 30982, 30974, 30967, 30959, 30952, 30944, 30937, 30929, 30929, 30463, 32880, 21156, -5549, -2696, -4920, -4491, -4575, -4579, -4583, -4585, -4588, -4590, -4593, -4595, -4596, -4596, -4598, -4599, -4599, -4600, -4599, -4599, -4599, -4599, -4599, -4600, -4599, -4599, -4599, -4598, -4597, -4596, -4595, -4595, -4595, -4594, -4592, -4592, -4591, -4589, -4589, -4588, -4586, -4585, -4584, -4583, -4582, -4581, -4580, -4579, -4577, -4576, -4575, -4574, -4573, -4572, -4570, -4570, -4569, -4567, -4566, -4565, -4563, -4563, -4561, -4560, -4558, -4557, -4556, -4555, -4554, -4553, -4551, -4550, -4549, -4547, -4547, -4545, -4544, -4543, -4542, -4540, -4539, -4537, -4537, -4535, -4534, -4534, -4532, -4530, -4530, -4528, -4527, -4526, -4524, -4523, -4522, -4521, -4520, -4519, -4517, -4517, -4515, -4514, -4513, -4511, -4510, -4508, -4508, -4507, -4506, -4504, -4503, -4501, -4501, -4499, -4498, -4496, -4495, -4494, -4494, -4492, -4491, -4489, -4488, -4487, -4486, -4485, -4484, -4482, -4481, -4480, -4479, -4478, -4477, -4475, -4474, -4472, -4472, -4471, -4470, -4468, -4467, -4465, -4465, -4463, -4462, -4461, -4459, -4458, -4458, -4456, -4455, -4454, -4452, -4451, -4449, -4449, -4447, -4446, -4445, -4445, -4443, -4442, -4440, -4439, -4438, -4437, -4436, -4435, -4433, -4432, -4431, -4430, -4429, -4428, -4426, -4425, -4424, -4423, -4421, -4420, -4419, -4418, -4417, -4416, -4415, -4413, -4412, -4410, -4410, -4409, -4408, -4406, -4406, -4404, -4403, -4401, -4400, -4399, -4397, -4397, -4396, -4395, -4393, -4392, -4390, -4390, -4388, -4387, -4386, -4385, -4384, -4383, -4381, -4380, -4379, -4378, -4377, -4375, -4375, -4297, -4777, -2611, -4857};