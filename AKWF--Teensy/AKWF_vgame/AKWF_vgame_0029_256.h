/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0029 256 samples */
 
const int16_t AKWF_vgame_0029_256_DATA [256] = 
{2626, 4279, 3915, 3991, 4031, 3741, 8966, 15356, 15548, 15468, 15516, 15439, 15691, 19454, 21812, 21673, 21692, 21724, 21602, 22800, 24122, 24871, 24775, 24800, 24793, 24817, 25888, 26726, 27062, 26998, 27015, 26998, 27079, 27422, 28971, 29128, 30034, 32056, 31850, 31861, 31973, 32741, 32775, 32756, 32801, 32579, 30538, 28893, 25893, 26181, 26068, 26375, 24993, 20821, 19487, 17944, 18205, 18117, 18319, 17206, 15921, 14078, 13118, 13322, 13188, 13681, 9659, 6978, 2454, 1615, 1756, 1988, 739, -1925, -1956, -3123, -3096, -3113, -3027, -3594, -3861, -4968, -6832, -6595, -6711, -6324, -10598, -11821, -15357, -18135, -17696, -17370, -19453, -22927, -22494, -22940, -23045, -23013, -23060, -22760, -22579, -22478, -21299, -21240, -21255, -21269, -20877, -20914, -20233, -18477, -18598, -18700, -18204, -13408, -13726, -10212, -6100, -6665, -7050, -2692, 3187, 3626, 3500, 3546, 3538, 3525, 5811, 6291, 6183, 6972, 7111, 7077, 7084, 7084, 7084, 7084, 7084, 7070, 7142, 6803, 6098, 6396, 5277, 3343, 3619, 3426, 692, 351, 562, -316, -980, -882, -800, -428, -452, -407, -1136, -1416, -1124, -2360, -4202, -3857, -4299, -8617, -8858, -9100, -11849, -12010, -11837, -12723, -13827, -13704, -13726, -13730, -13735, -13665, -15787, -16503, -16357, -16384, -16384, -16390, -16354, -16674, -16856, -16818, -16826, -16818, -16854, -16695, -15977, -15931, -15944, -15939, -15942, -15939, -15481, -15046, -15055, -15056, -15050, -15053, -15065, -14183, -13197, -13302, -13283, -13223, -13491, -12164, -8054, -6934, -7131, -7075, -7121, -6943, -5408, -4956, -4853, -4876, -4865, -4895, -4758, -4404, -4431, -4427, -4427, -4434, -4400, -4590, -5080, -5779, -5750, -5756, -5763, -5726, -6057, -6228, -6192, -6198, -6205, -6170, -6340, -6670, -6634, -6641, -6641, -6625, -6706, -6154, -5745, -3203, -2528, -2696, -2613, -2852};