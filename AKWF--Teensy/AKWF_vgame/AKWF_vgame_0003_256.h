/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0003 256 samples */
 
const int16_t AKWF_vgame_0003_256_DATA [256] = 
{183, 671, 1139, 1608, 2074, 2538, 3002, 3463, 3924, 4384, 4842, 5302, 5761, 6218, 6676, 7134, 7592, 8052, 8511, 8969, 9429, 9888, 10347, 10808, 11269, 11728, 12190, 12650, 13111, 13571, 14032, 14492, 14953, 15413, 15873, 16334, 16793, 17253, 17714, 18172, 18631, 19091, 19550, 20009, 20469, 20927, 21387, 21846, 22305, 22763, 23223, 23680, 24139, 24598, 25057, 25515, 25975, 26433, 26892, 27351, 27809, 28268, 28727, 29185, 29644, 30103, 30562, 31021, 31479, 31934, 32409, 32757, 32597, 32309, 32082, 31743, 31198, 30469, 29605, 28659, 27664, 26625, 25551, 24461, 23377, 22322, 21309, 20340, 19423, 18564, 17762, 17022, 16338, 15709, 15128, 14594, 14097, 13635, 13199, 12785, 12387, 11997, 11614, 11234, 10852, 10464, 10071, 9669, 9258, 8839, 8407, 7967, 7518, 7059, 6593, 6123, 5646, 5163, 4680, 4193, 3704, 3217, 2728, 2242, 1758, 1273, 793, 316, -160, -634, -1105, -1574, -2040, -2505, -2969, -3430, -3891, -4352, -4811, -5269, -5727, -6185, -6644, -7102, -7559, -8018, -8477, -8935, -9395, -9855, -10314, -10774, -11235, -11695, -12156, -12617, -13076, -13538, -13998, -14459, -14920, -15380, -15840, -16301, -16760, -17220, -17680, -18139, -18598, -19059, -19516, -19976, -20436, -20894, -21353, -21812, -22270, -22729, -23188, -23647, -24106, -24565, -25022, -25482, -25941, -26399, -26858, -27317, -27776, -28234, -28694, -29152, -29612, -30069, -30528, -30988, -31445, -31900, -32373, -32747, -32620, -32326, -32100, -31776, -31246, -30529, -29673, -28731, -27740, -26704, -25632, -24543, -23457, -22399, -21383, -20411, -19490, -18627, -17819, -17074, -16388, -15754, -15171, -14633, -14134, -13669, -13232, -12816, -12416, -12027, -11643, -11263, -10881, -10494, -10101, -9701, -9290, -8871, -8441, -8001, -7552, -7095, -6629, -6158, -5682, -5201, -4717, -4229, -3742, -3253, -2766, -2279, -1794, -1312, -831, -347};