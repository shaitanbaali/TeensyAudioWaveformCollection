/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0089 256 samples */
 
const int16_t AKWF_vgame_0089_256_DATA [256] = 
{179, -97, 1486, 3033, 2807, 5668, 5989, 6598, 9088, 8926, 10431, 12063, 11796, 14649, 15276, 15605, 17880, 17479, 19829, 21360, 20854, 22782, 23651, 23938, 26798, 26631, 28073, 29662, 29424, 31898, 32502, 31434, 29354, 29572, 27964, 26479, 26882, 23961, 23590, 22497, 20641, 21108, 19614, 17390, 17768, 15316, 15195, 14368, 11501, 11908, 10171, 8746, 8203, 6214, 5899, 4976, 2047, 3970, -9551, -19329, -17217, -19976, -21018, -20919, -23382, -23276, -24952, -26889, -26483, -28901, -29323, -30098, -32300, -32858, -30473, -29198, -29125, -26798, -26901, -26180, -23350, -23601, -22070, -20787, -20685, -18316, -17504, -17057, -14725, -15119, -12963, -11470, -11535, -9176, -9370, -7870, -5535, -5928, -3732, -2458, -3311, -373, 118, 710, 3112, 2685, 4474, 6175, 5876, 8360, 8845, 9683, 11980, 11658, 13623, 14607, 14797, 11967, 11925, 11411, 9460, 8155, 16268, 24539, 23293, 21162, 20142, 19803, 17692, 17832, 16384, 14882, 14581, 12187, 11892, 10879, 8770, 9020, 7669, 5720, 6068, 3653, 2592, 2340, -92, 233, -1506, -2934, -2943, -5374, -5781, -6519, -8850, -8950, -10487, -11915, -11549, -13957, -15333, -14044, -11735, -11897, -10384, -8405, -8910, -6255, -5849, -5053, -3164, -3341, -1083, 173, 156, 2515, 2636, 3962, 6052, 5752, 7130, 8562, 8527, 10871, 11865, 12183, 14153, 15816, 6718, -1307, 445, 2713, 3353, 4131, 6008, 5742, 7858, 9027, 8955, 11318, 11748, 12341, 14427, 14431, 13311, 11554, 11977, 9101, 8951, 8493, 5686, 6072, 4227, 2683, 2327, 224, 47, -340, -2982, -2873, -4456, -6080, -5828, -8229, -9263, -9509, -11704, -11487, -13257, -15406, -14806, -17146, -17507, -18463, -21054, -20743, -22582, -23608, -23229, -25961, -26845, -27084, -29394, -29085, -30685, -32561, -32052, -29835, -29244, -28650, -26051, -27376, -18198, -5068, -5725, -3260, -3195, -3105};