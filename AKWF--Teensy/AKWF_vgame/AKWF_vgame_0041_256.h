/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0041 256 samples */
 
const int16_t AKWF_vgame_0041_256_DATA [256] = 
{703, 1869, 3829, 5656, 6839, 8319, 10858, 12864, 13581, 15808, 17181, 17543, 18466, 19669, 20269, 21125, 21928, 22493, 22965, 23092, 23792, 24342, 24856, 25572, 25755, 26076, 26289, 26575, 26658, 27028, 27015, 26990, 27129, 27791, 28351, 28449, 29178, 30205, 30933, 31703, 32347, 32793, 32809, 32437, 31910, 31189, 29516, 28573, 27507, 26322, 24271, 23104, 21985, 20235, 19604, 18744, 18125, 17416, 16883, 16297, 15179, 15000, 14143, 13002, 11200, 9989, 7827, 5354, 4255, 2727, 1138, -493, -1159, -2074, -2770, -3114, -3101, -3074, -3242, -3769, -4224, -5033, -5799, -6758, -8774, -10058, -11356, -13725, -15187, -16496, -18427, -20704, -21680, -22511, -23028, -23036, -22976, -22587, -22594, -22529, -22155, -21791, -21644, -21144, -20787, -20808, -20849, -20608, -19880, -19301, -18086, -16219, -15412, -13656, -11382, -8960, -7734, -5153, -2801, -2051, -524, 1560, 2975, 3607, 4740, 5328, 5892, 6579, 6889, 7114, 7076, 7084, 7084, 7084, 7084, 7084, 7079, 7104, 6759, 6589, 6157, 5574, 4482, 3846, 2749, 752, 317, -185, -874, -879, -917, -640, -416, -416, -702, -893, -1052, -1544, -2412, -3479, -4216, -6044, -7321, -8317, -9586, -11204, -12014, -11917, -12579, -12887, -12842, -12786, -13441, -13791, -14747, -15399, -15901, -16367, -16387, -16376, -16411, -16250, -16292, -16408, -16370, -16420, -16809, -16842, -16778, -16393, -16374, -16417, -16093, -15910, -15940, -15972, -15762, -15489, -15384, -15028, -15060, -15061, -14678, -14609, -14313, -13993, -13344, -12808, -12069, -10547, -9779, -8884, -7731, -7003, -6569, -6129, -5396, -5244, -4871, -4903, -4633, -4391, -4435, -4426, -4426, -4426, -4426, -4434, -4394, -4702, -4876, -5034, -5621, -5785, -6138, -6212, -6195, -6198, -6202, -6185, -6254, -6638, -6642, -6639, -6640, -6640, -6639, -6640, -6647, -5967, -5723, -5013, -4270, -2953, -1652, -568};