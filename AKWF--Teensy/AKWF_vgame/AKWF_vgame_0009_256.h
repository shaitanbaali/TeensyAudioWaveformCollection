/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0009 256 samples */
 
const int16_t AKWF_vgame_0009_256_DATA [256] = 
{1, 4, 8, 11, 15, 19, 21, 25, 28, 29, 32, 35, 37, 39, 42, 44, 46, 48, 51, 52, 54, 56, 57, 59, 60, 62, 64, 65, 66, 67, 68, 70, 71, 71, 72, 74, 74, 75, 76, 76, 76, 78, 79, 78, 79, 80, 79, 80, 81, 80, 81, 80, 81, 82, 83, 83, 82, 83, 84, 83, 84, 84, 84, 85, 86, 85, 89, 89, 105, 267, -567, 9512, 27239, 30854, 32467, 32667, 31876, 31061, 30358, 29661, 28954, 28267, 27572, 26767, 26971, 16184, -2203, -6407, -8616, -9394, -9166, -8913, -8759, -8600, -8424, -8248, -8077, -7913, -7750, -7589, -7432, -7277, -7125, -6977, -6829, -6686, -6544, -6406, -6270, -6136, -6005, -5876, -5749, -5626, -5504, -5383, -5266, -5150, -5037, -4926, -4817, -4710, -4606, -4502, -4401, -4302, -4204, -4109, -4015, -3923, -3832, -3744, -3658, -3573, -3490, -3408, -3328, -3250, -3172, -3097, -3024, -2952, -2880, -2810, -2743, -2676, -2611, -2546, -2483, -2422, -2361, -2303, -2245, -2189, -2132, -2079, -2025, -1973, -1922, -1872, -1824, -1776, -1729, -1683, -1639, -1595, -1551, -1510, -1469, -1429, -1389, -1351, -1313, -1277, -1241, -1206, -1171, -1138, -1105, -1073, -1042, -1012, -981, -952, -924, -896, -869, -842, -816, -791, -766, -742, -719, -695, -672, -651, -629, -608, -588, -568, -547, -529, -510, -492, -475, -457, -441, -425, -409, -394, -379, -364, -349, -336, -323, -310, -298, -285, -274, -261, -250, -239, -228, -217, -207, -197, -187, -178, -168, -159, -151, -143, -134, -126, -118, -111, -104, -97, -90, -84, -77, -70, -64, -58, -53, -48, -43, -38, -32, -28, -23, -18, -14, -10, -6, -2};