/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0078 256 samples */
 
const int16_t AKWF_vgame_0078_256_DATA [256] = 
{402, 1931, 3670, 4732, 4739, 4040, 3884, 3913, 3724, 4591, 6492, 8332, 9126, 8509, 7866, 8079, 9564, 11408, 12631, 12818, 12386, 12330, 12341, 12293, 12680, 13766, 15617, 16803, 16681, 16334, 16083, 16014, 16166, 16725, 18259, 19944, 20677, 20682, 20331, 20256, 20236, 20034, 20849, 22728, 24631, 25382, 24457, 23865, 24382, 25634, 27144, 28346, 28874, 28794, 28559, 28296, 28213, 28808, 30129, 31909, 32808, 32666, 32193, 31906, 32190, 32486, 32168, 30578, 28533, 27278, 27354, 28272, 28137, 27049, 25763, 24531, 23666, 23431, 23612, 23843, 23950, 23667, 22714, 21304, 19864, 19164, 19209, 19353, 19510, 19583, 19308, 18456, 16865, 15534, 15102, 14932, 14907, 15090, 15261, 15032, 13507, 11469, 10375, 10468, 11262, 11270, 10402, 9192, 7989, 7074, 6507, 6346, 6523, 6662, 6495, 5916, 4965, 3803, 2780, 2152, 2033, 2275, 2538, 2266, 1213, -565, -2046, -2483, -2262, -1846, -1790, -1862, -2064, -3327, -5194, -6525, -6761, -6081, -5933, -6511, -7407, -8459, -9448, -10176, -10501, -10417, -10231, -10264, -10813, -11661, -12482, -13494, -14514, -14990, -14834, -14290, -14387, -15469, -17242, -18690, -19051, -18818, -18553, -18894, -19592, -20348, -21270, -22203, -22914, -23157, -22961, -22874, -23111, -23689, -24576, -25625, -26565, -27239, -27563, -27394, -26989, -27144, -27885, -28929, -29979, -30792, -31250, -31422, -31440, -31433, -31307, -30729, -30043, -29650, -29668, -29877, -29716, -29370, -28969, -27938, -26526, -25485, -25115, -25356, -25441, -25287, -25193, -24712, -23635, -22018, -20778, -20975, -21537, -21560, -20769, -19304, -17649, -16686, -16652, -16851, -17065, -17151, -16727, -15687, -14182, -12871, -12307, -12302, -12576, -12793, -12792, -12445, -11486, -10045, -8531, -7747, -8047, -8437, -8590, -8607, -8127, -7004, -5295, -3873, -3841, -4457, -4788, -3942, -2236, -623, 366, 572, 420, 98, -235, -202};