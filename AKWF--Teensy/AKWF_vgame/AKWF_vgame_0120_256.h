/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0120 256 samples */
 
const int16_t AKWF_vgame_0120_256_DATA [256] = 
{566, 507, 523, 523, 536, 455, 1722, 2169, 2069, 2092, 2095, 2046, 3764, 5648, 5676, 5660, 5682, 5624, 5831, 7982, 9374, 9098, 9824, 11145, 11035, 10885, 11986, 12948, 12775, 12805, 12833, 12681, 13860, 16115, 16430, 16349, 16369, 16369, 16310, 18056, 19934, 19931, 19917, 19934, 19870, 20077, 22257, 23589, 23447, 23470, 23494, 23360, 24011, 26335, 27127, 26986, 27010, 27035, 26880, 28076, 30301, 30612, 30531, 30545, 30297, 31519, 28264, -9248, -11039, -10511, -10625, -10688, -10476, -8296, -6964, -7104, -7077, -7050, -7179, -6517, -4154, -3395, -3533, -3503, -3472, -3619, -2395, -158, 127, 54, 76, 77, 35, 1815, 3667, 3651, 3646, 3666, 3603, 3842, 6028, 7338, 7196, 7245, 7125, 7702, 8962, 9989, 10936, 10763, 10793, 10822, 10674, 11895, 14132, 14412, 14337, 14358, 14354, 14312, 16095, 17940, 17919, 17909, 17928, 17860, 18097, 20296, 21588, 21442, 21464, 20710, 24739, 3622, -23768, -18808, -19723, -19696, -19670, -19806, -18556, -16343, -16069, -16138, -16114, -16118, -16130, -14335, -12514, -12529, -12533, -12507, -12575, -12295, -10104, -8827, -8962, -8931, -8898, -9032, -8294, -5955, -5236, -5367, -5336, -5305, -5445, -4173, -1955, -1697, -1763, -1740, -1741, -1766, 61, 1866, 1832, 1834, 1855, 1784, 2058, 4289, 5532, 5388, 5419, 5425, 5421, 5376, 8273, 9399, 9172, 9214, 9185, 8991, 10577, -22848, -33628, -31546, -31922, -31885, -32100, -30735, -28232, -28359, -28338, -28329, -28280, -28522, -26333, -24514, -24771, -24719, -24705, -24712, -24701, -21913, -20955, -21143, -21101, -21068, -21188, -20634, -17696, -17444, -17504, -17485, -17431, -17673, -16304, -13750, -13906, -13879, -13871, -13819, -14070, -11847, -10054, -10319, -10265, -10254, -10263, -10258, -7460, -6519, -6701, -6663, -6635, -6757, -6180, -3262, -3028, -3086, -3069, -3028, -3237, -1956};