/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0115 256 samples */
 
const int16_t AKWF_vgame_0115_256_DATA [256] = 
{609, 990, 1616, 2056, 3448, 3474, 3503, 4219, 4603, 5167, 5790, 7051, 6988, 6912, 7715, 8197, 8809, 9589, 9816, 10305, 10765, 11382, 11763, 12391, 12827, 13352, 13927, 14325, 14962, 15360, 15934, 16442, 16899, 17518, 17899, 18517, 18967, 19467, 20047, 20452, 21084, 21491, 22045, 22573, 22999, 23626, 24005, 24618, 25089, 25565, 26162, 26533, 27229, 27306, 28193, 28590, 29190, 29601, 30362, 30949, 31064, 31721, 31600, 35018, 3366, -12803, -8799, -9239, -8621, -8130, -7665, -7097, -6319, -5985, -5629, -5084, -4511, -4115, -3466, -2694, -2497, -1983, -1527, -900, -538, 164, 913, 1017, 1654, 2023, 2742, 2770, 3643, 4769, 4695, 5175, 5672, 6278, 6600, 7561, 8239, 8692, 9203, 9152, 9896, 10175, 11238, 11828, 11721, 12433, 12804, 13454, 13778, 14915, 15306, 15283, 16015, 16386, 16991, 17416, 18559, 18759, 18873, 19557, 19951, 20376, 21947, -14284, -23423, -21027, -20763, -20619, -19983, -19365, -17884, -17949, -17852, -17139, -16739, -16215, -15478, -14310, -14459, -14217, -13565, -13080, -12665, -11682, -10754, -10954, -10553, -9989, -9421, -9096, -7887, -7232, -7428, -6886, -6416, -5781, -5487, -4126, -3738, -3886, -3231, -2834, -2186, -1827, -410, -245, -362, 77, 586, 1333, 1815, 2442, 2843, 3422, 3931, 4384, 5016, 5394, 6019, 6487, 6916, 7844, 8830, 8628, 8997, 9494, 10204, 10524, -26141, -33716, -31411, -31243, -30760, -30157, -29766, -29123, -28703, -28146, -27588, -27167, -26524, -26131, -25523, -25037, -24564, -23905, -23719, -23137, -22715, -21874, -21480, -20764, -20026, -19934, -19251, -18872, -18231, -17840, -17083, -16419, -16327, -15616, -15223, -14626, -14181, -13407, -12844, -12688, -12013, -11562, -11039, -10518, -9731, -9304, -9025, -8428, -7903, -7455, -6857, -6070, -5780, -5355, -4854, -4253, -3867, -3200, -2430, -2255, -1998, -1171, -706, -227};