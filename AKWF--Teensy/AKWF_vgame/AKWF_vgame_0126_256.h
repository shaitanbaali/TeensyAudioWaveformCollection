/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0126 256 samples */
 
const int16_t AKWF_vgame_0126_256_DATA [256] = 
{4789, 6624, 6457, 5337, 14357, 19815, 20457, 31950, 32297, 32173, 32207, 32206, 32204, 32201, 32198, 32194, 32190, 32185, 32180, 32175, 32169, 32164, 32158, 32152, 32144, 32139, 32132, 32124, 32117, 32110, 32103, 32095, 32084, 31887, 32948, 23346, 18242, 19307, 19101, 19093, 19087, 19080, 19073, 19067, 19061, 19054, 19048, 19042, 19036, 19030, 19024, 19019, 19014, 19008, 19002, 18997, 18991, 18986, 18980, 18975, 18970, 18965, 18959, 18954, 18948, 18944, 18938, 18933, 18928, 18923, 18917, 18913, 18907, 18902, 18897, 18891, 18887, 18881, 18876, 18871, 18866, 18861, 18856, 18851, 18846, 18841, 18836, 18830, 18826, 18821, 18815, 18811, 18805, 18800, 18783, 18704, 19264, 8575, 5210, 5969, 5827, 5822, 5819, 5815, 5813, 5810, 5806, 5804, 5800, 5798, 5796, 5793, 5790, 5788, 5786, 5784, 5782, 5780, 5778, 5776, 5774, 5772, 5758, 5706, 6134, -4688, -7749, -6919, -7741, -4819, 6082, 5713, 5741, 5757, 5757, 5757, 5756, 5754, 5754, 5736, 5746, 5872, -5338, -7644, -7091, -7192, -7191, -7191, -7191, -7192, -7191, -7190, -7189, -7189, -7188, -7186, -7186, -7184, -7183, -7181, -7186, -7353, -6370, -16065, -20958, -19919, -20109, -20107, -20104, -20102, -20098, -20094, -20091, -20087, -20082, -20078, -20074, -20069, -20066, -20060, -20056, -20051, -20047, -20042, -20037, -20032, -20027, -20022, -20017, -20012, -20007, -20002, -19996, -19992, -19986, -19981, -19976, -19971, -19965, -19961, -19955, -19949, -19945, -19940, -19934, -19929, -19923, -19919, -19913, -19908, -19902, -19897, -19892, -19887, -19881, -19876, -19871, -19865, -19860, -19854, -19849, -19848, -20022, -18998, -27916, -33596, -32565, -32749, -32743, -32737, -32730, -32723, -32715, -32708, -32701, -32694, -32686, -32678, -32670, -32662, -32654, -32646, -32638, -32630, -32621, -32614, -32605, -32597, -32588, -32580, -32569, -32375, -33382, -26648, -19384, -10997};