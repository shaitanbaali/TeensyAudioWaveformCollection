/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0068 256 samples */
 
const int16_t AKWF_vgame_0068_256_DATA [256] = 
{7412, 7401, 7559, 7660, 7553, 7765, 10836, 11119, 11049, 11062, 11065, 11105, 10923, 12504, 14662, 19437, 22486, 21795, 21920, 21966, 21675, 22809, 25658, 25290, 25332, 25326, 25325, 25326, 25267, 26133, 29297, 28430, 19081, 18016, 18285, 18440, 18315, 18569, 21649, 21851, 21797, 21802, 21795, 21856, 21493, 23064, 25669, 25284, 25176, 25199, 25181, 25163, 25444, 24485, 21617, 21743, 21716, 21707, 21702, 21662, 21840, 21317, 17940, 18803, 28312, 28974, 28957, 29112, 29084, 28476, 25370, 25119, 25040, 25048, 25038, 25022, 25040, 25074, 22051, 21459, 21586, 21555, 21550, 21490, 21771, 20640, 17737, 17966, 18101, 18069, 18060, 18073, 17974, 17306, 14550, 13522, 4113, 3224, 3486, 3415, 3471, 2981, -70, -359, -292, -309, -311, -320, -299, -338, -2952, -5494, -11496, -10895, -11162, -11248, -10986, -11858, -14742, -14603, -14622, -14624, -14621, -14653, -14467, -14982, -18356, -17452, -8133, -7397, -7567, -7568, -7438, -7808, -10864, -11087, -11160, -11144, -11145, -11157, -11094, -11141, -14632, -13073, -7258, -7471, -7522, -7508, -7424, -8360, -11224, -11087, -11105, -11105, -11102, -11139, -10922, -11722, -14515, -15141, -24814, -25595, -25330, -25407, -25269, -25649, -28857, -29021, -28754, -28877, -28876, -28884, -28996, -29202, -32302, -32861, -32726, -32743, -32735, -32736, -32659, -32719, -29730, -28772, -28916, -28758, -28648, -28642, -28962, -28208, -25311, -24437, -15099, -14347, -14552, -14318, -14362, -14127, -11010, -10800, -10842, -10826, -10821, -10805, -10845, -10668, -7575, -6993, -7218, -7127, -6954, -7147, -7166, -7108, -4112, -3344, -3344, -3334, -3327, -3293, -3464, -2995, 234, -542, -9983, -10687, -10637, -10756, -10757, -10362, -7284, -6957, -7073, -7068, -6829, -6764, -7209, -6811, -3498, -4946, -11035, -10428, -10688, -10728, -10674, -10516, -7590, -6755, -6940, -6778, -6664, -6857, -6846, -7140, -4347, -3033};