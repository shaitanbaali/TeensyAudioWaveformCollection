/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0092 256 samples */
 
const int16_t AKWF_vgame_0092_256_DATA [256] = 
{595, 2780, 7150, 12798, 18127, 22254, 25699, 28289, 29966, 31096, 31422, 31612, 31770, 31593, 31236, 30678, 29991, 29668, 29228, 28914, 28585, 28399, 28213, 27892, 27704, 27499, 26815, 26310, 26177, 25714, 25633, 25325, 25013, 24908, 24375, 23841, 23209, 22474, 22146, 21618, 21363, 21186, 21028, 20974, 20849, 20855, 20573, 19915, 19345, 19095, 18869, 18762, 18349, 17920, 17737, 17501, 17237, 16837, 15928, 15572, 15177, 14726, 14648, 14414, 14311, 14169, 14058, 13946, 13506, 12822, 12542, 12192, 11860, 11682, 11522, 11491, 11332, 10771, 10373, 9935, 9748, 9468, 8840, 8618, 8410, 8350, 8263, 8071, 7850, 7450, 6845, 6689, 6487, 6339, 6200, 6003, 6085, 5823, 5438, 5285, 4860, 4422, 4359, 3864, 3492, 3384, 3330, 3163, 3147, 3144, 3056, 2497, 2166, 2258, 2177, 2196, 2025, 1980, 1749, 1271, 1120, 775, 244, 125, -111, 280, 728, 657, 634, 793, 756, 411, -216, -1207, -3673, -8421, -14073, -19757, -24170, -27300, -29682, -31004, -31745, -32469, -32593, -32706, -32659, -32133, -31603, -30996, -30345, -29880, -29661, -29618, -29667, -29331, -28978, -28497, -28036, -27506, -26946, -26611, -26262, -25729, -25662, -25286, -24995, -24912, -24436, -23969, -23378, -22907, -22489, -22155, -21954, -21719, -21502, -21199, -20599, -20156, -19601, -19147, -18937, -18578, -18125, -17951, -17726, -17545, -17476, -16976, -16488, -16112, -15624, -15209, -14771, -14428, -14296, -14130, -13891, -13389, -13177, -12791, -12286, -12039, -11717, -11274, -11111, -11054, -10968, -10975, -10656, -10203, -9822, -9372, -8866, -8612, -8362, -8118, -8035, -7954, -7584, -7453, -7196, -6727, -6494, -6096, -5620, -5431, -5378, -5483, -5631, -5442, -5170, -4763, -4359, -3933, -3525, -3095, -2769, -2749, -2925, -2645, -2427, -2207, -1817, -1725, -1390, -1031, -779, -638, -780, -930, -842, -806, -449, -85};