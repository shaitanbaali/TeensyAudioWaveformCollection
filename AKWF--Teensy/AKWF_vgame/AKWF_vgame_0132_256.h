/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0132 256 samples */
 
const int16_t AKWF_vgame_0132_256_DATA [256] = 
{6125, 6614, 6850, 17893, 19459, 19059, 19133, 19374, 18116, 25678, 32656, 31448, 31672, 31665, 31662, 31658, 31653, 31648, 31643, 31637, 31631, 31625, 31620, 31613, 31606, 31600, 31593, 31584, 31480, 32000, 29856, 19004, 18977, 19032, 18997, 18990, 18984, 18977, 18970, 18915, 19140, 18357, 7299, 6154, 6462, 6396, 6390, 6386, 6382, 6378, 6374, 6371, 6368, 6365, 6361, 6359, 6377, 6371, 6146, 16815, 19386, 18766, 18875, 18873, 18869, 18866, 18862, 18859, 18854, 18850, 18846, 18842, 18838, 18833, 18829, 18824, 18820, 18815, 18810, 18806, 18801, 18796, 18784, 18651, 19447, 9504, 5524, 6391, 6230, 6046, 7027, 2129, -7176, -6132, -6334, -6330, -6331, -6337, -6456, -5733, -15851, -19544, -18726, -18871, -18870, -18868, -18866, -18864, -18861, -18859, -18856, -18853, -18849, -18846, -18842, -18839, -18835, -18753, -19162, -17528, -6549, -6190, -6305, -6274, -6064, -7150, 1963, 7128, 6093, 6285, 6285, 6287, 6371, 5910, 7779, 18708, 18887, 18795, 18822, 18822, 18820, 18818, 18815, 18813, 18810, 18807, 18803, 18800, 18796, 18792, 18789, 18787, 18564, 19711, 13856, 5280, 6442, 6219, 6171, 6394, 5630, -5414, -6578, -6266, -6330, -6332, -6330, -6553, -5381, -11504, -19843, -18651, -18880, -18870, -18869, -18867, -18865, -18862, -18860, -18857, -18853, -18850, -18846, -18843, -18839, -18836, -18832, -18828, -18824, -18820, -18815, -18810, -18808, -18627, -19580, -14968, -5454, -6426, -6235, -6238, -6235, -6231, -6229, -6226, -6222, -6220, -6217, -6215, -6237, -6175, -6241, -17065, -19160, -18644, -18733, -18730, -18727, -18723, -18720, -18716, -18712, -18918, -17781, -24441, -32148, -31017, -31221, -31217, -31211, -31205, -31199, -31192, -31185, -31180, -31173, -31166, -31159, -31151, -31143, -31136, -31129, -31121, -31113, -30915, -31940, -22832, -17703, -18523, -19423, -14016, -5057, -6180, -5969, -5978, -5892, -6245};