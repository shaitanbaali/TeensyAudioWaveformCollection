/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0083 256 samples */
 
const int16_t AKWF_vgame_0083_256_DATA [256] = 
{4477, 14919, 22828, 28284, 31601, 31580, 29605, 27696, 26255, 26138, 27423, 29054, 29134, 27984, 27529, 27665, 27537, 27850, 29176, 28072, 27478, 27614, 27579, 27574, 27568, 27562, 27554, 27548, 27542, 27534, 27527, 27521, 27514, 27507, 27500, 27493, 27485, 27479, 27472, 27465, 27457, 27450, 27443, 27436, 27426, 27451, 27287, 28153, 29029, 28384, 27294, 27394, 27388, 27265, 28331, 28950, 28230, 26285, 24553, 24825, 27733, 31528, 32782, 29127, 21920, 13034, 2844, -5957, -12521, -14717, -13526, -11211, -8241, -6492, -7633, -9644, -11528, -11762, -9770, -8920, -8927, -9526, -10537, -10364, -10546, -9607, -8912, -8909, -9756, -10534, -10363, -10503, -9367, -8918, -8917, -9978, -10479, -10479, -9464, -8877, -9006, -8943, -10170, -10434, -10406, -10253, -8996, -8942, -9002, -8834, -9675, -10459, -10454, -9705, -8823, -8976, -8942, -8942, -8939, -8953, -8875, -9117, -10333, -10391, -10181, -8939, -8899, -8954, -8783, -9627, -10444, -10264, -10412, -9303, -8796, -8942, -8821, -9121, -10346, -10310, -9078, -8818, -8896, -8875, -8874, -8872, -8869, -8867, -8864, -8862, -8860, -8857, -8854, -8852, -8850, -8847, -8850, -8833, -8830, -10061, -10283, -10275, -10079, -8827, -8809, -8859, -8689, -9570, -10320, -10314, -9522, -8677, -8834, -8821, -8725, -9061, -10234, -10261, -9978, -8760, -8781, -8787, -8794, -8730, -8898, -10146, -10267, -9069, -8680, -8784, -8789, -8631, -9408, -10287, -10103, -10269, -9208, -8632, -8766, -8764, -8618, -9212, -10308, -8966, -8650, -8744, -8722, -8731, -8629, -9741, -10340, -9428, -8577, -8734, -8697, -8729, -8578, -9251, -10189, -10181, -9598, -8568, -8734, -8553, -9472, -10202, -10035, -10160, -9002, -8591, -8587, -9674, -10155, -10050, -10048, -8797, -8588, -8640, -9861, -10090, -10078, -9889, -8643, -8583, -9633, -10626, -10758, -9892, -8387, -7026, -8177, -10469, -13504, -14346, -11038, -3612};