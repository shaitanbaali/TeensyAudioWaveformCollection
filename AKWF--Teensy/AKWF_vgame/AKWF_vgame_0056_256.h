/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0056 256 samples */
 
const int16_t AKWF_vgame_0056_256_DATA [256] = 
{564, 1264, 2279, 3218, 3933, 4951, 6196, 6971, 7504, 8972, 9901, 10678, 11331, 12679, 13484, 14331, 15519, 16079, 16974, 18053, 19474, 19748, 20655, 22138, 22727, 23286, 24414, 25372, 25944, 26893, 27971, 28474, 29165, 30091, 30585, 30712, 31394, 31894, 32082, 32358, 32358, 32123, 31892, 31747, 31460, 31178, 31025, 30801, 30557, 30279, 29894, 29678, 29734, 29065, 28797, 28840, 28360, 27956, 27956, 27470, 27075, 27077, 26590, 26190, 25849, 25701, 25195, 24829, 24509, 24335, 23803, 23453, 23192, 22869, 22274, 22145, 21604, 21261, 20979, 20782, 20061, 19643, 19435, 18903, 18609, 18052, 17923, 17336, 17011, 16724, 16146, 15747, 15391, 14829, 14435, 14047, 13615, 13136, 12599, 12300, 12115, 11426, 11302, 10802, 10108, 9981, 9519, 8916, 8309, 8210, 7592, 7000, 6870, 6366, 5708, 5224, 5087, 4377, 3919, 3733, 3213, 2507, 2155, 1943, 1161, 419, 444, 81, -684, -908, -1213, -2082, -2660, -2633, -3105, -3852, -4322, -4421, -5296, -5782, -6066, -6273, -7040, -7398, -7582, -8509, -8884, -9199, -9613, -10193, -10462, -10778, -11727, -11759, -12134, -12687, -12838, -13360, -14043, -14443, -14632, -15382, -15748, -15980, -16535, -17067, -17475, -17794, -18171, -18369, -18708, -19248, -19967, -20157, -20476, -20852, -21353, -21473, -21958, -22487, -22827, -23166, -23520, -23673, -24180, -24545, -24865, -25034, -25572, -25918, -26199, -26415, -26973, -27468, -27516, -27796, -28181, -28409, -28672, -29059, -29285, -29551, -29938, -30161, -30430, -30816, -31049, -31026, -31377, -31756, -31910, -31946, -32299, -32488, -32787, -32769, -32728, -32385, -32210, -31511, -30801, -30470, -29863, -28896, -28611, -27655, -26584, -25917, -25420, -24221, -23427, -22809, -21490, -20272, -19731, -19159, -17720, -16757, -16057, -15036, -13970, -13104, -12363, -11155, -10577, -9723, -8321, -7194, -6512, -5640, -4857, -3987, -2889, -1873, -943, -207};