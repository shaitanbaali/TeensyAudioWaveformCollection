/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0087 256 samples */
 
const int16_t AKWF_vgame_0087_256_DATA [256] = 
{7970, 26962, 32471, 29507, 25868, 25982, 28087, 28771, 27386, 26725, 28439, 28392, 27434, 27495, 28254, 28555, 27748, 27433, 27562, 27549, 27537, 27532, 27527, 27520, 27515, 27509, 27502, 27496, 27490, 27484, 27477, 27471, 27464, 27457, 27450, 27444, 27437, 27430, 27423, 27416, 27409, 27402, 27395, 27387, 27380, 27374, 27366, 27358, 27351, 27344, 27337, 27330, 27322, 27328, 27294, 27202, 27681, 28153, 27574, 27082, 27302, 28085, 28595, 28341, 27458, 27363, 28083, 28458, 27927, 27207, 27645, 28287, 28300, 27516, 27041, 27148, 27160, 27137, 27132, 27124, 27116, 27109, 27102, 27095, 27087, 27080, 27073, 27066, 27058, 27051, 27044, 27037, 27029, 27022, 27014, 27007, 27000, 26992, 26985, 26978, 26971, 26964, 26956, 26948, 26942, 26935, 26926, 26930, 26919, 26770, 27199, 28002, 27387, 26884, 27422, 27571, 27195, 26826, 27494, 27997, 27490, 26759, 27373, 28637, 25334, 24865, 30528, 31543, 17517, -9983, -27939, -32728, -29895, -26561, -26454, -29038, -29435, -28044, -27161, -28092, -28900, -27982, -27872, -28383, -28494, -27991, -27902, -28796, -28497, -27634, -27596, -28409, -28812, -27935, -27768, -28250, -28464, -28047, -27728, -28234, -28562, -28311, -27732, -27973, -28376, -27848, -27484, -27717, -28305, -28139, -27582, -27568, -27619, -27596, -27588, -27580, -27574, -27567, -27559, -27552, -27549, -27519, -27538, -27721, -28030, -28357, -28585, -28655, -28624, -28614, -28611, -28602, -28590, -28610, -28570, -28355, -28345, -28567, -28686, -28152, -27400, -27508, -27591, -27376, -27347, -27363, -27351, -27342, -27347, -27325, -27211, -27631, -28236, -27841, -27264, -27273, -27985, -28138, -27463, -27109, -27598, -28356, -27833, -27218, -27209, -27197, -27241, -27320, -27246, -27159, -27166, -27243, -27260, -27164, -27010, -27419, -28151, -27710, -27008, -27038, -27888, -28111, -27252, -26989, -27104, -27119, -26970, -27237, -28046, -28669, -27335, -24852, -26194, -31152, -32914, -16903};