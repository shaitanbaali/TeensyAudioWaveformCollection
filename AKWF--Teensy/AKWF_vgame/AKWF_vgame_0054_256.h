/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0054 256 samples */
 
const int16_t AKWF_vgame_0054_256_DATA [256] = 
{1042, 1532, 1962, 3553, 4509, 5409, 6205, 6807, 7853, 9391, 10014, 11379, 12291, 12314, 13889, 14972, 15183, 16140, 18156, 18854, 19333, 20061, 20746, 22264, 23169, 24347, 25023, 25583, 26320, 27303, 27938, 28605, 29953, 30239, 30541, 30948, 31823, 31899, 32236, 32345, 32359, 32161, 31886, 31795, 31412, 31056, 31022, 30659, 30584, 30499, 29926, 29706, 29599, 29211, 28891, 28511, 27993, 27975, 27856, 27286, 27085, 26957, 26570, 26249, 25877, 25316, 24926, 24781, 24203, 24029, 23888, 23502, 23185, 22776, 22324, 21979, 21492, 21172, 20864, 20310, 19657, 19675, 19267, 18822, 18459, 18004, 17556, 17029, 16869, 16484, 16170, 15733, 15340, 14806, 14390, 14169, 13860, 13099, 12508, 12256, 11615, 11331, 11000, 10525, 10205, 9924, 9101, 8736, 8408, 7731, 7458, 7036, 6590, 6227, 5783, 5190, 4645, 4181, 3820, 3509, 3055, 2194, 2235, 1809, 991, 737, 225, -121, -425, -915, -1734, -2067, -2404, -2920, -3171, -3981, -4422, -4376, -5233, -5687, -6016, -6786, -7011, -7101, -7923, -8478, -8760, -9195, -9934, -10106, -10445, -10750, -11316, -12095, -12397, -13053, -13201, -13545, -13971, -14415, -14698, -15187, -16183, -16142, -16240, -17131, -17504, -17921, -18372, -18286, -18797, -19569, -19817, -20379, -20499, -20877, -21546, -21843, -21822, -22041, -22952, -23173, -23378, -23759, -24063, -24519, -24931, -25250, -25605, -26148, -26205, -26456, -26826, -27135, -27610, -27993, -27930, -28240, -28743, -29087, -29274, -29422, -29775, -30254, -30593, -30645, -31033, -30993, -31238, -31806, -31896, -31965, -32333, -32358, -32722, -32803, -32553, -32314, -32041, -31700, -31283, -30427, -30095, -28758, -28301, -27700, -26957, -25961, -25362, -24552, -22863, -22652, -21543, -20426, -20222, -19232, -17589, -16667, -16039, -15343, -14662, -13182, -12139, -11285, -10445, -9423, -8668, -7311, -6770, -6373, -4804, -3756, -3151, -2356, -1049, -325};