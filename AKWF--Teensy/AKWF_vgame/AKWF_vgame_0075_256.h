/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0075 256 samples */
 
const int16_t AKWF_vgame_0075_256_DATA [256] = 
{1676, 4900, 7679, 10037, 11900, 13218, 13923, 14041, 13700, 12891, 11739, 10373, 8972, 7639, 6501, 5768, 5530, 5739, 6272, 7063, 8047, 9087, 10085, 10967, 11589, 11868, 11796, 11427, 10820, 10013, 9157, 8393, 7770, 7366, 7256, 7458, 7869, 8342, 8819, 9288, 9752, 10198, 10544, 10679, 10553, 10215, 9758, 9239, 8707, 8282, 8053, 8017, 8127, 8337, 8632, 8986, 9370, 9760, 10060, 10162, 10044, 9812, 9607, 9475, 9343, 9115, 8756, 8383, 8157, 8157, 8334, 8608, 8941, 9299, 9578, 9697, 9674, 9619, 9630, 9687, 9674, 9481, 9130, 8768, 8544, 8484, 8535, 8635, 8772, 8939, 9120, 9301, 9463, 9579, 9637, 9636, 9576, 9458, 9293, 9109, 8921, 8743, 8601, 8515, 8489, 8523, 8617, 8764, 8941, 9123, 9297, 9447, 9561, 9638, 9632, 9483, 9166, 8788, 8517, 8437, 8480, 8521, 8484, 8428, 8483, 8726, 9095, 9423, 9590, 9605, 9529, 9415, 9265, 9089, 8901, 8717, 8561, 8455, 8408, 8422, 8496, 8625, 8793, 8979, 9164, 9334, 9470, 9567, 9598, 9508, 9264, 8906, 8538, 8238, 8017, 7898, 7890, 8000, 8244, 8633, 9148, 9685, 10145, 10487, 10647, 10553, 10192, 9596, 8809, 7865, 6914, 6174, 5775, 5733, 6063, 6743, 7743, 9013, 10484, 12018, 13302, 13672, 13638, 13583, 12470, 10442, 7802, 4678, 1164, -2644, -6586, -10553, -14463, -18120, -21444, -24380, -26848, -28845, -30358, -31399, -31999, -32191, -32026, -31550, -30833, -30010, -29188, -28423, -27722, -27091, -26569, -26228, -26137, -26295, -26649, -27133, -27712, -28315, -28837, -29223, -29496, -29704, -29864, -29941, -29884, -29679, -29336, -28862, -28268, -27603, -26962, -26422, -26021, -25802, -25795, -26010, -26494, -27282, -28340, -29515, -30654, -31672, -32432, -32768, -32597, -31886, -30605, -28749, -26348, -23450, -20109, -16437, -12632, -8867, -5213, -1608};