/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0032 256 samples */
 
const int16_t AKWF_vgame_0032_256_DATA [256] = 
{1356, 1584, 4421, 9278, 9862, 9656, 9870, 13806, 14033, 15395, 19511, 19484, 19499, 19363, 20713, 21237, 22055, 23574, 23447, 23469, 23441, 24582, 24774, 25159, 26185, 26176, 26581, 26533, 26820, 27046, 27006, 27012, 26996, 28144, 28343, 29015, 29107, 30526, 31584, 31491, 32660, 32788, 32742, 32849, 30762, 29949, 30238, 28344, 28065, 25432, 23587, 21237, 20680, 21004, 19674, 18501, 18214, 16973, 15541, 15460, 15618, 14292, 13629, 13684, 9776, 5488, 5760, 6014, 4318, 2082, 1612, -1766, -2756, -2634, -2623, -2907, -3150, -3014, -4271, -4980, -4874, -4735, -5553, -7096, -7567, -13749, -14801, -14638, -14267, -16625, -19384, -18969, -21744, -22197, -22778, -23094, -22924, -22580, -22536, -22181, -21985, -21654, -21765, -21389, -20749, -20826, -20783, -20941, -19638, -18995, -18690, -16716, -14681, -11554, -12348, -10177, -7461, -6307, -2679, -799, 1220, 577, 2611, 4206, 4009, 5139, 6273, 6722, 6595, 6766, 7110, 7078, 7084, 7084, 7084, 7084, 7082, 7078, 7112, 6224, 4902, 4833, 4992, 4366, 2093, 2430, 668, -1070, -843, -886, -882, -502, -398, -598, -915, -889, -835, -1074, -2672, -2455, -4071, -5257, -6598, -9135, -8722, -10664, -11078, -11951, -12470, -12443, -12830, -12882, -13669, -13713, -14835, -15031, -15411, -16460, -16366, -16390, -16358, -15967, -15929, -15952, -16435, -16842, -16822, -16825, -16821, -16845, -16745, -16365, -16419, -16113, -15908, -15947, -15942, -15938, -15549, -15495, -15196, -14813, -14576, -14642, -14521, -13722, -13782, -13248, -10548, -9583, -9764, -9824, -7984, -7486, -7262, -5426, -5285, -5314, -5348, -5065, -4869, -4703, -4393, -4434, -4426, -4427, -4430, -4410, -4495, -4865, -4897, -5294, -5286, -5511, -5764, -5877, -6225, -6193, -6198, -6198, -6206, -6164, -6400, -6676, -6632, -6641, -6641, -6625, -6707, -6094, -5662, -5903, -4594, -4106, -2457, -724};