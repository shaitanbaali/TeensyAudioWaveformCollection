/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0127 256 samples */
 
const int16_t AKWF_vgame_0127_256_DATA [256] = 
{5115, 9263, 19487, 19121, 19404, 18179, 25417, 32752, 31538, 31765, 31759, 31757, 31754, 31751, 31746, 31741, 31737, 31732, 31727, 31721, 31715, 31709, 31702, 31695, 31690, 31683, 31676, 31669, 31660, 31652, 31646, 31638, 31630, 31622, 31614, 31607, 31598, 31591, 31587, 31347, 32553, 25956, 17982, 19194, 18953, 18952, 18946, 18941, 18934, 18926, 18920, 18914, 18908, 18902, 18896, 18890, 18884, 18879, 18873, 18868, 18862, 18856, 18851, 18846, 18840, 18834, 18829, 18824, 18818, 18813, 18807, 18802, 18797, 18792, 18787, 18782, 18777, 18771, 18766, 18762, 18756, 18751, 18725, 18719, 18962, 8286, 5640, 6266, 6145, 6141, 6137, 6134, 6130, 6126, 6095, 6154, 6135, -4738, -6892, -6362, -6461, -6464, -6465, -6465, -6466, -6467, -6460, -6692, -5470, -12679, -20050, -18805, -19043, -19035, -19033, -19031, -19028, -19025, -19021, -19019, -19016, -19016, -18788, -19971, -12179, -5213, -7614, 483, 7372, 4942, 13122, 19726, 18511, 18743, 18741, 18741, 18740, 18738, 18736, 18735, 18733, 18730, 18727, 18514, 19652, 11160, 5199, 6357, 6134, 6132, 6130, 6127, 6124, 6122, 6120, 5985, 6716, 3413, -6950, -6363, -6461, -6465, -6466, -6466, -6467, -6466, -6467, -6474, -6554, -6004, -16467, -19636, -18907, -19034, -19033, -19031, -19028, -19026, -19022, -19019, -19017, -19013, -19009, -19004, -19001, -18997, -18993, -18989, -18984, -18980, -18975, -18971, -18966, -18961, -18957, -18952, -18948, -18943, -18938, -18933, -18928, -18924, -18919, -18914, -18909, -18904, -18899, -18894, -18889, -18884, -18877, -19086, -17942, -26958, -32287, -31236, -31420, -31415, -31408, -31402, -31395, -31388, -31381, -31374, -31366, -31359, -31353, -31345, -31337, -31330, -31321, -31314, -31306, -31298, -31290, -31282, -31274, -31267, -31258, -31250, -31242, -31234, -31226, -31218, -31209, -31200, -31014, -31966, -23290, -17730, -18759, -18606, -18571, -7706, -5486, -6466};