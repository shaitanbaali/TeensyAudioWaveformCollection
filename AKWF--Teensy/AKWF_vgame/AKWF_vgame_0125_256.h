/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0125 256 samples */
 
const int16_t AKWF_vgame_0125_256_DATA [256] = 
{5125, 6127, 5895, 5940, 6188, 4904, 12641, 19773, 18540, 18771, 18769, 18768, 18768, 18766, 18765, 18763, 18761, 18758, 18751, 18979, 17765, 26502, 32476, 31351, 31552, 31544, 31434, 32049, 21509, 18087, 18835, 18695, 18690, 18684, 18678, 18673, 18668, 18663, 18657, 18652, 18647, 18641, 18636, 18631, 18626, 18621, 18616, 18610, 18605, 18601, 18595, 18590, 18585, 18580, 18575, 18570, 18565, 18560, 18555, 18549, 18545, 18540, 18535, 18530, 18525, 18520, 18515, 18510, 18505, 18500, 18495, 18490, 18485, 18480, 18475, 18470, 18465, 18461, 18456, 18450, 18445, 18440, 18435, 18430, 18425, 18421, 18416, 18411, 18405, 18401, 18396, 18393, 18195, 19248, 14010, 4653, 5758, 5541, 5543, 5539, 5536, 5532, 5530, 5526, 5524, 5521, 5519, 5516, 5514, 5511, 5509, 5380, 6067, 3036, -7694, -7245, -7310, -7318, -7319, -7318, -7318, -7318, -7318, -7319, -7318, -7317, -7296, -7293, -7527, 3316, 6028, 5384, 5502, 5504, 5504, 5504, 5504, 5503, 5502, 5502, 5501, 5501, 5500, 5499, 5498, 5497, 5496, 5495, 5494, 5493, 5492, 5491, 5489, 5487, 5364, 6018, 3224, -7604, -7296, -7317, -7333, -7333, -7334, -7333, -7332, -7333, -7331, -7330, -7330, -7329, -7327, -7327, -7325, -7324, -7323, -7321, -7320, -7319, -7317, -7317, -7440, -6766, -9596, -20407, -20086, -20103, -20117, -20115, -20112, -20108, -20105, -20101, -20097, -20093, -20089, -20085, -20080, -20076, -20071, -20067, -20062, -20057, -20052, -20047, -20043, -20037, -20033, -20027, -20023, -20017, -20013, -20007, -20002, -19997, -19992, -19987, -19981, -19976, -19969, -20184, -19034, -24958, -33498, -32590, -32748, -32746, -32740, -32733, -32726, -32719, -32712, -32705, -32697, -32690, -32682, -32674, -32666, -32659, -32650, -32643, -32634, -32625, -32618, -32604, -32489, -33077, -23302, -19044, -19911, -19621, -20287, -17426, -6635, -6960, -6822, -7277};