/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0002 256 samples */
 
const int16_t AKWF_vgame_0002_256_DATA [256] = 
{7847, 29872, 33250, 32612, 32738, 32266, 32196, 32700, 32777, 32762, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32765, 32761, 32787, 32548, 32102, 32466, 32781, 32532, 33559, 24500, 2214, -20508, -33415, -32571, -32776, -32576, -32109, -32442, -32786, -32762, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32770, -32739, -32490, -32507, -32750, -32704, -32962, -31830, -21146, -21812, -30259, -13043};