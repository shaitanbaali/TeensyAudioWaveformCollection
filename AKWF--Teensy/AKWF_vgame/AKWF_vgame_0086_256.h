/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0086 256 samples */
 
const int16_t AKWF_vgame_0086_256_DATA [256] = 
{217, 1431, 3369, 4418, 4410, 4442, 4331, 3656, 4106, 5141, 7021, 7987, 8425, 8687, 8181, 7308, 7958, 9358, 10755, 12032, 12053, 12093, 11872, 11272, 11850, 13054, 14478, 15904, 16280, 16231, 15721, 15414, 15772, 16748, 18279, 19270, 20224, 20254, 19675, 19167, 19586, 20558, 21953, 23147, 24125, 24147, 23646, 23050, 23439, 24535, 26038, 26987, 27834, 28011, 27530, 27124, 27377, 28253, 29679, 31082, 32215, 31430, 30742, 31716, 32120, 31136, 29236, 27892, 27166, 27099, 27128, 27721, 27868, 27354, 25594, 23928, 23560, 22937, 23055, 24090, 24292, 23136, 21223, 19991, 19347, 19370, 19295, 19551, 20135, 19408, 17549, 16064, 15248, 15114, 15105, 15648, 15900, 15544, 13953, 12212, 11208, 10915, 11515, 11945, 12407, 11387, 9919, 8465, 7393, 7406, 7415, 8005, 8184, 7638, 6106, 4770, 3372, 3123, 3481, 3953, 3921, 3773, 2376, 1028, -506, -1047, -464, 20, 62, -338, -1219, -3156, -4488, -5032, -4054, -3710, -5313, -7326, -8071, -8551, -8689, -8184, -7706, -7430, -8912, -10942, -12182, -12084, -12084, -12172, -11597, -11461, -13316, -14697, -15595, -16282, -16280, -16170, -15569, -15462, -16812, -18556, -19442, -20305, -20488, -20016, -19603, -19855, -20721, -22214, -23314, -24275, -24116, -23627, -23057, -23663, -24565, -25840, -27231, -27932, -28035, -27493, -27166, -27526, -28437, -29411, -31316, -32293, -31874, -30592, -31091, -32682, -31478, -28926, -27963, -27636, -27093, -27245, -27829, -27898, -27230, -25371, -23866, -23566, -22910, -23252, -23760, -24120, -23328, -21770, -19938, -19357, -19433, -19330, -19717, -20135, -19377, -18123, -16192, -15182, -15177, -15184, -15770, -15950, -15413, -13896, -12477, -11584, -11049, -11108, -12162, -12339, -11508, -10145, -8230, -7430, -7444, -7521, -8126, -8183, -7610, -6466, -4560, -3332, -3179, -3618, -4001, -3983, -3695, -2229, -818, 264, 681, 404, -111, -515};