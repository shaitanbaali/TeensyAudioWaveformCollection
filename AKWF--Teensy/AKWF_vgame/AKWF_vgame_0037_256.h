/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0037 256 samples */
 
const int16_t AKWF_vgame_0037_256_DATA [256] = 
{2605, 4006, 4378, 6295, 8284, 10460, 12070, 14390, 15572, 16706, 17792, 18158, 19041, 20110, 21443, 21747, 22427, 22860, 23175, 23574, 24307, 24680, 24902, 25637, 25993, 26360, 26596, 26566, 26961, 27025, 27022, 26954, 27551, 28092, 28459, 29192, 29822, 30785, 31649, 31810, 32310, 32840, 32714, 32051, 31082, 30027, 28952, 28160, 25703, 23646, 24020, 22286, 20735, 19606, 19048, 18004, 17718, 17373, 16838, 16016, 15097, 14497, 12364, 12041, 10706, 8454, 6448, 4744, 3900, 321, -4, -824, -1734, -2383, -3086, -3100, -3099, -3096, -3444, -3733, -4360, -5376, -6811, -8299, -9173, -10231, -11484, -13767, -15912, -18308, -19921, -20797, -22187, -23065, -23004, -23059, -22840, -22540, -22621, -22414, -22036, -21699, -21361, -20984, -20774, -20848, -20579, -20231, -19808, -18715, -17767, -16317, -14467, -13008, -11820, -9370, -6597, -4523, -2679, -1126, 260, 2027, 3209, 3691, 4318, 5356, 6236, 6692, 6621, 7020, 7100, 7080, 7084, 7084, 7084, 7077, 7112, 6928, 6648, 6480, 5713, 5431, 5018, 4075, 1579, 298, 206, -543, -857, -882, -916, -609, -414, -430, -532, -916, -1255, -1574, -2774, -3376, -4715, -5447, -7015, -8712, -10271, -11480, -11610, -11980, -12326, -12516, -12833, -12944, -13654, -14025, -14776, -15463, -15816, -16184, -16414, -16370, -16408, -16276, -15930, -16352, -16363, -16546, -16858, -16815, -16839, -16772, -16379, -16418, -16150, -15906, -15942, -15970, -15639, -15462, -15533, -15191, -15040, -14999, -14601, -14640, -14391, -14041, -12960, -12905, -12395, -10893, -9921, -8868, -7927, -6650, -6642, -6316, -6044, -5313, -4961, -4786, -4426, -4427, -4427, -4427, -4426, -4427, -4430, -4410, -4495, -4882, -4842, -5104, -5440, -5969, -6228, -6190, -6199, -6198, -6199, -6199, -6198, -6195, -6576, -6657, -6637, -6640, -6638, -6650, -6602, -6226, -5920, -5381, -4555, -3500, -2539, -1589};