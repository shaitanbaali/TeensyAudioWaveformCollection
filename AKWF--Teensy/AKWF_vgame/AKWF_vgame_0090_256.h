/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0090 256 samples */
 
const int16_t AKWF_vgame_0090_256_DATA [256] = 
{1703, 4193, 3908, 2404, 1211, 357, 686, 1679, 2517, 2688, 1903, 1037, 1004, 1935, 2518, 1917, 1578, 1197, 1868, 1843, 1828, 1835, 1836, 1836, 1836, 1836, 1836, 1836, 1836, 1836, 1836, 1836, 1836, 1836, 1834, 1833, 1834, 1834, 1834, 1834, 1832, 1831, 1832, 1832, 1832, 1831, 1831, 1831, 1831, 1830, 1829, 1829, 1829, 1829, 1827, 1826, 1827, 1827, 1825, 1824, 1825, 1825, 1823, 1824, 1804, 1894, 1572, 892, 1292, 2153, 3207, 2848, 432, -1989, -598, 5270, 14659, 24462, 30387, 31729, 30853, 29325, 29153, 29254, 29156, 29330, 30088, 29809, 29140, 29182, 29182, 29172, 29166, 29159, 29153, 29147, 29140, 29133, 29126, 29119, 29112, 29105, 29098, 29090, 29083, 29076, 29068, 29061, 29054, 29046, 29038, 29031, 29024, 29015, 29008, 29000, 28992, 28985, 28978, 28969, 28962, 28955, 28947, 28939, 28932, 28924, 28916, 28909, 28901, 28893, 28884, 28895, 28793, 29096, 29534, 28643, 27679, 27185, 29247, 32377, 32245, 27003, 17075, 6542, 531, -1099, 96, 1279, 2043, 2162, 1443, 1253, 545, 578, 1322, 1338, 1307, 1314, 1311, 1310, 1308, 1307, 1306, 1315, 1216, 1829, 1748, 745, -171, 69, 2337, 5133, 3556, -4393, -15298, -24570, -28651, -28383, -26737, -26068, -26114, -26130, -26029, -26393, -26952, -26967, -26502, -26009, -26099, -26004, -26590, -26991, -26261, -25985, -26062, -26037, -26033, -26027, -26020, -26014, -26008, -26001, -25994, -25989, -25982, -25974, -25968, -25962, -25954, -25948, -25941, -25934, -25927, -25921, -25914, -25907, -25900, -25894, -25887, -25879, -25886, -25829, -25936, -26614, -26730, -26480, -25827, -25746, -26063, -26653, -26684, -26262, -25728, -25717, -26210, -26647, -26614, -26028, -25670, -25723, -26352, -26612, -26508, -25780, -25701, -26493, -26483, -25577, -24830, -24874, -26110, -28804, -29285, -23979, -14445, -4665};