/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0114 256 samples */
 
const int16_t AKWF_vgame_0114_256_DATA [256] = 
{7225, 19783, 24737, 22451, 14106, 3606, -3741, -4952, -736, 5111, 8140, 6910, 4021, 3019, 4397, 6011, 5944, 4715, 3909, 4300, 5142, 5320, 4603, 3922, 4090, 4648, 4913, 4595, 3986, 3828, 4148, 4521, 4470, 3910, 3583, 3721, 4169, 4355, 4150, 3741, 3524, 3609, 3703, 3707, 3671, 3625, 3583, 3546, 3512, 3478, 3446, 3415, 3385, 3356, 3328, 3293, 3288, 3329, 3313, 3254, 3077, 3019, 3077, 3100, 3083, 3054, 3024, 2998, 2974, 2951, 2928, 2907, 2888, 2865, 2851, 2932, 3038, 3138, 3031, 2729, 2508, 2510, 2752, 3029, 3014, 2829, 2633, 2500, 2480, 2606, 2857, 2864, 2702, 2607, 2583, 2580, 2578, 2572, 2561, 2549, 2537, 2530, 2425, 2320, 2298, 2443, 2682, 2592, 2305, 2120, 2185, 2475, 2661, 2453, 2132, 1992, 2215, 2434, 2451, 2200, 2016, 2103, 2210, 2232, 2216, 2196, 2179, 2166, 2157, 2148, 2142, 2135, 2128, 2122, 2115, 2108, 2102, 2097, 2091, 2085, 2078, 2073, 2068, 2063, 2058, 2053, 2047, 2041, 2038, 2024, 2074, 2183, 2222, 2077, 1762, 1694, 2029, 2397, 2363, 1918, 1535, 1642, 2187, 2515, 2156, 1616, 1526, 1982, 2461, 2286, 1723, 1461, 1851, 2455, 2463, 1717, 1054, 1371, 2448, 3030, 2322, 1016, 930, 2429, 3643, 2490, -229, -651, 3211, 7222, 4133, -8226, -23640, -32486, -30149, -19769, -8164, -924, -26, -4163, -9807, -12768, -11601, -8780, -7793, -9421, -11144, -10845, -9153, -8217, -8976, -10238, -10242, -9104, -8152, -8444, -9484, -9869, -9208, -8164, -7912, -8653, -9370, -9162, -8300, -7648, -7945, -8761, -8893, -8216, -7567, -7593, -8296, -8675, -8149, -7425, -7214, -7870, -8500, -8216, -7287, -6730, -7334, -8363, -8397, -7163, -6107, -6901, -8622, -8769, -6314, -4013, -5802, -10981, -12702, -5724};