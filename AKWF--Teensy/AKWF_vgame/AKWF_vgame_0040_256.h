/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0040 256 samples */
 
const int16_t AKWF_vgame_0040_256_DATA [256] = 
{891, 3168, 4636, 5861, 8044, 9473, 11150, 12810, 14983, 15949, 17295, 18342, 18985, 19498, 20539, 21644, 22132, 22680, 23046, 23457, 23983, 24552, 25206, 25315, 25849, 26206, 26563, 26536, 26799, 27049, 26990, 27078, 27387, 27798, 28362, 28717, 29399, 30077, 31334, 31918, 32071, 32642, 32812, 32528, 32080, 30454, 29347, 28697, 26905, 25608, 24302, 23154, 21069, 19954, 19557, 18401, 18126, 17763, 16857, 15746, 15444, 15015, 13538, 12857, 11832, 9689, 6819, 5634, 4057, 1929, 1151, -190, -1328, -2290, -2781, -3121, -3100, -3072, -3262, -3824, -4097, -4734, -6042, -7204, -8055, -9565, -11921, -13773, -14803, -17096, -18851, -19985, -21822, -22862, -23030, -23052, -22823, -22540, -22627, -22374, -22126, -21823, -21668, -21005, -20775, -20814, -20832, -20478, -19952, -19359, -17914, -17237, -15678, -13103, -11898, -9992, -7746, -4939, -3809, -2167, -50, 1105, 2490, 3605, 4551, 4946, 5811, 6701, 6594, 6861, 7119, 7076, 7084, 7084, 7084, 7084, 7076, 7119, 6851, 6645, 6169, 5488, 5088, 3843, 2860, 1799, 556, -169, -770, -904, -875, -900, -539, -390, -742, -908, -905, -1620, -1824, -2615, -3848, -5660, -6646, -7827, -9654, -10589, -11295, -12018, -12327, -12517, -12867, -12818, -12943, -13402, -14280, -15209, -15647, -16211, -16411, -16370, -16409, -16275, -15881, -16191, -16426, -16340, -16631, -16860, -16811, -16854, -16517, -16350, -16418, -16069, -15913, -15945, -15948, -15565, -15506, -15182, -15027, -15060, -15057, -14696, -14518, -14173, -13773, -13266, -12206, -11492, -10569, -9450, -8080, -7828, -6942, -6252, -6130, -5648, -5085, -4834, -4913, -4668, -4392, -4434, -4426, -4426, -4427, -4433, -4397, -4570, -4912, -4812, -5348, -5814, -5722, -6091, -6222, -6193, -6199, -6200, -6196, -6203, -6588, -6654, -6637, -6640, -6641, -6633, -6673, -6359, -6178, -5750, -4613, -4054, -3134, -2060};