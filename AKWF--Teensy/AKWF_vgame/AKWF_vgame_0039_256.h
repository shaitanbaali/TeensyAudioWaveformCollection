/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0039 256 samples */
 
const int16_t AKWF_vgame_0039_256_DATA [256] = 
{146, 997, 2923, 4737, 6032, 6988, 9403, 11551, 13104, 14674, 16250, 17504, 18147, 19021, 19691, 20771, 21552, 21781, 22538, 23173, 23460, 23875, 24415, 24938, 25453, 25960, 26313, 26570, 26662, 27029, 27015, 26978, 27196, 27430, 28050, 28419, 28770, 29433, 30507, 31287, 31769, 32308, 32747, 32751, 32390, 31678, 30187, 28884, 28275, 26808, 25201, 23781, 22599, 20848, 19901, 19659, 18524, 17803, 17336, 16724, 15821, 15341, 14551, 13485, 12447, 10880, 8787, 6685, 5289, 3104, 1796, 478, -777, -1717, -2493, -3035, -3113, -3088, -3124, -3484, -3836, -4399, -5369, -6385, -7620, -9203, -10745, -12337, -14311, -15844, -17645, -19460, -20325, -21931, -22952, -23027, -23041, -22924, -22557, -22609, -22314, -21946, -21635, -21146, -20790, -20809, -20838, -20653, -20100, -19595, -18685, -17541, -16044, -14243, -12445, -10507, -8663, -7381, -4477, -2598, -1144, 592, 2558, 3222, 4316, 4876, 5516, 6408, 6728, 7077, 7084, 7083, 7084, 7084, 7084, 7084, 7083, 7083, 7085, 6667, 6128, 5606, 5118, 4582, 3258, 1977, 662, 51, -472, -892, -877, -913, -576, -421, -423, -757, -930, -1350, -1938, -2949, -3603, -5048, -6564, -7764, -9112, -10432, -11422, -11650, -12179, -12719, -12868, -12816, -12939, -13418, -14225, -14945, -15606, -16056, -16379, -16383, -16375, -16426, -16146, -16172, -16430, -16355, -16475, -16842, -16819, -16844, -16480, -16359, -16402, -16026, -15919, -15950, -15921, -15530, -15496, -15131, -15029, -15092, -14863, -14567, -14645, -14441, -13884, -13377, -12445, -11369, -10344, -9307, -8253, -7571, -7091, -6531, -6190, -5590, -5155, -4852, -4902, -4560, -4398, -4433, -4427, -4426, -4427, -4427, -4431, -4407, -4751, -4911, -5389, -5742, -5966, -6234, -6190, -6199, -6198, -6198, -6206, -6166, -6373, -6674, -6633, -6641, -6641, -6633, -6669, -6399, -5867, -5184, -4704, -3689, -3046, -1885};