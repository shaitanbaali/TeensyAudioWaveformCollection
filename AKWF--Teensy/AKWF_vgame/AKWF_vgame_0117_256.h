/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0117 256 samples */
 
const int16_t AKWF_vgame_0117_256_DATA [256] = 
{922, 2359, 3132, 3709, 4679, 5544, 6557, 7735, 8274, 9191, 10093, 10948, 12176, 13008, 13618, 14893, 15606, 16417, 17682, 18228, 19108, 20017, 20866, 22045, 22964, 23571, 24520, 25404, 26303, 27317, 29269, 24264, 4221, 6049, 7087, 7675, 8855, 9358, 10548, 11680, 12264, 12995, 13944, 14811, 15786, 16995, 17529, 18434, 19298, 20388, 21585, 22205, 22889, 23838, 24720, 25616, 27021, 27512, 28289, 29234, 30058, 30398, 35729, 4124, -22623, -16742, -16447, -15724, -14994, -14057, -12855, -12162, -10998, -10459, -9550, -8629, -7779, -6541, -5739, -5061, -4116, -3224, -2273, -1044, -486, 393, 1314, 2166, 3351, 4213, 5072, 6039, 6679, 7489, 9549, 6868, -14144, -13928, -12631, -11583, -11040, -10104, -9198, -8338, -7076, -6338, -5615, -4672, -3794, -2791, -1613, -732, -144, 753, 1608, 2832, 3664, 4327, 5274, 6162, 7111, 8349, 8908, 9753, 10809, 11353, 14787, 1795, -15231, -11574, -11248, -9864, -9156, -8531, -7563, -6697, -5664, -4519, -3980, -3053, -2140, -1288, -42, 739, 1390, 2677, 3339, 4215, 5445, 5989, 6884, 7803, 8652, 9853, 10719, 11365, 12302, 13037, 14981, -4565, -10157, -7906, -7283, -6193, -5143, -4476, -3343, -2771, -1853, -587, 111, 856, 1796, 2663, 3691, 4850, 5383, 6317, 7166, 8300, 9467, 10062, 10788, 11729, 12614, 13542, 14939, 15384, 16212, 16324, 21497, 1975, -35145, -30884, -30580, -29751, -28467, -27811, -27039, -26063, -24894, -24177, -23041, -22501, -21563, -20644, -19793, -18520, -17781, -17061, -16102, -15229, -14226, -13031, -12495, -11581, -10653, -9813, -8566, -7792, -6856, -6300, -3744, -11394, -29479, -27141, -26570, -25640, -24801, -23614, -22678, -22071, -21102, -20235, -18971, -18270, -17507, -16571, -15685, -14657, -13498, -12637, -12047, -11113, -10254, -9012, -8231, -7526, -6583, -5690, -4715, -3509, -2947, -2096, -1005, 1};