/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0124 256 samples */
 
const int16_t AKWF_vgame_0124_256_DATA [256] = 
{18711, 19915, 19637, 19691, 19934, 18669, 26648, 33519, 32323, 32542, 32539, 32536, 32533, 32530, 32525, 32520, 32515, 32510, 32504, 32498, 32491, 32486, 32478, 32471, 32466, 32458, 32450, 32443, 32435, 32428, 32420, 32412, 32404, 32396, 32388, 32381, 32372, 32364, 32355, 32347, 32339, 32331, 32188, 32938, 29501, 18935, 19548, 19439, 19428, 19420, 19414, 19406, 19400, 19393, 19387, 19380, 19375, 19368, 19362, 19356, 19350, 19346, 19554, 18369, 27263, 33096, 31848, 32648, 22129, 18652, 19431, 19283, 19277, 19271, 19265, 19259, 19253, 19247, 19243, 19125, 19727, 17153, 6135, 6405, 6377, 6361, 6356, 6353, 6349, 6346, 6342, 6338, 6339, 6102, 7346, -313, -7556, -6279, -6525, -6524, -6525, -6526, -6527, -6526, -6526, -6526, -6526, -6527, -6523, -6716, -5664, -10788, -20258, -19163, -19374, -19363, -19360, -19358, -19355, -19352, -19349, -19346, -19342, -19337, -19219, -19766, -17793, 4827, 6772, 17250, 19679, 19117, 19222, 19223, 19223, 19223, 19221, 19220, 19218, 19216, 19196, 19159, 19551, 8818, 5777, 6488, 6354, 6350, 6347, 6344, 6342, 6341, 6338, 6334, 6195, 6936, 3712, -6941, -6443, -6506, -6519, -6521, -6521, -6521, -6522, -6521, -6521, -6511, -6753, -5508, -13562, -20354, -19136, -19365, -19358, -19355, -19353, -19350, -19347, -19344, -19340, -19337, -19333, -19329, -19364, -19209, -19623, -30451, -32286, -32939, -27651, -6695, -5338, -13645, -20271, -19047, -19273, -19262, -19257, -19253, -19248, -19242, -19238, -19232, -19228, -19223, -19218, -19214, -19294, -18831, -20638, -31542, -32131, -31987, -32019, -32013, -32006, -32000, -31993, -31986, -31979, -31972, -31965, -31957, -31949, -31941, -31933, -31926, -31918, -31910, -31902, -31894, -31886, -31877, -31870, -31861, -31852, -31845, -31836, -31828, -31820, -31811, -31803, -31795, -31786, -31778, -31768, -31578, -32555, -27238, -17974, -19651, -9080, -5394, -6024, -6581};