/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0034 256 samples */
 
const int16_t AKWF_vgame_0034_256_DATA [256] = 
{546, 3155, 3639, 3631, 6539, 8037, 10716, 11003, 13288, 13517, 16498, 17463, 18733, 18767, 20570, 21930, 21687, 22230, 23202, 23226, 23486, 24254, 24957, 25216, 25845, 25903, 26263, 26275, 26995, 27171, 27133, 27153, 27088, 27360, 28488, 29252, 29306, 29805, 30722, 30980, 32026, 32427, 32559, 32433, 32607, 31879, 30286, 29223, 27141, 25212, 25582, 24418, 22240, 20920, 19964, 19411, 18673, 18225, 17385, 16203, 15485, 15298, 13126, 12266, 12755, 9641, 8443, 6747, 5141, 2352, 1796, -153, -942, -1689, -2249, -2630, -3186, -3111, -3051, -3719, -3986, -4580, -5999, -7694, -7366, -9505, -10094, -12557, -14269, -18567, -21292, -20861, -20745, -22286, -23290, -23130, -22849, -22660, -22696, -22703, -22651, -21867, -21802, -21073, -20871, -20927, -20879, -20476, -20525, -19111, -16497, -16528, -16125, -13026, -12727, -9951, -8175, -4829, -4432, -1318, -1415, 2616, 4166, 4510, 5449, 5286, 5435, 6606, 6694, 7056, 7132, 7114, 7118, 7118, 7117, 7116, 7128, 6755, 6646, 6700, 6564, 5516, 4830, 3288, 1450, 1344, 1179, -352, -614, -913, -878, -902, -843, -416, -615, -927, -866, -2068, -3289, -2875, -4322, -5819, -6595, -8417, -10036, -11243, -11522, -12021, -12302, -12970, -12855, -13602, -13858, -13682, -14344, -15150, -15465, -16533, -16447, -16461, -16461, -16462, -16466, -16441, -16552, -16921, -16903, -16905, -16898, -16929, -16642, -16259, -15990, -16025, -16012, -16045, -15694, -15579, -15314, -15093, -15129, -15149, -14781, -14682, -14441, -13511, -13295, -13429, -11544, -11133, -9954, -9151, -7715, -7552, -6450, -6224, -5578, -5340, -5004, -4402, -4457, -4448, -4447, -4447, -4447, -4447, -4448, -4448, -4453, -4425, -4752, -4934, -5970, -6279, -6216, -6229, -6228, -6228, -6229, -6229, -6232, -6210, -6572, -6695, -6667, -6672, -6672, -6674, -6340, -6069, -5334, -5352, -3709, -1696, -1859, -1473};