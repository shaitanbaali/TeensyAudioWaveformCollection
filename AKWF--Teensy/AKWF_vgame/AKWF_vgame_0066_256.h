/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0066 256 samples */
 
const int16_t AKWF_vgame_0066_256_DATA [256] = 
{6920, 14355, 11293, 7903, 8532, 10150, 9865, 9361, 9768, 9755, 9752, 9754, 9754, 9754, 9754, 9754, 9753, 9753, 9752, 9750, 9749, 9747, 9746, 9745, 9743, 9741, 9739, 9737, 9736, 9734, 9732, 9729, 9727, 9725, 9723, 9720, 9718, 9716, 9713, 9711, 9708, 9706, 9704, 9701, 9699, 9696, 9694, 9691, 9688, 9686, 9684, 9681, 9679, 9676, 9674, 9671, 9669, 9666, 9664, 9660, 9658, 9656, 9653, 9650, 9648, 9645, 9643, 9640, 9637, 9635, 9632, 9630, 9628, 9625, 9622, 9620, 9617, 9614, 9612, 9609, 9607, 9604, 9602, 9599, 9597, 9593, 9591, 9589, 9586, 9584, 9581, 9579, 9576, 9573, 9571, 9569, 9565, 9563, 9561, 9558, 9555, 9553, 9550, 9547, 9545, 9542, 9540, 9538, 9535, 9532, 9530, 9527, 9525, 9523, 9520, 9517, 9514, 9512, 9509, 9507, 9504, 9502, 9500, 9496, 9494, 9491, 9489, 9486, 9484, 9481, 9479, 9476, 9473, 9471, 9468, 9466, 9464, 9461, 9458, 9456, 9454, 9451, 9448, 9446, 9443, 9441, 9438, 9436, 9433, 9430, 9428, 9426, 9423, 9420, 9418, 9416, 9413, 9410, 9408, 9405, 9403, 9400, 9398, 9396, 9389, 9406, 9348, 9044, 9390, 9373, 9426, 9152, 9154, 9417, 9361, 9368, 9018, 9323, 9383, 9336, 8861, 9056, 9747, 9824, 8945, 7971, 7915, 9414, 12179, 12314, 3686, -13143, -27820, -32758, -30381, -27584, -27389, -28105, -28717, -29300, -29122, -28402, -28367, -28808, -28784, -28776, -28772, -28767, -28761, -28756, -28749, -28743, -28734, -28746, -28680, -28374, -28719, -28705, -28696, -28689, -28683, -28676, -28668, -28661, -28654, -28646, -28639, -28631, -28624, -28616, -28610, -28602, -28595, -28587, -28580, -28572, -28564, -28557, -28549, -28542, -28535, -28523, -28530, -28495, -28006, -28242, -28527, -28509, -28273, -27980, -27038, -27419, -30911, -32096, -22413, -7286};