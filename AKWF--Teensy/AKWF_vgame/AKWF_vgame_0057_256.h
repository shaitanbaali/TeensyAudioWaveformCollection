/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0057 256 samples */
 
const int16_t AKWF_vgame_0057_256_DATA [256] = 
{373, 1179, 2268, 3019, 3858, 5338, 6078, 6542, 7959, 8703, 9617, 10564, 11622, 12298, 13287, 14740, 15309, 15874, 17023, 18359, 18991, 19931, 20966, 21621, 22634, 23582, 24616, 25015, 26043, 27103, 27455, 28227, 29180, 29964, 30380, 31090, 31477, 31705, 32261, 32346, 32330, 32321, 31937, 31893, 31562, 31379, 31033, 30998, 30651, 30282, 30097, 29776, 29586, 29219, 28894, 28712, 28340, 28019, 27835, 27461, 27140, 26956, 26583, 26259, 26100, 25565, 25214, 24924, 24720, 24183, 23838, 23620, 23211, 22696, 22533, 21991, 21651, 21402, 21166, 20412, 20078, 19810, 19646, 19020, 18752, 18444, 17672, 17453, 17086, 16632, 16280, 15784, 15659, 14959, 14470, 14352, 13825, 13147, 13042, 12503, 11833, 11715, 11235, 10623, 10047, 9940, 9300, 8733, 8627, 7979, 7425, 7285, 6773, 6105, 5655, 5501, 4777, 4350, 4149, 3624, 2921, 2590, 2353, 1586, 1286, 1003, 472, -252, -471, -815, -1582, -1781, -2147, -2697, -3403, -3544, -4000, -4720, -4861, -5297, -5882, -6524, -6625, -7197, -7838, -7947, -8502, -9241, -9593, -9737, -10401, -10927, -11082, -11591, -12275, -12692, -12861, -13603, -13997, -14214, -14750, -15049, -15580, -16054, -16362, -16915, -17035, -17640, -17942, -18238, -18821, -19207, -19591, -20046, -20394, -20567, -20962, -21529, -21896, -22221, -22406, -23092, -23210, -23709, -24089, -24415, -24573, -25105, -25457, -25753, -25948, -26480, -26820, -27083, -27325, -27714, -27962, -28204, -28594, -28837, -29081, -29470, -29706, -29986, -30197, -30507, -30882, -31064, -31414, -31461, -31798, -31979, -32323, -32356, -32723, -32773, -32776, -32709, -32013, -31851, -31432, -30868, -30178, -29583, -28654, -27639, -27374, -26377, -25444, -24410, -23861, -22698, -21800, -21082, -20356, -19317, -18143, -17514, -16299, -15546, -14840, -13841, -12467, -11472, -11114, -9845, -8877, -8107, -7121, -6073, -5308, -4496, -3018, -2239, -1758, -789};