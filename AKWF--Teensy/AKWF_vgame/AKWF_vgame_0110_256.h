/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0110 256 samples */
 
const int16_t AKWF_vgame_0110_256_DATA [256] = 
{15220, 13723, 14067, 14012, 14020, 14026, 14031, 14034, 14037, 14038, 14038, 14038, 14038, 14038, 14035, 14033, 14030, 14027, 14024, 14020, 14016, 14011, 14007, 14001, 13996, 13989, 13983, 13977, 13972, 13966, 13958, 13951, 13945, 13939, 13932, 13924, 13918, 13912, 13906, 13898, 13891, 13884, 13876, 13869, 13861, 13855, 13848, 13840, 13833, 13825, 13818, 13811, 13802, 13795, 13789, 13781, 13774, 13767, 13759, 13751, 13745, 13736, 13729, 13722, 13714, 13708, 13699, 13692, 13685, 13677, 13669, 13662, 13655, 13647, 13639, 13632, 13625, 13618, 13610, 13602, 13596, 13587, 13580, 13572, 13565, 13558, 13551, 13543, 13536, 13529, 13521, 13513, 13507, 13498, 13491, 13484, 13476, 13468, 13461, 13454, 13447, 13439, 13432, 13425, 13418, 13409, 13403, 13395, 13389, 13381, 13373, 13366, 13358, 13351, 13343, 13336, 13329, 13322, 13315, 13308, 13301, 13292, 13285, 13278, 13269, 12959, 14573, 7312, -11169, -9746, -9976, -9992, -9995, -9997, -9998, -10000, -10000, -9999, -9997, -9998, -9996, -9994, -9992, -9989, -9987, -9984, -9981, -9977, -9973, -9970, -9965, -9962, -9958, -9953, -9948, -9945, -9939, -9934, -9930, -9927, -9922, -9917, -9911, -9906, -9902, -9899, -9893, -9888, -9883, -9878, -9873, -9868, -9863, -9858, -9853, -9847, -9842, -9838, -9832, -9827, -9821, -9817, -9810, -9805, -9801, -9796, -9790, -9785, -9781, -9776, -9772, -9767, -9760, -9755, -9751, -9745, -9740, -9734, -9729, -9724, -9719, -9714, -9709, -9704, -9698, -9693, -9688, -9683, -9678, -9673, -9668, -9663, -9659, -9653, -9648, -9642, -9637, -9632, -9627, -9623, -9617, -9611, -9607, -9602, -9597, -9591, -9586, -9580, -9575, -9570, -9566, -9762, -8622, -13431, -33187, -32687, -32731, -32743, -32732, -32723, -32713, -32700, -32689, -32676, -32663, -32650, -32636, -32622, -32608, -32592, -32577, -32562, -32539, -32075, -34499, -20354};