/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0021 256 samples */
 
const int16_t AKWF_vgame_0021_256_DATA [256] = 
{1880, 4232, 5821, 7319, 9983, 9981, 11509, 13138, 14013, 15379, 17188, 19680, 19672, 20273, 21502, 22783, 23661, 24550, 25357, 25396, 26129, 26800, 27474, 28179, 29548, 30130, 30636, 31080, 31369, 31500, 31331, 30996, 31027, 31021, 31027, 30987, 31356, 31332, 30727, 30565, 29550, 28771, 28110, 27417, 26785, 25740, 25120, 23390, 21965, 20804, 19814, 18794, 17795, 16676, 16067, 14886, 13185, 11738, 10795, 9767, 8743, 7759, 6635, 5344, 4755, 3559, 2204, 1175, 366, -163, -487, -729, -1714, -2732, -2542, -3220, -3551, -3480, -3506, -3143, -3014, -3177, -3524, -3465, -3608, -3954, -3918, -3963, -3758, -3462, -3493, -3838, -4008, -3318, -3057, -2644, -1893, -1253, -943, -595, 306, 426, 967, 1685, 2356, 2988, 4154, 5180, 5454, 6198, 6835, 7320, 8374, 9608, 10454, 10782, 11529, 12211, 12519, 13121, 13728, 13915, 14429, 14921, 14839, 14847, 14885, 14689, 14376, 14452, 14267, 13893, 13560, 13222, 12881, 12539, 12201, 11858, 11690, 11303, 10624, 9910, 9419, 9045, 8339, 7636, 7156, 6972, 6682, 6329, 5984, 5667, 5673, 5713, 5513, 4803, 4859, 4496, 3817, 3534, 3164, 2985, 2635, 2596, 2294, 1612, 1217, 1052, -78, -970, -898, -1287, -1897, -2846, -3720, -4693, -5237, -5487, -6955, -6952, -7498, -8164, -9215, -9636, -10263, -10584, -10864, -11883, -12666, -13704, -14071, -15044, -16091, -16989, -17494, -17702, -18593, -18918, -19579, -20612, -21400, -22158, -23193, -23875, -24224, -24953, -26383, -27187, -27841, -28529, -29195, -29905, -30402, -30595, -30874, -31230, -31570, -31908, -32243, -32611, -32793, -32761, -32765, -32779, -32711, -32359, -32026, -31706, -31246, -30633, -29418, -28746, -28843, -27742, -27030, -26170, -25295, -23689, -23186, -22354, -21282, -20911, -19718, -18480, -16466, -16202, -15249, -13797, -12398, -10731, -9927, -5983, -5655, -4573, -2957, -1162};