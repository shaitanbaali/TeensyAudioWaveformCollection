/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0018 256 samples */
 
const int16_t AKWF_vgame_0018_256_DATA [256] = 
{1112, 2125, 5437, 5744, 7578, 7798, 10058, 11364, 13835, 13983, 16549, 19246, 19175, 19436, 20932, 21064, 22881, 23543, 24471, 24646, 25765, 25846, 27023, 26957, 29304, 30793, 30517, 30657, 31423, 31461, 31487, 31188, 30989, 31030, 31017, 31027, 31434, 31394, 30303, 30103, 30181, 30053, 28602, 28038, 26930, 25458, 25354, 25145, 23028, 21877, 20027, 19791, 18351, 18132, 16433, 15205, 13439, 13269, 10490, 8993, 9371, 8321, 6953, 6419, 4862, 3593, 2584, 1933, 793, 638, -16, -135, -2292, -2709, -2543, -2901, -3552, -3485, -3488, -3107, -3046, -3072, -3012, -3264, -3970, -3923, -3930, -3925, -3955, -3824, -3433, -3767, -3843, -3444, -3586, -3067, -2202, -1401, -812, -671, -493, 25, 867, 1713, 2197, 2710, 4749, 5280, 5435, 7005, 6893, 7709, 8359, 9736, 10040, 10981, 11367, 11874, 12174, 12873, 14482, 14412, 14380, 14689, 14880, 14868, 14758, 14400, 14419, 14400, 14486, 13946, 13554, 12858, 12146, 12235, 12302, 11737, 11286, 10708, 9944, 9529, 9724, 8823, 8204, 7555, 7441, 6760, 6538, 6288, 6079, 5731, 5673, 5658, 4880, 4792, 4778, 3997, 3919, 3594, 3407, 3069, 3004, 2232, 2179, 1411, 1408, 263, -1007, -839, -883, -1661, -1727, -2946, -4455, -5353, -5234, -6041, -6103, -7136, -7612, -9328, -9669, -9598, -9603, -10660, -11187, -12225, -13719, -14040, -13979, -15408, -16127, -17500, -17552, -18321, -18390, -19450, -20013, -20990, -21071, -23134, -24581, -24345, -24931, -26262, -26411, -27407, -28283, -29356, -29502, -30164, -30297, -31048, -30988, -31982, -32405, -32296, -32416, -32774, -32766, -32767, -32763, -32789, -32652, -32341, -32193, -31570, -30877, -28834, -28819, -28911, -28527, -27181, -26386, -24974, -24005, -24149, -23510, -21466, -20550, -19640, -19064, -17924, -17291, -15383, -13925, -12576, -12046, -7763, -5795, -6427, -4396, -3014, -1990, -280};