/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0044 256 samples */
 
const int16_t AKWF_vgame_0044_256_DATA [256] = 
{1627, 3204, 5053, 4748, 4813, 4790, 4882, 7218, 10118, 11593, 11298, 11377, 11286, 11666, 14561, 17171, 18075, 17874, 17915, 17954, 17735, 20474, 24211, 24531, 24441, 24465, 24523, 24219, 25783, 30176, 30149, 30135, 30147, 30182, 29994, 31203, 32469, 32301, 32331, 32331, 32320, 32381, 32105, 31413, 31462, 31483, 30744, 30531, 30657, 30247, 29645, 29708, 29780, 29251, 28752, 28923, 28385, 27893, 27964, 28030, 27669, 26572, 26755, 25805, 25247, 25347, 25400, 25038, 24392, 24539, 23460, 23086, 23164, 23185, 23040, 21895, 21821, 20704, 20491, 20542, 20518, 20596, 19603, 19009, 17564, 17453, 17480, 17474, 17479, 16413, 15888, 14836, 14859, 14855, 14823, 14972, 13924, 12597, 11746, 11811, 11794, 11771, 11872, 11425, 9415, 8655, 8760, 8736, 8706, 8841, 8153, 6144, 5607, 5673, 5799, 4517, 3787, 4075, 2753, 2068, 2209, 2183, 2183, 2170, 2255, 826, 325, 548, -28, -972, -842, -892, -2413, -2684, -2566, -2781, -4326, -4346, -4510, -6057, -6149, -6052, -6363, -7482, -7344, -7745, -9223, -9168, -9173, -9163, -10320, -10424, -10992, -12341, -12208, -12256, -12132, -13030, -13509, -14261, -15425, -15259, -15309, -15207, -16243, -16579, -17314, -18012, -17891, -17944, -17781, -18638, -19707, -20526, -21054, -20953, -20981, -20930, -21146, -22234, -23339, -23649, -23578, -23607, -23525, -23889, -24983, -25681, -25799, -25772, -25781, -25778, -25761, -27075, -28412, -28401, -28396, -28405, -28388, -28438, -29426, -30187, -30139, -30147, -30148, -30169, -30045, -31082, -32004, -31871, -31896, -31895, -31910, -31833, -32270, -32827, -32761, -32738, -32355, -32295, -32467, -31309, -30452, -30578, -30746, -28712, -27761, -28193, -25799, -24713, -24933, -24972, -22359, -21708, -21951, -19324, -18661, -18750, -19071, -16873, -15061, -15218, -12070, -11720, -11775, -11960, -11032, -8703, -8327, -5266, -5228, -5200, -5461, -4095, -2112, -1550};