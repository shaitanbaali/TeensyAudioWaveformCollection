/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0098 256 samples */
 
const int16_t AKWF_vgame_0098_256_DATA [256] = 
{4740, 15062, 25016, 30969, 32475, 31907, 31612, 31837, 32113, 32143, 32042, 31933, 31835, 31764, 31791, 32015, 32447, 32761, 32577, 31846, 31092, 30920, 31410, 32046, 32259, 31964, 31499, 31204, 31123, 31208, 31450, 31850, 32203, 32232, 31885, 31422, 31156, 31145, 31280, 31457, 31666, 31795, 31675, 31266, 30803, 30589, 30683, 30956, 31269, 31599, 31821, 31735, 31277, 30741, 30547, 30805, 31223, 31436, 31349, 31107, 30871, 30674, 30546, 30558, 30734, 30977, 31140, 31188, 31132, 30978, 30716, 30460, 30390, 30566, 30842, 31003, 30997, 30860, 30586, 29998, 29547, 30168, 31962, 32658, 31811, 26543, 18152, 8483, -1930, -11637, -17731, -18926, -17116, -15554, -15525, -16325, -17114, -17708, -18126, -18008, -17148, -16032, -15581, -16217, -17365, -18026, -17777, -17021, -16425, -16260, -16357, -16511, -16645, -16762, -16804, -16744, -16600, -16409, -16176, -15967, -15925, -16131, -16463, -16672, -16644, -16452, -16208, -15932, -15715, -15795, -16342, -17086, -17442, -17059, -16254, -15695, -15741, -16171, -16559, -16698, -16655, -16492, -16215, -15895, -15789, -16067, -16558, -16845, -16674, -16206, -15798, -15661, -15718, -15828, -15906, -15978, -16066, -16196, -16329, -16373, -16244, -16027, -15978, -16271, -16774, -17124, -17091, -16766, -16366, -15989, -15685, -15683, -16192, -17018, -17510, -17192, -16296, -15584, -15576, -16099, -16659, -16950, -17009, -16843, -16417, -15826, -15451, -15610, -16181, -16686, -16783, -16548, -16243, -16044, -15940, -15942, -16066, -16291, -16498, -16608, -16616, -16472, -16105, -15584, -15280, -15514, -16182, -16759, -16835, -16476, -16009, -15662, -15442, -15473, -15924, -16705, -17193, -16834, -15740, -14750, -14573, -15130, -15837, -16220, -16295, -16157, -15846, -15383, -15009, -14955, -15204, -15527, -15725, -15791, -15750, -15624, -15420, -15207, -15022, -14874, -14929, -15411, -16276, -16805, -16184, -14473, -13125, -13675, -15997, -17972, -17484, -14378, -10389, -7365, -5411, -1917};