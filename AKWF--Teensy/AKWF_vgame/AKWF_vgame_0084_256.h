/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0084 256 samples */
 
const int16_t AKWF_vgame_0084_256_DATA [256] = 
{279, 88, 522, 5220, 20521, 22492, 23920, 24193, 26456, 26191, 27230, 29480, 29283, 31235, 32538, 32296, 29739, 29390, 28680, 26374, 27038, 24626, 23658, 23493, 20748, 20894, 19301, 17474, 18015, 16158, 14447, 14822, 12400, 11674, 11012, 8571, 8726, 6861, 5435, 5665, 3185, 3134, 2044, -337, 270, -2267, -3248, -2818, -5274, -6055, -6420, -8841, -8336, -10460, -11717, -11895, -14306, -14841, -13688, -11435, -11785, -9694, -8767, -8767, -5987, -6449, -4219, -5965, -21511, -18665, -17213, -17894, -15012, -14675, -13921, -11746, -11882, -9938, -8734, -8565, -6351, -5806, -4828, -2772, -3287, -1031, 267, 8, 2452, 3106, 3527, 6205, 5738, 7517, 8836, 8687, 11532, 11480, 12780, 14818, 14745, 12645, 11530, 11373, 8731, 9047, 8318, 6046, 5965, 4318, 2829, 2908, 445, 96, -584, -3343, -2649, -4696, -5867, -5992, -8538, -8598, -9918, -12036, -11250, -13200, -14771, -14694, -17036, -17418, -19108, -19170, -4032, -4491, -6257, -5925, -8596, -8734, -9561, -11810, -11277, -13757, -14764, -14334, -11902, -11572, -11183, -8870, -9248, -7159, -5838, -5698, -3314, -2950, -1995, 263, -163, 1801, 3344, 3099, 5798, 5778, 6879, 8910, 8616, 11034, 11821, 11682, 14435, 14624, 15562, 17924, 17579, 19572, 20828, 20875, 23435, 23719, 24570, 26899, 26356, 28535, 29448, 29479, 32230, 32562, 31088, 29118, 29580, 27782, 26375, 26627, 23922, 23682, 23216, 14344, 1891, 1127, -148, -166, -2836, -2928, -3924, -6364, -5516, -7896, -9035, -8981, -11431, -11757, -12483, -14957, -14383, -16704, -17825, -17987, -20341, -20597, -21572, -23814, -23569, -25704, -26937, -26883, -29444, -29196, -30068, -32190, -32467, -30745, -28977, -29477, -26839, -26837, -25685, -23407, -23848, -21431, -20525, -20238, -17825, -17682, -16538, -14294, -14775, -13229, -11455, -11470, -9087, -8416, -8057, -5607, -6030, -3847, -2536, -2942};