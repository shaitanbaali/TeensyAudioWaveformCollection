/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0074 256 samples */
 
const int16_t AKWF_vgame_0074_256_DATA [256] = 
{8939, 23956, 31950, 31875, 26683, 22170, 21164, 23628, 26381, 27557, 26258, 24314, 24040, 25046, 26069, 26383, 25897, 25268, 24413, 24878, 25310, 25845, 25941, 25421, 24922, 24759, 25199, 25233, 25927, 25436, 25079, 25150, 25128, 25123, 25117, 25111, 25104, 25098, 25091, 25084, 25078, 25071, 25065, 25059, 25052, 25046, 25039, 25033, 25026, 25019, 25013, 25006, 24999, 24992, 24986, 24980, 24973, 24967, 24960, 24953, 24946, 24940, 24933, 24926, 24920, 24913, 24907, 24900, 24894, 24887, 24880, 24873, 24867, 24859, 24853, 24846, 24839, 24833, 24827, 24820, 24813, 24806, 24800, 24793, 24786, 24780, 24773, 24766, 24760, 24754, 24747, 24740, 24734, 24727, 24720, 24713, 24707, 24700, 24693, 24689, 24685, 24621, 25258, 25232, 24634, 24176, 24469, 24947, 25399, 25274, 24372, 23831, 23936, 24711, 25651, 26637, 25704, 23170, 21796, 21924, 24523, 27400, 29339, 28439, 24235, 15095, 1476, -13117, -25336, -31248, -30140, -25688, -22521, -21980, -23448, -25256, -25447, -25428, -24871, -24650, -24705, -24689, -24687, -24684, -24679, -24674, -24670, -24665, -24661, -24654, -24649, -24644, -24638, -24633, -24627, -24621, -24615, -24610, -24604, -24598, -24591, -24585, -24579, -24573, -24566, -24560, -24554, -24548, -24541, -24536, -24529, -24523, -24516, -24510, -24503, -24497, -24490, -24483, -24476, -24470, -24464, -24458, -24451, -24445, -24438, -24432, -24425, -24419, -24412, -24405, -24399, -24392, -24386, -24380, -24373, -24367, -24360, -24354, -24347, -24340, -24334, -24327, -24321, -24314, -24309, -24302, -24295, -24289, -24281, -24275, -24268, -24262, -24255, -24249, -24243, -24241, -24220, -24245, -24736, -24971, -24526, -24180, -24190, -24177, -24658, -24900, -24871, -24326, -23904, -23858, -24216, -24679, -24880, -24444, -23961, -23341, -23728, -24763, -25246, -24830, -23721, -23224, -23575, -24606, -26068, -26052, -24060, -21884, -21369, -22715, -25124, -27227, -28425, -26570, -19434, -6690};