/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0071 256 samples */
 
const int16_t AKWF_vgame_0071_256_DATA [256] = 
{26520, 30163, 29303, 29411, 29504, 29423, 29360, 29339, 29432, 29375, 29390, 29401, 29321, 29298, 29294, 29486, 29406, 29453, 29345, 29371, 29636, 29621, 29615, 29609, 29602, 29595, 29587, 29580, 29574, 29566, 29558, 29551, 29542, 29547, 29483, 29429, 29440, 29458, 29509, 29489, 29483, 29474, 29473, 29444, 29109, 29070, 29069, 29060, 29056, 29022, 29138, 29195, 29157, 29216, 29139, 29146, 29202, 29012, 29028, 29158, 29149, 28654, 30099, 24804, -9811, -9789, -9766, -9710, -9782, -9726, -9754, -9789, -9896, -9842, -9766, -9822, -9839, -9762, -9775, -9838, -9879, -9732, -9797, -9707, -9988, -9976, -9976, -9975, -9973, -9972, -9970, -9968, -9966, -9964, -9962, -9959, -9957, -9956, -9954, -9951, -9948, -9946, -9944, -9941, -9939, -9936, -9934, -9931, -9929, -9927, -9924, -9921, -9919, -9916, -9914, -9911, -9908, -9906, -9903, -9900, -9898, -9896, -9893, -9890, -9887, -9885, -9882, -9880, -9876, -9874, -9872, -9869, -9866, -9864, -9861, -9859, -9856, -9853, -9851, -9848, -9845, -9843, -9840, -9837, -9835, -9832, -9830, -9827, -9824, -9822, -9819, -9817, -9814, -9811, -9808, -9806, -9803, -9800, -9798, -9796, -9793, -9790, -9787, -9785, -9782, -9780, -9777, -9775, -9772, -9769, -9767, -9764, -9761, -9759, -9756, -9753, -9751, -9748, -9746, -9743, -9741, -9738, -9735, -9732, -9730, -9727, -9725, -9722, -9719, -9716, -9714, -9712, -9709, -9707, -9703, -9701, -9699, -9696, -9693, -9691, -9688, -9685, -9683, -9680, -9678, -9675, -9673, -9670, -9667, -9665, -9662, -9660, -9657, -9655, -9652, -9649, -9646, -9644, -9642, -9639, -9637, -9633, -9631, -9628, -9626, -9623, -9621, -9618, -9616, -9613, -9610, -9608, -9605, -9603, -9598, -9607, -9557, -9296, -9503, -9403, -9327, -9400, -9397, -9400, -9446, -9317, -9451, -9439, -9327, -9405, -9206, -9469, -9291, -9393, -8792, -10885};