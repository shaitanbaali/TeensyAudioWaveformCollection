/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0104 256 samples */
 
const int16_t AKWF_vgame_0104_256_DATA [256] = 
{13260, 16495, 15778, 15915, 16017, 15458, 17773, 29844, 29885, 29822, 29846, 29887, 29641, 30890, 32966, 32715, 32754, 32749, 32720, 32659, 33063, 20643, 16552, 17484, 17305, 17298, 17292, 17287, 17281, 17276, 17268, 17094, 18012, 14140, -1374, -1064, -1062, -1098, -1231, -546, -4169, -8998, -8319, -8445, -8447, -8428, -8544, -7443, -6889, -7005, -6982, -6969, -7019, -6868, -3647, -3222, -3331, -3310, -3309, -3307, -3308, -3306, -3305, -3305, -3303, -3372, -3006, -5068, -7257, -6902, -6967, -6963, -7099, -6351, -15117, -18579, -17826, -17957, -17955, -17951, -17949, -17946, -17943, -17940, -17937, -17798, -18520, -15206, -7089, -7771, -7643, -7642, -7639, -7637, -7633, -7631, -7628, -7625, -7622, -7572, -7842, -3064, -1118, -3407, -7936, -7535, -7601, -7602, -7599, -7597, -7595, -7593, -7632, -7402, -8496, -10714, -10471, -10515, -10516, -10355, -11185, -5436, -1028, -1853, -1695, -1682, -1663, -1920, 7374, 9764, 9208, 9313, 9334, 9216, 9701, 12236, 12251, 12238, 12243, 12137, 12706, 9799, 5143, 5745, 5630, 5630, 5617, 5677, 5155, 4838, 4901, 4887, 4899, 4858, 4928, 9376, 10175, 9973, 10009, 10007, 10005, 10003, 10001, 9999, 9997, 9995, 9967, 10102, 9376, 8409, 8542, 8515, 8511, 8438, 8842, 4983, 3037, 3440, 3364, 3367, 3345, 3403, 4690, 4859, 4878, 4535, 6193, 9498, 9152, 9215, 9211, 9210, 9207, 9273, 8911, 10975, 13155, 12800, 12864, 12863, 12697, 13590, 3066, -1092, -193, -355, -399, -195, -952, -10051, -10795, -10589, -10631, -10651, -10547, -11018, -12176, -12078, -12094, -12091, -12145, -11856, -13644, -15250, -14965, -15016, -15012, -15010, -15007, -15005, -15002, -14998, -14995, -15029, -14825, -15636, -21429, -21628, -21558, -21570, -21555, -21608, -21319, -20770, -20826, -20809, -20813, -20539, -21950, -11631, -4228, -5643, -5368, -5410, -5193, -6111};