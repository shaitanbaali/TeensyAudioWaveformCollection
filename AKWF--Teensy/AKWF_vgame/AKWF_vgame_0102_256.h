/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0102 256 samples */
 
const int16_t AKWF_vgame_0102_256_DATA [256] = 
{8214, 11340, 10630, 10774, 10928, 10097, 13557, 31460, 31687, 31592, 31628, 31625, 31620, 31614, 31607, 31597, 31588, 31580, 31568, 31557, 31546, 31533, 31520, 31507, 31494, 31481, 31467, 31453, 31438, 31423, 31407, 31392, 31377, 31362, 31347, 31331, 31315, 31299, 31282, 31266, 31250, 31235, 31218, 31202, 31185, 31168, 31152, 31136, 31119, 31104, 31086, 31069, 31053, 31036, 31019, 31004, 30986, 30968, 30953, 30936, 30917, 30902, 30887, 30869, 30852, 30835, 30818, 30800, 30786, 30769, 30751, 30734, 30718, 30701, 30684, 30668, 30652, 30634, 30620, 30601, 30584, 30569, 30551, 30534, 30518, 30502, 30484, 30468, 30451, 30433, 30418, 30402, 30384, 30368, 30352, 30334, 30317, 30302, 30285, 30268, 30253, 30234, 30218, 30202, 30183, 30169, 30154, 30135, 30120, 30103, 30086, 30069, 30054, 30036, 30021, 30004, 29987, 29971, 29959, 29605, 31373, 17744, 7468, 9391, 9007, 8976, 8930, 9419, -8275, -12757, -11696, -11902, -11907, -11912, -11915, -11918, -11919, -12033, -11437, -13770, -32166, -32946, -32702, -32754, -32747, -32740, -32732, -32723, -32712, -32701, -32690, -32678, -32666, -32652, -32640, -32627, -32613, -32599, -32583, -32569, -32553, -32538, -32524, -32508, -32492, -32477, -32460, -32443, -32426, -32411, -32396, -32379, -32361, -32346, -32328, -32313, -32294, -32278, -32262, -32245, -32228, -32211, -32194, -32177, -32160, -32143, -32126, -32109, -32091, -32075, -32059, -32040, -32023, -32008, -31990, -31971, -31956, -31939, -31920, -31904, -31888, -31870, -31852, -31836, -31820, -31801, -31785, -31769, -31750, -31733, -31717, -31700, -31681, -31665, -31650, -31631, -31616, -31598, -31580, -31563, -31547, -31530, -31513, -31497, -31479, -31462, -31446, -31428, -31411, -31395, -31378, -31360, -31344, -31328, -31309, -31294, -31276, -31260, -31244, -31226, -31208, -31193, -31176, -31159, -31133, -30867, -32284, -16647, -8890, -10526, -10201, -10187, -10173, -10202, -9983, -10876};