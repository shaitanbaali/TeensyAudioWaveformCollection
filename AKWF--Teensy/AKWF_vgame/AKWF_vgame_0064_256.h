/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0064 256 samples */
 
const int16_t AKWF_vgame_0064_256_DATA [256] = 
{4700, 11110, 13284, 12530, 10719, 9436, 8757, 8703, 9148, 9591, 10403, 10716, 10449, 9942, 9587, 9552, 9795, 10063, 10111, 10090, 9781, 9733, 9729, 9785, 10087, 10100, 10048, 9737, 9725, 9729, 9725, 9724, 9722, 9719, 9717, 9714, 9712, 9710, 9707, 9705, 9702, 9700, 9698, 9695, 9692, 9690, 9688, 9685, 9683, 9680, 9678, 9675, 9673, 9669, 9667, 9665, 9662, 9660, 9657, 9655, 9652, 9650, 9647, 9645, 9642, 9639, 9637, 9634, 9632, 9629, 9626, 9624, 9621, 9619, 9616, 9614, 9611, 9609, 9606, 9603, 9601, 9598, 9596, 9593, 9591, 9588, 9585, 9583, 9581, 9578, 9575, 9573, 9570, 9568, 9565, 9562, 9559, 9557, 9555, 9552, 9550, 9547, 9544, 9541, 9539, 9536, 9534, 9532, 9529, 9526, 9524, 9522, 9518, 9516, 9514, 9511, 9509, 9506, 9503, 9501, 9498, 9496, 9493, 9491, 9488, 9485, 9483, 9481, 9478, 9475, 9473, 9470, 9468, 9465, 9463, 9460, 9458, 9455, 9452, 9450, 9447, 9445, 9443, 9440, 9437, 9435, 9432, 9429, 9427, 9425, 9422, 9420, 9417, 9414, 9412, 9409, 9407, 9404, 9402, 9399, 9397, 9399, 9365, 9630, 9757, 9758, 9507, 9357, 9356, 9562, 9814, 9949, 9724, 9423, 9010, 8968, 9290, 10026, 10064, 10052, 9691, 9239, 8528, 7914, 8034, 9602, 12344, 13974, 12210, 5085, -5984, -17865, -26989, -31237, -31556, -30024, -28413, -27479, -27517, -27541, -27955, -28436, -28858, -28942, -28719, -28237, -28172, -28159, -28432, -28544, -28502, -28525, -28439, -28134, -28119, -28176, -28477, -28469, -28459, -28451, -28456, -28419, -28099, -28042, -28326, -28435, -28398, -28389, -28420, -28239, -27987, -28324, -28375, -28348, -28345, -28337, -28330, -28322, -28315, -28307, -28300, -28292, -28290, -28258, -28329, -28616, -28647, -27909, -26571, -25988, -27318, -30304, -32750, -31312, -25140, -9649};