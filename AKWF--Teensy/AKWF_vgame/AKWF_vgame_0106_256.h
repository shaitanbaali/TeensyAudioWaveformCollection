/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0106 256 samples */
 
const int16_t AKWF_vgame_0106_256_DATA [256] = 
{2892, 3868, 4816, 11938, 15400, 14988, 14655, 17618, 19945, 19483, 26201, 28503, 28064, 27999, 28727, 30134, 30340, 32544, 32729, 32675, 32682, 32673, 32671, 32677, 31528, 31373, 30924, 30047, 29530, 27363, 27195, 24811, 24950, 23250, 21186, 21473, 19277, 18227, 16093, 16290, 15676, 13424, 13657, 12451, 10767, 9474, 9603, 9556, 8974, 8933, 8636, 8501, 8950, 8882, 8831, 9312, 9497, 10046, 11777, 12164, 12316, 14057, 14132, 14044, 14297, 16976, 17456, 17351, 17306, 17682, 18049, 18016, 19172, 19340, 19285, 19330, 19139, 18643, 18483, 17292, 17455, 16283, 15189, 15281, 13712, 12521, 9887, 10268, 9277, 6562, 6996, 4461, 811, -2055, -1652, -1865, -4769, -5066, -7950, -10909, -12503, -12095, -12690, -15562, -15411, -16508, -18560, -18864, -18797, -18792, -19328, -19520, -19312, -17681, -17437, -17455, -17634, -16361, -15387, -15410, -13059, -12898, -9570, -8961, -8010, -5623, -4998, -949, -1347, 1181, 3115, 3144, 6971, 8671, 11661, 11220, 12185, 14089, 14482, 16564, 17508, 18793, 18548, 18913, 19335, 19246, 19380, 18508, 17840, 18064, 17595, 15888, 16149, 14623, 10747, 9913, 10115, 10069, 7164, 6928, 5546, -1383, -1855, -1780, -1509, -3835, -4910, -7115, -12453, -12221, -12285, -12085, -13129, -14938, -15367, -17609, -17386, -18328, -18849, -19090, -19508, -19439, -19444, -19473, -18931, -18781, -18619, -18246, -17150, -15965, -16278, -15483, -14729, -14783, -13146, -11938, -11434, -11609, -11232, -10130, -10304, -9346, -8792, -8900, -8876, -8873, -8878, -8834, -9412, -10734, -10851, -10846, -10678, -12182, -12646, -14342, -17558, -17321, -17376, -17241, -20018, -20634, -21241, -23254, -23637, -26537, -26357, -27588, -28469, -29180, -30568, -30340, -31475, -31730, -31848, -32423, -31969, -31612, -31792, -30950, -30278, -30222, -28773, -25601, -24138, -24662, -23459, -21119, -20363, -15933, -12041, -11050, -11400, -10898, -5019, -4861};