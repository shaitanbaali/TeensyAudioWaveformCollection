/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0063 256 samples */
 
const int16_t AKWF_vgame_0063_256_DATA [256] = 
{2526, 11172, 18852, 24814, 29484, 32302, 32725, 31374, 28869, 26585, 25353, 24952, 26242, 28031, 29231, 29658, 29096, 28354, 27211, 26631, 26660, 27409, 28462, 28471, 28459, 28404, 27762, 27218, 27177, 27255, 27870, 28413, 28395, 28406, 28341, 27697, 27158, 27115, 27189, 27810, 28349, 28330, 28341, 28275, 27634, 27092, 27051, 27125, 27744, 28285, 28265, 28275, 28212, 27569, 27027, 26983, 27071, 27634, 28317, 28756, 28168, 27484, 26975, 26922, 27023, 27549, 28290, 29402, 29259, 28068, 26715, 24965, 24529, 25793, 27660, 30204, 32227, 32193, 30174, 25809, 19495, 11608, 3691, -4203, -11221, -15986, -18683, -18538, -16551, -13430, -10594, -9416, -9686, -11476, -13386, -15074, -15619, -14814, -13051, -11813, -11402, -11936, -12732, -13705, -13888, -14285, -13720, -13097, -12435, -11962, -12605, -13114, -13202, -13755, -13656, -13156, -13025, -12538, -12453, -12599, -13063, -13185, -13724, -13630, -13127, -12994, -12495, -12472, -12447, -12547, -13065, -13074, -13092, -12987, -12461, -12444, -12419, -12523, -13039, -13056, -13032, -13023, -13065, -12959, -12393, -12478, -13016, -13030, -13004, -13007, -13004, -13000, -12996, -12994, -12990, -12986, -12983, -12979, -12976, -12972, -12969, -12965, -12962, -12958, -12954, -12952, -12948, -12945, -12941, -12937, -12934, -12930, -12927, -12924, -12920, -12917, -12913, -12910, -12906, -12903, -12900, -12896, -12893, -12889, -12886, -12882, -12879, -12876, -12872, -12869, -12865, -12861, -12858, -12855, -12851, -12848, -12844, -12841, -12837, -12834, -12831, -12827, -12824, -12820, -12817, -12814, -12810, -12807, -12803, -12800, -12797, -12793, -12790, -12786, -12783, -12780, -12777, -12762, -12805, -12689, -12178, -12101, -12237, -12746, -12765, -12727, -12779, -12661, -12138, -12123, -12095, -12211, -12666, -12850, -13219, -12771, -12607, -12115, -12092, -12077, -12133, -12766, -13279, -13361, -13149, -12051, -11340, -10886, -11543, -12759, -14024, -15124, -15001, -13758, -11090, -5229};