/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0052 256 samples */
 
const int16_t AKWF_vgame_0052_256_DATA [256] = 
{936, 1484, 2089, 3433, 4681, 5283, 6199, 6791, 7795, 9251, 9773, 11793, 12281, 12393, 13518, 14954, 15493, 16132, 17571, 18188, 19216, 20274, 20805, 21815, 23051, 24451, 24481, 25526, 26076, 27139, 28193, 28631, 29238, 30466, 31132, 30935, 31434, 32063, 32329, 32352, 32229, 31870, 31923, 31781, 31466, 31248, 30869, 30561, 30615, 30453, 30151, 29928, 29353, 29283, 29053, 28664, 28406, 28177, 27795, 27123, 27107, 26943, 26640, 26445, 25903, 25239, 24959, 24734, 24459, 24218, 23818, 23643, 23105, 22206, 22319, 22020, 21638, 21395, 21181, 20583, 20049, 19875, 19266, 18744, 18512, 18172, 17616, 17517, 17082, 16541, 16360, 15727, 15232, 15046, 14410, 13920, 13732, 13088, 12629, 12332, 11424, 11339, 11092, 10454, 9977, 9795, 9064, 8221, 8381, 7820, 7353, 7145, 6508, 5913, 5737, 5170, 4809, 4083, 3394, 3585, 2725, 2099, 2202, 1452, 1196, 850, 137, -297, -479, -1184, -1423, -1780, -2508, -2708, -3756, -3951, -4014, -4425, -5111, -5471, -6181, -6458, -6793, -7509, -7773, -8118, -8779, -9275, -10057, -10087, -10407, -10745, -11456, -11708, -12062, -12772, -13021, -13382, -14081, -14375, -14506, -15314, -15766, -15843, -16305, -16995, -17187, -17584, -18629, -18807, -18850, -19161, -19551, -20225, -20518, -20863, -21126, -21818, -22009, -22393, -22666, -22970, -24024, -24006, -24204, -24590, -24877, -25084, -25470, -25758, -25940, -26436, -27080, -27280, -27623, -28134, -28406, -28498, -28826, -29040, -29378, -29888, -30178, -30135, -30469, -30843, -31059, -30984, -31240, -31810, -31880, -32138, -32373, -32293, -32572, -32790, -32783, -32506, -32282, -31644, -30898, -30552, -30097, -28877, -28787, -27769, -26652, -26076, -25623, -23981, -22539, -22871, -21569, -20799, -20301, -18997, -17706, -17046, -16187, -15545, -14621, -13149, -12589, -10708, -9949, -9970, -8898, -7457, -6809, -6265, -4837, -4153, -3192, -2090, -1552, -551};