/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0028 256 samples */
 
const int16_t AKWF_vgame_0028_256_DATA [256] = 
{1759, 2527, 7621, 7650, 7638, 7564, 7871, 13497, 15538, 18562, 18361, 18402, 18449, 18223, 20386, 22412, 23424, 23311, 23344, 23353, 23297, 24646, 25910, 26572, 26458, 26484, 26499, 26421, 26915, 27744, 27844, 27822, 27829, 27852, 27762, 28109, 32091, 32907, 32733, 32767, 32759, 32790, 32693, 29561, 29081, 29200, 29177, 29144, 29321, 28620, 23900, 23685, 24103, 21187, 19443, 19922, 19267, 17423, 17478, 17693, 16557, 14548, 15167, 13253, 10003, 10351, 10496, 9665, 3680, 3926, 1191, -1737, -1278, -1261, -1720, -3214, -3096, -3422, -3622, -3591, -3576, -3614, -6389, -6580, -10831, -12406, -12049, -12216, -11707, -15775, -18430, -22600, -23508, -23303, -23336, -23361, -23016, -22824, -22463, -22439, -22446, -22420, -22542, -21824, -20900, -20604, -20888, -18745, -17271, -17457, -17973, -15138, -9832, -10434, -10319, -10227, -10658, -8630, -482, 2615, 2137, 2245, 2259, 2211, 2341, 6333, 7353, 7138, 7180, 7180, 7180, 7180, 7180, 7180, 7180, 7180, 7178, 7180, 7186, 6405, 6240, 6332, 6125, 4128, 4083, 3774, 208, -66, 53, -156, -912, -913, -820, -441, -451, -450, -432, -1637, -1620, -2838, -5597, -5338, -5466, -5036, -8083, -9999, -10967, -12780, -12518, -12574, -12539, -12934, -12866, -14305, -15433, -15221, -15285, -15158, -15840, -16740, -16263, -16132, -16165, -16166, -16125, -16418, -16636, -16976, -17075, -17046, -17091, -16921, -16148, -16159, -16160, -16159, -16158, -16155, -16168, -16129, -15251, -14789, -14817, -14813, -14802, -14816, -14822, -12458, -9667, -9922, -9873, -9872, -9840, -10048, -6718, -5151, -5439, -5386, -5387, -5370, -5459, -4892, -4418, -4505, -4488, -4488, -4488, -4488, -4489, -4489, -4493, -4463, -5217, -5429, -5354, -6123, -6320, -6274, -6283, -6284, -6277, -6302, -6699, -6742, -6730, -6732, -6729, -6747, -6675, -6286, -6281, -6237, -6482, -5170, -3631, -2511};