/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0045 256 samples */
 
const int16_t AKWF_vgame_0045_256_DATA [256] = 
{1393, 1474, 4212, 4417, 4388, 4207, 6641, 7483, 7891, 10544, 10480, 10484, 10443, 13107, 13472, 14405, 16794, 16571, 16553, 16782, 19554, 19441, 21153, 23436, 23113, 23055, 23577, 25873, 25564, 27271, 28598, 28382, 28268, 29957, 30731, 30475, 31514, 31975, 31879, 31888, 32260, 32346, 32344, 31605, 31420, 31479, 31410, 30634, 30582, 30542, 29766, 29687, 29746, 29576, 28820, 28870, 28707, 27955, 27951, 28019, 27342, 27015, 27177, 26731, 25702, 25788, 25810, 24707, 24395, 24521, 24212, 22789, 22196, 22304, 22282, 22257, 22386, 21560, 20845, 21098, 20253, 19546, 19708, 19567, 17443, 16951, 17061, 17039, 17021, 17107, 16740, 14587, 14374, 14429, 14417, 14383, 14559, 13683, 11324, 11361, 11364, 11358, 11322, 11515, 10448, 8200, 8319, 8303, 8291, 8325, 8200, 6674, 5607, 5694, 5678, 5657, 5742, 5375, 3180, 2068, 2214, 2183, 2162, 2245, 1826, -145, -988, -841, -876, -859, -932, -1977, -3075, -3575, -3475, -3506, -3444, -3702, -5163, -6283, -6611, -6539, -6573, -6466, -6937, -8398, -9461, -9644, -9602, -9639, -9496, -10199, -11625, -12629, -12642, -12805, -13953, -14006, -13909, -14271, -15344, -15280, -15301, -15240, -15505, -16918, -17515, -18440, -18328, -18365, -18284, -18666, -19610, -20299, -21076, -20947, -20992, -20882, -21457, -22281, -23095, -23686, -23572, -23587, -23603, -24376, -24438, -25471, -25845, -25767, -25756, -25861, -26619, -26676, -27809, -28002, -27964, -27923, -28144, -28846, -28915, -29687, -29717, -29720, -29651, -30008, -30602, -30744, -31488, -31453, -31454, -31464, -32233, -32329, -32468, -32795, -32756, -32791, -32666, -31885, -32029, -31069, -30008, -30152, -30268, -29636, -27387, -27771, -25634, -24246, -24480, -24625, -22201, -21207, -21586, -19476, -18633, -18830, -18733, -16425, -13515, -11997, -12292, -12215, -12296, -12001, -9293, -9194, -8964, -6262, -6038, -6279, -5491, -2510, -2744, -2136};