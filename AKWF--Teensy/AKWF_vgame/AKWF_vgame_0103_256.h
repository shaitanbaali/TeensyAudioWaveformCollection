/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0103 256 samples */
 
const int16_t AKWF_vgame_0103_256_DATA [256] = 
{1745, 1501, 1560, 1549, 1688, 973, 5060, 9330, 8636, 8766, 8764, 8764, 8764, 8765, 8805, 8551, 12896, 14255, 13945, 13998, 13996, 13994, 13992, 13991, 13884, 14444, 11872, 5676, 6209, 6108, 6105, 6202, 5684, 8904, 11753, 11246, 11340, 11334, 11351, 11233, 13402, 14070, 13915, 13940, 13944, 13902, 14053, 15208, 15245, 15228, 15228, 15224, 15221, 15217, 15213, 15211, 15207, 15204, 15188, 15246, 14811, 14481, 14540, 14525, 14519, 14514, 14538, 13425, 13142, 13202, 13187, 13163, 13268, 12819, 10548, 10542, 10549, 10541, 10538, 10534, 10531, 10529, 10525, 10522, 10518, 10475, 10692, 8818, 7701, 7925, 7880, 7943, 7736, 8159, 28795, 33532, 32557, 32787, 32589, 24494, 22544, 22996, 22903, 22897, 22891, 22723, 23583, 19006, 13002, 13848, 13687, 13679, 13565, 14177, 8240, 5299, 5906, 5791, 5762, 5861, 5544, -792, -1603, -1395, -1437, -1392, -1645, -551, 2652, 2453, 2482, 2483, 2470, 2533, 2160, 1771, 1833, 1820, 1821, 1724, 2245, -4046, -6481, -5952, -6047, -6069, -5960, -6361, -11008, -11367, -11264, -11284, -11283, -11282, -11279, -11278, -11276, -11274, -11269, -11354, -10901, -13718, -16209, -15766, -15847, -15842, -15819, -15933, -13756, -13083, -13233, -13201, -13210, -13145, -13391, -15112, -15164, -15142, -15144, -15148, -15094, -15338, -15828, -15770, -15777, -15772, -15758, -15815, -15380, -15051, -15109, -15094, -15087, -15082, -15107, -13994, -13710, -13771, -13757, -13850, -13304, -15526, -26825, -26869, -26811, -26831, -26711, -27333, -24121, -19063, -19720, -19592, -19585, -19481, -20027, -15344, -12551, -13114, -13002, -12998, -12993, -12988, -12983, -12979, -12976, -12971, -12909, -13225, -11860, -6904, -7077, -7059, -7047, -7172, -6489, -10079, -14788, -14115, -14236, -14233, -14230, -14226, -14223, -14220, -14216, -14212, -14178, -14304, -13903, -5837, -4804, -5070, -5016, -4950, -5282, -3778};