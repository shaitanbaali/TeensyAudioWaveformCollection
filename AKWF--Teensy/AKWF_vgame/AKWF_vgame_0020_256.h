/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0020 256 samples */
 
const int16_t AKWF_vgame_0020_256_DATA [256] = 
{1848, 2959, 4594, 6286, 8141, 9226, 10720, 11722, 13368, 15596, 16274, 18830, 19800, 19733, 20454, 22250, 22934, 23529, 24623, 25079, 25749, 26447, 26877, 27916, 29091, 30143, 30147, 30864, 31130, 31454, 31475, 31379, 31011, 31024, 31020, 31019, 31414, 31416, 30841, 30614, 30329, 29196, 28163, 27708, 27133, 25239, 24350, 24396, 22560, 21812, 20365, 19027, 17803, 17548, 16400, 14615, 13593, 12690, 11180, 8844, 8817, 8210, 6987, 6071, 4579, 3293, 2355, 1718, 840, 411, -382, -824, -1406, -2707, -2580, -2870, -3247, -3512, -3518, -3334, -3033, -3034, -3230, -3500, -3788, -3959, -3917, -3963, -3747, -3468, -3469, -3677, -3975, -3676, -3078, -2558, -2418, -1558, -800, -570, 355, 437, 1031, 1776, 2238, 2719, 3857, 5351, 5088, 6146, 7121, 7559, 8545, 9510, 9965, 10745, 11454, 11976, 12765, 13091, 13819, 14503, 14393, 14787, 14871, 14843, 14886, 14591, 14376, 14456, 14152, 13934, 13659, 13171, 12616, 12718, 12491, 11747, 11455, 11151, 10417, 9718, 9497, 9104, 8001, 7731, 7391, 6569, 6097, 6113, 6142, 5998, 5647, 5705, 5571, 5157, 4449, 4233, 3872, 3542, 3382, 2826, 2615, 2505, 2064, 1364, 1180, 746, -679, -891, -969, -1679, -2031, -2840, -3862, -4955, -5423, -6038, -6440, -7187, -7769, -8265, -9628, -9558, -9923, -10775, -11782, -11910, -12575, -13957, -14287, -15248, -16569, -16960, -17678, -18514, -18753, -19053, -20091, -20432, -21445, -22721, -23077, -23990, -24855, -25495, -26652, -27511, -27889, -29369, -29757, -29875, -30409, -31073, -30961, -31255, -32294, -32405, -32755, -32769, -32764, -32776, -32726, -32354, -32310, -32399, -31802, -31360, -31230, -30021, -28695, -28958, -28015, -27389, -26883, -25564, -24439, -24134, -22595, -21630, -20763, -19596, -19229, -17092, -16023, -16087, -14699, -12571, -11505, -10374, -7877, -6645, -5119, -2915, -1901, -640};