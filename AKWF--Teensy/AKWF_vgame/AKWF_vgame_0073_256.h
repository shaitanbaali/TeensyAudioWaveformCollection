/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0073 256 samples */
 
const int16_t AKWF_vgame_0073_256_DATA [256] = 
{10560, 24163, 32502, 30007, 26667, 27380, 30045, 29032, 27722, 28658, 29048, 28276, 28630, 29040, 28328, 28165, 28667, 28407, 28085, 28255, 28671, 28255, 28169, 28648, 28299, 28036, 28269, 28616, 28185, 28015, 28349, 28239, 27977, 28315, 28232, 28007, 28001, 28344, 28463, 28002, 27978, 28408, 28351, 27936, 27998, 28451, 28213, 27919, 28367, 28458, 28076, 27896, 28641, 28319, 27813, 28545, 28656, 27824, 28253, 29114, 26343, 27303, 32892, 25078, 2252, -11905, -11876, -8620, -7878, -10274, -10706, -8892, -8994, -10343, -9561, -9190, -9977, -9928, -9029, -9382, -9991, -9397, -9315, -9615, -9553, -9563, -9561, -9560, -9558, -9557, -9555, -9553, -9551, -9549, -9547, -9545, -9543, -9541, -9539, -9537, -9534, -9532, -9529, -9528, -9525, -9523, -9520, -9518, -9516, -9513, -9511, -9508, -9506, -9506, -9489, -9529, -9834, -9494, -9486, -9490, -9486, -9483, -9481, -9478, -9476, -9473, -9471, -9469, -9466, -9463, -9460, -9458, -9456, -9453, -9450, -9448, -9446, -9443, -9441, -9438, -9436, -9433, -9430, -9428, -9426, -9423, -9420, -9418, -9416, -9413, -9410, -9408, -9405, -9403, -9400, -9398, -9395, -9393, -9390, -9388, -9385, -9382, -9379, -9387, -9333, -9534, -9637, -9320, -9375, -9361, -9360, -9357, -9355, -9352, -9349, -9347, -9345, -9342, -9340, -9337, -9335, -9332, -9330, -9327, -9331, -9286, -9626, -9428, -9283, -9319, -9309, -9306, -9313, -9263, -9446, -9577, -9249, -9301, -9290, -9287, -9285, -9282, -9280, -9277, -9275, -9272, -9269, -9267, -9265, -9262, -9260, -9258, -9255, -9252, -9250, -9248, -9245, -9242, -9239, -9237, -9235, -9233, -9230, -9227, -9225, -9223, -9220, -9218, -9215, -9213, -9210, -9208, -9205, -9203, -9201, -9198, -9195, -9193, -9191, -9188, -9180, -9209, -9108, -8815, -9505, -9250, -8807, -9165, -9535, -9045, -9068, -9799, -7675, -8027, -13485, -7221};