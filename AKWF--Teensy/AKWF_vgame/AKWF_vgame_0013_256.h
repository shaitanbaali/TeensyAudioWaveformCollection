/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0013 256 samples */
 
const int16_t AKWF_vgame_0013_256_DATA [256] = 
{4156, 6009, 5601, 5676, 5778, 5255, 7775, 15702, 15752, 15702, 15723, 15833, 15257, 19054, 23578, 23066, 23153, 23158, 23197, 22956, 26377, 28230, 27903, 27964, 28003, 27810, 29039, 31205, 31503, 31439, 31457, 31454, 31479, 31133, 31380, 31476, 31455, 31454, 31447, 31517, 30235, 27911, 27971, 27967, 27916, 28120, 26284, 23237, 20730, 21038, 20923, 21182, 18425, 17559, 15147, 13251, 13608, 13511, 13668, 13019, 9709, 6725, 5976, 6150, 6054, 6371, 4868, 1695, 105, -16, -3, 29, -118, -1941, -2608, -3566, -3477, -3490, -3516, -3408, -3006, -3285, -3529, -3487, -3502, -3461, -3682, -3988, -3600, -3470, -3500, -3494, -3488, -3519, -3416, -1875, -1711, -1736, -1832, -1307, -459, 17, 1834, 1727, 1791, 1539, 3233, 4365, 5477, 7195, 6944, 7014, 6877, 9059, 9595, 11056, 11938, 11770, 11762, 11915, 13451, 13572, 14684, 14894, 14845, 14854, 14847, 14886, 14724, 13969, 13979, 13983, 13980, 13197, 13167, 12653, 11701, 11805, 11840, 11606, 10435, 10652, 9206, 8132, 8329, 8355, 7283, 6919, 7030, 6285, 6074, 6133, 6085, 5693, 5703, 5560, 4407, 4337, 4444, 4039, 2981, 3124, 2811, 2132, 2162, 2324, 1350, 265, 608, -461, -1464, -1202, -1624, -3506, -3529, -3345, -5435, -6291, -5965, -6730, -7994, -7811, -7944, -9881, -10131, -9872, -11329, -12424, -12074, -12758, -14947, -14848, -14781, -16969, -17634, -17256, -20221, -22105, -21786, -21847, -21866, -21795, -22025, -26589, -27723, -27473, -27524, -27559, -27377, -28216, -30985, -31035, -31011, -31021, -31049, -30902, -31780, -32864, -32746, -32767, -32763, -32774, -32726, -32014, -31398, -31472, -31458, -31420, -31574, -30743, -27580, -26489, -26695, -26649, -26601, -26835, -24762, -20595, -19981, -20133, -20091, -20081, -20193, -16702, -11867, -11764, -11813, -11710, -12104, -9545, -5220, -1547, -1808, -1756, -1698, -1965};