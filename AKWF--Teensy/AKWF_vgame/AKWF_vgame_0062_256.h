/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0062 256 samples */
 
const int16_t AKWF_vgame_0062_256_DATA [256] = 
{23240, 34324, 32410, 32762, 32741, 32846, 32226, 29042, 27500, 27739, 27688, 27689, 27682, 27719, 27405, 27172, 26001, 25804, 25852, 25843, 25829, 25899, 25596, 24077, 21761, 21046, 20794, 20766, 20760, 20797, 20640, 19136, 17562, 16972, 17101, 17075, 17066, 17089, 17036, 13970, 12403, 11924, 12022, 11998, 11994, 11959, 12191, 8484, 6913, 6940, 6931, 6922, 6921, 6853, 7232, 3821, 1994, 2378, 2306, 2301, 2300, 2359, -3, -518, -700, -1440, -1372, -1385, -1389, -1378, -1397, -2966, -3380, -3691, -3688, -3690, -3692, -3700, -3640, -4775, -5145, -5061, -5076, -5077, -5077, -5097, -4983, -6006, -6554, -6439, -6460, -6460, -6460, -6477, -6388, -6983, -7454, -7366, -7383, -7383, -7385, -7379, -7387, -8184, -8337, -8300, -8306, -8306, -8306, -8321, -8242, -8634, -9296, -9213, -9229, -9228, -9228, -9240, -9177, -9468, -10200, -10142, -10153, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10014, -10748, -7591, 6951, 6935, 6459, 6450, 6462, 6460, 6447, 6515, 6225, 5050, 5079, 5077, 5076, 5069, 5100, 4952, 4510, 3734, 3678, 3693, 3690, 3690, 3688, 3693, 3683, 3279, 3217, 3233, 3231, 3188, 3398, 1953, 1041, -7666, -10594, -10054, -10149, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10153, -10145, -10184, -9988, -9657, -9698, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9645, -9898, -8946, -901};