/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0130 256 samples */
 
const int16_t AKWF_vgame_0130_256_DATA [256] = 
{16577, 19377, 18734, 18858, 18860, 18861, 19067, 17980, 23188, 32528, 31445, 31638, 31635, 31631, 31628, 31623, 31618, 31614, 31609, 31602, 31596, 31591, 31584, 31578, 31569, 31451, 32058, 29496, 18571, 18766, 18766, 18738, 18732, 18725, 18720, 18714, 18708, 18701, 18666, 18748, 18578, 7427, 5500, 5978, 5882, 5877, 5874, 5870, 5867, 5863, 5860, 5857, 5854, 5850, 5848, 5858, 5887, 5551, 16342, 19150, 18494, 18612, 18609, 18606, 18602, 18598, 18595, 18590, 18588, 18717, 17984, 21107, 31761, 31283, 31327, 31338, 31332, 31326, 31319, 31313, 31307, 31300, 31299, 31049, 32305, 24373, 17485, 18699, 18462, 18461, 18454, 18448, 18442, 18436, 18369, 18666, 17561, 6318, 5433, 5672, 5626, 5390, 6569, -2354, -8101, -6978, -7192, -7340, -6520, -10130, -20376, -20560, -16896, -6591, -7308, -7199, -7189, -7187, -7187, -7185, -7184, -7183, -7164, -7176, -7113, 2630, 13384, 19230, 18182, 17923, 20407, 6742, -9196, -6589, -7783, -4655, 5970, 5540, 5584, 5599, 5600, 5598, 5597, 5595, 5504, 5997, 4014, -7063, -7250, -7159, -7189, -7189, -7189, -7190, -7189, -7188, -7188, -7370, -6391, -10907, -20708, -19806, -19957, -19960, -19958, -19955, -19952, -19939, -20155, -19035, -27816, -33494, -32539, -32705, -32701, -32695, -32688, -32682, -32676, -32670, -32635, -32671, -32570, -22062, -19346, -19964, -19838, -19832, -19825, -19819, -19812, -19806, -19605, -20639, -15739, -6161, -7176, -6991, -6984, -6980, -6975, -6971, -6967, -6964, -6960, -6957, -6954, -6951, -6948, -6945, -6942, -6939, -6937, -6934, -6933, -7103, -6173, -10383, -20384, -19562, -19692, -19696, -19693, -19689, -19685, -19683, -19806, -19115, -22034, -32529, -32420, -32413, -32431, -32426, -32420, -32413, -32408, -32400, -32393, -32384, -32193, -33182, -25216, -18649, -19779, -19556, -19554, -19547, -19542, -19541, -19355, -20298, -10400, -5992, -6695, -7578};