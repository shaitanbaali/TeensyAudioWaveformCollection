/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0096 256 samples */
 
const int16_t AKWF_vgame_0096_256_DATA [256] = 
{501, 1323, 2130, 2971, 3811, 4604, 5381, 6167, 6988, 7853, 8706, 9537, 10403, 11278, 12100, 12879, 13637, 14384, 15132, 15884, 16647, 17408, 18153, 18885, 19602, 20311, 21000, 21646, 22283, 22943, 23561, 24091, 24578, 25062, 25574, 26120, 26672, 27199, 27662, 28050, 28367, 28669, 29000, 29369, 29765, 30126, 30425, 30666, 30874, 31114, 31367, 31591, 31796, 31993, 32163, 32300, 32429, 32558, 32670, 32749, 32768, 32754, 32750, 32748, 32731, 32686, 32606, 32516, 32430, 32350, 32261, 32116, 31938, 31793, 31649, 31454, 31231, 31004, 30784, 30570, 30303, 29973, 29638, 29309, 28960, 28617, 28310, 27996, 27630, 27192, 26678, 26142, 25618, 25127, 24657, 24139, 23552, 22905, 22238, 21603, 20971, 20315, 19650, 18988, 18292, 17576, 16892, 16223, 15538, 14816, 14035, 13238, 12465, 11677, 10870, 10056, 9243, 8435, 7615, 6745, 5839, 4928, 4045, 3222, 2395, 1534, 658, -217, -1084, -1935, -2795, -3671, -4565, -5462, -6344, -7178, -7965, -8748, -9551, -10359, -11164, -11973, -12785, -13577, -14344, -15085, -15806, -16525, -17277, -18064, -18844, -19591, -20288, -20948, -21598, -22235, -22859, -23446, -23986, -24476, -24928, -25390, -25871, -26336, -26779, -27217, -27640, -28027, -28387, -28737, -29075, -29398, -29681, -29928, -30184, -30457, -30698, -30912, -31117, -31308, -31487, -31662, -31840, -32006, -32146, -32237, -32281, -32310, -32338, -32373, -32397, -32393, -32342, -32216, -32081, -31977, -31894, -31818, -31693, -31523, -31348, -31163, -30961, -30746, -30523, -30288, -30038, -29774, -29501, -29231, -28957, -28659, -28339, -28016, -27665, -27259, -26814, -26346, -25884, -25440, -24982, -24502, -24017, -23526, -23032, -22509, -21921, -21304, -20698, -20091, -19481, -18841, -18174, -17508, -16852, -16179, -15510, -14884, -14250, -13554, -12797, -11982, -11159, -10362, -9573, -8796, -8041, -7267, -6427, -5551, -4669, -3789, -2908, -2024, -1151, -288};