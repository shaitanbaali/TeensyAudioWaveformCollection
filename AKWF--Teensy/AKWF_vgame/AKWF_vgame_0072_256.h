/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0072 256 samples */
 
const int16_t AKWF_vgame_0072_256_DATA [256] = 
{21996, 30507, 27388, 28561, 28245, 28270, 28389, 28294, 28165, 28166, 28193, 28208, 28180, 28285, 28261, 28124, 28249, 28246, 28240, 28234, 28228, 28222, 28215, 28208, 28202, 28195, 28188, 28182, 28174, 28168, 28161, 28154, 28146, 28139, 28133, 28125, 28118, 28111, 28103, 28096, 28089, 28081, 28074, 28067, 28060, 28052, 28045, 28037, 28026, 28036, 27906, 27954, 27794, 28036, 28024, 27969, 27951, 27745, 27926, 27784, 27738, 28226, 26425, 31505, 12505, -13082, -8087, -10052, -9329, -9624, -9585, -9327, -9616, -9458, -9543, -9705, -9541, -9630, -9568, -9556, -9557, -9555, -9554, -9554, -9552, -9551, -9550, -9554, -9517, -9719, -9651, -9722, -9760, -9609, -9740, -9505, -9538, -9530, -9529, -9519, -9551, -9749, -9571, -9734, -9561, -9604, -9490, -9516, -9476, -9708, -9580, -9697, -9563, -9706, -9517, -9641, -9598, -9648, -9710, -9550, -9652, -9578, -9638, -9543, -9524, -9691, -9481, -9775, -9515, -9659, -9511, -9665, -9465, -9604, -9553, -9602, -9525, -9609, -9582, -9616, -9497, -9612, -9508, -9609, -9408, -9657, -9402, -9537, -9413, -9376, -9503, -9567, -9493, -9571, -9594, -9440, -9587, -9538, -9511, -9517, -9497, -9532, -9459, -9554, -9430, -9597, -9530, -9557, -9404, -9583, -9370, -9340, -9341, -9346, -9587, -9317, -9541, -9403, -9529, -9388, -9521, -9473, -9484, -9417, -9482, -9322, -9537, -9363, -9509, -9349, -9620, -9320, -9524, -9310, -9609, -9330, -9524, -9447, -9355, -9330, -9244, -9504, -9309, -9535, -9516, -9312, -9457, -9331, -9443, -9441, -9307, -9468, -9288, -9209, -9470, -9281, -9458, -9251, -9343, -9219, -9431, -9441, -9197, -9454, -9255, -9450, -9183, -9433, -9234, -9344, -9320, -9339, -9324, -9161, -9191, -9183, -9181, -9179, -9176, -9174, -9171, -9168, -9166, -9163, -9163, -9152, -9264, -9046, -9246, -9116, -9131, -9231, -9318, -8912, -9426, -8987};