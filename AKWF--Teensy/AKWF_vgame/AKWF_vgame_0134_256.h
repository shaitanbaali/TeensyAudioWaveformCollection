/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0134 256 samples */
 
const int16_t AKWF_vgame_0134_256_DATA [256] = 
{3830, 6173, 5647, 5747, 5749, 5749, 5749, 5749, 5749, 5749, 5749, 5747, 5747, 5746, 5745, 5745, 5744, 5742, 5742, 5741, 5740, 5738, 5738, 5736, 5735, 5734, 5732, 5731, 5730, 5762, 5620, 6078, 15882, 17111, 16791, 16850, 16848, 16844, 16841, 16839, 16836, 16832, 16829, 16826, 16823, 16818, 16815, 16811, 16807, 16803, 16800, 16795, 16791, 16787, 16783, 16779, 16774, 16770, 16766, 16762, 16757, 16753, 16767, 16767, 16547, 25950, 28326, 27755, 27852, 27849, 27842, 27837, 27831, 27825, 27819, 27812, 27806, 27800, 27792, 27786, 27780, 27773, 27766, 27759, 27753, 27774, 26771, 31891, 1225, -31322, -27149, -27952, -27892, -18786, -16358, -16933, -16823, -16823, -16822, -16821, -16821, -16818, -16817, -16815, -16812, -16810, -16807, -16804, -16802, -16798, -16794, -16791, -16788, -16784, -16780, -16777, -16773, -16769, -16765, -16761, -16757, -16753, -16749, -16745, -16730, -16707, -16935, -7446, -5159, -5683, -5585, -5582, -5579, -5576, -5572, -5569, -5568, -5564, -5562, -5560, -5558, -5556, -5554, -5551, -5549, -5547, -5545, -5544, -5541, -5540, -5538, -5536, -5534, -5533, -5531, -5529, -5533, -5332, -6381, 965, 6460, 5412, 5613, 5612, 5612, 5613, 5613, 5613, 5612, 5612, 5612, 5611, 5610, 5609, 5609, 5608, 5607, 5605, 5605, 5604, 5603, 5601, 5601, 5599, 5598, 5597, 5596, 5594, 5591, 5248, 7085, -1734, -18172, -16348, -16670, -16676, -16674, -16673, -16672, -16670, -16668, -16666, -16663, -16661, -16658, -16655, -16652, -16649, -16646, -16643, -16639, -16635, -16632, -16628, -16624, -16620, -16616, -16612, -16608, -16597, -16497, -17099, -8138, -4859, -5585, -5449, -5445, -5442, -5439, -5437, -5434, -5431, -5429, -5426, -5424, -5422, -5420, -5418, -5416, -5414, -5412, -5410, -5408, -5406, -5405, -5402, -5401, -5399, -5398, -5396, -5394, -5393, -5391, -5409, -5305, -5748};