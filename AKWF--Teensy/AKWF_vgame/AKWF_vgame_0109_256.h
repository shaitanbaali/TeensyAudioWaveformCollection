/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0109 256 samples */
 
const int16_t AKWF_vgame_0109_256_DATA [256] = 
{71, 45, 53, 52, 64, 9, 281, 766, 709, 721, 722, 722, 721, 722, 724, 725, 723, 720, 1289, 1412, 1383, 1388, 1389, 1389, 1389, 1387, 1386, 1387, 1423, 1291, 1767, 6804, 10276, 9947, 10008, 10008, 10083, 9685, 12015, 14299, 13912, 13981, 14051, 13723, 15911, 21566, 22807, 22530, 22588, 22592, 22559, 22634, 26114, 26659, 26517, 26554, 26482, 26700, 30916, 31922, 31795, 31811, 31805, 31799, 31791, 31784, 31777, 31770, 31763, 31766, 31521, 32788, 27104, 21625, 22614, 22419, 22411, 22364, 22608, 19438, 18176, 18449, 18353, 18545, 17653, 14804, 12063, 11647, 11741, 11717, 11704, 11734, 11586, 11020, 11031, 11025, 11020, 11028, 10965, 11254, 11719, 11655, 11662, 11659, 11655, 11651, 11648, 11644, 11641, 11642, 11617, 11697, 12275, 12293, 12282, 12281, 12278, 12274, 12271, 12268, 12265, 12261, 12258, 12217, 12369, 11493, 9258, 6155, 6295, 6267, 6262, 6189, 6560, 4626, 1960, 2337, 2261, 2267, 2204, -313, -3638, -5304, -4976, -5040, -5044, -5061, -4941, -7719, -8506, -8327, -8404, -8161, -9319, -11982, -12897, -13017, -12993, -12996, -12986, -13027, -12830, -12291, -12327, -12317, -12315, -12301, -12362, -12013, -11589, -11651, -11636, -11633, -11630, -11627, -11625, -11622, -11619, -11604, -11665, -11245, -10892, -10952, -10937, -10934, -10931, -10941, -10869, -11141, -12874, -12922, -12913, -12850, -13105, -16346, -17901, -20359, -20141, -20178, -20171, -20397, -19199, -25997, -33569, -32574, -32731, -32834, -32184, -31316, -31424, -31396, -31390, -31382, -31374, -31370, -31361, -30779, -30661, -30679, -30653, -30694, -29214, -27961, -24030, -23982, -23995, -23979, -23907, -24258, -22510, -19003, -19366, -19249, -19483, -18343, -15430, -13243, -10984, -11368, -11288, -11281, -11227, -11521, -7879, -6348, -6678, -6547, -6896, -4116, -2277, -891, -573, -634, -620, -614, -631, -550};