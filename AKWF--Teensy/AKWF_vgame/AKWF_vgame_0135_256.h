/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0135 256 samples */
 
const int16_t AKWF_vgame_0135_256_DATA [256] = 
{6541, 6466, 6482, 6481, 6481, 6481, 6481, 6481, 6481, 6481, 6480, 6479, 6478, 6478, 6477, 6475, 6475, 6474, 6472, 6471, 6469, 6469, 6468, 6466, 6465, 6463, 6462, 6460, 6459, 6457, 6456, 6454, 6452, 6450, 6449, 6448, 6446, 6444, 6443, 6441, 6440, 6435, 6659, 5471, 13383, 19562, 18426, 18635, 18629, 18627, 18624, 18621, 18617, 18613, 18610, 18606, 18602, 18598, 18593, 18590, 18585, 18581, 18576, 18572, 18567, 18564, 18558, 18553, 18549, 18545, 18540, 18534, 18530, 18526, 18521, 18516, 18511, 18506, 18502, 18496, 18492, 18487, 18482, 18477, 18471, 18681, 17545, 23333, 31587, 30445, 30652, 30643, 30637, 30631, 30623, 30617, 30610, 30603, 30596, 30589, 30582, 30575, 30567, 30560, 30552, 30545, 30537, 30530, 30522, 30514, 30507, 30499, 30488, 30220, 31619, 25604, 5251, 6168, 6059, 6026, 6020, 6015, 6010, 6004, 6001, 5996, 5992, 5989, 5985, 5979, 5721, 7037, 1822, -28985, -30988, -30519, -30648, -30648, -30647, -30645, -30642, -30638, -30635, -30631, -30627, -30622, -30616, -30611, -30605, -30599, -30593, -30587, -30580, -30574, -30567, -30560, -30553, -30546, -30539, -30531, -30522, -30367, -31183, -26372, -17531, -18453, -18267, -18267, -18260, -18253, -18248, -18241, -18235, -18229, -18224, -18218, -18212, -18206, -18201, -18195, -18190, -18185, -18179, -18174, -18169, -18163, -18159, -18153, -18148, -18143, -18138, -18133, -18128, -18123, -18117, -18113, -18108, -18103, -18098, -18093, -18088, -18083, -18078, -18073, -18068, -18064, -18059, -18055, -17879, -18819, -14278, -5015, -6008, -5811, -5815, -5811, -5808, -5804, -5801, -5798, -5796, -5792, -5790, -5787, -5785, -5783, -5781, -5778, -5776, -5774, -5772, -5770, -5768, -5766, -5764, -5763, -5760, -5759, -5757, -5755, -5753, -5751, -5750, -5748, -5746, -5744, -5743, -5742, -5740, -5739, -5737, -5735, -5733, -5727, -5752, -5617};