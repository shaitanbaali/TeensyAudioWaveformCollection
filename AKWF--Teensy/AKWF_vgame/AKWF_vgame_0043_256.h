/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0043 256 samples */
 
const int16_t AKWF_vgame_0043_256_DATA [256] = 
{2690, 4006, 6073, 7789, 7465, 7526, 7591, 7303, 9336, 14545, 15697, 15436, 15496, 15500, 15506, 15428, 18425, 19186, 19078, 18728, 21195, 23307, 23059, 25861, 26195, 26109, 26183, 25890, 27349, 30168, 31790, 31897, 31878, 31884, 31893, 31843, 32056, 32779, 32752, 32819, 32449, 31814, 31953, 31610, 30940, 31010, 30990, 31031, 30839, 30203, 29547, 28681, 28807, 28782, 28779, 28774, 28841, 26866, 25989, 26157, 26125, 26125, 26104, 26221, 25264, 24704, 24816, 24804, 24777, 23604, 23494, 22463, 22069, 22155, 22139, 22117, 22232, 20827, 19121, 19016, 19049, 19039, 19032, 19067, 18944, 17384, 17238, 17253, 17374, 16774, 15458, 15279, 13731, 13720, 13730, 13713, 13761, 13594, 11556, 10099, 10203, 10185, 10184, 10157, 10304, 9579, 8287, 8431, 8450, 8264, 6670, 6759, 5836, 4727, 4903, 4866, 4869, 4851, 3543, 1753, 730, 922, 884, 884, 858, 997, -344, -996, -869, -836, -2327, -2745, -2579, -4076, -4508, -4407, -4456, -4306, -5576, -6350, -7755, -8020, -7959, -7970, -8015, -7777, -9014, -12022, -11947, -11948, -11954, -11967, -11899, -12187, -13313, -13278, -13311, -13149, -14049, -15089, -15518, -16931, -16803, -16826, -16847, -16756, -17143, -19384, -20485, -20339, -20370, -20370, -20393, -20265, -21048, -21835, -21533, -22578, -23609, -23457, -23370, -24308, -24891, -24777, -24805, -24768, -24921, -26002, -27125, -27524, -27437, -27454, -27455, -27455, -27436, -28575, -28833, -28788, -28713, -29284, -29719, -29717, -30902, -31024, -30992, -31003, -30973, -31675, -32028, -32719, -32776, -32764, -32767, -32751, -32844, -32380, -30934, -31010, -30998, -30998, -30953, -31198, -30019, -27685, -27943, -27867, -28021, -27300, -25050, -23066, -20497, -20884, -20811, -20799, -20787, -20964, -15333, -12914, -13367, -13282, -13285, -13226, -13529, -10933, -9506, -9782, -9771, -9651, -6512, -6278, -3143, -2008, -2259, -2222, -2173, -2386};