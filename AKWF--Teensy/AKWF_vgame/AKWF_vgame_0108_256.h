/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0108 256 samples */
 
const int16_t AKWF_vgame_0108_256_DATA [256] = 
{1552, 3311, 4365, 4194, 4232, 4230, 4263, 4077, 5465, 6400, 6214, 6317, 5981, 7241, 19668, 21575, 21767, 21721, 21737, 21736, 21737, 21686, 23398, 23823, 23720, 23758, 23623, 24213, 25912, 27565, 27796, 27736, 27742, 27749, 27673, 27947, 29704, 29746, 29721, 29742, 29410, 31222, 27451, 12196, 12943, 12852, 12826, 12851, 12682, 13434, 14958, 14792, 14815, 14835, 14721, 16095, 17802, 18966, 18794, 18828, 18821, 18851, 18651, 19907, 20983, 20781, 20845, 20664, 21599, 22879, 23672, 24249, 24129, 24145, 24125, 23709, 26171, -13396, -26878, -23871, -24375, -24566, -23166, -22243, -21251, -20998, -21051, -21040, -21029, -21073, -20900, -19112, -18976, -19008, -18995, -19013, -17375, -16584, -14942, -14936, -14936, -14930, -14899, -15033, -14411, -12791, -12911, -13004, -12407, -14668, -30838, -30943, -28777, -29076, -28993, -29173, -27755, -26842, -27017, -26977, -26972, -26947, -27045, -26503, -25667, -24423, -23409, -23593, -23551, -23545, -23509, -23659, -22092, -21373, -21518, -21447, -21634, -20306, -19704, -7925, -4667, -5412, -5270, -5262, -5271, -5232, -4050, -3865, -3907, -3877, -3973, -2388, -1579, 65, 181, 154, 162, 177, 108, 405, 1545, 1511, 1524, 1482, 1669, 3306, 4141, 5677, 5536, 5565, 5566, 5286, 6791, -1072, -12571, -10990, -11280, -11330, -10792, -10725, -9578, -8427, -8619, -8582, -8581, -8544, -8727, -7296, -6413, -6577, -6556, -6537, -4755, -4531, -3529, -3095, -3186, -3168, -3164, -3165, -3188, -1453, -1063, -1140, -1212, -834, 867, 983, 2760, 2948, 2899, 2910, 2920, 2866, 3078, 4250, 4260, 4284, 4114, 5001, 6325, 6686, 8384, 8279, 8295, 8294, 8322, 8160, 8958, 10449, 10277, 10331, 10201, 10767, 13207, 3174, -8716, -6885, -7227, -7228, -7165, -7496, -5312, -3602, -3915, -3851, -3896, -2732, -2585, -1140, -355, -515, -485, -490, -466, -572};