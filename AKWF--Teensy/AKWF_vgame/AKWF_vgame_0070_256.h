/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0070 256 samples */
 
const int16_t AKWF_vgame_0070_256_DATA [256] = 
{22266, 31619, 29691, 30130, 30176, 30115, 30058, 30087, 30056, 30072, 30117, 30169, 30168, 30163, 30158, 30152, 30146, 30140, 30134, 30128, 30121, 30115, 30108, 30101, 30094, 30087, 30080, 30072, 30064, 30058, 30050, 30042, 30036, 30027, 30019, 30012, 30005, 29996, 29989, 29980, 29973, 29965, 29958, 29949, 29942, 29934, 29926, 29918, 29910, 29902, 29894, 29886, 29879, 29871, 29862, 29855, 29846, 29839, 29830, 29823, 29790, 29770, 29777, 29430, -5625, -11073, -9802, -9996, -10063, -10055, -10059, -10061, -10064, -10065, -10066, -10068, -10067, -10068, -10069, -10062, -10089, -10236, -10246, -10261, -10229, -10229, -10221, -10223, -10178, -10227, -10215, -10175, -10206, -10178, -10293, -10241, -10266, -10198, -10295, -10252, -10163, -10145, -10158, -10186, -10229, -10197, -10180, -10126, -10122, -10151, -10178, -10166, -10190, -10179, -10174, -10203, -10132, -10129, -10155, -10182, -10049, -10106, -10098, -10161, -10070, -10145, -10148, -10107, -10196, -10123, -10116, -10123, -10038, -10131, -10085, -10135, -10071, -10052, -10045, -10048, -10092, -10123, -10142, -10050, -10105, -10050, -10115, -10139, -10086, -9857, -10102, -10073, -10072, -10087, -10099, -10103, -10100, -10036, -9876, -10086, -10058, -10112, -10068, -10027, -10058, -10078, -10060, -10057, -9971, -10068, -10081, -10031, -9936, -9992, -10028, -9936, -9948, -9950, -10043, -9913, -9939, -10047, -10017, -9989, -9953, -9923, -9979, -9967, -9924, -9942, -9783, -9939, -10003, -9890, -9913, -9974, -9917, -9895, -9969, -9903, -9896, -9911, -9917, -9951, -9942, -9931, -10063, -9919, -9898, -9981, -9888, -9898, -9881, -9934, -9828, -9993, -9866, -9911, -9895, -9924, -9902, -9889, -9832, -9911, -9929, -9932, -9900, -9933, -9802, -9912, -9848, -9815, -9869, -9785, -9786, -9863, -9801, -9877, -9789, -9771, -9636, -9662, -9654, -9651, -9648, -9646, -9643, -9641, -9638, -9636, -9633, -9632, -9594, -9704, -9495, -9716};