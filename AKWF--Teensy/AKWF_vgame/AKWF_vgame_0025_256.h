/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0025 256 samples */
 
const int16_t AKWF_vgame_0025_256_DATA [256] = 
{1483, 3182, 4342, 6241, 7498, 8801, 9934, 11969, 13383, 14689, 16597, 17413, 18625, 19786, 20862, 21772, 22838, 23942, 24427, 25067, 25804, 26165, 26796, 27709, 28797, 29317, 30052, 31008, 31124, 31470, 31478, 31349, 31000, 31025, 31030, 30981, 31284, 31367, 31006, 30855, 30024, 29045, 28590, 28093, 27015, 26412, 25380, 23789, 22877, 21748, 20560, 19155, 18381, 17582, 15790, 14870, 13983, 12504, 11075, 10440, 9442, 7996, 7382, 6305, 4832, 3412, 2577, 1795, 794, 361, -234, -861, -939, -1655, -2585, -3048, -3242, -3521, -3521, -3298, -3032, -3032, -3263, -3509, -3821, -3954, -3925, -3923, -3962, -3661, -3429, -3724, -3967, -3914, -3505, -2773, -2232, -1739, -1015, -501, -381, 102, 1148, 1457, 2302, 3009, 3608, 4467, 5063, 6162, 6618, 7492, 8712, 9001, 9789, 10672, 11550, 11970, 12630, 13121, 13261, 13963, 14423, 14630, 14887, 14840, 14883, 14557, 14381, 14449, 14121, 13925, 13608, 13227, 13091, 12459, 12202, 11841, 11391, 11049, 10510, 10003, 9295, 9090, 8284, 7704, 7381, 6927, 6532, 6167, 6133, 5967, 5640, 5707, 5552, 5003, 4704, 4182, 3956, 3534, 3000, 3089, 2790, 2408, 2175, 1918, 1198, 602, 143, -582, -902, -1126, -2309, -3073, -3353, -4315, -5479, -6047, -6497, -7341, -7906, -8260, -8816, -9529, -10045, -10553, -11623, -11852, -12358, -13482, -14452, -14998, -16105, -17276, -17597, -18059, -18665, -19355, -19778, -20670, -21722, -22222, -22929, -24081, -24955, -25323, -26621, -27504, -27752, -28626, -29428, -30006, -30472, -30793, -31148, -31462, -31471, -32161, -32378, -32704, -32779, -32764, -32768, -32767, -32407, -32336, -32229, -31544, -31334, -30470, -29764, -29163, -28331, -27560, -26403, -25971, -25042, -24002, -23385, -22158, -20713, -19760, -19332, -18019, -16908, -15974, -14799, -12883, -10903, -10533, -8391, -6446, -5237, -4101, -1563, -359};