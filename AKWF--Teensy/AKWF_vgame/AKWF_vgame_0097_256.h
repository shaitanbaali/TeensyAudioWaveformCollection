/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0097 256 samples */
 
const int16_t AKWF_vgame_0097_256_DATA [256] = 
{777, 1921, 1820, 1251, 2477, 3706, 3753, 3406, 3944, 5472, 5977, 5798, 5897, 7049, 7923, 7568, 7848, 9072, 10539, 10551, 10128, 10904, 11749, 12110, 12061, 12638, 13691, 14284, 14418, 14650, 15696, 16349, 16263, 16155, 17028, 18444, 18476, 18321, 18939, 20052, 20620, 20423, 20914, 21953, 22831, 22670, 22515, 23362, 24406, 24790, 24346, 25211, 26629, 26972, 26782, 26965, 28097, 28570, 28400, 28723, 29746, 30835, 30967, 30959, 31443, 32490, 32633, 31720, 31326, 31140, 30656, 29604, 28880, 28811, 28314, 27478, 26682, 26186, 25850, 25406, 24660, 24042, 23841, 23193, 22241, 21562, 21420, 21225, 20273, 19556, 19176, 18594, 17790, 17007, 16629, 16507, 16234, 15369, 14745, 14553, 14091, 13176, 12254, 12364, 12246, 11192, 10344, 10007, 9929, 9228, 8243, 7608, 7560, 7413, 6571, 5813, 5477, 5416, 4545, 3500, 3462, 3315, 2655, 1778, 1330, 1099, 301, -592, -1068, -871, -853, -1424, -2260, -2634, -2676, -3690, -4576, -4605, -4637, -5346, -6622, -6914, -6865, -7418, -8362, -9024, -8995, -9149, -9858, -10924, -11150, -11118, -12014, -12869, -13173, -13035, -13700, -14860, -15057, -15129, -15666, -16631, -17206, -17183, -17185, -17841, -18943, -19261, -19322, -19803, -20876, -21616, -21571, -21938, -22636, -23242, -23609, -23934, -24453, -25136, -25654, -25793, -26259, -27001, -27564, -27820, -28165, -29106, -29632, -29722, -30164, -30857, -31483, -31680, -31691, -31664, -31508, -30988, -30171, -29535, -29112, -28746, -28176, -27698, -27425, -26747, -26026, -25641, -25183, -24556, -23869, -23427, -23053, -22462, -21844, -21274, -20754, -20280, -19785, -19204, -18788, -18387, -17615, -16899, -16414, -15988, -15431, -14797, -14388, -14007, -13492, -12894, -12318, -11797, -11220, -10496, -9761, -9618, -9310, -8259, -7342, -7000, -7106, -6437, -5490, -5220, -5090, -4506, -3244, -2644, -2646, -2276, -1269, -431, -957, -662};