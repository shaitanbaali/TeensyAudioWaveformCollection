/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0026 256 samples */
 
const int16_t AKWF_vgame_0026_256_DATA [256] = 
{3095, 4176, 3995, 3745, 4945, 11360, 11889, 17288, 17825, 17682, 17711, 17752, 17530, 18504, 21390, 21227, 21297, 21046, 22849, 23934, 24885, 26296, 26087, 26125, 26125, 26137, 26071, 26749, 27065, 27007, 26979, 27144, 28281, 28438, 31147, 31515, 31422, 31439, 31453, 31383, 31685, 32767, 32749, 32830, 32451, 28582, 28718, 25673, 21658, 22250, 22135, 22142, 22078, 22409, 19434, 17896, 18155, 18400, 16747, 14836, 15050, 9947, 9134, 9336, 9298, 9230, 9609, 7993, 1200, 1337, 1362, 1258, -2643, -3186, -3243, -3575, -3535, -3543, -3567, -3554, -3433, -11930, -15153, -14480, -14611, -14626, -14599, -14566, -21047, -22413, -22076, -22138, -22140, -22136, -22257, -21727, -21688, -21700, -21697, -21683, -21761, -21377, -20731, -20915, -18278, -17581, -17589, -18371, -12629, -8678, -9438, -9298, -9291, -9264, -9508, -1981, -75, -522, -444, -339, -900, 2298, 7434, 7009, 7078, 7084, 7084, 7084, 7084, 7084, 7084, 7084, 7086, 7036, 7293, 5581, 4221, 4472, 4424, 4424, 4396, 4578, 892, -208, 46, -1, -11, 45, -249, -907, -881, -883, -884, -937, -646, -2009, -5115, -4816, -4871, -4889, -4845, -4902, -11415, -13135, -12772, -12841, -12842, -12857, -12757, -14183, -14707, -14589, -14614, -14611, -14591, -16105, -16452, -16368, -16383, -16384, -16389, -16359, -16495, -16848, -16822, -16809, -16894, -16288, -15912, -15735, -15462, -15504, -15496, -15496, -15491, -15521, -15171, -15029, -15060, -15053, -15033, -15147, -13791, -9967, -9675, -9760, -9741, -9702, -9913, -8984, -6060, -6227, -6200, -6179, -6275, -5827, -4588, -4411, -4434, -4426, -4426, -4426, -4426, -4426, -4426, -4427, -4427, -4439, -4369, -5477, -6219, -6196, -6196, -6199, -6203, -6179, -6284, -6653, -6638, -6640, -6641, -6611, -6771, -5897, -4732, -4903, -4870, -4869, -4800, -5190, -1619, 330, -77, -6, 23, -108};