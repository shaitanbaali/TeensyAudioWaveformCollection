/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0136 256 samples */
 
const int16_t AKWF_vgame_0136_256_DATA [256] = 
{5937, 6901, 6688, 6730, 6730, 6731, 6731, 6731, 6730, 6730, 6730, 6729, 6728, 6727, 6726, 6725, 6724, 6722, 6722, 6720, 6719, 6718, 6716, 6715, 6713, 6712, 6711, 6801, 6294, 8392, 19614, 19666, 19608, 19628, 19626, 19622, 19619, 19617, 19613, 19608, 19604, 19600, 19597, 19592, 19588, 19583, 19579, 19574, 19570, 19565, 19560, 19555, 19550, 19546, 19541, 19536, 19635, 19054, 21463, 32622, 32425, 32423, 32425, 32137, 33789, 13263, 5096, 6853, 6531, 6525, 6521, 6516, 6512, 6508, 6503, 6499, 6497, 6494, 6490, 6487, 6490, 5853, 9259, -9131, -35006, -31705, -32316, -32320, -32318, -32316, -32313, -32310, -32306, -32301, -32297, -32289, -32079, -33190, -25479, -18328, -19569, -19324, -19321, -19315, -19309, -19303, -19298, -19293, -19287, -19282, -19277, -19271, -19266, -19260, -19255, -19250, -19244, -19239, -19234, -19228, -19223, -19218, -19213, -19207, -19149, -19395, -18482, -7109, -6008, -6307, -6242, -6237, -6233, -6230, -6226, -6223, -6220, -6216, -6214, -6211, -6209, -6206, -6204, -6201, -6199, -6197, -6194, -6193, -6190, -6188, -6186, -6184, -6182, -6180, -6178, -6176, -6101, -6477, -5018, 6318, 6908, 6719, 6764, 6765, 6765, 6765, 6765, 6765, 6765, 6765, 6764, 6764, 6762, 6762, 6760, 6759, 6759, 6757, 6756, 6754, 6753, 6752, 6750, 6749, 6748, 6738, 6953, 5820, 15169, 20566, 19465, 19668, 19663, 19660, 19657, 19653, 19649, 19646, 19642, 19639, 19635, 19630, 19626, 19621, 19617, 19609, 19313, 20893, 14005, -7258, -6304, -5330, -10935, -20121, -19011, -19217, -19215, -19216, -19214, -19213, -19213, -19210, -19207, -19081, -19759, -16868, -5961, -6305, -6278, -6258, -6254, -6252, -6250, -6248, -6246, -6243, -6242, -6239, -6237, -6235, -6234, -6232, -6229, -6228, -6225, -6223, -6222, -6220, -6218, -6216, -6215, -6213, -6211, -6229, -6120, -6584};