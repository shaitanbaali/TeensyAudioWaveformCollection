/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0059 256 samples */
 
const int16_t AKWF_vgame_0059_256_DATA [256] = 
{29937, 27965, 28428, 28341, 28341, 28341, 28341, 28341, 28341, 28385, 28142, 30491, 31640, 31393, 31440, 31439, 31438, 31461, 31348, 32247, 32847, 32750, 32767, 32765, 32472, 33864, 27664, -22571, -27636, -26278, -26564, -26489, -26918, -25069, -18819, -19077, -19048, -19046, -18941, -19635, -17932, -15196, -15563, -15497, -15497, -15489, -15530, -15226, -15022, -15013, -15271, -13942, -11727, -12018, -11598, -11493, -11516, -11483, -11645, -9920, -9165, -9328, -9299, -9298, -9298, -9271, -9424, -8139, -7403, -7555, -7527, -7527, -7504, -7628, -6960, -6093, -6223, -6198, -6199, -6184, -6262, -5633, -5249, -5327, -5312, -5304, -5337, -5215, -3743, -3494, -3555, -3543, -3540, -3554, -3499, -3111, -3094, -3092, -3132, -2900, -2726, -2191, -788, -905, -885, -871, -934, -641, 265, 464, 433, 442, 440, 468, 324, 1655, 2326, 2218, 2075, 2989, 4119, 3954, 5521, 5813, 5742, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5756, 5763, 5722, 5938, 6232, 6190, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6198, 6205, 6164, 6399, 6675, 6631, 6640, 6640, 6640, 6632, 6672, 6468, 6165, 6205, 6197, 6198, 6197, 6181, 6282, 4858, 4329, 4448, 4426, 4422, 4437, 4390, 3612, 3523, 3546, 3542, 3528, 3601, 3291, 2175, 2217, 2213, 2212, 2212, 2212, 2212, 2212, 2204, 2245, 2074, 1315, 1328, 1329, 1328, 1328, 1317, 1373, 1153, -398, -456, -438, -442, -442, -448, -421, -517, -1691, -1792, -1765, -1770, -1845, -1427, -3285, -9135, -8795, -8858, -8837, -8688, -7335, -14479, -24168, -22762, -23030, -23023, -23021, -23051, -22041, -21628, -21714, -21697, -21697, -21697, -21697, -21697, -21696, -21369, -23104, -15580};