/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0030 256 samples */
 
const int16_t AKWF_vgame_0030_256_DATA [256] = 
{3785, 5708, 4980, 9356, 15132, 15594, 15460, 15532, 15330, 17698, 18934, 21058, 21297, 21267, 21138, 22489, 23097, 23169, 24349, 24377, 24260, 25237, 25790, 25576, 26350, 27088, 26994, 27011, 27019, 27004, 27163, 28036, 29330, 29202, 29249, 29120, 29673, 31862, 32232, 32803, 32793, 32584, 30710, 30448, 30849, 28703, 26701, 27193, 26542, 23052, 23065, 22802, 18448, 17555, 17751, 17700, 17755, 17519, 15742, 13526, 12695, 12853, 12920, 12557, 7824, 7563, 3166, 1979, 2299, 2083, -1042, -1390, -1355, -2931, -3151, -3052, -3314, -3629, -3307, -4719, -8887, -8860, -8841, -8949, -8487, -11011, -15411, -19036, -19031, -19099, -18744, -20647, -23335, -22954, -23028, -23019, -23056, -22856, -22529, -22682, -22103, -21150, -21306, -21103, -20768, -20813, -20803, -18210, -16115, -16448, -16377, -16380, -16318, -12440, -6786, -3496, -4101, -3959, -4122, 37, 861, 3245, 4659, 4387, 4361, 5780, 6386, 7048, 7090, 7081, 7084, 7084, 7083, 7085, 7083, 6700, 6625, 6643, 6622, 6710, 5740, 5088, 2443, 2152, 2189, 2383, 393, -601, -456, -882, -881, -905, -790, -435, -403, -626, -1388, -1201, -1839, -4109, -3828, -4572, -9470, -11697, -11463, -11523, -11464, -11707, -12848, -12842, -12838, -12856, -12774, -13098, -15054, -14961, -15717, -16490, -16359, -16384, -16384, -16391, -16350, -16655, -16859, -16818, -16825, -16818, -16853, -16593, -16034, -15921, -15946, -15940, -15940, -15935, -15967, -15226, -15016, -15055, -15090, -14829, -14579, -14612, -14220, -14115, -14348, -13098, -11712, -12287, -10346, -6492, -6667, -6648, -6618, -6737, -6097, -5142, -4889, -4870, -4864, -4902, -4699, -4393, -4434, -4426, -4428, -4424, -4434, -4835, -4822, -5169, -5819, -5742, -5756, -6143, -6221, -6161, -6397, -6676, -6633, -6641, -6640, -6640, -6640, -6640, -6640, -6640, -6635, -6673, -5895, -5901, -4009, -2930, -3081, -3353};