/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0051 256 samples */
 
const int16_t AKWF_vgame_0051_256_DATA [256] = 
{1414, 2002, 2903, 3760, 4855, 5641, 6327, 7625, 8427, 9609, 10358, 11032, 12312, 13110, 14376, 14959, 16248, 17383, 18363, 19341, 19832, 20393, 21697, 22475, 24883, 24891, 24994, 26056, 26663, 27436, 28538, 30289, 30077, 30346, 30983, 31454, 31946, 32222, 32346, 32356, 32173, 31799, 31455, 31493, 31206, 30996, 30993, 30636, 30433, 30147, 29903, 29339, 29279, 29167, 28892, 28386, 27911, 27611, 27098, 27114, 26907, 26640, 26358, 26153, 25316, 24890, 24865, 24511, 24304, 24058, 23517, 22931, 22746, 22510, 21838, 21620, 21370, 21131, 20464, 20064, 19921, 19668, 19051, 18668, 17985, 17561, 17519, 16945, 16515, 16289, 15598, 15206, 14957, 14623, 13972, 13752, 13522, 12868, 12482, 11823, 11596, 11367, 10746, 10352, 9716, 9295, 8707, 8479, 8240, 7571, 7185, 6587, 6104, 5603, 5403, 4731, 4302, 4042, 3818, 2418, 2123, 2233, 1546, 1168, 508, 265, -801, -884, -900, -1608, -2007, -2594, -2973, -3975, -3891, -4080, -4745, -5214, -5665, -6260, -7076, -6957, -7299, -7550, -8229, -8546, -9680, -10099, -10060, -10399, -10737, -11337, -11806, -12615, -12644, -12830, -13492, -13945, -14458, -14733, -15660, -15690, -16017, -16728, -16959, -17357, -18035, -18324, -18393, -19126, -19378, -19617, -20129, -20737, -20946, -21131, -21830, -22052, -22281, -22907, -23424, -23586, -23756, -24001, -24596, -24982, -25266, -25635, -25849, -26560, -26799, -27077, -27337, -27558, -27874, -28069, -28377, -28613, -28860, -29143, -29397, -30098, -30322, -30587, -30865, -31071, -31420, -31474, -31423, -31708, -31931, -32226, -32587, -32825, -32553, -32282, -32408, -31895, -31416, -30796, -30525, -28848, -28290, -28501, -27512, -26910, -25991, -25268, -22815, -22697, -22710, -21270, -20614, -19816, -18650, -16039, -16283, -15507, -14774, -13869, -13322, -11484, -10391, -10603, -9299, -8490, -7162, -6695, -4826, -3818, -3942, -2476, -1847, -917, -427, 8};