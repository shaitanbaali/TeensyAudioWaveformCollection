/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0085 256 samples */
 
const int16_t AKWF_vgame_0085_256_DATA [256] = 
{6678, 15162, 13138, 9450, 7288, 7979, 10659, 10864, 9290, 9722, 11070, 10574, 9248, 8936, 9145, 9177, 9149, 9149, 9148, 9147, 9146, 9145, 9143, 9142, 9140, 9139, 9137, 9135, 9133, 9131, 9129, 9127, 9125, 9123, 9121, 9119, 9116, 9114, 9112, 9110, 9108, 9105, 9103, 9101, 9098, 9096, 9094, 9092, 9089, 9087, 9085, 9082, 9080, 9077, 9075, 9072, 9070, 9068, 9066, 9063, 9060, 9058, 9055, 9053, 9051, 9048, 9046, 9043, 9041, 9039, 9036, 9034, 9032, 9029, 9026, 9024, 9022, 9019, 9017, 9015, 9012, 9010, 9007, 9005, 9003, 9000, 8998, 8996, 8993, 8991, 8988, 8986, 8983, 8981, 8979, 8976, 8974, 8971, 8969, 8966, 8964, 8962, 8959, 8957, 8955, 8952, 8949, 8947, 8944, 8942, 8940, 8938, 8935, 8933, 8930, 8928, 8926, 8923, 8921, 8918, 8916, 8913, 8911, 8908, 8906, 8904, 8902, 8899, 8897, 8894, 8892, 8889, 8887, 8885, 8883, 8880, 8878, 8875, 8873, 8871, 8869, 8866, 8864, 8861, 8859, 8856, 8854, 8851, 8850, 8847, 8845, 8842, 8840, 8837, 8835, 8833, 8830, 8828, 8825, 8823, 8821, 8818, 8816, 8813, 8811, 8809, 8807, 8804, 8802, 8799, 8797, 8795, 8793, 8789, 8790, 8819, 8739, 8549, 9117, 10475, 10506, 9083, 9066, 10493, 10488, 9185, 8095, 8134, 11739, 13648, 4211, -11380, -23932, -30998, -30454, -27098, -26392, -27256, -28579, -29077, -27780, -27212, -28541, -29046, -27794, -26918, -27012, -27142, -27111, -27096, -27092, -27086, -27079, -27073, -27067, -27061, -27054, -27048, -27041, -27035, -27029, -27022, -27015, -27007, -27001, -26994, -26987, -26980, -26973, -26966, -26959, -26951, -26944, -26938, -26931, -26924, -26917, -26909, -26902, -26895, -26888, -26882, -26874, -26866, -26860, -26853, -26817, -26845, -27140, -26644, -24568, -25524, -31198, -32039, -23557, -8972};