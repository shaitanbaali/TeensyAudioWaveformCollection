/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0065 256 samples */
 
const int16_t AKWF_vgame_0065_256_DATA [256] = 
{1048, 4303, 4377, 4262, 4452, 4393, 4513, 4033, 6108, 8670, 8351, 8472, 8320, 8186, 8327, 8422, 8297, 11620, 12801, 12351, 12429, 12369, 12731, 12193, 12986, 16475, 16596, 16343, 16416, 16434, 16324, 16653, 16187, 18608, 20895, 20312, 20695, 20374, 20487, 20403, 20392, 23818, 24869, 24279, 24608, 24398, 24658, 24025, 25358, 28594, 28482, 28290, 28509, 28563, 28347, 28511, 27962, 30695, 32938, 32322, 32565, 32370, 32512, 32422, 32343, 28818, 28079, 28532, 28172, 28492, 28112, 28705, 27473, 24135, 24307, 24456, 24193, 24241, 24178, 24107, 24601, 21770, 19842, 20268, 20269, 20110, 20278, 20353, 20159, 16638, 15747, 16270, 16192, 16229, 15819, 16556, 14936, 11688, 12033, 12205, 11919, 11971, 11937, 11812, 12389, 9285, 7539, 8106, 7732, 8028, 7729, 8103, 7829, 4229, 3502, 4062, 3808, 3967, 3634, 4220, 2404, -510, -274, -116, -257, -231, -254, -367, 123, -2779, -4609, -4104, -4384, -4284, -4474, -4144, -4664, -7954, -8621, -8193, -8594, -8201, -8641, -7908, -9856, -12686, -12387, -12443, -12453, -12322, -12407, -12628, -12050, -15262, -16685, -16501, -16530, -16520, -16595, -16225, -16894, -20430, -20616, -20381, -20560, -20513, -20460, -20627, -19885, -22194, -24862, -24464, -24368, -24379, -24452, -24561, -24134, -27406, -28728, -28505, -28566, -28442, -28482, -28258, -28908, -32242, -32550, -32224, -32491, -32217, -32477, -32229, -32749, -30632, -27909, -28368, -28319, -28383, -28254, -28295, -28548, -25126, -23760, -24556, -24166, -24197, -23950, -24501, -23522, -20236, -20077, -20268, -20193, -20171, -20244, -20049, -20625, -18118, -15637, -16168, -16142, -16166, -15974, -15995, -15990, -12859, -11652, -12276, -11909, -11904, -11822, -12287, -11272, -8040, -7793, -8046, -7915, -7788, -7929, -7702, -8289, -5707, -3437, -3916, -3923, -3934, -3783, -3746, -3855, -387, 640, 67, 315, 272, 502, 74};