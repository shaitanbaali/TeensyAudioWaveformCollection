/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0060 256 samples */
 
const int16_t AKWF_vgame_0060_256_DATA [256] = 
{24905, 34043, 32474, 32763, 32767, 32711, 33019, 31448, 27490, 27727, 27694, 27689, 27655, 27836, 26855, 25697, 25877, 25843, 25843, 25817, 25965, 24563, 23879, 24024, 23994, 23964, 24148, 21417, 17296, 17011, 17098, 17075, 17075, 17075, 17075, 17075, 17075, 17075, 17015, 17328, 15929, 12037, 12010, 12008, 11998, 12001, 11916, 12354, 8641, 6578, 6998, 6920, 6913, 6935, 6900, 2883, 2161, 2338, 2305, 2275, 2446, 1707, -1444, -1376, -1381, -1384, -1421, -1221, -2241, -3866, -3650, -3692, -3690, -3690, -3690, -3690, -3690, -3691, -3702, -3641, -3893, -5083, -5078, -5074, -5076, -5077, -5087, -5031, -5254, -6450, -6468, -6457, -6454, -7247, -7415, -7375, -7383, -7382, -7382, -7382, -7399, -7311, -7928, -8375, -8291, -8307, -8307, -8310, -8284, -9061, -9268, -9220, -9228, -9228, -9228, -9228, -9228, -9228, -9228, -9244, -9159, -9770, -10222, -10136, -10153, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10153, -9946, -11106, -5576, 7415, 6248, 6464, 6460, 6460, 6460, 6460, 6460, 6460, 6452, 6488, 6338, 5199, 4008, 3620, 3707, 3690, 3690, 3690, 3690, 3690, 3690, 3688, 3693, 3682, 3280, 3216, 3233, 3230, 3230, 3231, 2982, 4293, -3106, -11185, -9918, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10153, -10145, -10187, -9967, -9655, -9699, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9767, -9360, -11131};