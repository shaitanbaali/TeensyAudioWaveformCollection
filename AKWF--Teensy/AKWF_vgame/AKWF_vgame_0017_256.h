/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0017 256 samples */
 
const int16_t AKWF_vgame_0017_256_DATA [256] = 
{1349, 1693, 4737, 4900, 7610, 7687, 9217, 11429, 12171, 14930, 15180, 17537, 17238, 19216, 20606, 21406, 22778, 23186, 24589, 24371, 25456, 25719, 26822, 27519, 28311, 29405, 29254, 30433, 30584, 31232, 31536, 31166, 30990, 31030, 31017, 31031, 31413, 31482, 31085, 31066, 30751, 28227, 27891, 28009, 27868, 26291, 26346, 25271, 24078, 23035, 20406, 20210, 18360, 18194, 16220, 16340, 14910, 13535, 12585, 10387, 10082, 8186, 8470, 6835, 6238, 4388, 2469, 2036, 737, 927, 149, 49, -905, -1261, -2251, -3187, -3050, -3466, -3512, -3129, -3040, -3071, -3024, -3315, -3520, -3518, -3913, -3935, -3550, -3480, -3498, -3494, -3489, -3516, -3408, -2656, -2588, -1438, -1337, -980, -440, -135, 886, 1030, 2211, 2051, 3169, 3936, 4626, 5706, 6151, 7484, 7577, 10453, 11026, 10918, 10820, 11538, 12247, 12618, 14387, 14426, 14417, 14385, 14690, 14896, 14805, 14429, 14411, 14415, 14431, 14045, 14066, 13200, 12133, 12250, 12243, 12198, 11407, 11456, 10118, 9037, 9194, 9223, 8966, 7849, 7872, 6531, 6036, 6128, 6143, 5975, 5667, 5621, 4899, 4782, 4794, 4873, 4365, 3925, 3623, 2603, 2622, 2608, 2681, 2006, 1832, 884, -973, -871, -793, -1228, -2304, -1958, -3726, -5886, -5655, -5578, -6262, -7116, -6852, -8696, -9762, -9597, -9515, -10430, -11022, -10856, -13566, -14589, -14395, -14323, -16114, -16656, -16826, -19008, -19281, -19190, -19279, -20823, -20941, -22466, -24416, -24501, -24377, -24792, -26655, -26664, -28152, -29751, -29716, -29651, -29980, -30605, -30709, -31617, -31918, -31903, -31831, -32287, -32814, -32783, -32545, -32300, -32332, -32364, -32023, -31947, -31303, -29611, -29205, -29286, -29322, -27816, -27583, -26091, -23760, -23540, -23646, -23458, -21526, -21448, -19076, -16614, -16564, -16727, -16086, -13954, -13857, -9444, -5942, -6103, -6332, -5007, -3009, -2352};