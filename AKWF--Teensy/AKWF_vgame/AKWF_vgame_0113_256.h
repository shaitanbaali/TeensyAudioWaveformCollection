/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0113 256 samples */
 
const int16_t AKWF_vgame_0113_256_DATA [256] = 
{6141, 16871, 29047, 31459, 18430, 7250, 4079, 5102, 7167, 8753, 9644, 10051, 10191, 10204, 10160, 10094, 10021, 9945, 9870, 9796, 9722, 9649, 9579, 9510, 9440, 9374, 9308, 9244, 9181, 9120, 8944, 9363, 6967, -4614, -17697, -27020, -16970, -1554, 4182, 3514, 1163, -784, -1934, -2503, -2743, -2824, -2835, -2815, -2786, -2753, -2720, -2685, -2651, -2617, -2584, -2552, -2521, -2490, -2461, -2430, -2401, -2372, -2343, -2315, -2288, -2262, -2237, -2210, -2185, -2159, -2134, -2111, -2088, -2065, -2043, -2021, -1998, -1976, -1956, -1936, -1916, -1895, -1876, -1857, -1839, -1820, -1802, -1785, -1767, -1750, -1734, -1717, -1701, -1685, -1669, -1654, -1640, -1625, -1610, -1596, -1583, -1570, -1556, -1543, -1529, -1517, -1505, -1493, -1481, -1469, -1458, -1447, -1436, -1425, -1414, -1404, -1393, -1383, -1374, -1364, -1354, -1346, -1335, -1327, -1318, -1309, -1301, -1292, -1284, -1276, -1268, -1261, -1253, -1246, -1239, -1232, -1224, -1217, -1210, -1203, -1197, -1191, -1185, -1178, -1171, -1166, -1161, -1155, -1149, -1143, -1138, -1133, -1128, -1123, -1118, -1112, -1107, -1102, -1098, -1093, -1089, -1084, -1080, -1076, -1072, -1067, -1063, -1059, -1055, -1051, -1047, -1044, -1041, -1037, -1033, -1030, -1026, -1023, -1020, -1016, -1013, -1010, -1007, -1004, -1001, -998, -995, -992, -989, -988, -985, -983, -980, -978, -975, -972, -969, -967, -965, -963, -961, -958, -956, -954, -952, -950, -948, -946, -944, -942, -940, -938, -936, -935, -934, -932, -930, -928, -926, -925, -923, -921, -921, -919, -917, -916, -914, -913, -912, -910, -908, -908, -906, -905, -904, -903, -901, -899, -898, -898, -896, -895, -894, -893, -893, -891, -890, -889, -887, -886, -886, -885, -866, -974, -489, -499};