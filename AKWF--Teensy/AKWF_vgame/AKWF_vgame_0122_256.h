/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0122 256 samples */
 
const int16_t AKWF_vgame_0122_256_DATA [256] = 
{6259, 6886, 6751, 6779, 6780, 6781, 6988, 5895, 11255, 20185, 19118, 19309, 19310, 19308, 19306, 19303, 19300, 19298, 19295, 19292, 19289, 19285, 19282, 19425, 18631, 22089, 32316, 31692, 31778, 31781, 31774, 31769, 31764, 31757, 31750, 31743, 31737, 31729, 31722, 31715, 31708, 31700, 31692, 31685, 31677, 31669, 31661, 31654, 31646, 31638, 31630, 31622, 31614, 31605, 31596, 31588, 31581, 31572, 31564, 31556, 31547, 31539, 31531, 31523, 31514, 31506, 31497, 31489, 31481, 31472, 31464, 31455, 31446, 31439, 31431, 31422, 31413, 31405, 31397, 31388, 31380, 31372, 31363, 31354, 31346, 31338, 31329, 31321, 31313, 31304, 31296, 31288, 31279, 31270, 31262, 31254, 31245, 31172, 31494, 30255, 19200, 18511, 18711, 18658, 18650, 18643, 18637, 18630, 18623, 18617, 18611, 18604, 18599, 18593, 18564, 18588, 18685, 7938, 5570, 6137, 6026, 6021, 6018, 5833, 6805, 2134, -7330, -6349, -6537, -6533, -6534, -6535, -6533, -6750, -5594, -12092, -20065, -18838, -19074, -19066, -19065, -19062, -19060, -19057, -19054, -19052, -19049, -19045, -19041, -19038, -19035, -19081, -18834, -19706, -30691, -31767, -31480, -31532, -31527, -31521, -31514, -31509, -31502, -31495, -31488, -31481, -31474, -31467, -31459, -31451, -31444, -31436, -31429, -31421, -31413, -31405, -31398, -31390, -31382, -31374, -31366, -31358, -31350, -31342, -31333, -31324, -31316, -31308, -31300, -31292, -31285, -31275, -31267, -31259, -31251, -31243, -31233, -31225, -31217, -31210, -31201, -31192, -31184, -31176, -31168, -31159, -31150, -31142, -31135, -31125, -31117, -31109, -31101, -31093, -31083, -31075, -31068, -31059, -31050, -31042, -31034, -31026, -31017, -31009, -31000, -30857, -31611, -27729, -17834, -18562, -18420, -18415, -18408, -18401, -18395, -18387, -18382, -18375, -18369, -18364, -18358, -18351, -18259, -18724, -16813, -5843, -5757, -5810, -5784, -5779, -5775, -5772, -5768, -5780, -5698, -6043};