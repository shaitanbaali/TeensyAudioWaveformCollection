/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0099 256 samples */
 
const int16_t AKWF_vgame_0099_256_DATA [256] = 
{12096, 12106, 12114, 12121, 12125, 12130, 12132, 12135, 12137, 12138, 12138, 12137, 12136, 12135, 12132, 12130, 12127, 12122, 12120, 12116, 12111, 12106, 12102, 12099, 12093, 12088, 12082, 12077, 12071, 12067, 12061, 12055, 12049, 12044, 12038, 12032, 12025, 12020, 12014, 12006, 12000, 11993, 11987, 11981, 11975, 11969, 11963, 11956, 11950, 11944, 11937, 11931, 11924, 11917, 11911, 11904, 11898, 11892, 11887, 11879, 11872, 11866, 11860, 11853, 11847, 11840, 11833, 11827, 11820, 11814, 11808, 11801, 11795, 11789, 11782, 11775, 11768, 11762, 11756, 11750, 11743, 11737, 11729, 11723, 11717, 11710, 11704, 11697, 11691, 11685, 11679, 11671, 11665, 11659, 11652, 11645, 11639, 11633, 11627, 11621, 11614, 11607, 11601, 11594, 11587, 11581, 11575, 11569, 11562, 11556, 11549, 11542, 11537, 11531, 11525, 11518, 11512, 11504, 11497, 11491, 11484, 11478, 11472, 11466, 11459, 11369, 11771, 10297, -9571, -11308, -10845, -10943, -10944, -10945, -10947, -10947, -10945, -10946, -10944, -10942, -10941, -10938, -10935, -10933, -10929, -10926, -10922, -10919, -10916, -10911, -10906, -10902, -10898, -10892, -10887, -10883, -10877, -10872, -10868, -10863, -10857, -10853, -10847, -10842, -10837, -10832, -10826, -10820, -10816, -10809, -10803, -10799, -10793, -10787, -10783, -10777, -10770, -10764, -10760, -10754, -10748, -10743, -10738, -10732, -10726, -10721, -10715, -10708, -10703, -10698, -10692, -10687, -10681, -10675, -10670, -10665, -10659, -10653, -10648, -10643, -10636, -10631, -10626, -10618, -10614, -10609, -10602, -10598, -10590, -10584, -10580, -10575, -10569, -10565, -10559, -10552, -10547, -10542, -10536, -10529, -10524, -10519, -10513, -10508, -10502, -10496, -10491, -10485, -10481, -10474, -10469, -10464, -10457, -10452, -10447, -10442, -10436, -10431, -10424, -10408, -10802, -8735, -20422, -34111, -32449, -32744, -32725, -32562, -33440, -15860, -9150, -10580, -10305, -10308, -10249, -10454};