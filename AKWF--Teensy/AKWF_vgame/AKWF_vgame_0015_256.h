/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0015 256 samples */
 
const int16_t AKWF_vgame_0015_256_DATA [256] = 
{1872, 5074, 4742, 4867, 4528, 7433, 8699, 10688, 13054, 12286, 14765, 16963, 16331, 18114, 22069, 22853, 22706, 22580, 23521, 24595, 24448, 26010, 26251, 26242, 28207, 28307, 29184, 30862, 31420, 31461, 31455, 31465, 31093, 31004, 31026, 31028, 30992, 31162, 31475, 31468, 30623, 28984, 27806, 27980, 28060, 27524, 26075, 26459, 23744, 22615, 22294, 19608, 19767, 19198, 16975, 14007, 13434, 13515, 13770, 11554, 10359, 10189, 7418, 7654, 5809, 4085, 4606, 3022, 1064, -54, -3, 102, -593, -1446, -1149, -2139, -3193, -3033, -3440, -3538, -3335, -2995, -3360, -3524, -3489, -3488, -3858, -3948, -3931, -3561, -3479, -3498, -3491, -3506, -3194, -2897, -1777, -1722, -1820, -1420, -324, -664, 1227, 3270, 3010, 3074, 2986, 3387, 4675, 5810, 7176, 6895, 7195, 9126, 9173, 9233, 12024, 12803, 12640, 12650, 12729, 13886, 13989, 14697, 14890, 14846, 14853, 14851, 14870, 14397, 13560, 13535, 13531, 13605, 13206, 12652, 12471, 11751, 11800, 11818, 10688, 10482, 10241, 8333, 7306, 7457, 7417, 7466, 6743, 6571, 6006, 5616, 5692, 5678, 5663, 5731, 5121, 3674, 3450, 3498, 3528, 3235, 3043, 2996, 2209, 2216, 2026, 462, 507, -149, -1278, -2219, -2183, -2150, -2297, -4640, -4722, -5529, -6713, -6420, -7140, -7962, -7868, -9250, -10756, -11470, -11360, -11233, -11992, -13252, -12990, -15243, -15745, -16152, -17582, -17386, -17813, -18997, -20827, -21026, -20866, -21386, -23239, -23040, -23608, -25459, -25137, -27066, -28088, -28164, -29643, -30060, -30648, -30583, -30517, -31089, -31540, -31376, -31982, -32388, -32353, -32737, -32805, -32544, -32313, -31996, -31868, -31921, -31820, -30240, -30298, -29175, -26155, -26222, -26216, -26216, -26197, -24106, -22885, -20455, -20519, -20685, -19773, -18108, -18789, -14059, -10458, -11029, -10868, -11156, -9761, -7138, -4304, -1791, -2356, -1802};