/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0111 256 samples */
 
const int16_t AKWF_vgame_0111_256_DATA [256] = 
{3442, 6374, 5907, 6006, 5980, 6074, 9072, 11799, 12961, 12773, 12612, 13670, 15209, 14963, 16931, 17378, 17266, 19241, 19624, 19508, 21054, 22567, 22547, 22553, 22483, 22856, 23298, 23488, 24077, 24011, 24022, 24674, 24799, 24693, 25142, 25559, 25479, 25500, 25426, 25790, 26281, 26202, 26212, 26199, 26205, 26855, 26961, 26926, 26927, 26906, 26952, 27608, 27673, 27607, 27781, 28403, 28372, 28367, 28371, 28313, 28532, 29129, 29082, 29065, 29116, 29773, 29836, 29742, 30251, 30595, 30521, 30540, 30458, 30909, 31292, 31844, 32025, 31977, 31976, 31972, 31942, 32018, 32674, 32697, 32678, 32672, 32664, 32655, 32647, 32639, 32626, 32637, 32557, 31883, 31833, 31837, 31815, 31862, 31631, 30215, 30712, 27303, 25646, 26684, 26446, 26544, 26214, 23564, 23389, 22115, 21849, 22019, 21520, 18818, 19215, 16730, 12576, 12884, 12832, 12757, 13032, 10725, 7450, 5065, 5283, 5411, 4636, 612, 1243, -3151, -6614, -5716, -7884, -9344, -8835, -10927, -14669, -15208, -15086, -15048, -15348, -16589, -16785, -18634, -20574, -21239, -21091, -21145, -20980, -21966, -23487, -23335, -23362, -23322, -23481, -24054, -24432, -24900, -24821, -24830, -24824, -24830, -24762, -25307, -25615, -25493, -26076, -26338, -26272, -26274, -26918, -27045, -27005, -27005, -27004, -26968, -27082, -27728, -27727, -27716, -27710, -27723, -27608, -28493, -29281, -29162, -29175, -29167, -29174, -29093, -29555, -29950, -29880, -29834, -30418, -30658, -30597, -30608, -30552, -30755, -31371, -31272, -31505, -32098, -32042, -32041, -32043, -31987, -32574, -32802, -32745, -32745, -32737, -32728, -32720, -32712, -32704, -32695, -32687, -32677, -32658, -32707, -32379, -31951, -30937, -30239, -30465, -29975, -28724, -28972, -28230, -24532, -24220, -24294, -24232, -24391, -23569, -21507, -19058, -18926, -18946, -19015, -16434, -15970, -15065, -12651, -13172, -11677, -8818, -9268, -8466, -3172, -431, -897, -771, -876};