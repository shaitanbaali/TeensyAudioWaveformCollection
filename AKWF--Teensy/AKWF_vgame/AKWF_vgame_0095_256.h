/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0095 256 samples */
 
const int16_t AKWF_vgame_0095_256_DATA [256] = 
{322, 1290, 1862, 2425, 3664, 4329, 4922, 5876, 6797, 7339, 7941, 8580, 8768, 9909, 11222, 11901, 12599, 13489, 14349, 15028, 15862, 16377, 16996, 17898, 18726, 19607, 20273, 21337, 22366, 22890, 23409, 24036, 24463, 24574, 25328, 25761, 25988, 26909, 27654, 28271, 29054, 29645, 30113, 30522, 30514, 30573, 30926, 31067, 31494, 31707, 31886, 32373, 32461, 32503, 32627, 32769, 32531, 32362, 32269, 31892, 32059, 32393, 32372, 32430, 32484, 32407, 32167, 31683, 31191, 31038, 30777, 30548, 30359, 30106, 30332, 30169, 29739, 29502, 29250, 28670, 27950, 27995, 27808, 27584, 27711, 27409, 27002, 26714, 26362, 25673, 24845, 23993, 23084, 22308, 21776, 21403, 20644, 20071, 19690, 19004, 18375, 17710, 16940, 15952, 15259, 14522, 13748, 13589, 13197, 12520, 11921, 11250, 10708, 10106, 9353, 8418, 7623, 6907, 6403, 5909, 5102, 4602, 4055, 3357, 2513, 1570, 585, -421, -1196, -2144, -2841, -3251, -3985, -4615, -5314, -6195, -6910, -7690, -8863, -9961, -10798, -11467, -12107, -13163, -13934, -14678, -15598, -16242, -16940, -18018, -19048, -19823, -20702, -21456, -21779, -22298, -23015, -23575, -24231, -24784, -25395, -26317, -27073, -27750, -28180, -28408, -28749, -29098, -29296, -29604, -30064, -30419, -30731, -31219, -31591, -31712, -32124, -32329, -32038, -32080, -32110, -32029, -32169, -32180, -32290, -32354, -32320, -32227, -31965, -31693, -31651, -31495, -31287, -31227, -30957, -30878, -30955, -30787, -30701, -30506, -30162, -29688, -29252, -28862, -28322, -28018, -27639, -27324, -27127, -26853, -26494, -26086, -25727, -25194, -24704, -24179, -23642, -23076, -22736, -22534, -22196, -22102, -21614, -20871, -20309, -19457, -18618, -17828, -17191, -16654, -16288, -15925, -15375, -14892, -14177, -13544, -12810, -11935, -11230, -10653, -9948, -9276, -9061, -8506, -8041, -7835, -6854, -6114, -5489, -4735, -3888, -3000, -2239, -1703, -1266, -486};