/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0137 256 samples */
 
const int16_t AKWF_vgame_0137_256_DATA [256] = 
{6276, 16298, 20721, 19777, 19949, 19950, 19952, 19952, 19951, 19950, 19949, 19947, 19946, 19943, 19941, 19938, 19935, 19931, 19928, 19924, 19921, 19917, 19913, 19908, 19905, 19900, 19896, 20122, 18882, 27098, 33732, 32511, 32731, 32724, 32719, 32712, 32706, 32699, 32692, 32684, 32677, 32670, 32662, 32654, 32647, 32639, 32631, 32623, 32615, 32606, 32599, 32590, 32582, 32573, 32566, 32557, 32548, 32540, 32532, 32523, 32514, 32506, 32497, 32489, 32480, 32472, 32463, 32455, 32446, 32437, 32428, 32420, 32412, 32403, 32394, 32386, 32377, 32368, 32359, 32351, 32342, 32334, 32325, 32316, 32308, 32299, 32290, 32282, 32273, 32265, 32255, 32247, 32238, 32230, 32221, 32212, 32204, 32195, 32187, 32177, 32170, 32161, 32152, 32144, 32135, 32127, 32117, 32109, 32100, 32092, 32083, 32075, 32066, 32057, 32049, 32040, 32032, 32023, 32015, 32006, 31997, 31988, 31980, 31972, 31963, 30832, 36860, 4885, -37461, -31236, -32402, -32405, -32407, -32408, -32407, -32408, -32406, -32404, -32402, -32400, -32396, -32391, -32387, -32382, -32376, -32371, -32365, -32359, -32352, -32347, -32339, -32332, -32325, -32318, -32311, -32304, -32296, -32288, -32280, -32273, -32265, -32256, -32249, -32241, -32233, -32225, -32216, -32208, -32199, -32191, -32183, -32175, -32167, -32158, -32149, -32141, -32133, -32124, -32115, -32107, -32098, -32090, -32082, -32074, -32064, -32056, -32048, -32039, -32030, -32021, -32013, -32005, -31996, -31987, -31979, -31971, -31962, -31953, -31945, -31936, -31928, -31919, -31911, -31902, -31893, -31885, -31877, -31868, -31859, -31851, -31842, -31834, -31825, -31816, -31808, -31800, -31791, -31782, -31774, -31765, -31758, -31748, -31740, -31731, -31723, -31599, -32239, -29396, -18514, -18869, -18819, -18802, -18795, -18788, -18780, -18774, -18768, -18761, -18755, -18749, -18742, -18736, -18731, -18725, -18719, -18714, -18708, -18702, -18697, -18691, -18686, -18680, -18675, -18668, -18672, -18591};