/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0105 256 samples */
 
const int16_t AKWF_vgame_0105_256_DATA [256] = 
{2704, 3851, 3597, 3648, 3706, 3403, 4586, 12999, 13321, 13211, 13239, 13499, 12069, 18882, 32238, 30768, 31029, 31028, 31025, 31020, 31015, 31011, 31006, 31000, 30988, 30979, 31068, 27584, 26689, 26894, 26847, 26677, 27550, 24008, 5629, 5516, 5634, 5579, 5253, 6952, -1552, -15004, -13301, -13613, -13616, -13500, -14134, -9276, -6287, -6882, -6772, -6769, -6776, -6773, -4991, -4647, -4730, -4715, -4835, -4185, -6908, -17957, -17691, -17698, -17710, -17969, -16613, -23773, -33636, -32562, -32753, -32749, -32501, -33832, -16748, -8795, -10432, -10127, -10075, -10278, -9576, 6083, 8112, 7598, 7699, 7701, 7702, 7704, 7705, 7705, 7707, 7698, 7998, 6428, 15639, 25438, 23838, 24145, 24134, 24047, 24507, 19139, 16878, 17357, 17264, 17247, 17312, 17061, 14039, 13767, 13834, 13816, 13710, 14274, 11640, 5137, 5680, 5575, 5575, 5510, 5838, 3758, 1867, 2200, 2134, 2121, 2027, 2700, -9715, -13677, -12785, -12850, -13292, -15031, -14984, -14984, -14986, -14985, -14982, -14861, -15518, -12371, -6204, -6879, -6756, -6752, -6738, -6801, -6348, -6007, -6070, -6056, -6066, -6070, -5897, -12265, -13893, -13503, -13571, -13570, -13567, -13565, -13562, -13559, -13557, -13553, -13504, -13745, -12527, -10601, -10843, -10796, -10792, -10354, -12704, 6336, 17781, 15504, 15923, 15947, 15898, 15910, 27197, 29369, 28834, 28926, 28823, 29365, 27068, 17758, 17976, 17964, 17952, 17543, 19654, 8522, -6364, -4283, -4680, -4676, -4593, -5039, -928, 1137, 718, 792, 784, 808, 729, -1080, -1314, -1255, -1268, -1283, -1200, -1575, -2694, -2626, -2637, -2629, -2941, -1306, -10903, -21111, -19443, -19764, -19751, -19749, -19747, -19744, -19741, -19738, -19735, -19740, -19695, -19840, -21647, -21804, -21758, -21762, -21698, -22023, -20485, -16688, -17001, -16938, -16940, -16662, -18113, -8969, -655, -2128, -1842, -1852, -1800, -2015};