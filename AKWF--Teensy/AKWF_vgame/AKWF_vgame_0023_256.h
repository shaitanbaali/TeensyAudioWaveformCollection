/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0023 256 samples */
 
const int16_t AKWF_vgame_0023_256_DATA [256] = 
{805, 2621, 4396, 5873, 7116, 8850, 10050, 11603, 13187, 14529, 15774, 17281, 18571, 19771, 20547, 21584, 23165, 23448, 24340, 25050, 25784, 25798, 26737, 27642, 28314, 29405, 30082, 30555, 31100, 31472, 31450, 31477, 31121, 30999, 31035, 30981, 31265, 31395, 30972, 30648, 30314, 29400, 28399, 27668, 27380, 26618, 25999, 24848, 23263, 21733, 20586, 19596, 18551, 17533, 16534, 15188, 13967, 12542, 11786, 10960, 9503, 8452, 7511, 6103, 4718, 3920, 2579, 1873, 1085, 303, -224, -401, -1006, -1703, -2285, -3033, -3234, -3525, -3495, -3131, -3048, -3029, -3250, -3503, -3798, -3958, -3924, -3926, -3950, -3852, -3492, -3463, -3763, -3967, -3522, -2959, -2613, -2161, -1240, -724, -215, 301, 794, 1370, 2269, 2754, 3519, 4279, 5084, 5441, 6545, 7786, 8387, 8959, 9789, 10554, 11286, 11746, 12461, 12811, 13308, 13620, 14123, 14822, 14861, 14846, 14875, 14758, 14393, 14450, 14143, 13936, 13589, 13548, 13200, 12628, 12251, 12108, 11467, 10905, 10560, 10015, 9513, 8993, 8512, 7831, 7408, 7210, 6647, 6155, 6133, 5983, 5646, 5703, 5355, 5193, 4763, 4195, 3929, 3695, 3306, 3063, 2779, 2585, 2206, 1648, 971, 655, 132, -393, -825, -1160, -2047, -2738, -3559, -4293, -5065, -5866, -6544, -7019, -7544, -8056, -8544, -8974, -10027, -10757, -11406, -11852, -12336, -13412, -14190, -14956, -15964, -17006, -17618, -18064, -18386, -18961, -19809, -20552, -21291, -22147, -23137, -23808, -24627, -25365, -26423, -27105, -27882, -28267, -29175, -29767, -30252, -30804, -31029, -31332, -31500, -31959, -32316, -32526, -32794, -32761, -32766, -32774, -32422, -32326, -32261, -31750, -31231, -30733, -29884, -29183, -28289, -27966, -26746, -25922, -25195, -24441, -23383, -22024, -21301, -19962, -19294, -18278, -17222, -16337, -15452, -13488, -11840, -10330, -8829, -7038, -5239, -4070, -2283, -633};