/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0004 256 samples */
 
const int16_t AKWF_vgame_0004_256_DATA [256] = 
{621, 1425, 2183, 2924, 3651, 4375, 5120, 5910, 6772, 7716, 8753, 9894, 11141, 12480, 13894, 15359, 16847, 18343, 19820, 21252, 22625, 23919, 25120, 26227, 27231, 28128, 28922, 29617, 30216, 30728, 31159, 31518, 31813, 32052, 32243, 32395, 32513, 32602, 32669, 32716, 32746, 32762, 32766, 32756, 32732, 32695, 32641, 32570, 32479, 32364, 32222, 32051, 31845, 31601, 31312, 30968, 30545, 30021, 29491, 29025, 28614, 28233, 27873, 27534, 27222, 26939, 26683, 26449, 26237, 26042, 25865, 25706, 25559, 25424, 25299, 25180, 25067, 24956, 24846, 24733, 24618, 24495, 24366, 24227, 24076, 23912, 23734, 23539, 23327, 23098, 22848, 22580, 22290, 21978, 21646, 21291, 20911, 20513, 20091, 19645, 19179, 18689, 18178, 17647, 17094, 16521, 15929, 15317, 14687, 14041, 13375, 12694, 11999, 11287, 10562, 9826, 9074, 8312, 7541, 6759, 5969, 5171, 4363, 3551, 2735, 1910, 1084, 254, -571, -1366, -2128, -2871, -3598, -4322, -5065, -5851, -6706, -7644, -8674, -9807, -11048, -12378, -13789, -15251, -16737, -18233, -19713, -21149, -22527, -23827, -25036, -26149, -27160, -28065, -28868, -29570, -30175, -30693, -31130, -31494, -31794, -32036, -32231, -32386, -32505, -32596, -32664, -32714, -32745, -32762, -32766, -32757, -32735, -32699, -32646, -32577, -32486, -32372, -32234, -32065, -31862, -31621, -31335, -30996, -30580, -30062, -29528, -29057, -28643, -28260, -27898, -27558, -27244, -26960, -26702, -26466, -26252, -26056, -25877, -25717, -25570, -25434, -25308, -25189, -25076, -24965, -24854, -24742, -24627, -24505, -24376, -24238, -24088, -23925, -23748, -23555, -23344, -23116, -22868, -22601, -22313, -22003, -21672, -21318, -20942, -20544, -20123, -19679, -19215, -18728, -18217, -17688, -17137, -16564, -15974, -15364, -14734, -14090, -13426, -12746, -12052, -11341, -10617, -9881, -9131, -8370, -7601, -6819, -6028, -5231, -4424, -3613, -2796, -1974, -1151, -301};