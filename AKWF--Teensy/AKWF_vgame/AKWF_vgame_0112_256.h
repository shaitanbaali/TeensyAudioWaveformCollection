/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0112 256 samples */
 
const int16_t AKWF_vgame_0112_256_DATA [256] = 
{1759, 4106, 5235, 4862, 3612, 2526, 2325, 3141, 4806, 7024, 9225, 10472, 10053, 8440, 6991, 6678, 7635, 9548, 11990, 14106, 14647, 13228, 11213, 10732, 12690, 15902, 18240, 18519, 17163, 15445, 14356, 14275, 15277, 17323, 19851, 21634, 21525, 19637, 17508, 16533, 16809, 18084, 20321, 22948, 24445, 23574, 21016, 19153, 19875, 22817, 25755, 26596, 25177, 23102, 21921, 21898, 22624, 23958, 25920, 27667, 27823, 26188, 24076, 22867, 22945, 23972, 25727, 27792, 29058, 28614, 26807, 24994, 24139, 24184, 25056, 26989, 29510, 30936, 29812, 26994, 25134, 25886, 28522, 31015, 31815, 30821, 29002, 27447, 26796, 27292, 28908, 31129, 32660, 32329, 30309, 28117, 27176, 27559, 27888, 26609, 23621, 20598, 19587, 20863, 22352, 21775, 18968, 15569, 13247, 12606, 13135, 13899, 14102, 13325, 11501, 8943, 6373, 4812, 4798, 5798, 6714, 6821, 5986, 4305, 1931, -443, -1711, -1519, -573, 233, 452, -138, -1975, -4926, -7521, -8021, -6326, -4381, -4303, -6360, -9127, -11071, -11636, -11154, -10229, -9472, -9388, -10197, -11730, -13508, -14937, -15546, -15187, -14150, -13099, -12863, -14016, -16432, -18962, -20079, -19201, -17251, -15766, -15527, -16329, -17967, -20273, -22363, -22875, -21366, -19215, -18386, -19482, -21558, -23329, -24105, -23881, -22973, -21884, -21233, -21494, -22599, -23964, -25092, -25798, -25893, -25138, -23730, -22678, -23176, -25392, -27962, -29048, -28006, -25974, -24724, -25073, -26466, -27931, -28917, -29278, -28954, -28007, -26916, -26387, -26780, -27897, -29211, -30182, -30496, -30083, -29043, -27749, -26966, -27330, -28721, -30313, -31247, -31177, -30357, -29303, -28450, -27853, -27166, -26180, -25215, -24783, -24910, -24958, -24340, -23039, -21195, -18971, -16920, -15845, -16024, -16717, -16864, -16111, -14676, -12704, -10260, -8045, -7311, -8307, -9576, -9304, -6972, -3665, -1198, -676, -1716, -3002, -3448, -2652, -694};