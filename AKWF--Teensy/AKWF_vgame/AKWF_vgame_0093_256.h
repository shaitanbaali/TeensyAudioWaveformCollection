/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0093 256 samples */
 
const int16_t AKWF_vgame_0093_256_DATA [256] = 
{1771, 5675, 9660, 13632, 17506, 21191, 24477, 27239, 29388, 30859, 31654, 31856, 31426, 30262, 28382, 25870, 22860, 19564, 16221, 12902, 9664, 6661, 3964, 1698, 42, -998, -1524, -1572, -1190, -404, 827, 2520, 4580, 6930, 9526, 12303, 15165, 18052, 20819, 23303, 25388, 27009, 28115, 28708, 28791, 28348, 27379, 25902, 23953, 21622, 18982, 16190, 13426, 10806, 8403, 6242, 4217, 2304, 633, -665, -1424, -1463, -785, 518, 2378, 4705, 7399, 10347, 13413, 16385, 19075, 21463, 23502, 25187, 26540, 27506, 27981, 27949, 27411, 26399, 25028, 23380, 21465, 19344, 17042, 14611, 12189, 9899, 7875, 6309, 5256, 4732, 4710, 5064, 5706, 6600, 7709, 9028, 10570, 12315, 14202, 16181, 18174, 20096, 21915, 23562, 24975, 26105, 26845, 27115, 26848, 25986, 24620, 22873, 20924, 19000, 17217, 15671, 14402, 13355, 12485, 11746, 11076, 10466, 9900, 9343, 8776, 8125, 7297, 6212, 4747, 2828, 468, -2325, -5462, -8796, -12311, -15919, -19508, -23014, -26260, -28974, -31062, -32389, -32798, -32655, -31862, -30383, -28289, -25680, -22666, -19441, -16318, -13345, -10537, -7944, -5555, -3415, -1698, -514, 126, 227, -271, -1400, -3146, -5492, -8284, -11165, -14041, -16891, -19651, -22383, -25078, -27445, -29281, -30492, -31022, -30889, -30211, -28962, -27005, -24399, -21320, -17929, -14579, -11495, -8790, -6554, -4882, -3823, -3419, -3696, -4583, -5904, -7543, -9368, -11301, -13318, -15400, -17520, -19660, -21736, -23649, -25275, -26462, -27146, -27319, -26996, -26261, -25180, -23777, -22109, -20219, -18154, -16050, -14035, -12222, -10735, -9592, -8786, -8306, -8084, -8083, -8336, -8856, -9624, -10631, -11797, -13040, -14313, -15594, -16844, -18038, -19137, -20051, -20718, -21113, -21225, -21086, -20743, -20234, -19599, -18872, -18089, -17260, -16364, -15414, -14428, -13412, -12418, -11434, -10326, -8940, -7126, -4710, -1622};