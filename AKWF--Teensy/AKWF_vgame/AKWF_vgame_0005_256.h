/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0005 256 samples */
 
const int16_t AKWF_vgame_0005_256_DATA [256] = 
{-3, 211, 767, 1275, 1787, 2302, 2815, 3328, 3842, 4364, 4878, 5392, 5906, 6419, 6933, 7446, 7962, 8483, 8997, 9509, 10024, 10538, 11050, 11563, 12083, 12600, 13114, 13628, 14141, 14655, 15168, 15682, 16203, 16718, 17232, 17746, 18259, 18772, 19286, 19803, 20322, 20837, 21349, 21864, 22377, 22890, 23403, 23925, 24439, 24953, 25468, 25981, 26495, 27008, 27523, 28044, 28558, 29071, 29586, 30099, 30612, 31126, 31640, 32160, 32692, 32517, 31933, 31435, 30922, 30408, 29894, 29374, 28859, 28344, 27831, 27318, 26803, 26291, 25774, 25253, 24741, 24226, 23713, 23200, 22686, 22172, 21653, 21135, 20623, 20109, 19595, 19081, 18568, 18052, 17532, 17019, 16504, 15991, 15477, 14963, 14450, 13932, 13413, 12901, 12387, 11872, 11360, 10846, 10331, 9811, 9295, 8782, 8270, 7755, 7240, 6728, 6212, 5691, 5179, 4665, 4151, 3637, 3122, 2610, 2092, 1573, 1061, 549, 40, -470, -985, -1505, -2019, -2532, -3047, -3560, -4075, -4588, -5105, -5624, -6137, -6650, -7164, -7679, -8192, -8706, -9227, -9741, -10255, -10769, -11282, -11797, -12309, -12825, -13346, -13859, -14372, -14887, -15401, -15913, -16427, -16946, -17463, -17977, -18490, -19005, -19518, -20031, -20546, -21067, -21581, -22094, -22609, -23122, -23635, -24149, -24665, -25186, -25699, -26212, -26727, -27239, -27752, -28266, -28787, -29303, -29817, -30331, -30843, -31358, -31855, -32427, -32743, -32247, -31711, -31207, -30693, -30179, -29665, -29152, -28633, -28114, -27603, -27089, -26575, -26062, -25548, -25033, -24513, -23997, -23484, -22971, -22457, -21943, -21431, -20914, -20394, -19881, -19367, -18853, -18340, -17825, -17312, -16793, -16275, -15763, -15249, -14735, -14221, -13708, -13193, -12674, -12158, -11645, -11131, -10617, -10103, -9591, -9072, -8554, -8042, -7527, -7013, -6500, -5986, -5472, -4953, -4436, -3923, -3410, -2895, -2382, -1870, -1353, -838, -300};