/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0061 256 samples */
 
const int16_t AKWF_vgame_0061_256_DATA [256] = 
{24276, 34116, 32457, 32761, 32767, 32695, 33089, 30307, 27301, 27780, 27687, 27689, 27678, 27742, 27476, 26287, 26301, 26336, 25983, 25814, 25850, 25843, 25843, 25761, 26205, 23992, 20395, 20850, 20768, 20768, 20699, 21061, 19022, 16782, 17141, 17074, 17074, 17030, 17273, 16267, 11937, 12000, 12007, 11998, 11993, 11973, 12147, 8297, 7198, 7125, 6891, 6929, 6922, 6918, 6880, 7135, 3399, 2061, 2360, 2306, 2300, 2306, 2339, -840, -1518, -1355, -1385, -1393, -1354, -1489, -3527, -3736, -3679, -3691, -3700, -3650, -3850, -5059, -5084, -5073, -5076, -5081, -5055, -5167, -5552, -5534, -5536, -5537, -5548, -5482, -6195, -6517, -6447, -6460, -6462, -6465, -6433, -7208, -7424, -7373, -7382, -7382, -7399, -7311, -7848, -8380, -8289, -8307, -8306, -8322, -8236, -8871, -9296, -9213, -9229, -9228, -9228, -9228, -9229, -9229, -9232, -9208, -9990, -10191, -10144, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10150, -10161, -9944, -10144, -5515, 7207, 6303, 6456, 6460, 6438, 6555, 5989, 4979, 5097, 5076, 5076, 5051, 5182, 4478, 3583, 3714, 3689, 3690, 3681, 3727, 3442, 3193, 3238, 3229, 3230, 3193, 3395, 1738, 758, 960, 922, 811, 1423, -1222, -10506, -10085, -10148, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10152, -10153, -10144, -10188, -9879, -9656, -9698, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9690, -9766, -9364, -11126};