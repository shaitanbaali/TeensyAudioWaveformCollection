/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0006 256 samples */
 
const int16_t AKWF_vgame_0006_256_DATA [256] = 
{0, 1, 2, 3, 5, 5, 6, 7, 7, 8, 9, 10, 11, 11, 11, 12, 14, 13, 14, 14, 15, 16, 16, 17, 16, 17, 17, 18, 19, 18, 19, 20, 20, 20, 20, 21, 20, 21, 21, 21, 21, 20, 22, 23, 22, 23, 23, 23, 22, 23, 24, 23, 24, 24, 24, 24, 24, 24, 24, 24, 24, 23, 24, 24, 24, 25, 24, 24, 24, 23, 23, 23, 20, 105, -110, 845, 17712, 29874, 31743, 32117, 14879, 1759, -679, -2692, -3020, -2859, -2783, -2759, -2714, -2655, -2599, -2548, -2496, -2445, -2395, -2346, -2298, -2251, -2205, -2160, -2115, -2071, -2027, -1984, -1943, -1902, -1862, -1823, -1784, -1746, -1708, -1671, -1635, -1599, -1564, -1531, -1497, -1463, -1432, -1400, -1369, -1339, -1308, -1279, -1250, -1222, -1195, -1167, -1140, -1114, -1089, -1064, -1039, -1014, -990, -968, -946, -923, -901, -879, -858, -838, -818, -798, -778, -760, -741, -723, -705, -687, -670, -653, -637, -621, -605, -590, -575, -560, -545, -531, -517, -503, -490, -477, -464, -453, -439, -427, -416, -405, -394, -383, -372, -362, -351, -341, -331, -321, -313, -304, -294, -286, -278, -269, -261, -253, -246, -238, -231, -223, -216, -210, -203, -197, -190, -183, -177, -171, -166, -160, -154, -149, -144, -139, -133, -128, -123, -119, -115, -111, -107, -103, -99, -95, -91, -87, -84, -80, -76, -73, -70, -67, -63, -61, -58, -55, -52, -49, -47, -44, -42, -40, -37, -35, -33, -31, -29, -26, -25, -23, -21, -19, -17, -16, -14, -12, -11, -9, -8, -7, -6, -5, -3, -2, -1, 0};