/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0119 256 samples */
 
const int16_t AKWF_vgame_0119_256_DATA [256] = 
{1031, 2346, 2110, 3795, 4082, 5681, 6589, 6691, 8396, 8503, 10561, 10688, 11503, 12726, 13261, 15095, 15248, 17007, 16803, 18205, 19469, 19359, 20953, 21863, 23704, 23437, 24065, 25532, 25414, 29525, 18719, 2872, 4855, 5519, 7129, 6888, 8339, 10236, 11384, 11086, 11504, 13127, 13270, 15177, 16866, 17542, 17234, 18026, 19889, 19572, 21049, 23723, 24057, 23927, 24095, 25818, 25872, 27976, 30157, 30203, 30064, 30556, 31633, 36394, 3381, -19714, -14980, -16042, -15187, -13393, -13725, -12956, -11601, -11240, -9200, -9457, -8102, -7392, -6313, -4835, -5068, -3307, -3132, -1323, -759, 432, 1296, 1368, 3501, 3412, 4456, 5517, 7221, 7702, 8909, -9786, -16826, -13694, -12863, -11360, -11051, -11090, -9003, -8814, -8167, -6441, -4562, -4427, -4626, -3195, -2558, -1485, 396, 1774, 1760, 1653, 3592, 4141, 4335, 6928, 8509, 8362, 8208, 9396, 9827, 13160, -36, -14949, -12408, -13084, -11359, -10433, -10539, -7110, -6121, -6302, -6429, -5536, -4316, -3864, -341, 7, -65, -132, 232, 2228, 2366, 4434, 4519, 5383, 6580, 7072, 9074, 10639, 10912, 10636, 12108, 13317, 12918, 16277, 9130, -8959, -7551, -7191, -5751, -5409, -3559, -2641, -1310, -1707, -534, 1020, 802, 2276, 4182, 5289, 4996, 5416, 7039, 7217, 9140, 10818, 11465, 11159, 11990, 13823, 13515, 15015, 17680, 17771, 18751, 14857, -29874, -33603, -30453, -28500, -28463, -28592, -28089, -26052, -26406, -24581, -21661, -21900, -21859, -21864, -20113, -20088, -17568, -15352, -15654, -15657, -15411, -13307, -13387, -12333, -11313, -10575, -8786, -9089, -7443, -7085, -5723, -3962, -6727, -26656, -27860, -26433, -25474, -23779, -23032, -23291, -21651, -21282, -19764, -18687, -17179, -16875, -16900, -14819, -14626, -13968, -12238, -10360, -10227, -10419, -8954, -8352, -7274, -5357, -3990, -4025, -4121, -2189, -1652, -1339};