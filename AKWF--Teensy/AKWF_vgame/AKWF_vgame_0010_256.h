/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0010 256 samples */
 
const int16_t AKWF_vgame_0010_256_DATA [256] = 
{1427, 1282, 1316, 1320, 1439, 675, 10749, 16552, 15537, 15729, 15724, 15793, 15428, 19113, 20823, 20470, 20534, 20608, 20210, 22223, 27993, 27965, 27947, 27963, 28000, 27800, 28694, 31167, 30990, 31022, 31021, 31029, 30986, 31240, 31493, 31449, 31458, 31458, 31435, 31561, 29790, 29158, 29299, 29269, 29245, 29414, 25913, 20615, 20501, 20550, 20534, 20465, 20848, 19036, 14963, 15364, 15289, 15208, 15582, 13571, 7010, 4956, 5326, 5240, 5237, 5219, 5378, 1730, 669, 918, 866, 869, 910, -1298, -3528, -3493, -3489, -3494, -3488, -3524, -3344, -3027, -3065, -3058, -3073, -2984, -3477, -3733, -3447, -3502, -3495, -3493, -3494, -3506, -2760, -2587, -2628, -2611, -2626, -2629, -144, 2677, 2613, 2613, 2619, 2672, 2393, 3812, 5901, 5628, 5677, 5751, 5408, 7438, 11947, 12802, 12622, 12668, 12672, 12656, 12701, 14224, 14465, 14405, 14416, 14411, 14436, 14328, 13966, 13982, 13980, 13980, 13948, 14118, 13185, 12095, 12263, 12223, 12262, 12104, 10334, 8436, 7742, 7890, 7834, 7984, 6710, 5999, 6142, 6116, 6116, 6100, 6163, 5775, 4753, 3427, 3511, 3493, 3494, 3470, 3598, 2837, 2079, 2207, 2174, 2221, 2021, 630, -1588, -2316, -2153, -2185, -2203, -2105, -2476, -5959, -6162, -6104, -6156, -5982, -7137, -9346, -11509, -11316, -11360, -11357, -11420, -11085, -13276, -15130, -14791, -14876, -14770, -15206, -17762, -20385, -21103, -20939, -20972, -20997, -20857, -21414, -24848, -24928, -24893, -24965, -24675, -26861, -29555, -31149, -30981, -31021, -31022, -31043, -30926, -31826, -32428, -32309, -32335, -32313, -32403, -32735, -31646, -31410, -31468, -31457, -31435, -31554, -31070, -28825, -28833, -28817, -28952, -28317, -25282, -23175, -20226, -20605, -20534, -20533, -20465, -20840, -17651, -15872, -16229, -16051, -16654, -11921, -8549, -3076, -1987, -2229, -2185, -2156, -2305, -1649};