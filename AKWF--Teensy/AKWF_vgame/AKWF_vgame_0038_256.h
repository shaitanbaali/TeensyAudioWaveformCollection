/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0038 256 samples */
 
const int16_t AKWF_vgame_0038_256_DATA [256] = 
{434, 1469, 3729, 5422, 6722, 8109, 10883, 12059, 14285, 16050, 16043, 17852, 18633, 19487, 20285, 21391, 22222, 22376, 22774, 23057, 23683, 24386, 24990, 25279, 25560, 25918, 26470, 26570, 26634, 27022, 26992, 27086, 27477, 27392, 27959, 28744, 29130, 29429, 30880, 31492, 32012, 32771, 32763, 32757, 32158, 31275, 29654, 28870, 28184, 26186, 24639, 23732, 22303, 20182, 19682, 18879, 18393, 18059, 17049, 16277, 15591, 15172, 13973, 13243, 11616, 10278, 8839, 5967, 4173, 3291, 1743, -251, -990, -2016, -2436, -2772, -3112, -3075, -3191, -3584, -3880, -4558, -5860, -6966, -8749, -9676, -11288, -12907, -14876, -15965, -18587, -21017, -21168, -22139, -23082, -23035, -22896, -22555, -22591, -22575, -22227, -21876, -21556, -21026, -20783, -20818, -20803, -20852, -20095, -19148, -18496, -16782, -15699, -14607, -11828, -9768, -8578, -6143, -3702, -2320, -309, 697, 1797, 3718, 4584, 4830, 5673, 6621, 6645, 7014, 7100, 7080, 7084, 7084, 7084, 7083, 7086, 7079, 6680, 6680, 6360, 5491, 5187, 3920, 3027, 1098, 273, -305, -757, -904, -903, -770, -419, -449, -432, -812, -898, -1105, -1834, -3478, -3806, -5695, -6926, -7481, -9162, -11141, -11507, -11682, -12235, -12571, -12878, -12778, -13125, -13890, -14557, -14991, -15835, -16250, -16409, -16375, -16393, -16350, -16033, -16374, -16393, -16355, -16694, -16848, -16845, -16702, -16356, -16390, -16385, -16004, -15925, -15937, -15972, -15666, -15475, -15462, -15064, -15062, -15010, -14614, -14622, -14476, -13438, -12858, -12215, -11197, -10600, -9242, -8025, -7272, -6578, -6380, -6016, -5511, -5158, -4887, -4628, -4392, -4435, -4426, -4426, -4426, -4427, -4431, -4407, -4510, -4891, -4839, -5124, -5690, -6161, -6207, -6195, -6198, -6199, -6199, -6201, -6184, -6551, -6662, -6636, -6640, -6639, -6643, -6636, -6161, -5736, -5445, -4864, -3471, -2712, -1898};