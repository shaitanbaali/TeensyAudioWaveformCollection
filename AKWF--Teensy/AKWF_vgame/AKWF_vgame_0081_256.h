/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0081 256 samples */
 
const int16_t AKWF_vgame_0081_256_DATA [256] = 
{3306, 7774, 10767, 12393, 13195, 12511, 11627, 10134, 8826, 8052, 7291, 6970, 7008, 7479, 8321, 8468, 8733, 8974, 8914, 8922, 8921, 8919, 8918, 8917, 8915, 8914, 8912, 8911, 8898, 8938, 8849, 8442, 8393, 8424, 8412, 8410, 8419, 8365, 8513, 8897, 8897, 8876, 8881, 8878, 8866, 8921, 8706, 8351, 8379, 8390, 8372, 8349, 8713, 8901, 8842, 8852, 8839, 8872, 8811, 8401, 8327, 8363, 8350, 8348, 8357, 8307, 8422, 8819, 8839, 8811, 8817, 8813, 8811, 8809, 8807, 8804, 8802, 8800, 8798, 8796, 8793, 8791, 8788, 8786, 8784, 8781, 8779, 8777, 8774, 8772, 8769, 8767, 8765, 8762, 8760, 8758, 8755, 8753, 8751, 8748, 8746, 8744, 8741, 8739, 8737, 8735, 8732, 8730, 8728, 8725, 8723, 8721, 8718, 8716, 8713, 8711, 8709, 8706, 8704, 8702, 8699, 8697, 8695, 8692, 8690, 8688, 8685, 8683, 8682, 8669, 8704, 8634, 8225, 8158, 8192, 8180, 8189, 8131, 8310, 8680, 8660, 8646, 8647, 8642, 8690, 8388, 8108, 8160, 8152, 8155, 8136, 8129, 8514, 8666, 8610, 8621, 8607, 8646, 8557, 8148, 8101, 8130, 8119, 8127, 8067, 8282, 8592, 8658, 9044, 9091, 9082, 8769, 8304, 7826, 7619, 7500, 7122, 7100, 7131, 7515, 7611, 7797, 8507, 9389, 10266, 11046, 11462, 11447, 10338, 8421, 5145, 792, -4498, -10631, -16564, -22055, -26786, -30374, -32061, -32759, -32158, -30755, -29325, -27663, -26403, -25572, -25482, -25845, -26631, -27261, -27620, -28082, -28443, -28335, -27915, -27868, -27926, -27558, -27339, -27389, -27384, -27335, -27415, -27816, -27855, -27817, -27774, -28068, -28376, -28098, -27788, -27708, -27324, -27268, -26902, -26749, -26792, -26773, -26777, -26734, -26800, -27234, -27663, -28053, -28792, -29773, -30123, -30138, -29798, -28351, -26022, -22227, -17592, -12096, -7153, -1918};