/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0128 256 samples */
 
const int16_t AKWF_vgame_0128_256_DATA [256] = 
{6650, 6131, 6254, 6235, 6237, 6240, 6242, 6244, 6244, 6246, 6241, 6419, 5479, 15445, 19726, 18813, 18975, 19017, 18814, 19517, 30750, 31944, 31630, 31687, 31682, 31677, 31673, 31667, 31661, 31655, 31649, 31643, 31635, 31628, 31622, 31615, 31608, 31600, 31471, 32161, 21799, 18181, 18982, 18826, 18756, 19077, 17824, 6541, 5926, 6100, 6054, 6050, 6045, 6040, 6037, 6034, 6030, 6027, 6023, 6020, 6017, 6015, 6012, 6009, 6170, 5294, 9166, 19358, 18600, 18718, 18720, 18716, 18713, 18709, 18706, 18702, 18699, 18694, 18690, 18686, 18681, 18677, 18673, 18668, 18664, 18660, 18655, 18650, 18646, 18641, 18636, 18603, 18658, 18631, 7689, 5434, 5982, 5874, 5762, 6344, 3931, -6951, -6882, -6846, -6873, -7096, -5928, -11905, -20542, -19399, -19605, -19606, -19605, -19603, -19601, -19598, -19596, -19593, -19589, -19586, -19583, -19579, -19575, -19572, -19568, -19425, -20161, -16933, -6394, -6893, -6824, -6814, -6572, -7811, -945, 6928, 5709, 5942, 5933, 6112, 5171, 15138, 19420, 18509, 18672, 18669, 18668, 18667, 18664, 18662, 18660, 18657, 18654, 18650, 18647, 18643, 18640, 18636, 18641, 18397, 19639, 12169, 4874, 6114, 5872, 5877, 5751, 6446, -3912, -7528, -6717, -6869, -6934, -6595, -7931, -19150, -19736, -19560, -19599, -19598, -19596, -19594, -19592, -19589, -19586, -19583, -19580, -19576, -19573, -19569, -19565, -19562, -19557, -19553, -19548, -19544, -19540, -19535, -19529, -19440, -19900, -18036, -6969, -6705, -6805, -6770, -6766, -6762, -6758, -6755, -6751, -6749, -6748, -6949, -5822, -14610, -20397, -19245, -19459, -19456, -19452, -19449, -19444, -19440, -19436, -19433, -19543, -18926, -21469, -32013, -32160, -32102, -32127, -32121, -32115, -32108, -32101, -32096, -32089, -32081, -32074, -32066, -32059, -32052, -32044, -32035, -31957, -32211, -31153, -9258, -5838, -6691, -6526, -6413, -6967, -4491};