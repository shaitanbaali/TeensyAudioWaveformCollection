/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0088 256 samples */
 
const int16_t AKWF_vgame_0088_256_DATA [256] = 
{3100, 5275, 4842, 4928, 4928, 4959, 4799, 5380, 9501, 9626, 9573, 9587, 9586, 9607, 9502, 9836, 13995, 14330, 14224, 14244, 14245, 14164, 14581, 12154, 13394, 14448, 14191, 14222, 14234, 14106, 14640, 16466, 17881, 19111, 18815, 18858, 18853, 18925, 18524, 20402, 23850, 23426, 23500, 23493, 23486, 23546, 23197, 24686, 28408, 28064, 28120, 28112, 28106, 28097, 28165, 27771, 31124, 33004, 32675, 32729, 32722, 32713, 32634, 32985, 29875, 27657, 28091, 27996, 27990, 27952, 28103, 27514, 23386, 23252, 23298, 23277, 23268, 23240, 23336, 22994, 18826, 18483, 18581, 18552, 18546, 18543, 18452, 18887, 16711, 13491, 13932, 13839, 13835, 13910, 13458, 15763, 14935, 13537, 13858, 13806, 13803, 13721, 14114, 12228, 8771, 9186, 9104, 9102, 9100, 9030, 9375, 7819, 4141, 4481, 4416, 4415, 4412, 4412, 4333, 4739, 1280, -594, -192, -272, -272, -270, -363, 112, -3054, -5312, -4860, -4949, -4947, -4977, -4818, -5401, -9520, -9647, -9594, -9607, -9606, -9601, -9692, -9219, -11718, -14646, -14178, -14266, -14264, -14184, -14602, -12173, -13413, -14468, -14211, -14242, -14256, -14116, -14705, -16550, -17960, -19121, -18838, -18878, -18872, -18946, -18545, -20422, -23870, -23445, -23519, -23511, -23507, -23501, -23558, -23208, -26892, -28430, -28072, -28133, -28126, -28118, -28185, -27790, -31145, -33024, -32695, -32749, -32741, -32733, -32658, -32990, -29851, -27684, -28110, -28016, -28010, -27972, -28124, -27534, -23406, -23273, -23319, -23297, -23289, -23260, -23357, -23010, -18849, -18505, -18601, -18573, -18567, -18563, -18472, -18908, -16731, -13511, -13953, -13860, -13855, -13930, -13485, -15758, -14887, -13569, -13875, -13825, -13822, -13741, -14135, -12248, -8791, -9207, -9125, -9123, -9119, -9117, -9053, -9392, -5710, -4159, -4503, -4435, -4433, -4433, -4354, -4759, -1301, 574, 172, 252, 252, 247, 278, 164};