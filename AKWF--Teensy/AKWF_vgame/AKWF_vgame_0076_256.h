/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0076 256 samples */
 
const int16_t AKWF_vgame_0076_256_DATA [256] = 
{2647, 8885, 11968, 12764, 12713, 11831, 9917, 8050, 7116, 7702, 9495, 11535, 12702, 12698, 11883, 10724, 9905, 9601, 9633, 9815, 9937, 9965, 9956, 9933, 9922, 9921, 9919, 9917, 9915, 9913, 9911, 9908, 9906, 9904, 9901, 9900, 9896, 9894, 9892, 9890, 9887, 9884, 9882, 9880, 9877, 9874, 9872, 9869, 9866, 9864, 9862, 9859, 9857, 9854, 9851, 9849, 9846, 9843, 9841, 9839, 9836, 9833, 9831, 9828, 9826, 9822, 9820, 9817, 9815, 9812, 9810, 9807, 9804, 9802, 9799, 9797, 9794, 9791, 9789, 9786, 9784, 9781, 9778, 9775, 9773, 9770, 9767, 9765, 9762, 9760, 9756, 9755, 9752, 9750, 9747, 9744, 9742, 9739, 9737, 9733, 9731, 9728, 9726, 9723, 9721, 9718, 9715, 9713, 9710, 9707, 9705, 9702, 9700, 9697, 9695, 9692, 9689, 9686, 9684, 9681, 9679, 9676, 9674, 9671, 9668, 9666, 9663, 9661, 9658, 9656, 9653, 9651, 9647, 9645, 9643, 9640, 9637, 9635, 9632, 9630, 9627, 9624, 9622, 9619, 9617, 9614, 9612, 9609, 9607, 9604, 9601, 9599, 9596, 9593, 9591, 9589, 9586, 9583, 9580, 9578, 9575, 9573, 9570, 9568, 9565, 9563, 9560, 9558, 9555, 9552, 9550, 9547, 9545, 9542, 9539, 9537, 9535, 9531, 9534, 9551, 9560, 9549, 9387, 8971, 8743, 9144, 10889, 12377, 12276, 12329, 7394, -2711, -13734, -23020, -28839, -31735, -32652, -32771, -32522, -31738, -30771, -29972, -29582, -29587, -29781, -29923, -29954, -29944, -29916, -29899, -29893, -29887, -29880, -29874, -29867, -29860, -29853, -29846, -29839, -29832, -29824, -29817, -29810, -29802, -29795, -29787, -29780, -29772, -29764, -29756, -29749, -29741, -29733, -29725, -29717, -29710, -29702, -29694, -29686, -29678, -29670, -29667, -29679, -29683, -29667, -29502, -29084, -28843, -29230, -30926, -32440, -32349, -32456, -27644, -17577, -6390};