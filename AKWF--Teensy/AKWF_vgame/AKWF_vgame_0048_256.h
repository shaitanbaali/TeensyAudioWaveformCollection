/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0048 256 samples */
 
const int16_t AKWF_vgame_0048_256_DATA [256] = 
{1911, 1553, 3146, 3921, 4945, 6280, 6095, 8056, 8233, 10252, 10993, 11221, 12667, 12844, 15165, 15314, 16777, 17102, 16996, 19282, 19645, 21194, 22079, 23474, 23585, 23704, 25671, 25699, 26417, 27994, 29703, 29720, 29650, 30346, 30540, 31270, 32112, 32333, 32324, 32345, 31975, 31892, 31824, 31268, 30992, 31015, 31084, 30683, 29674, 29749, 29484, 29239, 29267, 29335, 28696, 28337, 28431, 27404, 27022, 27089, 27148, 26774, 26190, 26070, 24973, 24886, 24894, 24971, 24482, 23963, 24037, 23255, 23172, 22503, 22270, 22129, 21401, 21352, 20560, 20589, 20139, 19643, 19408, 18765, 18656, 17871, 18019, 17154, 16513, 16566, 15833, 15468, 14794, 14917, 14616, 13910, 14060, 13127, 12229, 11741, 11820, 11756, 10980, 10925, 9923, 9091, 8673, 8793, 8567, 7414, 7478, 7029, 5909, 5635, 5680, 5728, 4629, 4355, 3861, 2415, 2129, 2204, 2169, 1387, 1353, 995, -783, -897, -878, -807, -1442, -1688, -2436, -4007, -3917, -3942, -3863, -4916, -5278, -5392, -6111, -6218, -7389, -7376, -7819, -8316, -8545, -9245, -9090, -10141, -10493, -10986, -11359, -11716, -12304, -12196, -13342, -13543, -13793, -14400, -14895, -15374, -15205, -15794, -16131, -16688, -17520, -18054, -18419, -18278, -18950, -19252, -19329, -20067, -20804, -21024, -20900, -21293, -21917, -21790, -22557, -23551, -23610, -23561, -23694, -24454, -24461, -25337, -26223, -26223, -26170, -26390, -27133, -27007, -27542, -28464, -28387, -28397, -28404, -28798, -28778, -29628, -30227, -30134, -30129, -30218, -30993, -30999, -31216, -31466, -31580, -31928, -31864, -32220, -32324, -32568, -32804, -32391, -32312, -32356, -31216, -31053, -30087, -29706, -29412, -27480, -27661, -26556, -25705, -24029, -23489, -23663, -22128, -21912, -20399, -19447, -17696, -17449, -17414, -15436, -15384, -14563, -12699, -10991, -10874, -11083, -9443, -8736, -7792, -5905, -4324, -4348, -4523, -3573, -2179, -1527};