/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0031 256 samples */
 
const int16_t AKWF_vgame_0031_256_DATA [256] = 
{1226, 1962, 1421, 3469, 6565, 5923, 10711, 15457, 15520, 15516, 15322, 16364, 18191, 18685, 20932, 20698, 21235, 22678, 22547, 22682, 24265, 25366, 25217, 25199, 25414, 26160, 26087, 26410, 26605, 26532, 26876, 27009, 27139, 27884, 29017, 29275, 29252, 29057, 30609, 31567, 31535, 32720, 32806, 32644, 31828, 32077, 30343, 27510, 25079, 25262, 25311, 24979, 19506, 18400, 18647, 18573, 18701, 17865, 17202, 17133, 15303, 13398, 12721, 12790, 13191, 10636, 8115, 8323, 3510, 3237, 1668, -752, -212, -1407, -2913, -3071, -3113, -3034, -3419, -4079, -3838, -4683, -5900, -5652, -9155, -9616, -11102, -14089, -16840, -18916, -18560, -18438, -21716, -22749, -22664, -22685, -22560, -22587, -22573, -22627, -21950, -21572, -20854, -20802, -20814, -20811, -20749, -21097, -18777, -15659, -16004, -15892, -16156, -14890, -11410, -8124, -4344, -5116, -4358, -461, -520, -47, 4685, 5453, 5280, 5283, 5421, 6584, 6665, 7029, 7096, 7081, 7084, 7080, 7101, 7011, 6633, 6640, 6616, 6746, 5964, 5397, 4375, 2453, 2730, 2552, 196, 18, -397, -694, -393, -451, -440, -447, -841, -862, -1576, -1830, -1673, -4312, -5023, -4729, -8056, -11481, -11528, -11509, -11472, -12195, -12421, -12491, -12882, -12736, -13303, -14722, -14521, -15534, -16219, -16401, -16370, -16406, -16287, -15929, -15915, -16239, -16419, -16350, -16690, -16871, -16742, -16373, -16001, -15926, -15944, -15940, -15937, -15956, -15878, -15492, -15513, -15427, -15041, -15068, -14877, -14139, -13200, -13287, -13351, -13015, -11029, -11307, -9402, -7757, -7948, -6717, -6646, -6540, -5393, -4956, -4883, -4587, -4397, -4433, -4426, -4426, -4426, -4426, -4427, -4425, -4437, -4771, -5067, -5785, -5757, -5725, -5927, -6239, -6159, -6383, -6675, -6632, -6641, -6640, -6640, -6640, -6640, -6640, -6638, -6655, -6251, -6308, -5629, -1249, -792, -915, -867, -962};