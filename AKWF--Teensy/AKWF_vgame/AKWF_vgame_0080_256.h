/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0080 256 samples */
 
const int16_t AKWF_vgame_0080_256_DATA [256] = 
{2438, 8788, 12313, 13227, 12611, 11269, 9982, 9163, 8752, 8789, 8745, 8916, 9609, 10229, 10288, 10275, 10275, 9664, 9230, 9290, 9225, 9495, 9791, 9827, 10323, 9944, 9758, 9614, 9200, 9299, 9737, 9763, 9748, 9749, 9740, 9770, 9659, 9220, 9224, 9663, 9757, 9723, 9728, 9722, 9733, 9711, 9198, 9429, 9764, 9700, 9708, 9705, 9702, 9704, 9702, 9332, 9654, 9706, 9684, 9686, 9675, 9707, 9587, 9153, 9169, 9169, 9165, 9142, 9570, 9684, 9677, 9267, 9117, 9155, 9143, 9142, 9139, 9136, 9134, 9132, 9129, 9126, 9123, 9122, 9119, 9117, 9114, 9112, 9109, 9107, 9104, 9101, 9099, 9097, 9095, 9092, 9090, 9087, 9085, 9082, 9080, 9078, 9075, 9072, 9070, 9068, 9065, 9063, 9060, 9058, 9056, 9052, 9058, 9019, 9145, 9608, 9198, 8999, 9046, 9033, 9031, 9028, 9036, 8988, 9158, 9556, 9514, 9517, 9515, 9512, 9510, 9507, 9505, 9502, 9500, 9497, 9495, 9492, 9490, 9488, 9485, 9482, 9480, 9477, 9475, 9472, 9470, 9467, 9465, 9462, 9459, 9457, 9454, 9446, 9485, 9090, 8913, 8907, 9263, 9478, 9425, 9433, 9429, 9423, 9436, 9402, 8893, 9146, 9465, 9401, 9410, 9407, 9404, 9402, 9400, 9397, 9390, 9407, 9347, 8944, 8660, 7995, 7785, 8243, 9578, 11433, 13141, 13185, 10998, 6153, -1026, -9338, -17265, -24021, -29021, -31361, -32235, -31450, -30051, -28767, -27435, -26580, -26066, -26319, -27496, -28703, -29349, -29985, -29554, -28864, -27867, -27374, -27210, -27872, -28563, -29045, -29031, -29003, -28432, -27710, -27429, -27626, -27965, -28328, -28957, -28968, -28970, -28493, -27737, -27404, -27411, -27519, -28185, -28827, -28909, -28918, -28546, -27790, -27341, -27346, -27824, -28504, -29174, -29368, -28600, -27259, -25961, -25777, -26903, -29343, -31864, -32888, -31563, -27093, -19957, -7506};