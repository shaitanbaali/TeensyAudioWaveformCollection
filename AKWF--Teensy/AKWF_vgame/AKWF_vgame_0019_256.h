/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0019 256 samples */
 
const int16_t AKWF_vgame_0019_256_DATA [256] = 
{1666, 3132, 5375, 6501, 9947, 10061, 10103, 12233, 13333, 17124, 17775, 19602, 19639, 19824, 20794, 21783, 23147, 24256, 25943, 25683, 26329, 26750, 27375, 27753, 29376, 30238, 30094, 30821, 31117, 31437, 31494, 31235, 30986, 31035, 30998, 31120, 31508, 31254, 30683, 30616, 30361, 28904, 28481, 27974, 27142, 25127, 24952, 23756, 22942, 21270, 20500, 19071, 17619, 17480, 15756, 14919, 13709, 12721, 10941, 9668, 9502, 8086, 7323, 6179, 5033, 3287, 2176, 1987, 916, 542, -216, -801, -1254, -1732, -2645, -3162, -3453, -3494, -3527, -3245, -3029, -3048, -3138, -3469, -3684, -3962, -3930, -3905, -3520, -3496, -3462, -3736, -4035, -3168, -2538, -2631, -2302, -1929, -905, -610, 437, 412, 551, 1604, 2200, 2995, 4007, 5378, 5137, 5596, 6936, 7619, 8242, 9678, 11098, 10825, 11223, 11800, 12276, 12951, 14010, 14471, 14403, 14796, 14868, 14844, 14884, 14573, 14396, 14377, 14023, 13815, 13541, 13292, 12731, 12694, 12483, 11795, 11573, 11361, 10671, 9655, 9646, 8606, 8173, 7943, 7564, 6879, 6577, 6533, 6183, 6005, 5652, 5727, 5475, 4777, 4746, 4433, 4035, 3454, 3250, 2859, 2618, 2505, 2230, 1723, 1252, 696, -66, -491, -730, -1078, -2083, -2720, -3510, -4354, -4909, -6108, -7036, -6918, -7471, -7918, -8518, -8969, -9977, -10419, -10912, -11805, -12393, -13358, -13950, -14789, -15769, -16994, -17389, -18092, -19311, -19159, -19446, -20449, -21120, -21755, -23259, -25104, -24784, -25303, -26190, -26964, -27535, -28998, -29842, -29615, -30097, -30629, -30891, -31005, -31945, -32395, -32347, -32741, -32773, -32763, -32780, -32437, -32309, -32321, -32401, -31919, -31439, -30827, -29377, -29327, -28856, -27978, -27175, -26580, -25054, -23554, -23759, -22580, -21270, -20576, -19279, -17968, -17088, -16815, -15074, -14067, -12676, -11296, -8822, -6957, -6446, -4489, -3093, -1669};