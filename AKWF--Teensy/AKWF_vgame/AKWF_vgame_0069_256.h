/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0069 256 samples */
 
const int16_t AKWF_vgame_0069_256_DATA [256] = 
{3746, 14358, 24395, 30904, 32752, 30226, 26573, 25021, 26196, 28255, 29308, 28850, 27697, 27089, 27382, 27918, 28259, 28126, 27818, 27543, 27340, 27353, 27658, 28419, 28637, 28085, 26848, 25898, 26396, 28189, 30240, 30722, 28320, 22897, 14638, 4702, -4298, -8914, -8422, -4829, -1588, -1303, -3532, -5840, -6064, -4557, -3280, -3189, -4149, -4960, -5036, -4454, -3720, -3620, -4166, -4723, -4846, -4424, -3952, -3948, -4246, -4531, -4758, -4535, -4227, -4126, -4325, -4491, -4486, -4435, -4178, -4145, -4396, -4485, -4486, -4357, -4150, -4149, -4175, -4416, -4475, -4479, -4310, -4130, -4159, -4157, -4155, -4153, -4152, -4151, -4150, -4150, -4148, -4147, -4146, -4145, -4143, -4142, -4141, -4140, -4139, -4138, -4137, -4136, -4135, -4133, -4133, -4132, -4131, -4129, -4128, -4127, -4126, -4125, -4123, -4122, -4127, -4107, -4126, -4374, -4457, -4220, -4092, -4093, -4182, -4410, -4421, -4411, -4182, -4080, -4119, -4078, -4173, -4402, -4412, -4402, -4174, -4076, -4073, -4201, -4406, -4404, -4376, -4133, -4072, -4066, -4232, -4411, -4374, -4392, -4369, -4124, -4063, -4057, -4225, -4396, -4390, -4333, -4090, -4057, -4054, -4248, -4425, -4253, -4051, -4051, -4077, -4317, -4377, -4380, -4212, -4031, -4060, -4058, -4056, -4055, -4054, -4052, -4052, -4051, -4050, -4048, -4047, -4046, -4045, -4044, -4043, -4041, -4041, -4040, -4039, -4037, -4036, -4036, -4034, -4033, -4032, -4031, -4030, -4028, -4027, -4027, -4026, -4025, -4023, -4022, -4023, -4018, -3996, -4203, -4335, -4333, -4241, -4009, -3998, -4003, -4229, -4360, -4151, -3984, -3988, -4043, -4281, -4315, -4338, -3934, -3588, -3890, -4421, -4571, -4304, -4027, -3737, -3801, -4305, -4672, -4482, -3899, -3388, -3580, -4572, -5253, -4712, -3455, -2662, -3292, -5134, -6084, -5192, -2643, -978, -2056, -5305, -8379, -8195, -3657};