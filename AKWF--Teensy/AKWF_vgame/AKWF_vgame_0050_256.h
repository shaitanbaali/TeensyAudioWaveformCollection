/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0050 256 samples */
 
const int16_t AKWF_vgame_0050_256_DATA [256] = 
{338, 1339, 2171, 2890, 6046, 6170, 5966, 7130, 7879, 8501, 10035, 11393, 11188, 12709, 13565, 14368, 15351, 16648, 16973, 18452, 19267, 19918, 20507, 21220, 23838, 24589, 24331, 25248, 25737, 26557, 27568, 28808, 29305, 29810, 30104, 30786, 31526, 32115, 32375, 32314, 32367, 32097, 31869, 31557, 31373, 31011, 31056, 30764, 30553, 30195, 30213, 29535, 28752, 28859, 28829, 28442, 28388, 28126, 27476, 27027, 27085, 26683, 26648, 26276, 26244, 25600, 25227, 24516, 24453, 24081, 24054, 23354, 22721, 22721, 22700, 21923, 21841, 21174, 20810, 20110, 20069, 19687, 19656, 18956, 18632, 17764, 17449, 17485, 17461, 16752, 16365, 15766, 15288, 14793, 14825, 14103, 13728, 13084, 13042, 11606, 11291, 11426, 11090, 10466, 10334, 9577, 8836, 8769, 8422, 7844, 7673, 6980, 6867, 6183, 5756, 5227, 5018, 4335, 4319, 3086, 2096, 2231, 2028, 1778, 1479, 462, 17, -473, -594, -836, -1186, -2185, -2588, -3718, -3985, -3864, -4198, -4790, -5303, -5740, -6423, -6524, -6846, -7421, -7980, -8267, -8824, -10102, -10052, -9987, -10662, -10921, -11337, -12102, -12715, -12607, -13317, -13526, -14063, -14411, -14823, -15318, -15953, -16145, -16738, -17036, -17444, -18272, -18377, -18287, -18971, -19209, -19710, -20153, -20829, -20978, -21297, -21369, -21940, -22340, -23077, -23608, -23613, -23484, -24367, -25441, -25294, -25451, -25813, -25718, -26379, -26728, -27067, -27022, -27851, -28488, -28370, -28441, -28822, -28860, -29161, -29850, -30192, -30187, -30576, -30605, -30989, -31024, -31362, -31546, -31890, -31925, -32308, -32344, -32651, -32362, -32334, -32288, -31917, -31841, -30785, -30229, -29260, -29113, -27990, -27855, -26422, -25794, -23807, -23063, -23223, -22969, -21181, -20360, -19238, -18132, -17401, -17268, -15906, -14871, -13475, -13193, -10284, -9953, -10232, -9120, -7763, -7554, -6302, -4444, -4509, -3355, -2102, -1766, -830, -669};