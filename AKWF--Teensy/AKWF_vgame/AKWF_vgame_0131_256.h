/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0131 256 samples */
 
const int16_t AKWF_vgame_0131_256_DATA [256] = 
{13020, 20957, 19200, 19533, 19538, 19539, 19539, 19539, 19539, 19538, 19536, 19535, 19533, 19530, 19528, 19525, 19522, 19520, 19516, 19512, 19509, 19505, 19500, 19496, 19492, 19487, 19484, 19479, 19474, 19470, 19466, 19460, 19455, 19451, 19446, 19441, 19436, 19432, 19427, 19421, 19417, 19412, 19406, 19402, 19396, 19392, 19386, 19381, 19376, 19371, 19366, 19360, 19356, 19351, 19345, 19341, 19411, 19003, 20561, 31903, 32292, 32151, 32180, 32174, 32166, 32160, 32153, 32146, 32139, 32132, 32124, 32117, 32109, 32101, 32093, 32085, 32078, 32069, 32062, 32054, 32045, 32038, 32029, 32020, 32012, 32004, 31995, 31987, 31979, 31970, 31962, 31953, 31945, 31936, 31929, 31920, 31911, 31903, 31894, 31886, 31878, 31869, 31861, 31852, 31843, 31835, 31827, 31818, 31810, 31801, 31793, 31784, 31776, 31767, 31759, 31750, 31742, 31733, 31724, 31716, 31707, 31700, 31691, 31682, 31673, 31658, 30574, 36425, -6312, -37448, -31685, -32760, -32764, -32766, -32767, -32768, -32767, -32765, -32763, -32760, -32758, -32754, -32749, -32744, -32740, -32734, -32728, -32722, -32716, -32710, -32703, -32696, -32690, -32683, -32675, -32667, -32660, -32652, -32644, -32636, -32628, -32620, -32612, -32604, -32596, -32588, -32579, -32571, -32562, -32554, -32546, -32538, -32529, -32520, -32512, -32503, -32495, -32486, -32478, -32469, -32460, -32452, -32443, -32434, -32426, -32418, -32409, -32400, -32391, -32383, -32374, -32366, -32357, -32348, -32336, -32130, -33187, -25116, -18432, -19655, -19411, -19406, -19398, -19391, -19384, -19377, -19371, -19364, -19358, -19351, -19345, -19339, -19333, -19327, -19321, -19316, -19310, -19304, -19299, -19293, -19287, -19282, -19276, -19271, -19265, -19260, -19254, -19249, -19244, -19239, -19233, -19228, -19223, -19217, -19212, -19207, -19202, -19196, -19191, -19186, -19181, -19175, -19170, -19166, -19160, -19155, -19150, -19145, -19139, -19134, -19129, -19124, -19118, -19182, -18813, -20390};