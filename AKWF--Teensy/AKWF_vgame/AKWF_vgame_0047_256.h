/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0047 256 samples */
 
const int16_t AKWF_vgame_0047_256_DATA [256] = 
{2353, 2014, 2780, 5332, 5259, 5090, 5978, 7620, 7212, 8330, 10253, 9897, 12118, 12665, 13272, 15231, 16377, 17650, 17474, 17296, 19246, 20222, 20257, 24184, 25058, 24863, 24941, 24738, 26112, 27207, 28843, 29373, 29232, 29347, 30525, 30503, 31168, 32410, 32315, 32330, 32332, 32325, 31995, 31723, 31004, 31020, 31046, 30699, 30536, 30693, 29651, 28728, 28862, 28830, 28870, 28551, 28435, 27979, 27448, 27562, 27438, 26654, 26697, 26279, 25144, 24857, 24915, 24911, 24879, 24106, 24039, 23338, 23093, 23259, 22649, 21738, 21898, 21100, 20126, 20087, 20085, 20168, 19751, 18665, 17985, 17897, 17901, 17987, 16966, 16539, 16550, 15331, 14341, 14434, 14401, 14482, 13868, 13579, 12966, 12105, 12359, 11623, 10799, 10993, 10608, 9166, 8658, 8737, 8825, 8293, 7324, 7503, 6410, 6038, 6184, 5085, 4781, 4629, 3859, 2753, 2587, 2607, 2710, 1732, 1265, 1156, -6, 26, -117, -906, -747, -1787, -2992, -3513, -3490, -3474, -3567, -4748, -4727, -5367, -6221, -6074, -7230, -7474, -7434, -8071, -9112, -9701, -9604, -9541, -10592, -11004, -10861, -11594, -11780, -12049, -13175, -13001, -13915, -14519, -15173, -15323, -15250, -15422, -16599, -16483, -17350, -18871, -18771, -18789, -18776, -18833, -19929, -20337, -21001, -20979, -20905, -21312, -21933, -21731, -23260, -24150, -24002, -24042, -23977, -24285, -24883, -25382, -25850, -25728, -25922, -26673, -26623, -26747, -28174, -28450, -28391, -28381, -28470, -29237, -29283, -29646, -29741, -29636, -30128, -30653, -30560, -31384, -31910, -31893, -31901, -31866, -32048, -32340, -32417, -32772, -32764, -32773, -32061, -31894, -31729, -29871, -28719, -28869, -28803, -28989, -27323, -26710, -25266, -23785, -24250, -22836, -21636, -22017, -20823, -17337, -16450, -16607, -16768, -15662, -14248, -14480, -12190, -11699, -11835, -9525, -9236, -8422, -6237, -4522, -4289, -4578, -2784, -1522, -1915, -1197};