/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0094 256 samples */
 
const int16_t AKWF_vgame_0094_256_DATA [256] = 
{149, 389, 649, 1159, 1416, 1628, 1773, 1904, 1665, 1939, 2714, 3128, 3383, 3457, 3363, 3120, 3413, 3601, 3947, 4384, 4794, 5050, 4759, 4533, 4438, 4770, 4991, 5423, 5626, 5772, 5452, 5485, 5752, 5986, 6331, 6481, 6560, 6334, 6092, 6187, 9938, 16883, 23185, 27886, 30955, 32142, 32323, 32484, 32278, 32042, 31793, 31264, 30727, 29858, 28970, 28218, 28214, 27927, 27457, 26781, 26349, 25431, 24798, 24357, 24066, 23497, 23150, 22906, 22152, 21329, 20626, 20297, 19985, 19615, 19314, 19109, 18492, 17637, 17023, 16704, 16363, 16040, 15704, 15053, 14162, 13768, 13106, 12840, 12589, 12277, 11895, 11748, 10899, 10353, 9978, 9990, 9786, 9408, 9057, 8544, 7883, 7256, 6866, 6711, 6668, 6407, 6263, 5828, 5183, 4816, 4519, 4192, 4062, 3979, 3530, 2990, 3193, 2857, 2826, 2721, 2549, 2004, 1743, 1179, 742, 358, 311, 11, -286, -598, -1020, -1436, -1933, -2151, -2011, -1989, -2165, -2207, -2590, -3089, -3308, -3506, -3557, -3547, -3494, -3696, -4057, -4399, -4860, -4772, -4804, -4549, -4624, -4816, -5436, -5562, -5603, -5562, -5645, -5611, -5577, -5871, -6288, -6526, -6457, -6405, -6310, -8275, -13827, -20744, -26345, -29942, -31890, -32685, -32681, -32307, -32030, -31844, -31465, -30860, -30441, -29829, -28902, -28367, -27781, -27657, -27193, -26669, -25873, -25383, -24652, -24009, -23615, -23475, -22988, -22408, -21929, -21153, -20574, -20162, -19786, -19541, -19068, -18448, -17806, -17140, -16611, -16206, -16051, -15844, -15292, -14815, -14226, -13485, -13004, -12474, -12370, -12123, -11747, -11197, -10829, -10349, -9842, -9560, -9552, -9199, -8875, -8422, -7655, -7210, -6812, -6520, -6523, -6432, -6084, -5639, -5051, -4525, -4230, -4120, -4013, -3536, -3308, -2938, -2392, -2342, -2127, -2093, -2023, -2079, -1366, -994, -589, -7, 208, 38};