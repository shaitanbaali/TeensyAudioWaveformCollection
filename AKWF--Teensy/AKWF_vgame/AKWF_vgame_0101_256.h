/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0101 256 samples */
 
const int16_t AKWF_vgame_0101_256_DATA [256] = 
{7439, 11723, 10777, 10959, 10963, 10964, 10965, 10968, 10968, 10965, 10964, 10964, 10961, 10960, 10957, 10954, 11178, 9902, 15631, 32906, 31853, 32013, 32012, 32003, 31995, 31985, 31975, 31964, 31953, 31940, 31928, 31915, 31901, 31887, 31873, 31860, 31846, 31831, 31816, 31801, 31786, 31769, 31754, 31739, 31723, 31708, 31692, 31675, 31659, 31643, 31626, 31610, 31594, 31577, 31560, 31545, 31528, 31512, 31495, 31479, 31463, 31445, 31428, 31413, 31396, 31378, 31362, 31345, 31330, 31313, 31295, 31279, 31262, 31245, 31229, 31213, 31195, 31179, 31163, 31145, 31129, 31113, 31096, 31078, 31063, 31045, 31029, 31013, 30996, 30979, 30963, 30946, 30928, 30913, 30897, 30879, 30863, 30847, 30829, 30814, 30796, 30779, 30763, 30747, 30730, 30714, 30698, 30679, 30292, 32283, 19179, 7862, 9894, 9494, 9481, 9468, 9457, 9446, 9435, 9425, 9416, 9406, 9115, 10631, 3715, -12890, -11480, -11717, -11731, -11734, -11735, -11737, -11737, -11738, -11737, -11735, -11736, -11733, -11731, -11729, -11726, -11723, -11720, -11716, -11712, -11708, -11704, -11700, -11696, -11795, -11249, -13261, -31628, -33010, -32681, -32744, -32734, -32724, -32715, -32704, -32691, -32679, -32666, -32654, -32641, -32626, -32611, -32598, -32583, -32568, -32553, -32537, -32522, -32507, -32492, -32475, -32460, -32443, -32426, -32410, -32393, -32377, -32362, -32345, -32329, -32311, -32295, -32278, -32261, -32245, -32228, -32211, -32195, -32177, -32160, -32143, -32127, -32110, -32093, -32075, -32059, -32042, -32024, -32008, -31991, -31973, -31958, -31942, -31923, -31906, -31891, -31872, -31856, -31840, -31823, -31804, -31789, -31771, -31754, -31737, -31721, -31704, -31686, -31669, -31653, -31636, -31620, -31603, -31585, -31568, -31552, -31536, -31518, -31138, -33085, -19369, -8734, -10725, -10330, -10319, -10306, -10294, -10282, -10272, -10261, -10251, -10242, -10232, -10224, -10214, -10206, -10200, -10192, -10222, -10014, -10880};