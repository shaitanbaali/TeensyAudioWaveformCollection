/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0055 256 samples */
 
const int16_t AKWF_vgame_0055_256_DATA [256] = 
{752, 1718, 2362, 3370, 4415, 5385, 6465, 6934, 8132, 9327, 10103, 11026, 11711, 12761, 13775, 14948, 15469, 16413, 17484, 18105, 19058, 20093, 21120, 22166, 23120, 23752, 24816, 25581, 26372, 27081, 27971, 28391, 29168, 30185, 30684, 31265, 31900, 31892, 32268, 32339, 32358, 32142, 31767, 31442, 31491, 31183, 30974, 30656, 30459, 30163, 29916, 29684, 29379, 29180, 28863, 28686, 28112, 27964, 27810, 27229, 27059, 26730, 26574, 25871, 25784, 25523, 24982, 24836, 24498, 24103, 23633, 23510, 22963, 22715, 22447, 21871, 21443, 21307, 20802, 20248, 20098, 19933, 19418, 18751, 18263, 17961, 17793, 17271, 16734, 16603, 16015, 15605, 15157, 14586, 14454, 14084, 13501, 13272, 12710, 12215, 11662, 11365, 11137, 10585, 10085, 9545, 9167, 8779, 8240, 7739, 7190, 6982, 6663, 6112, 5604, 5094, 4585, 4044, 3929, 3762, 2872, 2224, 2133, 1654, 1131, 618, 112, -419, -842, -981, -1509, -2017, -2321, -2822, -3339, -3851, -4359, -4888, -5565, -5921, -6129, -6457, -7030, -7417, -7787, -8331, -8837, -9349, -9860, -10381, -10518, -10948, -11483, -11983, -12532, -12674, -12807, -13658, -14176, -14465, -14908, -15433, -15982, -16180, -16488, -17227, -17632, -17915, -17950, -18446, -18960, -19474, -19995, -20132, -20555, -21126, -21403, -21643, -22194, -22341, -22677, -23050, -23612, -24004, -24154, -24721, -24910, -25258, -25741, -25858, -26417, -26625, -27057, -27583, -27486, -27831, -28340, -28491, -28808, -29035, -29286, -29597, -30092, -30248, -30561, -30804, -31025, -31173, -31461, -31729, -31942, -32288, -32330, -32663, -32785, -32767, -32750, -32287, -31892, -31519, -30965, -30503, -29753, -28988, -28181, -27501, -26521, -25645, -24958, -23850, -23257, -22793, -21413, -20053, -19527, -18646, -17588, -16526, -15828, -15010, -13559, -12840, -11831, -11298, -10587, -9204, -8207, -7173, -6533, -5569, -4531, -3510, -2476, -1804, -852, -29};