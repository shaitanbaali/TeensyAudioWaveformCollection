/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0042 256 samples */
 
const int16_t AKWF_vgame_0042_256_DATA [256] = 
{3115, 8560, 8933, 8820, 8854, 8871, 8788, 9089, 12608, 12906, 12822, 12912, 12544, 14455, 18127, 21171, 21262, 21246, 21253, 21301, 21034, 22216, 25851, 25648, 25677, 25744, 25451, 27668, 30316, 32001, 31847, 31883, 31883, 31899, 31819, 32240, 32819, 32756, 32764, 32768, 32748, 31753, 30916, 30498, 30572, 30555, 30556, 30534, 30653, 29714, 29130, 29248, 29219, 29252, 29111, 28024, 26903, 26495, 26584, 26567, 26566, 26561, 26605, 25102, 24724, 24813, 24781, 24863, 24490, 23355, 21873, 21654, 21708, 21697, 21687, 21741, 21533, 19977, 19908, 19931, 19893, 20047, 19207, 17707, 16380, 16386, 16386, 16383, 16360, 16484, 15913, 14514, 14631, 14609, 14577, 14726, 13301, 11437, 10056, 10221, 10183, 10184, 10152, 10321, 9348, 8270, 8444, 8409, 8411, 8393, 6708, 4841, 3834, 4021, 3983, 3985, 3957, 4103, 2773, 2097, 2239, 2171, 2387, 1097, -104, -1344, -1861, -1750, -1771, -1775, -1768, -1757, -3664, -4064, -3967, -4013, -3858, -5530, -6420, -7820, -8003, -7962, -7970, -7986, -7903, -8236, -10174, -10192, -10184, -10175, -10230, -11645, -12468, -14242, -14152, -14167, -14169, -14201, -14030, -14823, -16515, -16356, -16398, -16317, -16679, -18039, -18862, -20055, -19895, -19927, -19925, -19957, -19786, -20822, -21839, -21664, -21725, -21577, -22316, -23492, -24254, -24896, -24799, -24686, -25333, -26684, -26541, -26568, -26567, -26567, -26592, -26463, -27308, -27960, -28949, -29284, -29213, -29226, -29229, -29217, -29248, -30409, -30592, -30547, -30569, -30495, -31542, -32024, -32688, -32781, -32764, -32767, -32767, -32767, -32767, -32767, -32767, -32737, -32905, -31836, -30561, -29834, -27298, -27487, -27453, -27454, -27393, -27725, -26082, -23183, -23532, -23389, -23810, -20688, -19023, -17312, -14738, -15126, -15054, -15056, -14973, -15407, -12572, -10285, -10700, -10598, -10775, -7027, -6272, -3595, -1942, -2273, -2212, -2223, -2167, -2417};