/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0014 256 samples */
 
const int16_t AKWF_vgame_0014_256_DATA [256] = 
{4740, 5880, 5631, 5726, 5483, 6571, 9954, 13568, 14079, 14010, 13757, 15014, 18322, 20743, 21022, 21004, 20770, 21936, 24252, 23867, 24616, 25902, 25730, 25838, 27766, 28001, 27983, 30843, 31582, 31428, 31456, 31465, 31429, 31045, 31015, 31023, 31019, 31033, 30971, 30609, 30538, 28626, 28328, 28472, 28165, 26622, 26773, 26127, 23091, 23295, 22577, 19577, 19739, 19362, 15244, 12414, 12729, 12634, 12827, 11913, 9715, 8026, 6314, 6603, 6537, 6638, 3268, 2623, 773, -160, 36, 3, -1143, -1347, -1314, -2857, -3106, -3057, -3452, -3517, -3447, -3208, -3924, -3934, -3929, -3931, -3924, -3958, -3800, -3466, -3503, -3484, -3534, -3887, -4046, -3181, -898, -348, -464, -436, -419, -519, 475, 982, 725, 2441, 3220, 2901, 4670, 7641, 7920, 7845, 7875, 7803, 9517, 10417, 12190, 12244, 12230, 12203, 13329, 13518, 13912, 14933, 14836, 14854, 14853, 14840, 14920, 14046, 13459, 13561, 13538, 13552, 13491, 12828, 11748, 11278, 11379, 11326, 11490, 10363, 9482, 8137, 7801, 7854, 7958, 7032, 6470, 6529, 6126, 6105, 6147, 5822, 5618, 5819, 4539, 3366, 3521, 3494, 3483, 3518, 2959, 1969, 1219, 1332, 1294, 1381, -81, -429, -1283, -1837, -1736, -1694, -3544, -4028, -3875, -5767, -6201, -6081, -7979, -8419, -8100, -9301, -11886, -11778, -11789, -11835, -11652, -12802, -14817, -16698, -16574, -16632, -16464, -17635, -18313, -19298, -20707, -20539, -20333, -22160, -23383, -22950, -24556, -25533, -25129, -27097, -28164, -27820, -29135, -30899, -31052, -31009, -31033, -30970, -31269, -32011, -32699, -32782, -32764, -32767, -32758, -32809, -32560, -31859, -31882, -31992, -31376, -30439, -30804, -29489, -27720, -28178, -26999, -25556, -25970, -24792, -21047, -19923, -20150, -20044, -20328, -18480, -16914, -13926, -12928, -13070, -13449, -10617, -8489, -8489, -4172, -3831, -4068, -3396};