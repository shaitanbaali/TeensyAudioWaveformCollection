/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0091 256 samples */
 
const int16_t AKWF_vgame_0091_256_DATA [256] = 
{4772, 11643, 13462, 11578, 8521, 6790, 8018, 10464, 11349, 9984, 8549, 8559, 9643, 10123, 9889, 9107, 8796, 9268, 9939, 9689, 9182, 9030, 9131, 9595, 9713, 9426, 9213, 9025, 9446, 9749, 9479, 9284, 9019, 9261, 9455, 9727, 9464, 9338, 9367, 9358, 9356, 9354, 9351, 9349, 9346, 9344, 9342, 9339, 9337, 9335, 9332, 9329, 9328, 9328, 9306, 9372, 9538, 9296, 9315, 9310, 9308, 9305, 9302, 9300, 9297, 9295, 9293, 9290, 9287, 9285, 9282, 9282, 9274, 9279, 9567, 9604, 9606, 9538, 9251, 9258, 9545, 9595, 9575, 9570, 9606, 9358, 9255, 9575, 9566, 9559, 9559, 9556, 9553, 9551, 9548, 9546, 9543, 9540, 9537, 9532, 9558, 9265, 9258, 9550, 9513, 9549, 9371, 9141, 9258, 9519, 9524, 9445, 9169, 9158, 9220, 9531, 9280, 9136, 9169, 9159, 9157, 9154, 9152, 9149, 9147, 9144, 9141, 9139, 9137, 9134, 9132, 9129, 9127, 9124, 9122, 9120, 9117, 9115, 9112, 9110, 9107, 9105, 9103, 9100, 9097, 9095, 9092, 9097, 9057, 9226, 9431, 9145, 8913, 8919, 9152, 9393, 9416, 9080, 8690, 8925, 9352, 9420, 9204, 8740, 8783, 9253, 9411, 9296, 8836, 8691, 9083, 9572, 9482, 8856, 8309, 8600, 9499, 9941, 9165, 8263, 8184, 9685, 10978, 9622, 6749, 6456, 10377, 14352, 12415, 2409, -11325, -23122, -29655, -31068, -29504, -26664, -25017, -26104, -28389, -29385, -28021, -26375, -26528, -27780, -28635, -28042, -26882, -26660, -27552, -28178, -28069, -27137, -26803, -27172, -27830, -28183, -27473, -26937, -27009, -27482, -27962, -27913, -27064, -26852, -27345, -27707, -27797, -27295, -26756, -27155, -27600, -27764, -27486, -26763, -26967, -27433, -27902, -27698, -26884, -26591, -27193, -28119, -28000, -26789, -26153, -26867, -28756, -28745, -26085, -23940, -25681, -30525, -33044, -26879, -16906, -6587};