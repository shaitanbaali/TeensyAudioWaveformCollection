/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0033 256 samples */
 
const int16_t AKWF_vgame_0033_256_DATA [256] = 
{1996, 2830, 2486, 6022, 7785, 10522, 10779, 13891, 14194, 14326, 17456, 17774, 19113, 19851, 21285, 21192, 21498, 22590, 22680, 23345, 23926, 24909, 24683, 25273, 26196, 26218, 26553, 26798, 27046, 27003, 27027, 26943, 27393, 27911, 28512, 28860, 28668, 30105, 30524, 31576, 32458, 32668, 32791, 32722, 31949, 31977, 29585, 28316, 26170, 26211, 25725, 23074, 22876, 20302, 19377, 18054, 18259, 17212, 16798, 16584, 15650, 14518, 13121, 13325, 10540, 10384, 8659, 5746, 3298, 1569, 1543, -868, -760, -1808, -2781, -2986, -3094, -3211, -3578, -3495, -4126, -4637, -6976, -6886, -8519, -10164, -11438, -14275, -14809, -17891, -17400, -20273, -21870, -22293, -23128, -23002, -23023, -23039, -22653, -22622, -21966, -21711, -21211, -20743, -20826, -20811, -20822, -20041, -19986, -18575, -18238, -17376, -14133, -13811, -10323, -10088, -6171, -5922, -4267, -1686, -852, 2333, 2468, 4458, 4323, 5170, 5791, 6115, 6682, 6755, 7112, 7077, 7084, 7084, 7084, 7084, 7082, 7089, 7071, 6288, 6220, 5118, 4959, 3376, 2679, 1487, 283, 426, -791, -910, -873, -909, -568, -398, -529, -878, -957, -1731, -1787, -3751, -3844, -5072, -7130, -7838, -10743, -10746, -11960, -11890, -12423, -12912, -12842, -12757, -13781, -14201, -14365, -15534, -15427, -16023, -16450, -16368, -16384, -16383, -16384, -16384, -16391, -16352, -16660, -16891, -16589, -16348, -16391, -16382, -16396, -16022, -15921, -15941, -15957, -15870, -15499, -15467, -15077, -15051, -14653, -14704, -13857, -12725, -12850, -12908, -12570, -10239, -10214, -7521, -6476, -6662, -6714, -6304, -5255, -5291, -4559, -4398, -4434, -4427, -4426, -4426, -4426, -4426, -4426, -4434, -4393, -4721, -4822, -5351, -6260, -6186, -6198, -6198, -6204, -6173, -6312, -6664, -6636, -6640, -6640, -6640, -6640, -6640, -6640, -6631, -6680, -6461, -5737, -5763, -1952, -674, -911, -995};