/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0007 256 samples */
 
const int16_t AKWF_vgame_0007_256_DATA [256] = 
{1, 2, 3, 5, 6, 7, 9, 10, 11, 13, 14, 15, 16, 17, 18, 19, 20, 20, 21, 23, 23, 24, 24, 25, 25, 26, 28, 27, 28, 28, 29, 30, 29, 29, 30, 31, 30, 31, 32, 33, 33, 33, 34, 33, 34, 33, 34, 35, 34, 35, 35, 35, 35, 35, 35, 35, 34, 36, 35, 34, 35, 35, 35, 35, 34, 35, 34, 33, 34, 33, 33, 33, 52, 191, -592, 10592, 27769, 30918, 32510, 32472, 32423, 20394, 2562, -1265, -3590, -4386, -4248, -4105, -4052, -3990, -3909, -3827, -3750, -3675, -3600, -3525, -3453, -3383, -3313, -3244, -3177, -3111, -3045, -2982, -2919, -2857, -2797, -2738, -2679, -2622, -2565, -2510, -2457, -2403, -2351, -2300, -2250, -2200, -2151, -2104, -2058, -2012, -1967, -1923, -1880, -1838, -1796, -1754, -1715, -1676, -1638, -1599, -1562, -1526, -1490, -1455, -1422, -1387, -1355, -1322, -1291, -1260, -1229, -1199, -1171, -1143, -1114, -1087, -1060, -1034, -1008, -983, -958, -933, -910, -887, -864, -842, -820, -798, -778, -758, -738, -718, -699, -681, -662, -644, -626, -610, -593, -576, -560, -545, -529, -514, -499, -485, -471, -458, -444, -431, -418, -406, -393, -382, -370, -359, -348, -336, -326, -316, -306, -296, -286, -278, -268, -259, -251, -242, -234, -226, -218, -210, -202, -194, -187, -180, -173, -167, -162, -156, -149, -144, -138, -132, -127, -122, -116, -111, -106, -102, -96, -92, -88, -83, -80, -75, -71, -68, -64, -60, -56, -53, -50, -47, -44, -41, -38, -35, -33, -30, -27, -25, -22, -20, -17, -15, -13, -11, -8, -7, -6, -4, -2, -1};