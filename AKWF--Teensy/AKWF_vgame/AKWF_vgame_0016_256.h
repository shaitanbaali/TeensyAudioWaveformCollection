/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0016 256 samples */
 
const int16_t AKWF_vgame_0016_256_DATA [256] = 
{2692, 3691, 3329, 5925, 6480, 8812, 10415, 13204, 13571, 13694, 16833, 16932, 18043, 20320, 22293, 22293, 22196, 23645, 24014, 25025, 26369, 27161, 27045, 27151, 29088, 29245, 29712, 31169, 31504, 31437, 31483, 31138, 31001, 31005, 31350, 31479, 31458, 31444, 30649, 30670, 30066, 27590, 27503, 27508, 27634, 26275, 25788, 25292, 22723, 22518, 19782, 19788, 18607, 17513, 16476, 14177, 14576, 12343, 11845, 10034, 9176, 8021, 6857, 6889, 4112, 4039, 2986, 1674, 517, -111, 66, -686, -796, -1961, -2759, -3370, -3522, -3478, -3099, -3051, -3046, -3120, -3497, -3500, -3469, -3800, -3991, -3666, -3462, -3503, -3493, -3500, -3860, -4012, -3561, -1847, -1227, -1323, -1364, -671, -501, 454, 2383, 2671, 2600, 2608, 4145, 4303, 4951, 8161, 8339, 8312, 8181, 9494, 10001, 11057, 12808, 12640, 12667, 12652, 13781, 13977, 14222, 14906, 14842, 14847, 14886, 14571, 14419, 14207, 13953, 13965, 13183, 13115, 12921, 12720, 11776, 11261, 11431, 10717, 10530, 9722, 9078, 8063, 7820, 7866, 7084, 7021, 6697, 6002, 5698, 5668, 5708, 5360, 5271, 4812, 4053, 3458, 3504, 3498, 3109, 3083, 2850, 1708, 1253, 1304, 1404, 424, -4, -575, -2300, -2685, -2609, -2577, -4466, -4812, -5144, -7680, -7909, -7863, -7795, -8446, -8626, -9704, -11907, -11773, -11806, -11720, -13576, -13978, -14433, -15761, -15977, -17520, -17374, -18278, -18749, -19555, -20664, -20513, -22471, -22665, -23351, -24437, -25860, -26819, -26527, -27571, -27916, -28913, -29830, -30406, -30619, -30567, -31338, -31436, -31719, -32425, -32730, -32774, -32766, -32761, -32788, -32586, -32081, -31421, -31462, -31489, -30357, -30167, -29794, -27526, -26535, -26651, -26782, -25542, -24985, -23584, -20478, -20028, -20109, -20191, -17985, -17484, -16922, -11486, -10785, -10908, -11156, -9045, -8003, -5915, -295, -463, -422, -551};