/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0024 256 samples */
 
const int16_t AKWF_vgame_0024_256_DATA [256] = 
{1457, 2597, 4186, 6359, 7105, 8759, 10100, 12154, 12841, 14644, 16642, 17152, 18336, 19800, 20602, 21404, 22864, 23726, 24152, 24913, 25788, 26408, 26836, 27822, 28594, 29334, 30046, 30680, 31321, 31479, 31446, 31479, 31134, 30997, 31030, 31004, 31091, 31177, 30980, 30680, 30417, 29001, 28380, 27886, 27165, 26606, 25651, 24480, 22784, 22019, 20537, 19212, 18627, 17500, 16077, 15084, 14138, 12611, 11176, 10641, 9343, 8151, 7511, 6523, 4837, 3662, 3061, 1608, 844, 354, -42, -553, -1190, -1609, -2593, -3118, -3380, -3514, -3505, -3150, -3039, -3058, -3081, -3434, -3617, -3950, -3927, -3927, -3607, -3817, -3489, -3541, -3827, -3536, -3263, -2619, -2542, -1801, -896, -430, -284, 371, 1040, 1467, 2254, 3053, 3460, 4229, 5198, 5928, 6644, 7695, 8577, 9021, 9883, 10689, 11249, 11728, 12429, 13002, 13494, 14029, 14421, 14782, 14870, 14846, 14872, 14777, 14402, 14435, 14338, 13963, 13616, 13463, 12959, 12593, 12270, 12124, 11496, 10926, 10785, 10276, 9649, 8986, 8540, 7862, 7410, 7233, 6663, 6166, 6131, 5815, 5644, 5703, 5403, 5021, 4799, 4512, 3931, 3525, 3160, 3067, 2797, 2592, 2227, 1672, 960, 847, 289, -618, -928, -1355, -1948, -3040, -3546, -4269, -5473, -5799, -6234, -6945, -7875, -7967, -8721, -9586, -9944, -10756, -11351, -12011, -12434, -13479, -14365, -14904, -15934, -16986, -17537, -17742, -18570, -19230, -19567, -20445, -21519, -22269, -23034, -24274, -24973, -25352, -26481, -27052, -27909, -28623, -29659, -29758, -30247, -30973, -31015, -31115, -31631, -32180, -32327, -32498, -32793, -32758, -32784, -32680, -32311, -32386, -31973, -31437, -31276, -30791, -29727, -28861, -28357, -27250, -26632, -26117, -25104, -23970, -23123, -22184, -20953, -20198, -19354, -18346, -16762, -16042, -14919, -13061, -11811, -10413, -8804, -6165, -5459, -3996, -1825, -755};