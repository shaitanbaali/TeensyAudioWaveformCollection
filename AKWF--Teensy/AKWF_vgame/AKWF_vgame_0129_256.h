/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0129 256 samples */
 
const int16_t AKWF_vgame_0129_256_DATA [256] = 
{6609, 7051, 6956, 6975, 6976, 6976, 6976, 6976, 6976, 6974, 6974, 6974, 6973, 6972, 6971, 6970, 6968, 6967, 6966, 6965, 6963, 6962, 6960, 6959, 6957, 6956, 6954, 6946, 7172, 5991, 14741, 20462, 19347, 19551, 19544, 19542, 19538, 19535, 19531, 19528, 19524, 19519, 19515, 19511, 19507, 19502, 19498, 19493, 19488, 19484, 19480, 19475, 19470, 19465, 19460, 19455, 19451, 19445, 19441, 19489, 19229, 20114, 31238, 32252, 31961, 32013, 32007, 32002, 31994, 31987, 31979, 31972, 31965, 31958, 31951, 31943, 31936, 31928, 31920, 31912, 31905, 31896, 31888, 31880, 31872, 31864, 31856, 31848, 31839, 31831, 31823, 31814, 31806, 31798, 31789, 31781, 31772, 31764, 31756, 31747, 31739, 31731, 31722, 31713, 31704, 31697, 31688, 31680, 31505, 32425, 22767, 18246, 19210, 19020, 19013, 19006, 18999, 18992, 18985, 18979, 18972, 18966, 18960, 18954, 18948, 18926, 18518, 20947, -8929, -21091, -18399, -18904, -18903, -19118, -18011, -24667, -32284, -31340, -31512, -31512, -31509, -31505, -31502, -31497, -31493, -31487, -31482, -31476, -31471, -31465, -31458, -31451, -31445, -31438, -31431, -31424, -31417, -31409, -31402, -31395, -31387, -31378, -31371, -31362, -31355, -31348, -31340, -31331, -31324, -31316, -31307, -31300, -31292, -31283, -31274, -31266, -31258, -31250, -31242, -31233, -31225, -31217, -31209, -31201, -31192, -31184, -31175, -31168, -31159, -31151, -31132, -31043, -31533, -21319, -17873, -18637, -18489, -18481, -18474, -18468, -18461, -18454, -18449, -18442, -18436, -18431, -18425, -18419, -18413, -18407, -18402, -18396, -18391, -18385, -18380, -18374, -18369, -18364, -18359, -18353, -18348, -18344, -18337, -18180, -19040, -9049, -4981, -5863, -5700, -5696, -5691, -5688, -5686, -5682, -5679, -5676, -5673, -5671, -5668, -5666, -5663, -5661, -5658, -5657, -5654, -5652, -5650, -5648, -5646, -5645, -5643, -5641, -5639, -5649, -5586, -5856};