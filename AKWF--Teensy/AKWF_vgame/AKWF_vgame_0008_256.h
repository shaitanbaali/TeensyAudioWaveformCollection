/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0008 256 samples */
 
const int16_t AKWF_vgame_0008_256_DATA [256] = 
{1, 4, 7, 10, 13, 16, 18, 21, 23, 25, 28, 30, 32, 34, 36, 38, 40, 42, 43, 45, 47, 48, 49, 51, 52, 53, 54, 55, 56, 57, 58, 60, 60, 61, 62, 62, 63, 64, 65, 66, 66, 66, 66, 67, 68, 68, 69, 70, 70, 70, 71, 70, 71, 71, 71, 72, 71, 72, 71, 71, 72, 71, 71, 70, 69, 70, 69, 67, 68, 85, 221, -570, 10651, 27814, 30916, 32536, 32626, 31812, 31002, 30293, 29599, 28860, 28037, 28107, 16149, -1542, -5259, -7497, -8202, -7983, -7767, -7640, -7503, -7350, -7198, -7051, -6907, -6766, -6626, -6488, -6354, -6222, -6092, -5964, -5839, -5715, -5595, -5476, -5359, -5245, -5132, -5021, -4913, -4807, -4702, -4601, -4500, -4401, -4304, -4208, -4116, -4025, -3935, -3846, -3760, -3676, -3593, -3511, -3431, -3353, -3275, -3200, -3126, -3054, -2982, -2913, -2844, -2776, -2711, -2646, -2583, -2522, -2461, -2401, -2343, -2286, -2229, -2175, -2121, -2068, -2017, -1967, -1917, -1869, -1822, -1775, -1730, -1685, -1643, -1600, -1557, -1517, -1477, -1438, -1400, -1362, -1325, -1290, -1255, -1220, -1186, -1154, -1122, -1090, -1060, -1030, -1000, -972, -944, -916, -889, -863, -838, -813, -789, -765, -741, -718, -696, -675, -654, -633, -613, -593, -574, -555, -537, -519, -501, -485, -468, -450, -435, -420, -405, -390, -376, -362, -348, -336, -322, -310, -299, -287, -276, -264, -253, -243, -233, -223, -212, -203, -194, -185, -176, -167, -159, -151, -144, -136, -129, -121, -114, -108, -100, -95, -89, -82, -77, -71, -66, -60, -54, -50, -45, -40, -37, -32, -27, -23, -19, -15, -11, -7, -4, -1};