/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0116 256 samples */
 
const int16_t AKWF_vgame_0116_256_DATA [256] = 
{179, 453, 1036, 1438, 2085, 2458, 3136, 3494, 3862, 4651, 5088, 5643, 6157, 6636, 7237, 7538, 8044, 8833, 9131, 9957, 10503, 10799, 11304, 11599, 12289, 12850, 13526, 14028, 14286, 14977, 15325, 15700, 16489, 17094, 17494, 17963, 18471, 19055, 19349, 19871, 20632, 20963, 21637, 21999, 22632, 23081, 23382, 24082, 24670, 25082, 25722, 26039, 26438, 27393, 27923, 28215, 28674, 29238, 29764, 30001, 30878, 31439, 30873, 35797, 7570, -13870, -9393, -9528, -9005, -8559, -8057, -7492, -7054, -6421, -6112, -5659, -4856, -4508, -3856, -3462, -2831, -2010, -2053, -1430, -748, -381, 250, 794, 1499, 1658, 2044, 2814, 3296, 3785, 4506, 4878, 5413, 5740, 6211, 7011, 7350, 8001, 8402, 9005, 9500, 9797, 10438, 11092, 11473, 12137, 12492, 13161, 13530, 13873, 14704, 15463, 15657, 16176, 16648, 17267, 17522, 18195, 19017, 19120, 19833, 20216, 20121, 24314, 6133, -24654, -20318, -20633, -19966, -19594, -18919, -18560, -18191, -17402, -16966, -16408, -15886, -15429, -14478, -14420, -14007, -13230, -12749, -11994, -11786, -10921, -10750, -10401, -9722, -9107, -8721, -7944, -7586, -7311, -6474, -6108, -5479, -5040, -4482, -3938, -3644, -3051, -2327, -1983, -1305, -946, -274, 133, 459, 1211, 1731, 2185, 3114, 3302, 3836, 4181, 4619, 5412, 5845, 6678, 6806, 7422, 7941, 8237, 8817, 9625, 9254, 13941, -14288, -35615, -31146, -31567, -30797, -30300, -29800, -29234, -28791, -28145, -27830, -27370, -26570, -26215, -25558, -25143, -24543, -24074, -23261, -22952, -22444, -22037, -21366, -21013, -20286, -19764, -19603, -18799, -18326, -17803, -17245, -16794, -16159, -15848, -15371, -14565, -14220, -13564, -13157, -12548, -12048, -11743, -11097, -10429, -10093, -9139, -8831, -8386, -7963, -7610, -6817, -6367, -5547, -5286, -4825, -4201, -3895, -3413, -2588, -2097, -1627, -1215, -605, -141};