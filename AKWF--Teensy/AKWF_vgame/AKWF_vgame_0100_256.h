/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0100 256 samples */
 
const int16_t AKWF_vgame_0100_256_DATA [256] = 
{7877, 11880, 10983, 11155, 11157, 11158, 11159, 11159, 11158, 11156, 11155, 11153, 11150, 11147, 11144, 11142, 11138, 11134, 11130, 11126, 11122, 11117, 11112, 11107, 11102, 11097, 11093, 11087, 11082, 11078, 11071, 11066, 11061, 11055, 11049, 11043, 11038, 11032, 11025, 11021, 11015, 11009, 11004, 10998, 10992, 10985, 10979, 10974, 10968, 10962, 10956, 10950, 10945, 10939, 10934, 10928, 10923, 10916, 10910, 10903, 10898, 10893, 10886, 10880, 10874, 10869, 10864, 10857, 10851, 10845, 10839, 10833, 10827, 10821, 10816, 10809, 10804, 10799, 10792, 10786, 10781, 10775, 10768, 10763, 10757, 10750, 10744, 10739, 10733, 10727, 10721, 10715, 10709, 10705, 10699, 10693, 10687, 10680, 10674, 10695, 10730, 10174, 27367, 32849, 31789, 31974, 31965, 31956, 31944, 31932, 31921, 31909, 31895, 31881, 31867, 31854, 31840, 31824, 31784, 31544, 32976, -2203, -12922, -10521, -10965, -10971, -10979, -10985, -10990, -10994, -10997, -10997, -11245, -9894, -16260, -33131, -32170, -32334, -32335, -32328, -32321, -32314, -32304, -32295, -32285, -32256, -32052, -33155, -17033, -9585, -11169, -10856, -10847, -10836, -10824, -10816, -10808, -10801, -10792, -10784, -10777, -10767, -10761, -10753, -10746, -10739, -10732, -10726, -10719, -10712, -10706, -10699, -10692, -10686, -10680, -10674, -10667, -10662, -10656, -10650, -10643, -10637, -10631, -10626, -10620, -10614, -10608, -10601, -10596, -10591, -10584, -10580, -10574, -10569, -10562, -10557, -10551, -10545, -10539, -10533, -10527, -10522, -10517, -10511, -10506, -10500, -10495, -10489, -10483, -10477, -10472, -10466, -10460, -10454, -10450, -10444, -10438, -10432, -10426, -10421, -10415, -10409, -10404, -10398, -10392, -10387, -10382, -10377, -10371, -10366, -10359, -10355, -10349, -10344, -10338, -10333, -10327, -10321, -10315, -10310, -10305, -10299, -10295, -10288, -10283, -10277, -10272, -10266, -10261, -10255, -10249, -10244, -10238, -10272, -10062, -10954};