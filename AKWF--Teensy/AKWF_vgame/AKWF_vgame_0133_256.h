/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0133 256 samples */
 
const int16_t AKWF_vgame_0133_256_DATA [256] = 
{4464, 6560, 6083, 6173, 6174, 6176, 6176, 6176, 6176, 6175, 6174, 6174, 6173, 6173, 6172, 6171, 6170, 6169, 6168, 6167, 6166, 6164, 6163, 6162, 6161, 6159, 6158, 6156, 6155, 6153, 6152, 6150, 6149, 6149, 6298, 5461, 9238, 18798, 18015, 18144, 18146, 18143, 18141, 18137, 18134, 18131, 18127, 18124, 18119, 18116, 18112, 18108, 18104, 18099, 18095, 18091, 18087, 18082, 18078, 18073, 18069, 18064, 18059, 18055, 18050, 18046, 18041, 18036, 18032, 18026, 18237, 17067, 24367, 30970, 29794, 30010, 30004, 29998, 29992, 29986, 29979, 29972, 29965, 29959, 29952, 29944, 29937, 29931, 29923, 29916, 29908, 29901, 29893, 29885, 29878, 29870, 29839, 29314, 32457, -5353, -21032, -17570, -18219, -18227, -18229, -18232, -18234, -18234, -18235, -18235, -18234, -18233, -18232, -18230, -18228, -18226, -18224, -18221, -18218, -18214, -18175, -18310, -17927, -7415, -5866, -6260, -6180, -6176, -6174, -6171, -6169, -6166, -6164, -6161, -6159, -6157, -6154, -6152, -6150, -6148, -6146, -6144, -6142, -6140, -6139, -6137, -6134, -6133, -6131, -6129, -6128, -6126, -6124, -6122, -6120, -6118, -6118, -6006, -6633, 3266, 6494, 5770, 5902, 5903, 5903, 5903, 5903, 5903, 5903, 5903, 5902, 5901, 5233, 8779, -11107, -32979, -29479, -30131, -30131, -29943, -30955, -22027, -17311, -18281, -18100, -18096, -18091, -18088, -18084, -18080, -18075, -18071, -18066, -18062, -18057, -18053, -18049, -18044, -18040, -18035, -18031, -18026, -18021, -18017, -18012, -18007, -18003, -17998, -17993, -17988, -17984, -17979, -17974, -17969, -17964, -17960, -17959, -17753, -18828, -13211, -5002, -6133, -5908, -5911, -5908, -5905, -5901, -5898, -5896, -5893, -5890, -5887, -5885, -5882, -5880, -5878, -5876, -5874, -5871, -5869, -5867, -5865, -5864, -5862, -5859, -5858, -5856, -5854, -5852, -5850, -5849, -5847, -5845, -5865, -5746, -6258};