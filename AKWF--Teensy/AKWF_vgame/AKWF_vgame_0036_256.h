/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0036 256 samples */
 
const int16_t AKWF_vgame_0036_256_DATA [256] = 
{1121, 3819, 3882, 6227, 7434, 8605, 11157, 12339, 13941, 16195, 17060, 17585, 19075, 19609, 20643, 21732, 21796, 22570, 22915, 23169, 23852, 24808, 25325, 25160, 25579, 26259, 26564, 26534, 26820, 27050, 26986, 27100, 27398, 27845, 28449, 29455, 29637, 30018, 31471, 31601, 32086, 32753, 32808, 32521, 31969, 31099, 29519, 28520, 27119, 23757, 24042, 23083, 21442, 19905, 19512, 18713, 18172, 17749, 16809, 15930, 15511, 14700, 13026, 12508, 11443, 9257, 7966, 5442, 3486, 2662, 902, -479, -1189, -2186, -2665, -2927, -3137, -3068, -3357, -3757, -3954, -4712, -6134, -8859, -8641, -10093, -12093, -13239, -15307, -17371, -18812, -20160, -21828, -22609, -23101, -23035, -22892, -22555, -22574, -22652, -22167, -21640, -21415, -21012, -20812, -20664, -20334, -20383, -20044, -19851, -16716, -15854, -15632, -13367, -10859, -9688, -7639, -4709, -3519, -1843, 357, 1261, 2597, 4187, 5330, 5303, 6035, 6312, 6638, 7015, 7100, 7080, 7084, 7084, 7084, 7077, 7114, 6922, 6628, 6559, 6147, 5473, 4973, 4024, 1460, 265, 451, -338, -580, -897, -908, -581, -419, -424, -559, -948, -1270, -1441, -3311, -3505, -4014, -5614, -7299, -8071, -9561, -10918, -11367, -12054, -12340, -12569, -12827, -13033, -13722, -13883, -15012, -15198, -15635, -16370, -16388, -16374, -16420, -16195, -15967, -16401, -16350, -16631, -16856, -16834, -16757, -16377, -16379, -16409, -16058, -15915, -15939, -15975, -15733, -15463, -15500, -15107, -15033, -15092, -14835, -14580, -14339, -13821, -12790, -12979, -11902, -10935, -10157, -8776, -7596, -7138, -6608, -6124, -5920, -5234, -4839, -4694, -4391, -4435, -4426, -4426, -4426, -4426, -4426, -4434, -4396, -4700, -4914, -5224, -5587, -6121, -6215, -6193, -6198, -6199, -6198, -6205, -6169, -6492, -6671, -6633, -6641, -6640, -6639, -6647, -6605, -6274, -5575, -5162, -4699, -2622, -658, -1001};