/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgame_0107 256 samples */
 
const int16_t AKWF_vgame_0107_256_DATA [256] = 
{10255, 16690, 15050, 16502, 18194, 18844, 21697, 23857, 24239, 24019, 24595, 27430, 27529, 30747, 32775, 32735, 32856, 32133, 30603, 30977, 29228, 27215, 27451, 27432, 27303, 26090, 26193, 25108, 23982, 23655, 22602, 22818, 21127, 20826, 18567, 17202, 17142, 14707, 14875, 13332, 11890, 9925, 9221, 9445, 7136, 6786, 4430, 3166, 4013, 4075, 3797, 5556, 6734, 7378, 9132, 10636, 10658, 10527, 12121, 12714, 12681, 14838, 16798, 16422, 17254, 18722, 18570, 18456, 21343, 22767, 22522, 22439, 23006, 24647, 24369, 25897, 26486, 27567, 28635, 28471, 29084, 29212, 26336, 25787, 25218, 23806, 23259, 20449, 20313, 18534, 18495, 18178, 15261, 15019, 12880, 11951, 10379, 10519, 10151, 9034, 8923, 9455, 1252, -10765, -9206, -9591, -11349, -11489, -11920, -13674, -14254, -14114, -14341, -12300, -11493, -10923, -9591, -10303, -10112, -10384, -8914, -7528, -6546, -1130, -808, -580, -2257, 11315, 19712, 18350, 20468, 23334, 6970, -10202, -4730, -1286, -858, 1997, 1486, 4494, 5920, 6189, 9001, 9630, 10487, 10492, 9630, 10013, 4272, -8436, -8078, -8974, -8774, -9108, -10245, -10092, -10917, -12608, -12896, -12809, -12865, -14630, -14750, -16905, -19993, -20196, -20031, -20457, -22821, -22525, -24271, -28232, -28058, -28074, -28024, -29677, -30258, -29449, -28008, -27758, -25985, -26193, -24830, -24084, -22848, -21159, -21395, -19584, -19418, -18688, -17358, -16112, -15165, -15509, -14032, -13268, -13039, -10767, -9061, -8543, -8827, -7871, -6615, -6192, -4479, -2853, -2638, -2562, -3405, -4073, -3975, -6263, -8686, -8660, -8404, -9614, -12217, -11567, -14438, -17571, -17178, -17192, -17407, -19190, -19085, -20209, -21225, -21884, -23342, -23108, -24277, -24406, -25677, -27303, -27113, -27177, -26980, -28224, -29273, -29071, -29101, -29147, -26833, -26531, -23620, -22013, -19943, -19785, -19523, -16529, -16546, -15348, -12886, -10408, -10259, -11180};