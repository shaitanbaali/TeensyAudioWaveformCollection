/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0035 256 samples */
 
const int16_t AKWF_aguitar_0035_256_DATA [256] = 
{535, 2210, 3811, 5372, 6951, 8472, 9965, 11446, 12963, 14433, 15889, 17368, 18878, 20349, 21801, 23228, 24621, 25954, 27222, 28390, 29412, 30335, 31130, 31750, 32216, 32551, 32747, 32770, 32712, 32525, 32269, 31949, 31618, 31242, 30889, 30536, 30260, 29976, 29756, 29575, 29392, 29224, 29065, 28855, 28615, 28271, 27853, 27364, 26703, 25958, 25080, 24046, 22914, 21690, 20382, 19022, 17588, 16200, 14813, 13461, 12179, 10982, 9884, 8909, 8082, 7365, 6759, 6274, 5871, 5557, 5270, 5032, 4781, 4525, 4203, 3792, 3343, 2728, 2014, 1217, 289, -741, -1842, -3036, -4279, -5538, -6751, -7944, -9058, -10063, -10944, -11680, -12257, -12689, -12942, -13022, -12946, -12754, -12444, -12004, -11523, -10991, -10459, -9879, -9341, -8840, -8361, -7926, -7563, -7259, -6968, -6760, -6608, -6477, -6352, -6254, -6183, -6089, -6034, -5949, -5848, -5768, -5706, -5618, -5553, -5500, -5472, -5493, -5552, -5684, -5846, -6130, -6488, -6899, -7445, -8097, -8859, -9737, -10709, -11787, -12982, -14238, -15598, -16992, -18451, -19907, -21354, -22782, -24159, -25451, -26653, -27763, -28729, -29542, -30200, -30707, -31016, -31180, -31160, -30949, -30590, -30076, -29401, -28596, -27644, -26566, -25368, -24048, -22614, -21074, -19457, -17735, -15925, -14062, -12133, -10143, -8117, -6065, -3995, -1952, 100, 2123, 4101, 6013, 7872, 9618, 11317, 12887, 14320, 15658, 16864, 17937, 18868, 19622, 20210, 20645, 20916, 20998, 20925, 20641, 20189, 19561, 18757, 17784, 16630, 15358, 13934, 12379, 10726, 8967, 7148, 5276, 3353, 1397, -533, -2483, -4398, -6240, -8066, -9801, -11474, -13064, -14560, -15943, -17244, -18424, -19508, -20472, -21305, -22033, -22650, -23137, -23497, -23761, -23885, -23883, -23762, -23513, -23133, -22624, -21996, -21233, -20344, -19342, -18222, -16988, -15657, -14216, -12715, -11171, -9531, -7875, -6200, -4477, -2799, -1100};