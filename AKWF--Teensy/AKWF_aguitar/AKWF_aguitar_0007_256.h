/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0007 256 samples */
 
const int16_t AKWF_aguitar_0007_256_DATA [256] = 
{669, 2156, 3636, 5125, 6625, 8118, 9593, 11057, 12503, 13941, 15361, 16772, 18173, 19568, 20940, 22293, 23613, 24897, 26117, 27259, 28326, 29294, 30152, 30890, 31502, 31988, 32358, 32602, 32733, 32769, 32702, 32544, 32318, 32022, 31656, 31230, 30762, 30246, 29695, 29100, 28476, 27832, 27181, 26498, 25793, 25071, 24317, 23536, 22716, 21864, 20967, 20030, 19047, 18044, 17021, 15984, 14958, 13965, 13010, 12102, 11261, 10489, 9799, 9185, 8623, 8111, 7620, 7147, 6678, 6189, 5678, 5145, 4596, 4025, 3462, 2898, 2371, 1903, 1487, 1150, 906, 747, 683, 707, 809, 976, 1200, 1472, 1774, 2092, 2438, 2771, 3087, 3405, 3698, 3967, 4208, 4405, 4565, 4695, 4779, 4808, 4791, 4729, 4634, 4502, 4346, 4165, 3976, 3779, 3576, 3365, 3152, 2932, 2687, 2413, 2103, 1750, 1346, 888, 379, -164, -752, -1369, -2015, -2670, -3319, -3973, -4617, -5253, -5871, -6474, -7075, -7670, -8254, -8830, -9398, -9965, -10524, -11063, -11588, -12100, -12599, -13078, -13544, -13994, -14420, -14839, -15242, -15615, -15971, -16313, -16609, -16870, -17091, -17246, -17341, -17370, -17318, -17179, -16955, -16655, -16273, -15825, -15315, -14757, -14179, -13582, -12982, -12417, -11892, -11397, -10947, -10565, -10240, -9969, -9755, -9580, -9446, -9341, -9242, -9138, -9039, -8930, -8792, -8641, -8462, -8264, -8056, -7844, -7634, -7446, -7285, -7165, -7087, -7072, -7116, -7213, -7374, -7597, -7871, -8189, -8550, -8950, -9376, -9825, -10298, -10794, -11304, -11821, -12340, -12856, -13370, -13874, -14359, -14829, -15283, -15720, -16142, -16558, -16955, -17341, -17714, -18064, -18383, -18657, -18898, -19091, -19215, -19274, -19254, -19149, -18958, -18683, -18318, -17872, -17364, -16788, -16160, -15491, -14814, -14108, -13403, -12692, -11963, -11225, -10450, -9639, -8779, -7857, -6863, -5787, -4632, -3403, -2101, -704};