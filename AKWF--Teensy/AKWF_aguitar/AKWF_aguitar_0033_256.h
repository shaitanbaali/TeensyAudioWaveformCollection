/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0033 256 samples */
 
const int16_t AKWF_aguitar_0033_256_DATA [256] = 
{671, 2789, 4843, 6923, 9001, 11041, 13032, 14968, 16806, 18570, 20207, 21697, 23045, 24270, 25291, 26188, 26891, 27401, 27719, 27837, 27781, 27500, 27018, 26334, 25446, 24345, 23062, 21576, 19951, 18142, 16171, 14055, 11810, 9467, 7018, 4459, 1893, -691, -3307, -5866, -8409, -10889, -13260, -15555, -17757, -19742, -21615, -23386, -24962, -26397, -27655, -28778, -29744, -30528, -31205, -31764, -32197, -32506, -32679, -32754, -32722, -32600, -32355, -31992, -31474, -30841, -30117, -29215, -28137, -26959, -25631, -24129, -22514, -20743, -18856, -16894, -14850, -12732, -10523, -8308, -6126, -3937, -1794, 270, 2271, 4163, 5945, 7630, 9177, 10608, 11955, 13174, 14301, 15351, 16295, 17196, 18054, 18840, 19605, 20335, 21044, 21706, 22379, 23022, 23622, 24167, 24621, 25026, 25338, 25543, 25640, 25613, 25440, 25148, 24720, 24077, 23345, 22534, 21440, 20261, 18967, 17587, 16156, 14646, 13143, 11602, 10068, 8557, 7091, 5686, 4333, 3029, 1816, 703, -315, -1276, -2138, -2949, -3666, -4370, -5023, -5623, -6199, -6728, -7238, -7780, -8281, -8768, -9259, -9743, -10233, -10725, -11177, -11585, -11969, -12347, -12651, -12893, -13046, -13176, -13224, -13166, -13059, -12871, -12609, -12251, -11840, -11355, -10754, -10151, -9498, -8791, -8073, -7308, -6512, -5702, -4896, -4112, -3284, -2457, -1656, -828, 20, 817, 1658, 2491, 3322, 4155, 5020, 5871, 6712, 7558, 8408, 9237, 10074, 10875, 11637, 12329, 12994, 13591, 14083, 14523, 14870, 15090, 15215, 15240, 15128, 14880, 14518, 14012, 13375, 12635, 11735, 10730, 9625, 8433, 7109, 5708, 4232, 2697, 1128, -469, -2125, -3764, -5375, -6982, -8547, -10050, -11479, -12832, -14106, -15242, -16296, -17212, -17995, -18606, -19124, -19481, -19692, -19750, -19635, -19388, -18982, -18381, -17673, -16815, -15809, -14648, -13371, -11976, -10427, -8788, -7022, -5220, -3304, -1269};