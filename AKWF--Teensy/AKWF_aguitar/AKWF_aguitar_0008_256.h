/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0008 256 samples */
 
const int16_t AKWF_aguitar_0008_256_DATA [256] = 
{767, 2755, 4742, 6704, 8683, 10678, 12607, 14521, 16384, 18203, 19925, 21560, 23121, 24582, 25933, 27164, 28276, 29266, 30143, 30883, 31536, 32007, 32358, 32656, 32760, 32768, 32686, 32480, 32167, 31777, 31295, 30680, 30005, 29307, 28504, 27659, 26735, 25786, 24793, 23803, 22774, 21710, 20664, 19601, 18546, 17490, 16457, 15427, 14415, 13430, 12454, 11472, 10537, 9603, 8712, 7811, 6949, 6071, 5231, 4404, 3627, 2867, 2104, 1380, 710, 86, -544, -1109, -1655, -2170, -2609, -2991, -3347, -3621, -3852, -3993, -4043, -4047, -3987, -3808, -3552, -3233, -2800, -2317, -1729, -1095, -381, 380, 1184, 2019, 2886, 3814, 4676, 5555, 6414, 7260, 8066, 8809, 9507, 10132, 10666, 11153, 11544, 11828, 12026, 12115, 12111, 11990, 11768, 11432, 11007, 10467, 9860, 9114, 8318, 7477, 6536, 5582, 4554, 3505, 2438, 1350, 273, -816, -1886, -2950, -3997, -5024, -6050, -7054, -8049, -9013, -9987, -10938, -11881, -12809, -13700, -14604, -15520, -16394, -17242, -18103, -18923, -19709, -20467, -21185, -21875, -22520, -23127, -23662, -24134, -24581, -24922, -25216, -25432, -25550, -25606, -25587, -25459, -25263, -24996, -24642, -24228, -23740, -23162, -22580, -21923, -21212, -20478, -19703, -18894, -18032, -17185, -16342, -15458, -14566, -13647, -12705, -11794, -10823, -9875, -8886, -7922, -6927, -5927, -4934, -3919, -2924, -1936, -938, 33, 977, 1912, 2775, 3640, 4431, 5175, 5853, 6478, 7008, 7433, 7816, 8044, 8194, 8240, 8159, 7936, 7596, 7131, 6550, 5830, 5029, 4066, 3007, 1864, 618, -658, -2018, -3426, -4843, -6277, -7722, -9150, -10546, -11917, -13205, -14445, -15606, -16660, -17649, -18527, -19283, -19952, -20480, -20885, -21161, -21288, -21298, -21185, -20947, -20563, -20019, -19390, -18611, -17706, -16656, -15513, -14274, -12916, -11487, -9933, -8303, -6615, -4848, -3028, -1089};