/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0018 256 samples */
 
const int16_t AKWF_aguitar_0018_256_DATA [256] = 
{254, 768, 1369, 2079, 2909, 3854, 4940, 6142, 7455, 8878, 10387, 11974, 13622, 15296, 16981, 18633, 20212, 21709, 23101, 24354, 25468, 26441, 27289, 28028, 28657, 29200, 29663, 30063, 30407, 30707, 30951, 31144, 31300, 31426, 31536, 31638, 31750, 31877, 32018, 32172, 32330, 32492, 32628, 32724, 32767, 32736, 32617, 32411, 32110, 31697, 31161, 30490, 29672, 28716, 27621, 26380, 25020, 23552, 21992, 20391, 18762, 17115, 15474, 13836, 12191, 10554, 8905, 7272, 5676, 4139, 2660, 1263, -65, -1328, -2530, -3687, -4824, -5945, -7054, -8145, -9192, -10202, -11165, -12080, -12965, -13834, -14694, -15555, -16407, -17254, -18082, -18870, -19615, -20306, -20933, -21509, -22050, -22546, -22998, -23399, -23724, -23955, -24096, -24145, -24107, -23989, -23806, -23596, -23385, -23199, -23060, -22969, -22917, -22881, -22865, -22862, -22861, -22860, -22868, -22887, -22900, -22909, -22893, -22851, -22766, -22644, -22488, -22294, -22064, -21802, -21502, -21161, -20776, -20360, -19924, -19475, -19020, -18583, -18181, -17819, -17496, -17210, -16949, -16698, -16450, -16215, -15975, -15722, -15449, -15157, -14857, -14543, -14217, -13881, -13520, -13125, -12695, -12228, -11712, -11156, -10551, -9892, -9172, -8377, -7523, -6625, -5686, -4747, -3823, -2913, -2034, -1211, -463, 190, 754, 1223, 1610, 1958, 2289, 2578, 2828, 3056, 3247, 3396, 3484, 3510, 3465, 3352, 3197, 3022, 2838, 2656, 2485, 2323, 2180, 2059, 1966, 1911, 1895, 1920, 2003, 2135, 2306, 2505, 2717, 2926, 3119, 3299, 3461, 3617, 3762, 3898, 4027, 4145, 4238, 4305, 4344, 4343, 4300, 4208, 4072, 3881, 3635, 3338, 2987, 2582, 2137, 1649, 1141, 626, 113, -390, -882, -1365, -1827, -2248, -2605, -2886, -3092, -3203, -3237, -3203, -3118, -2996, -2852, -2691, -2523, -2342, -2142, -1928, -1703, -1452, -1181, -889, -559, -171};