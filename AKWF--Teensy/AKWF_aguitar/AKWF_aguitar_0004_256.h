/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0004 256 samples */
 
const int16_t AKWF_aguitar_0004_256_DATA [256] = 
{158, 614, 982, 1292, 1523, 1665, 1716, 1688, 1593, 1524, 1351, 1137, 985, 873, 778, 776, 846, 1069, 1404, 1848, 2450, 3217, 4140, 5180, 6344, 7625, 8998, 10387, 11816, 13312, 14826, 16315, 17750, 19159, 20567, 21929, 23181, 24366, 25583, 26704, 27691, 28659, 29538, 30349, 31046, 31620, 32115, 32463, 32690, 32769, 32678, 32536, 32249, 31843, 31349, 30737, 30080, 29427, 28641, 27871, 27145, 26378, 25647, 24937, 24281, 23657, 23046, 22399, 21817, 21205, 20559, 19867, 19109, 18269, 17396, 16465, 15445, 14345, 13157, 11958, 10739, 9465, 8179, 6918, 5659, 4452, 3290, 2159, 1080, 79, -853, -1756, -2579, -3272, -3938, -4579, -5099, -5588, -6044, -6414, -6738, -7058, -7350, -7601, -7872, -8159, -8455, -8758, -9118, -9510, -9874, -10289, -10677, -11075, -11439, -11745, -12034, -12220, -12353, -12450, -12411, -12331, -12218, -12028, -11773, -11519, -11270, -11018, -10752, -10585, -10453, -10350, -10324, -10347, -10425, -10543, -10699, -10900, -11090, -11274, -11480, -11671, -11868, -12034, -12172, -12322, -12472, -12586, -12733, -12917, -13119, -13326, -13545, -13830, -14113, -14432, -14775, -15097, -15424, -15749, -16053, -16331, -16534, -16684, -16813, -16884, -16853, -16770, -16667, -16496, -16255, -16007, -15702, -15335, -14997, -14602, -14218, -13808, -13386, -13022, -12633, -12272, -11931, -11639, -11388, -11158, -11000, -10874, -10785, -10740, -10697, -10661, -10633, -10605, -10542, -10414, -10258, -10009, -9693, -9313, -8887, -8388, -7808, -7217, -6598, -5959, -5333, -4677, -4093, -3535, -2921, -2402, -1899, -1386, -890, -430, 9, 445, 844, 1252, 1636, 1968, 2242, 2468, 2641, 2704, 2654, 2513, 2279, 1914, 1441, 879, 210, -525, -1274, -2049, -2858, -3628, -4325, -4948, -5478, -5869, -6114, -6216, -6202, -6047, -5766, -5364, -4856, -4288, -3635, -2965, -2287, -1608, -995, -352};