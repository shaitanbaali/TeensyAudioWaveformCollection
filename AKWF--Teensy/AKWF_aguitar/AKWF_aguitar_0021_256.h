/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0021 256 samples */
 
const int16_t AKWF_aguitar_0021_256_DATA [256] = 
{544, 1959, 3415, 4912, 6439, 7982, 9555, 11127, 12700, 14241, 15769, 17284, 18751, 20162, 21547, 22860, 24116, 25318, 26452, 27506, 28475, 29368, 30170, 30877, 31485, 31973, 32350, 32614, 32755, 32732, 32587, 32293, 31839, 31226, 30467, 29541, 28482, 27251, 25872, 24374, 22727, 20970, 19112, 17165, 15140, 13043, 10897, 8743, 6583, 4407, 2245, 122, -1951, -3968, -5889, -7736, -9500, -11139, -12652, -14059, -15329, -16470, -17466, -18324, -19041, -19630, -20061, -20354, -20517, -20550, -20463, -20242, -19895, -19452, -18893, -18223, -17469, -16630, -15689, -14655, -13570, -12392, -11156, -9864, -8518, -7131, -5712, -4258, -2793, -1313, 157, 1617, 3066, 4485, 5854, 7181, 8437, 9626, 10736, 11770, 12692, 13529, 14280, 14913, 15433, 15857, 16160, 16369, 16457, 16418, 16302, 16077, 15748, 15327, 14823, 14223, 13552, 12808, 12010, 11147, 10222, 9272, 8283, 7273, 6229, 5175, 4101, 3032, 1952, 863, -215, -1282, -2348, -3422, -4449, -5498, -6523, -7524, -8525, -9496, -10438, -11362, -12254, -13107, -13919, -14687, -15275, -15870, -16523, -17070, -17577, -18023, -18406, -18708, -18942, -19126, -19240, -19305, -19301, -19246, -19145, -19021, -18839, -18617, -18394, -18127, -17830, -17531, -17218, -16869, -16522, -16153, -15783, -15389, -14978, -14547, -14095, -13645, -13172, -12661, -12115, -11548, -10968, -10346, -9686, -9002, -8279, -7536, -6766, -5968, -5148, -4318, -3494, -2652, -1829, -1015, -223, 530, 1263, 1931, 2546, 3121, 3621, 4055, 4413, 4699, 4911, 5041, 5108, 5085, 5003, 4850, 4625, 4349, 4013, 3645, 3205, 2736, 2235, 1680, 1139, 541, -83, -701, -1347, -2006, -2680, -3351, -4000, -4664, -5316, -5946, -6548, -7114, -7664, -8168, -8607, -8997, -9322, -9572, -9749, -9838, -9842, -9760, -9559, -9273, -8883, -8370, -7775, -7067, -6244, -5328, -4317, -3225, -2038, -748};