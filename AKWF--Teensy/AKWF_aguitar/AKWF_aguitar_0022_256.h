/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0022 256 samples */
 
const int16_t AKWF_aguitar_0022_256_DATA [256] = 
{1288, 3390, 5374, 7338, 9281, 11210, 13142, 15004, 16879, 18720, 20509, 22284, 23946, 25542, 27035, 28384, 29617, 30650, 31469, 32100, 32522, 32726, 32749, 32577, 32227, 31727, 31040, 30269, 29364, 28323, 27186, 25951, 24641, 23223, 21750, 20177, 18553, 16888, 15147, 13379, 11628, 9866, 8123, 6438, 4748, 3151, 1660, 184, -1136, -2416, -3586, -4675, -5683, -6598, -7403, -8164, -8928, -9539, -10137, -10748, -11323, -11944, -12600, -13292, -14019, -14748, -15492, -16274, -17023, -17714, -18386, -18992, -19606, -20149, -20651, -21131, -21567, -22065, -22523, -22993, -23437, -23894, -24351, -24797, -25166, -25496, -25698, -25837, -25899, -25843, -25714, -25505, -25281, -24971, -24654, -24296, -23971, -23552, -23101, -22681, -22205, -21728, -21134, -20456, -19722, -18884, -17920, -16910, -15752, -14503, -13090, -11613, -10085, -8476, -6793, -5079, -3282, -1507, 272, 2011, 3728, 5381, 7042, 8572, 10046, 11439, 12748, 14020, 15210, 16322, 17360, 18334, 19270, 20089, 20818, 21472, 22017, 22472, 22785, 22990, 23124, 23151, 23077, 22959, 22797, 22538, 22232, 21907, 21505, 21025, 20522, 19855, 19135, 18285, 17301, 16180, 14956, 13579, 12129, 10590, 9001, 7388, 5804, 4294, 2881, 1656, 575, -262, -917, -1333, -1530, -1558, -1357, -1062, -675, -223, 213, 626, 954, 1205, 1315, 1321, 1207, 1033, 770, 456, 166, -82, -294, -362, -329, -122, 223, 739, 1334, 2055, 2812, 3586, 4336, 4983, 5498, 5864, 6033, 6007, 5760, 5295, 4651, 3796, 2836, 1731, 590, -624, -1802, -2934, -4025, -5027, -5919, -6746, -7493, -8130, -8722, -9278, -9811, -10360, -10948, -11566, -12243, -12979, -13785, -14671, -15565, -16519, -17460, -18398, -19275, -20058, -20738, -21279, -21654, -21815, -21785, -21551, -21035, -20359, -19440, -18338, -17039, -15602, -13996, -12278, -10472, -8610, -6650, -4686, -2694, -649};