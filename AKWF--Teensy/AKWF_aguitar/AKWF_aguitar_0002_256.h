/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0002 256 samples */
 
const int16_t AKWF_aguitar_0002_256_DATA [256] = 
{1005, 3187, 5333, 7501, 9584, 11675, 13649, 15547, 17400, 19173, 20870, 22339, 23730, 25043, 26216, 27240, 28211, 29068, 29732, 30381, 30932, 31405, 31836, 32142, 32365, 32585, 32707, 32747, 32767, 32753, 32761, 32634, 32449, 32332, 32093, 31845, 31585, 31187, 30741, 30316, 29820, 29273, 28691, 27962, 27236, 26467, 25546, 24654, 23756, 22706, 21680, 20642, 19481, 18378, 17269, 16156, 15052, 13935, 12845, 11804, 10836, 9887, 8969, 8060, 7236, 6491, 5724, 5005, 4368, 3712, 3088, 2601, 2162, 1653, 1229, 902, 617, 401, 209, 136, 182, 286, 411, 690, 1065, 1498, 2023, 2634, 3375, 4097, 4922, 5803, 6730, 7716, 8727, 9682, 10691, 11745, 12702, 13566, 14420, 15366, 16120, 16771, 17366, 17857, 18384, 18757, 18968, 19146, 19265, 19314, 19203, 19074, 18839, 18563, 18278, 17957, 17615, 17236, 16836, 16431, 16076, 15664, 15322, 14945, 14638, 14342, 13979, 13698, 13365, 12983, 12610, 12207, 11724, 11291, 10783, 10133, 9472, 8707, 7896, 7014, 5927, 4794, 3640, 2354, 1039, -347, -1813, -3388, -5003, -6565, -8132, -9731, -11249, -12762, -14244, -15501, -16724, -17897, -18878, -19719, -20380, -21005, -21443, -21757, -21970, -22078, -22069, -21974, -21951, -21746, -21424, -21189, -20976, -20757, -20530, -20315, -20194, -20086, -20020, -20013, -20054, -20156, -20406, -20676, -20888, -21188, -21609, -22087, -22568, -23044, -23522, -24050, -24584, -25070, -25542, -25982, -26405, -26695, -26993, -27272, -27487, -27652, -27672, -27657, -27657, -27607, -27411, -27311, -27137, -26897, -26632, -26441, -26237, -26052, -25847, -25573, -25376, -25257, -25233, -25141, -25098, -25189, -25201, -25348, -25493, -25670, -25802, -25971, -26196, -26315, -26494, -26644, -26660, -26568, -26454, -26276, -25888, -25451, -24874, -24132, -23305, -22287, -21127, -19791, -18337, -16813, -15136, -13330, -11411, -9549, -7549, -5417, -3333, -1120};