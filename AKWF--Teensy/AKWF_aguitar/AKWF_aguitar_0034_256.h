/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0034 256 samples */
 
const int16_t AKWF_aguitar_0034_256_DATA [256] = 
{526, 1458, 2457, 3521, 4624, 5734, 6800, 7820, 8768, 9635, 10428, 11181, 11910, 12657, 13456, 14331, 15275, 16318, 17454, 18645, 19874, 21095, 22282, 23413, 24470, 25467, 26423, 27341, 28230, 29086, 29882, 30613, 31254, 31786, 32209, 32510, 32693, 32765, 32751, 32669, 32534, 32372, 32201, 32020, 31831, 31619, 31373, 31071, 30672, 30148, 29475, 28653, 27677, 26579, 25416, 24207, 22984, 21783, 20636, 19562, 18570, 17655, 16831, 16085, 15378, 14708, 14063, 13409, 12725, 11994, 11208, 10334, 9372, 8337, 7253, 6154, 5094, 4109, 3219, 2461, 1838, 1347, 987, 732, 559, 438, 329, 198, 36, -175, -428, -700, -965, -1214, -1439, -1627, -1788, -1945, -2113, -2309, -2542, -2801, -3075, -3340, -3580, -3771, -3901, -3977, -4001, -3986, -3961, -3938, -3930, -3960, -4045, -4199, -4423, -4730, -5129, -5618, -6196, -6844, -7555, -8306, -9050, -9754, -10382, -10914, -11339, -11654, -11894, -12091, -12278, -12480, -12738, -13071, -13493, -14011, -14612, -15280, -15994, -16710, -17408, -18057, -18636, -19150, -19593, -19977, -20313, -20622, -20908, -21182, -21447, -21712, -21978, -22229, -22461, -22662, -22811, -22899, -22921, -22865, -22733, -22543, -22304, -22028, -21738, -21433, -21128, -20819, -20501, -20161, -19796, -19399, -18948, -18444, -17884, -17260, -16585, -15867, -15105, -14315, -13526, -12742, -11980, -11242, -10557, -9920, -9330, -8788, -8285, -7798, -7311, -6818, -6310, -5798, -5292, -4814, -4384, -4016, -3733, -3536, -3422, -3386, -3407, -3471, -3538, -3582, -3570, -3483, -3312, -3070, -2775, -2452, -2143, -1894, -1727, -1667, -1735, -1935, -2263, -2698, -3209, -3760, -4313, -4841, -5333, -5784, -6199, -6561, -6889, -7166, -7385, -7534, -7612, -7604, -7502, -7323, -7080, -6789, -6469, -6138, -5814, -5511, -5220, -4932, -4639, -4327, -3995, -3639, -3233, -2776, -2269, -1698, -1039, -280};