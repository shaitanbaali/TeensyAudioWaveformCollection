/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0028 256 samples */
 
const int16_t AKWF_aguitar_0028_256_DATA [256] = 
{551, 2380, 4115, 5812, 7400, 8822, 10112, 11228, 12142, 12875, 13441, 13834, 14094, 14267, 14373, 14479, 14589, 14734, 14932, 15252, 15640, 16183, 16806, 17503, 18273, 19093, 19867, 20645, 21325, 21914, 22349, 22649, 22787, 22735, 22540, 22194, 21711, 21145, 20500, 19879, 19272, 18700, 18248, 17864, 17670, 17628, 17684, 17873, 18192, 18576, 19041, 19510, 19968, 20393, 20747, 20946, 21075, 21009, 20802, 20476, 19983, 19372, 18696, 17946, 17104, 16264, 15434, 14603, 13821, 13059, 12363, 11681, 11012, 10355, 9691, 8952, 8116, 7221, 6166, 4982, 3692, 2139, 491, -1331, -3274, -5330, -7462, -9626, -11740, -13850, -15846, -17698, -19373, -20883, -22117, -23137, -23933, -24475, -24761, -24856, -24694, -24382, -23928, -23283, -22539, -21693, -20739, -19727, -18659, -17515, -16351, -15122, -13886, -12586, -11242, -9860, -8435, -6982, -5509, -4024, -2536, -1034, 446, 1899, 3306, 4652, 5924, 7067, 8129, 9046, 9850, 10488, 10974, 11297, 11459, 11460, 11361, 11067, 10672, 10155, 9530, 8860, 8122, 7391, 6597, 5837, 5118, 4414, 3779, 3181, 2641, 2158, 1782, 1427, 1131, 918, 745, 584, 496, 414, 358, 356, 390, 464, 562, 709, 907, 1114, 1375, 1670, 1994, 2355, 2721, 3138, 3547, 3981, 4391, 4787, 5195, 5592, 5941, 6276, 6561, 6810, 6993, 7139, 7205, 7223, 7146, 6994, 6739, 6404, 5943, 5392, 4716, 3900, 3012, 2025, 942, -235, -1473, -2777, -4122, -5504, -6881, -8275, -9649, -10994, -12319, -13632, -14903, -16152, -17390, -18631, -19817, -21046, -22270, -23454, -24664, -25885, -27033, -28176, -29240, -30207, -31064, -31783, -32293, -32654, -32773, -32714, -32414, -31873, -31121, -30196, -29113, -27907, -26614, -25239, -23851, -22447, -21100, -19803, -18524, -17351, -16196, -15069, -13980, -12800, -11627, -10394, -9108, -7687, -6180, -4607, -2949, -1179};