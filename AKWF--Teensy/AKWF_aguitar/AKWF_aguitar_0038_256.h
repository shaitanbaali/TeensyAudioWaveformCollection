/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0038 256 samples */
 
const int16_t AKWF_aguitar_0038_256_DATA [256] = 
{439, 1978, 3537, 5108, 6763, 8407, 10028, 11659, 13287, 14898, 16467, 17949, 19424, 20798, 22086, 23351, 24474, 25558, 26556, 27501, 28394, 29147, 29840, 30489, 31075, 31544, 31936, 32307, 32544, 32683, 32762, 32729, 32616, 32379, 32083, 31661, 31146, 30561, 29917, 29166, 28393, 27538, 26650, 25718, 24773, 23805, 22845, 21833, 20853, 19879, 18892, 17898, 16946, 16003, 15041, 14138, 13238, 12368, 11512, 10698, 9946, 9172, 8484, 7804, 7164, 6568, 6019, 5498, 5026, 4538, 4087, 3685, 3272, 2872, 2520, 2176, 1847, 1523, 1232, 965, 689, 465, 267, 54, -114, -241, -379, -462, -569, -674, -748, -780, -853, -861, -866, -837, -801, -768, -685, -498, -304, -143, 139, 417, 703, 1043, 1366, 1722, 2063, 2399, 2678, 2915, 3119, 3278, 3366, 3343, 3292, 3155, 2918, 2621, 2259, 1805, 1275, 697, 35, -849, -1613, -2455, -3342, -4287, -5254, -6282, -7326, -8393, -9444, -10526, -11612, -12641, -13610, -14597, -15541, -16390, -17145, -17884, -18553, -19126, -19607, -20057, -20436, -20745, -21001, -21250, -21389, -21502, -21594, -21661, -21680, -21685, -21681, -21607, -21543, -21454, -21337, -21193, -21053, -20873, -20704, -20500, -20289, -20019, -19744, -19426, -19080, -18717, -18287, -17783, -17253, -16680, -16014, -15325, -14552, -13737, -12877, -11968, -11027, -10101, -9145, -8232, -7301, -6442, -5634, -4893, -4204, -3610, -3084, -2624, -2284, -2021, -1825, -1673, -1601, -1607, -1683, -1780, -1915, -2099, -2327, -2568, -2822, -3137, -3471, -3804, -4189, -4534, -4900, -5314, -5714, -6065, -6432, -6810, -7143, -7496, -7836, -8141, -8455, -8784, -9081, -9379, -9696, -10041, -10376, -10669, -10987, -11293, -11593, -11855, -12094, -12281, -12393, -12462, -12477, -12345, -12141, -11871, -11503, -11015, -10427, -9773, -8965, -8105, -7108, -6028, -4885, -3672, -2350, -928};