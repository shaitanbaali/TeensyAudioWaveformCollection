/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0027 256 samples */
 
const int16_t AKWF_aguitar_0027_256_DATA [256] = 
{564, 2122, 3747, 5447, 7175, 8970, 10795, 12616, 14513, 16326, 18125, 19901, 21667, 23320, 24855, 26326, 27679, 28901, 30038, 30893, 31639, 32215, 32585, 32724, 32761, 32555, 32200, 31671, 30948, 30094, 29027, 27964, 26690, 25336, 23901, 22467, 20941, 19346, 17812, 16250, 14772, 13216, 11732, 10311, 8866, 7557, 6309, 5170, 4084, 3107, 2247, 1481, 834, 329, -19, -271, -322, -234, -40, 298, 760, 1280, 1969, 2709, 3546, 4408, 5241, 6040, 6913, 7603, 8293, 8828, 9339, 9737, 9955, 10059, 10093, 9980, 9750, 9447, 9000, 8462, 7863, 7166, 6421, 5629, 4831, 3984, 3027, 2062, 1114, 37, -1102, -2177, -3301, -4459, -5650, -6754, -7899, -9037, -10140, -11155, -12162, -13073, -13868, -14544, -15096, -15536, -15780, -15920, -15937, -15789, -15522, -15222, -14702, -14188, -13539, -12846, -12144, -11395, -10616, -9811, -9005, -8207, -7412, -6600, -5797, -4924, -4027, -3180, -2310, -1342, -384, 556, 1525, 2529, 3467, 4430, 5322, 6124, 6937, 7558, 8144, 8543, 8820, 8922, 8903, 8774, 8469, 8043, 7489, 6840, 6055, 5204, 4338, 3383, 2414, 1449, 353, -655, -1677, -2716, -3784, -4846, -5846, -6936, -8068, -9185, -10243, -11345, -12480, -13523, -14613, -15658, -16593, -17511, -18324, -19002, -19555, -19982, -20238, -20374, -20321, -20135, -19855, -19422, -18854, -18145, -17425, -16636, -15782, -14908, -14054, -13200, -12369, -11597, -10846, -10111, -9380, -8703, -8099, -7515, -7033, -6478, -5973, -5485, -5023, -4578, -4197, -3815, -3468, -3112, -2906, -2700, -2543, -2531, -2564, -2634, -2842, -3109, -3491, -3851, -4293, -4841, -5434, -6001, -6601, -7223, -7847, -8473, -9008, -9515, -9999, -10382, -10723, -11054, -11278, -11431, -11562, -11602, -11556, -11396, -11230, -11011, -10649, -10216, -9704, -9126, -8430, -7662, -6790, -5770, -4696, -3501, -2237, -850};