/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0015 256 samples */
 
const int16_t AKWF_aguitar_0015_256_DATA [256] = 
{1028, 3441, 5754, 8018, 10185, 12250, 14205, 16028, 17695, 19197, 20511, 21647, 22599, 23342, 23867, 24168, 24257, 24126, 23784, 23232, 22457, 21498, 20220, 18772, 17228, 15505, 13598, 11543, 9393, 7089, 4720, 2300, -204, -2702, -5202, -7686, -10093, -12443, -14705, -16849, -18862, -20776, -22530, -24163, -25651, -27001, -28210, -29288, -30219, -31001, -31665, -32164, -32517, -32713, -32756, -32612, -32309, -31815, -31154, -30312, -29263, -28063, -26684, -25133, -23432, -21608, -19650, -17591, -15449, -13268, -11012, -8739, -6442, -4162, -1906, 311, 2474, 4554, 6544, 8442, 10231, 11906, 13455, 14874, 16163, 17308, 18319, 19219, 20001, 20663, 21221, 21694, 22096, 22412, 22679, 22900, 23067, 23173, 23255, 23281, 23242, 23154, 22980, 22702, 22355, 21871, 21272, 20576, 19721, 18775, 17706, 16531, 15304, 14009, 12657, 11311, 9957, 8642, 7397, 6210, 5136, 4159, 3291, 2556, 1941, 1448, 1066, 790, 591, 475, 438, 451, 494, 579, 666, 748, 821, 889, 932, 935, 921, 871, 783, 677, 544, 364, 208, 28, -154, -325, -484, -595, -693, -759, -764, -735, -678, -572, -430, -274, -119, 50, 201, 351, 459, 522, 545, 504, 409, 271, 62, -188, -469, -795, -1136, -1457, -1768, -2056, -2290, -2481, -2607, -2651, -2616, -2504, -2262, -1936, -1517, -1000, -393, 318, 1111, 1966, 2898, 3871, 4892, 5931, 6965, 7994, 8972, 9879, 10710, 11441, 12048, 12500, 12821, 12978, 12974, 12773, 12427, 11897, 11213, 10387, 9421, 8337, 7142, 5866, 4486, 3045, 1523, -48, -1671, -3329, -5024, -6753, -8491, -10251, -11981, -13717, -15413, -17070, -18648, -20131, -21499, -22741, -23827, -24731, -25438, -25938, -26228, -26291, -26104, -25705, -25067, -24197, -23121, -21828, -20343, -18692, -16864, -14901, -12835, -10659, -8393, -6073, -3715, -1293};