/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0016 256 samples */
 
const int16_t AKWF_aguitar_0016_256_DATA [256] = 
{809, 2342, 3913, 5507, 7103, 8690, 10230, 11708, 13127, 14480, 15762, 16975, 18131, 19239, 20299, 21320, 22294, 23221, 24108, 24937, 25706, 26403, 27019, 27557, 27982, 28277, 28429, 28443, 28280, 27950, 27440, 26750, 25886, 24850, 23648, 22270, 20748, 19085, 17267, 15333, 13290, 11154, 8973, 6751, 4498, 2243, -7, -2237, -4422, -6568, -8655, -10654, -12574, -14402, -16113, -17753, -19293, -20748, -22128, -23415, -24634, -25770, -26821, -27798, -28693, -29507, -30249, -30912, -31487, -31976, -32352, -32610, -32752, -32755, -32631, -32380, -32008, -31523, -30936, -30246, -29466, -28618, -27706, -26741, -25739, -24726, -23706, -22681, -21681, -20688, -19702, -18748, -17796, -16845, -15912, -14998, -14104, -13246, -12412, -11606, -10828, -10080, -9367, -8674, -7999, -7363, -6746, -6164, -5598, -5044, -4490, -3926, -3347, -2770, -2180, -1596, -1026, -478, 40, 525, 980, 1384, 1745, 2071, 2357, 2589, 2785, 2943, 3070, 3182, 3280, 3376, 3500, 3618, 3753, 3874, 3985, 4087, 4162, 4208, 4228, 4218, 4196, 4135, 4049, 3947, 3831, 3696, 3557, 3445, 3361, 3313, 3324, 3369, 3464, 3600, 3743, 3894, 4043, 4170, 4270, 4321, 4316, 4252, 4103, 3869, 3556, 3152, 2677, 2136, 1542, 932, 287, -339, -962, -1553, -2111, -2630, -3084, -3465, -3782, -3995, -4112, -4130, -4049, -3874, -3598, -3242, -2801, -2289, -1731, -1109, -463, 190, 851, 1492, 2104, 2670, 3190, 3649, 4071, 4460, 4829, 5186, 5546, 5920, 6322, 6768, 7263, 7831, 8461, 9155, 9911, 10719, 11561, 12413, 13241, 14035, 14777, 15414, 15928, 16312, 16533, 16581, 16431, 16098, 15576, 14871, 14004, 12983, 11842, 10601, 9268, 7893, 6479, 5056, 3639, 2261, 931, -338, -1515, -2609, -3581, -4418, -5124, -5665, -6041, -6234, -6217, -5992, -5556, -4918, -4090, -3066, -1908, -571};