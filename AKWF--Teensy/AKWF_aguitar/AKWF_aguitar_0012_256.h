/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0012 256 samples */
 
const int16_t AKWF_aguitar_0012_256_DATA [256] = 
{1087, 3532, 5899, 8233, 10498, 12674, 14774, 16695, 18509, 20243, 21791, 23209, 24525, 25690, 26771, 27758, 28624, 29466, 30205, 30881, 31460, 31973, 32365, 32658, 32751, 32718, 32451, 31943, 31240, 30309, 29095, 27646, 26012, 24232, 22225, 20106, 17908, 15644, 13360, 11130, 8851, 6716, 4585, 2551, 637, -1177, -2876, -4503, -6004, -7384, -8725, -10010, -11200, -12362, -13506, -14641, -15722, -16754, -17717, -18627, -19486, -20181, -20821, -21318, -21735, -22101, -22407, -22689, -23037, -23385, -23773, -24233, -24765, -25281, -25817, -26319, -26785, -27143, -27401, -27566, -27609, -27582, -27492, -27344, -27152, -26946, -26684, -26366, -26052, -25677, -25210, -24679, -24068, -23381, -22637, -21861, -21020, -20178, -19347, -18506, -17659, -16746, -15834, -14826, -13669, -12415, -11035, -9525, -7913, -6240, -4567, -2891, -1314, 173, 1603, 2926, 4190, 5447, 6720, 8046, 9503, 11025, 12713, 14453, 16292, 18135, 19878, 21511, 22952, 24207, 25187, 25935, 26420, 26715, 26846, 26821, 26692, 26516, 26268, 25961, 25620, 25245, 24823, 24326, 23769, 23138, 22444, 21731, 20970, 20155, 19327, 18449, 17542, 16600, 15545, 14412, 13202, 11910, 10516, 9040, 7502, 5936, 4334, 2783, 1300, -114, -1422, -2628, -3716, -4703, -5582, -6372, -7075, -7659, -8126, -8499, -8719, -8764, -8659, -8365, -7913, -7280, -6509, -5636, -4693, -3746, -2835, -2005, -1335, -837, -523, -389, -456, -656, -957, -1315, -1665, -1986, -2188, -2255, -2145, -1843, -1355, -700, 85, 954, 1848, 2681, 3455, 4054, 4408, 4537, 4358, 3897, 3129, 2107, 862, -558, -2078, -3615, -5153, -6598, -7854, -8948, -9813, -10467, -10910, -11162, -11309, -11299, -11281, -11289, -11337, -11476, -11721, -12112, -12596, -13203, -13849, -14532, -15217, -15811, -16263, -16565, -16626, -16464, -16008, -15292, -14310, -13042, -11541, -9810, -7880, -5763, -3560, -1194};