/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0029 256 samples */
 
const int16_t AKWF_aguitar_0029_256_DATA [256] = 
{756, 2484, 4054, 5520, 6891, 8073, 9184, 10180, 11082, 11890, 12572, 13209, 13820, 14361, 14889, 15441, 15988, 16554, 17162, 17768, 18425, 19163, 19942, 20771, 21599, 22473, 23366, 24205, 25033, 25849, 26597, 27281, 27883, 28382, 28790, 29065, 29248, 29313, 29270, 29150, 28924, 28599, 28211, 27711, 27112, 26471, 25763, 25050, 24323, 23543, 22729, 21881, 20990, 20141, 19306, 18470, 17613, 16727, 15922, 15161, 14363, 13587, 12865, 12132, 11423, 10730, 10087, 9454, 8794, 8173, 7556, 6966, 6396, 5814, 5240, 4714, 4190, 3633, 3048, 2485, 1961, 1398, 778, 154, -308, -751, -1426, -2092, -2739, -3471, -4244, -4946, -5605, -6304, -7018, -7686, -8296, -8890, -9456, -9905, -10338, -10761, -11118, -11419, -11679, -11923, -12132, -12313, -12480, -12633, -12781, -12907, -13076, -13219, -13338, -13511, -13668, -13802, -13901, -13976, -14020, -14013, -13996, -13958, -13863, -13695, -13484, -13258, -12998, -12677, -12352, -12046, -11729, -11396, -11047, -10673, -10315, -9992, -9649, -9249, -8848, -8460, -8006, -7479, -6923, -6310, -5624, -4846, -3990, -3048, -2007, -898, 318, 1578, 2899, 4257, 5574, 6980, 8328, 9624, 10855, 11978, 13021, 13923, 14713, 15358, 15841, 16174, 16343, 16373, 16243, 15988, 15642, 15180, 14605, 13985, 13340, 12650, 11944, 11273, 10628, 9951, 9288, 8652, 8054, 7514, 6997, 6473, 5948, 5397, 4826, 4298, 3779, 3188, 2539, 1863, 1145, 395, -388, -1232, -2136, -3085, -4093, -5167, -6266, -7419, -8633, -9872, -11155, -12482, -13793, -15135, -16500, -17862, -19222, -20545, -21840, -23076, -24274, -25449, -26531, -27527, -28462, -29319, -30083, -30754, -31319, -31805, -32228, -32522, -32690, -32766, -32716, -32581, -32282, -31847, -31311, -30635, -29819, -28879, -27792, -26551, -25172, -23686, -22126, -20436, -18621, -16744, -14819, -12817, -10761, -8740, -6750, -4776, -2834, -935};