/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0019 256 samples */
 
const int16_t AKWF_aguitar_0019_256_DATA [256] = 
{786, 3253, 5787, 8157, 10528, 12880, 15163, 17330, 19445, 21463, 23249, 24938, 26529, 27894, 29024, 30150, 31114, 31732, 32206, 32575, 32752, 32765, 32617, 32312, 31785, 31043, 30203, 29257, 28196, 26940, 25595, 24380, 22965, 21293, 19693, 18063, 16369, 14735, 13188, 11700, 10357, 9199, 8175, 7271, 6508, 5858, 5340, 5022, 4832, 4668, 4580, 4572, 4524, 4482, 4453, 4322, 4100, 3792, 3342, 2761, 2067, 1261, 319, -784, -1981, -3327, -4780, -6234, -7764, -9379, -11073, -12704, -14308, -15921, -17522, -19113, -20633, -22061, -23347, -24540, -25614, -26561, -27377, -28023, -28495, -28813, -28947, -28864, -28577, -28073, -27396, -26535, -25497, -24360, -23045, -21576, -19927, -18180, -16456, -14649, -12796, -11020, -9233, -7516, -5880, -4376, -3006, -1734, -593, 389, 1195, 1883, 2389, 2789, 3104, 3322, 3444, 3480, 3528, 3616, 3708, 3800, 3862, 4041, 4349, 4664, 5111, 5701, 6279, 7059, 7953, 8860, 9794, 10831, 12013, 13123, 14211, 15324, 16379, 17347, 18199, 18930, 19649, 20271, 20621, 20893, 20985, 20862, 20604, 20241, 19785, 19170, 18408, 17641, 16813, 15923, 15036, 14128, 13187, 12305, 11538, 10770, 10038, 9339, 8703, 8116, 7516, 6914, 6319, 5808, 5194, 4556, 3850, 3077, 2307, 1486, 592, -376, -1350, -2423, -3483, -4532, -5634, -6743, -7887, -8993, -9977, -11016, -12024, -12994, -13961, -14814, -15575, -16320, -16931, -17448, -17946, -18324, -18597, -18817, -18864, -18771, -18605, -18299, -17881, -17307, -16648, -15913, -15007, -14052, -13004, -11904, -10784, -9700, -8652, -7587, -6598, -5761, -4987, -4356, -3953, -3715, -3646, -3747, -4021, -4506, -5140, -5924, -6858, -7932, -9015, -10181, -11442, -12569, -13721, -14909, -15920, -16819, -17672, -18283, -18659, -18979, -19119, -18965, -18581, -18014, -17212, -16230, -15035, -13584, -11978, -10164, -8189, -6041, -3805, -1471};