/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0023 256 samples */
 
const int16_t AKWF_aguitar_0023_256_DATA [256] = 
{406, 1260, 2129, 3035, 4007, 5017, 6076, 7160, 8277, 9434, 10608, 11799, 13015, 14217, 15422, 16601, 17763, 18902, 20014, 21078, 22113, 23085, 24026, 24919, 25762, 26571, 27337, 28043, 28741, 29385, 29982, 30551, 31051, 31511, 31912, 32240, 32501, 32680, 32761, 32756, 32660, 32455, 32168, 31761, 31258, 30669, 29976, 29226, 28390, 27472, 26495, 25466, 24378, 23244, 22076, 20867, 19633, 18365, 17092, 15808, 14517, 13207, 11921, 10660, 9415, 8179, 6987, 5821, 4675, 3605, 2556, 1532, 549, -405, -1314, -2198, -3058, -3895, -4727, -5516, -6295, -7059, -7805, -8534, -9235, -9887, -10530, -11115, -11677, -12187, -12631, -13039, -13398, -13688, -13927, -14128, -14277, -14386, -14477, -14514, -14552, -14553, -14543, -14517, -14485, -14442, -14384, -14304, -14208, -14100, -13974, -13809, -13652, -13486, -13300, -13097, -12909, -12717, -12546, -12387, -12234, -12122, -12030, -11949, -11894, -11855, -11827, -11797, -11778, -11728, -11674, -11582, -11463, -11306, -11106, -10885, -10622, -10322, -9995, -9654, -9296, -8942, -8583, -8230, -7904, -7576, -7270, -6982, -6716, -6427, -6159, -5887, -5613, -5311, -4996, -4660, -4279, -3879, -3467, -3030, -2578, -2111, -1642, -1206, -782, -385, -31, 286, 549, 755, 917, 1000, 1036, 1020, 947, 835, 669, 471, 249, -13, -288, -612, -941, -1284, -1654, -2055, -2457, -2874, -3291, -3733, -4154, -4567, -4976, -5347, -5694, -6008, -6275, -6509, -6683, -6827, -6920, -6864, -6920, -6982, -7032, -7076, -7137, -7206, -7318, -7465, -7649, -7880, -8140, -8436, -8768, -9113, -9472, -9819, -10169, -10481, -10753, -10984, -11155, -11273, -11340, -11339, -11280, -11174, -11017, -10812, -10579, -10328, -10059, -9773, -9474, -9182, -8897, -8598, -8294, -7997, -7700, -7387, -7074, -6731, -6375, -5993, -5584, -5142, -4682, -4186, -3639, -3063, -2456, -1801, -1105, -347};