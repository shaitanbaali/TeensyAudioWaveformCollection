/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0011 256 samples */
 
const int16_t AKWF_aguitar_0011_256_DATA [256] = 
{975, 3973, 6802, 9458, 11888, 14108, 16084, 17797, 19305, 20607, 21761, 22777, 23692, 24538, 25328, 26091, 26841, 27532, 28174, 28786, 29319, 29781, 30152, 30454, 30680, 30876, 31036, 31167, 31321, 31484, 31686, 31906, 32154, 32395, 32598, 32747, 32752, 32610, 32255, 31654, 30797, 29654, 28226, 26571, 24687, 22641, 20500, 18315, 16142, 14033, 12063, 10248, 8622, 7185, 5938, 4864, 3905, 3055, 2288, 1553, 817, 72, -671, -1422, -2162, -2892, -3557, -4158, -4642, -5007, -5256, -5361, -5328, -5219, -5022, -4760, -4519, -4289, -4147, -4095, -4161, -4364, -4707, -5174, -5754, -6414, -7109, -7804, -8464, -9033, -9470, -9775, -9907, -9869, -9673, -9325, -8870, -8329, -7759, -7180, -6629, -6153, -5738, -5407, -5168, -5013, -4900, -4808, -4729, -4619, -4492, -4316, -4092, -3850, -3599, -3372, -3227, -3180, -3273, -3532, -3945, -4531, -5241, -6050, -6897, -7746, -8529, -9197, -9726, -10068, -10245, -10253, -10138, -9939, -9710, -9541, -9465, -9544, -9823, -10320, -11034, -11941, -12992, -14167, -15368, -16533, -17605, -18515, -19218, -19669, -19873, -19836, -19569, -19117, -18502, -17831, -17119, -16420, -15783, -15235, -14786, -14448, -14208, -14035, -13914, -13785, -13626, -13391, -13060, -12572, -11934, -11118, -10118, -8965, -7647, -6210, -4699, -3113, -1508, 77, 1630, 3120, 4515, 5832, 7045, 8163, 9190, 10127, 10973, 11727, 12388, 12943, 13389, 13689, 13847, 13835, 13630, 13240, 12669, 11918, 11002, 9948, 8798, 7603, 6397, 5210, 4083, 3045, 2114, 1298, 583, -52, -620, -1164, -1708, -2296, -2948, -3681, -4511, -5418, -6394, -7414, -8467, -9492, -10481, -11383, -12188, -12897, -13481, -13955, -14352, -14685, -14973, -15260, -15574, -15941, -16379, -16902, -17500, -18142, -18820, -19458, -20008, -20424, -20639, -20603, -20246, -19552, -18471, -17019, -15205, -13027, -10565, -7861, -4983, -1940};