/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0014 256 samples */
 
const int16_t AKWF_aguitar_0014_256_DATA [256] = 
{1864, 4887, 7875, 10843, 13748, 16551, 19162, 21619, 23868, 25880, 27647, 29167, 30424, 31411, 32122, 32567, 32752, 32698, 32402, 31893, 31209, 30364, 29388, 28315, 27151, 25920, 24649, 23327, 21953, 20528, 19087, 17611, 16126, 14640, 13166, 11723, 10332, 9026, 7803, 6661, 5603, 4602, 3658, 2771, 1908, 1060, 218, -605, -1373, -2092, -2702, -3181, -3505, -3675, -3674, -3541, -3300, -3017, -2725, -2482, -2369, -2417, -2652, -3079, -3714, -4534, -5504, -6606, -7786, -8995, -10221, -11442, -12647, -13854, -15069, -16309, -17612, -18954, -20363, -21825, -23289, -24743, -26118, -27350, -28411, -29238, -29798, -30080, -30087, -29841, -29389, -28763, -28029, -27223, -26393, -25549, -24724, -23901, -23071, -22226, -21349, -20418, -19397, -18320, -17151, -15901, -14597, -13250, -11845, -10425, -8958, -7477, -5977, -4443, -2886, -1298, 332, 1987, 3646, 5298, 6954, 8568, 10134, 11615, 13016, 14334, 15542, 16643, 17653, 18555, 19351, 20049, 20625, 21103, 21476, 21721, 21866, 21933, 21890, 21778, 21608, 21381, 21107, 20776, 20385, 19918, 19370, 18695, 17892, 16947, 15837, 14549, 13101, 11505, 9783, 7971, 6114, 4272, 2501, 823, -709, -2058, -3211, -4148, -4879, -5427, -5786, -5989, -6055, -5989, -5829, -5575, -5236, -4829, -4380, -3865, -3338, -2788, -2233, -1690, -1164, -629, -120, 401, 950, 1545, 2209, 2958, 3808, 4743, 5760, 6841, 7927, 8984, 9954, 10788, 11439, 11878, 12093, 12083, 11859, 11457, 10923, 10299, 9627, 8929, 8249, 7584, 6932, 6289, 5605, 4878, 4063, 3131, 2097, 948, -337, -1706, -3157, -4667, -6221, -7782, -9339, -10898, -12470, -14009, -15558, -17091, -18630, -20155, -21652, -23096, -24439, -25641, -26663, -27484, -28059, -28381, -28445, -28242, -27803, -27134, -26259, -25216, -24017, -22669, -21169, -19525, -17757, -15829, -13741, -11499, -9086, -6514, -3831, -959};