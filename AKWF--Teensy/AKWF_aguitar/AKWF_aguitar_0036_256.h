/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0036 256 samples */
 
const int16_t AKWF_aguitar_0036_256_DATA [256] = 
{140, 466, 808, 1154, 1478, 1762, 2006, 2200, 2353, 2481, 2599, 2729, 2873, 3048, 3256, 3481, 3712, 3941, 4136, 4303, 4428, 4512, 4562, 4589, 4616, 4665, 4774, 4953, 5223, 5591, 6047, 6577, 7154, 7742, 8308, 8820, 9245, 9567, 9773, 9859, 9815, 9659, 9406, 9069, 8661, 8213, 7735, 7271, 6828, 6443, 6139, 5921, 5821, 5841, 6003, 6295, 6725, 7272, 7926, 8657, 9432, 10215, 10968, 11670, 12290, 12810, 13220, 13520, 13723, 13854, 13927, 13977, 14032, 14129, 14299, 14561, 14946, 15459, 16110, 16904, 17817, 18837, 19929, 21076, 22257, 23460, 24652, 25830, 26960, 28035, 29039, 29952, 30751, 31425, 31965, 32365, 32635, 32759, 32748, 32632, 32401, 32073, 31660, 31174, 30632, 30056, 29454, 28846, 28236, 27638, 27044, 26457, 25862, 25257, 24631, 23974, 23281, 22530, 21717, 20821, 19842, 18783, 17620, 16367, 15025, 13599, 12120, 10597, 9028, 7451, 5881, 4324, 2816, 1348, -77, -1445, -2766, -4032, -5250, -6436, -7592, -8709, -9800, -10859, -11883, -12871, -13824, -14728, -15584, -16405, -17174, -17908, -18604, -19267, -19909, -20535, -21143, -21745, -22336, -22917, -23491, -24042, -24557, -25041, -25475, -25852, -26166, -26414, -26591, -26704, -26749, -26746, -26690, -26593, -26467, -26313, -26141, -25957, -25769, -25585, -25399, -25225, -25057, -24904, -24768, -24635, -24514, -24386, -24250, -24103, -23935, -23742, -23519, -23271, -22993, -22685, -22357, -22001, -21615, -21207, -20778, -20332, -19872, -19403, -18937, -18477, -18030, -17601, -17189, -16786, -16393, -16003, -15613, -15215, -14797, -14350, -13875, -13365, -12834, -12291, -11742, -11215, -10722, -10280, -9897, -9576, -9313, -9094, -8897, -8707, -8492, -8238, -7917, -7512, -7022, -6442, -5777, -5040, -4267, -3481, -2726, -2038, -1444, -971, -634, -424, -335, -329, -382, -470, -553, -596, -584, -505, -354, -126};