/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0009 256 samples */
 
const int16_t AKWF_aguitar_0009_256_DATA [256] = 
{649, 2684, 4732, 6790, 8881, 10982, 13077, 15139, 17162, 19130, 21006, 22802, 24467, 25997, 27360, 28591, 29657, 30543, 31298, 31868, 32282, 32571, 32729, 32768, 32685, 32497, 32245, 31889, 31452, 30953, 30372, 29718, 29001, 28196, 27330, 26400, 25408, 24348, 23258, 22114, 20938, 19751, 18552, 17350, 16142, 14968, 13800, 12689, 11610, 10553, 9523, 8554, 7609, 6713, 5870, 5042, 4280, 3569, 2905, 2278, 1713, 1202, 747, 346, -38, -361, -667, -942, -1205, -1469, -1738, -2014, -2296, -2599, -2910, -3233, -3554, -3870, -4149, -4410, -4616, -4766, -4853, -4870, -4816, -4690, -4491, -4217, -3894, -3539, -3133, -2724, -2280, -1846, -1407, -988, -579, -175, 248, 630, 1026, 1433, 1828, 2254, 2671, 3088, 3489, 3887, 4255, 4589, 4855, 5077, 5215, 5268, 5218, 5071, 4827, 4475, 4047, 3503, 2876, 2173, 1409, 584, -320, -1265, -2236, -3249, -4306, -5371, -6469, -7570, -8682, -9792, -10888, -11966, -13000, -14005, -14940, -15808, -16594, -17287, -17890, -18413, -18814, -19125, -19345, -19474, -19522, -19511, -19428, -19277, -19102, -18889, -18620, -18349, -18030, -17707, -17346, -16967, -16576, -16152, -15722, -15269, -14814, -14341, -13857, -13389, -12923, -12464, -12008, -11552, -11112, -10674, -10218, -9762, -9260, -8740, -8171, -7537, -6849, -6117, -5301, -4431, -3511, -2541, -1557, -549, 457, 1446, 2383, 3284, 4114, 4852, 5502, 6051, 6493, 6821, 7045, 7173, 7180, 7091, 6920, 6639, 6253, 5798, 5250, 4620, 3917, 3136, 2291, 1390, 422, -578, -1598, -2659, -3712, -4764, -5803, -6813, -7794, -8747, -9646, -10506, -11321, -12088, -12835, -13535, -14214, -14852, -15483, -16075, -16633, -17160, -17626, -18034, -18371, -18631, -18781, -18807, -18724, -18493, -18123, -17608, -16916, -16095, -15134, -14016, -12782, -11430, -9949, -8381, -6730, -4973, -3158, -1226};