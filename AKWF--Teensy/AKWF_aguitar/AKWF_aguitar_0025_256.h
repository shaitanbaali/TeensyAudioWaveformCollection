/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0025 256 samples */
 
const int16_t AKWF_aguitar_0025_256_DATA [256] = 
{648, 1878, 3133, 4420, 5723, 7049, 8385, 9725, 11061, 12419, 13743, 15085, 16403, 17719, 19028, 20316, 21596, 22849, 24062, 25253, 26376, 27436, 28435, 29354, 30178, 30892, 31503, 32006, 32382, 32628, 32754, 32753, 32649, 32409, 32062, 31623, 31079, 30450, 29728, 28936, 28068, 27134, 26152, 25116, 24025, 22903, 21738, 20563, 19357, 18151, 16942, 15732, 14533, 13359, 12215, 11087, 9982, 8885, 7822, 6789, 5739, 4685, 3634, 2589, 1523, 444, -649, -1757, -2862, -3969, -5056, -6131, -7155, -8143, -9077, -9938, -10736, -11449, -12093, -12634, -13129, -13611, -13951, -14231, -14432, -14568, -14656, -14668, -14625, -14532, -14383, -14172, -13915, -13609, -13238, -12835, -12400, -11928, -11434, -10952, -10462, -10000, -9571, -9191, -8873, -8602, -8401, -8267, -8197, -8178, -8221, -8304, -8425, -8572, -8735, -8897, -9063, -9229, -9371, -9522, -9632, -9734, -9830, -9914, -9983, -10026, -10066, -10096, -10117, -10109, -10087, -10043, -9969, -9861, -9724, -9539, -9318, -9057, -8754, -8419, -8059, -7650, -7232, -6785, -6315, -5832, -5347, -4849, -4349, -3832, -3319, -2809, -2291, -1761, -1233, -704, -201, 303, 797, 1270, 1709, 2093, 2430, 2709, 2925, 3055, 3113, 3073, 2983, 2802, 2551, 2245, 1886, 1491, 1070, 652, 230, -178, -562, -928, -1265, -1555, -1820, -2076, -2288, -2482, -2670, -2847, -3021, -3188, -3377, -3558, -3767, -3976, -4206, -4456, -4722, -5012, -5311, -5623, -5970, -6322, -6680, -7060, -7426, -7786, -8141, -8457, -8744, -8988, -9177, -9300, -9374, -9355, -9289, -9169, -8978, -8751, -8491, -8199, -7901, -7609, -7327, -7073, -6856, -6670, -6542, -6453, -6407, -6421, -6470, -6560, -6682, -6831, -7001, -7179, -7358, -7522, -7682, -7812, -7919, -7969, -7977, -7922, -7797, -7591, -7308, -6924, -6450, -5882, -5205, -4438, -3564, -2623, -1603, -467};