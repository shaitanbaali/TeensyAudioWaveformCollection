/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0024 256 samples */
 
const int16_t AKWF_aguitar_0024_256_DATA [256] = 
{410, 1372, 2405, 3517, 4723, 5993, 7307, 8680, 10066, 11470, 12871, 14254, 15611, 16918, 18188, 19400, 20560, 21666, 22703, 23694, 24637, 25525, 26374, 27180, 27946, 28663, 29334, 29966, 30534, 31053, 31510, 31891, 32221, 32460, 32629, 32735, 32768, 32715, 32605, 32431, 32185, 31861, 31473, 31034, 30500, 29908, 29233, 28484, 27659, 26735, 25760, 24705, 23568, 22383, 21144, 19851, 18524, 17176, 15817, 14457, 13128, 11808, 10534, 9299, 8122, 7009, 5959, 4959, 4034, 3145, 2299, 1489, 711, -73, -849, -1634, -2427, -3225, -4047, -4867, -5687, -6509, -7312, -8091, -8850, -9580, -10280, -10938, -11567, -12169, -12728, -13253, -13758, -14233, -14682, -15084, -15454, -15799, -16080, -16324, -16526, -16667, -16769, -16824, -16840, -16808, -16748, -16655, -16555, -16435, -16306, -16176, -16057, -15949, -15833, -15744, -15672, -15612, -15569, -15528, -15497, -15463, -15430, -15362, -15288, -15177, -15034, -14846, -14602, -14336, -14015, -13666, -13293, -12888, -12481, -12068, -11671, -11273, -10884, -10495, -10123, -9740, -9348, -8935, -8501, -8029, -7517, -6978, -6398, -5788, -5160, -4524, -3881, -3258, -2641, -2064, -1524, -1033, -577, -168, 205, 534, 823, 1092, 1332, 1561, 1783, 1987, 2190, 2383, 2574, 2750, 2912, 3047, 3146, 3192, 3187, 3128, 2986, 2772, 2485, 2110, 1668, 1166, 612, 34, -571, -1167, -1744, -2276, -2762, -3190, -3556, -3850, -4091, -4281, -4432, -4552, -4660, -4776, -4906, -5053, -5238, -5451, -5695, -5979, -6289, -6618, -6964, -7310, -7675, -8030, -8375, -8734, -9074, -9418, -9766, -10112, -10463, -10829, -11180, -11539, -11890, -12228, -12543, -12828, -13091, -13288, -13424, -13502, -13492, -13415, -13239, -12985, -12636, -12226, -11737, -11193, -10602, -9980, -9344, -8694, -8058, -7445, -6851, -6279, -5730, -5206, -4695, -4192, -3668, -3123, -2543, -1906, -1209, -415};