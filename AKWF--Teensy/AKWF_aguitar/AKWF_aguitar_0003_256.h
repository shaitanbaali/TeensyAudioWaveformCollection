/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0003 256 samples */
 
const int16_t AKWF_aguitar_0003_256_DATA [256] = 
{586, 1598, 2712, 3912, 5196, 6566, 7991, 9460, 10950, 12509, 14079, 15661, 17199, 18745, 20267, 21782, 23142, 24499, 25795, 26990, 28135, 29126, 30017, 30797, 31421, 31964, 32359, 32619, 32727, 32763, 32710, 32595, 32338, 32070, 31744, 31342, 30992, 30641, 30238, 29831, 29423, 29019, 28611, 28180, 27738, 27218, 26640, 26066, 25450, 24734, 23988, 23174, 22260, 21333, 20359, 19394, 18415, 17353, 16299, 15323, 14326, 13333, 12382, 11418, 10501, 9618, 8732, 7858, 7049, 6193, 5340, 4542, 3746, 2942, 2152, 1403, 673, -14, -698, -1374, -2009, -2623, -3136, -3646, -4157, -4578, -4956, -5339, -5625, -5877, -6098, -6241, -6349, -6405, -6395, -6346, -6299, -6173, -6109, -5995, -5819, -5664, -5566, -5430, -5321, -5259, -5202, -5208, -5252, -5262, -5304, -5347, -5414, -5425, -5478, -5532, -5538, -5536, -5534, -5538, -5572, -5638, -5704, -5852, -6009, -6207, -6498, -6823, -7207, -7670, -8150, -8675, -9212, -9694, -10241, -10746, -11203, -11655, -12049, -12348, -12629, -12838, -12983, -13054, -13120, -13168, -13142, -13099, -13058, -13019, -12955, -12929, -12911, -12893, -12917, -12943, -13012, -13104, -13198, -13320, -13479, -13639, -13815, -14010, -14229, -14464, -14681, -14900, -15128, -15317, -15489, -15633, -15761, -15834, -15857, -15818, -15728, -15577, -15387, -15120, -14782, -14398, -13966, -13481, -12938, -12378, -11787, -11169, -10525, -9848, -9191, -8541, -7881, -7259, -6643, -6111, -5633, -5224, -4887, -4638, -4497, -4478, -4574, -4772, -5090, -5501, -6016, -6593, -7217, -7867, -8534, -9187, -9799, -10334, -10812, -11158, -11407, -11538, -11536, -11429, -11212, -10886, -10519, -10072, -9513, -8981, -8414, -7846, -7309, -6773, -6273, -5877, -5491, -5162, -4930, -4707, -4537, -4418, -4303, -4255, -4282, -4229, -4213, -4237, -4243, -4175, -4105, -4027, -3845, -3599, -3274, -2895, -2416, -1789, -1093, -279};