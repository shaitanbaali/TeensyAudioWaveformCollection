/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0006 256 samples */
 
const int16_t AKWF_aguitar_0006_256_DATA [256] = 
{828, 2925, 5022, 7121, 9208, 11248, 13267, 15205, 17064, 18836, 20502, 22057, 23505, 24827, 26020, 27087, 28053, 28913, 29668, 30328, 30907, 31406, 31832, 32192, 32453, 32638, 32751, 32762, 32680, 32495, 32207, 31824, 31328, 30734, 30049, 29287, 28454, 27562, 26643, 25715, 24764, 23804, 22864, 21947, 21051, 20182, 19328, 18503, 17703, 16907, 16151, 15387, 14603, 13827, 13023, 12223, 11401, 10548, 9672, 8763, 7845, 6926, 5999, 5098, 4215, 3376, 2601, 1905, 1309, 803, 401, 126, -49, -108, -66, 78, 297, 574, 930, 1347, 1792, 2267, 2776, 3288, 3836, 4389, 4941, 5513, 6098, 6685, 7283, 7884, 8477, 9066, 9642, 10194, 10737, 11244, 11709, 12141, 12526, 12858, 13124, 13338, 13485, 13568, 13592, 13534, 13420, 13246, 13001, 12713, 12377, 11989, 11569, 11118, 10635, 10128, 9609, 9079, 8536, 7990, 7451, 6901, 6349, 5798, 5217, 4617, 4000, 3352, 2664, 1944, 1185, 379, -476, -1350, -2253, -3175, -4103, -5017, -5894, -6730, -7508, -8210, -8820, -9339, -9758, -10062, -10280, -10399, -10429, -10401, -10314, -10175, -10013, -9838, -9649, -9469, -9298, -9142, -9024, -8926, -8834, -8765, -8727, -8678, -8634, -8598, -8555, -8509, -8457, -8380, -8282, -8185, -8072, -7948, -7838, -7732, -7658, -7607, -7586, -7604, -7662, -7783, -7949, -8158, -8409, -8692, -9010, -9363, -9722, -10094, -10484, -10877, -11302, -11724, -12165, -12648, -13159, -13713, -14314, -14953, -15657, -16415, -17214, -18062, -18944, -19842, -20757, -21674, -22588, -23475, -24322, -25142, -25914, -26631, -27289, -27892, -28448, -28934, -29365, -29738, -30049, -30310, -30500, -30623, -30678, -30664, -30571, -30414, -30185, -29877, -29485, -29024, -28487, -27878, -27209, -26457, -25633, -24769, -23831, -22819, -21744, -20606, -19390, -18116, -16760, -15327, -13812, -12229, -10567, -8818, -7001, -5113, -3177, -1144};