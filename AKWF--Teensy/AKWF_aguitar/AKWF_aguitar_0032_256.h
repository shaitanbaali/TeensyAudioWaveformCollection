/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0032 256 samples */
 
const int16_t AKWF_aguitar_0032_256_DATA [256] = 
{290, 1168, 2090, 3079, 4106, 5176, 6286, 7406, 8525, 9621, 10706, 11766, 12777, 13755, 14683, 15578, 16444, 17282, 18065, 18805, 19486, 20105, 20668, 21144, 21547, 21889, 22147, 22301, 22372, 22326, 22168, 21890, 21502, 20987, 20377, 19685, 18913, 18075, 17161, 16210, 15217, 14185, 13148, 12108, 11115, 10178, 9307, 8530, 7856, 7275, 6822, 6474, 6273, 6219, 6310, 6550, 6938, 7477, 8119, 8871, 9708, 10633, 11602, 12642, 13743, 14863, 16029, 17198, 18390, 19564, 20756, 21905, 23055, 24188, 25297, 26386, 27429, 28416, 29343, 30168, 30889, 31503, 32004, 32381, 32637, 32760, 32743, 32584, 32285, 31817, 31212, 30450, 29526, 28469, 27285, 25957, 24500, 22914, 21184, 19349, 17373, 15299, 13154, 10922, 8656, 6350, 4053, 1744, -559, -2812, -5021, -7181, -9230, -11219, -13096, -14864, -16509, -18071, -19517, -20864, -22126, -23288, -24329, -25285, -26140, -26868, -27492, -28026, -28454, -28766, -28968, -29063, -29025, -28856, -28571, -28150, -27621, -26980, -26251, -25443, -24566, -23627, -22652, -21629, -20595, -19564, -18541, -17532, -16554, -15620, -14739, -13918, -13120, -12387, -11697, -11059, -10486, -9982, -9549, -9202, -8927, -8746, -8640, -8602, -8651, -8764, -8953, -9209, -9550, -9944, -10383, -10872, -11364, -11879, -12412, -12930, -13456, -13978, -14508, -15025, -15536, -16034, -16516, -16970, -17391, -17774, -18116, -18416, -18669, -18865, -18991, -19050, -19040, -18936, -18752, -18494, -18167, -17797, -17366, -16900, -16393, -15847, -15283, -14672, -14046, -13391, -12710, -12011, -11299, -10577, -9834, -9078, -8316, -7545, -6769, -6005, -5262, -4571, -3929, -3348, -2841, -2403, -2035, -1740, -1490, -1321, -1225, -1175, -1176, -1229, -1329, -1429, -1548, -1670, -1792, -1908, -2037, -2178, -2322, -2482, -2661, -2829, -2989, -3126, -3230, -3310, -3356, -3354, -3289, -3171, -2971, -2687, -2286, -1784, -1183, -464};