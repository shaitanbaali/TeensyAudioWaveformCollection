/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0026 256 samples */
 
const int16_t AKWF_aguitar_0026_256_DATA [256] = 
{603, 2130, 3679, 5243, 6808, 8383, 9933, 11436, 12906, 14350, 15725, 17050, 18314, 19522, 20694, 21798, 22862, 23886, 24854, 25788, 26686, 27541, 28345, 29107, 29810, 30462, 31045, 31550, 31983, 32335, 32578, 32727, 32770, 32707, 32537, 32262, 31881, 31402, 30827, 30170, 29415, 28589, 27695, 26732, 25711, 24650, 23538, 22382, 21213, 20009, 18794, 17570, 16345, 15126, 13928, 12749, 11587, 10454, 9352, 8265, 7206, 6165, 5139, 4113, 3080, 2057, 1014, -36, -1093, -2163, -3246, -4316, -5367, -6418, -7428, -8403, -9326, -10181, -10963, -11686, -12328, -12897, -13380, -13778, -14111, -14360, -14553, -14673, -14729, -14737, -14677, -14572, -14419, -14224, -13995, -13746, -13475, -13184, -12904, -12619, -12350, -12103, -11895, -11709, -11569, -11462, -11398, -11365, -11357, -11395, -11454, -11524, -11606, -11700, -11798, -11903, -11990, -12078, -12163, -12234, -12295, -12337, -12362, -12369, -12345, -12282, -12195, -12064, -11890, -11665, -11397, -11081, -10722, -10312, -9871, -9399, -8916, -8409, -7891, -7374, -6861, -6364, -5870, -5383, -4909, -4427, -3951, -3475, -2987, -2490, -1973, -1442, -888, -321, 258, 840, 1417, 1983, 2521, 3029, 3496, 3908, 4260, 4544, 4747, 4880, 4937, 4925, 4832, 4673, 4456, 4182, 3861, 3501, 3113, 2694, 2261, 1816, 1361, 907, 449, -4, -449, -880, -1305, -1706, -2099, -2466, -2796, -3097, -3360, -3591, -3793, -3951, -4088, -4199, -4298, -4399, -4513, -4638, -4803, -5006, -5262, -5569, -5931, -6348, -6804, -7289, -7797, -8306, -8795, -9256, -9663, -10000, -10272, -10471, -10574, -10609, -10569, -10471, -10322, -10157, -9972, -9784, -9621, -9493, -9397, -9342, -9338, -9380, -9464, -9587, -9736, -9897, -10087, -10272, -10441, -10605, -10732, -10823, -10880, -10869, -10793, -10648, -10412, -10090, -9664, -9124, -8482, -7714, -6838, -5851, -4743, -3534, -2229, -808};