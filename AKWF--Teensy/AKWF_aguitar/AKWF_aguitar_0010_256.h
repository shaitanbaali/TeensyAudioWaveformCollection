/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0010 256 samples */
 
const int16_t AKWF_aguitar_0010_256_DATA [256] = 
{365, 1566, 2825, 4162, 5560, 7057, 8600, 10192, 11808, 13436, 15052, 16646, 18199, 19690, 21113, 22481, 23767, 24998, 26168, 27242, 28259, 29196, 30067, 30835, 31492, 32035, 32444, 32710, 32769, 32666, 32381, 31892, 31208, 30362, 29353, 28208, 26963, 25633, 24236, 22832, 21426, 20015, 18662, 17338, 16068, 14856, 13697, 12568, 11483, 10444, 9442, 8469, 7545, 6664, 5836, 5069, 4384, 3769, 3235, 2793, 2410, 2100, 1836, 1610, 1407, 1177, 933, 628, 266, -134, -616, -1162, -1751, -2367, -3002, -3601, -4155, -4638, -5031, -5333, -5523, -5576, -5541, -5404, -5196, -4940, -4659, -4379, -4113, -3885, -3703, -3581, -3518, -3498, -3524, -3558, -3581, -3588, -3543, -3461, -3302, -3065, -2768, -2406, -1999, -1550, -1095, -648, -227, 134, 442, 680, 847, 915, 912, 850, 710, 516, 282, -3, -310, -657, -1024, -1432, -1872, -2352, -2866, -3411, -3995, -4629, -5289, -5963, -6662, -7347, -8030, -8688, -9317, -9890, -10427, -10925, -11388, -11824, -12238, -12664, -13077, -13520, -13988, -14493, -15021, -15579, -16139, -16698, -17219, -17698, -18093, -18378, -18554, -18581, -18450, -18157, -17720, -17130, -16408, -15583, -14672, -13703, -12701, -11704, -10724, -9774, -8870, -8019, -7220, -6468, -5747, -5062, -4408, -3756, -3087, -2422, -1754, -1077, -411, 237, 863, 1449, 1982, 2444, 2832, 3147, 3379, 3529, 3624, 3668, 3662, 3635, 3610, 3588, 3590, 3607, 3639, 3710, 3787, 3850, 3906, 3920, 3868, 3762, 3571, 3276, 2894, 2402, 1811, 1132, 363, -488, -1392, -2349, -3373, -4413, -5484, -6606, -7736, -8889, -10057, -11217, -12389, -13543, -14667, -15739, -16729, -17617, -18394, -19016, -19467, -19727, -19773, -19606, -19245, -18680, -17921, -17004, -15950, -14795, -13567, -12303, -11023, -9761, -8525, -7330, -6177, -5062, -3986, -2914, -1855, -740};