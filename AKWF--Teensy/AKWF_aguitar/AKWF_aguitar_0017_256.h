/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0017 256 samples */
 
const int16_t AKWF_aguitar_0017_256_DATA [256] = 
{579, 2389, 4260, 6194, 8147, 10092, 12002, 13860, 15640, 17337, 18939, 20467, 21910, 23264, 24526, 25706, 26802, 27805, 28735, 29584, 30335, 31001, 31575, 32031, 32384, 32618, 32745, 32763, 32681, 32504, 32241, 31887, 31457, 30934, 30311, 29580, 28751, 27791, 26689, 25458, 24072, 22534, 20869, 19044, 17087, 15028, 12861, 10651, 8410, 6157, 3932, 1763, -333, -2322, -4226, -6036, -7738, -9331, -10826, -12222, -13539, -14797, -15997, -17148, -18273, -19358, -20416, -21442, -22424, -23363, -24246, -25066, -25826, -26501, -27088, -27590, -27988, -28288, -28486, -28572, -28562, -28447, -28234, -27929, -27547, -27094, -26581, -26001, -25383, -24724, -24019, -23275, -22511, -21726, -20918, -20099, -19267, -18421, -17575, -16732, -15902, -15087, -14297, -13530, -12799, -12097, -11440, -10823, -10234, -9680, -9129, -8571, -8019, -7443, -6836, -6210, -5557, -4890, -4217, -3540, -2887, -2257, -1657, -1107, -610, -168, 215, 539, 808, 1041, 1254, 1446, 1650, 1859, 2078, 2312, 2551, 2781, 2993, 3185, 3340, 3475, 3575, 3626, 3639, 3607, 3531, 3411, 3262, 3104, 2963, 2835, 2739, 2671, 2646, 2664, 2701, 2766, 2841, 2919, 2997, 3077, 3133, 3161, 3145, 3068, 2939, 2748, 2491, 2174, 1820, 1430, 1018, 590, 152, -299, -758, -1226, -1702, -2175, -2646, -3085, -3507, -3895, -4246, -4550, -4799, -4972, -5062, -5056, -4928, -4694, -4346, -3901, -3375, -2794, -2178, -1548, -925, -332, 221, 716, 1145, 1504, 1786, 1998, 2151, 2247, 2305, 2350, 2389, 2445, 2524, 2633, 2779, 2978, 3217, 3504, 3838, 4211, 4617, 5033, 5446, 5819, 6139, 6381, 6511, 6513, 6377, 6096, 5655, 5056, 4302, 3403, 2386, 1270, 99, -1099, -2301, -3457, -4536, -5534, -6403, -7135, -7701, -8096, -8298, -8300, -8100, -7687, -7062, -6235, -5208, -4001, -2617, -1045};