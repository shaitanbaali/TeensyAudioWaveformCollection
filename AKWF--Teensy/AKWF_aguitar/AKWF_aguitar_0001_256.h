/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0001 256 samples */
 
const int16_t AKWF_aguitar_0001_256_DATA [256] = 
{1367, 4203, 7217, 10374, 13528, 16653, 19609, 22306, 24738, 26807, 28485, 29867, 30898, 31632, 32131, 32444, 32619, 32712, 32753, 32758, 32708, 32576, 32443, 32184, 31843, 31406, 30879, 30176, 29325, 28301, 27146, 25769, 24236, 22542, 20626, 18564, 16327, 13910, 11376, 8696, 5957, 3158, 348, -2378, -5026, -7457, -9738, -11762, -13539, -15063, -16396, -17565, -18556, -19482, -20381, -21212, -22019, -22821, -23585, -24337, -25040, -25682, -26309, -26914, -27475, -28013, -28558, -29095, -29586, -30023, -30408, -30676, -30854, -30881, -30771, -30549, -30251, -29916, -29546, -29175, -28847, -28543, -28285, -28031, -27752, -27448, -27021, -26548, -25937, -25185, -24292, -23331, -22243, -21092, -19884, -18635, -17298, -15892, -14507, -13031, -11479, -9905, -8377, -6865, -5403, -4014, -2684, -1339, -14, 1352, 2771, 4326, 5971, 7696, 9478, 11282, 13000, 14648, 16146, 17483, 18656, 19695, 20731, 21642, 22619, 23646, 24710, 25741, 26778, 27663, 28402, 28929, 29179, 29241, 29058, 28696, 28228, 27747, 27216, 26708, 26205, 25679, 25045, 24218, 23096, 21673, 19932, 17960, 15820, 13631, 11548, 9702, 8205, 7125, 6392, 5986, 5763, 5485, 5080, 4332, 3190, 1678, -243, -2427, -4736, -6983, -9074, -10834, -12208, -13190, -13781, -14073, -14189, -14214, -14182, -14228, -14290, -14393, -14446, -14372, -14092, -13586, -12861, -11853, -10663, -9354, -8038, -6744, -5610, -4660, -3886, -3312, -2866, -2503, -2152, -1793, -1355, -874, -323, 166, 619, 988, 1241, 1379, 1401, 1398, 1315, 1340, 1478, 1803, 2296, 2946, 3743, 4595, 5442, 6167, 6705, 6937, 6816, 6264, 5297, 3943, 2221, 238, -1881, -4035, -6123, -8008, -9680, -10997, -11957, -12558, -12811, -12758, -12435, -11924, -11278, -10607, -9909, -9285, -8803, -8451, -8246, -8196, -8251, -8370, -8544, -8691, -8690, -8540, -8159, -7455, -6436, -5009, -3247, -1046};