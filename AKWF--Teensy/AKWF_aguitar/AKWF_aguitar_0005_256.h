/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0005 256 samples */
 
const int16_t AKWF_aguitar_0005_256_DATA [256] = 
{872, 2407, 3853, 5299, 6717, 8075, 9375, 10644, 11824, 12958, 14023, 15013, 15921, 16759, 17529, 18187, 18778, 19314, 19726, 20070, 20358, 20572, 20686, 20760, 20755, 20662, 20542, 20354, 20105, 19819, 19450, 19038, 18626, 18170, 17661, 17141, 16590, 16006, 15415, 14804, 14170, 13499, 12838, 12162, 11452, 10727, 10014, 9283, 8508, 7762, 7014, 6219, 5448, 4652, 3886, 3091, 2283, 1515, 751, 14, -743, -1467, -2118, -2771, -3394, -3935, -4417, -4875, -5281, -5640, -5901, -6088, -6210, -6295, -6295, -6209, -6077, -5897, -5646, -5336, -4989, -4580, -4128, -3656, -3153, -2637, -2111, -1585, -1027, -492, 20, 530, 996, 1453, 1896, 2277, 2632, 2949, 3208, 3419, 3597, 3727, 3803, 3840, 3850, 3793, 3696, 3541, 3352, 3154, 2919, 2655, 2363, 2056, 1730, 1407, 1074, 716, 388, 60, -268, -538, -816, -1094, -1323, -1529, -1717, -1853, -1965, -2060, -2085, -2086, -2064, -1972, -1845, -1654, -1445, -1171, -851, -509, -102, 352, 856, 1405, 1956, 2556, 3208, 3864, 4536, 5209, 5892, 6583, 7274, 7938, 8559, 9174, 9775, 10328, 10839, 11306, 11723, 12111, 12458, 12744, 12995, 13205, 13353, 13465, 13561, 13591, 13606, 13600, 13542, 13463, 13345, 13188, 13013, 12794, 12558, 12313, 12023, 11694, 11307, 10893, 10447, 9921, 9345, 8720, 8035, 7288, 6470, 5589, 4632, 3609, 2533, 1360, 153, -1139, -2520, -3933, -5374, -6883, -8443, -10000, -11568, -13141, -14732, -16326, -17859, -19384, -20894, -22320, -23708, -25012, -26219, -27364, -28398, -29324, -30139, -30870, -31479, -31945, -32326, -32596, -32737, -32760, -32655, -32462, -32170, -31783, -31310, -30719, -30052, -29305, -28487, -27615, -26683, -25651, -24569, -23458, -22273, -21045, -19775, -18455, -17097, -15698, -14270, -12813, -11340, -9824, -8301, -6793, -5254, -3701, -2166, -614};