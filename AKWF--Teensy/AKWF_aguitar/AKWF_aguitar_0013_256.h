/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0013 256 samples */
 
const int16_t AKWF_aguitar_0013_256_DATA [256] = 
{1434, 3560, 5486, 7306, 8951, 10449, 11757, 12833, 13774, 14536, 15160, 15629, 16000, 16303, 16533, 16711, 16855, 16959, 17036, 17072, 17040, 16927, 16711, 16399, 15962, 15411, 14685, 13872, 12962, 11996, 11024, 10056, 9157, 8384, 7775, 7333, 7094, 7020, 7167, 7477, 7967, 8551, 9227, 9945, 10708, 11527, 12336, 13145, 13967, 14820, 15666, 16535, 17414, 18287, 19103, 19843, 20481, 20963, 21243, 21273, 21041, 20498, 19625, 18463, 16946, 15160, 13131, 10901, 8526, 6034, 3462, 893, -1657, -4137, -6524, -8861, -11087, -13228, -15217, -17158, -18996, -20742, -22406, -23963, -25451, -26813, -28068, -29171, -30104, -30893, -31491, -31926, -32154, -32176, -32024, -31680, -31157, -30511, -29754, -28840, -27898, -26870, -25786, -24674, -23552, -22411, -21228, -20031, -18803, -17541, -16208, -14853, -13408, -11890, -10291, -8639, -6956, -5205, -3441, -1705, -6, 1629, 3164, 4579, 5840, 6899, 7808, 8487, 8988, 9265, 9346, 9282, 9051, 8697, 8230, 7710, 7150, 6552, 5943, 5347, 4776, 4186, 3629, 3037, 2458, 1842, 1216, 560, -113, -751, -1391, -2011, -2573, -3072, -3478, -3813, -4032, -4139, -4175, -4110, -3974, -3761, -3498, -3157, -2776, -2306, -1772, -1101, -337, 592, 1681, 2944, 4363, 5952, 7634, 9427, 11252, 13111, 14946, 16644, 18263, 19704, 20964, 22053, 22975, 23693, 24283, 24712, 25005, 25243, 25367, 25386, 25330, 25228, 25015, 24690, 24261, 23659, 22948, 22080, 21069, 19926, 18680, 17306, 15838, 14323, 12753, 11132, 9530, 7924, 6317, 4708, 3150, 1476, -211, -1788, -3404, -5064, -6802, -8576, -10402, -12293, -14228, -16200, -18159, -20131, -22074, -23953, -25703, -27333, -28795, -30049, -31101, -31910, -32445, -32727, -32744, -32493, -31996, -31269, -30295, -29125, -27777, -26248, -24556, -22734, -20808, -18775, -16641, -14433, -12179, -9883, -7563, -5233, -2950, -681};