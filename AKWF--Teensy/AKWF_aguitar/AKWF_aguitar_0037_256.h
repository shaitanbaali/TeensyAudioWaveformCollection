/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0037 256 samples */
 
const int16_t AKWF_aguitar_0037_256_DATA [256] = 
{386, 1622, 2802, 3912, 4965, 5942, 6948, 7890, 8821, 9798, 10765, 11784, 12856, 13954, 15070, 16220, 17409, 18582, 19782, 20950, 22096, 23200, 24282, 25295, 26295, 27236, 28105, 28921, 29680, 30372, 30998, 31566, 32019, 32371, 32633, 32758, 32763, 32620, 32323, 31897, 31297, 30581, 29761, 28773, 27718, 26592, 25389, 24167, 22909, 21652, 20398, 19173, 17954, 16784, 15623, 14476, 13345, 12249, 11172, 10113, 9088, 8097, 7149, 6245, 5428, 4652, 3971, 3391, 2850, 2435, 2060, 1742, 1482, 1243, 1032, 789, 540, 250, -79, -439, -869, -1308, -1748, -2226, -2647, -3061, -3422, -3699, -3904, -4026, -4063, -4049, -3980, -3841, -3667, -3505, -3359, -3233, -3139, -3093, -3113, -3198, -3307, -3449, -3626, -3823, -3982, -4136, -4260, -4366, -4409, -4417, -4418, -4392, -4305, -4251, -4201, -4156, -4150, -4154, -4211, -4284, -4400, -4532, -4691, -4857, -5010, -5207, -5411, -5599, -5813, -6037, -6293, -6571, -6871, -7205, -7588, -8009, -8435, -8917, -9403, -9909, -10381, -10852, -11326, -11740, -12145, -12521, -12868, -13226, -13572, -13927, -14281, -14666, -15111, -15576, -16077, -16608, -17148, -17691, -18205, -18665, -19047, -19333, -19488, -19480, -19343, -19034, -18540, -17919, -17145, -16245, -15267, -14211, -13097, -11981, -10862, -9798, -8769, -7785, -6880, -6029, -5269, -4555, -3901, -3319, -2751, -2241, -1786, -1376, -995, -668, -415, -193, -67, 28, 26, -29, -171, -346, -562, -825, -1105, -1405, -1694, -1952, -2220, -2458, -2630, -2811, -2978, -3117, -3235, -3384, -3543, -3716, -3898, -4132, -4379, -4699, -5015, -5368, -5770, -6170, -6616, -7077, -7544, -8034, -8542, -9054, -9584, -10123, -10686, -11237, -11774, -12303, -12800, -13257, -13627, -13895, -14083, -14130, -14045, -13777, -13344, -12784, -12043, -11141, -10089, -8928, -7673, -6337, -4976, -3594, -2242, -874};