/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0030 256 samples */
 
const int16_t AKWF_aguitar_0030_256_DATA [256] = 
{998, 2522, 3947, 5346, 6671, 7865, 8944, 9899, 10726, 11437, 12024, 12496, 12868, 13169, 13425, 13622, 13724, 13773, 13826, 13830, 13791, 13733, 13643, 13524, 13423, 13349, 13278, 13254, 13316, 13482, 13765, 14141, 14635, 15275, 16045, 16917, 17873, 18886, 19965, 21081, 22176, 23252, 24273, 25206, 26046, 26787, 27373, 27762, 27981, 28030, 27894, 27577, 27102, 26486, 25693, 24768, 23787, 22768, 21699, 20624, 19559, 18559, 17598, 16659, 15805, 15044, 14330, 13695, 13114, 12560, 12066, 11619, 11175, 10727, 10294, 9881, 9464, 9031, 8601, 8172, 7749, 7326, 6883, 6452, 6037, 5602, 5162, 4737, 4303, 3863, 3412, 2947, 2476, 1981, 1439, 847, 209, -473, -1199, -1969, -2772, -3597, -4424, -5267, -6112, -6902, -7665, -8393, -9066, -9663, -10154, -10534, -10845, -11046, -11152, -11143, -11009, -10803, -10525, -10177, -9755, -9282, -8792, -8276, -7735, -7210, -6690, -6131, -5541, -4957, -4363, -3706, -2989, -2236, -1423, -544, 360, 1324, 2342, 3359, 4355, 5324, 6298, 7234, 8099, 8879, 9593, 10255, 10810, 11263, 11642, 11958, 12214, 12397, 12509, 12576, 12606, 12600, 12573, 12532, 12474, 12414, 12373, 12342, 12301, 12277, 12270, 12270, 12261, 12225, 12148, 12033, 11850, 11590, 11252, 10810, 10250, 9558, 8725, 7754, 6627, 5331, 3899, 2331, 647, -1159, -3071, -5019, -7001, -8989, -10946, -12835, -14629, -16315, -17870, -19278, -20552, -21667, -22626, -23447, -24172, -24793, -25301, -25722, -26091, -26432, -26733, -27014, -27291, -27574, -27876, -28209, -28559, -28940, -29362, -29826, -30313, -30799, -31264, -31704, -32087, -32385, -32619, -32749, -32768, -32701, -32521, -32225, -31815, -31314, -30749, -30101, -29361, -28556, -27695, -26775, -25810, -24788, -23704, -22575, -21417, -20216, -18980, -17682, -16343, -15026, -13666, -12297, -10877, -9440, -8014, -6562, -5062, -3560, -2060, -501};