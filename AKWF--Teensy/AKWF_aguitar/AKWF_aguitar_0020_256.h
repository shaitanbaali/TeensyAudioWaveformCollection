/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0020 256 samples */
 
const int16_t AKWF_aguitar_0020_256_DATA [256] = 
{648, 1663, 2633, 3571, 4435, 5166, 5753, 6168, 6382, 6374, 6138, 5691, 5075, 4340, 3557, 2842, 2246, 1831, 1602, 1575, 1731, 2008, 2367, 2789, 3215, 3650, 4119, 4657, 5272, 5994, 6835, 7784, 8810, 9839, 10822, 11689, 12370, 12834, 13053, 13010, 12709, 12148, 11343, 10335, 9177, 7916, 6615, 5356, 4206, 3206, 2322, 1521, 780, 45, -706, -1484, -2293, -3126, -3943, -4681, -5317, -5813, -6115, -6182, -6002, -5611, -5049, -4363, -3672, -3037, -2483, -2052, -1801, -1703, -1718, -1895, -2172, -2531, -2949, -3337, -3637, -3794, -3722, -3377, -2767, -1960, -955, 174, 1378, 2587, 3715, 4729, 5583, 6256, 6675, 6893, 6966, 6953, 6916, 6929, 7084, 7447, 8040, 8741, 9575, 10450, 11271, 12007, 12623, 13194, 13747, 14313, 15012, 15888, 16859, 17919, 19010, 20010, 20930, 21722, 22357, 22876, 23305, 23607, 23774, 23792, 23624, 23354, 23030, 22739, 22554, 22555, 22744, 23076, 23482, 23818, 23989, 23874, 23458, 22733, 21790, 20769, 19722, 18742, 17952, 17346, 16849, 16398, 15893, 15208, 14283, 13104, 11646, 9937, 8017, 5942, 3775, 1655, -377, -2274, -3889, -5141, -6005, -6412, -6389, -6004, -5329, -4470, -3553, -2659, -1905, -1332, -979, -852, -892, -1029, -1184, -1277, -1287, -1231, -1194, -1294, -1672, -2432, -3617, -5211, -7179, -9420, -11793, -14234, -16664, -19099, -21524, -23891, -26158, -28222, -29961, -31310, -32213, -32675, -32766, -32591, -32226, -31746, -31246, -30761, -30244, -29621, -28877, -27992, -26941, -25762, -24501, -23228, -22025, -20938, -19960, -19107, -18338, -17567, -16769, -15886, -14912, -13907, -12909, -11952, -11110, -10454, -9993, -9721, -9654, -9750, -9973, -10300, -10713, -11158, -11570, -11890, -12065, -12094, -11931, -11561, -10998, -10279, -9471, -8608, -7739, -6919, -6156, -5409, -4650, -3880, -3074, -2213, -1300, -311};