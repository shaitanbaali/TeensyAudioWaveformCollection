/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_aguitar_0031 256 samples */
 
const int16_t AKWF_aguitar_0031_256_DATA [256] = 
{-643, -2015, -3286, -4469, -5588, -6601, -7516, -8344, -9060, -9668, -10177, -10571, -10878, -11063, -11158, -11150, -11054, -10892, -10658, -10347, -9997, -9586, -9159, -8699, -8242, -7775, -7328, -6906, -6493, -6129, -5812, -5549, -5326, -5176, -5085, -5072, -5158, -5283, -5513, -5811, -6205, -6680, -7219, -7843, -8523, -9257, -10028, -10845, -11692, -12558, -13400, -14234, -15072, -15872, -16625, -17357, -17997, -18607, -19152, -19633, -20043, -20392, -20688, -20887, -21050, -21121, -21133, -21102, -20980, -20811, -20585, -20283, -19975, -19629, -19232, -18811, -18374, -17900, -17464, -17000, -16544, -16119, -15707, -15332, -14970, -14650, -14354, -14125, -13898, -13719, -13591, -13485, -13466, -13491, -13548, -13676, -13827, -14067, -14384, -14729, -15135, -15621, -15932, -16392, -17023, -17676, -18336, -19016, -19670, -20315, -20940, -21509, -22052, -22514, -22924, -23255, -23489, -23651, -23694, -23643, -23510, -23261, -22908, -22436, -21873, -21173, -20401, -19424, -18611, -17402, -16226, -14933, -13596, -12160, -10659, -9115, -7516, -5856, -4220, -2542, -825, 854, 2564, 4234, 5882, 7516, 9114, 10673, 12202, 13683, 15101, 16447, 17750, 18962, 20093, 21133, 22065, 22888, 23614, 24220, 24708, 25077, 25292, 25432, 25420, 25320, 25085, 24728, 24280, 23756, 23119, 22410, 21639, 20785, 19876, 18920, 17925, 16871, 15822, 14761, 13684, 12615, 11583, 10550, 9576, 8649, 7777, 6985, 6279, 5663, 5125, 4705, 4360, 4133, 4007, 3987, 4048, 4217, 4485, 4854, 5317, 5857, 6488, 7236, 8028, 8897, 9861, 10899, 11976, 13143, 14374, 15625, 16925, 18242, 19546, 20887, 22185, 23470, 24739, 25946, 27084, 28133, 29128, 30014, 30779, 31418, 31950, 32367, 32624, 32760, 32757, 32628, 32337, 31888, 31313, 30589, 29744, 28751, 27652, 26422, 25097, 23684, 22179, 20602, 18972, 17293, 15590, 13865, 12142, 10421, 8699, 7032, 5385, 3793, 2248, 729};