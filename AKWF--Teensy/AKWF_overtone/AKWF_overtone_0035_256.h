/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0035 256 samples */
 
const int16_t AKWF_overtone_0035_256_DATA [256] = 
{19608, 29377, 19282, 14501, 10535, 7602, 5412, 3836, 2649, 1747, 1085, 592, 229, -39, -237, -383, -491, -570, -627, -669, -699, -720, -736, -746, -752, -757, -757, -759, -758, -757, -756, -753, -750, -748, -745, -742, -739, -736, -733, -728, -726, -724, -720, -716, -713, -709, -706, -703, -700, -697, -694, -690, -687, -684, -681, -677, -674, -671, -667, -664, -662, -659, -656, -652, -650, -646, -644, -640, -637, -634, -631, -628, -625, -622, -620, -617, -613, -611, -608, -605, -601, -599, -596, -593, -590, -587, -585, -582, -579, -576, -574, -570, -567, -565, -563, -560, -557, -554, -552, -549, -546, -543, -541, -538, -535, -533, -530, -528, -525, -523, -519, -517, -515, -512, -510, -507, -505, -502, -500, -498, -494, -492, -490, -487, -485, -482, -479, -478, -474, -472, -470, -468, -466, -463, -460, -458, -456, -454, -451, -449, -447, -445, -442, -440, -438, -436, -434, -431, -429, -427, -423, -422, -420, -418, -416, -413, -411, -410, -406, -405, -402, -401, -398, -396, -395, -392, -390, -387, -386, -384, -382, -379, -377, -376, -373, -372, -370, -367, -365, -364, -361, -360, -358, -355, -353, -352, -350, -348, -346, -344, -342, -340, -339, -337, -335, -333, -331, -329, -328, -326, -323, -322, -321, -319, -316, -315, -314, -311, -310, -308, -305, -304, -302, -301, -299, -296, -296, -295, -292, -290, -289, -287, -285, -284, -282, -280, -278, -277, -275, -274, -273, -271, -269, -268, -266, -265, -263, -260, -259, -258, -257, -255, -253, -253, -250, -248, -246, -245, -245, -236, -242, -243, -238, -265, -116, -712};