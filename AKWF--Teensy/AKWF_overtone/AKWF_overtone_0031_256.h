/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0031 256 samples */
 
const int16_t AKWF_overtone_0031_256_DATA [256] = 
{2114, 7578, 10492, 11406, 10868, 9486, 7796, 6197, 4909, 4016, 3494, 3256, 3198, 3221, 3249, 3238, 3171, 3049, 2888, 2705, 2518, 2342, 2182, 2043, 1924, 1819, 1726, 1643, 1564, 1487, 1414, 1342, 1274, 1209, 1149, 1093, 1041, 993, 948, 906, 867, 828, 791, 755, 721, 688, 656, 625, 596, 567, 541, 515, 491, 468, 446, 425, 404, 384, 366, 347, 330, 313, 298, 281, 267, 253, 239, 226, 214, 202, 190, 179, 169, 158, 148, 139, 129, 121, 113, 104, 97, 89, 81, 75, 68, 61, 55, 49, 43, 37, 32, 27, 22, 17, 12, 8, 4, -1, -5, -8, -12, -16, -19, -23, -26, -29, -31, -35, -37, -39, -41, -44, -46, -47, -49, -50, -52, -53, -52, -52, -53, -52, -50, -45, -38, -28, -17, -4, 7, 20, 33, 43, 54, 63, 71, 78, 86, 93, 98, 104, 110, 116, 121, 127, 131, 135, 141, 144, 148, 152, 156, 159, 162, 165, 167, 171, 173, 175, 178, 180, 182, 184, 185, 188, 190, 191, 193, 194, 195, 197, 198, 198, 200, 201, 202, 203, 204, 204, 205, 205, 206, 208, 207, 208, 209, 209, 208, 210, 211, 210, 211, 211, 211, 210, 211, 212, 211, 211, 212, 211, 211, 209, 207, 202, 195, 186, 175, 164, 152, 140, 129, 118, 108, 98, 90, 81, 73, 65, 57, 49, 41, 34, 26, 19, 12, 6, 0, -6, -12, -18, -24, -29, -34, -40, -45, -50, -55, -60, -64, -68, -72, -77, -80, -85, -90, -131, -58, -1197, -8826, -20877, -29708, -32784, -30116, -23160, -14211, -5176};