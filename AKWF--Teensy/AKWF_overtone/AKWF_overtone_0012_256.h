/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0012 256 samples */
 
const int16_t AKWF_overtone_0012_256_DATA [256] = 
{1511, 3819, 6147, 8371, 10420, 12718, 14363, 15333, 18874, 19726, 21767, 22613, 24158, 24425, 25741, 27982, 28625, 29129, 31222, 32186, 30758, 30550, 31061, 31549, 30718, 31748, 29915, 29816, 29499, 29764, 28681, 28272, 27716, 25803, 25276, 24910, 25398, 24479, 23598, 22221, 21636, 20117, 16622, 15814, 14110, 13113, 10716, 10490, 8800, 7711, 5245, 3441, 1979, -355, -1059, -1878, -4922, -6193, -7554, -8701, -11320, -11956, -11670, -14063, -14868, -15545, -15002, -15172, -17953, -17525, -16175, -17134, -17620, -16874, -17443, -16783, -16257, -15964, -16317, -15836, -15785, -15579, -13839, -14053, -13704, -12706, -11542, -12448, -11814, -10892, -10707, -9422, -10001, -9786, -7525, -7990, -9538, -8755, -8031, -9395, -9023, -8239, -8689, -9170, -8470, -9698, -9856, -9584, -9616, -10685, -10839, -11180, -12645, -11921, -11316, -10996, -10712, -12118, -11611, -12352, -12195, -12203, -10505, -8627, -8128, -8371, -7878, -6756, -6247, -5103, -4201, -3806, -1626, -375, -100, 1687, 960, 2970, 4282, 6099, 7904, 7538, 10032, 12407, 14453, 14847, 15301, 17380, 17644, 18068, 19273, 19826, 20781, 20783, 22226, 22988, 22356, 23339, 22523, 25118, 24984, 23359, 23663, 23540, 23820, 21979, 21708, 21671, 20651, 19123, 17080, 14973, 13579, 13939, 11974, 8977, 7200, 6535, 7609, 6991, 7048, 5376, 5343, 5816, 4861, 4953, 4232, 3128, 4560, 3175, 3271, 5423, 2592, 3041, 4351, 3429, 1449, 1857, 573, 147, 233, -69, -540, -1148, -2833, -4381, -4575, -5325, -7032, -7279, -9454, -10348, -10978, -11627, -13391, -12814, -15338, -16234, -16588, -20013, -20386, -20827, -22345, -24306, -26128, -26637, -27263, -27711, -29494, -29670, -29924, -30911, -30685, -31164, -32107, -31745, -31604, -31778, -29515, -29039, -29046, -27103, -25869, -25323, -24976, -22365, -20252, -19906, -17352, -14732, -11617, -10704, -7778, -5343, -3083, -592};