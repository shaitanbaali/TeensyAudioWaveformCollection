/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0024 256 samples */
 
const int16_t AKWF_overtone_0024_256_DATA [256] = 
{288, 1458, 1898, 1899, 2145, 2455, 2824, 3244, 3714, 4223, 4773, 5364, 5993, 6657, 7361, 8102, 8872, 9680, 10523, 11397, 12305, 13248, 14217, 15219, 16250, 17311, 18405, 19521, 20666, 21842, 23035, 24274, 25384, 26431, 27242, 27768, 28264, 28852, 29170, 29382, 29497, 29869, 30458, 31050, 31658, 32270, 32742, 32680, 32182, 30807, 28462, 25811, 14656, -10094, -15060, -17463, -19083, -20097, -20763, -21193, -21457, -21610, -21678, -21684, -21649, -21579, -21490, -21385, -21272, -21156, -21045, -20942, -20851, -20774, -20717, -20688, -20692, -20728, -20812, -20949, -21162, -21466, -21886, -22632, -23560, -22234, -20329, -18606, -16922, -15301, -13741, -12247, -10820, -9453, -8158, -6929, -5765, -4670, -3644, -2686, -1799, -981, -230, 446, 1055, 1594, 2060, 2457, 2785, 3040, 3225, 3340, 3384, 3359, 3264, 3098, 2865, 2562, 2191, 1752, 1245, 673, 31, -638, -1575, -1285, 649, 1913, 2996, 3927, 4736, 5446, 6066, 6604, 7065, 7452, 7774, 8033, 8228, 8366, 8446, 8472, 8446, 8366, 8242, 8066, 7851, 7591, 7292, 6957, 6584, 6178, 5745, 5285, 4802, 4301, 3786, 3259, 2730, 2206, 1692, 1202, 744, 344, 16, -196, -245, -35, 767, 1265, 10726, 24406, 24849, 25076, 24542, 23592, 22357, 20897, 19253, 17461, 15541, 13476, 11698, 9656, 7893, 6460, 5453, 4811, 4451, 4168, 3882, 3475, 2862, 2033, 1016, -129, -1346, -2598, -3849, -5067, -6243, -7369, -8430, -9431, -10370, -11237, -12045, -12783, -13463, -14083, -14639, -15134, -15576, -15955, -16278, -16548, -16764, -16925, -17036, -17091, -17094, -17048, -16954, -16809, -16616, -16373, -16086, -15750, -15370, -14940, -14463, -13943, -13372, -12751, -12083, -11353, -10562, -9598, -8643, -8601, -8632, -8566, -8437, -8240, -7975, -7643, -7245, -6779, -6247, -5650, -4987, -4261, -3472, -2619, -1706, -710};