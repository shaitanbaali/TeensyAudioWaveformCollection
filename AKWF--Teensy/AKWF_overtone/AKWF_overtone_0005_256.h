/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0005 256 samples */
 
const int16_t AKWF_overtone_0005_256_DATA [256] = 
{1957, 5513, 8748, 11767, 14545, 17086, 19367, 21418, 23233, 24799, 26132, 27212, 28044, 28625, 28980, 29085, 28940, 28537, 27903, 27040, 25927, 24574, 22980, 21170, 19107, 16852, 14348, 11619, 8663, 5492, 2109, -1470, -5266, -9271, -13482, -17878, -22463, -27122, -30608, -32340, -32743, -32153, -30812, -28900, -26593, -24062, -21371, -18583, -15832, -13119, -10502, -8016, -5651, -3466, -1464, 367, 2028, 3477, 4758, 5852, 6767, 7503, 8083, 8492, 8737, 8842, 8828, 8668, 8399, 8014, 7525, 6962, 6302, 5577, 4780, 3960, 3076, 2166, 1240, 298, -647, -1576, -2484, -3366, -4202, -4981, -5721, -6382, -6961, -7450, -7848, -8141, -8308, -8365, -8269, -8064, -7704, -7174, -6490, -5643, -4621, -3430, -2058, -521, 1216, 3097, 5150, 7366, 9739, 12198, 14782, 17404, 20059, 22682, 25154, 27439, 29414, 30913, 31757, 31755, 30630, 28002, 23670, 18818, 14223, 9817, 5638, 1691, -2014, -5497, -8743, -11769, -14546, -17088, -19367, -21419, -23233, -24800, -26133, -27214, -28045, -28626, -28981, -29086, -28941, -28538, -27904, -27042, -25928, -24576, -22983, -21172, -19110, -16855, -14349, -11621, -8665, -5494, -2114, 1477, 5267, 9267, 13479, 17875, 22461, 27121, 30607, 32340, 32748, 32151, 30811, 28899, 26590, 24060, 21369, 18581, 15829, 13117, 10501, 8012, 5651, 3468, 1460, -370, -2031, -3480, -4760, -5855, -6769, -7505, -8086, -8495, -8740, -8844, -8832, -8671, -8402, -8016, -7528, -6964, -6304, -5579, -4783, -3962, -3079, -2169, -1243, -299, 645, 1574, 2483, 3365, 4200, 4979, 5719, 6379, 6958, 7447, 7846, 8139, 8306, 8363, 8267, 8063, 7702, 7173, 6488, 5643, 4620, 3429, 2057, 519, -1216, -3100, -5158, -7367, -9741, -12199, -14784, -17404, -20061, -22684, -25155, -27440, -29415, -30913, -31758, -31760, -30630, -28003, -23672, -18819, -14224, -9825, -5652, -1656};