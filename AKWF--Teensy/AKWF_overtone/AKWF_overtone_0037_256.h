/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0037 256 samples */
 
const int16_t AKWF_overtone_0037_256_DATA [256] = 
{102, 355, 534, 665, 757, 827, 874, 909, 931, 943, 952, 955, 955, 953, 948, 943, 937, 930, 924, 914, 906, 899, 890, 882, 874, 865, 857, 849, 841, 833, 824, 816, 808, 800, 793, 786, 777, 771, 764, 756, 748, 742, 733, 726, 718, 713, 704, 697, 692, 683, 676, 670, 663, 656, 649, 643, 637, 630, 624, 617, 611, 605, 599, 593, 587, 580, 575, 569, 562, 557, 552, 547, 541, 535, 529, 523, 518, 513, 507, 502, 496, 491, 487, 481, 475, 471, 465, 460, 455, 450, 446, 441, 437, 431, 427, 423, 418, 413, 410, 406, 401, 396, 392, 387, 383, 379, 374, 369, 367, 363, 358, 354, 351, 345, 342, 338, 332, 330, 325, 323, 319, 315, 312, 309, 305, 302, 297, 295, 291, 287, 285, 281, 278, 275, 271, 269, 265, 261, 260, 255, 253, 250, 246, 245, 240, 237, 233, 229, 229, 224, 221, 219, 216, 214, 212, 207, 207, 202, 201, 200, 194, 196, 199, 455, -949, 9704, 31228, 25007, 17483, 12660, 8935, 6165, 4123, 2611, 1493, 671, 63, -380, -707, -946, -1115, -1239, -1327, -1386, -1429, -1454, -1469, -1478, -1478, -1477, -1471, -1462, -1453, -1442, -1431, -1419, -1405, -1393, -1380, -1366, -1354, -1339, -1327, -1314, -1300, -1288, -1275, -1261, -1250, -1236, -1224, -1211, -1198, -1187, -1172, -1161, -1150, -1136, -1124, -1113, -1099, -1089, -1077, -1065, -1055, -1042, -1032, -1022, -1009, -1002, -990, -979, -970, -957, -950, -940, -927, -922, -910, -901, -904, -1132, 186, -9922, -31652, -25829, -18232, -13396, -9633, -6860, -4792, -3264, -2139, -1300, -684, -225};