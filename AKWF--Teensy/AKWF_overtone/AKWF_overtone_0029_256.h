/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0029 256 samples */
 
const int16_t AKWF_overtone_0029_256_DATA [256] = 
{661, 1625, 2545, 3337, 3761, 3582, 2885, 2143, 1643, 1291, 1043, 1170, 1860, 3103, 4847, 6660, 8129, 9516, 10837, 11476, 11089, 10035, 9056, 8642, 8717, 8805, 8669, 8354, 7979, 7757, 7909, 8466, 9668, 12142, 15850, 19622, 22215, 23349, 22797, 20045, 15475, 10489, 6640, 4978, 5337, 6247, 6208, 4433, 614, -5092, -11920, -18793, -24646, -28652, -30942, -32275, -32772, -32119, -30470, -28480, -26902, -26135, -25875, -25436, -24424, -22853, -20666, -17817, -14835, -12426, -10724, -9338, -7600, -5151, -2451, -398, 420, 18, -1152, -2412, -3127, -2745, -872, 2210, 5512, 8144, 9866, 10806, 11051, 10618, 9753, 9079, 9276, 10731, 13368, 16676, 19929, 22472, 23790, 23534, 21800, 19278, 16872, 15083, 13807, 12724, 11570, 10079, 7981, 5165, 1829, -1547, -4600, -7328, -9886, -12452, -15051, -17433, -19306, -20448, -20585, -19609, -17814, -15723, -13810, -12369, -11430, -10866, -10554, -10335, -9952, -9108, -7609, -5483, -2981, -490, 1493, 2422, 2062, 795, -543, -1169, -685, 968, 3489, 6201, 8439, 9971, 10888, 11328, 11480, 11570, 11706, 11858, 12080, 12571, 13373, 14394, 15553, 16625, 17159, 16893, 15960, 14583, 12924, 11084, 9101, 6983, 4745, 2543, 571, -1096, -2468, -3652, -4953, -6690, -8898, -11367, -13688, -15342, -15970, -15538, -14256, -12466, -10579, -8925, -7654, -6744, -6107, -5702, -5444, -5102, -4445, -3427, -2116, -581, 1021, 2309, 2843, 2495, 1504, 235, -916, -1687, -2040, -2006, -1651, -1121, -538, 71, 720, 1428, 2094, 2503, 2598, 2585, 2797, 3456, 4585, 6116, 7928, 9707, 10995, 11567, 11467, 10741, 9403, 7539, 5324, 3027, 955, -668, -1816, -2631, -3300, -4097, -5342, -7092, -9060, -10856, -12046, -12376, -11959, -11045, -9809, -8365, -6927, -5786, -4948, -4228, -3597, -3042, -2554, -2054, -1316, -316};