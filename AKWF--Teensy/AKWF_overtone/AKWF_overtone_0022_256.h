/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0022 256 samples */
 
const int16_t AKWF_overtone_0022_256_DATA [256] = 
{7442, 6507, 5584, 4998, 2212, 11515, 22669, 19769, 19110, 18095, 17082, 16107, 14949, 14283, 30193, 31820, 30082, 29139, 28072, 27014, 25958, 24907, 23865, 22825, 21796, 20775, 19760, 18757, 17765, 16779, 15808, 14848, 13897, 12963, 12040, 11129, 10236, 9357, 8490, 7644, 6811, 5994, 5197, 4415, 3650, 2906, 2180, 1472, 786, 118, -528, -1154, -1761, -2345, -2908, -3451, -3970, -4467, -4942, -5394, -5823, -6230, -6612, -6972, -7308, -7620, -7908, -8174, -8415, -8632, -8824, -8991, -9137, -9257, -9353, -9426, -9473, -9497, -9496, -9471, -9423, -9352, -9257, -9139, -8997, -8829, -8643, -8432, -8197, -7942, -7664, -7363, -7042, -6699, -6334, -5951, -5543, -5118, -4672, -4207, -3723, -3219, -2797, -1732, -3216, -19691, -19897, -18972, -18345, -17648, -16931, -16202, -15459, -14699, -13929, -13146, -12350, -11541, -10725, -9896, -9056, -8209, -7352, -6486, -5615, -4733, -3847, -2955, -2055, -1153, -245, 666, 1579, 2496, 3417, 4337, 5259, 6182, 7102, 8024, 8945, 9862, 10779, 11691, 12599, 13506, 14407, 15301, 16191, 17075, 17951, 18822, 19684, 20537, 21383, 22219, 23045, 23863, 24667, 25461, 26246, 27016, 27776, 28523, 29254, 29973, 30679, 31180, 32921, 28913, 13408, 14844, 15053, 17589, 7155, -3525, -964, -672, -43, 566, 1158, 1377, 3825, -7520, -17484, -15064, -14882, -14369, -13880, -13411, -12964, -12538, -12132, -11751, -11392, -11055, -10742, -10451, -10182, -9938, -9716, -9516, -9340, -9189, -9060, -8953, -8872, -8812, -8776, -8765, -8775, -8809, -8865, -8947, -9048, -9174, -9321, -9491, -9684, -9897, -10133, -10391, -10671, -10970, -11291, -11632, -11994, -12377, -12777, -13197, -13639, -14097, -14575, -15070, -15582, -16114, -16661, -17224, -17804, -18402, -19012, -19585, -20444, -20414, -4062, -2548, -3874, -4532, -5311, -6099, -6899, -7710, -8529, -9358, -10193, -11054};