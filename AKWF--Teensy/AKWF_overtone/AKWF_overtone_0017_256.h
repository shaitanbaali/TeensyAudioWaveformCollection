/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0017 256 samples */
 
const int16_t AKWF_overtone_0017_256_DATA [256] = 
{1675, 4422, 7412, 10055, 12189, 14266, 16110, 17509, 18659, 19575, 20132, 20391, 20409, 20145, 19611, 18861, 17899, 16734, 15406, 13943, 12353, 10672, 8932, 7145, 5344, 3555, 1791, 82, -1553, -3105, -4548, -5873, -7070, -8125, -9035, -9795, -10399, -10848, -11146, -11293, -11295, -11160, -10895, -10509, -10014, -9421, -8741, -7987, -7176, -6314, -5419, -4506, -3582, -2664, -1762, -885, -46, 745, 1486, 2166, 2777, 3318, 3784, 4173, 4483, 4713, 4866, 4942, 4944, 4877, 4743, 4548, 4297, 3996, 3653, 3271, 2860, 2426, 1975, 1514, 1050, 588, 136, -300, -719, -1113, -1479, -1814, -2112, -2374, -2598, -2781, -2923, -3024, -3085, -3106, -3088, -3035, -2948, -2828, -2681, -2508, -2311, -2096, -1865, -1623, -1372, -1116, -858, -602, -350, -106, 127, 349, 556, 746, 920, 1073, 1207, 1320, 1411, 1482, 1532, 1562, 1572, 1564, 1537, 1495, 1438, 1367, 1285, 1193, 1093, 986, 876, 763, 648, 535, 424, 316, 213, 117, 28, -52, -124, -187, -238, -280, -312, -332, -343, -342, -333, -314, -287, -251, -208, -159, -105, -46, 17, 83, 150, 219, 287, 355, 421, 485, 545, 602, 655, 703, 746, 785, 817, 843, 864, 878, 887, 890, 887, 880, 868, 851, 829, 804, 777, 746, 713, 677, 641, 604, 566, 529, 491, 455, 419, 386, 354, 324, 296, 270, 247, 227, 210, 195, 183, 172, 165, 160, 157, 156, 156, 159, 163, 168, 173, 180, 187, 193, 200, 207, 213, 218, 223, 227, 229, 230, 230, 228, 225, 221, 215, 207, 199, 188, 176, 163, 149, 133, 116, -138, 996, -6856, -29923, -31324, -29305, -30801, -25226, -20375, -19292, -15706, -10986, -8267, -5260, -1308};