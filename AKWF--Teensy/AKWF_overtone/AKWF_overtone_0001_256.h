/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0001 256 samples */
 
const int16_t AKWF_overtone_0001_256_DATA [256] = 
{2683, 6628, 10386, 13978, 17337, 20412, 23174, 25583, 27639, 29333, 30665, 31659, 32325, 32684, 32762, 32588, 32181, 31560, 30758, 29795, 28688, 27459, 26126, 24702, 23206, 21651, 20045, 18402, 16736, 15049, 13353, 11658, 9963, 8283, 6620, 4980, 3367, 1787, 237, -1264, -2731, -4149, -5518, -6838, -8105, -9313, -10468, -11565, -12599, -13570, -14479, -15321, -16101, -16813, -17458, -18035, -18542, -18982, -19349, -19647, -19877, -20037, -20126, -20143, -20091, -19970, -19779, -19520, -19191, -18794, -18331, -17801, -17205, -16542, -15819, -15034, -14181, -13275, -12305, -11279, -10202, -9068, -7882, -6647, -5363, -4034, -2666, -1253, 194, 1673, 3184, 4725, 6282, 7863, 9456, 11057, 12662, 14263, 15854, 17431, 18979, 20497, 21975, 23395, 24751, 26034, 27223, 28308, 29272, 30093, 30760, 31246, 31531, 31591, 31409, 30958, 30215, 29160, 27778, 26050, 23980, 21563, 18803, 15737, 12392, 8804, 5048, 1181, -2733, -6607, -10375, -13974, -17333, -20410, -23172, -25580, -27634, -29328, -30662, -31655, -32324, -32683, -32762, -32585, -32179, -31561, -30758, -29795, -28689, -27459, -26124, -24702, -23206, -21652, -20045, -18405, -16739, -15050, -13355, -11659, -9966, -8289, -6624, -4982, -3372, -1793, -242, 1261, 2725, 4144, 5512, 6832, 8100, 9310, 10463, 11559, 12593, 13564, 14474, 15316, 16094, 16808, 17450, 18028, 18533, 18972, 19343, 19640, 19870, 20029, 20117, 20136, 20083, 19964, 19770, 19512, 19183, 18786, 18324, 17790, 17195, 16535, 15812, 15023, 14173, 13267, 12297, 11271, 10193, 9058, 7872, 6639, 5354, 4024, 2655, 1245, -204, -1681, -3195, -4734, -6290, -7871, -9463, -11065, -12670, -14270, -15863, -17441, -18989, -20507, -21985, -23403, -24760, -26040, -27232, -28317, -29278, -30100, -30767, -31252, -31539, -31599, -31418, -30967, -30222, -29167, -27785, -26057, -23983, -21568, -18808, -15741, -12399, -8817, -5070, -1133};