/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0043 256 samples */
 
const int16_t AKWF_overtone_0043_256_DATA [256] = 
{2624, 8125, 13452, 18463, 22914, 26639, 29522, 31489, 32548, 32745, 32166, 30925, 29153, 26985, 24550, 21971, 19351, 16764, 14267, 11908, 9682, 7597, 5642, 3780, 1990, 243, -1490, -3227, -4977, -6741, -8509, -10258, -11965, -13593, -15101, -16451, -17598, -18508, -19152, -19498, -19532, -19249, -18649, -17742, -16549, -15100, -13420, -11549, -9532, -7399, -5191, -2946, -689, 1542, 3706, 5767, 7655, 9281, 10537, 11303, 11472, 10988, 9855, 8151, 6020, 3660, 1271, -953, -2833, -4253, -5144, -5481, -5295, -4654, -3664, -2437, -1103, 212, 1405, 2381, 3071, 3434, 3461, 3161, 2567, 1736, 738, -358, -1474, -2528, -3461, -4205, -4716, -4968, -4939, -4631, -4053, -3228, -2187, -975, 370, 1804, 3285, 4765, 6217, 7612, 8919, 10125, 11218, 12183, 13016, 13706, 14246, 14617, 14799, 14767, 14491, 13945, 13107, 11974, 10562, 8937, 7181, 5421, 3769, 2313, 1098, 89, -792, -1661, -2645, -3874, -5418, -7337, -9628, -12232, -15074, -18028, -20946, -23688, -26102, -28042, -29408, -30111, -30095, -29344, -27870, -25731, -22986, -19739, -16113, -12209, -8170, -4116, -151, 3607, 7077, 10194, 12899, 15164, 16977, 18333, 19258, 19776, 19925, 19751, 19301, 18621, 17756, 16754, 15653, 14483, 13279, 12066, 10863, 9687, 8556, 7480, 6478, 5559, 4736, 4019, 3413, 2899, 2441, 1976, 1412, 643, -423, -1856, -3642, -5706, -7922, -10104, -12068, -13636, -14661, -15050, -14750, -13775, -12180, -10063, -7557, -4800, -1948, 843, 3450, 5758, 7672, 9146, 10141, 10661, 10735, 10404, 9731, 8786, 7650, 6399, 5101, 3823, 2614, 1513, 548, -274, -957, -1514, -1969, -2351, -2698, -3048, -3434, -3889, -4443, -5117, -5922, -6867, -7950, -9151, -10461, -11844, -13271, -14700, -16087, -17382, -18541, -19509, -20229, -20641, -20661, -20195, -19134, -17370, -14821, -11458, -7337, -2460};