/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0004 256 samples */
 
const int16_t AKWF_overtone_0004_256_DATA [256] = 
{13201, 29567, 32130, 32690, 32648, 32153, 31466, 30670, 29815, 28929, 28030, 27127, 26225, 25329, 24436, 23550, 22672, 21800, 20936, 20082, 19236, 18400, 17573, 16754, 15946, 15150, 14361, 13585, 12821, 12066, 11325, 10595, 9875, 9170, 8477, 7794, 7128, 6472, 5830, 5203, 4589, 3988, 3402, 2829, 2271, 1727, 1197, 681, 183, -302, -774, -1228, -1669, -2095, -2505, -2900, -3281, -3646, -3996, -4331, -4650, -4956, -5245, -5519, -5781, -6024, -6253, -6468, -6668, -6853, -7026, -7181, -7323, -7453, -7566, -7666, -7754, -7826, -7885, -7931, -7964, -7985, -7991, -7986, -7970, -7940, -7899, -7847, -7782, -7707, -7621, -7525, -7418, -7300, -7172, -7037, -6890, -6735, -6572, -6399, -6219, -6032, -5835, -5633, -5423, -5207, -4984, -4756, -4522, -4282, -4038, -3789, -3535, -3278, -3018, -2753, -2485, -2216, -1945, -1670, -1394, -1118, -839, -560, -281, -3, 274, 551, 830, 1105, 1378, 1649, 1918, 2185, 2448, 2707, 2963, 3216, 3463, 3706, 3944, 4177, 4403, 4625, 4841, 5051, 5253, 5448, 5638, 5818, 5992, 6159, 6315, 6464, 6605, 6736, 6859, 6972, 7074, 7169, 7254, 7328, 7391, 7444, 7487, 7519, 7539, 7550, 7549, 7535, 7511, 7475, 7427, 7369, 7297, 7214, 7119, 7011, 6892, 6760, 6615, 6458, 6290, 6107, 5913, 5708, 5488, 5257, 5013, 4757, 4489, 4208, 3914, 3608, 3290, 2959, 2617, 2261, 1896, 1518, 1127, 726, 312, -112, -548, -995, -1454, -1924, -2403, -2894, -3396, -3907, -4429, -4962, -5503, -6054, -6614, -7184, -7762, -8351, -8946, -9551, -10165, -10783, -11414, -12050, -12692, -13343, -13998, -14661, -15332, -16007, -16687, -17376, -18068, -18763, -19465, -20171, -20883, -21597, -22313, -23034, -23757, -24481, -25206, -25928, -26642, -27340, -28004, -28606, -29097, -29395, -29240, -28488, -25741, -9252};