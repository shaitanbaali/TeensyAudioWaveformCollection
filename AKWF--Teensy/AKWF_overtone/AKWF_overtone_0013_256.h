/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0013 256 samples */
 
const int16_t AKWF_overtone_0013_256_DATA [256] = 
{515, 1354, 1887, 1749, 1263, 1059, 1511, 2566, 3888, 5190, 6149, 6899, 7638, 8689, 9376, 9722, 9469, 8978, 8408, 7878, 7483, 6955, 6385, 5542, 4504, 3757, 2651, 1338, 489, 255, 1446, 2509, 2738, 3487, 5586, 8889, 11557, 12541, 12774, 13519, 15157, 16489, 16656, 17336, 18480, 18943, 22293, 22282, 20743, 22064, 22391, 22710, 23373, 24145, 25018, 24756, 24825, 24740, 22935, 20563, 17607, 14743, 12079, 9076, 4588, 67, -2057, -2658, -4700, -7147, -7715, -7268, -6129, -4207, -3558, -4586, -5797, -7228, -9219, -11409, -12330, -13432, -16078, -19506, -23647, -28550, -32134, -32584, -31576, -31291, -31296, -31166, -30826, -30432, -29577, -27755, -25051, -21925, -19616, -18347, -18358, -17798, -14323, -8093, -1574, 2508, 4926, 7554, 9881, 11582, 13817, 15521, 15469, 13324, 10718, 7953, 4549, 862, -1934, -3762, -5059, -5543, -6217, -7338, -7233, -5373, -2697, 102, 1782, 2663, 3435, 4145, 4701, 4921, 5064, 5248, 5160, 4765, 3390, 1045, -541, -1808, -3336, -4338, -5172, -4975, -4050, -3042, -972, 1394, 3130, 4982, 6758, 7859, 8508, 9037, 9498, 10094, 11663, 13694, 15258, 16344, 17365, 18168, 18682, 18773, 18111, 16828, 14700, 11373, 7944, 5182, 2775, 716, -1629, -4392, -6686, -8279, -9414, -10191, -10121, -9199, -7464, -5307, -3228, -1200, 883, 3609, 6760, 10437, 13873, 16059, 16697, 16623, 16720, 16807, 15976, 13983, 10890, 7500, 4774, 2713, 607, -1958, -3986, -5107, -5325, -4811, -3800, -2164, -167, 1515, 3180, 4684, 5645, 6561, 7215, 7248, 6967, 5973, 4396, 2421, -214, -2983, -6012, -9324, -12492, -15187, -17559, -19497, -20873, -21700, -22053, -21985, -21846, -22337, -22921, -23155, -23211, -23437, -23465, -23741, -23660, -22974, -22024, -20834, -19396, -17806, -15718, -13013, -10299, -7738, -5428, -3456, -1747, -563};