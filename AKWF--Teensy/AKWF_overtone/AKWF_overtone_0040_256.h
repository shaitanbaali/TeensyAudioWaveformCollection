/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0040 256 samples */
 
const int16_t AKWF_overtone_0040_256_DATA [256] = 
{932, 2222, 2447, 2101, 1678, 1623, 2331, 4052, 6542, 9078, 11076, 12415, 13184, 13438, 13193, 12635, 12330, 11669, 11542, 12786, 14563, 16351, 17680, 18182, 17625, 16109, 14146, 12360, 11051, 10186, 7347, 5411, 3318, 1186, -1313, -4066, -6747, -9152, -11293, -13287, -15272, -17237, -18998, -20367, -21179, -21245, -20513, -19200, -17791, -15517, -13298, -11722, -8738, -6678, -5677, -4996, -4253, -3193, -1774, -144, 1452, 2689, 3079, 3206, 3431, 3110, 3208, 4007, 5549, 7616, 9719, 11418, 12588, 13302, 13659, 13799, 13879, 13964, 14031, 14117, 14474, 14048, 13407, 13425, 13463, 13200, 12453, 11318, 9945, 8437, 6852, 5222, 3544, 1849, 141, -737, -846, -375, -6047, -11759, -12651, -14691, -16710, -18547, -19852, -20386, -20150, -19304, -18042, -16991, -15067, -1627, 736, -140, -1053, -1566, -1898, -1900, -1572, -980, -180, 702, 1383, 1560, 1173, 418, -563, -781, -23, 461, 1099, 1870, 2688, 3492, 4271, 5041, 5817, 6519, 6997, 7234, 7385, 7686, 8281, 9158, 10381, 10790, 10787, 10978, 10767, 10194, 9256, 7951, 6345, 4554, 2772, 1211, 11, -759, -3396, -4977, -6571, -8096, -9828, -11604, -13166, -14234, -14654, -14530, -14040, -13303, -12404, -11499, -10792, -10260, -9780, -9325, -8998, -7703, -6099, -4613, -1308, 1246, 2752, 3787, 4438, 4666, 4391, 3752, 3108, 2671, 2251, 2549, 3819, 4927, 6309, 7936, 9503, 10780, 11972, 13048, 13572, 13344, 12663, 12046, 11813, 11868, 11877, 11687, 11448, 10180, 8677, 8012, 7739, 8058, 9378, 11585, 13794, 15184, 15601, 14851, 12592, 9189, 5551, 3457, 3485, 5242, 1011, -3893, -4905, -8185, -12572, -17630, -22624, -26792, -29598, -31224, -32122, -32665, -31346, -17569, -14435, -14681, -15378, -15896, -16144, -15882, -15151, -13915, -12174, -10336, -8879, -7863, -6980, -5751, -4084, -1612};