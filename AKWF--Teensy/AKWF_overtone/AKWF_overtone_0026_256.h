/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0026 256 samples */
 
const int16_t AKWF_overtone_0026_256_DATA [256] = 
{1194, 3373, 4836, 5840, 6484, 6867, 7048, 7085, 7018, 6877, 6688, 6471, 6239, 6003, 5770, 5549, 5347, 5162, 5018, 4819, 4978, 7717, 9534, 10754, 11811, 12721, 13526, 14250, 14899, 15492, 16032, 16524, 16972, 17379, 17748, 18083, 18383, 18654, 18892, 19099, 19282, 19436, 19561, 19662, 19736, 19786, 19812, 19812, 19790, 19745, 19675, 19584, 19472, 19335, 19132, 19183, 17286, 14021, 12101, 10449, 9014, 7720, 6540, 5454, 4446, 3508, 2634, 1813, 1050, 340, -324, -938, -1510, -2037, -2518, -2957, -3356, -3712, -4028, -4303, -4537, -4732, -4871, -5053, -4857, -2023, -134, 1149, 2044, 4240, 52, -25085, -25765, -26412, -27112, -27723, -28289, -28813, -29298, -29745, -30159, -30536, -30883, -31198, -31483, -31737, -31961, -32156, -32326, -32466, -32578, -32667, -32726, -32622, -33189, -31418, 12577, 18450, 16956, 17471, 15758, 12678, 10937, 9471, 8215, 7104, 6105, 5197, 4364, 3605, 2904, 2259, 1670, 1130, 636, 192, -210, -570, -886, -1163, -1399, -1594, -1753, -1872, -1952, -1996, -1984, -2019, -1672, 1306, 3327, 4753, 6010, 7119, 8130, 9061, 9924, 10733, 11491, 12203, 12878, 13513, 14113, 14680, 15216, 15722, 16198, 16646, 17067, 17461, 17828, 18170, 18487, 18780, 19048, 19292, 19510, 19706, 19879, 20026, 20152, 20255, 20288, 20573, 18888, 15875, 14180, 12759, 11547, 10477, 9518, 8652, 7856, 7134, 6467, 5853, 5296, 4783, 4315, 3894, 3512, 3171, 2872, 2610, 2387, 2200, 2050, 1938, 1715, 2464, -4199, -7762, -7145, -10069, -11900, -13123, -14185, -15100, -15918, -16658, -17329, -17947, -18516, -19040, -19530, -19982, -20400, -20788, -21145, -21475, -21780, -22057, -22309, -22538, -22742, -22925, -23086, -23224, -23341, -23437, -23512, -23567, -23601, -23616, -23612, -23588, -23498, -23664, -21865, -18734, -16936, -15354, -14313, -11395, -5737, -1681};