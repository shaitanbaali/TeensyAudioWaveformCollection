/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0033 256 samples */
 
const int16_t AKWF_overtone_0033_256_DATA [256] = 
{3178, 7780, 9982, 10407, 9619, 8194, 6609, 5197, 4124, 3429, 3070, 2948, 2966, 3032, 3084, 3088, 3034, 2930, 2790, 2634, 2477, 2331, 2203, 2092, 1998, 1918, 1847, 1781, 1719, 1657, 1597, 1538, 1478, 1422, 1366, 1315, 1267, 1220, 1176, 1135, 1096, 1059, 1024, 990, 957, 926, 896, 868, 841, 815, 790, 767, 745, 724, 704, 685, 667, 649, 632, 616, 601, 587, 573, 559, 546, 535, 524, 513, 503, 492, 483, 475, 466, 457, 450, 442, 435, 429, 422, 416, 410, 404, 400, 395, 390, 386, 382, 377, 374, 371, 368, 364, 361, 358, 356, 353, 350, 349, 345, 344, 343, 341, 339, 338, 337, 336, 335, 333, 333, 332, 331, 330, 331, 331, 330, 329, 329, 329, 330, 329, 327, 324, 319, 311, 301, 288, 271, 253, 235, 217, 201, 185, 170, 156, 143, 131, 120, 110, 99, 89, 80, 70, 61, 53, 46, 38, 30, 23, 17, 10, 4, -2, -6, -11, -16, -21, -26, -30, -35, -39, -42, -46, -50, -53, -56, -59, -62, -66, -68, -71, -73, -75, -77, -79, -82, -84, -85, -87, -89, -90, -91, -94, -95, -96, -97, -98, -100, -101, -101, -102, -103, -104, -104, -106, -107, -107, -108, -109, -108, -109, -110, -109, -110, -110, -111, -111, -110, -111, -113, -112, -113, -114, -113, -112, -113, -112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -113, -112, -110, -111, -110, -110, -111, -110, -109, -109, -110, -109, -108, -109, -108, -108, -107, -108, -182, 191, -2611, -13284, -24387, -31376, -32541, -28335, -20695, -11791, -3322};