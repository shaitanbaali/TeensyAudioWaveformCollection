/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0008 256 samples */
 
const int16_t AKWF_overtone_0008_256_DATA [256] = 
{72, 256, 438, 623, 809, 997, 1187, 1377, 1569, 1763, 1957, 2151, 2348, 2544, 2741, 2939, 3137, 3335, 3534, 3732, 3930, 4127, 4324, 4521, 4716, 4912, 5107, 5300, 5493, 5684, 5874, 6062, 6249, 6433, 6617, 6799, 6978, 7155, 7330, 7503, 7674, 7843, 8008, 8171, 8331, 8488, 8642, 8793, 8941, 9085, 9228, 9366, 9501, 9632, 9760, 9884, 10005, 10122, 10236, 10344, 10449, 10551, 10649, 10741, 10831, 10915, 10995, 11072, 11145, 11213, 11276, 11336, 11391, 10845, 14078, -3302, -34481, -32172, -32332, -32218, -32062, -31911, -31763, -31622, -31485, -31352, -31226, -31103, -30988, -30876, -30769, -30669, -30575, -30486, -30402, -30324, -30253, -30186, -30125, -29569, -32189, -18300, 15188, 14104, 14056, 14014, 13890, 13762, 13627, 13488, 13342, 13191, 13035, 12875, 12708, 12537, 12363, 12183, 12000, 11812, 11621, 11425, 11226, 11023, 10817, 10608, 10396, 10180, 9962, 9741, 9518, 9292, 9065, 8834, 8602, 8370, 8133, 7897, 7660, 7420, 7180, 6939, 6697, 6456, 6213, 5970, 5726, 5484, 5241, 4998, 4757, 4515, 4274, 4035, 3796, 3558, 3322, 3088, 2854, 2623, 2394, 2166, 1942, 1717, 1497, 1279, 1063, 851, 641, 433, 229, 30, -166, -359, -550, -736, -918, -1098, -1274, -1443, -1611, -1773, -1931, -2086, -2234, -2379, -2519, -2654, -2785, -2911, -3032, -3147, -3258, -3365, -3466, -3561, -3651, -3737, -3816, -3892, -3961, -4026, -4084, -4137, -4186, -4228, -4264, -4297, -4323, -4343, -4359, -4369, -4374, -4373, -4367, -4355, -4338, -4316, -4289, -4257, -4218, -4175, -4127, -4074, -4016, -3952, -3884, -3812, -3733, -3651, -3564, -3472, -3375, -3275, -3169, -3059, -2946, -2828, -2706, -2581, -2450, -2317, -2179, -2037, -1894, -1746, -1594, -1440, -1283, -1122, -959, -793, -624, -452, -279, -99};