/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0018 256 samples */
 
const int16_t AKWF_overtone_0018_256_DATA [256] = 
{2564, 6782, 11007, 14822, 18020, 20916, 23376, 25211, 26565, 27462, 27816, 27683, 27132, 26159, 24794, 23108, 21141, 18920, 16510, 13965, 11311, 8608, 5905, 3225, 619, -1877, -4244, -6445, -8458, -10270, -11859, -13216, -14338, -15217, -15854, -16255, -16423, -16370, -16106, -15647, -15007, -14203, -13259, -12188, -11013, -9757, -8437, -7073, -5691, -4302, -2929, -1592, -299, 929, 2080, 3147, 4116, 4979, 5733, 6371, 6891, 7293, 7576, 7742, 7796, 7741, 7582, 7330, 6990, 6571, 6081, 5533, 4934, 4294, 3627, 2938, 2239, 1542, 853, 181, -463, -1076, -1651, -2179, -2659, -3084, -3452, -3763, -4012, -4200, -4327, -4395, -4405, -4360, -4263, -4116, -3925, -3693, -3426, -3128, -2805, -2462, -2102, -1734, -1361, -986, -618, -258, 88, 417, 726, 1013, 1273, 1506, 1710, 1882, 2024, 2135, 2214, 2263, 2282, 2274, 2237, 2176, 2092, 1987, 1863, 1724, 1572, 1409, 1239, 1063, 885, 707, 531, 361, 196, 40, -104, -238, -359, -465, -557, -633, -694, -738, -767, -781, -780, -764, -735, -692, -638, -576, -503, -422, -335, -243, -147, -50, 48, 146, 243, 337, 427, 512, 592, 666, 731, 790, 841, 883, 916, 941, 959, 966, 967, 960, 945, 923, 896, 863, 824, 782, 736, 687, 636, 584, 530, 477, 423, 372, 322, 274, 229, 186, 148, 112, 81, 53, 30, 10, -4, -15, -22, -27, -27, -23, -18, -9, 1, 14, 28, 44, 60, 77, 94, 112, 128, 143, 159, 172, 184, 194, 203, 209, 214, 216, 215, 213, 209, 202, 193, 183, 170, 156, 140, 123, 105, 85, 64, -147, 726, -5396, -25037, -29318, -30012, -32872, -29592, -25747, -24230, -20459, -15282, -11304, -7017, -1837};