/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0028 256 samples */
 
const int16_t AKWF_overtone_0028_256_DATA [256] = 
{2213, 4550, 3766, 4067, 7573, 12595, 17179, 21090, 24280, 25698, 24727, 22268, 19355, 16352, 14105, 13775, 14659, 14452, 12198, 8895, 5221, 1082, -2949, -5734, -6717, -6248, -5221, -4564, -4650, -5432, -6782, -8005, -7958, -6459, -4116, -1182, 1892, 4049, 4799, 4836, 4963, 5459, 6630, 8796, 11412, 13238, 13545, 12590, 11104, 9582, 8243, 7412, 7246, 7252, 6742, 5568, 4033, 2414, 831, -672, -2058, -3077, -3409, -3147, -2874, -3144, -4011, -5051, -5624, -5280, -4147, -2779, -1568, -677, 7, 661, 982, 798, 859, 1819, 3242, 4427, 5089, 5044, 4472, 4116, 4164, 3833, 3001, 2631, 2901, 2559, 914, -990, -1876, -1824, -1790, -2177, -2489, -2282, -1999, -2462, -3619, -4532, -4727, -4465, -3846, -3018, -2582, -2495, -2030, -1434, -1800, -2808, -2745, -1282, 44, 485, 774, 1207, 1434, 1590, 1715, 1228, 416, 525, 1486, 1934, 1514, 1121, 1011, 556, -272, -906, -1354, -1823, -1831, -1284, -1061, -1468, -1877, -2153, -2486, -2490, -2095, -1876, -1839, -1424, -661, -107, 73, 176, 540, 1094, 1481, 1801, 2390, 3135, 3514, 3434, 3490, 3826, 3998, 3924, 3925, 3974, 3889, 3781, 3836, 3889, 3531, 2604, 1506, 892, 1014, 1462, 1755, 1716, 1341, 859, 759, 1115, 1327, 1099, 999, 1374, 1607, 1366, 1372, 1846, 1990, 1785, 2214, 3260, 3800, 3632, 3737, 4379, 4763, 4668, 4833, 5397, 5559, 5331, 5746, 6795, 7130, 6346, 5607, 5633, 5681, 4931, 3810, 3399, 3680, 3395, 2132, 847, -57, -1025, -1748, -1676, -1719, -2898, -4277, -4663, -4752, -5314, -5629, -5617, -6769, -9055, -10083, -9174, -8309, -7267, -4171, -2895, -10148, -22805, -30593, -31740, -32296, -32646, -28910, -23526, -22045, -24230, -27071, -29965, -31400, -28024, -20466, -13428, -8399, -3000};