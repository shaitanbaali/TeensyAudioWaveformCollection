/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0036 256 samples */
 
const int16_t AKWF_overtone_0036_256_DATA [256] = 
{23, 65, 96, 118, 135, 146, 155, 162, 167, 170, 172, 174, 175, 175, 176, 175, 175, 176, 175, 174, 175, 175, 174, 173, 174, 172, 171, 171, 170, 171, 169, 168, 168, 167, 168, 167, 166, 167, 165, 164, 164, 164, 164, 163, 162, 163, 162, 160, 161, 160, 159, 159, 159, 159, 158, 157, 157, 156, 155, 156, 155, 153, 154, 153, 152, 153, 152, 151, 152, 150, 149, 150, 149, 148, 149, 148, 147, 147, 146, 145, 145, 145, 144, 145, 144, 143, 535, -1755, 8793, 29979, 20092, 15217, 11238, 8277, 6085, 4460, 3253, 2359, 1696, 1204, 839, 570, 369, 222, 111, 30, -29, -74, -106, -130, -149, -161, -171, -178, -183, -187, -189, -191, -191, -192, -193, -193, -194, -193, -191, -192, -192, -191, -191, -190, -188, -189, -188, -187, -187, -186, -187, -185, -184, -184, -183, -184, -183, -183, -182, -180, -180, -179, -180, -179, -178, -178, -176, -177, -176, -175, -175, -175, -175, -174, -172, -173, -172, -172, -171, -169, -170, -169, -168, -169, -168, -168, -167, -165, -166, -165, -164, -165, -164, -163, -163, -161, -162, -161, -160, -161, -160, -159, -159, -707, 2345, -14094, -29372, -18852, -14461, -10669, -7865, -5784, -4237, -3094, -2245, -1614, -1148, -802, -545, -356, -215, -109, -33, 23, 66, 97, 119, 181, 285, -620, 23151, 25803, 17272, 13102, 9678, 7131, 5246, 3849, 2811, 2042, 1472, 1048, 735, 504, 331, 203, 108, 38, -13, -50, -652, 2477, -16132, -28809, -18442, -14153, -10444, -7701, -5660, -4148, -3029, -2196, -1580, -1123, -784, -533, -347, -209, -107, -31};