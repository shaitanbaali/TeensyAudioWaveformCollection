/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0019 256 samples */
 
const int16_t AKWF_overtone_0019_256_DATA [256] = 
{2018, 5805, 9546, 13243, 16798, 20144, 23212, 25921, 28235, 30104, 31489, 32379, 32760, 32626, 31992, 30879, 29317, 27337, 24983, 22316, 19369, 16208, 12899, 9480, 6024, 2584, -795, -4052, -7147, -10041, -12693, -15073, -17160, -18930, -20371, -21479, -22248, -22683, -22799, -22601, -22108, -21346, -20338, -19106, -17686, -16107, -14397, -12591, -10726, -8823, -6919, -5044, -3217, -1469, 173, 1700, 3091, 4331, 5409, 6320, 7053, 7615, 8003, 8216, 8267, 8161, 7909, 7520, 7012, 6401, 5695, 4916, 4082, 3207, 2308, 1401, 500, -374, -1213, -2002, -2728, -3388, -3961, -4447, -4842, -5139, -5331, -5423, -5410, -5293, -5077, -4761, -4347, -3844, -3255, -2584, -1836, -1016, -130, 815, 1819, 2877, 3984, 5131, 6320, 7547, 8798, 10075, 11365, 12648, 13919, 15149, 16315, 17382, 18311, 19061, 19584, 19835, 19766, 19337, 18511, 17272, 15601, 13513, 11023, 8160, 4987, 1556, -2068, -5791, -9538, -13243, -16799, -20144, -23212, -25921, -28235, -30104, -31489, -32379, -32760, -32626, -31992, -30879, -29317, -27337, -24983, -22316, -19369, -16209, -12899, -9480, -6025, -2585, 794, 4052, 7146, 10041, 12693, 15072, 17161, 18929, 20370, 21479, 22248, 22685, 22798, 22601, 22108, 21346, 20338, 19106, 17685, 16106, 14397, 12591, 10725, 8822, 6918, 5043, 3216, 1468, -174, -1701, -3092, -4331, -5410, -6320, -7054, -7616, -8003, -8217, -8268, -8162, -7909, -7521, -7013, -6402, -5696, -4917, -4083, -3208, -2309, -1401, -501, 373, 1212, 2001, 2727, 3387, 3961, 4446, 4841, 5139, 5330, 5422, 5409, 5292, 5076, 4760, 4347, 3843, 3254, 2583, 1835, 1015, 129, -816, -1820, -2878, -3985, -5132, -6322, -7548, -8799, -10075, -11365, -12649, -13920, -15150, -16316, -17382, -18312, -19061, -19584, -19835, -19766, -19337, -18512, -17273, -15604, -13514, -11023, -8167, -5004, -1506};