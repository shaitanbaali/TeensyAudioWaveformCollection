/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0039 256 samples */
 
const int16_t AKWF_overtone_0039_256_DATA [256] = 
{2069, 2132, 2862, 7973, 7671, 7304, 6934, 11953, 12925, 12288, 12020, 11708, 11413, 11136, 10876, 10638, 10421, 10225, 10055, 9910, 9791, 9700, 9636, 9602, 9598, 9624, 9682, 9773, 9896, 10052, 10241, 10465, 10723, 11016, 11343, 11702, 12098, 12526, 12990, 13486, 14018, 14580, 15175, 15802, 16460, 17147, 17865, 18611, 19384, 20183, 20001, 26248, -5584, -36281, -29817, -29697, -28556, -27402, -26232, -25052, -23859, -22658, -21451, -20237, -19019, -17801, -16581, -15362, -14149, -12939, -11733, -10540, -9355, -8179, -7020, -5875, -4744, -3635, -2543, -1471, -424, 602, 1575, 2674, 3151, -1538, -682, -4127, -5972, -4634, -3573, -4178, -8699, -7821, -7089, -6400, -5739, -5120, -4540, -3999, -3501, -3042, -2624, -2248, -1911, -1616, -1363, -1149, -975, -841, -746, -690, -672, -692, -749, -842, -969, -1129, -1325, -1539, -1814, -2115, 2938, 3797, 3105, 2739, 2245, 1850, 6825, 7084, 7430, 12276, 11674, 10990, 10285, 14955, 15563, 14545, 13881, 13160, 12439, 11722, 11011, 10305, 9609, 8921, 8245, 7584, 6935, 6302, 5687, 5090, 4512, 3957, 3422, 2910, 2422, 1959, 1521, 1109, 725, 368, 39, -261, -534, -778, -992, -1176, -1332, -1459, -1557, -1624, -1664, -1675, -1658, -1614, -1542, -1446, -1424, -718, -3630, -7596, -6775, -6599, -6298, -5978, -5639, -5283, -4912, -4523, -4122, -3710, -3285, -2851, -2409, -1959, -1505, -1045, -582, -116, 348, 816, 1278, 1739, 2197, 2648, 3094, 3532, 3961, 4381, 4763, 5287, 5203, -32, 294, -3666, -6009, -5153, -4557, -5611, -10563, -10099, -9763, -9453, -9154, -8878, -8623, -8390, -8179, -7990, -7822, -7678, -7556, -7455, -7376, -7318, -7283, -7269, -7273, -7298, -7342, -7404, -7483, -7579, -7693, -7820, -7962, -8105, -8291, -8485, -3303, -2299, -2830, -3036, -3252, -3677};