/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0014 256 samples */
 
const int16_t AKWF_overtone_0014_256_DATA [256] = 
{528, 1764, 2791, 3665, 4394, 4990, 5469, 5839, 6112, 6300, 6411, 6455, 6439, 6372, 6262, 6114, 5933, 5726, 5498, 5252, 4994, 4726, 4452, 4173, 3894, 3617, 3342, 3071, 2808, 2550, 2301, 2061, 1830, 1608, 1399, 1198, 1009, 829, 660, 503, 355, 216, 88, -31, -141, -241, -334, -419, -498, -568, -631, -688, -740, -785, -826, -861, -892, -919, -941, -960, -975, -989, -998, -1005, -1010, -1013, -1014, -1012, -1009, -1004, -999, -992, -984, -974, -965, -954, -942, -930, -918, -904, -891, -877, -862, -847, -833, -817, -801, -785, -769, -753, -737, -719, -703, -686, -669, -651, -634, -617, -599, -581, -563, -546, -527, -509, -491, -472, -454, -435, -416, -397, -378, -359, -340, -321, -301, -282, -263, -244, -224, -205, -185, -166, -146, -126, -107, -87, -68, -48, -29, -9, 9, 29, 47, 67, 86, 105, 124, 142, 161, 179, 197, 215, 234, 251, 268, 285, 302, 319, 336, 352, 368, 384, 399, 415, 429, 444, 458, 472, 485, 499, 512, 525, 537, 549, 559, 571, 581, 592, 602, 612, 621, 630, 637, 646, 653, 660, 667, 673, 679, 684, 689, 694, 698, 702, 705, 708, 710, 712, 714, 714, 715, 716, 715, 714, 714, 712, 709, 706, 704, 701, 697, 693, 689, 683, 678, 672, 666, 660, 653, 646, 638, 630, 622, 613, 604, 595, 584, 575, 564, 553, 543, 531, 520, 508, 496, 483, 471, 458, 445, 431, 417, 404, 390, 376, 361, 346, 332, 317, 302, 287, 272, 256, -351, 2847, -16904, -31807, -24146, -20900, -17362, -14160, -11263, -8665, -6344, -4278, -2456, -833};