/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0032 256 samples */
 
const int16_t AKWF_overtone_0032_256_DATA [256] = 
{4995, 10934, 13989, 14753, 13847, 11956, 9697, 7532, 5724, 4377, 3478, 2934, 2630, 2458, 2333, 2199, 2036, 1841, 1628, 1412, 1212, 1037, 897, 791, 714, 663, 629, 608, 596, 586, 579, 572, 565, 559, 554, 549, 545, 541, 538, 535, 532, 529, 525, 519, 513, 506, 499, 492, 483, 475, 466, 456, 446, 436, 426, 417, 406, 396, 385, 374, 363, 354, 343, 333, 324, 314, 304, 296, 287, 278, 270, 261, 253, 245, 237, 230, 223, 216, 210, 204, 197, 192, 186, 181, 175, 170, 166, 161, 156, 151, 147, 143, 139, 136, 132, 130, 126, 123, 119, 117, 114, 112, 108, 106, 104, 101, 99, 97, 94, 93, 91, 88, 87, 85, 83, 81, 80, 78, 77, 74, 73, 72, 70, 70, 68, 67, 66, 64, 64, 63, 61, 61, 59, 58, 58, 56, 55, 55, 54, 52, 52, 51, 50, 49, 48, 47, 47, 46, 44, 44, 44, 43, 41, 42, 41, 41, 40, 38, 38, 37, 38, 36, 35, 35, 34, 35, 34, 32, 33, 32, 31, 32, 31, 29, 30, 29, 28, 28, 29, 28, 26, 27, 26, 26, 25, 26, 24, 23, 24, 23, 24, 22, 21, 22, 21, 21, 20, 21, 21, 21, 19, 18, 19, 19, 18, 17, 18, 18, 17, 18, 17, 15, 16, 16, 15, 16, 15, 14, 15, 15, 14, 14, 15, 13, 12, 13, 13, 13, 13, 12, 13, 12, 11, 12, 12, 12, 11, 12, 11, 9, 10, 10, 10, 10, 10, -25, 34, -333, -7456, -19471, -29001, -32787, -30160, -22719, -12946, -3010};