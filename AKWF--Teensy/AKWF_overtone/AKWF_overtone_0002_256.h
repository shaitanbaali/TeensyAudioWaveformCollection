/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0002 256 samples */
 
const int16_t AKWF_overtone_0002_256_DATA [256] = 
{231, 622, 1015, 1419, 1831, 2253, 2686, 3126, 3575, 4034, 4501, 4976, 5460, 5950, 6450, 6958, 7471, 7994, 8524, 9059, 9602, 10152, 10706, 11269, 11837, 12409, 12988, 13573, 14161, 14756, 15354, 15957, 16566, 17175, 17790, 18409, 19030, 19654, 20281, 20910, 21542, 22176, 22811, 23448, 24087, 24726, 25366, 26007, 26647, 27289, 26790, 33523, -3122, -37013, -30147, -30454, -29633, -28816, -28001, -27191, -26384, -25580, -24782, -23988, -23198, -22414, -21637, -20864, -20099, -19340, -18586, -17842, -17104, -16372, -15651, -14936, -14230, -13535, -12846, -12167, -11499, -10839, -10189, -9550, -8921, -8302, -7696, -7098, -6512, -5939, -5375, -4823, -4285, -3757, -3241, -2738, -2246, -1768, -1302, -848, -407, 21, 436, 838, 1227, 1603, 1966, 2317, 2654, 2977, 3288, 3586, 3870, 4141, 4399, 4644, 4876, 5095, 5300, 5494, 5674, 5842, 5996, 6138, 6268, 6385, 6490, 6583, 6664, 6733, 6790, 6835, 6870, 6892, 6904, 6904, 6895, 6874, 6843, 6802, 6751, 6690, 6619, 6539, 6450, 6352, 6245, 6130, 6007, 5875, 5736, 5590, 5436, 5275, 5108, 4935, 4755, 4569, 4377, 4180, 3979, 3773, 3562, 3347, 3128, 2905, 2679, 2451, 2220, 1984, 1748, 1511, 1272, 1031, 788, 546, 304, 61, -181, -423, -664, -904, -1142, -1380, -1615, -1848, -2079, -2306, -2530, -2751, -2969, -3182, -3392, -3597, -3797, -3993, -4183, -4367, -4548, -4721, -4888, -5049, -5203, -5351, -5491, -5624, -5751, -5869, -5978, -6082, -6175, -6262, -6339, -6407, -6467, -6518, -6560, -6592, -6614, -6627, -6631, -6625, -6608, -6582, -6545, -6498, -6441, -6374, -6296, -6208, -6108, -5998, -5878, -5746, -5604, -5450, -5287, -5114, -4928, -4731, -4525, -4306, -4077, -3838, -3588, -3326, -3055, -2772, -2479, -2176, -1861, -1538, -1203, -859, -505, -134};