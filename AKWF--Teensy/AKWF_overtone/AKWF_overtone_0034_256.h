/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0034 256 samples */
 
const int16_t AKWF_overtone_0034_256_DATA [256] = 
{58, 162, 235, 290, 332, 363, 386, 404, 417, 427, 435, 442, 447, 451, 453, 456, 458, 460, 464, 465, 465, 468, 469, 471, 473, 473, 475, 477, 478, 480, 482, 483, 484, 486, 489, 490, 493, 493, 495, 496, 498, 501, 503, 503, 506, 507, 510, 512, 514, 515, 517, 519, 522, 524, 525, 527, 530, 532, 535, 538, 539, 542, 543, 546, 549, 552, 554, 556, 558, 561, 563, 566, 569, 571, 574, 577, 581, 583, 585, 588, 591, 594, 598, 600, 602, 605, 609, 613, 616, 618, 621, 624, 628, 632, 635, 638, 641, 645, 649, 653, 657, 659, 661, 666, 671, 675, 679, 682, 685, 690, 694, 698, 703, 705, 705, 706, 705, 701, 696, 689, 683, 677, 670, 663, 656, 646, 638, 632, 625, 618, 610, 601, 594, 586, 580, 573, 565, 558, 550, 544, 537, 531, 523, 516, 510, 503, 497, 491, 484, 476, 471, 465, 460, 454, 447, 441, 435, 429, 424, 418, 411, 406, 401, 395, 390, 385, 379, 373, 369, 363, 358, 354, 348, 342, 338, 333, 328, 323, 318, 313, 309, 305, 300, 296, 290, 287, 282, 278, 273, 269, 264, 260, 257, 253, 249, 245, 240, 236, 233, 229, 225, 220, 217, 213, 210, 207, 204, 199, 195, 192, 189, 185, 183, 178, 175, 172, 169, 166, 163, 159, 156, 153, 151, 147, 144, 141, 138, 135, 133, 131, 127, 124, 121, 119, 117, 114, 111, 110, 113, -467, 2927, -15953, -27959, -17549, -13423, -9835, -7185, -5212, -3752, -2671, -1865, -1269, -827, -499, -254, -72};