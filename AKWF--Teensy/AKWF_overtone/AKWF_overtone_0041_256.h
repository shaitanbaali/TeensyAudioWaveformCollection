/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0041 256 samples */
 
const int16_t AKWF_overtone_0041_256_DATA [256] = 
{1824, 4816, 7161, 9100, 10722, 12454, 13627, 14253, 16983, 17476, 19510, 21529, 23490, 24255, 25761, 27934, 28757, 29415, 31306, 32246, 31221, 31143, 31607, 32020, 31339, 32126, 30556, 30481, 29219, 27799, 25982, 24846, 23713, 21579, 20637, 19893, 19899, 18831, 17850, 16524, 15909, 14491, 12097, 12666, 12942, 7552, -721, -506, -2403, -3608, -5875, -7564, -8936, -10970, -11654, -12360, -14901, -15979, -2997, -543, -4288, -6173, -6765, -9376, -10593, -11614, -11578, -12051, -14564, -14438, -13514, -14397, -14830, -14324, -14264, -12250, -10975, -10054, -9750, -8850, -8355, -7783, -6019, -5869, -5303, -4250, -3098, -3646, -2985, -2124, -1910, -712, -2035, -3337, -2310, -3344, -5132, -4954, -4751, -6169, -6129, -5703, -6223, -6745, -6069, -9306, -10868, -11786, -12570, -13989, -14573, -15234, -16744, -16446, -16203, -16150, -16093, -17366, -17068, -17745, -17672, -17705, -16315, -14883, -13538, -12216, -10838, -7048, -4345, -2388, -1176, -706, 1019, 1909, 1977, 3262, 2556, 3980, 5427, 8229, 10400, 10655, 13110, 15391, 17343, 17913, 18485, 20322, 20659, 21089, 22113, 22578, 23337, 23294, 24363, 24982, 23465, 22624, 21023, 22307, 21513, 19611, 19338, 18790, 18629, 16818, 16327, 16081, 15114, 13690, 12465, 11990, 12516, 8219, 294, -1724, -3692, -4557, -3972, -4705, -4854, -6354, -6498, -6164, -7022, -7002, 6494, 8984, 8502, 6012, 5267, 6316, 3469, 3354, 4007, 2929, 1061, 1171, -26, -479, -451, -788, -650, 342, -163, -724, -293, -384, -1304, -1098, -2487, -2886, -3109, -3382, -4587, -3941, -5823, -6426, -6647, -9243, -10398, -12231, -14247, -16484, -18492, -19357, -20240, -20919, -22616, -22963, -23325, -24255, -23960, -26596, -28790, -29634, -30280, -30977, -29614, -29618, -29953, -28674, -27923, -27689, -27582, -25620, -24027, -23830, -21826, -19742, -17212, -16556, -13255, -9780, -6976, -2075};