/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0023 256 samples */
 
const int16_t AKWF_overtone_0023_256_DATA [256] = 
{3792, 1494, 1078, 2341, 3283, 4082, 4731, 5245, 5643, 5937, 6144, 6276, 6343, 6356, 6324, 6257, 6161, 6041, 5905, 5759, 5606, 5452, 5300, 5153, 5015, 4891, 4778, 4683, 4606, 4550, 4514, 4503, 4515, 4553, 4618, 4710, 4831, 4979, 5157, 5364, 5600, 5868, 6166, 6493, 6852, 7241, 7659, 8110, 8588, 9099, 9639, 10207, 10806, 11433, 12088, 12773, 13484, 14222, 14990, 15783, 16599, 17445, 18312, 19205, 20122, 21062, 22024, 23009, 24012, 25038, 26085, 27149, 28233, 29336, 30345, 32013, 30702, 19928, 17668, 11846, 4120, -757, -6976, -13190, -16728, -18646, -21706, -24297, -26469, -28253, -29690, -30810, -31649, -32237, -32598, -32757, -32738, -32557, -32233, -31784, -31222, -30561, -29809, -28984, -28090, -27137, -26137, -25090, -24006, -22894, -21755, -20595, -19423, -18236, -17043, -15846, -14646, -13449, -12258, -11072, -9897, -8733, -7581, -6446, -5330, -4228, -3147, -2095, -1040, 324, 1655, 2937, 4147, 3508, 4887, 5858, 6629, 7385, 8109, 8804, 9471, 10107, 10713, 11289, 11829, 12339, 12816, 13258, 13668, 14044, 14384, 14690, 14960, 15196, 15395, 15560, 15690, 15783, 15840, 15864, 15850, 15801, 15717, 15597, 15443, 15253, 15028, 14769, 14476, 14149, 13787, 13393, 12966, 12506, 12012, 11487, 10931, 10342, 9723, 9075, 8395, 7688, 6952, 6186, 5393, 4575, 3737, 2815, 2199, 2160, 1841, 1560, 1327, 1140, 985, 855, 747, 643, 556, 465, 367, 272, 165, 52, -85, -193, -509, -1676, -2240, -2688, -3319, -4014, -4804, -5610, -6411, -7206, -7989, -8762, -9532, -10285, -11013, -11722, -12401, -13055, -13676, -14279, -14772, -15171, -15648, -16077, -16443, -16759, -17025, -17242, -17402, -17494, -17492, -17215, -16215, -14809, -13777, -13658, -13200, -12591, -11957, -11371, -10857, -10414, -10038, -9719, -9449, -9235, -9076, -8913, -9160, -7534};