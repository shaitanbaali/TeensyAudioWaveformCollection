/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0027 256 samples */
 
const int16_t AKWF_overtone_0027_256_DATA [256] = 
{17428, 30660, 21632, 12396, 10009, 9616, 9938, 11953, 14124, 14782, 14452, 14251, 14380, 14630, 14961, 15327, 15597, 15718, 15748, 15748, 15730, 15685, 15611, 15504, 15356, 15170, 14946, 14696, 14423, 14121, 13800, 13457, 13090, 12707, 12304, 11887, 11456, 11013, 10557, 10091, 9617, 9137, 8650, 8157, 7659, 7161, 6662, 6157, 5655, 5152, 4653, 4159, 3664, 3174, 2691, 2211, 1739, 1274, 814, 364, -71, -505, -930, -1339, -1744, -2136, -2513, -2883, -3239, -3583, -3917, -4235, -4541, -4836, -5116, -5382, -5634, -5873, -6099, -6313, -6509, -6692, -6861, -7017, -7159, -7287, -7401, -7501, -7586, -7659, -7715, -7762, -7791, -7809, -7814, -7806, -7786, -7751, -7705, -7646, -7576, -7494, -7399, -7294, -7178, -7051, -6913, -6765, -6607, -6442, -6263, -6075, -5884, -5677, -5467, -5248, -5024, -4788, -4551, -4305, -4051, -3794, -3530, -3261, -2991, -2711, -2432, -2150, -1861, -1573, -1281, -989, -692, -398, -101, 196, 491, 789, 1083, 1378, 1669, 1957, 2246, 2532, 2816, 3094, 3368, 3637, 3904, 4165, 4419, 4667, 4912, 5148, 5378, 5600, 5815, 6024, 6222, 6415, 6594, 6767, 6933, 7085, 7229, 7364, 7489, 7602, 7702, 7792, 7873, 7939, 7996, 8039, 8071, 8088, 8093, 8085, 8065, 8032, 7983, 7923, 7848, 7758, 7657, 7539, 7406, 7261, 7102, 6924, 6735, 6531, 6311, 6078, 5827, 5561, 5285, 4993, 4680, 4355, 4018, 3665, 3295, 2911, 2511, 2098, 1669, 1226, 770, 298, -190, -689, -1204, -1734, -2278, -2835, -3405, -3989, -4590, -5201, -5824, -6462, -7111, -7772, -8445, -9131, -9831, -10539, -11260, -11993, -12738, -13490, -14256, -15030, -15813, -16608, -17413, -18225, -19047, -19879, -20717, -21562, -22417, -23278, -24146, -25025, -25903, -26792, -27687, -28587, -29493, -30404, -31232, -32305, -32358, -13989};