/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0015 256 samples */
 
const int16_t AKWF_overtone_0015_256_DATA [256] = 
{586, 1422, 2157, 2818, 3408, 3931, 4391, 4791, 5136, 5429, 5673, 5871, 6028, 6145, 6226, 6275, 6292, 6281, 6244, 6184, 6102, 6002, 5884, 5749, 5602, 5443, 5272, 5092, 4905, 4711, 4512, 4309, 4102, 3892, 3682, 3469, 3258, 3047, 2838, 2630, 2425, 2223, 2024, 1829, 1638, 1451, 1269, 1092, 920, 752, 591, 434, 283, 138, -1, -135, -263, -386, -503, -614, -720, -820, -915, -1005, -1089, -1168, -1241, -1311, -1375, -1434, -1489, -1539, -1585, -1626, -1663, -1697, -1726, -1751, -1773, -1791, -1805, -1816, -1825, -1830, -1832, -1831, -1827, -1820, -1812, -1801, -1787, -1771, -1753, -1733, -1711, -1686, -1661, -1634, -1604, -1574, -1542, -1509, -1474, -1438, -1402, -1363, -1324, -1284, -1243, -1202, -1159, -1115, -1071, -1027, -981, -936, -890, -843, -796, -748, -701, -653, -605, -557, -509, -460, -412, -364, -315, -267, -219, -171, -123, -75, -28, 18, 65, 112, 159, 205, 251, 296, 342, 385, 429, 473, 516, 557, 600, 641, 681, 721, 761, 799, 838, 875, 911, 947, 982, 1017, 1050, 1083, 1115, 1145, 1176, 1206, 1234, 1262, 1288, 1314, 1339, 1363, 1386, 1408, 1429, 1450, 1469, 1487, 1504, 1521, 1536, 1550, 1564, 1576, 1587, 1598, 1606, 1614, 1622, 1628, 1633, 1637, 1640, 1643, 1644, 1644, 1643, 1641, 1638, 1635, 1629, 1624, 1617, 1608, 1600, 1591, 1580, 1568, 1556, 1543, 1528, 1513, 1497, 1480, 1463, 1444, 1425, 1405, 1384, 1362, 1339, 1317, 1293, 1268, 1242, 1216, 1190, 1162, 1134, 1106, 1076, 1047, 1017, 986, 955, 923, 285, 3526, -15725, -33131, -26750, -24616, -21996, -19539, -17226, -15061, -13042, -11153, -9395, -7766, -6251, -4854, -3566, -2380, -1298, -292};