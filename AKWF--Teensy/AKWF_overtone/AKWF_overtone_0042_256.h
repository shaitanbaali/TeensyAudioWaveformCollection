/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0042 256 samples */
 
const int16_t AKWF_overtone_0042_256_DATA [256] = 
{259, 751, 1245, 1751, 2268, 2795, 3334, 3880, 4437, 5002, 5577, 6159, 6748, 7343, 7947, 8556, 9171, 9793, 10418, 11046, 11681, 12320, 12959, 13603, 14249, 14897, 15547, 16199, 16849, 17503, 18155, 18808, 19460, 20112, 20762, 21411, 22057, 22705, 23256, 24281, 23536, 3892, 1898, 3351, 3989, 5003, 4383, 11725, 31184, 31052, 30598, 37248, 820, -32882, -26143, -26530, -25803, -25085, -24374, -23673, -22980, -22292, -21616, -20948, -20285, -19633, -18988, -18350, -17722, -17102, -16488, -15883, -15289, -14697, -14117, -13543, -12976, -12420, -11868, -11324, -10789, -10262, -9738, -9224, -8718, -8219, -7726, -7239, -6759, -6288, -5822, -5363, -4911, -4465, -4027, -3596, -3168, -2749, -2339, -1933, -1535, -1143, -757, -379, -8, 356, 714, 1065, 1409, 1745, 2076, 2398, 2713, 3020, 3318, 3610, 3895, 4172, 4438, 4697, 4949, 5192, 5426, 5652, 5870, 6077, 6274, 6464, 6644, 6814, 6975, 7126, 7267, 7399, 7518, 7630, 7731, 7821, 7902, 7971, 8030, 8078, 8114, 8142, 8158, 8162, 8156, 8141, 8113, 8074, 8027, 7967, 7897, 7817, 7727, 7626, 7513, 7392, 7261, 7121, 6971, 6811, 6642, 6463, 6278, 6083, 5787, 5963, 4360, -16144, -19001, -18419, -18650, -18510, -20006, -13543, 5041, 4031, 3833, 3559, 3258, 2952, 2640, 2322, 2001, 1676, 1350, 1023, 693, 362, 31, -300, -630, -958, -1283, -1608, -1928, -2243, -2557, -2864, -3164, -3460, -3748, -4030, -4304, -4568, -4827, -5074, -5311, -5540, -5755, -5961, -6155, -6336, -6504, -6663, -6807, -6935, -7051, -7153, -7240, -7312, -7368, -7408, -7434, -7445, -7439, -7416, -7379, -7322, -7252, -7163, -7059, -6937, -6798, -6642, -6471, -6284, -6077, -5855, -5618, -5363, -5091, -4806, -4504, -4184, -3854, -3504, -3140, -2763, -2370, -1965, -1545, -1112, -667, -198};