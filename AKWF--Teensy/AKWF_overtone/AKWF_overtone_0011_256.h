/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0011 256 samples */
 
const int16_t AKWF_overtone_0011_256_DATA [256] = 
{1395, 3556, 5841, 8417, 10291, 11989, 13395, 14454, 15203, 15529, 16093, 16382, 16789, 17423, 18065, 19239, 20959, 22693, 23933, 25089, 25892, 26637, 27329, 28824, 30141, 31020, 31178, 31034, 30186, 29716, 28925, 27891, 27176, 26750, 26142, 25301, 24967, 24828, 25339, 25453, 25509, 25539, 25209, 24337, 23026, 20744, 17971, 15352, 12473, 9862, 7422, 5125, 3387, 1201, -432, -1967, -3288, -4120, -5115, -5749, -6255, -6914, -7994, -8803, -9882, -10126, -11342, -12438, -13120, -13889, -14404, -14839, -15484, -15918, -16809, -17841, -19414, -20848, -22333, -23800, -24870, -25074, -25155, -24769, -23860, -22925, -22132, -21559, -21042, -20505, -20603, -20485, -20189, -20117, -19943, -19334, -18597, -17527, -15920, -14534, -13086, -13053, -12412, -12008, -12029, -11018, -10109, -9254, -8299, -6616, -5812, -5638, -4337, -5002, -5788, -5754, -5929, -7005, -7363, -6588, -5352, -4342, -4730, -5326, -4269, -3479, -3313, -1672, 938, 1886, 1916, 2306, 3056, 3643, 5303, 7627, 8817, 11148, 12474, 12614, 12920, 13321, 12911, 12052, 11990, 12025, 12357, 13027, 13318, 13593, 13270, 13866, 12765, 12046, 11768, 12359, 13601, 14934, 17204, 18875, 21504, 23949, 24748, 25760, 27107, 26678, 25301, 23802, 21675, 19690, 18915, 17968, 17782, 19155, 21312, 22811, 24497, 25706, 25709, 24771, 23481, 21854, 20274, 18696, 16912, 14952, 13880, 12171, 8631, 5418, 1996, -1840, -5029, -7176, -8379, -9725, -10055, -10602, -11374, -12463, -12964, -13458, -13947, -13578, -13718, -14152, -14958, -16740, -18673, -21192, -23690, -26473, -29004, -30785, -32125, -32655, -31934, -30422, -27854, -25607, -23725, -22881, -22460, -22398, -22920, -23818, -24518, -24953, -24890, -24491, -23671, -22414, -21112, -19995, -19367, -19063, -18654, -18681, -18612, -17556, -16367, -15295, -13933, -12722, -11338, -10342, -10220, -9564, -9284, -8732, -7909, -6952, -5952, -4702, -2858, -803};