/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0016 256 samples */
 
const int16_t AKWF_overtone_0016_256_DATA [256] = 
{1483, 4081, 6822, 8898, 11038, 12877, 14376, 15741, 16743, 17515, 18032, 18256, 18261, 18010, 17535, 16858, 15983, 14942, 13749, 12432, 11008, 9503, 7943, 6343, 4732, 3130, 1553, 25, -1436, -2821, -4110, -5292, -6360, -7300, -8110, -8785, -9322, -9720, -9982, -10109, -10108, -9983, -9742, -9394, -8947, -8414, -7803, -7127, -6398, -5626, -4824, -4007, -3180, -2358, -1552, -769, -19, 688, 1349, 1955, 2500, 2983, 3398, 3742, 4018, 4223, 4357, 4423, 4423, 4361, 4239, 4063, 3837, 3567, 3258, 2916, 2546, 2158, 1754, 1341, 926, 513, 108, -281, -655, -1008, -1334, -1632, -1899, -2133, -2331, -2494, -2619, -2709, -2762, -2780, -2763, -2715, -2635, -2528, -2395, -2239, -2063, -1870, -1663, -1446, -1221, -991, -761, -531, -306, -88, 120, 318, 503, 674, 827, 965, 1084, 1184, 1266, 1329, 1372, 1399, 1408, 1399, 1375, 1336, 1284, 1221, 1147, 1065, 976, 880, 781, 680, 577, 476, 376, 280, 188, 102, 23, -49, -112, -168, -214, -251, -279, -297, -306, -306, -297, -280, -255, -223, -185, -141, -91, -38, 18, 76, 137, 198, 260, 320, 379, 436, 491, 542, 589, 631, 670, 704, 732, 755, 773, 786, 794, 797, 795, 787, 776, 762, 742, 720, 695, 667, 638, 606, 573, 540, 507, 473, 439, 407, 375, 345, 316, 290, 264, 242, 221, 203, 188, 174, 163, 154, 148, 143, 141, 140, 141, 143, 146, 151, 156, 161, 167, 173, 179, 185, 191, 195, 200, 203, 205, 206, 206, 204, 202, 197, 192, 185, 177, 168, 158, 146, 133, 119, 101, -192, 1359, -9666, -27165, -22121, -31811, -25216, -20532, -21629, -15202, -13792, -10715, -6713, -4688, -1103};