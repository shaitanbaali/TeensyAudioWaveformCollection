/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0030 256 samples */
 
const int16_t AKWF_overtone_0030_256_DATA [256] = 
{3821, 14449, 23455, 24958, 18490, 6821, -7418, -19582, -24544, -22330, -16208, -7591, 2594, 10485, 12270, 8037, 188, -9996, -20716, -29032, -32704, -30923, -24172, -14101, -4465, 625, 34, -4195, -9166, -13125, -15507, -15896, -14469, -12295, -10234, -8326, -6263, -3878, -1023, 2311, 5031, 5944, 5569, 5029, 4375, 3030, 1201, -318, -996, 130, 4161, 10530, 17058, 21561, 22754, 19938, 13389, 5333, -1085, -4004, -3275, 399, 5788, 11084, 14579, 15562, 13927, 9566, 3036, -4129, -10055, -13427, -13596, -10521, -5501, -833, 1639, 1408, -1040, -4710, -8264, -10709, -11911, -12162, -11626, -10497, -9004, -7129, -4767, -2245, -237, 812, 943, 498, -127, -659, -1038, -1363, -1484, -844, 1082, 4308, 8256, 12084, 14792, 15338, 13351, 9586, 5516, 2518, 1424, 2501, 5221, 8536, 11567, 13731, 14416, 13156, 10109, 5968, 1529, -2322, -4561, -4599, -2707, 176, 2818, 4174, 3900, 2276, -448, -3806, -6909, -9162, -10673, -11326, -10562, -8574, -6402, -4634, -3488, -3485, -4792, -6542, -7683, -7934, -7535, -6801, -5992, -5126, -4021, -2700, -1283, 219, 1533, 2235, 2257, 1994, 1842, 2017, 2660, 3689, 4868, 6002, 7062, 8138, 9229, 9960, 9777, 8501, 6446, 4231, 2521, 1828, 2387, 3966, 5980, 7429, 7469, 6080, 3666, 573, -2765, -5322, -6347, -6133, -5054, -3005, -396, 1366, 1423, 114, -2402, -6150, -10128, -12771, -13690, -13302, -11654, -9097, -6603, -4743, -3378, -2740, -3312, -4628, -6269, -8124, -9626, -9803, -8432, -6009, -2655, 1347, 4805, 6749, 7379, 7057, 5587, 3356, 1514, 694, 882, 2186, 5076, 8692, 11693, 13710, 14658, 14205, 12044, 8967, 6024, 3836, 2808, 2604, 2312, 2460, 3282, 3703, 3233, 2796, 2968, 3144, 3146, 3876, 5948, 7980, 8835, 8715, 7502, 4006, -1199, -4858, -5385, -2656};