/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0021 256 samples */
 
const int16_t AKWF_overtone_0021_256_DATA [256] = 
{7999, 7406, 8304, 20410, 20958, 20360, 20054, 19826, 18682, 21690, 33018, 32041, 31680, 31091, 31483, 27254, 15281, 15552, 15009, 14575, 14140, 13701, 13260, 12768, 12540, 11512, -2306, 518, 11493, 10018, 9734, 9280, 8825, 8370, 7916, 7461, 7010, 6558, 6107, 5659, 5213, 4768, 4184, 4552, 539, -11508, -11273, -11754, -12137, -12511, -12880, -13243, -13605, -13960, -14308, -14653, -14991, -15323, -15650, -15970, -16101, -17424, -12964, -2352, -3690, -3832, -4147, -4206, -5849, 1290, 9780, 8087, 8031, 7727, 7430, 7144, 6866, 6598, 6337, 6087, 5623, 6608, -3810, -9766, -8757, -9120, -9259, -9388, -9507, -9615, -9714, -9801, -9879, -9946, -10003, -10049, -10086, -10113, -10128, -10133, -10129, -10114, -10088, -10054, -10009, -9954, -9889, -9815, -9730, -9636, -9531, -9419, -9296, -9164, -9023, -8874, -8715, -8546, -8370, -8185, -7992, -7791, -7580, -7363, -6947, -7769, 3262, 8430, 7842, 6923, 14376, 23571, 22402, 22858, 23066, 23279, 23499, 23724, 23955, 24191, 24433, 24679, 24931, 25188, 25226, 26709, 16783, 11312, 12804, 12915, 13244, 13529, 14082, 13664, 1619, 679, 1416, 1740, 2134, 2528, 2926, 3324, 3722, 4123, 4522, 4922, 5323, 5721, 5912, 7451, 2271, -7663, -6041, -5824, -5391, -5217, -3416, -11219, -18799, -16966, -16765, -16310, -15863, -15417, -14976, -14541, -14111, -13686, -13269, -12856, -12450, -11871, -12482, -1171, 3926, 3239, 3741, 4054, 4359, 4655, 4942, 5222, 5492, 5754, 6008, 6102, 7180, 3636, -7657, -6712, -6586, -6359, -6137, -5926, -5725, -5533, -5352, -5180, -5019, -4868, -4727, -4597, -4477, -4367, -4269, -4182, -4104, -4037, -3981, -3935, -3900, -3876, -3862, -3860, -3867, -3885, -4170, -2838, -10921, -19179, -17829, -18124, -18171, -18228, -18295, -18372, -18459, -18507, -18831, -18190, -5928, -4780, -5313, -5441, -5645, -5863};