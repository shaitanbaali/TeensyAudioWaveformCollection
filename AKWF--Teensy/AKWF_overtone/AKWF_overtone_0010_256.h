/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0010 256 samples */
 
const int16_t AKWF_overtone_0010_256_DATA [256] = 
{2349, 5947, 9701, 13661, 17507, 21064, 24363, 27126, 29471, 31296, 32331, 32747, 32596, 31824, 30405, 28434, 26156, 23612, 20734, 17688, 14555, 11387, 8237, 5112, 2132, -689, -3450, -6086, -8678, -11291, -13818, -16233, -18459, -20434, -22267, -23804, -24959, -25772, -26243, -26438, -26410, -26174, -25753, -25248, -24655, -23853, -22924, -21844, -20615, -19237, -17597, -15733, -13644, -11276, -8909, -6440, -3783, -1116, 1563, 4073, 6321, 8423, 10266, 11805, 13089, 14180, 15252, 16240, 17022, 17766, 18433, 18921, 19208, 19433, 19464, 19308, 19156, 19002, 18766, 18475, 18242, 17977, 17668, 17272, 16683, 15981, 15046, 13752, 12148, 10250, 8081, 5733, 3319, 931, -1465, -3794, -5697, -7251, -8564, -9560, -10140, -10250, -9989, -9512, -8915, -8575, -8460, -8183, -7990, -8069, -8305, -8420, -8422, -8605, -8915, -8986, -9496, -10081, -10147, -9919, -10055, -10130, -9750, -9661, -9680, -9726, -9705, -9181, -8852, -8656, -8159, -7907, -7565, -6755, -5538, -4288, -2950, -1258, 972, 3593, 6506, 9871, 13705, 16926, 19419, 21464, 23190, 24640, 25644, 26021, 25920, 25022, 23280, 21018, 18318, 15307, 11824, 7840, 3869, 41, -3702, -7408, -11015, -14379, -17489, -20459, -23062, -25136, -26697, -27918, -29031, -29686, -29675, -29190, -28239, -26858, -25028, -22690, -19876, -16602, -12969, -9225, -5712, -2508, 456, 3183, 5402, 7262, 8952, 10266, 11179, 12000, 13049, 14249, 15500, 16735, 17998, 19486, 21178, 22879, 24412, 25773, 26786, 27418, 27770, 27746, 27281, 26459, 25340, 23663, 21367, 18625, 15632, 12252, 8390, 4258, 314, -3438, -6926, -10061, -12801, -15023, -16664, -17747, -18279, -18422, -18403, -18349, -18133, -17787, -17321, -16720, -16088, -15514, -14997, -14477, -13962, -13443, -12909, -12385, -11895, -11582, -11531, -11678, -12000, -12288, -12425, -12533, -12449, -12034, -11240, -10057, -8526, -6527, -3959, -874};