/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0003 256 samples */
 
const int16_t AKWF_overtone_0003_256_DATA [256] = 
{19350, 34250, 30174, 29640, 28555, 27475, 26400, 25334, 24273, 23220, 22176, 21141, 20115, 19101, 18095, 17102, 16122, 15152, 14195, 13255, 12326, 11411, 10515, 9630, 8763, 7914, 7080, 6264, 5468, 4687, 3927, 3185, 2462, 1761, 1080, 417, -221, -841, -1438, -2013, -2566, -3097, -3605, -4090, -4552, -4990, -5405, -5797, -6164, -6507, -6827, -7121, -7391, -7637, -7858, -8055, -8227, -8373, -8496, -8594, -8667, -8715, -8738, -8737, -8712, -8662, -8588, -8489, -8366, -8220, -8050, -7856, -7639, -7398, -7136, -6849, -6540, -6210, -5856, -5483, -5087, -4669, -4231, -3773, -3295, -2796, -2279, -1742, -1186, -613, -21, 587, 1213, 1857, 2515, 3189, 3880, 4584, 5303, 6037, 6782, 7541, 8313, 9096, 9891, 10698, 11513, 12338, 13175, 14018, 14871, 15731, 16597, 17471, 18351, 19235, 20126, 21021, 21918, 22821, 23726, 24631, 25540, 26450, 27359, 28139, 29116, 30748, -17495, -34764, -30045, -29640, -28556, -27475, -26400, -25334, -24274, -23220, -22177, -21142, -20115, -19101, -18096, -17102, -16123, -15153, -14196, -13255, -12326, -11411, -10515, -9631, -8764, -7915, -7081, -6264, -5468, -4687, -3927, -3186, -2463, -1761, -1080, -417, 221, 840, 1438, 2012, 2566, 3097, 3605, 4090, 4552, 4990, 5405, 5797, 6164, 6507, 6827, 7120, 7390, 7637, 7858, 8055, 8227, 8374, 8497, 8594, 8667, 8715, 8738, 8738, 8712, 8662, 8589, 8489, 8367, 8221, 8050, 7857, 7640, 7399, 7136, 6849, 6540, 6210, 5857, 5482, 5087, 4670, 4231, 3774, 3294, 2795, 2279, 1742, 1186, 613, 22, -587, -1213, -1856, -2515, -3189, -3880, -4584, -5303, -6036, -6782, -7540, -8313, -9096, -9891, -10697, -11512, -12338, -13174, -14017, -14869, -15731, -16596, -17470, -18351, -19235, -20125, -21021, -21917, -22820, -23725, -24631, -25540, -26450, -27358, -28268, -29175, -30099};