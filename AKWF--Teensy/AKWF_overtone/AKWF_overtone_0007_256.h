/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0007 256 samples */
 
const int16_t AKWF_overtone_0007_256_DATA [256] = 
{25, 108, 190, 273, 356, 441, 527, 612, 698, 786, 873, 961, 1049, 1137, 1225, 1315, 1403, 1493, 1581, 1670, 1759, 1848, 1936, 2025, 2113, 2200, 2287, 2375, 2461, 2547, 2632, 2716, 2800, 2883, 2965, 3046, 3126, 3206, 3284, 3362, 3438, 3513, 3587, 3660, 3732, 3802, 3870, 3938, 4004, 4069, 4133, 4194, 4255, 4313, 4370, 4426, 4479, 4532, 4582, 4630, 4677, 4723, 4765, 4807, 4847, 4885, 4920, 4954, 4987, 5016, 5044, 5070, 5094, 5117, 5138, 5156, 5172, 5187, 5199, 4909, 6534, -895, -32677, -32686, -32418, -32375, -32262, -32151, -32042, -31935, -31830, -31728, -31609, -31155, -33207, -7380, 8870, 6107, 6576, 6539, 6500, 6457, 6411, 6364, 6313, 6259, 6203, 6144, 6083, 6019, 5953, 5885, 5814, 5741, 5665, 5588, 5509, 5428, 5345, 5260, 5174, 5086, 4996, 4905, 4812, 4717, 4621, 4524, 4426, 4327, 4225, 4124, 4022, 3918, 3815, 3709, 3604, 3498, 3390, 3283, 3175, 3067, 2958, 2849, 2741, 2631, 2522, 2413, 2304, 2195, 2087, 1979, 1870, 1763, 1656, 1549, 1444, 1338, 1234, 1131, 1028, 925, 825, 725, 626, 528, 432, 337, 243, 150, 59, -30, -118, -205, -290, -374, -454, -534, -613, -689, -763, -836, -907, -976, -1042, -1107, -1169, -1229, -1287, -1344, -1397, -1448, -1498, -1545, -1590, -1633, -1673, -1711, -1746, -1779, -1810, -1838, -1864, -1887, -1908, -1927, -1943, -1957, -1968, -1976, -1983, -1987, -1989, -1987, -1985, -1979, -1971, -1961, -1948, -1932, -1915, -1895, -1872, -1848, -1822, -1793, -1762, -1729, -1693, -1656, -1616, -1574, -1531, -1485, -1436, -1388, -1336, -1283, -1228, -1171, -1111, -1052, -990, -926, -860, -794, -726, -656, -585, -513, -439, -363, -288, -211, -133, -52};