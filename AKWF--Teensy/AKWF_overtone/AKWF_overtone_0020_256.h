/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0020 256 samples */
 
const int16_t AKWF_overtone_0020_256_DATA [256] = 
{2023, 6486, 11089, 15861, 20005, 23608, 26872, 29435, 31210, 32348, 32770, 32416, 31385, 29735, 27467, 24671, 21451, 17850, 13961, 9894, 5706, 1493, -2653, -6682, -10512, -14076, -17338, -20239, -22745, -24838, -26489, -27695, -28454, -28768, -28656, -28136, -27234, -25983, -24413, -22568, -20485, -18208, -15786, -13253, -10655, -8044, -5446, -2906, -463, 1862, 4034, 6024, 7825, 9411, 10767, 11897, 12788, 13438, 13858, 14051, 14026, 13797, 13381, 12791, 12049, 11178, 10194, 9119, 7981, 6796, 5586, 4379, 3185, 2026, 924, -110, -1065, -1924, -2682, -3330, -3860, -4273, -4565, -4737, -4792, -4733, -4565, -4298, -3936, -3491, -2970, -2387, -1753, -1073, -366, 357, 1092, 1819, 2533, 3229, 3890, 4512, 5091, 5615, 6084, 6494, 6838, 7119, 7334, 7486, 7574, 7600, 7567, 7480, 7342, 7159, 6934, 6674, 6384, 6069, 5738, 5393, 5042, 4690, 4340, 3982, 3719, 2053, -2061, -6482, -11082, -15862, -20006, -23609, -26872, -29435, -31210, -32348, -32770, -32416, -31385, -29735, -27467, -24672, -21452, -17850, -13961, -9894, -5707, -1493, 2652, 6682, 10512, 14075, 17337, 20238, 22745, 24838, 26489, 27694, 28454, 28768, 28656, 28136, 27234, 25983, 24412, 22567, 20485, 18207, 15785, 13252, 10655, 8043, 5445, 2905, 462, -1863, -4035, -6025, -7825, -9411, -10768, -11898, -12789, -13438, -13859, -14052, -14026, -13798, -13382, -12792, -12050, -11179, -10195, -9120, -7982, -6797, -5587, -4380, -3186, -2027, -925, 109, 1064, 1923, 2681, 3329, 3859, 4272, 4564, 4737, 4792, 4732, 4564, 4297, 3935, 3490, 2969, 2386, 1752, 1072, 365, -358, -1093, -1820, -2534, -3230, -3891, -4513, -5092, -5616, -6085, -6495, -6839, -7120, -7335, -7487, -7575, -7601, -7568, -7481, -7343, -7160, -6935, -6675, -6385, -6070, -5739, -5394, -5042, -4691, -4341, -3990, -3741, -1988};