/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0038 256 samples */
 
const int16_t AKWF_overtone_0038_256_DATA [256] = 
{36, 80, 110, 132, 148, 161, 169, 176, 180, 184, 186, 187, 188, 189, 188, 189, 189, 188, 189, 188, 187, 188, 187, 187, 186, 185, 185, 185, 184, 183, 182, 182, 182, 181, 181, 180, 180, 179, 178, 178, 178, 177, 175, 175, 175, 174, 174, 174, 173, 173, 172, 172, 171, 170, 169, 169, 169, 168, 167, 167, 166, 166, 165, 166, 165, 165, 164, 162, 163, 162, 162, 161, 160, 160, 159, 160, 159, 159, 158, 157, 157, 156, 156, 155, 154, 155, 154, 154, 153, 152, 153, 152, 152, 150, 149, 149, 149, 149, 148, 148, 148, 147, 146, 147, 146, 146, 145, 182, 12, 523, 14591, 13147, 9677, 7670, 6087, 4914, 4042, 3394, 2912, 2554, 2286, 2087, 1939, 1826, 1742, 1678, 1630, 1593, 1565, 1543, 1525, 1510, 1499, 1488, 1480, 1472, 1466, 1460, 1454, 1449, 1444, 1439, 1434, 1429, 1425, 1421, 1414, 1414, 1401, 1073, 723, 483, 303, 169, 69, -4, -57, -98, -127, -149, -166, -177, -185, -192, -196, -199, -201, -202, -203, -205, -204, -204, -204, -205, -204, -202, -203, -202, -202, -201, -201, -200, -200, -199, -198, -197, -196, -196, -196, -195, -194, -194, -194, -193, -193, -192, -191, -190, -189, -189, -189, -188, -188, -187, -186, -186, -186, -185, -183, -183, -183, -182, -182, -182, -181, -181, -180, -180, -179, -179, -178, -176, -176, -175, -175, -175, -174, -174, -173, -173, -173, -172, -170, -170, -169, -207, -336, 807, -23039, -27942, -18666, -14162, -10447, -7699, -5655, -4140, -3019, -2185, -1568, -1111, -772, -520, -333, -195, -93, -17};