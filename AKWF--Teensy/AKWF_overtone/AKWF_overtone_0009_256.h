/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0009 256 samples */
 
const int16_t AKWF_overtone_0009_256_DATA [256] = 
{1229, 3263, 5176, 6971, 8592, 9863, 10707, 11487, 12303, 13099, 13831, 14497, 14942, 15200, 15490, 15862, 16296, 16793, 17302, 17644, 17821, 17923, 18012, 18085, 18115, 18046, 17981, 18272, 18854, 19387, 19779, 20516, 21624, 22734, 23522, 24047, 24376, 24475, 24105, 22961, 21450, 20052, 18705, 16897, 15027, 13227, 11345, 9566, 8410, 7547, 6615, 6094, 5641, 4794, 3770, 3345, 2778, 1800, 553, -1041, -3333, -5788, -7896, -9885, -11520, -12770, -13896, -15032, -15617, -15802, -15825, -15522, -15023, -14772, -14845, -14976, -15567, -16589, -17783, -19072, -20755, -22597, -24339, -26052, -27755, -29469, -31118, -32400, -32778, -32488, -31872, -31043, -30107, -29405, -28816, -27939, -26817, -25672, -24650, -23826, -23266, -22667, -21728, -20403, -18790, -16871, -14554, -11816, -8810, -5725, -2640, 411, 3386, 6220, 8852, 11303, 13674, 15771, 17360, 18532, 19699, 20858, 21766, 22356, 22864, 23234, 23430, 23524, 23660, 23886, 24251, 24596, 24652, 24445, 24088, 23640, 23064, 22291, 21085, 19535, 18116, 17014, 16191, 15728, 15783, 16083, 16399, 16575, 16569, 16467, 16342, 16033, 15335, 14362, 13026, 11291, 9363, 7574, 5797, 4072, 2723, 1849, 1176, 676, 499, 437, 150, -573, -1654, -2807, -3756, -4493, -5065, -5364, -5425, -5414, -5476, -5627, -5875, -6236, -6682, -7114, -7425, -7568, -7580, -7552, -7605, -7708, -7795, -7903, -8086, -8220, -8223, -8234, -8358, -8534, -8679, -8820, -8906, -8938, -8838, -8441, -7703, -6892, -6084, -5052, -3936, -3187, -2843, -2465, -2064, -1828, -1786, -1825, -2013, -2263, -2550, -2954, -3445, -3815, -4082, -4459, -4954, -5492, -6078, -6777, -7573, -8405, -9207, -9923, -10492, -10887, -11213, -11608, -12067, -12573, -13137, -13733, -14251, -14698, -15097, -15397, -15554, -15624, -15554, -15234, -14687, -14008, -13114, -11834, -9910, -8133, -6262, -4343, -2476, -619};