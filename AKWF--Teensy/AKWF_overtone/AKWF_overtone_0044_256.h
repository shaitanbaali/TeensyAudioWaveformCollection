/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0044 256 samples */
 
const int16_t AKWF_overtone_0044_256_DATA [256] = 
{7364, 7283, 7177, 7290, 5728, 3274, 1916, 682, 574, 961, 1062, 2898, 4141, 4401, 4241, 3845, 3342, 2803, 2273, 1783, 1359, 897, 1049, 1981, 2395, 2713, 2971, 3193, 3391, 3575, 3767, 3862, 4345, 6862, 8471, 9633, 10625, 11474, 12203, 12947, 12691, 11951, 11753, 11631, 11582, 11581, 11616, 11683, 11781, 11906, 12054, 12228, 12444, 12586, 13315, 14638, 16320, 12078, 7199, 7753, 7463, 7336, 7232, 7148, 7081, 7031, 6957, 7155, 5481, 3505, 14619, 15719, 13395, 11350, 9885, 8598, 7472, 6483, 5602, 4822, 4140, 3541, 3027, 2596, 2257, 1899, 2177, 3247, 3786, 4229, 4618, 4972, 5203, 6073, 707, -1432, -849, -3020, -4246, -5070, -5788, -6421, -7020, -7477, -8834, -10582, -11713, -12702, -13560, -14312, -14978, -15561, -16070, -16513, -16891, -17218, -17369, -19585, -20913, -22063, -22825, -23415, -23905, -24314, -24659, -24947, -25183, -25372, -25516, -25616, -25639, -25834, -24292, -21841, -20399, -19199, -17475, -13664, -8221, -2479, 1765, 4304, 5874, 6791, 7264, 7459, 7463, 7353, 7193, 6903, 7155, 8134, 8549, 8831, 9027, 9168, 9267, 9336, 9400, 9365, 9692, 12017, 13461, 14459, 15289, 15979, 16542, 17120, 16690, 15776, 15402, 15101, 14870, 14685, 14534, 14415, 14322, 14257, 14214, 14194, 14218, 14166, 14700, 15828, 17316, 12878, 7803, 8161, 7678, 7356, 7058, 6782, 6523, 6280, 6016, 6027, 4180, 2001, 12935, 13850, 11345, 9120, 7477, 6013, 4716, 3555, 2506, 1558, 711, -46, -717, -1304, -1796, -2304, -2173, -1246, -846, -540, -285, -62, 143, 337, 543, 657, 1158, 3699, 5340, 6530, 7330, 9436, 4898, -14771, -15509, -17424, -18644, -19700, -20620, -21430, -22147, -22780, -23335, -23814, -24227, -24584, -24762, -26997, -28340, -29500, -30269, -30861, -31346, -31750, -32081, -32352, -32567, -32731};