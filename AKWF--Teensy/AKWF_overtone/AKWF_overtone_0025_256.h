/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0025 256 samples */
 
const int16_t AKWF_overtone_0025_256_DATA [256] = 
{610, 1575, 2362, 2989, 3449, 3739, 3857, 3877, 3345, 5339, 8351, 9546, 11468, 13921, 16868, 20246, 23921, 28344, 31297, 28121, 29112, 29918, 29616, 28487, 26701, 24417, 21775, 18610, 18630, 18130, 16457, 15452, 14842, 14545, 14444, 14439, 14443, 14386, 14210, 13866, 13326, 12571, 11597, 10402, 9002, 7427, 5692, 3839, 1911, -68, -2045, -3983, -5848, -7602, -9211, -10655, -11910, -12960, -13794, -14405, -14799, -14980, -14959, -14748, -14368, -13844, -13196, -12446, -11628, -10763, -9877, -8996, -8140, -7331, -6584, -5913, -5329, -4846, -4459, -4176, -3996, -3908, -3912, -3997, -4152, -4363, -4621, -4911, -5218, -5530, -5834, -6118, -6371, -6586, -6753, -6867, -6922, -6918, -6853, -6727, -6541, -6303, -6016, -5687, -5319, -4921, -4502, -4070, -3629, -3188, -2753, -2334, -1932, -1554, -1200, -878, -584, -324, -95, 104, 273, 415, 534, 633, 713, 785, 844, 898, 953, 1008, 1068, 1139, 1220, 1312, 1419, 1540, 1676, 1825, 1992, 2172, 2363, 2564, 2773, 2990, 3207, 3430, 3652, 3871, 4086, 4292, 4489, 4679, 4857, 5024, 5176, 5317, 5443, 5558, 5660, 5749, 5829, 5897, 5957, 6009, 6052, 6091, 6126, 6157, 6184, 6212, 6236, 6263, 6287, 6313, 6340, 6365, 6395, 6423, 6451, 6480, 6506, 6531, 6554, 6575, 6592, 6605, 6614, 6618, 6615, 6608, 6593, 6572, 6542, 6508, 6467, 6421, 6364, 6302, 6237, 6164, 6085, 6001, 5913, 5821, 5725, 5625, 5523, 5417, 5309, 5153, 5269, 4019, 480, -1250, -3463, -6264, -9548, -13244, -17282, -21672, -26213, -24682, -25349, -27078, -27605, -27310, -26330, -24802, -22903, -20306, -19720, -19992, -18522, -17564, -16947, -16597, -16426, -16356, -16312, -16238, -16086, -15818, -15415, -14854, -14136, -13260, -12241, -11091, -9835, -8501, -7110, -5702, -4305, -2944, -1656, -442};