/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_overtone_0006 256 samples */
 
const int16_t AKWF_overtone_0006_256_DATA [256] = 
{7855, 20631, 29357, 32749, 31170, 26949, 22961, 21128, 21635, 23225, 24228, 23658, 21712, 19455, 17990, 17749, 18285, 18684, 18241, 16906, 15242, 13989, 13528, 13660, 13800, 13415, 12387, 11066, 9976, 9440, 9378, 9386, 9048, 8238, 7165, 6225, 5690, 5534, 5474, 5189, 4549, 3690, 2902, 2407, 2216, 2133, 1905, 1415, 750, 118, -301, -485, -569, -737, -1086, -1571, -2041, -2363, -2512, -2575, -2681, -2904, -3216, -3519, -3726, -3817, -3846, -3892, -3999, -4147, -4282, -4359, -4375, -4362, -4355, -4358, -4352, -4317, -4254, -4186, -4127, -4073, -3987, -3841, -3640, -3430, -3268, -3163, -3071, -2915, -2644, -2283, -1922, -1658, -1508, -1398, -1194, -817, -301, 214, 583, 770, 885, 1108, 1568, 2231, 2905, 3388, 3608, 3697, 3908, 4425, 5222, 6066, 6669, 6912, 6947, 7099, 7640, 8570, 9600, 10340, 10599, 10533, 10565, 11087, 12149, 13403, 14321, 14587, 14350, 14164, 14598, 15813, 17385, 18574, 18845, 18303, 17688, 17901, 19334, 21491, 23242, 23565, 22349, 20651, 20153, 22029, 25967, 29941, 31075, 27136, 17892, 5458, -6615, -14908, -17780, -15945, -11832, -8205, -6739, -7431, -8987, -9868, -9271, -7497, -5561, -4426, -4382, -4955, -5333, -4955, -3852, -2553, -1659, -1432, -1653, -1828, -1562, -822, 91, 776, 1032, 966, 886, 1066, 1554, 2171, 2658, 2874, 2870, 2837, 2948, 3237, 3599, 3889, 4021, 4029, 4021, 4074, 4195, 4331, 4414, 4437, 4429, 4432, 4446, 4429, 4350, 4224, 4109, 4066, 4085, 4082, 3956, 3675, 3323, 3051, 2959, 3009, 3025, 2820, 2345, 1749, 1288, 1139, 1246, 1333, 1097, 432, -448, -1147, -1363, -1144, -890, -1090, -1954, -3210, -4250, -4558, -4113, -3492, -3503, -4602, -6482, -8171, -8664, -7687, -6063, -5337, -6784, -10363, -14362, -16041, -13003, -4284};