/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0003 256 samples */
 
const int16_t AKWF_distorted_0003_256_DATA [256] = 
{11689, 15411, 16953, 18215, 19208, 20041, 20768, 21408, 21982, 22506, 22982, 23425, 23834, 24217, 24577, 24912, 25231, 25533, 25818, 26087, 26347, 26593, 26827, 27052, 27268, 27473, 27671, 27863, 28046, 28221, 28391, 28554, 28711, 28865, 29013, 29152, 29289, 29424, 29552, 29675, 29797, 29914, 30025, 30134, 30241, 30343, 30442, 30538, 30632, 30722, 30809, 30894, 30977, 31058, 31134, 31208, 31283, 31353, 31420, 31487, 31551, 31613, 31674, 31732, 31788, 31844, 31895, 31947, 31996, 32042, 32090, 32134, 32176, 32216, 32258, 32295, 32332, 32366, 32399, 32434, 32462, 32492, 32521, 32547, 32571, 32597, 32620, 32641, 32662, 32680, 32698, 32715, 32731, 32743, 32762, 32749, 32415, 32172, 32210, 32242, 32116, 31864, 31583, 31349, 31178, 31024, 30828, 30568, 30273, 29981, 29710, 29450, 29172, 28860, 28514, 28154, 27791, 27426, 27042, 26623, 26160, 25654, 25097, 24497, 23643, 22196, 21346, 20293, 19030, 17332, 16376, 8118, -13720, -16099, -17740, -18989, -19981, -20817, -21547, -22193, -22776, -23304, -23786, -24232, -24645, -25030, -25390, -25729, -26047, -26344, -26627, -26894, -27150, -27390, -27620, -27838, -28046, -28243, -28433, -28613, -28785, -28951, -29109, -29260, -29405, -29542, -29676, -29803, -29925, -30040, -30152, -30258, -30360, -30456, -30549, -30638, -30723, -30801, -30877, -30952, -31020, -31085, -31145, -31203, -31257, -31309, -31355, -31400, -31438, -31477, -31510, -31538, -31566, -31589, -31610, -31626, -31638, -31648, -31655, -31659, -31658, -31653, -31645, -31636, -31622, -31603, -31581, -31556, -31526, -31493, -31458, -31416, -31370, -31322, -31265, -31206, -31137, -31064, -30955, -30818, -30714, -30622, -30509, -30365, -30203, -30036, -29872, -29707, -29533, -29346, -29138, -28922, -28702, -28478, -28245, -27998, -27738, -27463, -27176, -26881, -26571, -26243, -25891, -25518, -25114, -24679, -24201, -23649, -23026, -21744, -20675, -19851, -18688, -17299, -15596, -12140};