/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0044 256 samples */
 
const int16_t AKWF_distorted_0044_256_DATA [256] = 
{31949, 32227, 32194, 32220, 32236, 32253, 32269, 32283, 32297, 32309, 32322, 32335, 32347, 32357, 32367, 32377, 32384, 32393, 32400, 32405, 32412, 32418, 32422, 32425, 32429, 32433, 32433, 32434, 32443, 32455, 32467, 32476, 32484, 32492, 32500, 32507, 32510, 32505, 32499, 32491, 32484, 32475, 32466, 32456, 32445, 32442, 32444, 32445, 32445, 32443, 32443, 32440, 32437, 32433, 32427, 32422, 32416, 32408, 32400, 32390, 32379, 32370, 32347, 32369, 32728, 32765, 32751, 32749, 32744, 32739, 32733, 32728, 32721, 32714, 32705, 32696, 32689, 32679, 32668, 32656, 32643, 32628, 32613, 32592, 32562, 32530, 32492, 32451, 32404, 32352, 32291, 32221, 32157, 32092, 32017, 31935, 31842, 31737, 31617, 31484, 31316, 31081, 30801, 30463, 30049, 29539, 28896, 28062, 26947, 25346, 22989, 19028, -7216, -22462, -24126, -26328, -27680, -28664, -29414, -30004, -30473, -30853, -31167, -31425, -31639, -31538, -33080, -27865, 28432, 32970, 31553, 31634, 31418, 31157, 30840, 30457, 29982, 29384, 28623, 27616, 26230, 23935, 22329, 4698, -20241, -23087, -25549, -27079, -28169, -28980, -29610, -30111, -30515, -30845, -31122, -31352, -31520, -31651, -31766, -31870, -31960, -32041, -32112, -32176, -32238, -32304, -32364, -32415, -32461, -32503, -32538, -32570, -32598, -32617, -32632, -32646, -32658, -32669, -32679, -32690, -32700, -32708, -32716, -32723, -32728, -32734, -32740, -32744, -32749, -32752, -32761, -32751, -32400, -32337, -32368, -32375, -32385, -32395, -32402, -32410, -32416, -32421, -32425, -32428, -32433, -32434, -32435, -32436, -32435, -32434, -32433, -32438, -32449, -32459, -32468, -32477, -32485, -32492, -32498, -32503, -32501, -32494, -32487, -32480, -32470, -32462, -32450, -32438, -32427, -32426, -32426, -32423, -32421, -32418, -32413, -32408, -32403, -32397, -32390, -32383, -32374, -32365, -32355, -32345, -32334, -32323, -32310, -32296, -32284, -32269, -32254, -32239, -32222, -32177, -32311, -31492};