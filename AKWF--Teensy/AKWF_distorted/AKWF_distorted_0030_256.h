/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0030 256 samples */
 
const int16_t AKWF_distorted_0030_256_DATA [256] = 
{19212, 20473, 20196, 20261, 20259, 20288, 20166, 20716, 24969, 25836, 25638, 25682, 25681, 25727, 25486, 26959, 29611, 29526, 29528, 29535, 29533, 29545, 29486, 29777, 30741, 30802, 30782, 30785, 30783, 30791, 30755, 30907, 31743, 31867, 31836, 31843, 31842, 31841, 31838, 31843, 31942, 31975, 31966, 31967, 31967, 31971, 31951, 32058, 32335, 32339, 32335, 32337, 32336, 32336, 32329, 32358, 32496, 32512, 32508, 32508, 32506, 32507, 32506, 32509, 32543, 32550, 32547, 32548, 32547, 32548, 32547, 32547, 32613, 32642, 32636, 32635, 32636, 32636, 32633, 32649, 32710, 32714, 32712, 32712, 32713, 32712, 32711, 32709, 32700, 32697, 32698, 32697, 32697, 32697, 32698, 32695, 32604, 32568, 32574, 32572, 32573, 32568, 32590, 32466, 31911, 31868, 31882, 31876, 31873, 31867, 31891, 31773, 30944, 30801, 30836, 30824, 30824, 30812, 30830, 30757, 28742, 28047, 28196, 28156, 28151, 28131, 27904, 29351, 16810, 4033, 6931, 6019, 6080, 5258, 8041, -10288, -29375, -27576, -27844, -27876, -27876, -27925, -27680, -28799, -32154, -32278, -32239, -32254, -32253, -32255, -32248, -32269, -32515, -32580, -32567, -32570, -32568, -32570, -32559, -32626, -32762, -32760, -32759, -32759, -32760, -32760, -32759, -32761, -32766, -32768, -32766, -32765, -32766, -32765, -32766, -32762, -32720, -32708, -32711, -32710, -32708, -32708, -32709, -32708, -32651, -32624, -32629, -32628, -32626, -32623, -32629, -32604, -32511, -32504, -32504, -32503, -32501, -32499, -32508, -32467, -32111, -32036, -32052, -32048, -32047, -32044, -32046, -32034, -31835, -31768, -31782, -31777, -31775, -31775, -31773, -31776, -31595, -31501, -31517, -31511, -31510, -31505, -31519, -31443, -31083, -31039, -31048, -31046, -31044, -31037, -31051, -30979, -30137, -29920, -29969, -29955, -29952, -29944, -29945, -29961, -28134, -27272, -27443, -27404, -27398, -27343, -27574, -26386, -19622, -18826, -19053, -18993, -18963, -18859, -19290, -17042};