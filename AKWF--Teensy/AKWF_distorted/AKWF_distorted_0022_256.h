/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0022 256 samples */
 
const int16_t AKWF_distorted_0022_256_DATA [256] = 
{3105, 11079, 16879, 21218, 24389, 26701, 28381, 29586, 30458, 31090, 31548, 31886, 32135, 32320, 32457, 32560, 32636, 32691, 32728, 32753, 32765, 32767, 32760, 32743, 32716, 32680, 32632, 32573, 32499, 32411, 32303, 32175, 32022, 31839, 31623, 31365, 31061, 30705, 30285, 29793, 29220, 28553, 27783, 26902, 25886, 24737, 23429, 21960, 20329, 18520, 16516, 14324, 11935, 9339, 6555, 3555, 348, -2801, -5540, -7936, -10023, -11838, -13404, -14754, -15884, -16830, -17611, -18229, -18686, -19002, -19181, -19219, -19117, -18870, -18471, -17914, -17165, -16206, -14995, -13485, -11622, -9335, -6516, -3079, 1046, 5177, 8857, 12139, 14976, 17396, 19443, 21140, 22535, 23695, 24641, 25414, 26053, 26570, 27000, 27359, 27659, 27913, 28133, 28321, 28490, 28644, 28782, 28911, 29034, 29151, 29265, 29372, 29475, 29575, 29669, 29758, 29840, 29914, 29980, 30039, 30088, 30128, 30155, 30173, 30177, 30167, 30144, 30104, 30046, 29970, 29871, 29747, 29596, 29413, 29195, 28940, 28636, 28279, 27860, 27369, 26796, 26128, 25338, 24406, 23315, 22018, 20494, 18668, 16470, 13827, 10636, 6759, 1951, -3494, -8414, -12629, -16242, -19278, -21820, -23907, -25604, -26956, -28031, -28875, -29528, -30026, -30401, -30674, -30868, -30998, -31072, -31100, -31093, -31053, -30988, -30901, -30796, -30678, -30554, -30423, -30293, -30164, -30040, -29925, -29820, -29723, -29637, -29565, -29507, -29463, -29431, -29413, -29411, -29423, -29449, -29489, -29543, -29611, -29691, -29782, -29880, -29987, -30100, -30216, -30334, -30453, -30567, -30680, -30790, -30893, -30991, -31082, -31165, -31241, -31308, -31369, -31420, -31464, -31499, -31526, -31546, -31557, -31562, -31560, -31551, -31534, -31512, -31485, -31452, -31416, -31375, -31329, -31280, -31228, -31173, -31113, -31047, -30974, -30891, -30794, -30676, -30533, -30353, -30131, -29847, -29481, -29011, -28395, -27592, -26537, -25119, -23221, -20642, -17119, -12342, -5431};