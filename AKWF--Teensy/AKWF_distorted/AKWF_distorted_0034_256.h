/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0034 256 samples */
 
const int16_t AKWF_distorted_0034_256_DATA [256] = 
{32766, 32762, 32756, 32752, 32749, 32743, 32738, 32732, 32728, 32722, 32716, 32710, 32703, 32696, 32690, 32684, 32676, 32669, 32661, 32653, 32645, 32637, 32628, 32618, 32609, 32600, 32589, 32577, 32567, 32555, 32544, 32532, 32518, 32506, 32493, 32478, 32463, 32448, 32432, 32415, 32397, 32380, 32362, 32342, 32323, 32302, 32280, 32259, 32235, 32212, 32186, 32160, 32132, 32104, 32074, 32044, 32013, 31980, 31945, 31909, 31872, 31833, 31791, 31749, 31705, 31659, 31611, 31560, 31507, 31454, 31395, 31335, 31273, 31206, 31138, 31065, 30989, 30909, 30825, 30737, 30644, 30546, 30444, 30338, 30223, 30103, 29975, 29840, 29697, 29546, 29385, 29214, 29032, 28836, 28630, 28406, 28167, 27910, 27631, 27329, 27001, 26647, 26256, 25828, 25352, 24822, 24231, 23558, 22785, 21890, 20817, 19481, 17830, 15527, 5639, -564, 134, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -139, 552, -4007, -14636, -17625, -19250, -20641, -21744, -22664, -23451, -24137, -24741, -25277, -25761, -26196, -26592, -26951, -27283, -27588, -27871, -28131, -28371, -28598, -28807, -29004, -29188, -29361, -29523, -29676, -29820, -29955, -30085, -30206, -30321, -30429, -30532, -30630, -30723, -30813, -30897, -30978, -31055, -31128, -31196, -31263, -31326, -31386, -31446, -31499, -31553, -31603, -31652, -31698, -31743, -31785, -31827, -31867, -31903, -31940, -31975, -32008, -32040, -32070, -32099, -32128, -32156, -32182, -32208, -32232, -32255, -32277, -32298, -32320, -32339, -32359, -32377, -32395, -32412, -32429, -32446, -32461, -32476, -32490, -32504, -32516, -32530, -32542, -32553, -32565, -32575, -32587, -32598, -32608, -32616, -32627, -32636, -32644, -32652, -32660, -32668, -32675, -32683, -32689, -32695, -32702, -32709, -32715, -32721, -32727, -32732, -32737, -32742, -32748, -32752, -32723, -32680, -33332, -5334};