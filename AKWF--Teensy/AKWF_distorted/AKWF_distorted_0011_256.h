/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0011 256 samples */
 
const int16_t AKWF_distorted_0011_256_DATA [256] = 
{7800, 7800, 7873, 7462, 12284, 14006, 14654, 18698, 18544, 18565, 18629, 18297, 20870, 22484, 22166, 22276, 21998, 23663, 25288, 25010, 25062, 25062, 25089, 24940, 25625, 27383, 27242, 27267, 27267, 27267, 27298, 27133, 28253, 29111, 28951, 28980, 28980, 28980, 28980, 28980, 28980, 28980, 28981, 28993, 28920, 30004, 30380, 30297, 30311, 30311, 30311, 30311, 30311, 30311, 30311, 30311, 30311, 30311, 30311, 30311, 30325, 30250, 30600, 31404, 31330, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31343, 31355, 31292, 31902, 32197, 32135, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32146, 32092, 32360, 30946, 26083, -7794, -27869, -28334, -30210, -31264, -31583, -32199, -32101, -32601, -32803, -32760, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32765, -32777, -32732, -32182, -32137, -32149, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32146, -32132, -32210, -31695, -31282, -31358, -31343, -31343, -31343, -31343, -31343, -31343, -31343, -31343, -31343, -31343, -31343, -31343, -31337, -31370, -31238, -30332, -30305, -30314, -30311, -30311, -30311, -30311, -30311, -30307, -30328, -30256, -29080, -28954, -28987, -28980, -28980, -28980, -28980, -28950, -29114, -27971, -27139, -27297, -27267, -27230, -27434, -25909, -24903, -25099, -25045, -25137, -24773, -22280, -22205, -22173, -22484, -20870, -18297, -18596, -18721, -17950, -13815, -14062, -13011, -7701, -8085, -6623, 91, -9};