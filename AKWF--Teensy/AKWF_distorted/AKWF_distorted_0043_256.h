/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0043 256 samples */
 
const int16_t AKWF_distorted_0043_256_DATA [256] = 
{32718, 32752, 32732, 32722, 32708, 32693, 32678, 32661, 32643, 32623, 32602, 32579, 32554, 32528, 32498, 32465, 32431, 32394, 32353, 32309, 32259, 32207, 32148, 32085, 32018, 31943, 31860, 31768, 31694, 31629, 31558, 31486, 31406, 31322, 31231, 31138, 31018, 30840, 30639, 30414, 30161, 29873, 29550, 29178, 28746, 28408, 28125, 27801, 27448, 27057, 26623, 26139, 25593, 24977, 24266, 23437, 22456, 21263, 19686, 17927, 13588, 133, -14400, -13577, 28747, 31901, 30908, 31012, 30915, 30812, 30703, 30588, 30464, 30332, 30192, 30042, 29881, 29708, 29525, 29324, 29108, 28875, 28631, 28232, 27631, 26926, 26071, 24999, 23620, 21615, 19535, 9788, -9757, -17617, -19526, -21367, -22700, -23764, -24651, -25386, -26128, -26972, -27672, -28256, -28755, -29183, -29554, -29879, -30166, -30417, -30642, -30843, -31021, -31183, -31328, -31449, -31547, -31639, -31725, -31803, -31876, -31943, -32005, -32063, -32118, -31886, -33316, -28056, 28570, 33216, 31899, 32113, 32058, 32001, 31938, 31870, 31797, 31718, 31633, 31541, 31434, 31299, 31150, 30985, 30803, 30597, 30367, 30108, 29815, 29482, 29099, 28658, 28143, 27537, 26812, 25917, 25105, 24321, 23369, 22217, 20724, 18777, 15997, 3165, -13995, -19927, -22121, -23939, -25244, -26262, -27084, -27763, -28337, -28685, -28922, -29155, -29367, -29562, -29745, -29916, -30074, -30221, -30360, -30490, -30612, -30726, -30834, -30935, -31031, -31081, -30698, -33679, -152, 13397, -3751, -14840, -18273, -20043, -21528, -22671, -23619, -24420, -25108, -25710, -26242, -26714, -27139, -27522, -27868, -28185, -28466, -28834, -29262, -29622, -29937, -30216, -30463, -30682, -30878, -31056, -31178, -31267, -31355, -31438, -31517, -31589, -31656, -31719, -31789, -31877, -31959, -32032, -32099, -32161, -32218, -32269, -32318, -32361, -32401, -32439, -32473, -32504, -32533, -32560, -32584, -32607, -32627, -32647, -32665, -32682, -32697, -32711, -32724, -32708, -32873, -31702};