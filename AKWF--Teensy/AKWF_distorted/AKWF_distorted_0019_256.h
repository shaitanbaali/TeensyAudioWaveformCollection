/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0019 256 samples */
 
const int16_t AKWF_distorted_0019_256_DATA [256] = 
{23177, 29649, 29713, 30272, 30450, 30494, 30461, 30386, 30287, 30179, 30069, 29962, 29860, 29772, 29692, 29623, 29568, 29524, 29496, 29476, 29470, 29476, 29493, 29522, 29559, 29607, 29663, 29726, 29793, 29866, 29942, 30018, 30093, 30166, 30233, 30296, 30350, 30394, 30425, 30444, 30452, 30447, 30432, 30407, 30379, 30346, 30316, 30291, 30275, 30265, 30271, 30285, 30304, 30330, 30360, 30387, 30408, 30422, 30427, 30420, 30404, 30374, 30336, 30289, 30233, 30171, 30104, 30036, 29966, 29896, 29829, 29765, 29706, 29650, 29601, 29560, 29528, 29505, 29489, 29481, 29483, 29496, 29518, 29547, 29587, 29633, 29689, 29752, 29821, 29892, 29971, 30049, 30124, 30200, 30267, 30325, 30365, 30379, 30362, 30295, 30163, 29933, 29568, 28814, 28535, 23006, -3740, -26880, -28980, -30011, -30915, -31504, -31935, -32251, -32467, -32614, -32705, -32756, -32768, -32761, -32735, -32691, -32638, -32578, -32510, -32439, -32366, -32290, -32213, -32134, -32054, -31976, -31897, -31821, -31743, -31662, -31581, -31499, -31423, -31348, -31293, -31128, -31447, -32735, -32064, 15866, 32861, 29764, 30001, 29731, 29548, 29455, 29439, 29488, 29588, 29725, 29882, 30044, 30193, 30315, 30399, 30436, 30433, 30391, 30336, 30287, 30261, 30267, 30298, 30347, 30392, 30420, 30423, 30396, 30341, 30265, 30172, 30067, 29961, 29856, 29759, 29672, 29601, 29544, 29510, 29493, 29494, 29515, 29556, 29616, 29689, 29777, 29875, 29981, 30089, 30195, 30287, 30359, 30393, 30368, 30250, 29987, 29349, 28890, 25487, -7174, -29112, -29578, -30896, -31653, -32136, -32442, -32627, -32726, -32764, -32757, -32721, -32662, -32592, -32510, -32420, -32330, -32236, -32140, -32043, -31948, -31854, -31761, -31666, -31566, -31470, -31379, -31294, -31202, -31169, -31248, -31339, -31434, -31538, -31653, -31767, -31883, -32007, -32134, -32263, -32393, -32517, -32625, -32701, -32721, -32637, -32389, -31878, -30608, -30901, -16583};