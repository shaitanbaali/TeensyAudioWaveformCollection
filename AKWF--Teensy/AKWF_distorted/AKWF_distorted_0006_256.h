/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0006 256 samples */
 
const int16_t AKWF_distorted_0006_256_DATA [256] = 
{7859, 12223, 14757, 16936, 18846, 20606, 22270, 23869, 25443, 27019, 28621, 30363, 32400, 32834, 32747, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32748, 32833, 32278, 30300, 28562, 26961, 25390, 23814, 22210, 20548, 18780, 16861, 14600, 12370, 6453, -8437, -13605, -16914, -20433, -24008, -28431, -32650, -32793, -32749, -32767, -32767, -31869, -36824, -2649, 36530, 31945, 32762, 32768, 32743, 32818, 32457, 28242, 23873, 20313, 16791, 13501, 8128, -7356, -12365, -14704, -16937, -18846, -20607, -22271, -23869, -25444, -27019, -28621, -30363, -32400, -32834, -32747, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32748, -32833, -32278, -30300, -28562, -26961, -25390, -23814, -22211, -20548, -18780, -16861, -14601, -12370, -6454, 8437, 13605, 16914, 20433, 24008, 28431, 32650, 32793, 32749, 32768, 32768, 31864, 36847, 2149, -36557, -31939, -32762, -32767, -32743, -32818, -32457, -28242, -23873, -20313, -16845, -13361, -8619};