/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0042 256 samples */
 
const int16_t AKWF_distorted_0042_256_DATA [256] = 
{31346, 32593, 32417, 32501, 32540, 32572, 32603, 32630, 32654, 32675, 32693, 32711, 32726, 32739, 32737, 32828, 31477, 31167, 31403, 31500, 31600, 31689, 31766, 31834, 31893, 31944, 31989, 32028, 32062, 32091, 32115, 32136, 32152, 32165, 32175, 32182, 32186, 32187, 32184, 32181, 32173, 32161, 32149, 32132, 32112, 32089, 32063, 32031, 31997, 31957, 31913, 31864, 31808, 31748, 31683, 31607, 31525, 31435, 31335, 31226, 31105, 30971, 30827, 30665, 30490, 30296, 30084, 29850, 29597, 29318, 29013, 28680, 28317, 27920, 27492, 27021, 26514, 25968, 25377, 24744, 24069, 23354, 22602, 21823, 21028, 20235, 19469, 18766, 18160, 17712, 17463, 17441, 17647, 18075, 18676, 19390, 20189, 21024, 21865, 22701, 23509, 24277, 25012, 25696, 26336, 26929, 27478, 27983, 28447, 28872, 29260, 29614, 29935, 30228, 30494, 30733, 30952, 31148, 31325, 31485, 31629, 31757, 31875, 31979, 32071, 32146, 31257, 36598, -2437, -29899, -22754, -21508, -16110, 8588, 20944, 22696, 24803, 26146, 27149, 27934, 28562, 29054, 28974, 32379, -17993, -34403, -30569, -31084, -30935, -30780, -30621, -30457, -30289, -30120, -29954, -29789, -29633, -29482, -29342, -29216, -29105, -29012, -28937, -28884, -28854, -28847, -28862, -28898, -28956, -29034, -29127, -29237, -29360, -29492, -29631, -29777, -29923, -30074, -30225, -30371, -30516, -30658, -30793, -30924, -31049, -31168, -31280, -31386, -31485, -31577, -31665, -31744, -31821, -31891, -31955, -32014, -32069, -32120, -32165, -32208, -32246, -32282, -32314, -32343, -32371, -32395, -32416, -32436, -32453, -32468, -32482, -32494, -32504, -32514, -32521, -32527, -32531, -32534, -32535, -32534, -32534, -32532, -32526, -32520, -32514, -32506, -32494, -32482, -32466, -32448, -32427, -32404, -32378, -32349, -32315, -32277, -32233, -32185, -32128, -32065, -31994, -31911, -31818, -31712, -31590, -31451, -31290, -31105, -30888, -30637, -30342, -29995, -29581, -29083, -28481, -27709};