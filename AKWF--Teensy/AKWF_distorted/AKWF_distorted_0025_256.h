/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0025 256 samples */
 
const int16_t AKWF_distorted_0025_256_DATA [256] = 
{4663, 11847, 11013, 4449, 4335, 14261, 17305, 12569, 7183, 10421, 16857, 19075, 16379, 12033, 13869, 19447, 21108, 17483, 13722, 17009, 21429, 20640, 15950, 15628, 20443, 21994, 19736, 17606, 17784, 18884, 20806, 22020, 20758, 19347, 20558, 21859, 22344, 23503, 24307, 23903, 23695, 24622, 25639, 26246, 26940, 27718, 27667, 26727, 27543, 29755, 30358, 28647, 27371, 29422, 31146, 30906, 29305, 28835, 30502, 31350, 30661, 29557, 30232, 31100, 30416, 29270, 29905, 30730, 30160, 28755, 27298, 26529, 27925, 29646, 27430, 20488, 22997, 30563, 4268, -32145, -17573, 27367, 852, -34174, -32135, -24512, -23933, -32228, -32549, -31924, -31691, -32386, -32674, -32542, -32285, -32356, -32675, -32780, -32355, -31405, -31753, -32552, -32458, -30571, -28659, -30198, -31251, -30073, -25367, -20542, -22637, -25538, -22442, -1845, 11394, -4970, -10237, 10716, 21551, 15167, 5622, 13675, 22542, 19533, 6175, 3746, 15470, 17399, 3192, -13144, -11746, -3271, -8369, -19431, -21285, -18157, -19764, -24361, -24528, -22169, -23152, -25799, -25609, -23841, -23239, -23504, -23218, -22354, -20912, -19727, -19541, -17924, -9688, 323, -4547, -11914, -2055, 14637, 17992, 15218, 13745, 16292, 19701, 21924, 22225, 21489, 21758, 22344, 20998, 19152, 20902, 23541, 22029, 14912, 12161, 18602, 21337, 14846, 2697, 3535, 10409, 7502, -1779, -6639, -8202, -6577, -2575, -8043, -16018, -13652, -5199, -8487, -16201, -15251, -10604, -9937, -11816, -11791, -9409, -5795, -5593, -8248, -7057, -2758, 323, 3637, 5564, 3562, 3530, 6991, 8466, 9607, 11084, 6611, -1499, 3189, 13328, 13763, 1214, -9648, -3870, 9185, 10214, -5822, -16481, -10383, 2879, -2643, -14934, -14274, -9239, -12747, -17075, -13375, -8125, -12322, -18303, -18165, -12876, -8626, -10435, -14093, -16117, -14689, -6992, -1646, -8712, -13263, -5958, 1677, -4958, -7639, 2737, 7994, 265, -3633};