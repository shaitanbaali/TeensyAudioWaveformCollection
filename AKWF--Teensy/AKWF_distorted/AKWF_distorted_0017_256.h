/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0017 256 samples */
 
const int16_t AKWF_distorted_0017_256_DATA [256] = 
{1272, 4469, 7263, 9772, 12013, 14022, 15823, 17435, 18886, 20195, 21378, 22452, 23432, 24324, 25142, 25893, 26581, 27217, 27803, 28342, 28842, 29301, 29724, 30117, 30475, 30805, 31104, 31377, 31624, 31845, 32041, 32212, 32360, 32486, 32587, 32666, 32721, 32739, 32828, 32447, 30838, 29808, 28939, 28140, 27390, 26676, 25984, 25304, 24642, 23982, 23327, 22679, 22029, 21380, 20731, 20078, 19423, 18764, 18102, 17435, 16764, 16087, 15405, 14720, 14025, 13330, 12628, 11916, 11205, 10487, 9761, 9034, 8302, 7564, 6824, 6078, 5328, 4579, 3826, 3067, 2309, 1549, 788, 27, -735, -1499, -2260, -3021, -3782, -4539, -5297, -6051, -6801, -7546, -8291, -9031, -9767, -10495, -11221, -11943, -12654, -13361, -14061, -14756, -15454, -15503, -15228, -15005, -14777, -14552, -14331, -14113, -13900, -13690, -13483, -13283, -13085, -12893, -12705, -12523, -12343, -12172, -12003, -11839, -11680, -11527, -11378, -11234, -11096, -10962, -10834, -10709, -10590, -10476, -10366, -10261, -10161, -10064, -9973, -9885, -9801, -9723, -9648, -9577, -9510, -9447, -9388, -9332, -9281, -9232, -9186, -9144, -9104, -9070, -9037, -9006, -8979, -8955, -8933, -8914, -8897, -8882, -8870, -8859, -8851, -8844, -8841, -8838, -8837, -8838, -8841, -8844, -8850, -8857, -8865, -8874, -8886, -8896, -8909, -8922, -8937, -8952, -8968, -8984, -9003, -9019, -9037, -9057, -9077, -9095, -9116, -9136, -9156, -9177, -9199, -9219, -9240, -9261, -9282, -9303, -9324, -9345, -9365, -9386, -9407, -9425, -9446, -9465, -9483, -9503, -9520, -9539, -9555, -9572, -9589, -9606, -9621, -9636, -9650, -9664, -9677, -9690, -9701, -9712, -9723, -9732, -9742, -9750, -9758, -9765, -9771, -9776, -9782, -9786, -9789, -9792, -9793, -9795, -9794, -9795, -9793, -9791, -9788, -9784, -9776, -9784, -9744, -8631, -8907, -10157, -11644, -13467, -14248, -10341, -5992, -2124};