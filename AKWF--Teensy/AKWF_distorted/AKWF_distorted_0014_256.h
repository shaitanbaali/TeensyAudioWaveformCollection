/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0014 256 samples */
 
const int16_t AKWF_distorted_0014_256_DATA [256] = 
{30964, 30964, 30964, 30964, 30965, 30965, 30964, 30964, 30964, 30965, 30964, 30963, 30964, 30962, 30961, 30960, 30959, 30959, 30958, 30957, 30956, 30955, 30954, 30952, 30951, 30950, 30948, 30948, 30947, 30945, 30943, 30942, 30940, 30939, 30938, 30938, 30935, 30933, 30932, 30931, 30930, 30929, 30927, 30926, 30924, 30923, 30921, 30921, 30920, 30917, 30916, 30914, 30914, 30912, 30911, 30908, 30907, 30905, 30905, 30904, 30902, 30899, 30898, 30898, 30896, 30895, 30893, 30892, 30890, 30888, 30887, 30886, 30884, 30883, 30881, 30880, 30879, 30877, 30876, 30874, 30873, 30871, 30870, 30868, 30867, 30865, 30864, 30862, 30861, 30859, 30858, 30856, 30855, 30853, 30852, 30850, 30849, 30847, 30846, 30844, 30843, 30841, 30840, 30839, 30837, 30837, 30834, 30832, 30831, 30830, 30828, 30828, 30825, 30823, 30822, 30821, 30819, 30819, 30816, 30814, 30814, 30812, 30810, 30809, 30808, 30806, 30805, 30803, 30802, 30800, 30799, 30797, 30794, 30794, 30793, 30791, 30790, 30788, 30787, 30785, 30783, 30766, 30278, 33230, -15868, -31910, -28324, -28963, -28964, -28964, -28965, -28967, -28966, -28967, -28965, -28964, -28965, -28964, -28963, -28962, -28961, -28959, -28958, -28957, -28956, -28954, -28952, -28950, -28948, -28947, -28945, -28943, -28940, -28939, -28938, -28935, -28994, -28659, -31448, -33029, -32709, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32704, -33045, -30057, -28443, -28765, -28699, -28694, -28688, -28684, -28678, -28673, -28667, -28664, -28659, -28657, -28653, -28649, -28646, -28642, -28639, -28636, -28632, -28628, -28625, -28622, -28620, -28617, -28615, -28612, -28609, -28607, -28604, -28602, -28599, -28597, -28593, -28590, -28588, -28586, -28583, -28581, -28579, -28576, -28574, -28571};