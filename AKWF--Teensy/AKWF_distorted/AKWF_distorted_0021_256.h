/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0021 256 samples */
 
const int16_t AKWF_distorted_0021_256_DATA [256] = 
{4161, 11933, 17289, 21194, 24050, 26160, 27737, 28926, 29831, 30530, 31068, 31488, 31815, 32069, 32267, 32421, 32537, 32624, 32685, 32725, 32745, 32748, 32732, 32698, 32645, 32572, 32475, 32353, 32202, 32018, 31798, 31537, 31228, 30870, 30452, 29970, 29418, 28785, 28060, 27236, 26293, 25214, 23989, 22602, 21044, 19323, 17448, 15459, 13405, 11337, 9329, 7451, 5749, 4279, 3088, 2195, 1623, 1375, 1445, 1808, 2428, 3253, 4234, 5322, 6472, 7653, 8838, 10011, 11145, 12235, 13262, 14207, 15054, 15787, 16397, 16880, 17237, 17469, 17586, 17596, 17509, 17334, 17072, 16725, 16292, 15764, 15138, 14396, 13527, 12511, 11306, 9879, 8175, 6117, 3632, 589, -2824, -6151, -9300, -12222, -14857, -17192, -19225, -20960, -22429, -23660, -24680, -25525, -26224, -26799, -27279, -27683, -28027, -28328, -28600, -28850, -29085, -29307, -29518, -29715, -29897, -30059, -30196, -30307, -30384, -30427, -30433, -30400, -30326, -30208, -30046, -29839, -29590, -29302, -28978, -28628, -28256, -27872, -27488, -27105, -26731, -26367, -26010, -25652, -25284, -24890, -24454, -23957, -23380, -22708, -21925, -21019, -19988, -18841, -17580, -16229, -14812, -13347, -11865, -10385, -8909, -7456, -6013, -4569, -3100, -1569, 75, 1788, 3533, 5336, 7184, 9071, 10968, 12832, 14634, 16341, 17930, 19395, 20729, 21935, 23025, 24005, 24879, 25663, 26357, 26970, 27508, 27978, 28385, 28737, 29039, 29294, 29506, 29677, 29807, 29896, 29943, 29947, 29906, 29816, 29674, 29474, 29210, 28865, 28425, 27865, 27149, 26232, 25053, 23519, 21515, 18891, 15409, 10813, 4628, -3176, -10166, -15580, -19814, -23049, -25497, -27340, -28714, -29737, -30501, -31072, -31499, -31823, -32068, -32257, -32403, -32514, -32600, -32666, -32712, -32745, -32762, -32767, -32758, -32732, -32687, -32618, -32519, -32379, -32185, -31912, -31532, -30998, -30246, -29187, -27686, -25575, -22622, -18526, -12936, -5067};