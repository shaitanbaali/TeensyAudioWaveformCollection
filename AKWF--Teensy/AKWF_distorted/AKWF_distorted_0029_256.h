/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0029 256 samples */
 
const int16_t AKWF_distorted_0029_256_DATA [256] = 
{29259, 29659, 29581, 29595, 29598, 29617, 29513, 30014, 31882, 31948, 31924, 31931, 31931, 31932, 31928, 31949, 32050, 32057, 32055, 32053, 32052, 32057, 32032, 32144, 32512, 32520, 32516, 32517, 32514, 32515, 32513, 32523, 32560, 32560, 32558, 32559, 32558, 32559, 32557, 32565, 32598, 32598, 32596, 32597, 32596, 32598, 32592, 32616, 32690, 32689, 32688, 32688, 32688, 32689, 32685, 32704, 32752, 32752, 32751, 32750, 32751, 32751, 32751, 32750, 32764, 32768, 32766, 32765, 32766, 32765, 32766, 32766, 32764, 32763, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32763, 32764, 32762, 32761, 32762, 32761, 32762, 32761, 32759, 32760, 32759, 32760, 32759, 32757, 32758, 32758, 32758, 32758, 32758, 32758, 32757, 32758, 32758, 32755, 32754, 32755, 32754, 32755, 32754, 32753, 32752, 32737, 32734, 32735, 32734, 32732, 32273, 34758, 24516, -32031, -32978, -32584, -32719, -32720, -32719, -32719, -32719, -32719, -32719, -32719, -32719, -32719, -32719, -32720, -32716, -32696, -32694, -32694, -32694, -32693, -32693, -32693, -32693, -32693, -32693, -32694, -32691, -32690, -32690, -32691, -32686, -32664, -32662, -32663, -32663, -32662, -32661, -32660, -32661, -32659, -32657, -32658, -32658, -32656, -32655, -32656, -32655, -32655, -32656, -32655, -32654, -32653, -32653, -32652, -32651, -32652, -32651, -32651, -32651, -32652, -32650, -32649, -32650, -32623, -32612, -32614, -32613, -32614, -32612, -32611, -32611, -32610, -32609, -32610, -32609, -32610, -32609, -32607, -32608, -32635, -32643, -32640, -32641, -32639, -32638, -32639, -32638, -32609, -32600, -32601, -32601, -32600, -32600, -32601, -32597, -32564, -32556, -32557, -32556, -32554, -32554, -32557, -32543, -32351, -32306, -32315, -32311, -32310, -32305, -32317, -32270, -31457, -31279, -31318, -31305, -31305, -31297, -31313, -31233, -30444, -30306, -30337, -30327, -30322, -30298, -30372, -30077, -25098, -24009, -24270, -24208, -24182, -23816, -25721, -15709};