/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0040 256 samples */
 
const int16_t AKWF_distorted_0040_256_DATA [256] = 
{1590, 4636, 7535, 10412, 13313, 15135, 15803, 16456, 17043, 17570, 18050, 18499, 18914, 19303, 19667, 20019, 20330, 20646, 22804, 25100, 26532, 27621, 28456, 29122, 29662, 30105, 30475, 30786, 31050, 31277, 31471, 31639, 31787, 31914, 32025, 32123, 32208, 32284, 32351, 32409, 32463, 32509, 32549, 32586, 32618, 32647, 32672, 32696, 32716, 32734, 32741, 32741, 32743, 32743, 32745, 32747, 32748, 32748, 32749, 32752, 32753, 32753, 32754, 32753, 32767, 32712, 32478, 32439, 32391, 32340, 32281, 32217, 32145, 32066, 31976, 31876, 31764, 31636, 31493, 31331, 31149, 30935, 30871, 30901, 30917, 30935, 30952, 30970, 30988, 31004, 31022, 31039, 31056, 31072, 31089, 31105, 31121, 31138, 31153, 31169, 31184, 31200, 31215, 31231, 31245, 31259, 31273, 31288, 31303, 31317, 31331, 31344, 31356, 31374, 31262, 31060, 30839, 30584, 30290, 29948, 29547, 29072, 28502, 27806, 26945, 25842, 24377, 22082, 20127, 3592, -18190, -21563, -23878, -25504, -26687, -27600, -28334, -28934, -29430, -29850, -30206, -30512, -30777, -31007, -31207, -31386, -31432, -31411, -31399, -31388, -31374, -31359, -31347, -31334, -31320, -31305, -31290, -31276, -31263, -31248, -31232, -31217, -31201, -31186, -31171, -31156, -31140, -31124, -31108, -31092, -31076, -31059, -31042, -31025, -31007, -30991, -30974, -30953, -31088, -31289, -31454, -31601, -31731, -31848, -31952, -32044, -32126, -32199, -32266, -32326, -32378, -32429, -32459, -32558, -32763, -32750, -32750, -32750, -32749, -32748, -32747, -32745, -32743, -32743, -32742, -32740, -32740, -32738, -32736, -32735, -32723, -32702, -32681, -32656, -32628, -32597, -32563, -32524, -32478, -32428, -32372, -32309, -32237, -32154, -32060, -31953, -31832, -31692, -31533, -31347, -31131, -30882, -30588, -30238, -29822, -29320, -28701, -27931, -26939, -25622, -23803, -20781, -19136, -18914, -18456, -18010, -17518, -16989, -16405, -15750, -15032, -13032, -10150, -7270, -4343, -1286};