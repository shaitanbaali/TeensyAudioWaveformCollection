/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0024 256 samples */
 
const int16_t AKWF_distorted_0024_256_DATA [256] = 
{4779, 12547, 17328, 20755, 23220, 25073, 26487, 27589, 28464, 29167, 29737, 30205, 30594, 30917, 31192, 31423, 31619, 31786, 31929, 32049, 32150, 32235, 32305, 32362, 32408, 32445, 32473, 32495, 32510, 32521, 32527, 32529, 32527, 32521, 32512, 32499, 32482, 32462, 32437, 32409, 32378, 32342, 32303, 32259, 32210, 32156, 32096, 32030, 31957, 31877, 31791, 31696, 31593, 31483, 31365, 31237, 31101, 30953, 30795, 30626, 30445, 30253, 30048, 29830, 29595, 29342, 29067, 28763, 28425, 28044, 27609, 27113, 26541, 25875, 25104, 24205, 23159, 21938, 20523, 18886, 17005, 14857, 12440, 9772, 6859, 3753, 497, -2524, -4890, -6750, -8238, -9449, -10455, -11318, -12069, -12740, -13374, -13989, -14604, -15244, -15915, -16626, -17378, -18152, -18943, -19733, -20499, -21226, -21904, -22524, -23080, -23577, -24014, -24397, -24728, -25012, -25255, -25456, -25616, -25735, -25817, -25860, -25862, -25828, -25760, -25659, -25523, -25356, -25160, -24928, -24665, -24374, -24052, -23704, -23343, -22976, -22615, -22278, -21983, -21726, -21516, -21352, -21214, -21091, -20959, -20804, -20602, -20332, -19977, -19519, -18937, -18204, -17301, -16186, -14805, -13112, -11019, -8418, -5203, -1138, 3341, 7162, 10333, 12966, 15132, 16908, 18354, 19527, 20478, 21244, 21842, 22285, 22584, 22748, 22783, 22696, 22491, 22175, 21749, 21221, 20596, 19876, 19064, 18156, 17138, 15992, 14675, 13143, 11317, 9103, 6384, 2950, -1335, -5542, -9203, -12435, -15260, -17746, -19938, -21858, -23539, -25006, -26276, -27371, -28305, -29094, -29758, -30313, -30772, -31153, -31466, -31725, -31938, -32113, -32255, -32371, -32465, -32541, -32602, -32650, -32688, -32716, -32738, -32752, -32762, -32767, -32767, -32764, -32757, -32746, -32729, -32708, -32682, -32651, -32612, -32566, -32510, -32444, -32364, -32266, -32146, -31997, -31810, -31573, -31269, -30879, -30373, -29714, -28856, -27732, -26252, -24285, -21671, -18079, -13218, -5756};