/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0026 256 samples */
 
const int16_t AKWF_distorted_0026_256_DATA [256] = 
{3006, 7516, 13479, 20172, 22735, 24570, 26524, 27504, 28001, 28212, 28043, 28333, 28044, 28787, 30045, 30635, 30610, 30790, 30835, 30287, 29691, 29301, 29045, 29623, 31137, 32260, 32656, 32750, 32758, 32617, 32205, 31732, 31339, 30318, 29001, 28951, 28791, 27437, 26007, 25674, 23240, 22104, 20421, 14153, 1176, -2259, -3713, -13975, -23097, -27118, -28763, -29657, -29650, -28489, -26504, -21322, -8893, -1365, -5048, -5588, -85, -262, -4282, -6201, -5632, -287, 8432, 14333, 14814, 16215, 18443, 18851, 17044, 17393, 19329, 18480, 12539, -2833, -18731, -25370, -27818, -28946, -29786, -29958, -29687, -29526, -29491, -29308, -29143, -29515, -30011, -30358, -30630, -30760, -30489, -29963, -29550, -29108, -28483, -27837, -26831, -24097, -18274, -9726, 1968, 9732, 10149, 5785, -833, -7918, -13806, -17226, -18747, -19494, -19473, -17866, -15947, -16646, -18692, -20887, -23105, -24796, -25587, -26160, -26946, -27707, -28414, -29060, -29371, -29110, -28336, -27096, -25023, -21832, -17436, -12053, -5673, -46, 1515, 823, 1218, 2965, 6572, 12154, 16736, 19299, 20804, 21302, 21144, 20963, 20897, 20369, 19011, 16516, 11490, 1389, -9724, -16217, -19925, -22332, -23877, -24240, -23714, -22693, -21013, -19575, -19408, -19664, -19336, -17930, -15392, -9751, -2827, 14, 1308, 4810, 8636, 13620, 18002, 19673, 20423, 21045, 21665, 22594, 23262, 22887, 21563, 18869, 14475, 11375, 11272, 12201, 13323, 13763, 11057, 6852, 5784, 5068, 4789, 6984, 6768, 3573, 2688, 2067, 542, 1740, 3768, 2884, 1149, 2621, 5782, 9085, 13409, 16508, 16172, 15231, 14378, 11839, 10583, 9075, 5478, 3042, -983, -8367, -12415, -13348, -15546, -16664, -15350, -15604, -16638, -14059, -11931, -14729, -16367, -18247, -21941, -23830, -24768, -26118, -26959, -26911, -26606, -26333, -25040, -22617, -20852, -19601, -17817, -16626, -14145, -10914, -10601, -10878, -7838, -2591};