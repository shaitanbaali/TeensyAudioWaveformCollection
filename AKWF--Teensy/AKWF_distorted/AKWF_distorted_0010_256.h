/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0010 256 samples */
 
const int16_t AKWF_distorted_0010_256_DATA [256] = 
{2231, 5628, 5691, 7285, 8411, 5879, 7170, 13129, 17211, 19778, 21799, 23478, 24901, 26100, 27098, 27918, 28587, 29141, 29599, 29983, 30309, 30587, 30826, 31033, 31213, 31371, 31511, 31634, 31744, 31840, 31929, 32008, 32079, 32143, 32202, 32254, 32303, 32348, 32388, 32425, 32459, 32490, 32519, 32546, 32570, 32592, 32612, 32631, 32648, 32664, 32678, 32691, 32703, 32714, 32724, 32732, 32739, 32747, 32752, 32756, 32761, 32764, 32767, 32767, 32768, 32768, 32767, 32766, 32764, 32760, 32755, 32750, 32745, 32738, 32729, 32721, 32711, 32701, 32689, 32676, 32662, 32646, 32628, 32610, 32589, 32567, 32544, 32517, 32489, 32458, 32425, 32389, 32349, 32305, 32257, 32206, 32149, 32086, 32016, 31939, 31855, 31761, 31654, 31535, 31400, 31247, 31074, 30874, 30642, 30374, 30056, 29677, 29225, 28673, 27991, 27136, 26035, 24609, 22672, 19186, 16315, 16900, 16946, 15134, 14268, 12607, 9025, 3377, -2258, -5518, -5600, -7212, -8340, -5796, -7088, -13073, -17171, -19748, -21776, -23459, -24886, -26088, -27088, -27910, -28580, -29136, -29595, -29979, -30305, -30584, -30823, -31031, -31212, -31370, -31509, -31632, -31742, -31840, -31928, -32007, -32078, -32143, -32201, -32254, -32302, -32347, -32388, -32424, -32459, -32490, -32519, -32545, -32569, -32592, -32611, -32630, -32647, -32663, -32678, -32691, -32703, -32714, -32724, -32732, -32739, -32746, -32752, -32757, -32760, -32763, -32766, -32767, -32768, -32768, -32767, -32765, -32763, -32760, -32755, -32750, -32745, -32738, -32729, -32721, -32711, -32700, -32689, -32676, -32661, -32645, -32628, -32610, -32589, -32567, -32543, -32517, -32488, -32457, -32424, -32387, -32347, -32304, -32256, -32206, -32148, -32085, -32016, -31939, -31854, -31759, -31652, -31533, -31399, -31245, -31072, -30872, -30640, -30370, -30053, -29674, -29221, -28667, -27984, -27126, -26023, -24593, -22651, -19152, -16272, -16858, -16906, -15090, -14219, -12565, -8979, -3206};