/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0023 256 samples */
 
const int16_t AKWF_distorted_0023_256_DATA [256] = 
{3038, 10346, 15666, 19946, 23206, 25755, 27641, 29024, 30062, 30819, 31375, 31777, 32077, 32296, 32457, 32571, 32655, 32711, 32746, 32764, 32766, 32745, 32726, 32692, 32634, 32579, 32496, 32408, 32306, 32179, 32049, 31893, 31733, 31545, 31350, 31116, 30866, 30609, 30314, 30015, 29664, 29317, 28938, 28557, 28113, 27696, 27217, 26733, 26236, 25732, 25207, 24663, 24089, 23517, 22912, 22267, 21666, 20979, 20307, 19627, 18838, 18078, 17314, 16371, 15502, 14565, 13498, 12484, 11345, 10157, 8898, 7512, 6112, 4547, 2989, 1326, -596, -2331, -3908, -5591, -7087, -8516, -9962, -11149, -12340, -13499, -14583, -15573, -16500, -17387, -18255, -19076, -19799, -20564, -21203, -21834, -22457, -23023, -23600, -24120, -24615, -25085, -25529, -25951, -26386, -26747, -27120, -27476, -27789, -28115, -28394, -28678, -28941, -29187, -29419, -29643, -29841, -30046, -30224, -30389, -30557, -30687, -30827, -30948, -31052, -31160, -31251, -31336, -31418, -31480, -31543, -31594, -31629, -31664, -31691, -31706, -31711, -31708, -31692, -31665, -31619, -31557, -31476, -31364, -31228, -31040, -30792, -30480, -30051, -29518, -28820, -27877, -26620, -24966, -22705, -19688, -15564, -10080, -2562, 6026, 12534, 17444, 21111, 23805, 25782, 27215, 28283, 29069, 29637, 30044, 30328, 30510, 30622, 30671, 30645, 30574, 30443, 30259, 30014, 29695, 29318, 28866, 28337, 27732, 27005, 26168, 25266, 24163, 23005, 21739, 20250, 18675, 16916, 15013, 13134, 10921, 8663, 6278, 3690, 1064, -1564, -3828, -5938, -7949, -9667, -11110, -12627, -13784, -14934, -16015, -16908, -17900, -18652, -19427, -20139, -20758, -21408, -21977, -22574, -23071, -23566, -24024, -24475, -24885, -25267, -25669, -25989, -26305, -26620, -26866, -27122, -27361, -27568, -27754, -27902, -28030, -28138, -28206, -28249, -28234, -28188, -28106, -27967, -27740, -27436, -27056, -26560, -25912, -25027, -23930, -22468, -20593, -18118, -14819, -10562, -4519};