/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0016 256 samples */
 
const int16_t AKWF_distorted_0016_256_DATA [256] = 
{344, 1448, 2537, 3641, 4755, 5880, 7018, 8159, 9308, 10458, 11604, 12748, 13883, 15003, 16111, 17198, 18264, 19306, 20321, 21303, 22255, 23173, 24052, 24896, 25700, 26462, 27186, 27866, 28503, 29099, 29647, 30154, 30617, 31032, 31405, 31733, 32015, 32252, 32446, 32594, 32690, 32737, 32843, 30288, 27788, 26239, 24840, 23605, 22491, 21463, 20506, 19613, 18770, 17972, 17216, 16493, 15805, 15147, 14516, 13911, 13329, 12768, 12230, 11710, 11208, 10724, 10255, 9802, 9364, 8941, 8529, 8132, 7746, 7371, 7008, 6656, 6313, 5980, 5656, 5340, 5035, 4738, 4448, 4165, 3891, 3623, 3364, 3109, 2861, 2620, 2385, 2155, 1931, 1712, 1498, 1290, 1086, 887, 693, 503, 317, 135, -42, -215, -384, -551, -713, -873, -1029, -1184, -1340, -1495, -1650, -1806, -1962, -2117, -2272, -2428, -2582, -2739, -2894, -3049, -3205, -3360, -3515, -3669, -3824, -3978, -4133, -4286, -4441, -4595, -4748, -4901, -5054, -5207, -5358, -5510, -5661, -5813, -5963, -6112, -6263, -6413, -6560, -6708, -6856, -7002, -7149, -7295, -7439, -7583, -7727, -7869, -8011, -8153, -8293, -8433, -8571, -8708, -8845, -8981, -9115, -9249, -9382, -9514, -9644, -9774, -9903, -10031, -10156, -10282, -10406, -10528, -10649, -10770, -10888, -11006, -11122, -11237, -11350, -11462, -11573, -11683, -11791, -11896, -12002, -12106, -12207, -12307, -12406, -12503, -12601, -12694, -12786, -12878, -12967, -13055, -13140, -13224, -13306, -13388, -13467, -13544, -13622, -13694, -13766, -13837, -13905, -13972, -14038, -14100, -14162, -14222, -14279, -14335, -14388, -14442, -14492, -14539, -14586, -14631, -14674, -14714, -14753, -14790, -14826, -14859, -14890, -14918, -14946, -14972, -14995, -15016, -15035, -15053, -15069, -15082, -15094, -15103, -15110, -15117, -15121, -15123, -15123, -15120, -15116, -15110, -15016, -15434, -12790, -7713, -5385, -3484, -1983, -718};