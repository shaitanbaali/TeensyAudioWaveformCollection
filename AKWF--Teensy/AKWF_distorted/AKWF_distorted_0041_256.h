/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0041 256 samples */
 
const int16_t AKWF_distorted_0041_256_DATA [256] = 
{5855, 17224, 19395, 21353, 22768, 23888, 24811, 25580, 26242, 26817, 27319, 27763, 28157, 28510, 28828, 29116, 29377, 29616, 29833, 30034, 30217, 30385, 30541, 30686, 30819, 30944, 31060, 31168, 31268, 31361, 31450, 31531, 31607, 31678, 31747, 31810, 31868, 31924, 31977, 32026, 32072, 32115, 32157, 32196, 32233, 32267, 32299, 32331, 32360, 32387, 32412, 32438, 32462, 32483, 32504, 32523, 32542, 32560, 32577, 32593, 32608, 32622, 32636, 32647, 32660, 32672, 32683, 32691, 31665, 37298, -1658, -35356, -29990, -30841, -30717, -30575, -30423, -30258, -30077, -29883, -29670, -29436, -29180, -28900, -28589, -28245, -27862, -27429, -26944, -26390, -25749, -25007, -24126, -23056, -21726, -19873, -17934, -9878, 8216, 17604, 19649, 21553, 22931, 24018, 24804, 25872, 25966, -25247, -34195, -31971, -32346, -32316, -32284, -32250, -32213, -32176, -32136, -32094, -32050, -32002, -31951, -31897, -31839, -31778, -31713, -31643, -31569, -31490, -31406, -31316, -31219, -31114, -31003, -30884, -30755, -30616, -30465, -30302, -30127, -29935, -29726, -29500, -29251, -28976, -28674, -28338, -27964, -27549, -27077, -26539, -25926, -25212, -24370, -23362, -22105, -20412, -18505, -13271, 3520, 16376, 19164, 21118, 22603, 23755, 24698, 25489, 26164, 26747, 27257, 27708, 28108, 28466, 28790, 29080, 29345, 29585, 29806, 30008, 30194, 30364, 30522, 30667, 30803, 30929, 31046, 31154, 31256, 31349, 31437, 31520, 31598, 31670, 31737, 31800, 31861, 31914, 30844, 36947, -6473, -37286, -31452, -32511, -32491, -32470, -32447, -32423, -32397, -32370, -32341, -32311, -32280, -32246, -32209, -32171, -32132, -32089, -32044, -31995, -31943, -31889, -31832, -31770, -31704, -31634, -31560, -31480, -31394, -31303, -31206, -31100, -30988, -30868, -30736, -30596, -30445, -30280, -30103, -29909, -29698, -29468, -29215, -28938, -28631, -28293, -27914, -27488, -27011, -26464, -25839, -25112, -24248, -23212, -21921, -20160, -18341, -11585};