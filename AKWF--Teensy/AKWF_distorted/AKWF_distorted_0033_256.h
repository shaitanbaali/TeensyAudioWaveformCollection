/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0033 256 samples */
 
const int16_t AKWF_distorted_0033_256_DATA [256] = 
{18950, 25491, 28013, 29698, 30727, 31397, 31856, 32165, 32366, 32500, 32591, 32656, 32697, 32726, 32746, 32759, 32766, 32767, 32765, 32761, 32750, 32736, 32714, 32685, 32644, 32583, 32494, 32364, 32164, 31853, 31363, 30584, 29163, 27411, 20128, -15321, -26284, -27572, -28999, -29665, -30067, -30359, -30549, -30657, -30708, -30727, -30711, -30645, -30521, -30350, -30133, -29845, -29427, -28887, -28166, -27123, -25558, -23059, -19947, 3175, 21111, 22566, 24475, 25399, 25917, 26145, 26078, 25641, 24926, 23802, 21736, 19877, 335, -20153, -22651, -25135, -26753, -27870, -28701, -29374, -29882, -30241, -30550, -30809, -30995, -31114, -31225, -31308, -31353, -31378, -31376, -31360, -31339, -31284, -31199, -31091, -30964, -30812, -30617, -30382, -30133, -29814, -29393, -28856, -28183, -27255, -25989, -24109, -22162, -13378, 13639, 21689, 23619, 25431, 26576, 27371, 27969, 28462, 28879, 29188, 29458, 29706, 29927, 30089, 30203, 30268, 30267, 30214, 30111, 29941, 29689, 29351, 28890, 28270, 27574, 26678, 25415, 23753, 21533, 19398, 6777, -13780, -18961, -20847, -22335, -23388, -24136, -24733, -25274, -25550, -25676, -25800, -25907, -25856, -25623, -25316, -25073, -24581, -23795, -22861, -21581, -19830, -18030, -9423, 5891, 15307, 17917, 19467, 20099, 20270, 20544, 20734, 20647, 20313, 19897, 19464, 18580, 17091, 15707, 9185, -1815, -12278, -17143, -18587, -19831, -20885, -21743, -22509, -23245, -23950, -24703, -25336, -25821, -26317, -26809, -27229, -27546, -27821, -28075, -28267, -28381, -28549, -28688, -28750, -28801, -28798, -28750, -28672, -28558, -28426, -28313, -28201, -27940, -27614, -27359, -27179, -26918, -26635, -26432, -26254, -26023, -25721, -25401, -25126, -24830, -24514, -24193, -23759, -23189, -22746, -22765, -22817, -22898, -23107, -23248, -23556, -24081, -24653, -25144, -25609, -26060, -26466, -26871, -27339, -27805, -28121, -28396, -28619, -28710, -28675, -28527, -28183, -27465, -26147, -24327, -16765};