/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0020 256 samples */
 
const int16_t AKWF_distorted_0020_256_DATA [256] = 
{2624, 8242, 12775, 16534, 19640, 22188, 24283, 25970, 27331, 28427, 29301, 30006, 30572, 31024, 31387, 31680, 31915, 32104, 32257, 32380, 32479, 32557, 32620, 32670, 32708, 32735, 32752, 32763, 32768, 32766, 32758, 32745, 32726, 32703, 32674, 32639, 32599, 32554, 32504, 32447, 32384, 32314, 32235, 32150, 32057, 31957, 31847, 31724, 31592, 31448, 31290, 31118, 30927, 30721, 30497, 30253, 29983, 29686, 29363, 29019, 28640, 28224, 27773, 27286, 26758, 26191, 25580, 24925, 24227, 23488, 22715, 21893, 21049, 20187, 19310, 18420, 17535, 16679, 15831, 15001, 14229, 13505, 12827, 12212, 11646, 11125, 10647, 10195, 9772, 9379, 8990, 8590, 8187, 7766, 7313, 6814, 6258, 5653, 5015, 4354, 3680, 2934, 2148, 1357, 510, -360, -1186, -1957, -2696, -3425, -4152, -4833, -5448, -6044, -6633, -7186, -7701, -8191, -8676, -9154, -9624, -10082, -10529, -10972, -11397, -11835, -12277, -12706, -13137, -13574, -14017, -14464, -14913, -15388, -15860, -16312, -16781, -17267, -17761, -18238, -18708, -19185, -19677, -20161, -20624, -21088, -21556, -22024, -22476, -22914, -23352, -23783, -24198, -24607, -24999, -25374, -25741, -26093, -26427, -26750, -27051, -27320, -27565, -27786, -27981, -28152, -28289, -28390, -28462, -28504, -28508, -28478, -28412, -28310, -28172, -27995, -27778, -27526, -27245, -26928, -26587, -26226, -25839, -25438, -25037, -24643, -24264, -23908, -23575, -23275, -23016, -22807, -22652, -22554, -22514, -22528, -22591, -22701, -22861, -23067, -23296, -23559, -23861, -24176, -24505, -24851, -25198, -25543, -25885, -26227, -26560, -26875, -27182, -27478, -27753, -28015, -28262, -28492, -28705, -28901, -29079, -29240, -29388, -29522, -29640, -29742, -29825, -29894, -29950, -29988, -30011, -30018, -30004, -29970, -29916, -29840, -29736, -29598, -29432, -29229, -28980, -28676, -28307, -27863, -27330, -26686, -25906, -24956, -23798, -22395, -20657, -18514, -15859, -12562, -8498, -3275};