/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0008 256 samples */
 
const int16_t AKWF_distorted_0008_256_DATA [256] = 
{26855, 30796, 32194, 32790, 32757, 32766, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32757, 31908, 36554, 9862, -35191, -32040, -32719, -32766, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32760, -32791, -32251, -31101, -30212, -29957, -29946, -29555, -28760, 15890, 32077, 31007, 32298, 32732, 32771, 32765, 32768, 32768, 32768, 32763, 32511, 33564, 27679, -22881, -34261, -32385, -32754, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32763, -32773, -32392, -30651, -33451, -2659, 33656, 30778, 32599, 32786, 32760, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32752, 31920, 36515, 8627, -35752, -31981, -32729, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32760, -32790, -32586, -31787, -30063, -31096, -13679, 28246, 29860, 32456, 22201, -29603, -33105, -32622, -32760, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32752, -32815, -32229, -30667, -27310};