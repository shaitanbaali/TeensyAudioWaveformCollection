/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0009 256 samples */
 
const int16_t AKWF_distorted_0009_256_DATA [256] = 
{13168, 24828, 28707, 30534, 31438, 31920, 32197, 32364, 32471, 32544, 32594, 32630, 32657, 32676, 32692, 32704, 32714, 32722, 32728, 32734, 32739, 32743, 32745, 32749, 32751, 32753, 32755, 32757, 32758, 32760, 32760, 32761, 32763, 32763, 32765, 32764, 32765, 32767, 32766, 32766, 32767, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32766, 32766, 32767, 32765, 32764, 32765, 32763, 32763, 32761, 32760, 32760, 32759, 32757, 32755, 32753, 32751, 32749, 32746, 32743, 32740, 32735, 32730, 32724, 32717, 32709, 32697, 32684, 32666, 32643, 32613, 32571, 32511, 32424, 32289, 32070, 31690, 30971, 29482, 26319, 15899, -9545, -25577, -29840, -31549, -32212, -32492, -32620, -32684, -32719, -32724, -32006, -36016, -5625, 34252, 31725, 32415, 32499, 32537, 32579, 32602, 32597, 32550, 32431, 32147, 31450, 29666, 25226, 10777, -13278, -24750, -28637, -30525, -31433, -31917, -32195, -32362, -32470, -32543, -32593, -32630, -32657, -32676, -32692, -32704, -32713, -32722, -32728, -32734, -32739, -32743, -32745, -32749, -32751, -32753, -32755, -32757, -32758, -32760, -32760, -32761, -32763, -32763, -32765, -32764, -32765, -32767, -32766, -32766, -32767, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32766, -32766, -32767, -32765, -32764, -32765, -32763, -32763, -32761, -32760, -32760, -32759, -32757, -32755, -32753, -32751, -32749, -32746, -32743, -32740, -32735, -32730, -32724, -32717, -32709, -32697, -32684, -32666, -32643, -32612, -32571, -32511, -32423, -32287, -32068, -31687, -30963, -29466, -26284, -15776, 9689, 25612, 29851, 31553, 32213, 32492, 32620, 32684, 32719, 32724, 32006, 36015, 5611, -34252, -31725, -32415, -32499, -32536, -32579, -32602, -32596, -32550, -32431, -32145, -31445, -29702, -25175, -10587};