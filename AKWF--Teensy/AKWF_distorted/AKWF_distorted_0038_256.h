/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0038 256 samples */
 
const int16_t AKWF_distorted_0038_256_DATA [256] = 
{32765, 32759, 32752, 32745, 32738, 32732, 32723, 32715, 32707, 32698, 32688, 32678, 32668, 32655, 32645, 32633, 32619, 32606, 32591, 32576, 32561, 32544, 32526, 32507, 32487, 32468, 32447, 32423, 32399, 32374, 32346, 32317, 32288, 32257, 32222, 32187, 32150, 32111, 32068, 32024, 31979, 31929, 31876, 31819, 31760, 31697, 31631, 31560, 31484, 31403, 31317, 31226, 31127, 31023, 30911, 30790, 30661, 30523, 30373, 30213, 30037, 29849, 29643, 29420, 29177, 28909, 28616, 28291, 27934, 27535, 27086, 26581, 26004, 25340, 24569, 23653, 22539, 21137, 19218, 17106, 6043, -831, 193, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -176, 710, -4110, -16237, -18972, -20885, -22358, -23503, -24444, -25235, -25912, -26501, -27017, -27472, -27878, -28242, -28570, -28868, -29139, -29386, -29612, -29820, -30010, -30188, -30351, -30502, -30642, -30771, -30893, -31008, -31112, -31212, -31304, -31391, -31473, -31549, -31621, -31687, -31751, -31811, -31868, -31922, -31972, -32018, -32062, -32105, -32144, -32182, -32217, -32252, -32284, -32313, -32342, -32370, -32395, -32420, -32443, -32465, -32484, -32504, -32523, -32541, -32559, -32574, -32589, -32604, -32617, -32631, -32643, -32654, -32666, -32676, -32687, -32697, -32705, -32714, -32722, -32731, -32737, -32744, -32719, -32678, -33330, -5334};