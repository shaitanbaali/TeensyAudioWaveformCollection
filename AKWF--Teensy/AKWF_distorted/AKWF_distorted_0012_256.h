/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0012 256 samples */
 
const int16_t AKWF_distorted_0012_256_DATA [256] = 
{15548, 15548, 15647, 15092, 21581, 24011, 24419, 28147, 28007, 28026, 28066, 27861, 29452, 30450, 30253, 30311, 30195, 30892, 31573, 31457, 31478, 31478, 31486, 31444, 31638, 32136, 32096, 32103, 32103, 32103, 32109, 32078, 32292, 32456, 32426, 32431, 32431, 32431, 32431, 32431, 32431, 32431, 32432, 32433, 32424, 32565, 32614, 32604, 32605, 32605, 32605, 32605, 32605, 32605, 32605, 32605, 32605, 32605, 32605, 32605, 32607, 32600, 32631, 32702, 32695, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32696, 32697, 32694, 32728, 32745, 32742, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32743, 32733, 32742, 32324, 32831, -14561, -33791, -31990, -32566, -32691, -32710, -32745, -32740, -32761, -32769, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32766, -32744, -32742, -32743, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32742, -32746, -32717, -32693, -32697, -32696, -32696, -32696, -32696, -32696, -32696, -32696, -32696, -32696, -32696, -32696, -32696, -32696, -32699, -32687, -32607, -32605, -32606, -32605, -32605, -32605, -32605, -32605, -32605, -32608, -32598, -32444, -32428, -32432, -32431, -32431, -32431, -32431, -32426, -32457, -32238, -32079, -32109, -32103, -32093, -32151, -31718, -31433, -31489, -31471, -31510, -31357, -30313, -30282, -30256, -30450, -29452, -27861, -28035, -28168, -27464, -23665, -24002, -22576, -15374, -16116, -13195, 183, -17};