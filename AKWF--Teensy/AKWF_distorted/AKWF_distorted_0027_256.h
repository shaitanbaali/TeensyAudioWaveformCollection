/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0027 256 samples */
 
const int16_t AKWF_distorted_0027_256_DATA [256] = 
{20850, 27956, 30105, 30751, 30881, 31174, 31429, 31421, 31296, 31233, 30913, 30558, 30070, 29480, 28330, 27321, 25783, 23793, 21975, 20882, 20896, 21805, 24190, 26132, 26997, 28333, 29532, 30287, 30056, 29663, 29234, 28998, 28333, 27315, 26287, 25750, 26635, 27020, 26462, 24587, 23653, 16002, -18073, -26505, -28060, -29139, -29829, -29772, -29695, -29251, -28314, -24568, -24073, -10078, 21579, 25067, 26359, 27026, 28137, 28913, 29350, 29910, 30138, 30234, 30542, 30958, 30935, 30581, 30958, 31853, 32271, 32021, 31575, 31959, 32383, 32106, 30572, 29579, 30776, 31463, 31036, 29168, 28193, 29535, 31454, 23044, -22705, -30876, -29058, -30410, -31967, -32359, -32287, -32114, -32139, -32325, -32350, -32149, -31984, -32073, -32150, -32161, -32108, -31917, -31666, -31405, -31019, -30818, -30522, -29978, -29485, -30171, -30995, -31297, -30821, -30729, -31273, -31508, -30753, -29875, -29975, -30289, -29619, -27751, -26220, -26050, -27031, -14751, 23787, 28714, 28776, 28974, 30355, 31219, 31129, 30403, 29982, 29975, 29753, 29169, 29004, 29033, 29333, 29677, 30225, 30132, 30112, 30339, 30540, 29912, 28935, 28614, 28291, 27754, 27933, 29243, 29917, 30504, 31039, 31054, 30349, 28838, 29333, 17589, -23182, -28730, -29166, -29524, -29975, -30249, -30339, -29978, -29171, -28653, -29203, -29382, -28184, -25965, -25113, -26913, -18683, 20738, 28812, 28493, 29102, 30054, 31227, 31282, 30464, 28944, 29514, 30461, 30169, 27880, 27491, 30089, 30792, 30337, 29442, 30360, 30977, 30963, 31113, 31991, 32552, 32601, 32484, 32585, 32764, 32695, 32099, 31299, 30327, 32785, 4354, -33257, -31006, -31354, -31564, -32310, -32613, -32620, -32526, -32578, -32728, -32757, -32653, -32575, -32584, -32520, -32341, -31817, -31013, -30898, -30959, -30005, -28978, -29697, -30774, -31195, -30878, -30836, -31323, -31380, -31068, -31016, -30999, -30743, -30677, -30592, -30437, -30267, -29324, -26421, -23279, -14495};