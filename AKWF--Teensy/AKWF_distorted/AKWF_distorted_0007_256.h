/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0007 256 samples */
 
const int16_t AKWF_distorted_0007_256_DATA [256] = 
{19025, 28710, 28688, 29677, 30274, 30756, 31161, 31508, 31814, 32086, 32330, 32555, 32744, 32771, 32766, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32766, 32772, 32737, 32547, 32321, 32078, 31804, 31497, 31147, 30740, 30255, 29655, 28516, 29078, 15996, -21769, -29132, -29441, -30709, -31544, -32292, -32765, -32767, -32766, -32767, -32767, -31873, -36810, -2949, 36514, 31949, 32762, 32768, 32765, 32768, 32755, 32268, 31515, 30677, 29360, 29284, 20921, -18569, -28879, -28586, -29677, -30274, -30756, -31161, -31508, -31815, -32086, -32330, -32555, -32744, -32771, -32766, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32772, -32737, -32547, -32321, -32078, -31804, -31497, -31147, -30740, -30255, -29655, -28516, -29078, -15997, 21769, 29132, 29440, 30709, 31544, 32292, 32765, 32767, 32766, 32768, 32768, 31856, 36877, 1488, -36593, -31930, -32763, -32767, -32765, -32768, -32755, -32268, -31516, -30677, -29463, -29146, -21238};