/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0013 256 samples */
 
const int16_t AKWF_distorted_0013_256_DATA [256] = 
{8856, 19596, 25248, 28480, 30315, 31358, 31953, 32295, 32493, 32610, 32679, 32721, 32747, 32764, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32766, 32756, 32739, 32714, 32674, 32614, 32516, 32359, 32103, 31679, 30981, 29803, 27819, 24477, 18883, 9079, -5627, -16938, -23345, -26869, -28494, -29730, -30756, -31438, -31855, -32114, -32285, -32406, -32497, -32566, -32618, -32657, -32686, -32706, -32722, -32732, -32741, -32747, -32746, -32758, -32586, -31314, -30158, -30070, -29657, -28221, -25167, -20236, -14387, -9314, -6014, -4235, -3270, -2626, -2008, -1420, -933, -587, -352, -204, -118, -73, -39, -18, -12, 61, -182, 1327, 8757, 16193, 21233, 24799, 27420, 29273, 30498, 31283, 31779, 32093, 32298, 32436, 32529, 32595, 32642, 32675, 32699, 32716, 32730, 32738, 32745, 32751, 32753, 32755, 32756, 32757, 32755, 32753, 32748, 32748, 32765, 32768, 32767, 32767, 32760, 32751, 32738, 32717, 32685, 32636, 32554, 32425, 32215, 31868, 31296, 30338, 28731, 26022, 21446, 13735, 394, -13201, -21149, -25835, -28633, -30282, -31265, -31853, -32207, -32422, -32555, -32638, -32690, -32723, -32745, -32760, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32762, -32750, -32730, -32700, -32653, -32580, -32462, -32272, -31959, -31441, -30582, -29134, -26684, -22569, -15678, -3437, 10689, 20740, 15868, -12559, -25631, -28873, -30751, -31732, -32247, -32506, -32637, -32704, -32740, -32760, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32762, -32744, -32716, -32671, -32596, -32471, -32255, -31884, -31238, -30105, -28110, -24591, -18436, -6729};