/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0039 256 samples */
 
const int16_t AKWF_distorted_0039_256_DATA [256] = 
{32041, 32125, 32199, 32265, 32324, 32377, 32423, 32464, 32502, 32534, 32564, 32590, 32613, 32634, 32651, 32668, 32683, 32695, 32707, 32718, 32725, 32734, 32740, 32745, 32750, 32755, 32759, 32762, 32764, 32765, 32767, 32768, 32768, 32766, 32765, 32763, 32761, 32758, 32753, 32748, 32743, 32738, 32730, 32722, 32714, 32702, 32690, 32677, 32661, 32644, 32625, 32603, 32580, 32552, 32521, 32486, 32447, 32403, 32355, 32300, 32238, 32168, 32091, 32003, 31905, 31796, 31671, 31535, 31379, 31207, 31014, 30798, 30557, 30287, 29988, 29653, 29278, 28862, 28398, 27880, 27307, 26668, 25955, 25169, 24293, 23320, 22246, 21046, 19717, 18225, 16673, 14400, 8988, 4335, 1385, 54, 418, 2461, 6060, 11492, 15723, 17287, 18896, 20305, 21574, 22718, 23747, 24678, 25515, 26270, 26950, 27559, 28107, 28602, 29046, 29443, 29800, 30120, 30405, 30663, 30894, 31100, 31282, 31448, 31595, 31041, 34783, 16532, -32571, -31731, -31541, -31535, -31379, -31207, -31014, -30798, -30557, -30287, -29988, -29653, -29279, -28863, -28398, -27880, -27308, -26669, -25955, -25169, -24293, -23320, -22246, -21046, -19717, -18226, -16674, -14400, -8989, -4336, -1386, -55, -419, -2461, -6061, -11492, -15723, -17288, -18896, -20306, -21574, -22719, -23748, -24678, -25515, -26271, -26950, -27560, -28107, -28602, -29046, -29443, -29800, -30120, -30405, -30664, -30894, -31100, -31282, -31448, -31595, -31726, -31844, -31948, -32042, -32125, -32198, -32265, -32324, -32377, -32423, -32464, -32502, -32534, -32564, -32590, -32613, -32634, -32651, -32668, -32683, -32695, -32707, -32718, -32725, -32734, -32740, -32745, -32750, -32755, -32759, -32762, -32764, -32765, -32767, -32768, -32768, -32766, -32765, -32763, -32761, -32758, -32753, -32748, -32743, -32738, -32730, -32722, -32714, -32702, -32690, -32677, -32661, -32644, -32625, -32603, -32580, -32552, -32521, -32486, -32447, -32403, -32355, -32300, -32238, -31613, -34520, -18430};