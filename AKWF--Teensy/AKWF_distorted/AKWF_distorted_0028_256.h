/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0028 256 samples */
 
const int16_t AKWF_distorted_0028_256_DATA [256] = 
{12004, 20793, 23123, 23582, 23999, 23742, 23080, 23501, 24967, 26684, 27622, 27192, 27252, 27703, 27994, 28557, 28444, 28805, 29329, 29151, 29410, 29655, 29669, 30344, 30588, 30771, 31073, 30998, 31301, 31510, 31499, 31704, 31667, 31782, 31977, 31948, 32099, 32182, 32184, 32322, 32326, 32325, 32397, 32373, 32450, 32513, 32493, 32528, 32515, 32541, 32590, 32585, 32629, 32636, 32627, 32645, 32622, 32627, 32649, 32680, 32700, 32603, 32458, 32458, 32546, 32601, 32658, 32739, 32354, 33964, 20598, -24175, -21599, 17370, 25031, 16394, 15343, 18064, 23940, 27700, 27238, 26735, 24627, 16625, -13354, -26752, -27491, -29017, -30210, -30273, -30528, -30662, -30836, -31124, -30943, -31042, -31129, -31056, -31395, -31466, -31543, -31740, -31723, -31766, -31744, -31688, -31734, -31752, -31832, -31882, -31886, -31828, -31763, -31815, -31839, -31834, -31809, -31722, -31763, -31730, -31700, -31835, -31779, -31799, -31835, -31746, -31827, -31773, -31728, -31737, -31574, -31554, -31573, -31486, -31439, -31353, -31291, -31376, -31360, -31255, -31221, -31038, -30864, -30859, -30750, -30652, -30699, -30504, -30419, -30380, -30090, -30112, -30167, -30087, -29945, -29570, -28990, -28733, -28806, -28781, -28942, -28342, -27503, -27836, -27804, -27936, -28023, -27098, -26649, -27016, -26331, -26408, -26145, -25365, -25833, -25284, -23931, -24186, -24211, -23965, -22444, -20222, -21474, -23666, -24304, -22485, -20949, -20629, -20821, -21787, -19419, -17708, -18821, -19904, -21201, -20850, -19575, -20728, -22073, -22014, -21370, -21219, -20788, -22892, -23275, -20994, -22019, -22177, -21806, -23029, -23731, -22867, -20155, -20164, -22481, -23099, -23750, -24730, -23943, -22652, -22921, -24222, -25233, -24465, -23149, -22862, -23782, -24350, -24671, -24897, -24678, -24682, -25125, -24791, -24278, -24507, -23700, -24223, -24229, -22814, -23427, -23101, -23835, -23561, -22283, -22869, -22000, -21793, -21988, -22824, -23645, -20042, -18053, -12902, -4843, -11511};