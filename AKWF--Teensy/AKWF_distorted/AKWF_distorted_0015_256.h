/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0015 256 samples */
 
const int16_t AKWF_distorted_0015_256_DATA [256] = 
{1977, 4656, 7046, 9241, 11245, 13084, 14767, 16306, 17710, 18998, 20174, 21249, 22235, 23134, 23958, 24713, 25401, 26033, 26610, 27137, 27620, 28061, 28465, 28835, 29173, 29481, 29764, 30023, 30259, 30476, 30673, 30855, 31020, 31172, 31310, 31437, 31553, 31658, 31756, 31840, 31465, 34198, -2316, -14182, -9214, -7609, -5258, -2688, 110, 2901, 5452, 7779, 9916, 11869, 13650, 15285, 16778, 18141, 19395, 20534, 21580, 22538, 23412, 24212, 24945, 25614, 26225, 26787, 27299, 27768, 28197, 28589, 28949, 29276, 29577, 29852, 30102, 30331, 30542, 30735, 30909, 31072, 31218, 31353, 31476, 31588, 31692, 31786, 31871, 31951, 32023, 32088, 32149, 32204, 32255, 32301, 32343, 32382, 32417, 32449, 32478, 32505, 32531, 32555, 32574, 32593, 32611, 32626, 32641, 32654, 32667, 32678, 32688, 32697, 32705, 32713, 32720, 32727, 32732, 32739, 32743, 32747, 32751, 32755, 32759, 31625, 37744, 4950, -37909, -31588, -32760, -32758, -32753, -32750, -32745, -32741, -32736, -32730, -32724, -32717, -32710, -32701, -32693, -32684, -32673, -32662, -32649, -32635, -32619, -32604, -32585, -32566, -32545, -32520, -32495, -32466, -32436, -32402, -32366, -32326, -32282, -32234, -32181, -32124, -32061, -31993, -31918, -31836, -31747, -31649, -31542, -31425, -31296, -31157, -31004, -30836, -30655, -30454, -30236, -29999, -29738, -29451, -29141, -28799, -28426, -28019, -27573, -27086, -26554, -25971, -25336, -24641, -23879, -23049, -22141, -21145, -20061, -18874, -17574, -16157, -14607, -12908, -11058, -9029, -6810, -4394, -1738, 1106, 3812, 6285, 8236, 11977, 7032, -31701, -32140, -31808, -31808, -31715, -31615, -31505, -31384, -31253, -31109, -30951, -30779, -30592, -30386, -30161, -29915, -29647, -29353, -29033, -28681, -28297, -27878, -27420, -26918, -26371, -25770, -25115, -24400, -23616, -22760, -21825, -20803, -19684, -18464, -17127, -15666, -14068, -12321, -10411, -8329, -6049, -3565, -785};