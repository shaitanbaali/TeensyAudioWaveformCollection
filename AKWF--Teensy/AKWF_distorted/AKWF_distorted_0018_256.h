/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0018 256 samples */
 
const int16_t AKWF_distorted_0018_256_DATA [256] = 
{3206, 8605, 13478, 17968, 22045, 25747, 26944, 27061, 27312, 27486, 27634, 27754, 27848, 27921, 27979, 28015, 28074, 27891, 28714, 31021, 30753, 30707, 30648, 30599, 30557, 30521, 30485, 30456, 30428, 30403, 30378, 30357, 30335, 30316, 30298, 30280, 30264, 30248, 30234, 30221, 30207, 30196, 30183, 30171, 30160, 30149, 30139, 30130, 30120, 30112, 30104, 30097, 30088, 30082, 30075, 30069, 30063, 30057, 30052, 30047, 30042, 30038, 30034, 30030, 30025, 30023, 30020, 30017, 30013, 30011, 30011, 30008, 30006, 30007, 30004, 30003, 30004, 30001, 30000, 30000, 29025, 34352, -10321, -35343, -30414, -31559, -31723, -31871, -32003, -32123, -32233, -32332, -32420, -32501, -32572, -32631, -32682, -32720, -32747, -32764, -32768, -32757, -32733, -32696, -32641, -32571, -32487, -32384, -32265, -32129, -31977, -31806, -31620, -31415, -31190, -30949, -30689, -30410, -30111, -29789, -29445, -29079, -28678, -28245, -27739, -27308, -26277, -20931, -14934, -9512, -4547, 26, 4243, 8108, 11561, 14699, 17461, 19922, 22026, 23809, 25386, 26488, 26700, 26744, 26833, 26578, 27758, 31125, 30804, 30779, 30724, 30679, 30638, 30602, 30569, 30540, 30512, 30488, 30465, 30443, 30424, 30404, 30386, 30370, 30352, 30338, 30323, 30310, 30298, 30285, 30273, 30262, 30250, 30240, 30230, 30221, 30213, 30204, 30196, 30189, 30181, 30174, 30167, 30161, 30154, 30149, 30143, 30139, 30135, 30130, 30124, 30120, 30116, 30113, 30110, 30107, 30105, 30102, 30100, 30098, 30095, 30096, 30094, 30092, 30093, 30090, 30089, 30089, 30066, 29642, 32333, -18621, -34085, -30802, -31625, -31792, -31940, -32071, -32193, -32302, -32399, -32486, -32562, -32625, -32680, -32723, -32750, -32765, -32766, -32751, -32721, -32674, -32608, -32527, -32423, -32303, -32162, -32000, -31818, -31616, -31390, -31143, -30874, -30581, -30264, -29916, -29539, -29130, -28678, -28175, -27544, -27197, -23000, -15494, -8799, -2459};