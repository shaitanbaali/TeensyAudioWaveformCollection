/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0032 256 samples */
 
const int16_t AKWF_distorted_0032_256_DATA [256] = 
{19210, 24955, 27219, 28703, 29685, 30370, 30867, 31231, 31509, 31724, 31892, 32026, 32133, 32221, 32294, 32354, 32406, 32449, 32484, 32515, 32539, 32561, 32578, 32593, 32605, 32611, 32616, 32619, 32619, 32618, 32614, 32609, 32602, 32591, 32577, 32561, 32543, 32520, 32493, 32464, 32429, 32391, 32351, 32305, 32253, 32199, 32138, 32072, 31997, 31915, 31824, 31721, 31606, 31476, 31331, 31171, 30995, 30805, 30601, 30387, 30166, 29942, 29715, 29489, 29265, 29047, 28837, 28634, 28440, 28257, 28090, 27943, 27818, 27709, 27611, 27517, 27426, 27332, 27225, 27104, 26968, 26821, 26671, 26529, 26403, 26307, 26249, 26236, 26270, 26342, 26438, 26545, 26648, 26737, 26801, 26831, 26822, 26776, 26700, 26594, 26460, 26304, 26131, 25945, 25754, 25559, 25349, 25125, 24890, 24648, 24398, 24142, 23885, 23627, 23381, 23157, 22942, 22731, 22513, 22269, 21991, 21661, 21251, 20742, 20122, 19387, 18568, 17692, 16820, 16082, 15625, 15579, 15941, 16628, 17503, 18455, 19415, 20316, 21157, 21923, 22608, 23246, 23835, 24379, 24888, 25360, 25799, 26205, 26585, 26938, 27256, 27549, 27823, 28079, 28323, 28558, 28786, 29006, 29220, 29427, 29620, 29797, 29953, 30085, 30191, 30267, 30317, 30338, 30335, 30307, 30252, 30168, 30053, 29904, 29712, 29474, 29169, 28778, 28281, 27646, 26829, 25753, 24281, 21974, 19789, 1862, -18762, -21754, -24137, -25813, -27066, -28065, -28883, -29565, -30132, -30604, -30991, -31309, -31571, -31783, -31957, -32097, -32209, -32303, -32380, -32444, -32499, -32544, -32582, -32615, -32643, -32668, -32689, -32707, -32723, -32735, -32745, -32754, -32762, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32763, -32755, -32745, -32735, -32723, -32706, -32687, -32664, -32636, -32605, -32568, -32524, -32472, -32408, -32330, -32234, -32115, -31966, -31781, -31538, -31225, -30814, -30261, -29503, -28410, -26613, -24641, -13953};