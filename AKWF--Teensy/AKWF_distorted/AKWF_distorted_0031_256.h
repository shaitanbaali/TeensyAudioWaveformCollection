/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_distorted_0031 256 samples */
 
const int16_t AKWF_distorted_0031_256_DATA [256] = 
{24168, 27596, 26871, 27015, 27017, 27017, 27024, 27038, 27038, 27038, 27039, 27040, 27040, 27040, 27040, 27040, 27040, 27040, 27040, 27039, 27037, 27114, 26719, 29011, 32384, 32161, 32191, 32195, 32196, 32177, 32222, 32072, 27839, 26735, 27048, 26974, 26972, 26971, 26965, 26951, 26946, 26943, 26941, 26939, 26937, 26936, 26933, 26918, 26915, 26915, 26912, 26908, 26907, 26906, 26904, 26903, 26903, 26892, 26883, 26883, 26882, 26881, 26879, 26875, 26874, 26873, 26872, 26871, 26871, 26840, 26933, 26272, 24982, 25025, 25017, 25013, 25011, 25007, 25007, 25005, 25007, 24998, 24977, 24976, 24974, 24973, 24970, 24970, 24968, 24969, 24966, 24963, 24922, 24694, 26473, -21047, -35199, -32223, -32755, -32754, -32755, -32632, -33012, -31878, 16342, 23429, 21777, 22096, 22128, 22088, 22305, 21258, 16047, 15508, 15731, 15714, 15684, 15469, 17054, -9941, -25076, -22585, -23036, -23035, -23031, -23032, -23030, -23025, -23025, -23028, -23011, -22983, -22986, -22984, -22981, -22982, -22981, -22977, -22976, -22977, -22975, -22939, -23079, -22399, -18303, -17694, -17878, -17843, -17841, -17841, -17842, -17840, -17828, -17828, -17828, -17827, -17833, -17777, -17730, -17732, -17732, -17731, -17731, -17731, -17748, -17039, -20709, 13529, 34897, 31616, 32181, 32193, 32194, 32165, 31624, 34744, 4493, -21042, -17212, -17992, -18042, -18049, -18060, -18061, -18071, -18074, -18082, -18090, -18087, -18096, -18102, -18101, -18101, -18102, -18100, -18109, -18116, -18114, -18111, -18179, -18194, -18191, -18191, -18191, -18190, -17794, -20005, -6012, 17203, 15227, 15636, 15653, 15649, 15650, 15650, 15650, 15650, 15650, 15650, 15650, 15652, 15040, 18295, -3509, -29554, -26757, -27234, -27266, -27264, -27263, -27264, -27263, -27262, -27255, -27244, -27246, -27243, -27282, -27056, -28960, -30964, -30768, -30798, -30798, -30798, -30817, -30720, -31303, -32251, -32205, -32210, -32211, -32212, -32187, -32316, -31611};