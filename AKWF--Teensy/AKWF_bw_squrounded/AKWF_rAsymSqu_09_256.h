/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_09 256 samples */
 
const int16_t AKWF_rAsymSqu_09_256_DATA [256] = 
{912, 2955, 4826, 6583, 8230, 9775, 11225, 12581, 13852, 15045, 16160, 17206, 18187, 19105, 19966, 20774, 21528, 22237, 22902, 23522, 24106, 24653, 25163, 25644, 26094, 26514, 26910, 27278, 27624, 27950, 28254, 28539, 28807, 29056, 29291, 29511, 29718, 29910, 30092, 30261, 30419, 30569, 30708, 30839, 30961, 31076, 31184, 31284, 31379, 31468, 31551, 31628, 31701, 31770, 31833, 31893, 31950, 32002, 32052, 32097, 32141, 32182, 32220, 32255, 32288, 32320, 32350, 32377, 32402, 32427, 32449, 32470, 32491, 32509, 32527, 32543, 32558, 32573, 32585, 32598, 32610, 32621, 32632, 32641, 32651, 32659, 32667, 32674, 32682, 32688, 32695, 32700, 32705, 32710, 32715, 32720, 32724, 32728, 32731, 32735, 32739, 32741, 32743, 32747, 32749, 32751, 32753, 32755, 32758, 32759, 32760, 32762, 32763, 32765, 32756, 32783, 32537, 30701, 27572, 24117, 20672, 17367, 14229, 11278, 8512, 5910, 3477, 1197, -943, -2946, -4823, -6584, -8231, -9776, -11226, -12581, -13853, -15046, -16160, -17206, -18188, -19105, -19967, -20774, -21529, -22237, -22902, -23522, -24106, -24653, -25164, -25644, -26094, -26515, -26910, -27279, -27624, -27950, -28254, -28539, -28807, -29056, -29291, -29511, -29718, -29910, -30092, -30262, -30419, -30569, -30708, -30839, -30961, -31076, -31184, -31285, -31379, -31468, -31551, -31628, -31701, -31770, -31833, -31893, -31950, -32002, -32052, -32097, -32141, -32182, -32220, -32255, -32288, -32320, -32350, -32377, -32402, -32427, -32449, -32470, -32491, -32509, -32527, -32543, -32558, -32573, -32585, -32598, -32610, -32621, -32632, -32641, -32651, -32659, -32667, -32674, -32682, -32688, -32695, -32700, -32705, -32710, -32715, -32720, -32724, -32728, -32731, -32735, -32739, -32741, -32743, -32747, -32749, -32751, -32753, -32755, -32758, -32759, -32760, -32762, -32763, -32765, -32756, -32783, -32537, -30701, -27572, -24117, -20673, -17368, -14229, -11279, -8513, -5915, -3486, -1171};