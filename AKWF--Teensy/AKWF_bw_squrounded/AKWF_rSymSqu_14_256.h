/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_14 256 samples */
 
const int16_t AKWF_rSymSqu_14_256_DATA [256] = 
{2738, 8532, 14444, 20675, 25012, 26421, 27396, 28255, 28967, 29568, 30071, 30497, 30856, 31157, 31411, 31625, 31805, 31957, 32085, 32193, 32283, 32360, 32424, 32479, 32524, 32563, 32596, 32622, 32646, 32665, 32681, 32695, 32706, 32716, 32724, 32731, 32737, 32742, 32746, 32750, 32752, 32756, 32757, 32759, 32761, 32762, 32762, 32764, 32765, 32765, 32766, 32765, 32766, 32767, 32766, 32767, 32767, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32767, 32767, 32767, 32766, 32767, 32766, 32765, 32766, 32765, 32765, 32764, 32762, 32762, 32761, 32759, 32757, 32756, 32752, 32750, 32746, 32742, 32737, 32731, 32724, 32716, 32706, 32695, 32681, 32665, 32646, 32622, 32596, 32563, 32524, 32479, 32424, 32360, 32283, 32193, 32085, 31957, 31805, 31625, 31411, 31157, 30856, 30497, 30071, 29568, 28967, 28255, 27396, 26421, 25012, 20675, 14435, 8506, 2814, -2815, -8507, -14435, -20675, -25012, -26421, -27397, -28255, -28967, -29568, -30072, -30497, -30856, -31158, -31411, -31625, -31805, -31957, -32085, -32193, -32283, -32360, -32424, -32479, -32524, -32563, -32596, -32622, -32646, -32665, -32681, -32695, -32706, -32716, -32724, -32731, -32737, -32742, -32746, -32750, -32752, -32756, -32757, -32759, -32761, -32762, -32762, -32764, -32765, -32765, -32766, -32765, -32766, -32767, -32766, -32766, -32766, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32767, -32766, -32766, -32766, -32767, -32766, -32765, -32766, -32765, -32765, -32764, -32762, -32762, -32761, -32759, -32757, -32756, -32752, -32750, -32746, -32742, -32737, -32731, -32724, -32716, -32706, -32695, -32681, -32665, -32646, -32622, -32596, -32563, -32524, -32479, -32424, -32360, -32283, -32193, -32085, -31957, -31805, -31625, -31411, -31158, -30856, -30497, -30072, -29568, -28967, -28255, -27397, -26421, -25012, -20675, -14445, -8532, -2739};