/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_09 256 samples */
 
const int16_t AKWF_rSymSqu_09_256_DATA [256] = 
{1056, 3270, 5452, 7663, 9904, 12186, 14515, 16882, 19276, 21635, 23790, 25253, 25877, 26328, 26771, 27179, 27561, 27922, 28258, 28573, 28867, 29143, 29402, 29644, 29872, 30084, 30283, 30470, 30643, 30806, 30959, 31101, 31235, 31360, 31476, 31586, 31689, 31784, 31872, 31954, 32032, 32103, 32170, 32232, 32290, 32343, 32393, 32438, 32480, 32518, 32554, 32585, 32616, 32642, 32665, 32687, 32704, 32720, 32735, 32745, 32754, 32761, 32766, 32767, 32767, 32766, 32761, 32754, 32745, 32735, 32720, 32704, 32687, 32665, 32642, 32616, 32585, 32554, 32518, 32480, 32438, 32393, 32343, 32290, 32232, 32170, 32103, 32032, 31954, 31872, 31784, 31689, 31586, 31476, 31360, 31235, 31101, 30959, 30806, 30643, 30470, 30283, 30084, 29872, 29644, 29402, 29143, 28867, 28573, 28258, 27922, 27561, 27179, 26771, 26328, 25877, 25253, 23790, 21635, 19276, 16882, 14515, 12186, 9904, 7663, 5448, 3260, 1086, -1087, -3261, -5449, -7664, -9905, -12187, -14516, -16882, -19276, -21636, -23790, -25253, -25877, -26328, -26771, -27179, -27562, -27922, -28258, -28573, -28867, -29144, -29402, -29644, -29872, -30084, -30283, -30470, -30643, -30807, -30959, -31101, -31235, -31360, -31476, -31586, -31689, -31784, -31872, -31954, -32032, -32103, -32170, -32232, -32290, -32343, -32393, -32438, -32480, -32518, -32554, -32585, -32616, -32642, -32665, -32687, -32704, -32720, -32735, -32745, -32754, -32761, -32766, -32767, -32767, -32766, -32761, -32754, -32745, -32735, -32720, -32704, -32687, -32665, -32642, -32616, -32585, -32554, -32518, -32480, -32438, -32393, -32343, -32290, -32232, -32170, -32103, -32032, -31954, -31872, -31784, -31689, -31586, -31476, -31360, -31235, -31101, -30959, -30807, -30643, -30470, -30283, -30084, -29872, -29644, -29402, -29144, -28867, -28573, -28258, -27922, -27562, -27179, -26771, -26328, -25877, -25253, -23790, -21636, -19276, -16882, -14516, -12187, -9905, -7664, -5453, -3271, -1057};