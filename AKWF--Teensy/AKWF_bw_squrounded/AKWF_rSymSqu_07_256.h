/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_07 256 samples */
 
const int16_t AKWF_rSymSqu_07_256_DATA [256] = 
{718, 2221, 3699, 5187, 6683, 8192, 9717, 11254, 12814, 14395, 15991, 17609, 19241, 20870, 22480, 24016, 25391, 26427, 26952, 27267, 27579, 27876, 28158, 28428, 28687, 28933, 29169, 29395, 29610, 29816, 30012, 30199, 30376, 30546, 30706, 30861, 31006, 31145, 31277, 31402, 31520, 31632, 31737, 31836, 31931, 32018, 32101, 32178, 32249, 32316, 32378, 32435, 32487, 32534, 32578, 32616, 32650, 32679, 32705, 32726, 32742, 32755, 32763, 32767, 32767, 32763, 32755, 32742, 32726, 32705, 32679, 32650, 32616, 32578, 32534, 32487, 32435, 32378, 32316, 32249, 32178, 32101, 32018, 31931, 31836, 31737, 31632, 31520, 31402, 31277, 31145, 31006, 30861, 30706, 30546, 30376, 30199, 30012, 29816, 29610, 29395, 29169, 28933, 28687, 28428, 28158, 27876, 27579, 27267, 26952, 26427, 25391, 24016, 22480, 20870, 19241, 17609, 15991, 14395, 12814, 11254, 9717, 8192, 6683, 5187, 3696, 2214, 738, -739, -2215, -3697, -5188, -6683, -8192, -9718, -11255, -12815, -14395, -15991, -17610, -19242, -20871, -22480, -24016, -25391, -26427, -26952, -27267, -27579, -27876, -28158, -28428, -28687, -28933, -29169, -29395, -29610, -29816, -30013, -30199, -30377, -30546, -30707, -30861, -31007, -31145, -31277, -31402, -31520, -31632, -31737, -31836, -31931, -32018, -32101, -32178, -32249, -32316, -32378, -32435, -32487, -32534, -32578, -32616, -32650, -32679, -32705, -32726, -32742, -32755, -32763, -32767, -32767, -32763, -32755, -32742, -32726, -32705, -32679, -32650, -32616, -32578, -32534, -32487, -32435, -32378, -32316, -32249, -32178, -32101, -32018, -31931, -31836, -31737, -31632, -31520, -31402, -31277, -31145, -31007, -30861, -30707, -30546, -30377, -30199, -30013, -29816, -29610, -29395, -29169, -28933, -28687, -28428, -28158, -27876, -27579, -27267, -26952, -26427, -25391, -24016, -22480, -20871, -19242, -17610, -15991, -14395, -12815, -11255, -9718, -8192, -6683, -5188, -3700, -2222, -719};