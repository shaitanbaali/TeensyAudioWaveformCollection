/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_08 256 samples */
 
const int16_t AKWF_rAsymSqu_08_256_DATA [256] = 
{1161, 2818, 4353, 5815, 7201, 8516, 9767, 10950, 12074, 13142, 14151, 15112, 16023, 16885, 17705, 18483, 19219, 19919, 20584, 21212, 21810, 22377, 22914, 23424, 23908, 24367, 24803, 25216, 25607, 25979, 26332, 26666, 26984, 27285, 27571, 27842, 28098, 28343, 28575, 28794, 29002, 29200, 29388, 29565, 29734, 29894, 30046, 30190, 30327, 30456, 30580, 30696, 30806, 30912, 31011, 31106, 31196, 31280, 31361, 31438, 31511, 31579, 31644, 31707, 31766, 31822, 31874, 31925, 31972, 32018, 32061, 32101, 32140, 32177, 32211, 32244, 32275, 32305, 32334, 32360, 32385, 32409, 32432, 32454, 32474, 32494, 32512, 32529, 32547, 32562, 32577, 32591, 32604, 32617, 32629, 32641, 32652, 32662, 32673, 32681, 32690, 32699, 32707, 32714, 32721, 32728, 32735, 32741, 32747, 32752, 32757, 32754, 32776, 32621, 31337, 29002, 26281, 23460, 20675, 17973, 15387, 12925, 10579, 8352, 6242, 4233, 2331, 527, -1187, -2811, -4351, -5816, -7202, -8517, -9768, -10951, -12075, -13142, -14152, -15113, -16023, -16885, -17705, -18483, -19219, -19920, -20585, -21212, -21810, -22377, -22914, -23424, -23908, -24367, -24803, -25216, -25607, -25979, -26332, -26666, -26984, -27286, -27571, -27842, -28099, -28343, -28575, -28794, -29002, -29200, -29388, -29565, -29734, -29894, -30046, -30190, -30327, -30457, -30580, -30696, -30806, -30912, -31011, -31106, -31196, -31280, -31361, -31438, -31511, -31579, -31644, -31707, -31766, -31822, -31874, -31925, -31972, -32018, -32061, -32101, -32140, -32177, -32211, -32244, -32275, -32305, -32334, -32360, -32385, -32409, -32432, -32454, -32474, -32494, -32512, -32529, -32547, -32562, -32577, -32591, -32604, -32617, -32629, -32641, -32652, -32662, -32673, -32681, -32690, -32699, -32707, -32714, -32721, -32728, -32735, -32741, -32747, -32752, -32757, -32754, -32776, -32621, -31338, -29002, -26281, -23460, -20676, -17974, -15388, -12926, -10579, -8353, -6242, -4237, -2340, -505};