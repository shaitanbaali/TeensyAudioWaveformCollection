/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_04 256 samples */
 
const int16_t AKWF_rAsymSqu_04_256_DATA [256] = 
{524, 1295, 2034, 2762, 3473, 4172, 4857, 5528, 6186, 6831, 7463, 8082, 8690, 9284, 9868, 10441, 11001, 11551, 12090, 12617, 13135, 13642, 14139, 14627, 15105, 15572, 16032, 16482, 16922, 17355, 17779, 18194, 18602, 19000, 19391, 19775, 20150, 20519, 20881, 21234, 21581, 21922, 22254, 22581, 22902, 23215, 23522, 23825, 24120, 24409, 24695, 24972, 25245, 25513, 25775, 26032, 26284, 26531, 26773, 27010, 27243, 27472, 27694, 27913, 28128, 28338, 28544, 28747, 28944, 29139, 29330, 29516, 29698, 29878, 30054, 30226, 30395, 30561, 30723, 30882, 31038, 31191, 31341, 31487, 31631, 31772, 31910, 32046, 32178, 32309, 32436, 32560, 32686, 32769, 32598, 32116, 31413, 30552, 29577, 28520, 27414, 26273, 25110, 23943, 22773, 21608, 20454, 19313, 18184, 17075, 15982, 14907, 13854, 12816, 11799, 10802, 9822, 8862, 7922, 6998, 6092, 5205, 4335, 3481, 2647, 1826, 1023, 236, -536, -1292, -2034, -2763, -3474, -4173, -4858, -5528, -6186, -6832, -7463, -8083, -8690, -9285, -9869, -10441, -11001, -11551, -12090, -12617, -13136, -13643, -14140, -14628, -15105, -15573, -16032, -16482, -16923, -17356, -17779, -18194, -18602, -19000, -19391, -19775, -20151, -20519, -20881, -21234, -21581, -21922, -22255, -22581, -22902, -23215, -23523, -23825, -24120, -24410, -24695, -24972, -25245, -25513, -25775, -26032, -26284, -26531, -26773, -27010, -27243, -27472, -27694, -27913, -28128, -28338, -28544, -28747, -28945, -29139, -29330, -29516, -29698, -29878, -30054, -30226, -30395, -30561, -30723, -30882, -31038, -31191, -31341, -31487, -31631, -31772, -31910, -32046, -32178, -32309, -32436, -32560, -32686, -32769, -32598, -32116, -31413, -30552, -29577, -28521, -27414, -26273, -25111, -23943, -22773, -21608, -20455, -19313, -18185, -17076, -15982, -14907, -13854, -12817, -11799, -10803, -9823, -8863, -7923, -6998, -6093, -5206, -4335, -3482, -2648, -1828, -1027, -226};