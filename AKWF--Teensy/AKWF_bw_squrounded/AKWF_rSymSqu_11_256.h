/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_11 256 samples */
 
const int16_t AKWF_rSymSqu_11_256_DATA [256] = 
{1551, 4810, 8048, 11367, 14777, 18274, 21765, 24499, 25655, 26286, 26900, 27450, 27948, 28398, 28809, 29182, 29518, 29825, 30103, 30356, 30585, 30792, 30981, 31152, 31308, 31448, 31576, 31693, 31798, 31894, 31981, 32059, 32131, 32196, 32255, 32307, 32355, 32400, 32439, 32475, 32507, 32538, 32564, 32588, 32611, 32631, 32647, 32663, 32679, 32691, 32703, 32713, 32723, 32731, 32738, 32744, 32751, 32755, 32759, 32762, 32764, 32766, 32767, 32768, 32768, 32767, 32766, 32764, 32762, 32759, 32755, 32751, 32744, 32738, 32731, 32723, 32713, 32703, 32691, 32679, 32663, 32647, 32631, 32611, 32588, 32564, 32538, 32507, 32475, 32439, 32400, 32355, 32307, 32255, 32196, 32131, 32059, 31981, 31894, 31798, 31693, 31576, 31448, 31308, 31152, 30981, 30792, 30585, 30356, 30103, 29825, 29518, 29182, 28809, 28398, 27948, 27450, 26900, 26286, 25655, 24499, 21765, 18274, 14777, 11367, 8042, 4796, 1595, -1596, -4797, -8043, -11367, -14778, -18275, -21765, -24500, -25656, -26286, -26900, -27450, -27948, -28399, -28809, -29182, -29519, -29825, -30103, -30356, -30585, -30793, -30981, -31152, -31308, -31448, -31576, -31693, -31798, -31894, -31981, -32059, -32131, -32196, -32255, -32307, -32355, -32400, -32439, -32475, -32507, -32538, -32564, -32588, -32611, -32631, -32647, -32663, -32679, -32691, -32703, -32713, -32723, -32731, -32738, -32744, -32751, -32755, -32759, -32762, -32764, -32766, -32767, -32768, -32768, -32767, -32766, -32764, -32762, -32759, -32755, -32751, -32744, -32738, -32731, -32723, -32713, -32703, -32691, -32679, -32663, -32647, -32631, -32611, -32588, -32564, -32538, -32507, -32475, -32439, -32400, -32355, -32307, -32255, -32196, -32131, -32059, -31981, -31894, -31798, -31693, -31576, -31448, -31308, -31152, -30981, -30793, -30585, -30356, -30103, -29825, -29519, -29182, -28809, -28399, -27948, -27450, -26900, -26286, -25656, -24500, -21765, -18275, -14778, -11367, -8049, -4811, -1552};