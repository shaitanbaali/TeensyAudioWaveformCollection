/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_15 256 samples */
 
const int16_t AKWF_rAsymSqu_15_256_DATA [256] = 
{2579, 8344, 12883, 16593, 19612, 22070, 24071, 25694, 27015, 28091, 28964, 29675, 30253, 30723, 31106, 31417, 31668, 31874, 32042, 32177, 32288, 32377, 32450, 32510, 32558, 32598, 32629, 32656, 32677, 32694, 32707, 32720, 32729, 32736, 32742, 32747, 32751, 32754, 32757, 32759, 32761, 32762, 32763, 32765, 32766, 32766, 32767, 32766, 32767, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32713, 32880, 31645, 23176, 12648, 4222, -2689, -8304, -12872, -16594, -19613, -22070, -24071, -25694, -27015, -28091, -28965, -29675, -30254, -30723, -31106, -31417, -31668, -31875, -32042, -32177, -32288, -32377, -32450, -32510, -32558, -32598, -32629, -32656, -32677, -32694, -32707, -32720, -32729, -32736, -32742, -32747, -32751, -32754, -32757, -32759, -32761, -32762, -32763, -32765, -32766, -32766, -32767, -32766, -32767, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32713, -32880, -31645, -23188, -12671, -4144};