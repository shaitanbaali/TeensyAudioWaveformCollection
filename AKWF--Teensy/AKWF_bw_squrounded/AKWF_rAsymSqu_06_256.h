/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_06 256 samples */
 
const int16_t AKWF_rAsymSqu_06_256_DATA [256] = 
{525, 1642, 2698, 3723, 4714, 5672, 6601, 7496, 8362, 9202, 10011, 10795, 11554, 12286, 12995, 13681, 14343, 14985, 15604, 16203, 16783, 17344, 17884, 18409, 18916, 19405, 19879, 20338, 20780, 21208, 21622, 22023, 22411, 22785, 23147, 23498, 23836, 24164, 24481, 24786, 25083, 25369, 25646, 25913, 26173, 26423, 26665, 26899, 27126, 27344, 27556, 27761, 27959, 28150, 28335, 28514, 28688, 28855, 29017, 29172, 29324, 29471, 29612, 29748, 29881, 30009, 30133, 30252, 30368, 30480, 30589, 30693, 30794, 30892, 30986, 31078, 31167, 31252, 31335, 31414, 31492, 31567, 31639, 31708, 31776, 31842, 31905, 31966, 32026, 32082, 32138, 32191, 32242, 32293, 32341, 32387, 32433, 32477, 32519, 32560, 32599, 32638, 32674, 32708, 32742, 32768, 32409, 31389, 29956, 28302, 26528, 24708, 22887, 21081, 19310, 17586, 15906, 14275, 12698, 11165, 9685, 8255, 6867, 5526, 4231, 2976, 1764, 593, -542, -1638, -2697, -3724, -4715, -5673, -6602, -7496, -8363, -9203, -10012, -10796, -11555, -12287, -12996, -13681, -14343, -14985, -15605, -16204, -16783, -17344, -17885, -18409, -18916, -19406, -19880, -20338, -20780, -21209, -21623, -22023, -22411, -22786, -23147, -23498, -23836, -24164, -24481, -24787, -25083, -25369, -25646, -25914, -26173, -26423, -26665, -26899, -27126, -27345, -27556, -27761, -27959, -28150, -28335, -28514, -28688, -28855, -29017, -29172, -29324, -29471, -29612, -29749, -29881, -30009, -30133, -30252, -30368, -30480, -30589, -30693, -30794, -30892, -30986, -31078, -31167, -31252, -31335, -31414, -31492, -31567, -31639, -31708, -31776, -31842, -31905, -31966, -32026, -32082, -32138, -32191, -32242, -32293, -32341, -32387, -32433, -32477, -32519, -32560, -32599, -32638, -32674, -32708, -32742, -32768, -32409, -31389, -29956, -28302, -26528, -24708, -22887, -21081, -19311, -17587, -15906, -14275, -12698, -11166, -9685, -8255, -6868, -5527, -4232, -2979, -1770, -578};