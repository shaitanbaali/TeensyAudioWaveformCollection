/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_01 256 samples */
 
const int16_t AKWF_rSymSqu_01_256_DATA [256] = 
{303, 940, 1564, 2188, 2813, 3438, 4063, 4688, 5315, 5941, 6564, 7190, 7815, 8440, 9064, 9688, 10310, 10934, 11558, 12179, 12801, 13423, 14043, 14663, 15281, 15897, 16513, 17126, 17738, 18349, 18957, 19564, 20167, 20765, 21362, 21955, 22541, 23125, 23704, 24274, 24840, 25396, 25945, 26484, 27014, 27532, 28037, 28530, 29003, 29464, 29904, 30323, 30721, 31089, 31432, 31744, 32021, 32260, 32459, 32610, 32711, 32757, 32766, 32767, 32767, 32766, 32757, 32711, 32610, 32459, 32260, 32021, 31744, 31432, 31089, 30721, 30323, 29904, 29464, 29003, 28530, 28037, 27532, 27014, 26484, 25945, 25396, 24840, 24274, 23704, 23125, 22541, 21955, 21362, 20765, 20167, 19564, 18957, 18349, 17738, 17126, 16513, 15897, 15281, 14663, 14043, 13423, 12801, 12179, 11558, 10934, 10310, 9688, 9064, 8440, 7815, 7190, 6564, 5941, 5315, 4688, 4063, 3438, 2813, 2188, 1563, 937, 312, -313, -938, -1563, -2189, -2814, -3439, -4064, -4689, -5316, -5941, -6565, -7191, -7816, -8440, -9065, -9689, -10311, -10935, -11558, -12179, -12801, -13424, -14043, -14664, -15281, -15897, -16513, -17127, -17739, -18349, -18958, -19564, -20167, -20765, -21362, -21955, -22541, -23125, -23704, -24274, -24840, -25396, -25945, -26484, -27014, -27532, -28037, -28530, -29004, -29464, -29904, -30323, -30721, -31089, -31432, -31744, -32021, -32260, -32459, -32610, -32711, -32757, -32766, -32767, -32767, -32766, -32757, -32711, -32610, -32459, -32260, -32021, -31744, -31432, -31089, -30721, -30323, -29904, -29464, -29004, -28530, -28037, -27532, -27014, -26484, -25945, -25396, -24840, -24274, -23704, -23125, -22541, -21955, -21362, -20765, -20167, -19564, -18958, -18349, -17739, -17127, -16513, -15897, -15281, -14664, -14043, -13424, -12801, -12179, -11558, -10935, -10311, -9689, -9065, -8440, -7816, -7191, -6565, -5941, -5316, -4689, -4064, -3439, -2814, -2189, -1565, -941, -304};