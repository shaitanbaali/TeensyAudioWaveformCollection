/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_03 256 samples */
 
const int16_t AKWF_rSymSqu_03_256_DATA [256] = 
{384, 1186, 1973, 2763, 3552, 4344, 5136, 5928, 6723, 7520, 8315, 9114, 9916, 10716, 11523, 12329, 13135, 13947, 14760, 15573, 16391, 17210, 18028, 18850, 19673, 20493, 21316, 22135, 22953, 23766, 24572, 25367, 26153, 26922, 27668, 28388, 29072, 29711, 30293, 30803, 31225, 31536, 31709, 31808, 31901, 31988, 32070, 32147, 32221, 32290, 32354, 32413, 32468, 32518, 32564, 32605, 32641, 32673, 32700, 32722, 32740, 32755, 32763, 32767, 32767, 32763, 32755, 32740, 32722, 32700, 32673, 32641, 32605, 32564, 32518, 32468, 32413, 32354, 32290, 32222, 32148, 32070, 31988, 31901, 31808, 31709, 31536, 31225, 30803, 30293, 29711, 29072, 28388, 27668, 26922, 26153, 25367, 24572, 23766, 22953, 22135, 21316, 20493, 19673, 18850, 18028, 17210, 16391, 15573, 14760, 13947, 13135, 12329, 11523, 10716, 9916, 9114, 8315, 7520, 6723, 5928, 5136, 4344, 3552, 2763, 1972, 1183, 394, -395, -1184, -1973, -2763, -3553, -4345, -5137, -5929, -6723, -7521, -8316, -9115, -9917, -10717, -11523, -12329, -13136, -13947, -14761, -15574, -16391, -17210, -18029, -18850, -19674, -20494, -21317, -22136, -22953, -23766, -24572, -25367, -26153, -26922, -27668, -28388, -29072, -29711, -30293, -30803, -31226, -31536, -31709, -31808, -31901, -31988, -32070, -32148, -32222, -32290, -32354, -32413, -32468, -32518, -32564, -32605, -32641, -32673, -32700, -32722, -32740, -32755, -32763, -32767, -32767, -32763, -32755, -32740, -32722, -32700, -32673, -32641, -32605, -32564, -32518, -32468, -32413, -32354, -32290, -32221, -32147, -32070, -31988, -31901, -31808, -31709, -31536, -31226, -30803, -30293, -29711, -29072, -28388, -27668, -26922, -26153, -25367, -24572, -23766, -22953, -22136, -21316, -20494, -19674, -18850, -18029, -17210, -16391, -15574, -14761, -13947, -13136, -12329, -11523, -10717, -9917, -9115, -8316, -7521, -6723, -5929, -5137, -4345, -3553, -2763, -1974, -1187, -384};