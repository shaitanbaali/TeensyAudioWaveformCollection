/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_16 256 samples */
 
const int16_t AKWF_rSymSqu_16_256_DATA [256] = 
{3855, 12198, 20922, 26117, 27547, 28703, 29608, 30303, 30847, 31270, 31600, 31858, 32058, 32215, 32336, 32432, 32506, 32564, 32609, 32643, 32671, 32693, 32709, 32723, 32733, 32740, 32746, 32751, 32755, 32758, 32761, 32762, 32763, 32765, 32765, 32765, 32766, 32767, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32767, 32767, 32766, 32765, 32765, 32765, 32763, 32762, 32761, 32758, 32755, 32751, 32746, 32740, 32733, 32723, 32709, 32693, 32671, 32643, 32609, 32564, 32506, 32432, 32336, 32215, 32058, 31858, 31600, 31270, 30847, 30303, 29608, 28703, 27547, 26117, 20909, 12161, 3962, -3963, -12162, -20909, -26118, -27547, -28703, -29608, -30303, -30847, -31271, -31600, -31858, -32058, -32215, -32336, -32432, -32506, -32564, -32609, -32643, -32671, -32693, -32709, -32723, -32733, -32740, -32746, -32751, -32755, -32758, -32761, -32762, -32763, -32765, -32765, -32765, -32766, -32767, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32767, -32767, -32766, -32765, -32765, -32765, -32763, -32762, -32761, -32758, -32755, -32751, -32746, -32740, -32733, -32723, -32709, -32693, -32671, -32643, -32609, -32564, -32506, -32432, -32336, -32215, -32058, -31858, -31600, -31271, -30847, -30303, -29608, -28703, -27547, -26118, -20923, -12198, -3856};