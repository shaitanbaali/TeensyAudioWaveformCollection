/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_26 256 samples */
 
const int16_t AKWF_rSymSqu_26_256_DATA [256] = 
{22689, 33576, 32520, 32751, 32764, 32764, 32764, 32764, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32764, 32764, 32764, 32764, 32751, 32412, 33694, 22485, -22485, -33694, -32412, -32751, -32764, -32764, -32764, -32764, -32765, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32765, -32764, -32764, -32764, -32764, -32751, -32520, -33576, -22689};