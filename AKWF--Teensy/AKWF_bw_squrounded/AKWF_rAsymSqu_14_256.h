/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_14 256 samples */
 
const int16_t AKWF_rAsymSqu_14_256_DATA [256] = 
{2668, 7517, 11481, 14836, 17663, 20045, 22054, 23742, 25167, 26367, 27376, 28227, 28944, 29547, 30055, 30484, 30843, 31147, 31403, 31619, 31800, 31953, 32082, 32190, 32281, 32359, 32423, 32477, 32523, 32562, 32595, 32622, 32645, 32664, 32681, 32695, 32706, 32716, 32725, 32732, 32737, 32743, 32747, 32750, 32753, 32755, 32757, 32759, 32760, 32762, 32763, 32763, 32765, 32766, 32765, 32766, 32767, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32738, 32798, 32362, 26515, 17398, 9527, 2874, -2755, -7486, -11472, -14837, -17663, -20045, -22055, -23743, -25167, -26368, -27376, -28228, -28944, -29547, -30055, -30484, -30843, -31147, -31403, -31619, -31800, -31953, -32082, -32190, -32281, -32359, -32423, -32477, -32523, -32562, -32595, -32622, -32645, -32664, -32681, -32695, -32706, -32716, -32725, -32732, -32737, -32743, -32747, -32750, -32753, -32755, -32757, -32759, -32760, -32762, -32763, -32763, -32765, -32766, -32765, -32766, -32767, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32738, -32798, -32362, -26515, -17409, -9547, -2809};