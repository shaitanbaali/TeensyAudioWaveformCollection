/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_12 256 samples */
 
const int16_t AKWF_rAsymSqu_12_256_DATA [256] = 
{2176, 5641, 8640, 11316, 13695, 15813, 17698, 19369, 20857, 22181, 23354, 24400, 25330, 26155, 26890, 27543, 28122, 28638, 29097, 29504, 29867, 30189, 30475, 30730, 30956, 31157, 31337, 31496, 31636, 31762, 31874, 31973, 32062, 32141, 32210, 32272, 32328, 32377, 32420, 32458, 32493, 32524, 32551, 32575, 32597, 32616, 32633, 32647, 32661, 32673, 32684, 32693, 32702, 32709, 32715, 32721, 32727, 32732, 32735, 32739, 32743, 32745, 32748, 32751, 32752, 32754, 32756, 32757, 32758, 32759, 32761, 32762, 32762, 32762, 32763, 32763, 32765, 32766, 32765, 32765, 32766, 32767, 32766, 32767, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32744, 32800, 32361, 28354, 22074, 16097, 10689, 5871, 1585, -2234, -5621, -8634, -11317, -13696, -15813, -17698, -19369, -20857, -22181, -23355, -24400, -25330, -26155, -26890, -27543, -28123, -28638, -29097, -29504, -29867, -30189, -30475, -30730, -30956, -31157, -31337, -31496, -31636, -31762, -31874, -31973, -32062, -32141, -32210, -32272, -32328, -32377, -32420, -32458, -32494, -32524, -32551, -32575, -32597, -32616, -32633, -32647, -32661, -32673, -32684, -32693, -32702, -32709, -32715, -32721, -32727, -32732, -32735, -32739, -32743, -32745, -32748, -32750, -32752, -32754, -32756, -32757, -32758, -32759, -32761, -32762, -32762, -32762, -32763, -32763, -32765, -32766, -32765, -32765, -32766, -32767, -32766, -32766, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32744, -32800, -32361, -28354, -22074, -16097, -10696, -5886, -1538};