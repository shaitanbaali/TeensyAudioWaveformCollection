/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_02 256 samples */
 
const int16_t AKWF_rAsymSqu_02_256_DATA [256] = 
{175, 794, 1395, 1992, 2582, 3166, 3745, 4317, 4884, 5445, 5999, 6549, 7094, 7630, 8163, 8692, 9212, 9729, 10241, 10745, 11246, 11742, 12232, 12716, 13198, 13672, 14143, 14609, 15069, 15525, 15978, 16423, 16866, 17303, 17736, 18165, 18589, 19008, 19424, 19835, 20241, 20645, 21042, 21437, 21828, 22214, 22596, 22975, 23349, 23720, 24086, 24449, 24809, 25164, 25515, 25865, 26210, 26550, 26889, 27221, 27552, 27881, 28205, 28523, 28842, 29156, 29466, 29775, 30079, 30380, 30679, 30973, 31264, 31554, 31839, 32122, 32405, 32651, 32765, 32727, 32568, 32301, 31943, 31510, 31010, 30454, 29854, 29215, 28545, 27849, 27129, 26394, 25646, 24884, 24117, 23343, 22565, 21785, 21005, 20222, 19445, 18669, 17894, 17126, 16361, 15599, 14845, 14095, 13350, 12614, 11881, 11154, 10436, 9721, 9015, 8317, 7623, 6936, 6257, 5582, 4915, 4256, 3602, 2954, 2314, 1680, 1051, 431, -184, -793, -1395, -1993, -2582, -3167, -3746, -4317, -4885, -5446, -6000, -6550, -7095, -7631, -8164, -8693, -9213, -9729, -10242, -10746, -11247, -11742, -12233, -12717, -13199, -13673, -14144, -14610, -15069, -15526, -15978, -16424, -16867, -17304, -17736, -18166, -18589, -19009, -19425, -19835, -20241, -20645, -21043, -21438, -21828, -22214, -22596, -22975, -23349, -23721, -24086, -24449, -24809, -25164, -25516, -25865, -26210, -26551, -26889, -27222, -27552, -27881, -28205, -28524, -28842, -29156, -29466, -29775, -30079, -30381, -30679, -30973, -31264, -31554, -31840, -32122, -32405, -32651, -32765, -32727, -32568, -32301, -31943, -31510, -31010, -30454, -29854, -29216, -28545, -27849, -27129, -26394, -25646, -24884, -24117, -23344, -22566, -21785, -21005, -20222, -19446, -18670, -17894, -17127, -16361, -15599, -14846, -14095, -13351, -12615, -11881, -11155, -10436, -9722, -9016, -8317, -7623, -6937, -6258, -5583, -4916, -4257, -3603, -2955, -2315, -1682, -1055, -423};