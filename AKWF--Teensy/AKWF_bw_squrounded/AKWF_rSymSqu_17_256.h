/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_17 256 samples */
 
const int16_t AKWF_rSymSqu_17_256_DATA [256] = 
{4461, 14480, 23874, 27520, 28714, 29800, 30571, 31139, 31561, 31874, 32105, 32277, 32404, 32498, 32568, 32620, 32658, 32687, 32708, 32724, 32735, 32743, 32751, 32755, 32759, 32761, 32763, 32764, 32765, 32766, 32767, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32767, 32767, 32766, 32765, 32764, 32763, 32761, 32759, 32755, 32751, 32743, 32735, 32724, 32708, 32687, 32658, 32620, 32568, 32498, 32404, 32277, 32105, 31874, 31561, 31139, 30571, 29800, 28714, 27520, 23858, 14437, 4585, -4585, -14437, -23858, -27521, -28714, -29800, -30571, -31139, -31561, -31874, -32105, -32277, -32404, -32498, -32568, -32620, -32658, -32687, -32708, -32724, -32735, -32743, -32751, -32755, -32759, -32761, -32763, -32764, -32765, -32766, -32767, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32767, -32767, -32766, -32765, -32764, -32763, -32761, -32759, -32755, -32751, -32743, -32735, -32724, -32708, -32687, -32658, -32620, -32568, -32498, -32404, -32277, -32105, -31874, -31561, -31139, -30571, -29800, -28714, -27521, -23874, -14480, -4462};