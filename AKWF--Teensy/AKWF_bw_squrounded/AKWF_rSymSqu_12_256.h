/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_12 256 samples */
 
const int16_t AKWF_rSymSqu_12_256_DATA [256] = 
{1857, 5766, 9673, 13714, 17894, 22095, 25042, 26098, 26814, 27488, 28076, 28598, 29064, 29477, 29844, 30171, 30461, 30719, 30948, 31152, 31333, 31494, 31637, 31765, 31879, 31979, 32069, 32149, 32219, 32281, 32337, 32387, 32432, 32471, 32505, 32537, 32564, 32589, 32610, 32630, 32648, 32662, 32675, 32688, 32698, 32708, 32716, 32723, 32730, 32736, 32742, 32746, 32749, 32752, 32755, 32759, 32761, 32763, 32764, 32766, 32767, 32768, 32767, 32768, 32768, 32767, 32768, 32767, 32766, 32764, 32763, 32761, 32759, 32755, 32752, 32749, 32746, 32742, 32736, 32730, 32723, 32716, 32708, 32698, 32688, 32675, 32662, 32648, 32630, 32610, 32589, 32564, 32537, 32505, 32471, 32432, 32387, 32337, 32281, 32219, 32149, 32069, 31979, 31879, 31765, 31637, 31494, 31333, 31152, 30948, 30719, 30461, 30171, 29844, 29477, 29064, 28598, 28076, 27488, 26814, 26098, 25042, 22095, 17894, 13714, 9666, 5749, 1909, -1910, -5750, -9667, -13715, -17894, -22095, -25042, -26098, -26814, -27488, -28076, -28599, -29064, -29477, -29844, -30171, -30461, -30719, -30948, -31152, -31333, -31494, -31637, -31765, -31879, -31979, -32069, -32149, -32219, -32281, -32337, -32387, -32432, -32471, -32505, -32537, -32564, -32589, -32610, -32630, -32648, -32662, -32675, -32688, -32698, -32708, -32716, -32723, -32730, -32736, -32742, -32746, -32749, -32752, -32755, -32759, -32761, -32763, -32764, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32764, -32763, -32761, -32759, -32755, -32752, -32749, -32746, -32742, -32736, -32730, -32723, -32716, -32708, -32698, -32688, -32675, -32662, -32648, -32630, -32610, -32589, -32564, -32537, -32505, -32471, -32432, -32387, -32337, -32281, -32219, -32149, -32069, -31979, -31879, -31765, -31637, -31494, -31333, -31152, -30948, -30719, -30461, -30171, -29844, -29477, -29064, -28599, -28076, -27488, -26814, -26098, -25042, -22095, -17894, -13715, -9673, -5767, -1858};