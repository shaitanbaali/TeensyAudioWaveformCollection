/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_10 256 samples */
 
const int16_t AKWF_rSymSqu_10_256_DATA [256] = 
{1280, 3964, 6619, 9324, 12080, 14905, 17794, 20682, 23372, 25123, 25815, 26352, 26863, 27330, 27762, 28161, 28528, 28868, 29181, 29471, 29739, 29985, 30213, 30423, 30618, 30797, 30963, 31115, 31256, 31387, 31507, 31618, 31720, 31815, 31901, 31982, 32055, 32123, 32187, 32244, 32297, 32347, 32391, 32433, 32471, 32506, 32538, 32567, 32594, 32618, 32640, 32659, 32678, 32694, 32708, 32720, 32731, 32740, 32748, 32755, 32760, 32764, 32766, 32767, 32767, 32766, 32764, 32760, 32755, 32748, 32740, 32731, 32720, 32708, 32694, 32678, 32659, 32640, 32618, 32594, 32567, 32538, 32506, 32471, 32433, 32391, 32347, 32297, 32244, 32187, 32123, 32055, 31982, 31901, 31815, 31720, 31618, 31507, 31387, 31256, 31115, 30963, 30797, 30618, 30423, 30213, 29985, 29739, 29471, 29181, 28868, 28528, 28161, 27762, 27330, 26863, 26352, 25815, 25123, 23372, 20682, 17794, 14905, 12080, 9324, 6615, 3952, 1316, -1317, -3953, -6615, -9325, -12081, -14906, -17795, -20682, -23372, -25123, -25815, -26352, -26863, -27330, -27762, -28161, -28528, -28868, -29181, -29471, -29739, -29985, -30213, -30423, -30618, -30797, -30964, -31115, -31256, -31387, -31507, -31618, -31720, -31815, -31901, -31982, -32055, -32123, -32187, -32244, -32297, -32347, -32391, -32433, -32471, -32506, -32538, -32567, -32594, -32618, -32640, -32659, -32678, -32694, -32708, -32720, -32731, -32740, -32748, -32755, -32760, -32764, -32766, -32767, -32767, -32766, -32764, -32760, -32755, -32748, -32740, -32731, -32720, -32708, -32694, -32678, -32659, -32640, -32618, -32594, -32567, -32538, -32506, -32471, -32433, -32391, -32347, -32297, -32244, -32187, -32123, -32055, -31982, -31901, -31815, -31720, -31618, -31507, -31387, -31256, -31115, -30964, -30797, -30618, -30423, -30213, -29985, -29739, -29471, -29181, -28868, -28528, -28161, -27762, -27330, -26863, -26352, -25815, -25123, -23372, -20682, -17795, -14906, -12081, -9325, -6620, -3965, -1281};