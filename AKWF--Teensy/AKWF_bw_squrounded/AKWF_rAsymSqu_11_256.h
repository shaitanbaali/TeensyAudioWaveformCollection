/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_11 256 samples */
 
const int16_t AKWF_rAsymSqu_11_256_DATA [256] = 
{1484, 4432, 7042, 9418, 11574, 13534, 15314, 16925, 18391, 19721, 20925, 22021, 23016, 23916, 24735, 25478, 26151, 26763, 27319, 27822, 28280, 28695, 29071, 29413, 29724, 30004, 30260, 30493, 30703, 30894, 31067, 31224, 31367, 31497, 31614, 31721, 31817, 31905, 31985, 32058, 32123, 32183, 32237, 32286, 32331, 32372, 32408, 32441, 32472, 32499, 32524, 32547, 32567, 32585, 32603, 32619, 32632, 32645, 32656, 32667, 32676, 32685, 32692, 32699, 32705, 32712, 32717, 32721, 32726, 32730, 32733, 32737, 32739, 32742, 32745, 32747, 32749, 32751, 32752, 32754, 32755, 32757, 32758, 32759, 32759, 32760, 32762, 32762, 32762, 32763, 32763, 32763, 32764, 32765, 32766, 32766, 32765, 32766, 32767, 32766, 32767, 32767, 32767, 32766, 32767, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32766, 32744, 32818, 31975, 28129, 22943, 17921, 13272, 9017, 5158, 1654, -1531, -4417, -7037, -9418, -11575, -13534, -15315, -16926, -18391, -19722, -20926, -22022, -23016, -23916, -24735, -25479, -26152, -26763, -27319, -27822, -28280, -28695, -29071, -29413, -29724, -30005, -30260, -30493, -30703, -30894, -31067, -31224, -31367, -31497, -31614, -31721, -31817, -31905, -31986, -32058, -32123, -32183, -32237, -32286, -32331, -32372, -32408, -32441, -32472, -32499, -32524, -32547, -32567, -32585, -32603, -32619, -32632, -32645, -32656, -32667, -32676, -32685, -32692, -32699, -32705, -32712, -32717, -32721, -32726, -32730, -32733, -32737, -32739, -32742, -32745, -32747, -32749, -32751, -32752, -32754, -32755, -32757, -32758, -32759, -32759, -32760, -32762, -32762, -32762, -32763, -32763, -32763, -32764, -32765, -32766, -32766, -32765, -32766, -32767, -32766, -32766, -32766, -32767, -32766, -32767, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32744, -32818, -31975, -28129, -22943, -17922, -13272, -9023, -5171, -1615};