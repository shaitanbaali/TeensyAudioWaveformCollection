/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_03 256 samples */
 
const int16_t AKWF_rAsymSqu_03_256_DATA [256] = 
{404, 1077, 1728, 2371, 3003, 3627, 4242, 4848, 5445, 6033, 6613, 7184, 7748, 8301, 8849, 9387, 9916, 10440, 10956, 11463, 11963, 12456, 12941, 13420, 13892, 14356, 14814, 15264, 15709, 16147, 16578, 17002, 17422, 17835, 18241, 18643, 19037, 19426, 19810, 20186, 20559, 20927, 21288, 21644, 21995, 22340, 22680, 23016, 23347, 23673, 23994, 24310, 24622, 24930, 25232, 25531, 25825, 26114, 26399, 26680, 26957, 27230, 27500, 27763, 28024, 28282, 28536, 28786, 29032, 29274, 29514, 29749, 29981, 30210, 30434, 30657, 30876, 31090, 31303, 31512, 31717, 31921, 32121, 32318, 32512, 32700, 32765, 32604, 32258, 31766, 31158, 30459, 29689, 28865, 28001, 27106, 26187, 25257, 24316, 23369, 22423, 21478, 20536, 19602, 18674, 17753, 16844, 15943, 15052, 14174, 13306, 12447, 11604, 10769, 9945, 9136, 8334, 7545, 6769, 6001, 5246, 4503, 3769, 3045, 2334, 1631, 939, 258, -414, -1075, -1728, -2371, -3004, -3628, -4243, -4848, -5446, -6034, -6613, -7185, -7749, -8302, -8850, -9388, -9917, -10440, -10957, -11463, -11964, -12457, -12942, -13421, -13892, -14356, -14815, -15265, -15710, -16147, -16578, -17003, -17423, -17835, -18241, -18643, -19038, -19427, -19811, -20188, -20560, -20927, -21288, -21644, -21995, -22340, -22680, -23017, -23348, -23673, -23995, -24310, -24622, -24930, -25233, -25531, -25825, -26114, -26399, -26680, -26958, -27230, -27500, -27763, -28025, -28282, -28536, -28786, -29032, -29274, -29514, -29749, -29981, -30210, -30434, -30657, -30876, -31090, -31303, -31513, -31717, -31921, -32121, -32318, -32512, -32700, -32765, -32604, -32258, -31766, -31158, -30459, -29690, -28865, -28001, -27106, -26187, -25257, -24316, -23369, -22424, -21479, -20537, -19603, -18674, -17754, -16845, -15944, -15053, -14175, -13306, -12448, -11604, -10770, -9946, -9136, -8335, -7546, -6770, -6002, -5247, -4504, -3770, -3046, -2335, -1633, -943, -250};