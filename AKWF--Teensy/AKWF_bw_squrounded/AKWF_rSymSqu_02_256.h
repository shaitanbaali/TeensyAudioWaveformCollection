/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_02 256 samples */
 
const int16_t AKWF_rSymSqu_02_256_DATA [256] = 
{340, 1055, 1757, 2460, 3161, 3866, 4570, 5272, 5978, 6684, 7388, 8095, 8802, 9508, 10215, 10926, 11633, 12343, 13055, 13764, 14475, 15186, 15897, 16609, 17322, 18030, 18743, 19452, 20158, 20866, 21571, 22270, 22969, 23660, 24345, 25025, 25695, 26355, 27003, 27635, 28249, 28846, 29416, 29958, 30468, 30935, 31358, 31727, 32032, 32264, 32409, 32475, 32519, 32561, 32599, 32633, 32664, 32690, 32713, 32731, 32746, 32757, 32765, 32767, 32767, 32765, 32757, 32746, 32731, 32713, 32690, 32664, 32633, 32599, 32561, 32519, 32475, 32409, 32264, 32032, 31727, 31358, 30935, 30468, 29958, 29416, 28846, 28249, 27635, 27003, 26355, 25695, 25025, 24345, 23660, 22969, 22270, 21571, 20866, 20158, 19452, 18743, 18030, 17322, 16609, 15897, 15186, 14475, 13764, 13055, 12343, 11633, 10926, 10215, 9508, 8802, 8095, 7388, 6684, 5978, 5272, 4570, 3866, 3161, 2460, 1756, 1052, 350, -351, -1053, -1756, -2461, -3162, -3867, -4571, -5273, -5979, -6685, -7389, -8095, -8803, -9509, -10216, -10927, -11634, -12343, -13056, -13764, -14475, -15186, -15897, -16610, -17322, -18031, -18743, -19453, -20158, -20866, -21571, -22271, -22969, -23660, -24345, -25026, -25696, -26355, -27004, -27635, -28249, -28846, -29416, -29958, -30468, -30935, -31358, -31727, -32032, -32264, -32409, -32475, -32519, -32561, -32599, -32633, -32664, -32690, -32713, -32731, -32746, -32757, -32765, -32767, -32767, -32765, -32757, -32746, -32731, -32713, -32690, -32664, -32633, -32599, -32561, -32519, -32475, -32409, -32264, -32032, -31727, -31358, -30935, -30468, -29958, -29416, -28846, -28249, -27635, -27004, -26355, -25696, -25026, -24345, -23660, -22969, -22271, -21571, -20866, -20158, -19453, -18743, -18031, -17322, -16610, -15897, -15186, -14475, -13764, -13056, -12343, -11634, -10927, -10216, -9509, -8803, -8095, -7389, -6685, -5979, -5273, -4571, -3867, -3162, -2461, -1758, -1056, -341};