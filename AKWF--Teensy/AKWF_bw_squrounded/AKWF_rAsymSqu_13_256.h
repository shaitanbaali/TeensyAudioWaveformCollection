/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_13 256 samples */
 
const int16_t AKWF_rAsymSqu_13_256_DATA [256] = 
{1941, 6114, 9634, 12700, 15360, 17668, 19674, 21409, 22916, 24225, 25356, 26340, 27194, 27932, 28574, 29131, 29613, 30032, 30395, 30710, 30983, 31220, 31425, 31603, 31759, 31892, 32009, 32109, 32196, 32272, 32338, 32395, 32445, 32488, 32525, 32557, 32586, 32610, 32630, 32649, 32665, 32678, 32691, 32701, 32710, 32718, 32725, 32730, 32735, 32740, 32744, 32747, 32750, 32752, 32754, 32756, 32758, 32759, 32761, 32762, 32762, 32763, 32763, 32764, 32766, 32765, 32766, 32767, 32766, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32753, 32758, 32688, 28927, 21465, 14336, 8114, 2697, -2012, -6090, -9627, -12701, -15361, -17669, -19675, -21410, -22916, -24225, -25357, -26340, -27194, -27932, -28575, -29131, -29613, -30032, -30395, -30710, -30983, -31220, -31425, -31603, -31759, -31892, -32009, -32109, -32196, -32272, -32338, -32395, -32445, -32488, -32525, -32557, -32586, -32610, -32630, -32649, -32665, -32678, -32691, -32701, -32710, -32718, -32725, -32730, -32735, -32740, -32744, -32747, -32750, -32752, -32754, -32756, -32758, -32759, -32761, -32762, -32762, -32763, -32763, -32764, -32766, -32765, -32766, -32767, -32766, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32753, -32758, -32688, -28927, -21465, -14345, -8131, -2641};