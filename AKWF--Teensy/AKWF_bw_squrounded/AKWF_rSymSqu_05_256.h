/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_05 256 samples */
 
const int16_t AKWF_rSymSqu_05_256_DATA [256] = 
{513, 1586, 2639, 3697, 4757, 5822, 6891, 7962, 9041, 10126, 11214, 12311, 13418, 14529, 15650, 16780, 17915, 19059, 20206, 21352, 22498, 23631, 24741, 25814, 26822, 27726, 28483, 29002, 29271, 29475, 29676, 29869, 30054, 30233, 30405, 30570, 30728, 30879, 31024, 31162, 31295, 31422, 31542, 31656, 31764, 31867, 31963, 32053, 32139, 32217, 32291, 32361, 32424, 32482, 32534, 32581, 32623, 32658, 32689, 32715, 32737, 32752, 32763, 32767, 32767, 32763, 32752, 32737, 32715, 32689, 32658, 32623, 32581, 32534, 32482, 32424, 32361, 32291, 32217, 32139, 32053, 31963, 31867, 31764, 31656, 31542, 31422, 31295, 31162, 31024, 30879, 30728, 30570, 30405, 30233, 30054, 29869, 29676, 29475, 29271, 29002, 28483, 27726, 26822, 25814, 24741, 23631, 22498, 21352, 20206, 19059, 17915, 16780, 15650, 14529, 13418, 12311, 11214, 10126, 9041, 7962, 6891, 5822, 4757, 3697, 2637, 1581, 527, -528, -1582, -2638, -3698, -4758, -5822, -6892, -7963, -9041, -10126, -11214, -12312, -13418, -14529, -15651, -16781, -17916, -19059, -20207, -21352, -22499, -23632, -24741, -25814, -26822, -27727, -28484, -29002, -29271, -29475, -29676, -29869, -30055, -30234, -30405, -30570, -30728, -30879, -31024, -31163, -31295, -31422, -31542, -31656, -31764, -31867, -31963, -32053, -32139, -32217, -32291, -32361, -32424, -32482, -32534, -32581, -32623, -32658, -32689, -32715, -32737, -32752, -32763, -32767, -32767, -32763, -32752, -32737, -32715, -32689, -32658, -32623, -32581, -32534, -32482, -32424, -32361, -32291, -32217, -32139, -32053, -31963, -31867, -31764, -31656, -31542, -31422, -31295, -31163, -31024, -30879, -30728, -30570, -30405, -30234, -30055, -29869, -29676, -29475, -29271, -29002, -28484, -27727, -26822, -25814, -24741, -23632, -22499, -21352, -20207, -19059, -17916, -16781, -15651, -14529, -13418, -12312, -11214, -10126, -9041, -7963, -6892, -5822, -4758, -3698, -2640, -1587, -514};