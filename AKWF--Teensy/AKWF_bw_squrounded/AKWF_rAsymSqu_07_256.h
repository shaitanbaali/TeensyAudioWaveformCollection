/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_07 256 samples */
 
const int16_t AKWF_rAsymSqu_07_256_DATA [256] = 
{849, 2209, 3484, 4710, 5884, 7010, 8092, 9126, 10120, 11071, 11982, 12857, 13695, 14498, 15269, 16008, 16714, 17392, 18043, 18666, 19264, 19837, 20384, 20912, 21416, 21899, 22363, 22807, 23232, 23642, 24033, 24408, 24768, 25112, 25442, 25759, 26063, 26354, 26633, 26901, 27157, 27403, 27638, 27864, 28081, 28288, 28487, 28678, 28860, 29035, 29203, 29364, 29519, 29667, 29808, 29945, 30074, 30199, 30319, 30434, 30543, 30649, 30750, 30847, 30940, 31029, 31114, 31197, 31275, 31350, 31422, 31491, 31557, 31621, 31681, 31740, 31796, 31849, 31901, 31950, 31998, 32042, 32086, 32127, 32167, 32205, 32243, 32277, 32311, 32343, 32374, 32404, 32433, 32460, 32486, 32511, 32535, 32558, 32580, 32600, 32621, 32640, 32659, 32677, 32694, 32711, 32727, 32740, 32749, 32778, 32438, 31164, 29277, 27119, 24856, 22587, 20348, 18171, 16072, 14044, 12097, 10232, 8437, 6718, 5071, 3489, 1974, 523, -870, -2203, -3482, -4711, -5885, -7011, -8093, -9127, -10120, -11072, -11983, -12858, -13696, -14499, -15269, -16008, -16714, -17393, -18044, -18666, -19264, -19837, -20385, -20912, -21416, -21899, -22364, -22807, -23233, -23642, -24033, -24409, -24768, -25113, -25443, -25759, -26063, -26354, -26633, -26901, -27157, -27403, -27638, -27864, -28081, -28288, -28487, -28678, -28860, -29035, -29203, -29365, -29519, -29667, -29808, -29945, -30074, -30199, -30319, -30434, -30543, -30649, -30750, -30847, -30940, -31029, -31114, -31197, -31275, -31350, -31422, -31491, -31557, -31621, -31681, -31740, -31796, -31849, -31901, -31950, -31998, -32042, -32086, -32128, -32167, -32205, -32243, -32277, -32311, -32343, -32374, -32404, -32433, -32460, -32486, -32511, -32535, -32558, -32580, -32600, -32621, -32640, -32659, -32677, -32694, -32711, -32727, -32740, -32749, -32778, -32438, -31164, -29277, -27119, -24856, -22587, -20348, -18172, -16072, -14045, -12097, -10233, -8437, -6719, -5072, -3492, -1981, -505};