/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_18 256 samples */
 
const int16_t AKWF_rSymSqu_18_256_DATA [256] = 
{5291, 17513, 26319, 28510, 29748, 30685, 31317, 31757, 32063, 32278, 32426, 32530, 32602, 32652, 32687, 32712, 32729, 32741, 32750, 32755, 32759, 32762, 32764, 32765, 32766, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32767, 32766, 32765, 32764, 32762, 32759, 32755, 32750, 32741, 32729, 32712, 32687, 32652, 32602, 32530, 32426, 32278, 32063, 31757, 31317, 30685, 29748, 28510, 26300, 17461, 5445, -5445, -17461, -26300, -28510, -29748, -30685, -31317, -31757, -32063, -32278, -32426, -32530, -32602, -32652, -32687, -32712, -32729, -32741, -32750, -32755, -32759, -32762, -32764, -32765, -32766, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32767, -32766, -32765, -32764, -32762, -32759, -32755, -32750, -32741, -32729, -32712, -32687, -32652, -32602, -32530, -32426, -32278, -32063, -31757, -31317, -30685, -29748, -28510, -26319, -17513, -5292};