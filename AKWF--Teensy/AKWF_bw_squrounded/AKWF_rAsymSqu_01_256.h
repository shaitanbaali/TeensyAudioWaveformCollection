/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_01 256 samples */
 
const int16_t AKWF_rAsymSqu_01_256_DATA [256] = 
{291, 893, 1477, 2061, 2641, 3217, 3789, 4358, 4925, 5487, 6044, 6599, 7151, 7697, 8242, 8782, 9317, 9852, 10383, 10909, 11431, 11952, 12468, 12981, 13490, 13996, 14499, 14998, 15494, 15986, 16477, 16964, 17448, 17926, 18405, 18878, 19347, 19816, 20280, 20741, 21201, 21655, 22108, 22556, 23003, 23445, 23886, 24325, 24757, 25189, 25620, 26044, 26470, 26888, 27306, 27721, 28134, 28542, 28950, 29353, 29754, 30153, 30550, 30942, 31333, 31722, 32102, 32413, 32621, 32737, 32769, 32723, 32607, 32431, 32197, 31914, 31583, 31214, 30806, 30365, 29896, 29399, 28880, 28338, 27777, 27201, 26611, 26007, 25391, 24769, 24133, 23493, 22848, 22195, 21539, 20879, 20217, 19551, 18885, 18218, 17551, 16884, 16216, 15550, 14886, 14221, 13559, 12898, 12238, 11584, 10929, 10278, 9632, 8985, 8341, 7703, 7066, 6432, 5804, 5177, 4554, 3935, 3318, 2706, 2099, 1493, 891, 294, -300, -891, -1477, -2062, -2642, -3218, -3789, -4358, -4926, -5487, -6044, -6599, -7151, -7698, -8243, -8783, -9317, -9852, -10384, -10909, -11431, -11953, -12469, -12982, -13491, -13996, -14499, -14999, -15494, -15987, -16477, -16964, -17448, -17927, -18405, -18878, -19348, -19817, -20281, -20742, -21201, -21656, -22108, -22557, -23004, -23446, -23886, -24325, -24757, -25190, -25620, -26044, -26470, -26889, -27306, -27721, -28134, -28542, -28951, -29353, -29754, -30153, -30550, -30942, -31333, -31722, -32102, -32413, -32621, -32737, -32769, -32723, -32607, -32431, -32197, -31914, -31584, -31214, -30806, -30365, -29896, -29399, -28880, -28338, -27777, -27201, -26611, -26007, -25391, -24769, -24133, -23493, -22848, -22195, -21539, -20880, -20218, -19551, -18886, -18218, -17552, -16885, -16216, -15551, -14886, -14221, -13559, -12899, -12239, -11584, -10930, -10278, -9633, -8986, -8342, -7703, -7066, -6433, -5805, -5178, -4554, -3936, -3319, -2707, -2100, -1495, -895, -287};