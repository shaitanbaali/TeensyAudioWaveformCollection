/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_04 256 samples */
 
const int16_t AKWF_rSymSqu_04_256_DATA [256] = 
{438, 1357, 2258, 3162, 4067, 4973, 5883, 6794, 7708, 8626, 9544, 10468, 11397, 12327, 13263, 14205, 15148, 16099, 17052, 18009, 18972, 19937, 20901, 21868, 22831, 23788, 24736, 25666, 26570, 27441, 28259, 29006, 29656, 30170, 30498, 30674, 30821, 30964, 31100, 31231, 31356, 31476, 31589, 31699, 31802, 31899, 31992, 32080, 32161, 32237, 32309, 32374, 32435, 32491, 32541, 32586, 32627, 32662, 32693, 32718, 32738, 32753, 32762, 32768, 32768, 32762, 32753, 32738, 32718, 32693, 32662, 32627, 32586, 32541, 32491, 32435, 32374, 32309, 32237, 32161, 32080, 31992, 31899, 31802, 31699, 31589, 31476, 31356, 31231, 31100, 30964, 30821, 30674, 30498, 30170, 29656, 29006, 28259, 27441, 26570, 25666, 24736, 23788, 22831, 21868, 20901, 19937, 18972, 18009, 17052, 16099, 15148, 14205, 13263, 12327, 11397, 10468, 9544, 8626, 7708, 6794, 5883, 4973, 4067, 3162, 2256, 1353, 450, -451, -1354, -2257, -3163, -4068, -4974, -5884, -6794, -7709, -8627, -9545, -10469, -11397, -12328, -13264, -14205, -15148, -16099, -17053, -18010, -18973, -19937, -20902, -21868, -22832, -23788, -24736, -25666, -26571, -27442, -28259, -29006, -29656, -30170, -30498, -30674, -30821, -30964, -31100, -31231, -31356, -31476, -31590, -31699, -31802, -31899, -31992, -32080, -32161, -32237, -32309, -32374, -32435, -32491, -32541, -32586, -32627, -32662, -32693, -32718, -32738, -32753, -32762, -32768, -32768, -32762, -32753, -32738, -32718, -32693, -32662, -32627, -32586, -32541, -32491, -32435, -32374, -32309, -32237, -32161, -32080, -31992, -31899, -31802, -31699, -31590, -31476, -31356, -31231, -31100, -30964, -30821, -30674, -30498, -30170, -29656, -29006, -28259, -27442, -26571, -25666, -24736, -23788, -22832, -21868, -20902, -19937, -18973, -18010, -17053, -16099, -15148, -14205, -13264, -12328, -11397, -10469, -9545, -8627, -7709, -6794, -5884, -4974, -4068, -3163, -2259, -1358, -439};