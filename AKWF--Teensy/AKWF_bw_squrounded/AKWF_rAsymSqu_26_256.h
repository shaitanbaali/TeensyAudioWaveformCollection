/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_26 256 samples */
 
const int16_t AKWF_rAsymSqu_26_256_DATA [256] = 
{17146, 33574, 32459, 32734, 32759, 32761, 32760, 32760, 32761, 32760, 32760, 32761, 32760, 32759, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32466, 33575, 28511, -16454, -33805, -32350, -32734, -32759, -32761, -32760, -32760, -32761, -32760, -32760, -32761, -32760, -32759, -32760, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32759, -32574, -33571, -28228};