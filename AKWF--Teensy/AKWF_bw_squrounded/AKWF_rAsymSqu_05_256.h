/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_05 256 samples */
 
const int16_t AKWF_rAsymSqu_05_256_DATA [256] = 
{471, 1389, 2264, 3119, 3952, 4764, 5556, 6326, 7077, 7809, 8521, 9214, 9891, 10549, 11190, 11816, 12424, 13018, 13596, 14157, 14705, 15240, 15759, 16267, 16761, 17241, 17710, 18166, 18610, 19043, 19465, 19875, 20276, 20666, 21045, 21416, 21776, 22127, 22470, 22802, 23127, 23443, 23751, 24051, 24344, 24628, 24905, 25176, 25438, 25694, 25944, 26188, 26425, 26656, 26880, 27100, 27313, 27520, 27724, 27921, 28112, 28300, 28482, 28660, 28834, 29002, 29166, 29326, 29481, 29633, 29781, 29925, 30065, 30203, 30335, 30466, 30592, 30714, 30834, 30952, 31065, 31176, 31284, 31389, 31491, 31591, 31689, 31783, 31875, 31965, 32053, 32138, 32221, 32302, 32381, 32457, 32533, 32605, 32673, 32749, 32720, 32267, 31408, 30300, 29025, 27650, 26224, 24769, 23308, 21859, 20422, 19009, 17627, 16269, 14944, 13653, 12388, 11156, 9957, 8785, 7644, 6535, 5451, 4395, 3368, 2366, 1391, 441, -485, -1385, -2263, -3120, -3953, -4765, -5557, -6327, -7078, -7810, -8521, -9215, -9892, -10550, -11191, -11817, -12425, -13018, -13596, -14157, -14706, -15240, -15760, -16268, -16761, -17241, -17710, -18167, -18610, -19044, -19465, -19876, -20277, -20666, -21046, -21417, -21776, -22128, -22470, -22802, -23127, -23443, -23751, -24051, -24344, -24628, -24905, -25176, -25439, -25695, -25945, -26188, -26425, -26656, -26880, -27100, -27313, -27520, -27724, -27921, -28113, -28300, -28483, -28660, -28834, -29002, -29166, -29326, -29481, -29633, -29781, -29925, -30065, -30203, -30335, -30466, -30592, -30714, -30834, -30952, -31065, -31176, -31284, -31389, -31491, -31591, -31689, -31783, -31875, -31965, -32053, -32138, -32221, -32302, -32381, -32457, -32533, -32605, -32673, -32749, -32720, -32267, -31408, -30300, -29025, -27650, -26224, -24769, -23308, -21859, -20423, -19009, -17627, -16270, -14944, -13653, -12389, -11156, -9957, -8786, -7645, -6536, -5451, -4396, -3369, -2368, -1396, -430};