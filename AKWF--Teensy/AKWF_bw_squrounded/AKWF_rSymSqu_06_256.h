/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_06 256 samples */
 
const int16_t AKWF_rSymSqu_06_256_DATA [256] = 
{605, 1873, 3119, 4370, 5626, 6890, 8163, 9441, 10731, 12033, 13345, 14672, 16013, 17362, 18725, 20095, 21458, 22811, 24126, 25365, 26470, 27339, 27834, 28107, 28368, 28618, 28858, 29088, 29310, 29524, 29727, 29923, 30112, 30293, 30464, 30629, 30787, 30938, 31082, 31218, 31349, 31472, 31590, 31700, 31806, 31906, 31998, 32086, 32168, 32244, 32315, 32381, 32441, 32496, 32545, 32590, 32630, 32664, 32693, 32718, 32738, 32752, 32761, 32767, 32767, 32761, 32752, 32738, 32718, 32693, 32664, 32630, 32590, 32545, 32496, 32441, 32381, 32315, 32244, 32168, 32086, 31998, 31906, 31806, 31700, 31590, 31472, 31349, 31218, 31082, 30938, 30787, 30629, 30464, 30293, 30112, 29923, 29727, 29524, 29310, 29088, 28858, 28618, 28368, 28107, 27834, 27339, 26470, 25365, 24126, 22811, 21458, 20095, 18725, 17362, 16013, 14672, 13345, 12033, 10731, 9441, 8163, 6890, 5626, 4370, 3116, 1868, 622, -623, -1869, -3117, -4371, -5627, -6890, -8164, -9441, -10731, -12034, -13345, -14673, -16013, -17363, -18726, -20095, -21459, -22812, -24126, -25365, -26471, -27340, -27834, -28107, -28368, -28618, -28858, -29088, -29310, -29524, -29727, -29923, -30112, -30293, -30464, -30629, -30787, -30938, -31082, -31218, -31349, -31472, -31590, -31700, -31806, -31906, -31998, -32086, -32168, -32244, -32315, -32381, -32441, -32496, -32545, -32590, -32630, -32664, -32693, -32718, -32738, -32752, -32761, -32767, -32767, -32761, -32752, -32738, -32718, -32693, -32664, -32630, -32590, -32545, -32496, -32441, -32381, -32315, -32244, -32168, -32086, -31998, -31906, -31806, -31700, -31590, -31472, -31349, -31218, -31082, -30938, -30787, -30629, -30464, -30293, -30112, -29923, -29727, -29524, -29310, -29088, -28858, -28618, -28368, -28107, -27834, -27340, -26471, -25365, -24126, -22812, -21459, -20095, -18726, -17363, -16013, -14673, -13345, -12034, -10731, -9441, -8164, -6890, -5627, -4371, -3119, -1874, -606};