/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_08 256 samples */
 
const int16_t AKWF_rSymSqu_08_256_DATA [256] = 
{859, 2662, 4434, 6224, 8029, 9857, 11714, 13597, 15512, 17458, 19416, 21369, 23244, 24894, 25980, 26461, 26831, 27193, 27534, 27856, 28162, 28451, 28725, 28985, 29230, 29463, 29685, 29894, 30091, 30278, 30455, 30622, 30781, 30930, 31072, 31204, 31330, 31449, 31562, 31666, 31765, 31858, 31945, 32027, 32103, 32175, 32242, 32304, 32362, 32414, 32463, 32508, 32549, 32587, 32620, 32650, 32676, 32699, 32718, 32735, 32748, 32757, 32764, 32767, 32767, 32764, 32757, 32748, 32735, 32718, 32699, 32676, 32650, 32620, 32587, 32549, 32508, 32463, 32414, 32362, 32304, 32242, 32175, 32103, 32027, 31945, 31858, 31765, 31666, 31562, 31449, 31330, 31204, 31072, 30930, 30781, 30622, 30455, 30278, 30091, 29894, 29685, 29463, 29230, 28985, 28725, 28451, 28162, 27856, 27534, 27193, 26831, 26461, 25980, 24894, 23244, 21369, 19416, 17458, 15512, 13597, 11714, 9857, 8029, 6224, 4430, 2654, 884, -885, -2655, -4431, -6225, -8029, -9857, -11715, -13597, -15512, -17458, -19417, -21369, -23244, -24894, -25981, -26461, -26831, -27193, -27534, -27856, -28162, -28451, -28725, -28985, -29230, -29464, -29685, -29894, -30091, -30279, -30455, -30622, -30781, -30930, -31072, -31205, -31330, -31449, -31562, -31666, -31765, -31858, -31945, -32027, -32103, -32175, -32242, -32304, -32362, -32414, -32463, -32508, -32549, -32587, -32620, -32650, -32676, -32699, -32718, -32735, -32748, -32757, -32764, -32767, -32767, -32764, -32757, -32748, -32735, -32718, -32699, -32676, -32650, -32620, -32587, -32549, -32508, -32463, -32414, -32362, -32304, -32242, -32175, -32103, -32027, -31945, -31858, -31765, -31666, -31562, -31449, -31330, -31205, -31072, -30930, -30781, -30622, -30455, -30279, -30091, -29894, -29685, -29464, -29230, -28985, -28725, -28451, -28162, -27856, -27534, -27193, -26831, -26461, -25981, -24894, -23244, -21369, -19417, -17458, -15512, -13597, -11715, -9857, -8029, -6225, -4434, -2663, -860};