/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_15 256 samples */
 
const int16_t AKWF_rSymSqu_15_256_DATA [256] = 
{3361, 10507, 18036, 24119, 26247, 27392, 28420, 29231, 29891, 30430, 30866, 31221, 31511, 31745, 31936, 32093, 32218, 32322, 32405, 32473, 32527, 32572, 32609, 32638, 32663, 32683, 32699, 32712, 32723, 32731, 32737, 32743, 32749, 32752, 32755, 32757, 32760, 32761, 32762, 32763, 32765, 32765, 32765, 32766, 32767, 32766, 32767, 32766, 32767, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32767, 32766, 32767, 32766, 32767, 32766, 32765, 32765, 32765, 32763, 32762, 32761, 32760, 32757, 32755, 32752, 32749, 32743, 32737, 32731, 32723, 32712, 32699, 32683, 32663, 32638, 32609, 32572, 32527, 32473, 32405, 32322, 32218, 32093, 31936, 31745, 31511, 31221, 30866, 30430, 29891, 29231, 28420, 27392, 26247, 24119, 18023, 10475, 3454, -3455, -10476, -18024, -24119, -26247, -27392, -28420, -29231, -29891, -30430, -30866, -31221, -31511, -31745, -31936, -32093, -32218, -32322, -32405, -32473, -32527, -32572, -32609, -32638, -32663, -32683, -32699, -32712, -32723, -32731, -32737, -32743, -32749, -32752, -32755, -32757, -32760, -32761, -32762, -32763, -32765, -32765, -32765, -32766, -32767, -32766, -32767, -32766, -32767, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32767, -32766, -32767, -32766, -32767, -32766, -32765, -32765, -32765, -32763, -32762, -32761, -32760, -32757, -32755, -32752, -32749, -32743, -32737, -32731, -32723, -32712, -32699, -32683, -32663, -32638, -32609, -32572, -32527, -32473, -32405, -32322, -32218, -32093, -31936, -31745, -31511, -31221, -30866, -30430, -29891, -29231, -28420, -27392, -26247, -24119, -18036, -10507, -3362};