/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rSymSqu_13 256 samples */
 
const int16_t AKWF_rSymSqu_13_256_DATA [256] = 
{2290, 7123, 11990, 17083, 22145, 25180, 26218, 27083, 27844, 28499, 29064, 29556, 29984, 30352, 30673, 30953, 31193, 31402, 31584, 31742, 31878, 31996, 32100, 32189, 32266, 32333, 32391, 32441, 32485, 32522, 32556, 32584, 32609, 32631, 32649, 32665, 32679, 32691, 32701, 32711, 32719, 32726, 32732, 32737, 32742, 32745, 32749, 32752, 32754, 32757, 32758, 32760, 32762, 32762, 32764, 32765, 32765, 32765, 32766, 32767, 32766, 32767, 32766, 32767, 32767, 32766, 32767, 32766, 32767, 32766, 32765, 32765, 32765, 32764, 32762, 32762, 32760, 32758, 32757, 32754, 32752, 32749, 32745, 32742, 32737, 32732, 32726, 32719, 32711, 32701, 32691, 32679, 32665, 32649, 32631, 32609, 32584, 32556, 32522, 32485, 32441, 32391, 32333, 32266, 32189, 32100, 31996, 31878, 31742, 31584, 31402, 31193, 30953, 30673, 30352, 29984, 29556, 29064, 28499, 27844, 27083, 26218, 25180, 22145, 17083, 11981, 7101, 2355, -2355, -7102, -11982, -17084, -22145, -25180, -26219, -27083, -27844, -28499, -29065, -29556, -29984, -30352, -30673, -30953, -31193, -31402, -31584, -31742, -31878, -31996, -32100, -32189, -32266, -32333, -32391, -32441, -32485, -32522, -32556, -32584, -32609, -32631, -32649, -32665, -32679, -32691, -32701, -32711, -32719, -32726, -32732, -32737, -32742, -32745, -32749, -32752, -32754, -32757, -32758, -32760, -32762, -32762, -32764, -32765, -32765, -32765, -32766, -32767, -32766, -32767, -32766, -32767, -32767, -32766, -32767, -32766, -32767, -32766, -32765, -32765, -32765, -32764, -32762, -32762, -32760, -32758, -32757, -32754, -32752, -32749, -32745, -32742, -32737, -32732, -32726, -32719, -32711, -32701, -32691, -32679, -32665, -32649, -32631, -32609, -32584, -32556, -32522, -32485, -32441, -32391, -32333, -32266, -32189, -32100, -31996, -31878, -31742, -31584, -31402, -31193, -30953, -30673, -30352, -29984, -29556, -29065, -28499, -27844, -27083, -26219, -25180, -22145, -17084, -11990, -7123, -2291};