/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_rAsymSqu_10 256 samples */
 
const int16_t AKWF_rAsymSqu_10_256_DATA [256] = 
{1183, 3646, 5867, 7925, 9823, 11579, 13205, 14699, 16082, 17362, 18539, 19629, 20636, 21563, 22421, 23214, 23944, 24621, 25245, 25820, 26353, 26844, 27297, 27717, 28103, 28460, 28791, 29095, 29376, 29636, 29876, 30098, 30302, 30491, 30666, 30827, 30976, 31113, 31240, 31357, 31465, 31566, 31657, 31742, 31822, 31894, 31962, 32023, 32080, 32134, 32182, 32227, 32269, 32308, 32343, 32376, 32406, 32434, 32459, 32484, 32506, 32527, 32545, 32562, 32578, 32593, 32606, 32619, 32631, 32642, 32652, 32660, 32669, 32677, 32684, 32691, 32697, 32702, 32708, 32713, 32718, 32722, 32725, 32728, 32733, 32735, 32737, 32741, 32743, 32745, 32747, 32749, 32750, 32752, 32754, 32755, 32756, 32758, 32758, 32759, 32760, 32761, 32762, 32762, 32763, 32764, 32763, 32765, 32765, 32766, 32767, 32767, 32766, 32767, 32768, 32767, 32756, 32778, 32580, 30380, 26414, 22170, 18052, 14192, 10611, 7288, 4225, 1396, -1222, -3634, -5863, -7925, -9824, -11580, -13205, -14700, -16083, -17362, -18539, -19630, -20636, -21563, -22421, -23215, -23945, -24621, -25245, -25821, -26353, -26844, -27297, -27717, -28103, -28460, -28791, -29095, -29376, -29636, -29876, -30098, -30303, -30491, -30666, -30827, -30976, -31113, -31240, -31357, -31465, -31566, -31657, -31742, -31822, -31894, -31962, -32023, -32080, -32134, -32182, -32227, -32269, -32308, -32343, -32376, -32406, -32434, -32459, -32484, -32506, -32527, -32545, -32562, -32578, -32593, -32606, -32619, -32631, -32642, -32652, -32660, -32669, -32677, -32684, -32691, -32697, -32702, -32708, -32713, -32718, -32722, -32725, -32728, -32733, -32735, -32737, -32741, -32743, -32745, -32747, -32749, -32750, -32752, -32754, -32755, -32756, -32758, -32758, -32759, -32760, -32761, -32762, -32762, -32763, -32764, -32763, -32765, -32765, -32766, -32767, -32767, -32766, -32767, -32768, -32767, -32756, -32778, -32580, -30380, -26414, -22170, -18053, -14193, -10612, -7294, -4236, -1363};