/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0031 256 samples */
 
const int16_t AKWF_fmsynth_0031_256_DATA [256] = 
{718, 3328, 6038, 8734, 11383, 13972, 16459, 18799, 20974, 22957, 24723, 26291, 27637, 28773, 29711, 30465, 31055, 31507, 31839, 32077, 32239, 32341, 32400, 32418, 32401, 32351, 32262, 32123, 31930, 31666, 31332, 30914, 30407, 29810, 29123, 28351, 27512, 26615, 25677, 24714, 23750, 22804, 21907, 21077, 20331, 19696, 19185, 18815, 18604, 18553, 18674, 18967, 19434, 20067, 20849, 21778, 22835, 23988, 25212, 26468, 27726, 28944, 30071, 31062, 31866, 32438, 32738, 32721, 32353, 31613, 30482, 28963, 27059, 24798, 22224, 19397, 16350, 13182, 9964, 6788, 3756, 936, -1543, -3504, -4971, -5991, -6587, -6783, -6596, -6035, -5101, -3799, -2129, -67, 2270, 4740, 7272, 9783, 12247, 14614, 16833, 18884, 20747, 22396, 23857, 25114, 26177, 27051, 27766, 28321, 28734, 29016, 29170, 29201, 29110, 28884, 28507, 27963, 27226, 26246, 24989, 23407, 21436, 19027, 16125, 12622, 8496, 3657, -1863, -7207, -12045, -16369, -20128, -23335, -26004, -28139, -29817, -31064, -31924, -32457, -32720, -32765, -32645, -32408, -32100, -31758, -31421, -31109, -30845, -30650, -30531, -30493, -30533, -30651, -30835, -31075, -31353, -31650, -31950, -32228, -32466, -32646, -32749, -32766, -32683, -32498, -32214, -31840, -31384, -30866, -30314, -29752, -29213, -28724, -28315, -28011, -27836, -27802, -27916, -28178, -28573, -29081, -29675, -30316, -30964, -31573, -32102, -32501, -32728, -32754, -32545, -32084, -31351, -30358, -29111, -27620, -25908, -24010, -21961, -19799, -17583, -15318, -13073, -10871, -8750, -6754, -4898, -3191, -1674, -343, 781, 1701, 2414, 2916, 3210, 3296, 3185, 2885, 2396, 1741, 921, -40, -1133, -2339, -3644, -5014, -6431, -7873, -9322, -10748, -12135, -13459, -14693, -15840, -16873, -17786, -18566, -19206, -19699, -20045, -20235, -20265, -20133, -19833, -19353, -18693, -17845, -16799, -15556, -14118, -12467, -10627, -8599, -6392, -4056, -1507};