/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0080 256 samples */
 
const int16_t AKWF_fmsynth_0080_256_DATA [256] = 
{2695, 6464, 10336, 14036, 17234, 19705, 21263, 21838, 21509, 20452, 18936, 17226, 15620, 14375, 13690, 13714, 14524, 16123, 18418, 21220, 24283, 27258, 29848, 31729, 32677, 32600, 31554, 29713, 27348, 24768, 22283, 20145, 18550, 17604, 17365, 17824, 18889, 20432, 22234, 24009, 25437, 26200, 26049, 24848, 22616, 19541, 15889, 12038, 8309, 4980, 2305, 447, -527, -634, 19, 1260, 2849, 4511, 5956, 6905, 7130, 6490, 4946, 2450, -815, -4595, -8591, -12547, -16236, -19475, -22106, -24002, -25056, -25241, -24614, -23340, -21627, -19758, -17999, -16590, -15694, -15387, -15657, -16439, -17646, -19181, -20990, -23006, -25140, -27272, -29245, -30879, -32003, -32469, -32207, -31216, -29591, -27454, -24975, -22322, -19666, -17154, -14920, -13098, -11827, -11205, -11284, -12022, -13315, -14960, -16711, -18281, -19399, -19839, -19442, -18133, -15915, -12879, -9227, -5113, -834, 3306, 7013, 9987, 12014, 13019, 12996, 12084, 10504, 8558, 6525, 4708, 3394, 2817, 3142, 4446, 6727, 9854, 13597, 17622, 21599, 25102, 27797, 29431, 29916, 29332, 27898, 25922, 23738, 21652, 19922, 18704, 18128, 18258, 19106, 20617, 22669, 25085, 27566, 29782, 31394, 32094, 31702, 30185, 27682, 24470, 20917, 17433, 14304, 11830, 10176, 9396, 9461, 10257, 11610, 13288, 15022, 16528, 17515, 17752, 17059, 15388, 12818, 9549, 5839, 1928, -1944, -5478, -8429, -10670, -12076, -12649, -12467, -11696, -10542, -9259, -8114, -7341, -7117, -7533, -8595, -10235, -12336, -14789, -17454, -20221, -22976, -25549, -27760, -29454, -30482, -30791, -30387, -29373, -27915, -26210, -24437, -22735, -21192, -19856, -18757, -17937, -17460, -17425, -17909, -18941, -20458, -22319, -24304, -26147, -27578, -28368, -28373, -27540, -25911, -23586, -20711, -17471, -14018, -10512, -7181, -4219, -1864, -261, 482, 383, -443, -1780, -3363, -4907, -6124, -6768, -6649, -5675, -3845, -1020};