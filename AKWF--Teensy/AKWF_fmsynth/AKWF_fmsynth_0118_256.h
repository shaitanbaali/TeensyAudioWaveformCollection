/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0118 256 samples */
 
const int16_t AKWF_fmsynth_0118_256_DATA [256] = 
{3652, 11340, 18559, 24522, 28738, 31217, 32355, 32712, 32766, 32736, 32560, 31984, 30725, 28634, 25832, 22706, 19834, 17724, 16830, 17391, 19403, 22570, 26282, 29751, 32018, 32377, 30607, 27137, 22801, 18605, 15408, 13712, 13679, 15200, 17956, 21416, 24924, 27917, 30051, 31291, 31856, 32020, 31977, 31672, 30781, 28755, 25021, 19304, 11899, 3769, -3970, -10829, -16177, -19725, -21591, -21983, -21018, -18733, -15192, -10636, -5568, -644, 3679, 6998, 8907, 9166, 7676, 4369, -544, -6906, -14170, -21232, -27005, -30780, -32507, -32694, -32095, -31407, -31094, -31307, -31889, -32468, -32612, -32004, -30585, -28618, -26613, -25133, -24614, -25272, -26986, -29279, -31375, -32382, -31609, -28794, -24269, -18832, -13459, -8912, -5788, -4347, -4629, -6485, -9619, -13597, -17820, -21746, -24935, -27167, -28489, -28999, -28750, -27632, -25360, -21612, -16143, -9149, -1235, 6753, 13854, 19504, 23502, 25941, 27090, 27181, 26300, 24409, 21478, 17622, 13202, 8662, 4634, 1626, 26, 65, 1846, 5355, 10324, 16234, 22271, 27434, 31000, 32580, 32370, 31032, 29397, 28191, 27816, 28360, 29572, 30992, 32093, 32498, 32103, 31110, 29939, 29067, 28853, 29413, 30556, 31768, 32290, 31333, 28343, 23293, 16798, 9952, 3835, -766, -3698, -4869, -4258, -2072, 1421, 5921, 10889, 15665, 19662, 22544, 24277, 24856, 24277, 22376, 18925, 13674, 6728, -1157, -9382, -17118, -23250, -27505, -30020, -31273, -31738, -31692, -31148, -29930, -27820, -24757, -20924, -16834, -13089, -10317, -8979, -9336, -11444, -15157, -19983, -25084, -29406, -32027, -32521, -31073, -28359, -25276, -22663, -21091, -20824, -21822, -23813, -26326, -28799, -30742, -31912, -32322, -32245, -32053, -32016, -32160, -32202, -31594, -29684, -26034, -20564, -13738, -6402, 488, 6199, 10322, 12744, 13492, 12662, 10375, 6840, 2342, -2604, -7451, -11637, -14763, -16617, -17098, -16100, -13519, -9263, -3286};