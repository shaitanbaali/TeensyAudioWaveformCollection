/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0086 256 samples */
 
const int16_t AKWF_fmsynth_0086_256_DATA [256] = 
{2744, 10665, 17517, 23101, 27209, 29950, 31560, 32349, 32653, 32728, 32726, 32671, 32487, 32020, 31069, 29477, 27132, 24031, 20309, 16211, 12015, 8071, 4613, 1889, 70, -734, -462, 925, 3429, 6993, 11441, 16482, 21646, 26406, 30096, 32141, 32135, 29995, 25940, 20518, 14437, 8442, 3187, -1064, -4240, -6303, -7210, -6992, -5697, -3401, -264, 3600, 8088, 12824, 17478, 21681, 25162, 27802, 29626, 30755, 31371, 31643, 31685, 31526, 31074, 30129, 28389, 25506, 21207, 15385, 8200, 286, -7895, -15891, -22735, -27836, -31067, -32558, -32714, -32027, -30988, -29995, -29319, -29119, -29412, -30117, -31035, -31932, -32517, -32527, -31779, -30194, -27845, -24940, -21802, -18780, -16221, -14374, -13446, -13551, -14726, -16897, -19907, -23438, -27015, -30052, -31927, -32136, -30382, -26669, -21285, -14772, -7818, -1027, 5138, 10288, 14314, 17197, 19001, 19846, 19788, 18868, 17085, 14454, 11024, 6854, 2166, -2786, -7721, -12293, -16316, -19623, -22132, -23858, -24854, -25155, -24763, -23608, -21574, -18484, -14256, -8833, -2320, 4904, 12326, 19319, 25269, 29600, 32066, 32670, 31723, 29693, 27152, 24633, 22550, 21202, 20730, 21144, 22364, 24210, 26414, 28628, 30548, 31883, 32438, 32170, 31177, 29683, 27951, 26294, 24993, 24257, 24215, 24897, 26230, 28012, 29906, 31465, 32149, 31440, 28894, 24339, 17948, 10293, 2282, -5377, -12445, -18350, -22848, -26002, -28050, -29235, -29781, -29811, -29360, -28364, -26714, -24289, -21016, -16967, -12246, -7186, -2203, 2422, 6573, 10022, 12600, 14213, 14823, 14403, 12908, 10265, 6438, 1552, -4239, -10846, -17675, -23919, -28804, -31757, -32552, -31328, -28474, -24572, -20236, -16031, -12394, -9599, -7805, -7092, -7450, -8816, -11055, -14019, -17434, -21020, -24459, -27438, -29749, -31304, -32099, -32286, -32086, -31742, -31469, -31404, -31581, -31897, -32125, -31930, -30898, -28646, -24895, -19606, -12904, -5051};