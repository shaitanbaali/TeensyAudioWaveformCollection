/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0034 256 samples */
 
const int16_t AKWF_fmsynth_0034_256_DATA [256] = 
{7584, 21181, 29310, 32596, 32143, 29695, 26867, 24826, 24186, 25118, 27348, 30156, 32361, 32461, 28985, 20996, 8759, -6062, -20260, -30169, -32569, -26036, -12143, 4633, 19416, 29068, 32683, 31547, 27620, 22794, 18452, 15450, 14267, 15069, 17779, 21996, 26956, 31223, 32733, 29127, 18729, 2308, -15927, -29423, -32452, -23815, -6925, 12326, 27149, 32794, 28019, 15171, -639, -14772, -24764, -30272, -32430, -32741, -32403, -32183, -32352, -32704, -32588, -30938, -26441, -18015, -5603, 8990, 22770, 31384, 32006, 24349, 10622, -5476, -19913, -29499, -32788, -30172, -23519, -15071, -7001, -643, 3487, 5304, 4754, 1830, -3455, -10962, -19735, -27750, -32446, -31166, -22541, -7431, 10560, 25847, 32780, 27517, 11163, -9438, -25820, -32666, -29748, -20149, -7796, 4170, 13932, 20862, 25197, 27517, 28394, 28110, 26585, 23412, 18052, 10160, -187, -12025, -23251, -31033, -32369, -25536, -11134, 6588, 22239, 31287, 32273, 26641, 17014, 6185, -3786, -11770, -17370, -20811, -22388, -22295, -20502, -16729, -10657, -2030, 8667, 19948, 29165, 32806, 27675, 12975, -7125, -24873, -32737, -28179, -13900, 4463, 20790, 30649, 32522, 27376, 17972, 7463, -1668, -8483, -12891, -14907, -14738, -12373, -7730, -740, 8338, 18455, 27375, 32399, 31340, 23427, 9807, -6435, -21267, -30737, -32433, -26197, -14179, -252, 12344, 21777, 27701, 30794, 32102, 32513, 32546, 32247, 31187, 28474, 22967, 13644, 771, -13993, -26765, -32719, -28932, -15833, 2800, 20784, 31584, 30936, 18814, 460, -17229, -28823, -32758, -30654, -25086, -18449, -12441, -8039, -5664, -5461, -7411, -11386, -16989, -23411, -29262, -32596, -31236, -23469, -9505, 7572, 22904, 31724, 31653, 23623, 10580, -3827, -16536, -25739, -30917, -32714, -32338, -31107, -30038, -29762, -30425, -31684, -32700, -32189, -28678, -20987, -8843, 6339, 21155, 31152, 31630, 20431, 737, -19309, -31256, -31450, -21363, -5967};