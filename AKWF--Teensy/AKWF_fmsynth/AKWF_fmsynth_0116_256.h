/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0116 256 samples */
 
const int16_t AKWF_fmsynth_0116_256_DATA [256] = 
{2481, 6548, 10366, 13954, 17238, 20180, 22755, 24948, 26774, 28256, 29424, 30319, 30987, 31464, 31790, 31998, 32111, 32144, 32103, 31988, 31785, 31481, 31055, 30487, 29754, 28837, 27725, 26410, 24895, 23188, 21316, 19306, 17191, 15023, 12840, 10690, 8625, 6685, 4908, 3336, 1993, 904, 97, -419, -633, -532, -110, 637, 1703, 3093, 4791, 6772, 9018, 11481, 14109, 16850, 19617, 22328, 24903, 27243, 29255, 30870, 32018, 32648, 32740, 32299, 31346, 29928, 28127, 26018, 23693, 21266, 18818, 16439, 14215, 12195, 10432, 8966, 7810, 6980, 6482, 6313, 6466, 6930, 7700, 8749, 10051, 11584, 13308, 15174, 17137, 19139, 21126, 23048, 24853, 26497, 27956, 29202, 30229, 31041, 31647, 32072, 32344, 32495, 32557, 32562, 32541, 32512, 32492, 32492, 32503, 32516, 32504, 32437, 32267, 31946, 31411, 30607, 29478, 27957, 26014, 23624, 20769, 17487, 13829, 9866, 5726, 1554, -2568, -6683, -10697, -14483, -17929, -20989, -23630, -25838, -27641, -29071, -30166, -30983, -31570, -31975, -32244, -32409, -32493, -32516, -32485, -32393, -32232, -31982, -31622, -31123, -30462, -29612, -28553, -27276, -25778, -24059, -22149, -20076, -17872, -15599, -13302, -11037, -8868, -6838, -4990, -3371, -2000, -899, -88, 430, 643, 540, 115, -632, -1711, -3129, -4878, -6937, -9289, -11884, -14652, -17526, -20409, -23194, -25791, -28085, -29991, -31439, -32367, -32752, -32592, -31908, -30747, -29172, -27267, -25115, -22802, -20430, -18067, -15793, -13674, -11758, -10085, -8688, -7588, -6796, -6318, -6155, -6302, -6750, -7484, -8484, -9726, -11185, -12820, -14590, -16464, -18382, -20300, -22176, -23958, -25610, -27104, -28411, -29518, -30427, -31138, -31671, -32048, -32292, -32437, -32510, -32536, -32540, -32536, -32528, -32513, -32478, -32400, -32247, -31973, -31536, -30878, -29953, -28712, -27109, -25118, -22732, -19943, -16783, -13296, -9538, -5599, -1469};