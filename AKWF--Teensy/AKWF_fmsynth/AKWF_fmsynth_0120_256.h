/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0120 256 samples */
 
const int16_t AKWF_fmsynth_0120_256_DATA [256] = 
{3590, 11354, 18529, 24290, 28190, 30398, 31390, 31621, 31279, 30253, 28356, 25533, 22112, 18680, 15962, 14616, 15026, 17244, 20904, 25290, 29322, 31933, 32517, 31220, 28836, 26438, 24925, 24757, 25883, 27824, 29915, 31499, 32259, 32291, 32009, 31847, 31988, 32223, 31922, 30248, 26581, 20853, 13877, 6931, 1289, -2441, -4147, -3747, -1467, 2302, 7051, 12052, 16452, 19661, 21413, 21642, 20230, 16961, 11642, 4558, -3440, -11591, -18797, -24085, -27382, -29045, -29523, -29034, -27543, -24926, -21243, -16925, -12741, -9467, -7797, -8111, -10528, -14804, -20252, -25763, -30050, -32321, -32529, -31366, -29789, -28662, -28461, -29195, -30484, -31735, -32434, -32335, -31634, -30827, -30443, -30747, -31568, -32270, -31971, -29907, -25882, -20389, -14449, -9189, -5449, -3640, -3872, -5963, -9487, -13768, -18070, -21748, -24357, -25787, -26038, -25064, -22609, -18393, -12343, -4828, 3223, 10689, 16787, 21012, 23416, 24227, 23632, 21694, 18488, 14291, 9640, 5265, 1932, 153, 314, 2542, 6749, 12448, 18820, 24783, 29300, 31864, 32692, 32488, 32050, 31920, 32188, 32548, 32524, 31753, 30236, 28365, 26771, 26045, 26495, 28051, 30169, 31925, 32320, 30666, 26989, 22110, 17237, 13484, 11560, 11634, 13572, 16869, 20797, 24515, 27419, 29298, 30230, 30415, 29880, 28350, 25286, 20220, 13201, 5090, -2772, -9642, -14837, -17978, -19148, -18521, -16240, -12478, -7680, -2585, 1996, 5532, 7471, 7465, 5333, 1156, -4791, -12023, -19437, -25620, -29791, -31942, -32675, -32762, -32732, -32733, -32536, -31754, -30113, -27697, -25009, -22789, -21724, -22212, -24219, -27233, -30275, -32219, -32249, -30238, -26800, -22983, -19840, -18095, -18034, -19540, -22167, -25240, -28046, -30099, -31291, -31793, -31888, -31653, -30850, -28925, -25309, -19832, -12888, -5433, 1354, 6711, 10148, 11556, 11027, 8737, 5005, 291, -4670, -9133, -12465, -14311, -14430, -12695, -9003, -3246};