/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0108 256 samples */
 
const int16_t AKWF_fmsynth_0108_256_DATA [256] = 
{610, 1808, 2931, 4007, 5026, 5991, 6902, 7751, 8545, 9281, 9955, 10574, 11135, 11637, 12084, 12478, 12819, 13108, 13350, 13545, 13695, 13805, 13875, 13909, 13911, 13883, 13826, 13747, 13645, 13528, 13395, 13250, 13096, 12935, 12771, 12607, 12446, 12287, 12133, 11989, 11855, 11733, 11622, 11526, 11445, 11381, 11332, 11301, 11287, 11290, 11309, 11344, 11396, 11462, 11542, 11637, 11741, 11856, 11980, 12111, 12247, 12388, 12532, 12674, 12816, 12953, 13086, 13211, 13328, 13433, 13526, 13607, 13669, 13716, 13744, 13751, 13738, 13703, 13644, 13561, 13454, 13320, 13162, 12978, 12766, 12529, 12265, 11975, 11660, 11320, 10954, 10565, 10152, 9716, 9259, 8782, 8284, 7769, 7238, 6688, 6128, 5552, 4965, 4370, 3764, 3152, 2535, 1913, 1288, 664, 39, -584, -1202, -1818, -2427, -3026, -3620, -4203, -4773, -5334, -5879, -6411, -6927, -7427, -7910, -8375, -8822, -9248, -9655, -10041, -10405, -10748, -11068, -11366, -11640, -11891, -12117, -12319, -12497, -12648, -12774, -12875, -12950, -12999, -13021, -13016, -12984, -12924, -12837, -12722, -12579, -12408, -12208, -11979, -11721, -11434, -11118, -10772, -10397, -9993, -9558, -9096, -8604, -8082, -7532, -6955, -6348, -5717, -5058, -4375, -3670, -2939, -2187, -1419, -631, 173, 987, 1814, 2648, 3485, 4326, 5163, 5991, 6811, 7613, 8394, 9150, 9872, 10555, 11195, 11781, 12308, 12767, 13149, 13446, 13650, 13748, 13732, 13590, 13311, 12884, 12294, 11534, 10582, 9427, 8062, 6461, 4613, 2507, 116, -2570, -5560, -8908, -12358, -15512, -18371, -20938, -23216, -25228, -26976, -28468, -29722, -30743, -31543, -32135, -32526, -32731, -32758, -32619, -32325, -31886, -31313, -30617, -29804, -28891, -27881, -26788, -25621, -24385, -23091, -21752, -20369, -18954, -17516, -16056, -14587, -13114, -11641, -10176, -8729, -7295, -5889, -4513, -3168, -1864, -576};