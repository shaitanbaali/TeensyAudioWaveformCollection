/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0005 256 samples */
 
const int16_t AKWF_fmsynth_0005_256_DATA [256] = 
{1844, 4752, 7379, 9783, 11937, 13836, 15477, 16853, 17976, 18854, 19494, 19913, 20127, 20151, 20004, 19704, 19272, 18723, 18077, 17354, 16567, 15735, 14873, 13992, 13108, 12233, 11373, 10544, 9750, 8997, 8297, 7650, 7062, 6538, 6082, 5694, 5378, 5135, 4966, 4873, 4856, 4915, 5051, 5262, 5549, 5909, 6342, 6846, 7414, 8048, 8742, 9488, 10283, 11119, 11985, 12874, 13773, 14669, 15551, 16401, 17203, 17943, 18598, 19151, 19584, 19877, 20009, 19962, 19721, 19266, 18584, 17667, 16502, 15085, 13420, 11501, 9341, 6960, 4363, 1580, -1349, -4407, -7544, -10711, -13872, -16964, -19929, -22724, -25280, -27539, -29457, -30977, -32054, -32653, -32743, -32307, -31334, -29837, -27833, -25355, -22466, -19228, -15724, -12073, -8386, -4755, -1122, 2464, 5878, 9022, 11841, 14276, 16290, 17873, 19018, 19730, 20030, 19942, 19500, 18738, 17695, 16418, 14941, 13312, 11571, 9748, 7888, 6018, 4161, 2352, 609, -1055, -2615, -4069, -5404, -6608, -7682, -8622, -9421, -10081, -10602, -10980, -11214, -11307, -11255, -11056, -10711, -10217, -9570, -8772, -7820, -6713, -5454, -4045, -2489, -799, 1011, 2931, 4931, 6985, 9063, 11115, 13098, 14958, 16627, 18040, 19127, 19812, 20021, 19685, 18744, 17147, 14866, 11914, 8311, 4148, -422, -5191, -10044, -14997, -19796, -24137, -27772, -30517, -32204, -32734, -32066, -30211, -27237, -23258, -18457, -13044, -7256, -1390, 4277, 9461, 13857, 17224, 19342, 20043, 19235, 16910, 13169, 8203, 2343, -3893, -10147, -16349, -22014, -26719, -30160, -32162, -32673, -31718, -29410, -25911, -21449, -16283, -10661, -4886, 771, 6073, 10763, 14647, 17570, 19404, 20085, 19594, 17966, 15286, 11687, 7371, 2556, -2475, -7415, -12310, -17043, -21343, -25066, -28093, -30356, -31844, -32563, -32547, -31852, -30544, -28704, -26404, -23736, -20785, -17619, -14325, -10973, -7623, -4394, -1163};