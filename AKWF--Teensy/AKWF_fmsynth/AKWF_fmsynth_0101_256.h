/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0101 256 samples */
 
const int16_t AKWF_fmsynth_0101_256_DATA [256] = 
{1138, 5228, 9137, 12895, 16432, 19701, 22658, 25257, 27482, 29317, 30745, 31779, 32427, 32707, 32643, 32273, 31625, 30741, 29663, 28433, 27088, 25671, 24219, 22761, 21332, 19961, 18665, 17471, 16390, 15437, 14622, 13952, 13431, 13063, 12851, 12793, 12887, 13131, 13524, 14054, 14721, 15516, 16425, 17440, 18547, 19723, 20961, 22238, 23531, 24819, 26081, 27287, 28419, 29452, 30364, 31135, 31746, 32181, 32429, 32480, 32329, 31975, 31419, 30667, 29728, 28618, 27349, 25935, 24406, 22776, 21066, 19306, 17513, 15707, 13919, 12156, 10444, 8801, 7237, 5767, 4408, 3162, 2040, 1054, 201, -507, -1069, -1482, -1744, -1851, -1802, -1593, -1226, -699, -10, 838, 1851, 3019, 4341, 5814, 7423, 9163, 11020, 12968, 14996, 17076, 19169, 21253, 23286, 25218, 27016, 28626, 29998, 31088, 31845, 32223, 32183, 31692, 30726, 29265, 27311, 24881, 21983, 18679, 15029, 11097, 6997, 2844, -1263, -5369, -9466, -13429, -17145, -20551, -23584, -26196, -28372, -30100, -31381, -32236, -32686, -32762, -32504, -31950, -31147, -30132, -28953, -27657, -26268, -24835, -23387, -21953, -20562, -19236, -17988, -16845, -15815, -14905, -14131, -13494, -12999, -12652, -12449, -12393, -12483, -12716, -13087, -13593, -14228, -14984, -15848, -16818, -17877, -19009, -20207, -21449, -22715, -23992, -25254, -26482, -27655, -28749, -29741, -30613, -31344, -31913, -32305, -32510, -32515, -32311, -31899, -31277, -30450, -29431, -28228, -26856, -25343, -23704, -21961, -20147, -18284, -16396, -14517, -12662, -10858, -9133, -7492, -5960, -4548, -3262, -2117, -1115, -257, 453, 1017, 1435, 1701, 1809, 1760, 1548, 1176, 643, -47, -900, -1928, -3122, -4484, -6013, -7695, -9521, -11474, -13527, -15660, -17838, -20015, -22161, -24225, -26154, -27908, -29430, -30671, -31593, -32152, -32311, -32046, -31336, -30177, -28563, -26510, -24041, -21182, -17981, -14492, -10764, -6872, -2790};