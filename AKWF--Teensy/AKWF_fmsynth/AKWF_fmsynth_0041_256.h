/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0041 256 samples */
 
const int16_t AKWF_fmsynth_0041_256_DATA [256] = 
{573, 2113, 3592, 5141, 6700, 8276, 9862, 11429, 12992, 14536, 16044, 17513, 18932, 20283, 21585, 22814, 23966, 25046, 26041, 26953, 27788, 28544, 29217, 29816, 30339, 30796, 31188, 31521, 31801, 32029, 32216, 32367, 32483, 32572, 32638, 32688, 32721, 32744, 32758, 32765, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32766, 32762, 32761, 32758, 32754, 32753, 32753, 32753, 32752, 32753, 32758, 32763, 32767, 32767, 32768, 32765, 32753, 32731, 32696, 32646, 32571, 32472, 32339, 32169, 31958, 31696, 31378, 30999, 30551, 30031, 29434, 28753, 27986, 27130, 26181, 25150, 24019, 22801, 21503, 20122, 18672, 17165, 15589, 13977, 12327, 10667, 8989, 7315, 5657, 4030, 2445, 913, -564, -2005, -3410, -4763, -6056, -7294, -8460, -9559, -10583, -11530, -12403, -13204, -13929, -14584, -15170, -15685, -16137, -16527, -16856, -17131, -17353, -17524, -17650, -17734, -17779, -17788, -17766, -17715, -17642, -17548, -17439, -17320, -17194, -17064, -16938, -16817, -16708, -16616, -16543, -16495, -16476, -16492, -16543, -16633, -16769, -16950, -17179, -17456, -17787, -18171, -18607, -19095, -19633, -20216, -20846, -21521, -22230, -22975, -23737, -24521, -25321, -26118, -26913, -27691, -28440, -29163, -29842, -30465, -31030, -31526, -31946, -32284, -32536, -32700, -32767, -32742, -32624, -32412, -32109, -31723, -31258, -30718, -30110, -29442, -28725, -27966, -27176, -26358, -25529, -24688, -23850, -23025, -22214, -21428, -20672, -19948, -19266, -18628, -18035, -17490, -16995, -16554, -16164, -15825, -15538, -15300, -15110, -14967, -14868, -14806, -14780, -14791, -14832, -14894, -14978, -15080, -15194, -15317, -15442, -15567, -15686, -15796, -15890, -15968, -16026, -16055, -16056, -16024, -15951, -15842, -15688, -15487, -15235, -14929, -14568, -14149, -13668, -13123, -12510, -11827, -11084, -10262, -9370, -8406, -7374, -6275, -5101, -3860, -2576, -1175};