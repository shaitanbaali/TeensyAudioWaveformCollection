/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0106 256 samples */
 
const int16_t AKWF_fmsynth_0106_256_DATA [256] = 
{167, 553, 934, 1319, 1708, 2099, 2496, 2893, 3295, 3701, 4108, 4520, 4937, 5355, 5778, 6203, 6631, 7063, 7499, 7936, 8377, 8821, 9266, 9715, 10164, 10615, 11071, 11526, 11981, 12439, 12897, 13354, 13814, 14272, 14729, 15187, 15643, 16097, 16551, 17002, 17452, 17899, 18343, 18785, 19223, 19657, 20089, 20519, 20943, 21365, 21781, 22193, 22602, 23005, 23405, 23800, 24190, 24575, 24957, 25332, 25703, 26069, 26430, 26786, 27136, 27479, 27817, 28150, 28476, 28794, 29107, 29410, 29706, 29995, 30273, 30542, 30800, 31048, 31283, 31507, 31715, 31908, 32086, 32247, 32388, 32509, 32610, 32687, 32739, 32765, 32763, 32730, 32666, 32568, 32434, 32262, 32050, 31796, 31497, 31151, 30758, 30313, 29814, 29261, 28650, 27979, 27248, 26453, 25592, 24666, 23668, 22600, 21465, 20252, 18964, 17605, 16165, 14648, 13055, 11380, 9625, 7793, 5875, 3880, 1804, -353, -2468, -4471, -6376, -8176, -9883, -11502, -13029, -14474, -15842, -17130, -18347, -19496, -20577, -21597, -22556, -23456, -24304, -25099, -25843, -26541, -27192, -27799, -28365, -28891, -29377, -29827, -30240, -30618, -30963, -31274, -31554, -31804, -32022, -32211, -32372, -32505, -32611, -32688, -32739, -32764, -32764, -32739, -32690, -32615, -32518, -32398, -32255, -32089, -31903, -31695, -31468, -31220, -30954, -30670, -30367, -30049, -29715, -29364, -29001, -28624, -28233, -27833, -27421, -26998, -26568, -26129, -25682, -25231, -24773, -24310, -23845, -23376, -22904, -22433, -21960, -21485, -21012, -20541, -20071, -19603, -19138, -18673, -18214, -17758, -17307, -16859, -16415, -15976, -15542, -15111, -14686, -14266, -13851, -13439, -13033, -12631, -12233, -11841, -11450, -11066, -10685, -10306, -9933, -9562, -9192, -8827, -8464, -8102, -7743, -7385, -7029, -6674, -6318, -5965, -5612, -5259, -4905, -4551, -4197, -3842, -3487, -3128, -2769, -2410, -2046, -1682, -1316, -947, -577, -197};