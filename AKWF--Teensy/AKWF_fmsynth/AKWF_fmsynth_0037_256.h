/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0037 256 samples */
 
const int16_t AKWF_fmsynth_0037_256_DATA [256] = 
{1519, 3808, 5996, 8241, 10453, 12646, 14800, 16881, 18876, 20765, 22522, 24163, 25660, 27003, 28199, 29236, 30120, 30862, 31465, 31933, 32286, 32531, 32682, 32757, 32766, 32725, 32644, 32539, 32419, 32297, 32180, 32073, 31987, 31919, 31876, 31859, 31866, 31897, 31950, 32020, 32106, 32198, 32297, 32397, 32493, 32579, 32653, 32709, 32749, 32767, 32765, 32742, 32698, 32634, 32556, 32467, 32366, 32261, 32158, 32059, 31969, 31896, 31840, 31804, 31792, 31805, 31842, 31907, 31992, 32098, 32219, 32348, 32475, 32591, 32688, 32751, 32767, 32722, 32601, 32389, 32071, 31632, 31056, 30335, 29454, 28406, 27200, 25813, 24258, 22542, 20671, 18664, 16548, 14315, 12017, 9675, 7305, 4968, 2666, 429, -1735, -3866, -5937, -7909, -9799, -11573, -13221, -14731, -16120, -17375, -18500, -19499, -20368, -21120, -21765, -22303, -22743, -23085, -23337, -23506, -23592, -23603, -23539, -23403, -23201, -22931, -22596, -22201, -21747, -21242, -20684, -20080, -19437, -18757, -18051, -17329, -16590, -15846, -15112, -14390, -13694, -13034, -12414, -11845, -11338, -10901, -10540, -10263, -10076, -9983, -9993, -10105, -10327, -10660, -11106, -11661, -12330, -13103, -13982, -14963, -16038, -17184, -18404, -19683, -20997, -22337, -23676, -24988, -26272, -27493, -28630, -29665, -30572, -31339, -31958, -32406, -32678, -32771, -32678, -32407, -31960, -31344, -30576, -29670, -28638, -27500, -26271, -24981, -23644, -22284, -20912, -19552, -18217, -16928, -15697, -14536, -13453, -12458, -11558, -10758, -10065, -9476, -8997, -8625, -8360, -8202, -8146, -8188, -8325, -8553, -8863, -9250, -9708, -10229, -10805, -11426, -12085, -12773, -13485, -14206, -14929, -15647, -16352, -17036, -17695, -18316, -18896, -19429, -19915, -20342, -20711, -21019, -21260, -21434, -21534, -21561, -21509, -21377, -21159, -20853, -20454, -19957, -19357, -18658, -17841, -16910, -15864, -14692, -13400, -11996, -10456, -8804, -7040, -5161, -3227, -1106};