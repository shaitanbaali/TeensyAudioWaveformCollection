/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0099 256 samples */
 
const int16_t AKWF_fmsynth_0099_256_DATA [256] = 
{1305, 3593, 5440, 6916, 8078, 9003, 9776, 10495, 11255, 12125, 13161, 14398, 15824, 17419, 19119, 20840, 22502, 24022, 25342, 26427, 27260, 27843, 28196, 28344, 28314, 28144, 27872, 27555, 27255, 27041, 26976, 27120, 27496, 28094, 28889, 29798, 30722, 31564, 32222, 32631, 32771, 32642, 32295, 31796, 31215, 30602, 29995, 29404, 28812, 28182, 27456, 26571, 25449, 24019, 22204, 19959, 17240, 14073, 10522, 6721, 2856, -879, -4171, -6835, -8867, -10278, -11111, -11457, -11395, -11037, -10508, -9942, -9472, -9230, -9322, -9818, -10731, -12050, -13704, -15586, -17573, -19540, -21383, -23028, -24429, -25566, -26455, -27129, -27634, -28016, -28334, -28644, -28994, -29424, -29961, -30592, -31282, -31941, -32465, -32749, -32684, -32210, -31308, -30041, -28500, -26802, -25106, -23523, -22148, -21047, -20209, -19616, -19215, -18925, -18666, -18360, -17925, -17304, -16460, -15362, -14027, -12475, -10759, -8964, -7187, -5517, -4039, -2837, -1946, -1389, -1148, -1170, -1387, -1703, -2008, -2192, -2141, -1762, -991, 350, 2144, 4302, 6859, 9685, 12642, 15596, 18401, 20929, 23148, 24996, 26486, 27658, 28559, 29255, 29804, 30260, 30668, 31060, 31451, 31848, 32223, 32538, 32732, 32753, 32549, 32097, 31410, 30544, 29581, 28637, 27801, 27168, 26783, 26660, 26768, 27044, 27414, 27800, 28129, 28344, 28398, 28253, 27873, 27214, 26253, 24954, 23306, 21337, 19109, 16698, 14240, 11820, 9551, 7516, 5732, 4192, 2838, 1565, 262, -1180, -2869, -4870, -7242, -9973, -12992, -16173, -19362, -22389, -25112, -27414, -29234, -30573, -31488, -32069, -32406, -32583, -32667, -32702, -32714, -32713, -32705, -32696, -32697, -32711, -32736, -32763, -32765, -32712, -32573, -32324, -31959, -31494, -30968, -30430, -29930, -29507, -29191, -28985, -28873, -28820, -28779, -28699, -28527, -28204, -27677, -26875, -25743, -24218, -22269, -19900, -17132, -14046, -10777, -7461, -4256, -1266};