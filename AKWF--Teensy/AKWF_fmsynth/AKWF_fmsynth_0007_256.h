/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0007 256 samples */
 
const int16_t AKWF_fmsynth_0007_256_DATA [256] = 
{899, 1829, 2902, 4531, 6052, 7503, 9081, 10564, 12058, 13582, 15021, 16485, 17914, 19277, 20647, 21946, 23193, 24412, 25538, 26619, 27635, 28552, 29412, 30177, 30845, 31436, 31909, 32288, 32566, 32717, 32768, 32697, 32502, 32199, 31759, 31199, 30524, 29711, 28782, 27733, 26554, 25272, 23870, 22360, 20753, 19045, 17255, 15388, 13452, 11462, 9427, 7368, 5297, 3232, 1187, -887, -2992, -5089, -7185, -9251, -11263, -13228, -15113, -16906, -18613, -20200, -21670, -23019, -24223, -25291, -26214, -26976, -27592, -28045, -28339, -28477, -28451, -28271, -27935, -27444, -26812, -26032, -25115, -24073, -22899, -21613, -20222, -18723, -17139, -15473, -13729, -11925, -10067, -8162, -6227, -4265, -2283, -300, 1681, 3654, 5604, 7528, 9417, 11262, 13059, 14804, 16482, 18095, 19639, 21103, 22491, 23799, 25016, 26147, 27189, 28140, 29001, 29768, 30443, 31030, 31522, 31923, 32239, 32468, 32611, 32671, 32651, 32553, 32380, 32135, 31820, 31439, 30994, 30489, 29926, 29309, 28641, 27927, 27169, 26367, 25527, 24655, 23746, 22808, 21846, 20860, 19851, 18826, 17784, 16726, 15660, 14585, 13503, 12418, 11330, 10243, 9160, 8080, 7008, 5944, 4890, 3851, 2825, 1816, 815, -189, -1191, -2187, -3182, -4168, -5145, -6115, -7070, -8014, -8946, -9862, -10763, -11645, -12512, -13361, -14188, -14999, -15787, -16554, -17304, -18026, -18729, -19412, -20066, -20703, -21313, -21899, -22466, -23001, -23514, -24008, -24471, -24913, -25329, -25715, -26085, -26423, -26737, -27032, -27293, -27533, -27749, -27932, -28098, -28234, -28342, -28432, -28485, -28517, -28527, -28498, -28452, -28376, -28267, -28140, -27972, -27782, -27567, -27310, -27032, -26721, -26371, -26004, -25591, -25145, -24676, -24157, -23616, -23036, -22408, -21764, -21065, -20329, -19571, -18749, -17907, -17026, -16082, -15134, -14120, -13061, -12002, -10855, -9697, -8521, -7246, -6008, -4704, -3325, -2048, -562};