/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0060 256 samples */
 
const int16_t AKWF_fmsynth_0060_256_DATA [256] = 
{3418, 12147, 19584, 24836, 28307, 30294, 31274, 31609, 31475, 30808, 29349, 26717, 22558, 16732, 9346, 849, -7922, -16127, -22968, -27926, -31003, -32445, -32766, -32555, -32297, -32275, -32513, -32759, -32509, -31083, -27866, -22364, -14537, -4918, 5468, 15390, 23650, 29365, 32270, 32665, 31314, 29105, 26908, 25370, 24869, 25500, 27106, 29279, 31385, 32664, 32366, 30011, 25401, 18861, 11073, 2887, -4814, -11376, -16551, -20186, -22406, -23361, -23137, -21688, -18840, -14396, -8243, -508, 8208, 17111, 24930, 30431, 32730, 31557, 27305, 20961, 13814, 7085, 1605, -2197, -4287, -4599, -3137, -22, 4697, 10737, 17443, 23907, 29088, 32134, 32657, 30694, 26785, 21714, 16404, 11555, 7722, 5277, 4394, 5147, 7500, 11349, 16375, 21985, 27327, 31293, 32774, 30930, 25487, 17019, 6834, -3283, -12291, -19399, -24344, -27420, -29106, -29804, -29740, -28895, -27053, -23847, -18952, -12165, -3833, 5334, 14462, 22343, 28113, 31512, 32736, 32391, 31211, 29898, 28968, 28747, 29313, 30491, 31854, 32727, 32238, 29509, 23874, 15320, 4614, -6716, -17183, -25269, -30322, -32519, -32595, -31437, -29912, -28678, -28138, -28436, -29483, -30945, -32270, -32763, -31676, -28416, -22734, -14908, -5840, 3228, 11547, 18336, 23283, 26528, 28387, 29222, 29233, 28407, 26506, 23118, 17876, 10461, 1255, -8915, -18852, -26812, -31549, -32730, -30646, -26226, -20646, -14911, -9894, -6108, -3853, -3227, -4239, -6812, -10771, -15776, -21259, -26434, -30499, -32606, -32239, -29316, -24305, -18031, -11456, -5560, -956, 2052, 3363, 2915, 697, -3258, -8841, -15545, -22427, -28368, -32051, -32564, -29586, -23578, -15430, -6371, 2368, 9931, 15873, 20062, 22716, 24027, 24156, 23136, 20890, 17239, 12050, 5394, -2360, -10610, -18440, -25065, -29778, -32279, -32713, -31599, -29665, -27660, -26196, -25673, -26234, -27753, -29827, -31785, -32760, -31881, -28456, -22266, -13625, -3310};