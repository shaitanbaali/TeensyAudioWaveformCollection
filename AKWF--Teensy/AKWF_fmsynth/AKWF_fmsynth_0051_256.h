/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0051 256 samples */
 
const int16_t AKWF_fmsynth_0051_256_DATA [256] = 
{5776, 15500, 23033, 28240, 31237, 32523, 32763, 32569, 32390, 32428, 32642, 32766, 32376, 31006, 28247, 23942, 18155, 11284, 3953, -3162, -9494, -14661, -18520, -21064, -22379, -22535, -21524, -19207, -15392, -9899, -2774, 5602, 14494, 22788, 29152, 32471, 32107, 28219, 21584, 13582, 5635, -1151, -6503, -10315, -12508, -13107, -12182, -9760, -5860, -1023, 4399, 11266, 18188, 24321, 28940, 31763, 32759, 32311, 30984, 29393, 28061, 27370, 27523, 28498, 30055, 31709, 32720, 32197, 29251, 23351, 14466, 3785, -7252, -17631, -25684, -30627, -32651, -32401, -30828, -28826, -27107, -26097, -26024, -26873, -28436, -30316, -31954, -32760, -32140, -29708, -25390, -19587, -12910, -6203, -291, 4512, 8089, 10191, 10785, 9798, 7189, 2964, -2701, -9783, -17646, -24998, -30415, -32740, -31410, -26595, -19116, -10212, -1251, 6880, 13512, 18414, 21704, 23580, 24257, 23864, 22373, 19688, 15676, 10378, 3911, -3342, -10750, -17662, -23496, -27835, -30672, -32165, -32707, -32754, -32673, -32682, -32760, -32649, -31867, -29785, -25837, -19630, -11207, -1182, 9342, 19028, 26614, 31280, 32773, 31514, 28375, 24433, 20602, 17625, 15913, 15655, 16824, 19250, 22578, 26269, 29648, 31999, 32770, 31685, 28829, 24597, 19637, 14608, 10096, 6580, 4368, 3629, 4438, 6800, 10630, 15641, 21292, 26757, 30960, 32769, 31228, 25996, 17552, 7339, -2908, -12269, -19940, -25363, -28756, -30635, -31537, -31842, -31737, -31172, -29920, -27612, -23911, -18611, -11825, -4173, 3605, 11247, 17964, 23233, 26943, 29262, 30553, 31115, 31132, 30592, 29269, 26757, 22521, 16185, 7796, -1816, -12124, -21725, -28830, -32393, -32292, -29137, -23986, -18009, -12207, -7326, -3796, -1767, -1323, -2430, -4999, -8835, -13634, -18961, -24152, -28552, -31548, -32754, -32136, -29996, -26902, -23542, -20582, -18552, -17740, -18325, -20256, -23291, -26881, -30265, -32452, -32435, -29503, -23474, -14872, -4427};