/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0066 256 samples */
 
const int16_t AKWF_fmsynth_0066_256_DATA [256] = 
{1815, 6859, 11261, 15262, 18812, 21921, 24602, 26855, 28704, 30188, 31306, 32093, 32570, 32764, 32704, 32415, 31923, 31254, 30433, 29491, 28435, 27298, 26098, 24846, 23573, 22281, 20982, 19689, 18413, 17160, 15945, 14754, 13604, 12493, 11430, 10403, 9417, 8475, 7569, 6707, 5882, 5088, 4331, 3603, 2905, 2243, 1604, 990, 404, -155, -689, -1196, -1681, -2139, -2568, -2975, -3348, -3694, -4011, -4295, -4549, -4770, -4954, -5106, -5222, -5300, -5341, -5345, -5310, -5237, -5125, -4975, -4786, -4560, -4293, -3989, -3647, -3268, -2854, -2401, -1913, -1386, -823, -224, 411, 1090, 1810, 2576, 3385, 4246, 5168, 6148, 7193, 8312, 9499, 10776, 12142, 13597, 15145, 16778, 18493, 20288, 22141, 24015, 25884, 27682, 29359, 30825, 31968, 32650, 32710, 31943, 30112, 26918, 22026, 15081, 5475, -6155, -15855, -22954, -27905, -30977, -32488, -32724, -31927, -30341, -28179, -25644, -22860, -19976, -17090, -14267, -11574, -9027, -6598, -4299, -2080, 88, 2277, 4534, 6909, 9432, 12125, 14997, 18021, 21138, 24240, 27173, 29734, 31691, 32705, 32396, 30306, 25942, 18729, 7740, -6284, -17693, -25200, -29821, -32176, -32765, -32042, -30384, -28111, -25465, -22613, -19724, -16883, -14153, -11602, -9200, -6953, -4851, -2855, -937, 923, 2792, 4682, 6613, 8615, 10674, 12806, 15011, 17256, 19511, 21750, 23909, 25968, 27862, 29530, 30906, 31949, 32587, 32765, 32437, 31552, 30074, 27954, 25186, 21741, 17604, 12838, 7393, 1255, -4877, -10078, -14408, -17985, -20974, -23427, -25427, -27058, -28367, -29415, -30250, -30902, -31408, -31795, -32084, -32299, -32454, -32564, -32638, -32686, -32718, -32739, -32747, -32753, -32754, -32749, -32743, -32728, -32702, -32662, -32602, -32517, -32397, -32232, -32011, -31723, -31354, -30882, -30296, -29567, -28682, -27608, -26311, -24765, -22935, -20775, -18264, -15324, -11920, -8006, -3396};