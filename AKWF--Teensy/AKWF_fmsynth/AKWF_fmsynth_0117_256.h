/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0117 256 samples */
 
const int16_t AKWF_fmsynth_0117_256_DATA [256] = 
{2195, 6231, 9994, 13493, 16648, 19425, 21803, 23772, 25366, 26610, 27541, 28201, 28622, 28829, 28839, 28660, 28289, 27715, 26929, 25917, 24666, 23183, 21478, 19569, 17493, 15304, 13046, 10791, 8601, 6534, 4659, 3022, 1666, 631, -52, -364, -289, 184, 1061, 2336, 4003, 6035, 8387, 11019, 13858, 16804, 19773, 22652, 25319, 27685, 29648, 31141, 32128, 32600, 32582, 32128, 31319, 30252, 29027, 27754, 26526, 25425, 24523, 23869, 23491, 23405, 23606, 24075, 24776, 25663, 26681, 27762, 28848, 29869, 30769, 31503, 32041, 32366, 32486, 32420, 32199, 31869, 31485, 31095, 30746, 30484, 30341, 30333, 30465, 30724, 31085, 31497, 31898, 32216, 32359, 32240, 31770, 30872, 29483, 27571, 25139, 22221, 18887, 15260, 11456, 7622, 3915, 457, -2716, -5618, -8193, -10378, -12152, -13516, -14471, -15030, -15207, -15014, -14461, -13555, -12314, -10757, -8906, -6808, -4512, -2082, 404, 2947, 5514, 8011, 10369, 12533, 14446, 16084, 17425, 18450, 19161, 19550, 19612, 19341, 18722, 17739, 16366, 14585, 12395, 9789, 6803, 3501, -28, -3762, -7697, -11705, -15614, -19281, -22597, -25460, -27822, -29675, -31033, -31946, -32487, -32730, -32762, -32665, -32508, -32346, -32224, -32168, -32186, -32272, -32403, -32547, -32663, -32703, -32624, -32384, -31950, -31301, -30436, -29373, -28135, -26774, -25348, -23922, -22567, -21355, -20340, -19578, -19111, -18970, -19168, -19709, -20576, -21736, -23142, -24724, -26392, -28051, -29589, -30894, -31863, -32408, -32464, -31996, -31001, -29517, -27599, -25336, -22836, -20199, -17539, -14967, -12560, -10399, -8546, -7039, -5908, -5167, -4822, -4866, -5290, -6073, -7186, -8590, -10245, -12095, -14080, -16143, -18209, -20223, -22131, -23876, -25428, -26767, -27883, -28780, -29474, -29984, -30331, -30532, -30603, -30543, -30348, -29993, -29448, -28668, -27609, -26217, -24456, -22298, -19716, -16731, -13381, -9716, -5832, -1734};