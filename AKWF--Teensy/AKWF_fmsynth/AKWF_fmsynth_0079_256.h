/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0079 256 samples */
 
const int16_t AKWF_fmsynth_0079_256_DATA [256] = 
{194, 1041, 1972, 2945, 3972, 5050, 6183, 7353, 8560, 9811, 11090, 12395, 13722, 15046, 16387, 17728, 19051, 20354, 21631, 22863, 24063, 25204, 26284, 27302, 28239, 29099, 29876, 30564, 31162, 31667, 32072, 32385, 32606, 32735, 32770, 32721, 32591, 32382, 32099, 31751, 31342, 30877, 30363, 29803, 29204, 28573, 27916, 27237, 26536, 25822, 25096, 24367, 23626, 22882, 22137, 21388, 20643, 19897, 19148, 18396, 17644, 16888, 16134, 15368, 14594, 13815, 13024, 12224, 11410, 10580, 9735, 8876, 7997, 7105, 6177, 5215, 4217, 3185, 2121, 1026, -99, -1256, -2439, -3639, -4854, -6087, -7324, -8564, -9798, -11013, -12208, -13382, -14513, -15607, -16650, -17625, -18541, -19386, -20153, -20838, -21433, -21936, -22352, -22674, -22901, -23034, -23079, -23038, -22913, -22709, -22431, -22089, -21689, -21235, -20734, -20201, -19642, -19058, -18460, -17859, -17258, -16669, -16093, -15533, -15002, -14500, -14033, -13602, -13210, -12864, -12561, -12302, -12089, -11926, -11809, -11737, -11709, -11726, -11786, -11889, -12028, -12203, -12415, -12658, -12928, -13223, -13544, -13885, -14240, -14605, -14985, -15374, -15765, -16154, -16542, -16928, -17304, -17670, -18023, -18359, -18680, -18982, -19260, -19516, -19749, -19955, -20135, -20282, -20402, -20494, -20551, -20578, -20574, -20537, -20467, -20364, -20227, -20057, -19858, -19626, -19361, -19069, -18748, -18399, -18020, -17621, -17196, -16753, -16289, -15807, -15313, -14808, -14294, -13775, -13249, -12722, -12199, -11681, -11171, -10668, -10179, -9703, -9245, -8806, -8388, -7993, -7619, -7271, -6951, -6657, -6391, -6153, -5943, -5760, -5607, -5481, -5383, -5310, -5262, -5241, -5240, -5260, -5298, -5356, -5428, -5511, -5606, -5710, -5819, -5930, -6038, -6143, -6244, -6334, -6408, -6471, -6512, -6535, -6529, -6496, -6433, -6338, -6208, -6038, -5826, -5570, -5272, -4926, -4528, -4080, -3579, -3026, -2418, -1756, -1024, -259};