/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0014 256 samples */
 
const int16_t AKWF_fmsynth_0014_256_DATA [256] = 
{4966, 15264, 23193, 28571, 31549, 32684, 32687, 32205, 31718, 31486, 31571, 31895, 32304, 32628, 32757, 32665, 32420, 32153, 32013, 32100, 32390, 32679, 32541, 31294, 28120, 22259, 13352, 2256, -9762, -21141, -29199, -32393, -30587, -24783, -16582, -7637, 710, 7703, 13042, 16747, 19042, 20163, 20314, 19660, 18340, 16517, 14382, 12186, 10214, 8745, 8046, 8333, 9769, 12415, 16188, 20821, 25717, 29969, 32412, 31825, 27341, 18871, 7622, -4270, -15481, -24329, -29843, -32240, -32314, -31059, -29353, -27844, -26905, -26677, -27122, -28070, -29278, -30480, -31468, -32114, -32412, -32457, -32400, -32372, -32416, -32409, -32027, -30735, -27896, -22922, -15475, -5801, 5229, 16190, 25318, 31096, 32667, 30074, 24247, 16652, 8845, 2021, -3355, -7331, -9886, -11124, -11220, -10362, -8758, -6653, -4319, -2067, -204, 1029, 1400, 693, -1265, -4638, -9463, -15503, -22041, -27914, -31691, -32011, -28098, -20054, -8999, 3282, 14827, 23977, 29872, 32488, 32446, 30733, 28347, 26095, 24478, 23727, 23855, 24712, 26056, 27597, 29080, 30310, 31196, 31742, 32000, 32016, 31761, 31068, 29595, 26832, 22227, 15372, 6380, -3854, -14612, -24116, -30386, -32464, -30417, -25149, -17990, -10281, -3111, 2880, 7414, 10447, 12108, 12546, 11913, 10370, 8089, 5307, 2282, -674, -3249, -5180, -6224, -6184, -4890, -2196, 1973, 7580, 14284, 21368, 27711, 31830, 32274, 28081, 19349, 7609, -4667, -15960, -24650, -29949, -32215, -32344, -31303, -29898, -28682, -27950, -27793, -28140, -28839, -29691, -30517, -31186, -31643, -31892, -31957, -31830, -31404, -30429, -28508, -25118, -19792, -12285, -2767, 7922, 18391, 26931, 31899, 32316, 28181, 20550, 11168, 1984, -5903, -12316, -16957, -19933, -21537, -22021, -21559, -20255, -18205, -15555, -12511, -9377, -6501, -4200, -2756, -2391, -3275, -5546, -9253, -14271, -20107, -25875, -30374, -32314, -30738, -25356, -16707, -5781};