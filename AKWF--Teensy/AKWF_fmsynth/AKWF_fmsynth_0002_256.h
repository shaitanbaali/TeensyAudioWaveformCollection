/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0002 256 samples */
 
const int16_t AKWF_fmsynth_0002_256_DATA [256] = 
{1814, 6686, 10662, 13943, 16546, 18530, 19969, 20920, 21443, 21561, 21281, 20588, 19444, 17793, 15553, 12664, 9075, 4744, -292, -5920, -11972, -18102, -23856, -28676, -31860, -32690, -30511, -24928, -16029, -4890, 7041, 18376, 26512, 29409, 26170, 17090, 3754, -11187, -24300, -31934, -31205, -21108, -4480, 13345, 26387, 28994, 20238, 3284, -15758, -29642, -32057, -20574, -57, 19915, 29400, 23384, 5284, -16270, -30889, -30346, -13648, 9856, 26958, 27410, 11588, -11414, -29224, -31402, -15419, 8926, 26905, 27224, 10607, -12859, -30057, -30683, -13362, 10966, 27663, 26535, 9442, -13537, -30090, -30916, -14827, 8484, 26140, 28275, 14972, -6161, -25015, -32794, -25396, -6546, 14254, 27692, 27848, 16037, -2202, -19951, -31009, -31630, -21538, -4966, 12213, 24993, 29457, 25418, 14933, 1121, -12850, -24227, -31081, -32558, -28765, -20741, -10232, 596, 10722, 19236, 25200, 28509, 29432, 28413, 25976, 22618, 18783, 14828, 11012, 7544, 4535, 2065, 181, -1102, -1780, -1845, -1302, -145, 1610, 3962, 6871, 10260, 14034, 17996, 21888, 25378, 28027, 29331, 28760, 25826, 20229, 11983, 1894, -8965, -19718, -28199, -32493, -31462, -24881, -13590, 519, 14589, 25293, 29389, 24692, 11471, -6121, -22744, -32146, -30250, -17786, 874, 18884, 28891, 25550, 9082, -12726, -29419, -31798, -18864, 2738, 22335, 29397, 18544, -4440, -26020, -32606, -20399, 2755, 23465, 28959, 14314, -11028, -30236, -30107, -11581, 13101, 28569, 23889, 1456, -23203, -32865, -21417, 2512, 23799, 28728, 13049, -12568, -30800, -29610, -11055, 12885, 28216, 25284, 5464, -18560, -32269, -27806, -9237, 12996, 27626, 27024, 11130, -11011, -28358, -32415, -22479, -4087, 14924, 27295, 28372, 17664, 4, -17832, -29956, -32478, -25853, -12992, 2298, 16236, 25845, 29395, 26483, 18079, 6339, -5909, -17210, -25987, -31166, -32738, -31209, -27313, -21843, -15534, -8925, -2781};