/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0093 256 samples */
 
const int16_t AKWF_fmsynth_0093_256_DATA [256] = 
{433, 768, 1534, 3269, 5652, 8067, 10206, 12155, 14021, 15824, 17538, 19151, 20661, 22059, 23347, 24525, 25597, 26563, 27425, 28186, 28852, 29434, 29934, 30360, 30717, 31011, 31251, 31445, 31596, 31711, 31792, 31843, 31865, 31861, 31831, 31774, 31688, 31573, 31425, 31241, 31017, 30749, 30437, 30075, 29660, 29190, 28664, 28082, 27446, 26747, 25991, 25181, 24323, 23412, 22455, 21454, 20417, 19354, 18265, 17153, 16028, 14891, 13754, 12631, 11509, 10407, 9327, 8271, 7253, 6279, 5341, 4456, 3622, 2843, 2132, 1480, 895, 384, -55, -416, -697, -900, -1018, -1053, -1003, -867, -642, -327, 77, 570, 1157, 1827, 2591, 3445, 4384, 5408, 6511, 7691, 8951, 10285, 11678, 13131, 14627, 16169, 17742, 19338, 20923, 22507, 24069, 25577, 27020, 28369, 29589, 30671, 31568, 32247, 32667, 32780, 32589, 31995, 30970, 29470, 27435, 24865, 21725, 17816, 12960, 7267, 1268, -4547, -10034, -14972, -19128, -22444, -25075, -27245, -28982, -30319, -31311, -32013, -32468, -32718, -32775, -32739, -32579, -32333, -32025, -31677, -31303, -30921, -30543, -30180, -29838, -29528, -29253, -29020, -28834, -28696, -28608, -28569, -28580, -28639, -28745, -28900, -29094, -29326, -29591, -29884, -30197, -30526, -30863, -31199, -31527, -31837, -32121, -32369, -32567, -32714, -32769, -32770, -32703, -32514, -32225, -31820, -31294, -30642, -29857, -28935, -27887, -26696, -25376, -23929, -22363, -20698, -18948, -17108, -15219, -13294, -11354, -9446, -7567, -5751, -4036, -2442, -1009, 228, 1270, 2076, 2631, 2939, 3014, 2862, 2460, 1786, 847, -349, -1786, -3436, -5279, -7271, -9361, -11551, -13784, -16031, -18260, -20421, -22482, -24436, -26228, -27843, -29260, -30447, -31405, -32117, -32581, -32772, -32732, -32450, -31914, -31147, -30167, -28977, -27606, -26064, -24362, -22524, -20573, -18514, -16384, -14177, -11947, -9686, -7301, -4713, -2201, -369};