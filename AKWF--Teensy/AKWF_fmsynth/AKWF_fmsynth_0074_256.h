/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0074 256 samples */
 
const int16_t AKWF_fmsynth_0074_256_DATA [256] = 
{2449, 9790, 16549, 22503, 27198, 30488, 32299, 32772, 32202, 30899, 29227, 27497, 25957, 24792, 24092, 23879, 24133, 24772, 25689, 26737, 27794, 28721, 29418, 29821, 29908, 29705, 29263, 28666, 28000, 27346, 26771, 26300, 25927, 25599, 25221, 24646, 23708, 22198, 19931, 16769, 12619, 7550, 1701, -4683, -10976, -16555, -21250, -24952, -27736, -29705, -31012, -31816, -32263, -32453, -32436, -32197, -31678, -30772, -29329, -27219, -24321, -20550, -15985, -10699, -4920, 793, 5972, 10445, 14094, 16995, 19196, 20813, 21975, 22762, 23217, 23320, 22965, 21996, 20195, 17357, 13280, 7878, 1348, -5401, -11482, -16298, -19403, -20550, -19764, -17293, -13564, -9023, -4173, 589, 4935, 8656, 11658, 13918, 15438, 16264, 16439, 16015, 15026, 13529, 11572, 9222, 6589, 3772, 863, -1987, -4687, -7124, -9253, -11016, -12379, -13316, -13813, -13839, -13362, -12332, -10721, -8507, -5719, -2400, 1299, 5207, 9075, 12639, 15669, 17981, 19442, 20045, 19867, 19080, 17893, 16555, 15290, 14294, 13707, 13604, 13991, 14815, 15955, 17242, 18456, 19392, 19842, 19651, 18736, 17110, 14881, 12190, 9278, 6375, 3686, 1422, -296, -1376, -1741, -1358, -203, 1734, 4437, 7851, 11847, 16194, 20639, 24738, 28032, 30035, 30333, 28663, 24971, 19492, 12665, 5172, -1753, -7446, -11768, -14794, -16757, -17916, -18533, -18846, -19012, -19141, -19279, -19420, -19522, -19520, -19340, -18920, -18221, -17251, -16035, -14664, -13259, -11948, -10879, -10180, -9955, -10286, -11209, -12728, -14776, -17269, -20041, -22880, -25528, -27727, -29238, -29880, -29541, -28226, -26046, -23160, -19829, -16324, -12873, -9724, -7007, -4820, -3241, -2290, -1976, -2292, -3236, -4794, -6926, -9577, -12623, -15921, -19293, -22503, -25317, -27557, -29076, -29840, -29881, -29317, -28333, -27141, -25952, -24940, -24233, -23891, -23884, -24097, -24338, -24336, -23779, -22349, -19803, -15987, -10891, -4599};