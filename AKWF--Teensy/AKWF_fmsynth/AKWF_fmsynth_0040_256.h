/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0040 256 samples */
 
const int16_t AKWF_fmsynth_0040_256_DATA [256] = 
{4468, 10137, 11988, 9507, 3538, -3853, -10711, -15870, -18058, -16043, -9917, -1595, 6685, 13623, 18434, 20034, 17530, 11551, 3968, -3059, -7857, -8939, -5571, 1155, 8819, 15593, 21041, 24931, 26351, 24134, 18547, 11392, 4926, 1109, 1334, 5588, 11878, 17785, 22299, 25919, 28927, 30337, 28746, 24100, 17991, 12694, 10260, 11696, 16061, 20823, 24120, 25991, 27735, 29964, 31647, 31073, 27829, 23292, 19669, 18809, 20999, 24532, 26872, 27046, 26216, 26242, 27932, 30166, 30954, 29514, 26988, 25301, 25846, 28135, 29901, 29198, 26241, 23022, 21684, 23120, 26132, 28490, 29128, 28798, 29061, 30584, 32132, 31415, 27565, 21968, 16996, 14766, 16147, 20031, 24044, 26794, 28640, 30529, 32346, 32352, 28869, 22334, 14859, 8867, 6193, 7718, 12435, 17987, 22686, 26371, 29339, 30674, 28623, 22618, 14259, 5935, -1272, -3297, -171, 5886, 12628, 18577, 23200, 25739, 24713, 19348, 10940, 1879, -5929, -11118, -12383, -9189, -2625, 5027, 11919, 16855, 18573, 15832, 9016, 298, -8014, -14752, -19316, -20434, -17283, -10684, -2840, 4178, 8672, 9100, 4947, -2317, -9992, -16562, -21792, -25515, -26576, -23842, -17792, -10416, -4040, -686, -1659, -6535, -12996, -18618, -22805, -26218, -29117, -30347, -28416, -23408, -17198, -12194, -10312, -12424, -17111, -21644, -24433, -25965, -27612, -29852, -31490, -30733, -27299, -22766, -19477, -19206, -21883, -25302, -27082, -26788, -25813, -25928, -27750, -30008, -30735, -29242, -26832, -25567, -26582, -28921, -30180, -28846, -25598, -22485, -21446, -23098, -26171, -28519, -29180, -29053, -29667, -31344, -32500, -31080, -26729, -21104, -16426, -14651, -16383, -20353, -24331, -27092, -29106, -31137, -32694, -32055, -27961, -21179, -13881, -8331, -6239, -8209, -13030, -18506, -23155, -26857, -29626, -30415, -27684, -21280, -12927, -4928, 842, 2933, 676, -4873, -11532, -17560, -22352, -25163, -24646, -19953, -12078, -3147};