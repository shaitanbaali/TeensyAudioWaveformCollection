/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0092 256 samples */
 
const int16_t AKWF_fmsynth_0092_256_DATA [256] = 
{5440, 13109, 17331, 21385, 24749, 27375, 29429, 30930, 31951, 32546, 32768, 32661, 32268, 31633, 30789, 29769, 28611, 27320, 25934, 24475, 22955, 21405, 19828, 18232, 16637, 15053, 13487, 11960, 10459, 8997, 7585, 6221, 4918, 3676, 2494, 1374, 328, -648, -1549, -2379, -3136, -3820, -4420, -4945, -5392, -5758, -6045, -6251, -6375, -6419, -6381, -6259, -6049, -5759, -5385, -4921, -4372, -3736, -3010, -2201, -1298, -307, 770, 1939, 3188, 4519, 5937, 7439, 9011, 10652, 12350, 14107, 15911, 17752, 19606, 21459, 23291, 25079, 26791, 28391, 29829, 31050, 32004, 32603, 32760, 32370, 31315, 29440, 26567, 22537, 17055, 9802, 853, -8761, -16712, -22668, -27146, -30213, -32040, -32749, -32484, -31371, -29544, -27101, -24145, -20761, -17047, -13075, -8896, -4567, -146, 4313, 8747, 13079, 17280, 21230, 24842, 27978, 30470, 32140, 32769, 32075, 29735, 25435, 18602, 8827, -3476, -15095, -23018, -28238, -31335, -32664, -32533, -31241, -29023, -26122, -22663, -18799, -14660, -10319, -5867, -1403, 3087, 7499, 11779, 15860, 19716, 23239, 26364, 28991, 31008, 32308, 32769, 32243, 30585, 27623, 23275, 17268, 9243, -194, -9712, -17311, -22777, -26892, -29737, -31550, -32511, -32768, -32460, -31693, -30568, -29159, -27531, -25756, -23852, -21875, -19856, -17811, -15782, -13774, -11795, -9864, -7997, -6191, -4472, -2822, -1251, 232, 1628, 2930, 4139, 5262, 6298, 7239, 8085, 8850, 9524, 10111, 10613, 11027, 11358, 11608, 11776, 11863, 11867, 11792, 11639, 11408, 11100, 10713, 10248, 9707, 9087, 8390, 7618, 6767, 5848, 4851, 3779, 2638, 1426, 151, -1190, -2595, -4059, -5577, -7145, -8751, -10400, -12082, -13792, -15513, -17236, -18955, -20659, -22334, -23960, -25521, -26993, -28364, -29600, -30683, -31575, -32242, -32652, -32767, -32535, -31911, -30850, -29287, -27164, -24429, -20966, -16753, -12386, -5100};