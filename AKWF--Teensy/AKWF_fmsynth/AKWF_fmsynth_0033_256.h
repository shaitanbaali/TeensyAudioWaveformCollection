/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0033 256 samples */
 
const int16_t AKWF_fmsynth_0033_256_DATA [256] = 
{2308, 7670, 12148, 15842, 18802, 21059, 22690, 23759, 24330, 24440, 24102, 23290, 21968, 20079, 17571, 14362, 10449, 5810, 572, -5157, -11184, -17165, -22715, -27441, -30860, -32616, -32363, -29917, -25279, -18759, -10611, -2049, 2422, 10275, 18256, 24417, 28949, 31679, 32740, 32363, 30865, 28569, 25788, 22811, 19878, 17188, 14891, 13065, 11801, 11138, 11098, 11683, 12886, 14672, 16974, 19703, 22708, 25761, 28644, 31008, 32480, 32659, 31174, 27729, 22139, 14549, 5448, -4366, -14033, -22552, -28857, -32252, -32486, -29631, -24096, -16496, -7629, 1656, 10547, 18463, 24831, 29383, 32001, 32770, 31927, 29802, 26777, 23225, 19505, 15947, 12729, 10033, 7967, 6580, 5903, 5938, 6682, 8115, 10204, 12896, 16044, 19532, 23139, 26572, 29533, 31690, 32717, 32367, 30434, 26864, 21694, 15192, 7660, -482, -8663, -16318, -22958, -28074, -31408, -32745, -32078, -29588, -25530, -20331, -14450, -8337, -2463, 2884, 7683, 11762, 15077, 17655, 19524, 20771, 21439, 21553, 21118, 20108, 18481, 16146, 13041, 9132, 4401, -991, -6984, -13379, -19658, -25259, -29633, -32222, -32653, -30655, -26218, -19568, -11198, -1764, 7941, 17030, 24609, 29959, 32558, 32183, 28868, 22997, 15243, 6516, -2251, -10488, -17685, -23436, -27649, -30437, -32041, -32702, -32702, -32298, -31707, -31103, -30619, -30345, -30320, -30547, -30988, -31566, -32168, -32628, -32758, -32335, -31122, -28880, -25426, -20637, -14559, -7343, 540, 8703, 16587, 23426, 28641, 31830, 32761, 31443, 28073, 23026, 16687, 9607, 2244, -4940, -11544, -17331, -22180, -25980, -28797, -30724, -31902, -32522, -32750, -32746, -32649, -32557, -32528, -32580, -32682, -32763, -32709, -32362, -31541, -30043, -27677, -24293, -19771, -14095, -7370, 159, 8081, 15842, 22888, 28463, 31923, 32685, 30427, 25102, 17045, 7153, -3399, -13574, -22187, -28469, -31974, -32706, -30969, -27245, -22113, -16091, -9742, -3365};