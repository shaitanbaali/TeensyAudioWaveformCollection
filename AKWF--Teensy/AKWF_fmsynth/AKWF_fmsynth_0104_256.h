/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0104 256 samples */
 
const int16_t AKWF_fmsynth_0104_256_DATA [256] = 
{624, 2132, 3584, 5040, 6487, 7943, 9399, 10839, 12265, 13656, 15006, 16311, 17555, 18723, 19817, 20823, 21747, 22588, 23343, 24016, 24607, 25126, 25580, 25972, 26308, 26595, 26841, 27053, 27236, 27396, 27540, 27673, 27799, 27929, 28060, 28201, 28355, 28525, 28714, 28924, 29156, 29410, 29685, 29982, 30293, 30616, 30946, 31273, 31595, 31898, 32171, 32409, 32593, 32718, 32769, 32737, 32618, 32401, 32086, 31671, 31166, 30572, 29910, 29201, 28458, 27712, 26990, 26320, 25735, 25261, 24918, 24730, 24706, 24854, 25169, 25642, 26256, 26979, 27786, 28640, 29492, 30318, 31070, 31717, 32228, 32578, 32752, 32738, 32537, 32151, 31595, 30876, 30020, 29046, 27980, 26851, 25676, 24477, 23276, 22086, 20929, 19821, 18759, 17760, 16823, 15953, 15158, 14436, 13782, 13199, 12684, 12233, 11850, 11525, 11257, 11042, 10878, 10758, 10680, 10641, 10633, 10653, 10698, 10759, 10835, 10917, 11004, 11087, 11163, 11228, 11275, 11301, 11301, 11271, 11211, 11112, 10978, 10805, 10594, 10341, 10049, 9718, 9351, 8950, 8521, 8060, 7577, 7074, 6553, 6020, 5487, 4944, 4405, 3872, 3348, 2842, 2353, 1885, 1445, 1035, 659, 326, 34, -211, -407, -548, -630, -654, -614, -509, -339, -101, 200, 573, 1014, 1524, 2101, 2746, 3459, 4244, 5100, 6029, 7032, 8110, 9269, 10504, 11822, 13205, 14661, 16185, 17755, 19359, 20982, 22587, 24176, 25708, 27153, 28488, 29680, 30705, 31548, 32181, 32589, 32763, 32697, 32386, 31833, 31041, 30019, 28776, 27321, 25659, 23793, 21731, 19473, 17024, 14345, 11440, 8266, 4804, 1003, -2973, -6752, -10280, -13596, -16687, -19534, -22168, -24547, -26662, -28494, -30015, -31212, -32083, -32600, -32771, -32589, -32075, -31236, -30105, -28714, -27100, -25307, -23373, -21341, -19259, -17168, -15104, -13077, -11122, -9237, -7438, -5727, -4090, -2513, -954};