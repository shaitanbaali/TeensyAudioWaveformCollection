/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0029 256 samples */
 
const int16_t AKWF_fmsynth_0029_256_DATA [256] = 
{631, 2142, 3653, 5191, 6737, 8280, 9802, 11278, 12691, 14022, 15241, 16340, 17296, 18097, 18733, 19195, 19481, 19592, 19532, 19313, 18944, 18442, 17827, 17120, 16344, 15526, 14686, 13853, 13052, 12301, 11628, 11047, 10574, 10225, 10006, 9925, 9980, 10171, 10494, 10936, 11486, 12129, 12845, 13616, 14419, 15230, 16027, 16788, 17489, 18111, 18635, 19041, 19319, 19454, 19440, 19271, 18945, 18468, 17838, 17067, 16166, 15144, 14021, 12809, 11523, 10187, 8812, 7414, 6014, 4618, 3238, 1886, 563, -728, -1986, -3219, -4433, -5633, -6838, -8056, -9300, -10590, -11937, -13347, -14838, -16408, -18055, -19778, -21559, -23369, -25186, -26957, -28625, -30130, -31382, -32289, -32745, -32627, -31799, -30112, -27414, -23528, -18286, -11450, -3294, 3810, 9165, 13181, 16039, 17921, 19012, 19457, 19385, 18910, 18127, 17119, 15947, 14673, 13340, 11981, 10627, 9300, 8009, 6771, 5592, 4474, 3421, 2432, 1503, 637, -172, -928, -1632, -2287, -2898, -3464, -3988, -4475, -4921, -5330, -5702, -6037, -6337, -6599, -6824, -7015, -7168, -7284, -7362, -7404, -7408, -7372, -7300, -7190, -7041, -6854, -6629, -6365, -6063, -5723, -5343, -4922, -4461, -3956, -3408, -2814, -2169, -1474, -720, 93, 969, 1917, 2937, 4029, 5202, 6453, 7774, 9166, 10613, 12092, 13582, 15043, 16419, 17649, 18644, 19294, 19463, 18987, 17665, 15244, 11451, 5965, -1758, -11270, -19268, -25069, -29051, -31475, -32595, -32647, -31860, -30437, -28567, -26398, -24067, -21683, -19318, -17032, -14863, -12807, -10865, -9015, -7213, -5419, -3593, -1680, 350, 2519, 4842, 7292, 9822, 12361, 14777, 16913, 18560, 19451, 19274, 17654, 14176, 8386, -461, -11736, -20791, -26756, -30403, -32229, -32662, -32066, -30746, -28944, -26857, -24625, -22362, -20150, -18027, -16027, -14162, -12420, -10793, -9263, -7799, -6409, -5030, -3643, -2252, -805};