/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0070 256 samples */
 
const int16_t AKWF_fmsynth_0070_256_DATA [256] = 
{361, 1198, 1985, 2806, 3637, 4492, 5366, 6253, 7153, 8067, 8994, 9934, 10884, 11840, 12797, 13765, 14729, 15699, 16666, 17624, 18574, 19520, 20450, 21367, 22270, 23146, 24004, 24837, 25642, 26418, 27159, 27861, 28532, 29159, 29745, 30286, 30773, 31215, 31608, 31943, 32225, 32450, 32615, 32722, 32768, 32753, 32676, 32536, 32333, 32066, 31735, 31345, 30890, 30376, 29799, 29162, 28467, 27720, 26911, 26051, 25139, 24174, 23167, 22119, 21019, 19885, 18714, 17505, 16277, 15015, 13726, 12422, 11101, 9765, 8430, 7079, 5729, 4385, 3044, 1720, 415, -885, -2191, -3500, -4810, -6107, -7403, -8690, -9962, -11214, -12443, -13648, -14830, -15987, -17112, -18204, -19258, -20282, -21267, -22218, -23127, -23994, -24821, -25609, -26354, -27058, -27720, -28333, -28910, -29444, -29935, -30383, -30789, -31157, -31483, -31771, -32020, -32229, -32405, -32545, -32648, -32721, -32760, -32768, -32749, -32701, -32626, -32524, -32403, -32259, -32093, -31907, -31704, -31486, -31252, -31007, -30748, -30478, -30202, -29918, -29625, -29329, -29028, -28724, -28422, -28117, -27812, -27509, -27207, -26910, -26619, -26330, -26047, -25771, -25499, -25237, -24983, -24734, -24496, -24267, -24043, -23831, -23628, -23433, -23247, -23071, -22905, -22748, -22598, -22457, -22326, -22202, -22085, -21978, -21877, -21783, -21696, -21614, -21537, -21468, -21402, -21340, -21285, -21233, -21181, -21132, -21087, -21043, -20999, -20956, -20914, -20871, -20825, -20779, -20732, -20682, -20630, -20574, -20513, -20450, -20381, -20307, -20228, -20143, -20050, -19952, -19848, -19734, -19612, -19481, -19344, -19197, -19041, -18873, -18699, -18512, -18313, -18107, -17888, -17655, -17414, -17159, -16894, -16613, -16318, -16014, -15697, -15365, -15020, -14660, -14288, -13903, -13503, -13087, -12657, -12214, -11758, -11287, -10800, -10299, -9784, -9254, -8714, -8158, -7585, -6999, -6400, -5788, -5163, -4524, -3872, -3207, -2528, -1844, -1143, -423};