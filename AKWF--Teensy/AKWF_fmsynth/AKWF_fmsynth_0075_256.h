/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0075 256 samples */
 
const int16_t AKWF_fmsynth_0075_256_DATA [256] = 
{984, 3195, 5820, 8849, 12167, 15698, 19289, 22740, 25871, 28488, 30401, 31516, 31744, 31095, 29635, 27518, 24909, 22003, 19011, 16124, 13481, 11212, 9360, 7972, 7059, 6605, 6572, 6916, 7578, 8492, 9578, 10758, 11943, 13066, 14058, 14857, 15417, 15702, 15683, 15338, 14639, 13558, 12067, 10137, 7714, 4793, 1347, -2597, -6845, -11196, -15500, -19544, -23190, -26285, -28784, -30642, -31878, -32555, -32772, -32651, -32306, -31852, -31388, -30991, -30716, -30587, -30612, -30772, -31031, -31337, -31630, -31846, -31927, -31824, -31506, -30972, -30234, -29338, -28340, -27316, -26346, -25496, -24819, -24358, -24116, -24072, -24164, -24303, -24370, -24222, -23710, -22704, -21099, -18808, -15841, -12250, -8128, -3689, 933, 5547, 9945, 13977, 17550, 20609, 23125, 25120, 26625, 27699, 28404, 28785, 28886, 28733, 28353, 27758, 26958, 25975, 24826, 23546, 22189, 20783, 19398, 18093, 16925, 15950, 15225, 14771, 14620, 14783, 15252, 15990, 16956, 18074, 19245, 20355, 21283, 21896, 22091, 21771, 20885, 19425, 17452, 15046, 12326, 9456, 6604, 3912, 1533, -449, -1949, -2916, -3329, -3194, -2533, -1391, 176, 2081, 4226, 6539, 8892, 11196, 13379, 15356, 17119, 18646, 19933, 21004, 21880, 22575, 23107, 23457, 23590, 23449, 22956, 22010, 20502, 18334, 15445, 11801, 7475, 2591, -2358, -6970, -11016, -14327, -16811, -18468, -19349, -19571, -19282, -18649, -17825, -16955, -16151, -15506, -15080, -14898, -14967, -15276, -15796, -16481, -17279, -18150, -19039, -19915, -20740, -21502, -22202, -22843, -23430, -23980, -24491, -24966, -25383, -25703, -25876, -25839, -25513, -24831, -23729, -22172, -20148, -17696, -14856, -11739, -8450, -5133, -1922, 1080, 3797, 6158, 8140, 9736, 10965, 11869, 12471, 12808, 12897, 12752, 12379, 11773, 10942, 9885, 8619, 7195, 5635, 4009, 2396, 864, -503, -1629, -2468, -2954, -3048, -2716, -1945, -658};