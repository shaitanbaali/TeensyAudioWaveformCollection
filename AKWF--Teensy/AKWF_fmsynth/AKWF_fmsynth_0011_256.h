/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0011 256 samples */
 
const int16_t AKWF_fmsynth_0011_256_DATA [256] = 
{2827, 7964, 12820, 17251, 21058, 24160, 26527, 28204, 29283, 29898, 30180, 30260, 30251, 30225, 30229, 30245, 30220, 30029, 29502, 28416, 26501, 23505, 19199, 13475, 6464, -1296, -9619, -17939, -25130, -30218, -32466, -31542, -27494, -20794, -12172, -2568, 6984, 15600, 22542, 27328, 29791, 30032, 28368, 25265, 21252, 16850, 12494, 8519, 5159, 2505, 610, -534, -963, -697, 228, 1805, 3983, 6712, 9891, 13369, 16960, 20467, 23663, 26348, 28383, 29646, 30118, 29825, 28864, 27372, 25511, 23475, 21422, 19527, 17918, 16713, 15993, 15811, 16200, 17151, 18634, 20562, 22814, 25174, 27394, 29131, 29986, 29552, 27426, 23357, 17235, 9371, 512, -8653, -17612, -25152, -30329, -32641, -32001, -28691, -23248, -16353, -8722, -1048, 6141, 12477, 17705, 21810, 24832, 26914, 28262, 29054, 29490, 29685, 29762, 29737, 29627, 29365, 28873, 28042, 26735, 24874, 22325, 19098, 15166, 10618, 5596, 270, -5127, -10397, -15283, -19675, -23381, -26398, -28708, -30353, -31473, -32125, -32514, -32660, -32741, -32728, -32663, -32498, -32069, -31344, -29962, -27929, -24823, -20658, -15435, -8525, -2609, 728, 8214, 15046, 21493, 26428, 29443, 29771, 27128, 21547, 13408, 3867, -5926, -15291, -23311, -28977, -32064, -32689, -31184, -28136, -24028, -19467, -14807, -10434, -6567, -3324, -818, 970, 2000, 2333, 1941, 882, -832, -3162, -6040, -9400, -13076, -16961, -20809, -24437, -27620, -30137, -31847, -32621, -32454, -31363, -29501, -27029, -24175, -21173, -18248, -15602, -13372, -11705, -10650, -10281, -10610, -11656, -13404, -15791, -18736, -22029, -25422, -28563, -31041, -32415, -32276, -30321, -26383, -20520, -13019, -4404, 4663, 13339, 20829, 26428, 29585, 30069, 27911, 23485, 17353, 10269, 3085, -3602, -9725, -15042, -19369, -22714, -25163, -26881, -28004, -28652, -28922, -28844, -28436, -27650, -26437, -24718, -22414, -19488, -15922, -11774, -7169, -2236};