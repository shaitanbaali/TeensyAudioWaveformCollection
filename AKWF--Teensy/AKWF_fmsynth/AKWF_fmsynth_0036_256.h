/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0036 256 samples */
 
const int16_t AKWF_fmsynth_0036_256_DATA [256] = 
{3965, 11429, 17709, 22906, 26954, 29846, 31682, 32592, 32747, 32324, 31493, 30416, 29235, 28076, 27036, 26182, 25578, 25256, 25237, 25515, 26083, 26900, 27913, 29056, 30231, 31317, 32196, 32703, 32680, 31957, 30391, 27830, 24172, 19396, 13537, 6721, -735, -8579, -16268, -23191, -28661, -32036, -32623, -29919, -23717, -14356, -2851, 9372, 20579, 28804, 32607, 31379, 25197, 14931, 2107, -11313, -23008, -30695, -32643, -27746, -16382, -911, 14849, 27111, 32632, 30304, 20919, 6700, -9021, -22886, -31372, -32019, -23970, -9005, 8603, 23819, 32013, 31293, 22393, 7988, -8417, -22764, -31423, -31919, -23701, -8639, 8805, 23726, 31877, 31638, 23790, 10582, -4817, -19077, -29098, -32784, -29172, -18838, -4233, 11098, 23757, 31252, 32513, 27996, 18967, 7272, -5228, -16792, -25860, -31345, -32707, -29928, -23477, -14282, -3741, 6767, 16323, 23987, 29295, 32148, 32715, 31331, 28421, 24371, 19602, 14442, 9208, 4138, -620, -4967, -8818, -12157, -14969, -17276, -19136, -20564, -21600, -22278, -22619, -22634, -22321, -21671, -20661, -19262, -17429, -15118, -12300, -8953, -5075, -688, 4152, 9336, 14669, 19910, 24728, 28784, 31614, 32766, 31788, 28363, 22306, 13771, 3462, -7582, -18186, -26672, -31760, -32523, -28670, -20541, -9189, 3848, 16652, 26855, 32330, 31361, 23431, 9512, -7026, -22012, -31200, -32130, -24791, -11013, 5743, 21198, 31050, 31973, 22663, 5385, -13919, -28359, -32730, -26146, -11047, 7667, 24010, 32424, 29399, 14950, -5599, -23942, -32609, -28875, -14871, 4249, 21951, 31972, 30300, 16587, -3935, -22784, -32358, -29646, -16653, 1884, 19711, 30982, 31660, 21009, 2504, -16822, -29846, -32429, -24785, -10079, 7357, 22613, 31560, 31670, 22727, 7161, -10226, -24559, -32037, -31574, -24202, -12026, 2222, 15778, 26251, 31992, 32143, 26824, 16992, 4631, -7937, -19176, -27376, -31850, -32637, -30212, -25232, -18490, -10722, -2671};