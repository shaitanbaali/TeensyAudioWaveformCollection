/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0021 256 samples */
 
const int16_t AKWF_fmsynth_0021_256_DATA [256] = 
{103, 396, 682, 973, 1268, 1565, 1863, 2160, 2457, 2756, 3059, 3365, 3672, 3980, 4289, 4600, 4914, 5233, 5555, 5878, 6202, 6530, 6860, 7194, 7530, 7869, 8211, 8555, 8903, 9256, 9611, 9968, 10327, 10689, 11055, 11425, 11798, 12173, 12550, 12928, 13308, 13695, 14082, 14472, 14865, 15256, 15651, 16048, 16447, 16847, 17248, 17649, 18051, 18454, 18857, 19260, 19663, 20063, 20463, 20863, 21262, 21659, 22052, 22441, 22828, 23212, 23593, 23971, 24342, 24706, 25065, 25418, 25765, 26106, 26437, 26760, 27073, 27376, 27670, 27954, 28224, 28483, 28727, 28956, 29173, 29374, 29557, 29723, 29870, 29997, 30105, 30193, 30257, 30297, 30311, 30300, 30264, 30200, 30107, 29983, 29825, 29633, 29407, 29147, 28849, 28510, 28131, 27705, 27237, 26725, 26164, 25553, 24890, 24170, 23394, 22565, 21674, 20721, 19704, 18616, 17459, 16233, 14930, 13551, 12094, 10551, 8926, 7213, 5401, 3490, 1482, -604, -2714, -4805, -6827, -8742, -10549, -12260, -13882, -15432, -16909, -18304, -19619, -20854, -22011, -23102, -24128, -25086, -25978, -26802, -27562, -28263, -28909, -29498, -30032, -30512, -30938, -31317, -31648, -31933, -32174, -32370, -32525, -32640, -32717, -32759, -32766, -32738, -32677, -32584, -32465, -32319, -32145, -31946, -31722, -31475, -31208, -30920, -30615, -30291, -29951, -29594, -29225, -28841, -28445, -28039, -27620, -27193, -26758, -26315, -25866, -25411, -24948, -24482, -24013, -23541, -23068, -22590, -22111, -21632, -21152, -20673, -20197, -19720, -19244, -18772, -18299, -17830, -17366, -16904, -16446, -15992, -15541, -15093, -14652, -14213, -13779, -13351, -12927, -12508, -12095, -11686, -11282, -10883, -10489, -10100, -9715, -9335, -8961, -8590, -8224, -7863, -7506, -7153, -6805, -6460, -6119, -5783, -5451, -5120, -4793, -4471, -4151, -3835, -3520, -3206, -2895, -2587, -2283, -1983, -1683, -1380, -1074, -767, -462, -158};