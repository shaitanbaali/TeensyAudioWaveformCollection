/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0077 256 samples */
 
const int16_t AKWF_fmsynth_0077_256_DATA [256] = 
{121, 765, 1634, 2477, 3345, 4226, 5128, 6038, 6969, 7910, 8857, 9820, 10785, 11753, 12730, 13710, 14684, 15653, 16622, 17583, 18535, 19474, 20388, 21294, 22182, 23044, 23884, 24695, 25473, 26226, 26947, 27627, 28275, 28880, 29449, 29974, 30456, 30898, 31294, 31642, 31944, 32202, 32411, 32572, 32686, 32752, 32770, 32744, 32668, 32546, 32378, 32164, 31904, 31599, 31251, 30861, 30427, 29951, 29432, 28875, 28279, 27646, 26973, 26264, 25518, 24737, 23927, 23083, 22206, 21300, 20365, 19410, 18422, 17411, 16380, 15327, 14262, 13182, 12082, 10976, 9867, 8750, 7638, 6526, 5405, 4266, 3116, 1960, 800, -363, -1527, -2684, -3832, -4964, -6086, -7191, -8276, -9337, -10371, -11377, -12356, -13303, -14217, -15098, -15938, -16749, -17517, -18252, -18949, -19605, -20222, -20804, -21349, -21860, -22333, -22768, -23174, -23551, -23891, -24204, -24491, -24751, -24987, -25199, -25390, -25562, -25716, -25852, -25972, -26081, -26178, -26263, -26337, -26405, -26465, -26521, -26569, -26613, -26655, -26694, -26731, -26762, -26796, -26829, -26860, -26892, -26921, -26952, -26982, -27014, -27042, -27071, -27102, -27130, -27155, -27183, -27208, -27230, -27249, -27268, -27284, -27297, -27305, -27309, -27311, -27307, -27298, -27283, -27264, -27239, -27208, -27171, -27125, -27075, -27018, -26953, -26880, -26799, -26713, -26617, -26514, -26404, -26287, -26160, -26027, -25887, -25738, -25582, -25420, -25249, -25074, -24891, -24701, -24506, -24306, -24098, -23886, -23667, -23446, -23220, -22988, -22753, -22516, -22274, -22027, -21777, -21525, -21269, -21012, -20750, -20485, -20219, -19951, -19678, -19402, -19124, -18843, -18556, -18269, -17975, -17678, -17374, -17069, -16757, -16437, -16111, -15779, -15438, -15093, -14738, -14370, -13994, -13607, -13213, -12805, -12382, -11946, -11499, -11037, -10558, -10064, -9554, -9027, -8483, -7921, -7339, -6740, -6120, -5479, -4820, -4140, -3442, -2721, -1979, -1222, -405};