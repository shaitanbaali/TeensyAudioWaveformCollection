/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0078 256 samples */
 
const int16_t AKWF_fmsynth_0078_256_DATA [256] = 
{117, 784, 1825, 2933, 4155, 5474, 6888, 8397, 9987, 11648, 13357, 15099, 16876, 18649, 20410, 22131, 23782, 25352, 26828, 28170, 29370, 30410, 31266, 31940, 32416, 32693, 32769, 32650, 32340, 31849, 31196, 30394, 29459, 28423, 27297, 26104, 24868, 23610, 22349, 21114, 19901, 18732, 17627, 16588, 15625, 14745, 13946, 13233, 12607, 12068, 11613, 11237, 10938, 10710, 10552, 10454, 10414, 10426, 10483, 10577, 10704, 10856, 11027, 11209, 11395, 11575, 11748, 11902, 12031, 12129, 12186, 12199, 12158, 12060, 11899, 11666, 11361, 10975, 10505, 9946, 9302, 8565, 7739, 6819, 5794, 4662, 3424, 2084, 649, -880, -2494, -4174, -5908, -7671, -9453, -11230, -12979, -14674, -16286, -17797, -19190, -20440, -21527, -22435, -23153, -23680, -24008, -24136, -24072, -23826, -23402, -22815, -22091, -21243, -20298, -19267, -18173, -17045, -15898, -14756, -13633, -12545, -11508, -10537, -9642, -8832, -8114, -7494, -6976, -6562, -6257, -6061, -5972, -5989, -6107, -6331, -6649, -7064, -7563, -8148, -8814, -9544, -10335, -11191, -12090, -13032, -14003, -14987, -15992, -17002, -18006, -18999, -19969, -20908, -21822, -22691, -23515, -24298, -25022, -25692, -26312, -26872, -27372, -27818, -28204, -28531, -28803, -29014, -29167, -29259, -29291, -29262, -29167, -29005, -28775, -28471, -28095, -27637, -27098, -26481, -25776, -24982, -24104, -23139, -22088, -20965, -19756, -18481, -17140, -15740, -14305, -12830, -11325, -9808, -8288, -6776, -5293, -3831, -2407, -1036, 281, 1528, 2708, 3820, 4853, 5807, 6682, 7472, 8185, 8820, 9377, 9854, 10260, 10591, 10851, 11042, 11163, 11217, 11204, 11128, 10987, 10780, 10514, 10189, 9801, 9358, 8858, 8312, 7721, 7086, 6414, 5712, 4986, 4248, 3504, 2753, 2016, 1298, 602, -55, -671, -1238, -1746, -2187, -2559, -2850, -3057, -3179, -3207, -3136, -2966, -2689, -2309, -1815, -1218, -460};