/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0053 256 samples */
 
const int16_t AKWF_fmsynth_0053_256_DATA [256] = 
{9939, 24173, 31369, 32704, 30913, 28656, 27652, 28500, 30717, 32644, 31525, 24193, 9726, -8649, -25200, -32715, -28854, -16862, -2254, 10667, 19716, 24864, 27044, 27041, 24867, 19814, 11015, -1440, -15631, -27567, -32800, -28409, -15578, 267, 14290, 24133, 29356, 31448, 31981, 31611, 29830, 25109, 15671, 1505, -14921, -28498, -32680, -25780, -9952, 11160, 23678, 30417, 32649, 32564, 32142, 32313, 32754, 31994, 27895, 18757, 4625, -11697, -25678, -32531, -30193, -20386, -7713, 3394, 11433, 15934, 16995, 14738, 8924, -473, -12848, -25359, -32451, -29928, -17553, 526, 17852, 29224, 32789, 30257, 24979, 20159, 17747, 18444, 22040, 27304, 31803, 32311, 26191, 13268, -3739, -19774, -30147, -32688, -28616, -21238, -14029, -9300, -7994, -10313, -15914, -23606, -30510, -32662, -26801, -12763, 5755, 22578, 31845, 31383, 23240, 12157, 2341, -4153, -7122, -6432, -2182, 5416, 15866, 26315, 32420, 30584, 20321, 4416, -12129, -24736, -31367, -32729, -31177, -29204, -28493, -29551, -31628, -32771, -30240, -21661, -6840, 11009, 26109, 32772, 28338, 15331, 73, -12699, -21531, -26237, -28024, -27724, -25216, -19549, -9714, 3568, 18331, 29673, 32633, 26088, 12818, -2410, -15454, -24302, -29048, -31054, -31516, -30897, -28558, -23162, -13364, 798, 16652, 29093, 32621, 24674, 8308, -9299, -23093, -30496, -32710, -32400, -31760, -31859, -32560, -32542, -29563, -21237, -7173, 9773, 24891, 32442, 30442, 21281, 9227, -1959, -10134, -14906, -16379, -14709, -9657, -1059, 10550, 22849, 31469, 31528, 20548, 2315, -16215, -28876, -32798, -30197, -24878, -19941, -17214, -17450, -20568, -25659, -30717, -32759, -28394, -16032, 1334, 18454, 29862, 32717, 28703, 21474, 14360, 9477, 7734, 9442, 14386, 21626, 28956, 32767, 29033, 15802, -3221, -21364, -31666, -31543, -23850, -13230, -3494, 3358, 6743, 6599, 2961, -4071, -13719, -24054, -31473, -31954, -23132, -6821};