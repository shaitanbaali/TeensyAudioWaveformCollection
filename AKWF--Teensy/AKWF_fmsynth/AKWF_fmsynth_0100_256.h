/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0100 256 samples */
 
const int16_t AKWF_fmsynth_0100_256_DATA [256] = 
{230, 927, 1656, 2446, 3293, 4204, 5176, 6217, 7336, 8533, 9807, 11166, 12602, 14123, 15721, 17387, 19101, 20845, 22597, 24332, 26018, 27610, 29067, 30340, 31397, 32181, 32650, 32760, 32470, 31748, 30561, 28884, 26695, 23985, 20766, 16987, 12677, 7832, 2404, -3260, -8284, -12626, -16351, -19558, -22287, -24620, -26596, -28250, -29608, -30701, -31547, -32165, -32564, -32750, -32734, -32524, -32120, -31531, -30761, -29820, -28723, -27475, -26089, -24586, -22980, -21296, -19563, -17779, -15981, -14182, -12397, -10652, -8947, -7274, -5652, -4066, -2507, -983, 545, 2085, 3646, 5246, 6893, 8580, 10337, 12142, 13984, 15863, 17738, 19602, 21434, 23198, 24870, 26430, 27839, 29099, 30184, 31082, 31786, 32300, 32623, 32761, 32723, 32522, 32169, 31675, 31056, 30323, 29482, 28553, 27526, 26410, 25203, 23899, 22495, 20985, 19331, 17531, 15561, 13380, 10983, 8314, 5324, 1966, -1719, -5372, -8829, -12137, -15252, -18148, -20814, -23224, -25369, -27248, -28847, -30160, -31196, -31956, -32461, -32721, -32756, -32589, -32246, -31746, -31122, -30392, -29585, -28730, -27834, -26923, -26017, -25124, -24265, -23448, -22673, -21954, -21296, -20700, -20172, -19709, -19313, -18985, -18723, -18525, -18392, -18317, -18301, -18340, -18430, -18568, -18747, -18966, -19221, -19502, -19808, -20130, -20464, -20807, -21151, -21487, -21813, -22123, -22413, -22675, -22907, -23102, -23259, -23375, -23446, -23468, -23442, -23365, -23234, -23051, -22814, -22522, -22177, -21783, -21336, -20843, -20304, -19728, -19113, -18466, -17792, -17100, -16393, -15677, -14958, -14239, -13530, -12833, -12157, -11498, -10864, -10256, -9679, -9135, -8624, -8146, -7704, -7296, -6922, -6588, -6284, -6015, -5778, -5572, -5396, -5247, -5124, -5023, -4942, -4877, -4826, -4786, -4752, -4722, -4690, -4652, -4606, -4547, -4471, -4374, -4250, -4100, -3918, -3700, -3443, -3148, -2813, -2430, -2002, -1528, -1006, -428};