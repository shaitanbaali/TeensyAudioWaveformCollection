/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0010 256 samples */
 
const int16_t AKWF_fmsynth_0010_256_DATA [256] = 
{1296, 4611, 7645, 10618, 13475, 16059, 18487, 20648, 22529, 24195, 25550, 26652, 27518, 28094, 28461, 28596, 28506, 28251, 27800, 27196, 26469, 25595, 24636, 23589, 22455, 21288, 20064, 18815, 17563, 16288, 15034, 13797, 12570, 11394, 10246, 9141, 8100, 7099, 6165, 5298, 4485, 3753, 3086, 2487, 1974, 1528, 1164, 880, 670, 553, 512, 551, 687, 900, 1205, 1601, 2077, 2653, 3318, 4067, 4917, 5847, 6868, 7979, 9161, 10426, 11759, 13151, 14600, 16077, 17582, 19094, 20580, 22037, 23420, 24701, 25863, 26843, 27618, 28150, 28375, 28274, 27788, 26878, 25523, 23674, 21330, 18488, 15145, 11376, 7223, 2794, -1729, -6355, -11108, -15809, -20245, -24229, -27603, -30221, -31956, -32731, -32487, -31207, -28912, -25647, -21523, -16660, -11205, -5384, 622, 6586, 12234, 17371, 21749, 25136, 27385, 28327, 27877, 26021, 22767, 18278, 12755, 6490, -23, -6526, -12970, -19020, -24211, -28296, -31110, -32542, -32605, -31335, -28836, -25289, -20845, -15718, -10150, -4331, 1503, 7130, 12391, 17098, 21099, 24301, 26609, 27967, 28365, 27811, 26350, 24048, 21008, 17353, 13213, 8754, 4159, -402, -4843, -9200, -13424, -17346, -20883, -23994, -26625, -28775, -30444, -31633, -32380, -32708, -32648, -32245, -31531, -30547, -29333, -27922, -26358, -24666, -22878, -21032, -19138, -17226, -15325, -13435, -11586, -9792, -8045, -6374, -4781, -3265, -1842, -505, 741, 1890, 2949, 3911, 4780, 5560, 6242, 6835, 7339, 7750, 8079, 8315, 8464, 8531, 8500, 8389, 8191, 7897, 7520, 7045, 6477, 5821, 5062, 4210, 3261, 2207, 1063, -185, -1530, -2963, -4494, -6103, -7794, -9563, -11376, -13247, -15151, -17059, -18983, -20869, -22705, -24488, -26147, -27689, -29082, -30262, -31249, -31978, -32420, -32586, -32394, -31873, -31004, -29727, -28129, -26141, -23777, -21164, -18172, -14972, -11666, -8021, -4631, -1775};