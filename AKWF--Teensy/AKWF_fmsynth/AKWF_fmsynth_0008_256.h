/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0008 256 samples */
 
const int16_t AKWF_fmsynth_0008_256_DATA [256] = 
{4732, 12853, 18777, 22774, 25195, 26495, 27082, 27264, 27257, 27179, 27093, 27021, 26962, 26909, 26849, 26774, 26674, 26542, 26385, 26216, 26060, 25962, 25968, 26123, 26438, 26843, 27154, 26995, 25744, 22529, 16406, 6812, -5467, -18920, -29640, -32595, -25156, -8697, 10924, 24947, 25430, 10541, -11464, -28777, -32266, -21920, -4231, 13091, 24292, 27012, 21959, 11906, 386, -10140, -18958, -25428, -29589, -31871, -32735, -32539, -31550, -29924, -27764, -25119, -22019, -18525, -14708, -10675, -6595, -2635, 1017, 4173, 6693, 8462, 9374, 9343, 8250, 5961, 2319, -2754, -9144, -16457, -23784, -29741, -32648, -30925, -23814, -12168, 1180, 13811, 22992, 27010, 26197, 21930, 15907, 9608, 4062, -131, -2743, -3726, -3119, -995, 2515, 7163, 12547, 18053, 22877, 26178, 27181, 25373, 20637, 13358, 4459, -4825, -13929, -22042, -28196, -31833, -32650, -30517, -25443, -17633, -7547, 3837, 14977, 23675, 27221, 23149, 10722, -6698, -23590, -32489, -28646, -13597, 6251, 22230, 27132, 18489, 1003, -17054, -29353, -32680, -28622, -20413, -11061, -2525, 4233, 8997, 11964, 13400, 13544, 12551, 10507, 7489, 3598, -955, -5909, -10973, -15821, -20200, -23945, -26956, -29245, -30873, -31927, -32498, -32664, -32465, -31896, -30905, -29394, -27204, -24152, -20065, -14801, -8428, -1336, 6393, 14155, 20804, 25391, 27273, 26309, 22849, 17638, 11604, 5626, 441, -3480, -5879, -6605, -5562, -2662, 2094, 8496, 15844, 22707, 26930, 25977, 17960, 3602, -13162, -27209, -32662, -27516, -14053, 2910, 17844, 26294, 26103, 17732, 4323, -9928, -22320, -30227, -32615, -29789, -22715, -12647, -1091, 10340, 19958, 26006, 27008, 22105, 11680, -1865, -15711, -26855, -32278, -31217, -24698, -14771, -3760, 6365, 14459, 20125, 23584, 25423, 26228, 26420, 26138, 25203, 23184, 19510, 13726, 5739, -4014, -14375, -23705, -30263, -32635, -30267, -23670, -14302, -4203};