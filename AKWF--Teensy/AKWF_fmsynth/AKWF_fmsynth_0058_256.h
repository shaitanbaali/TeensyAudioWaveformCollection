/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0058 256 samples */
 
const int16_t AKWF_fmsynth_0058_256_DATA [256] = 
{3276, 9290, 12745, 13819, 12558, 9044, 3450, -3669, -11327, -18351, -23807, -27362, -29248, -29834, -29292, -27413, -23654, -17600, -9565, 1598, 11522, 19093, 24769, 28148, 29760, 30118, 29412, 27405, 23686, 18068, 10977, 3359, -3576, -8951, -12198, -13147, -11719, -7889, -1744, 6178, 14757, 22529, 28243, 31459, 32647, 32734, 32619, 32698, 32741, 32024, 29770, 25619, 19906, 13630, 8037, 4049, 2324, 3127, 6439, 11857, 18499, 25096, 30111, 32557, 32413, 30577, 28400, 27082, 27230, 28732, 30856, 32490, 32579, 30674, 27146, 23029, 19465, 17454, 17522, 19708, 23498, 27872, 31428, 32779, 31257, 27264, 22186, 17554, 14675, 14199, 16170, 20074, 24865, 29263, 32050, 32753, 31754, 30032, 28634, 28306, 29240, 30984, 32512, 32494, 29847, 24319, 16840, 9073, 2719, -1255, -2561, -1134, 2836, 8914, 16041, 22866, 28105, 31217, 32502, 32763, 32743, 32763, 32523, 31194, 27737, 21470, 12778, 3149, -5660, -12450, -16734, -18517, -17959, -15076, -9855, -2700, 5616, 13860, 20678, 25386, 28050, 29110, 28887, 27238, 23649, 17520, 8943, -1098, -10996, -19210, -24815, -27988, -29344, -29398, -28182, -25350, -20452, -13503, -5216, 2989, 9991, 14936, 17517, 17753, 15610, 10901, 3706, -5226, -14787, -23073, -28745, -31691, -32672, -32747, -32709, -32763, -32511, -31144, -27919, -22581, -15740, -8712, -2911, 721, 1766, 94, -4266, -10883, -18622, -25723, -30669, -32695, -32227, -30454, -28693, -27895, -28415, -29985, -31800, -32765, -31967, -29093, -24726, -20066, -16439, -14823, -15643, -18764, -23447, -28347, -31837, -32725, -30794, -26868, -22370, -18677, -16751, -16995, -19298, -23075, -27317, -30805, -32620, -32450, -30833, -28835, -27540, -27612, -29039, -31129, -32639, -32251, -29229, -23742, -16939, -10296, -5102, -2137, -1694, -3754, -8027, -13865, -20221, -25847, -29896, -32051, -32731, -32724, -32685, -32766, -32478, -30914, -27178, -20960, -12942, -4206};