/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0056 256 samples */
 
const int16_t AKWF_fmsynth_0056_256_DATA [256] = 
{3977, 14737, 23071, 28814, 31928, 32764, 31791, 29603, 26759, 23771, 21012, 18742, 17153, 16346, 16364, 17201, 18808, 21088, 23857, 26830, 29633, 31791, 32762, 31975, 28960, 23411, 15378, 5199, -6182, -17420, -26703, -32103, -31903, -25185, -12534, 3068, 18454, 29490, 32719, 27228, 14471, -2141, -18337, -29692, -32608, -25646, -10619, 7158, 23060, 31898, 31330, 22370, 8017, -7962, -21851, -30638, -32608, -27604, -17100, -3866, 9233, 20669, 28556, 32331, 32373, 29498, 24635, 18690, 12432, 6443, 1020, -3570, -7254, -10019, -11877, -12877, -13053, -12395, -10885, -8480, -5175, -908, 4248, 10121, 16426, 22634, 28004, 31720, 32706, 30036, 23085, 12213, -980, -14734, -26319, -32374, -31086, -22427, -8076, 8674, 23491, 31967, 30899, 19462, 1383, -17307, -30198, -32171, -23116, -6428, 12337, 27066, 32824, 27333, 12259, -6448, -23056, -32034, -31084, -21652, -7003, 8864, 22345, 30698, 32645, 28255, 18864, 6894, -5103, -15908, -24416, -29858, -32408, -32609, -31139, -28642, -25675, -22688, -20016, -17872, -16410, -15692, -15762, -16620, -18199, -20438, -23167, -26149, -29054, -31423, -32691, -32247, -29452, -23846, -15240, -4639, 5649, 17343, 27072, 32288, 31662, 24948, 13028, -1933, -16828, -28179, -32801, -28685, -16122, 1078, 18130, 29966, 32507, 25523, 11351, -5866, -21392, -31058, -32100, -24073, -9355, 7245, 21946, 30910, 32492, 27286, 17178, 4569, -8174, -19210, -27303, -31786, -32678, -30440, -25900, -19889, -13341, -6974, -1366, 3330, 7218, 10185, 12206, 13322, 13558, 12926, 11397, 8935, 5518, 1224, -3941, -10028, -16647, -23110, -28551, -32007, -32603, -29625, -22812, -12526, 107, 13331, 24788, 31749, 31901, 24013, 9484, -7833, -23510, -32139, -30650, -19676, -2591, 15543, 28859, 32665, 24799, 7968, -11577, -27191, -32817, -27137, -12873, 5002, 21304, 31198, 31914, 23355, 8347, -8111, -22424, -30994, -32543, -27914, -18886, -7348};