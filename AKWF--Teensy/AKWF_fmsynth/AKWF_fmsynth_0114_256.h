/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0114 256 samples */
 
const int16_t AKWF_fmsynth_0114_256_DATA [256] = 
{1396, 3788, 6166, 8573, 10967, 13327, 15628, 17839, 19949, 21935, 23780, 25473, 27005, 28361, 29540, 30536, 31346, 31973, 32416, 32681, 32770, 32692, 32454, 32064, 31535, 30877, 30095, 29208, 28225, 27155, 26015, 24814, 23561, 22273, 20956, 19621, 18281, 16941, 15610, 14300, 13013, 11756, 10540, 9366, 8239, 7166, 6144, 5181, 4284, 3445, 2672, 1968, 1329, 759, 261, -168, -525, -810, -1027, -1170, -1238, -1236, -1159, -1008, -783, -482, -109, 343, 868, 1472, 2150, 2904, 3735, 4639, 5612, 6660, 7777, 8957, 10199, 11499, 12846, 14242, 15674, 17129, 18605, 20088, 21558, 23015, 24433, 25796, 27089, 28292, 29384, 30348, 31160, 31796, 32238, 32465, 32457, 32189, 31652, 30827, 29700, 28273, 26533, 24485, 22148, 19527, 16647, 13558, 10291, 6904, 3489, 64, -3440, -6964, -10440, -13776, -16899, -19760, -22288, -24435, -26172, -27456, -28268, -28597, -28435, -27788, -26661, -25086, -23080, -20675, -17926, -14863, -11536, -8014, -4335, -564, 3228, 7002, 10693, 14234, 17587, 20695, 23504, 25989, 28103, 29815, 31111, 31970, 32382, 32347, 31866, 30958, 29637, 27934, 25879, 23507, 20870, 18017, 14989, 11859, 8679, 5502, 2414, -611, -3627, -6571, -9407, -12096, -14604, -16921, -19027, -20910, -22576, -24020, -25244, -26263, -27080, -27710, -28163, -28456, -28601, -28613, -28508, -28301, -28004, -27632, -27199, -26715, -26197, -25652, -25090, -24522, -23956, -23399, -22861, -22345, -21858, -21406, -20992, -20620, -20293, -20013, -19784, -19605, -19477, -19402, -19383, -19414, -19499, -19633, -19817, -20051, -20330, -20653, -21017, -21414, -21847, -22307, -22790, -23293, -23809, -24331, -24852, -25368, -25867, -26345, -26790, -27198, -27557, -27857, -28091, -28247, -28319, -28296, -28168, -27930, -27569, -27079, -26457, -25693, -24785, -23730, -22523, -21167, -19667, -18016, -16232, -14320, -12285, -10148, -7924, -5631, -3295, -888};