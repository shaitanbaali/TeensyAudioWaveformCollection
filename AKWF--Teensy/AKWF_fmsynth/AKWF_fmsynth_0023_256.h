/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0023 256 samples */
 
const int16_t AKWF_fmsynth_0023_256_DATA [256] = 
{317, 926, 1451, 1896, 2251, 2519, 2710, 2832, 2907, 2957, 3005, 3075, 3194, 3378, 3642, 3991, 4435, 4977, 5600, 6286, 7022, 7781, 8537, 9273, 9961, 10582, 11125, 11579, 11944, 12228, 12441, 12597, 12722, 12837, 12970, 13141, 13373, 13683, 14084, 14579, 15166, 15841, 16586, 17382, 18207, 19030, 19834, 20592, 21281, 21890, 22411, 22839, 23185, 23455, 23666, 23840, 23997, 24160, 24353, 24596, 24901, 25284, 25744, 26278, 26876, 27519, 28184, 28849, 29485, 30072, 30595, 31040, 31405, 31695, 31916, 32081, 32200, 32288, 32353, 32405, 32455, 32506, 32563, 32627, 32691, 32744, 32768, 32745, 32647, 32450, 32135, 31690, 31119, 30438, 29677, 28879, 28086, 27345, 26683, 26120, 25653, 25267, 24930, 24600, 24232, 23775, 23182, 22396, 21372, 20069, 18436, 16444, 14085, 11356, 8303, 4985, 1594, -1414, -3929, -5991, -7630, -8888, -9831, -10515, -11009, -11384, -11706, -12044, -12461, -13003, -13709, -14586, -15616, -16767, -17987, -19211, -20387, -21465, -22403, -23194, -23831, -24319, -24685, -24947, -25129, -25247, -25322, -25364, -25387, -25399, -25410, -25433, -25469, -25522, -25591, -25669, -25740, -25791, -25804, -25768, -25674, -25526, -25332, -25109, -24874, -24645, -24442, -24275, -24150, -24068, -24024, -24008, -24010, -24012, -24005, -23974, -23909, -23797, -23632, -23408, -23118, -22766, -22357, -21898, -21408, -20907, -20415, -19956, -19548, -19207, -18943, -18759, -18650, -18605, -18612, -18649, -18695, -18727, -18728, -18675, -18555, -18356, -18075, -17709, -17264, -16752, -16191, -15599, -15002, -14422, -13883, -13408, -13010, -12701, -12478, -12342, -12284, -12283, -12322, -12374, -12420, -12430, -12385, -12268, -12066, -11771, -11383, -10910, -10362, -9759, -9120, -8474, -7843, -7250, -6721, -6265, -5896, -5618, -5428, -5317, -5269, -5264, -5281, -5291, -5273, -5206, -5067, -4841, -4524, -4114, -3611, -3034, -2395, -1716, -1024, -328};