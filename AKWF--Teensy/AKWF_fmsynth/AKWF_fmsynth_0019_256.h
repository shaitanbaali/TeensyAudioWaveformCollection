/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0019 256 samples */
 
const int16_t AKWF_fmsynth_0019_256_DATA [256] = 
{597, 2434, 4290, 6222, 8236, 10341, 12532, 14777, 17059, 19333, 21543, 23652, 25600, 27336, 28828, 30048, 30973, 31612, 31969, 32068, 31946, 31637, 31190, 30643, 30044, 29422, 28813, 28238, 27714, 27247, 26837, 26480, 26164, 25883, 25608, 25331, 25022, 24661, 24220, 23671, 22981, 22103, 20995, 19588, 17813, 15577, 12761, 9229, 4807, -724, -6708, -12310, -17441, -21940, -25718, -28695, -30844, -32147, -32645, -32397, -31484, -30023, -28114, -25897, -23456, -20927, -18367, -15863, -13462, -11180, -9061, -7057, -5229, -3448, -1927, 340, 2067, 3284, 4596, 5815, 6979, 8097, 9130, 10108, 10992, 11810, 12532, 13177, 13735, 14216, 14625, 14962, 15243, 15468, 15656, 15808, 15942, 16063, 16187, 16324, 16481, 16675, 16914, 17208, 17568, 18005, 18526, 19138, 19852, 20669, 21594, 22628, 23753, 24971, 26251, 27556, 28837, 30018, 31000, 31650, 31809, 31242, 29714, 26878, 22405, 15848, 6667, -5013, -15094, -22409, -27478, -30679, -32311, -32758, -32269, -31137, -29545, -27683, -25687, -23650, -21657, -19750, -17968, -16316, -14823, -13466, -12254, -11180, -10228, -9396, -8670, -8046, -7505, -7053, -6668, -6350, -6087, -5870, -5693, -5546, -5422, -5308, -5202, -5086, -4963, -4816, -4640, -4428, -4170, -3865, -3502, -3080, -2589, -2034, -1403, -696, 88, 958, 1917, 2970, 4131, 5408, 6805, 8348, 10035, 11877, 13880, 16034, 18313, 20688, 23092, 25443, 27637, 29527, 30964, 31757, 31710, 30621, 28280, 24520, 19163, 12124, 3197, -6441, -14233, -19979, -24261, -27342, -29490, -30939, -31856, -32388, -32644, -32710, -32652, -32521, -32350, -32165, -31983, -31816, -31671, -31547, -31446, -31363, -31293, -31235, -31178, -31119, -31049, -30964, -30855, -30713, -30529, -30293, -29993, -29618, -29155, -28589, -27907, -27098, -26153, -25061, -23825, -22450, -20937, -19308, -17584, -15781, -13930, -12058, -10179, -8318, -6485, -4680, -2904, -1102};