/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0013 256 samples */
 
const int16_t AKWF_fmsynth_0013_256_DATA [256] = 
{2328, 7236, 11337, 14768, 17568, 19826, 21644, 23122, 24371, 25482, 26528, 27574, 28655, 29764, 30861, 31842, 32537, 32706, 32060, 30282, 27072, 22253, 15852, 8167, -50, -8414, -16481, -23300, -28320, -31342, -32433, -31893, -30124, -27556, -24566, -21459, -18457, -15679, -13174, -10940, -8921, -7034, -5186, -3264, -1160, 1213, 3955, 7108, 10664, 14590, 18740, 22888, 26746, 29928, 32034, 32703, 31670, 28844, 24337, 18511, 11891, 5090, -1278, -7148, -12381, -16735, -20208, -22886, -24885, -26356, -27430, -28218, -28821, -29318, -29766, -30220, -30706, -31224, -31739, -32177, -32401, -32232, -31445, -29814, -27108, -23189, -18041, -11759, -4643, 2882, 10352, 17227, 23080, 27625, 30707, 32364, 32770, 32177, 30870, 29123, 27168, 25161, 23196, 21318, 19500, 17688, 15809, 13748, 11404, 8680, 5475, 1776, -2435, -7311, -12693, -18237, -23512, -27967, -31065, -32376, -31635, -28822, -24149, -18055, -11088, -3830, 3079, 9481, 15026, 19574, 23158, 25883, 27881, 29316, 30331, 31046, 31559, 31939, 32229, 32460, 32631, 32712, 32648, 32336, 31643, 30385, 28361, 25381, 21279, 16024, 9754, 2843, -4294, -11537, -18304, -23985, -28250, -30997, -32302, -32392, -31566, -30139, -28392, -26547, -24773, -23155, -21726, -20483, -19372, -18317, -17235, -16017, -14552, -12738, -10453, -7600, -4118, 47, 4849, 10148, 15726, 21203, 26111, 29961, 32247, 32596, 30830, 27028, 21537, 14896, 7814, 1009, -5259, -10935, -15774, -19718, -22819, -25212, -27042, -28438, -29524, -30386, -31086, -31659, -32097, -32365, -32380, -32016, -31111, -29470, -26900, -23254, -18432, -12487, -5619, 1859, 9458, 16633, 22890, 27775, 31028, 32594, 32590, 31297, 29074, 26312, 23350, 20456, 17820, 15526, 13596, 12003, 10661, 9477, 8340, 7125, 5714, 4003, 1898, -658, -3776, -7520, -11801, -16425, -21119, -25480, -29067, -31484, -32398, -31646, -29242, -25392, -20434, -14778, -8870, -2977};