/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0038 256 samples */
 
const int16_t AKWF_fmsynth_0038_256_DATA [256] = 
{6372, 16825, 25630, 31120, 32774, 31211, 27759, 23814, 20474, 18415, 17881, 18786, 20787, 23425, 26155, 28515, 30228, 31263, 31730, 31747, 31244, 29894, 27101, 22249, 14927, 5425, -5288, -15574, -23999, -29611, -32287, -32727, -31981, -31044, -30545, -30713, -31399, -32213, -32725, -32644, -31943, -30873, -29860, -29334, -29568, -30545, -31874, -32746, -32054, -28731, -22159, -12759, -2164, 7961, 16676, 22995, 26965, 29084, 29965, 29969, 29190, 27512, 24811, 21133, 16799, 12408, 8665, 6106, 5175, 6111, 9008, 13697, 19606, 25686, 30472, 32706, 31786, 27993, 22328, 16123, 10573, 6479, 4234, 3924, 5461, 8561, 12770, 17464, 22022, 25840, 28623, 30343, 31203, 31428, 31090, 29976, 27641, 23576, 17536, 9614, 611, -8385, -16289, -22345, -26414, -28804, -29908, -30102, -29477, -27913, -25136, -21010, -15693, -9639, -3572, 1748, 5851, 8333, 9043, 7899, 4916, 145, -6106, -13164, -20105, -25977, -30043, -32198, -32772, -32463, -32007, -31881, -32197, -32664, -32676, -31577, -28882, -24526, -18980, -13019, -7526, -3253, -599, 191, -929, -3881, -8376, -13872, -19713, -25001, -29043, -31534, -32604, -32752, -32577, -32513, -32668, -32753, -32165, -30180, -26261, -20374, -13022, -5177, 2153, 8211, 12551, 15062, 15820, 14916, 12400, 8370, 3090, -2937, -9047, -14563, -18986, -22055, -23740, -24082, -23053, -20447, -16015, -9634, -1065, 8980, 18332, 25354, 29709, 31862, 32620, 32762, 32763, 32754, 32551, 31834, 30316, 27926, 24926, 21861, 19379, 18073, 18312, 20224, 23543, 27546, 31073, 32754, 31500, 26915, 19568, 10757, 1997, -5609, -11345, -15088, -16964, -17191, -15949, -13408, -9804, -5508, -1049, 2973, 6098, 7894, 8087, 6454, 2870, -2664, -9876, -17887, -25379, -30741, -32780, -31028, -26149, -19597, -13014, -7655, -4129, -2589, -2905, -4835, -8004, -11949, -16031, -19682, -22473, -24202, -24796, -24158, -22033, -18025, -11740, -3225};