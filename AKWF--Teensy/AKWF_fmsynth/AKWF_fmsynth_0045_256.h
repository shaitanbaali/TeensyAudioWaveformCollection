/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0045 256 samples */
 
const int16_t AKWF_fmsynth_0045_256_DATA [256] = 
{2554, 6428, 10046, 13381, 16384, 19032, 21306, 23208, 24768, 26007, 26968, 27677, 28164, 28448, 28542, 28448, 28162, 27663, 26919, 25902, 24569, 22861, 20744, 18173, 15129, 11633, 7703, 3426, -1058, -5815, -10743, -15667, -20326, -24485, -27954, -30559, -32184, -32770, -32291, -30789, -28348, -25111, -21202, -16798, -12080, -7232, -2412, 2245, 6642, 10687, 14316, 17498, 20219, 22516, 24401, 25918, 27102, 27999, 28649, 29090, 29344, 29431, 29355, 29120, 28704, 28096, 27266, 26181, 24826, 23167, 21162, 18822, 16128, 13089, 9773, 6163, 2332, -1630, -5645, -9637, -13517, -17197, -20590, -23621, -26232, -28415, -30134, -31398, -32229, -32668, -32764, -32586, -32200, -31672, -31076, -30474, -29921, -29465, -29141, -28981, -28993, -29178, -29528, -30016, -30602, -31237, -31847, -32362, -32695, -32754, -32434, -31652, -30336, -28396, -25806, -22559, -18654, -14172, -9277, -3803, 3194, 8887, 14159, 19080, 23435, 27069, 29856, 31727, 32655, 32659, 31798, 30161, 27891, 25132, 22010, 18717, 15377, 12119, 9086, 6308, 3856, 1781, 81, -1253, -2226, -2843, -3089, -2970, -2488, -1658, -493, 998, 2824, 4977, 7424, 10105, 12991, 15989, 19005, 21945, 24699, 27172, 29281, 30940, 32085, 32682, 32716, 32196, 31150, 29633, 27715, 25475, 22998, 20367, 17665, 14980, 12390, 9964, 7726, 5746, 4042, 2650, 1586, 855, 473, 450, 785, 1476, 2532, 3949, 5705, 7795, 10172, 12798, 15631, 18588, 21561, 24449, 27107, 29419, 31229, 32391, 32766, 32257, 30777, 28300, 24841, 20495, 15422, 9865, 4062, -1644, -7316, -12801, -17790, -22135, -25752, -28568, -30616, -31936, -32615, -32762, -32481, -31884, -31078, -30162, -29225, -28331, -27545, -26914, -26467, -26229, -26208, -26403, -26799, -27376, -28100, -28932, -29822, -30707, -31517, -32180, -32624, -32768, -32541, -31878, -30734, -29076, -26881, -24179, -20998, -17410, -13549, -9473, -5344, -1230};