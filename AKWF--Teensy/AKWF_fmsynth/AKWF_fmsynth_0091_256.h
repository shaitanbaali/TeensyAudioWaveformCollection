/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0091 256 samples */
 
const int16_t AKWF_fmsynth_0091_256_DATA [256] = 
{218, 841, 1465, 2130, 2867, 3678, 4564, 5509, 6514, 7577, 8686, 9842, 11047, 12280, 13545, 14831, 16120, 17424, 18725, 20010, 21277, 22510, 23697, 24846, 25936, 26960, 27918, 28791, 29583, 30292, 30908, 31433, 31869, 32211, 32470, 32647, 32744, 32770, 32739, 32652, 32522, 32358, 32172, 31973, 31766, 31563, 31371, 31196, 31047, 30924, 30830, 30771, 30743, 30747, 30780, 30840, 30926, 31031, 31153, 31285, 31424, 31567, 31709, 31849, 31981, 32103, 32215, 32316, 32404, 32479, 32543, 32594, 32635, 32667, 32690, 32707, 32718, 32724, 32726, 32722, 32715, 32702, 32678, 32644, 32596, 32525, 32429, 32300, 32126, 31900, 31608, 31241, 30780, 30209, 29512, 28670, 27662, 26477, 25074, 23439, 21554, 19380, 16928, 14177, 11012, 7362, 3328, -826, -4819, -8617, -12134, -15294, -18056, -20470, -22603, -24467, -26073, -27444, -28598, -29556, -30348, -30990, -31502, -31899, -32200, -32420, -32576, -32679, -32740, -32767, -32768, -32762, -32742, -32716, -32692, -32671, -32653, -32644, -32640, -32643, -32653, -32668, -32687, -32707, -32727, -32746, -32760, -32767, -32768, -32766, -32754, -32729, -32693, -32649, -32599, -32542, -32482, -32419, -32356, -32298, -32248, -32205, -32176, -32158, -32157, -32173, -32205, -32253, -32316, -32389, -32471, -32553, -32632, -32700, -32750, -32769, -32759, -32704, -32600, -32439, -32212, -31912, -31536, -31078, -30540, -29917, -29206, -28412, -27537, -26582, -25562, -24468, -23312, -22101, -20854, -19559, -18238, -16895, -15535, -14180, -12830, -11484, -10164, -8868, -7604, -6392, -5216, -4091, -3025, -2015, -1068, -194, 621, 1364, 2036, 2640, 3170, 3629, 4021, 4343, 4596, 4784, 4909, 4974, 4980, 4932, 4831, 4682, 4489, 4253, 3981, 3679, 3348, 2996, 2624, 2241, 1850, 1459, 1071, 691, 324, -24, -350, -647, -911, -1138, -1322, -1461, -1549, -1580, -1559, -1491, -1376, -1176, -842, -346};