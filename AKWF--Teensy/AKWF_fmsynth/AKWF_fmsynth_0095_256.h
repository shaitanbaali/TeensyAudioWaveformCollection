/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0095 256 samples */
 
const int16_t AKWF_fmsynth_0095_256_DATA [256] = 
{313, 1277, 2593, 3969, 5459, 7068, 8785, 10578, 12463, 14414, 16405, 18424, 20438, 22408, 24336, 26161, 27848, 29363, 30649, 31671, 32387, 32740, 32685, 32178, 31183, 29655, 27558, 24875, 21583, 17683, 13179, 7985, 2226, -3690, -9050, -13450, -17197, -20357, -23005, -25206, -27023, -28512, -29725, -30693, -31447, -32012, -32409, -32657, -32763, -32737, -32586, -32311, -31912, -31384, -30728, -29936, -29010, -27935, -26708, -25328, -23788, -22087, -20227, -18199, -16008, -13665, -11171, -8552, -5795, -2926, 42, 3080, 6162, 9267, 12372, 15437, 18420, 21268, 23929, 26372, 28510, 30291, 31644, 32490, 32767, 32409, 31347, 29525, 26897, 23462, 19153, 13986, 7944, 1193, -5628, -11324, -15912, -19653, -22667, -25090, -26999, -28507, -29686, -30592, -31279, -31790, -32162, -32425, -32600, -32708, -32759, -32767, -32743, -32688, -32607, -32505, -32382, -32234, -32062, -31864, -31636, -31374, -31075, -30731, -30337, -29890, -29385, -28815, -28170, -27457, -26665, -25789, -24841, -23808, -22692, -21504, -20243, -18915, -17538, -16097, -14618, -13113, -11582, -10051, -8526, -7009, -5520, -4074, -2675, -1348, -85, 1101, 2200, 3198, 4103, 4903, 5591, 6168, 6629, 6975, 7207, 7323, 7325, 7212, 6990, 6662, 6231, 5702, 5077, 4367, 3584, 2722, 1798, 824, -199, -1249, -2323, -3415, -4507, -5589, -6656, -7685, -8680, -9632, -10526, -11357, -12120, -12810, -13423, -13956, -14406, -14770, -15049, -15242, -15345, -15364, -15299, -15152, -14925, -14619, -14241, -13793, -13278, -12707, -12078, -11405, -10688, -9943, -9172, -8380, -7582, -6786, -5995, -5228, -4480, -3765, -3089, -2459, -1881, -1362, -903, -506, -178, 80, 269, 392, 448, 436, 359, 226, 38, -200, -484, -805, -1154, -1526, -1911, -2303, -2691, -3064, -3414, -3732, -4011, -4237, -4405, -4503, -4525, -4463, -4307, -4052, -3691, -3218, -2637, -1934, -1028, -205};