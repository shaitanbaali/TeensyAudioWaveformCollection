/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0121 256 samples */
 
const int16_t AKWF_fmsynth_0121_256_DATA [256] = 
{1626, 5659, 9361, 12714, 15615, 18024, 19931, 21338, 22277, 22775, 22859, 22547, 21851, 20784, 19358, 17607, 15584, 13350, 11000, 8643, 6378, 4319, 2568, 1205, 301, -93, 52, 759, 2030, 3846, 6158, 8897, 11964, 15216, 18507, 21687, 24587, 27099, 29141, 30675, 31730, 32368, 32677, 32768, 32740, 32679, 32639, 32641, 32682, 32725, 32715, 32596, 32310, 31826, 31132, 30243, 29216, 28123, 27052, 26104, 25366, 24913, 24798, 25046, 25645, 26556, 27702, 28974, 30238, 31349, 32160, 32550, 32427, 31759, 30574, 28950, 27017, 24941, 22884, 21007, 19444, 18288, 17608, 17427, 17734, 18491, 19625, 21053, 22664, 24338, 25976, 27474, 28763, 29810, 30605, 31168, 31535, 31743, 31829, 31808, 31672, 31385, 30884, 30087, 28904, 27248, 25067, 22334, 19092, 15451, 11544, 7572, 3742, 227, -2900, -5615, -7838, -9502, -10591, -11110, -11071, -10499, -9422, -7893, -5975, -3748, -1334, 1174, 3734, 6224, 8523, 10534, 12164, 13366, 14096, 14323, 14028, 13185, 11786, 9818, 7299, 4295, 903, -2785, -6744, -10828, -14811, -18501, -21769, -24518, -26715, -28396, -29612, -30441, -30963, -31244, -31328, -31236, -30962, -30488, -29780, -28817, -27580, -26081, -24368, -22505, -20590, -18742, -17074, -15696, -14710, -14185, -14173, -14692, -15741, -17277, -19217, -21460, -23850, -26219, -28401, -30231, -31591, -32417, -32696, -32482, -31871, -30996, -29998, -29011, -28162, -27540, -27203, -27176, -27446, -27976, -28697, -29527, -30379, -31160, -31802, -32257, -32503, -32558, -32458, -32270, -32059, -31892, -31817, -31857, -32004, -32212, -32403, -32476, -32317, -31809, -30861, -29419, -27467, -25057, -22286, -19274, -16192, -13193, -10413, -7995, -6020, -4556, -3643, -3286, -3476, -4186, -5370, -6956, -8859, -10990, -13233, -15473, -17620, -19578, -21278, -22678, -23750, -24484, -24882, -24932, -24623, -23930, -22820, -21258, -19205, -16655, -13627, -10168, -6386, -2313};