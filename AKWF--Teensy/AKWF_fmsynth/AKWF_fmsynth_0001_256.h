/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0001 256 samples */
 
const int16_t AKWF_fmsynth_0001_256_DATA [256] = 
{1230, 4366, 7486, 10620, 13718, 16737, 19618, 22283, 24682, 26761, 28482, 29841, 30854, 31559, 32014, 32281, 32419, 32480, 32491, 32467, 32401, 32270, 32050, 31713, 31241, 30624, 29867, 28987, 28016, 26986, 25943, 24929, 23985, 23155, 22474, 21972, 21676, 21607, 21778, 22196, 22865, 23777, 24903, 26214, 27651, 29123, 30512, 31649, 32309, 32208, 30997, 28274, 23567, 16453, 6292, -6120, -16176, -23091, -27725, -30564, -32091, -32704, -32714, -32364, -31837, -31265, -30740, -30321, -30047, -29933, -29979, -30174, -30493, -30903, -31362, -31822, -32229, -32532, -32685, -32648, -32401, -31941, -31297, -30516, -29674, -28863, -28186, -27730, -27569, -27741, -28238, -29006, -29942, -30919, -31780, -32372, -32563, -32255, -31395, -29977, -28048, -25675, -22957, -20007, -16912, -13764, -10641, -7582, -4628, -1817, 843, 3326, 5608, 7677, 9512, 11089, 12403, 13445, 14209, 14702, 14928, 14897, 14624, 14127, 13426, 12546, 11515, 10361, 9116, 7815, 6492, 5176, 3907, 2712, 1621, 669, -120, -724, -1117, -1279, -1196, -856, -249, 629, 1776, 3195, 4876, 6804, 8979, 11376, 13965, 16720, 19576, 22454, 25259, 27838, 30029, 31648, 32499, 32404, 31220, 28880, 25391, 20853, 15497, 9613, 3533, -2151, -6472, -9406, -11237, -12136, -12201, -11479, -9975, -7659, -4491, -366, 4306, 8857, 13110, 16919, 20203, 22955, 25173, 26901, 28206, 29145, 29781, 30168, 30341, 30307, 30054, 29534, 28652, 27266, 25185, 22125, 17724, 11583, 2931, -7330, -16106, -22910, -27808, -30895, -32406, -32604, -31777, -30204, -28139, -25798, -23341, -20904, -18581, -16428, -14495, -12812, -11386, -10235, -9360, -8759, -8426, -8354, -8527, -8932, -9549, -10356, -11324, -12428, -13640, -14918, -16234, -17550, -18828, -20036, -21138, -22102, -22910, -23541, -23977, -24205, -24215, -23995, -23527, -22802, -21809, -20534, -18979, -17153, -15065, -12746, -10224, -7532, -4709, -1709};