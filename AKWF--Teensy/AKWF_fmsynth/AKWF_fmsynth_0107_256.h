/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0107 256 samples */
 
const int16_t AKWF_fmsynth_0107_256_DATA [256] = 
{956, 3319, 5581, 7798, 9936, 11992, 13955, 15798, 17541, 19174, 20683, 22077, 23353, 24503, 25553, 26493, 27328, 28065, 28717, 29283, 29776, 30200, 30562, 30872, 31132, 31352, 31536, 31687, 31812, 31913, 31997, 32066, 32120, 32163, 32197, 32226, 32250, 32270, 32287, 32307, 32326, 32347, 32371, 32399, 32432, 32469, 32509, 32552, 32599, 32644, 32685, 32719, 32741, 32743, 32718, 32658, 32553, 32386, 32147, 31818, 31382, 30817, 30105, 29216, 28123, 26804, 25222, 23355, 21155, 18593, 15623, 12248, 8381, 3989, -903, -5732, -10119, -14059, -17612, -20740, -23447, -25761, -27680, -29230, -30442, -31328, -31914, -32224, -32289, -32133, -31782, -31263, -30600, -29819, -28943, -27991, -26980, -25936, -24871, -23806, -22743, -21702, -20688, -19713, -18785, -17908, -17082, -16313, -15601, -14953, -14366, -13833, -13357, -12935, -12565, -12243, -11964, -11722, -11515, -11336, -11182, -11045, -10921, -10802, -10684, -10560, -10425, -10275, -10099, -9894, -9657, -9379, -9056, -8682, -8252, -7762, -7210, -6584, -5888, -5114, -4259, -3323, -2307, -1200, -13, 1264, 2625, 4057, 5565, 7153, 8798, 10500, 12249, 14014, 15812, 17613, 19399, 21162, 22870, 24502, 26059, 27500, 28810, 29969, 30948, 31737, 32315, 32664, 32767, 32611, 32191, 31492, 30512, 29253, 27725, 25917, 23853, 21537, 18993, 16253, 13329, 10236, 7025, 3707, 317, -2882, -5739, -8263, -10486, -12449, -14165, -15659, -16976, -18117, -19107, -19966, -20699, -21330, -21873, -22331, -22722, -23049, -23323, -23555, -23749, -23913, -24055, -24179, -24293, -24406, -24520, -24641, -24776, -24930, -25108, -25312, -25550, -25820, -26122, -26460, -26835, -27243, -27679, -28139, -28614, -29102, -29588, -30064, -30515, -30932, -31303, -31609, -31839, -31979, -32012, -31928, -31716, -31365, -30864, -30211, -29401, -28424, -27282, -25982, -24525, -22926, -21179, -19300, -17301, -15201, -13017, -10763, -8448, -6096, -3731, -1315};