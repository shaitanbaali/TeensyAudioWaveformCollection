/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0022 256 samples */
 
const int16_t AKWF_fmsynth_0022_256_DATA [256] = 
{183, 755, 1320, 1871, 2452, 3020, 3578, 4227, 4868, 5386, 5900, 6456, 7004, 7569, 8155, 8750, 9364, 9999, 10652, 11329, 12028, 12752, 13501, 14279, 15081, 15912, 16773, 17658, 18574, 19516, 20478, 21463, 22465, 23476, 24499, 25517, 26525, 27517, 28470, 29381, 30230, 30990, 31655, 32185, 32557, 32753, 32711, 32419, 31828, 30867, 29526, 27721, 25379, 22483, 18908, 14601, 9488, 3535, -2463, -7542, -11758, -15352, -18224, -20494, -22254, -23486, -24304, -24741, -24821, -24632, -24181, -23515, -22689, -21705, -20616, -19446, -18198, -16923, -15618, -14298, -12997, -11699, -10426, -9192, -7980, -6812, -5687, -4592, -3546, -2533, -1552, -610, 308, 1203, 2073, 2929, 3772, 4605, 5437, 6264, 7096, 7933, 8778, 9635, 10501, 11382, 12277, 13184, 14108, 15043, 15991, 16952, 17916, 18889, 19868, 20841, 21815, 22780, 23728, 24663, 25575, 26458, 27310, 28120, 28884, 29599, 30252, 30843, 31362, 31800, 32154, 32414, 32573, 32626, 32562, 32375, 32059, 31606, 31010, 30260, 29351, 28283, 27040, 25618, 24018, 22229, 20239, 18058, 15674, 13072, 10278, 7268, 4025, 796, -2152, -4823, -7268, -9469, -11461, -13262, -14869, -16317, -17606, -18748, -19766, -20656, -21437, -22121, -22702, -23205, -23631, -23981, -24274, -24507, -24685, -24822, -24910, -24964, -24986, -24973, -24939, -24880, -24796, -24699, -24583, -24453, -24315, -24161, -24003, -23835, -23658, -23481, -23292, -23102, -22913, -22714, -22516, -22317, -22111, -21908, -21701, -21489, -21280, -21063, -20846, -20630, -20402, -20179, -19950, -19712, -19477, -19232, -18982, -18732, -18467, -18199, -17928, -17642, -17354, -17056, -16747, -16434, -16106, -15769, -15425, -15066, -14702, -14326, -13935, -13540, -13128, -12707, -12280, -11835, -11384, -10924, -10450, -9975, -9484, -8983, -8484, -7969, -7451, -6931, -6395, -5863, -5326, -4781, -4242, -3692, -3140, -2594, -2036, -1485, -935, -361};