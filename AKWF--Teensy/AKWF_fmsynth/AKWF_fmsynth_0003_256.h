/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0003 256 samples */
 
const int16_t AKWF_fmsynth_0003_256_DATA [256] = 
{3201, 7939, 11892, 15122, 17686, 19656, 21118, 22142, 22807, 23163, 23240, 23046, 22567, 21762, 20571, 18918, 16732, 13917, 10417, 6209, 1290, -4243, -10200, -16329, -22201, -27301, -31033, -32722, -31757, -27683, -20435, -10603, 410, 11578, 20983, 26446, 26691, 21411, 11323, -1811, -15497, -26713, -32467, -30579, -20564, -5167, 11179, 23586, 27203, 20895, 6761, -10668, -25675, -32689, -28189, -13083, 6284, 22201, 27239, 19409, 2380, -16876, -30319, -31616, -19073, 1247, 19832, 27361, 20344, 2783, -17275, -30782, -31016, -16948, 4052, 21837, 27201, 18120, -365, -19826, -31647, -30087, -15289, 5178, 22066, 27245, 19177, 2208, -16542, -29759, -32186, -22425, -4873, 13302, 25262, 26510, 17684, 2520, -13980, -26928, -32633, -29491, -18436, -3438, 11438, 22613, 27236, 25052, 17342, 6197, -6131, -17528, -26323, -31493, -32591, -29794, -23781, -15624, -6701, 1911, 9906, 16618, 21670, 25013, 26806, 27323, 26856, 25699, 24125, 22361, 20594, 18962, 17581, 16524, 15841, 15564, 15706, 16258, 17199, 18488, 20052, 21788, 23574, 25224, 26522, 27207, 26984, 25549, 22604, 17956, 11587, 3754, -4814, -13813, -22351, -28953, -32455, -32063, -27489, -19061, -7764, 4730, 16291, 24529, 27199, 22861, 11667, -3434, -18771, -29867, -32628, -26168, -12367, 4650, 19570, 27038, 23428, 9063, -10145, -26691, -32844, -25916, -9171, 10442, 24525, 26185, 13394, -7607, -26313, -32801, -23831, -4490, 15784, 26893, 22211, 3526, -18642, -32022, -28894, -11921, 9744, 25000, 25303, 9617, -12981, -29885, -31403, -17660, 3498, 21501, 27157, 16793, -3997, -23985, -32821, -26414, -9058, 10938, 24779, 26158, 13983, -5599, -23744, -32588, -28830, -15203, 2664, 18421, 26746, 24819, 13223, -3306, -19335, -30154, -32573, -26976, -15635, -1725, 11622, 21729, 26822, 26225, 20325, 10540, -806, -11870, -21543, -28446, -32077, -32599, -30515, -26485, -21180, -15173, -9194, -2247};