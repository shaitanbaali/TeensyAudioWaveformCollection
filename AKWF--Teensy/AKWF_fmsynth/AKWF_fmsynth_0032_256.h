/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0032 256 samples */
 
const int16_t AKWF_fmsynth_0032_256_DATA [256] = 
{2808, 11684, 19526, 25802, 30143, 32386, 32671, 31309, 28733, 25357, 21637, 17930, 14537, 11697, 9539, 8149, 7600, 7906, 9075, 11049, 13790, 17159, 20935, 24834, 28433, 31224, 32689, 32244, 29443, 24025, 16205, 6527, -3926, -14123, -22838, -29056, -32275, -32546, -30174, -25763, -19976, -13546, -7044, -896, 4554, 9120, 12765, 15475, 17339, 18402, 18711, 18284, 17120, 15172, 12396, 8752, 4270, -951, -6814, -12975, -19050, -24581, -29008, -31875, -32770, -31443, -27871, -22292, -15240, -7303, 671, 8164, 14832, 20295, 24484, 27523, 29573, 30858, 31604, 31984, 32120, 32068, 31800, 31216, 30152, 28377, 25630, 21649, 16270, 9483, 1617, -6948, -15592, -23319, -29129, -32312, -32472, -29606, -24017, -16393, -7544, 3916, 13095, 20170, 25874, 29755, 31964, 32757, 32476, 31507, 30215, 28937, 27904, 27287, 27184, 27599, 28461, 29646, 30942, 32075, 32726, 32561, 31283, 28631, 24493, 18875, 11996, 4247, -3912, -11929, -19191, -25204, -29565, -32080, -32768, -31790, -29468, -26212, -22485, -18703, -15183, -12230, -10011, -8644, -8186, -8655, -10050, -12319, -15372, -19008, -22920, -26776, -30043, -32198, -32730, -31262, -27550, -21610, -13768, -4631, 5051, 14400, 22483, 28540, 32010, 32692, 30682, 26387, 20430, 13553, 6559, 64, -5682, -10478, -14253, -17016, -18838, -19827, -20035, -19482, -18139, -15951, -12864, -8793, -3812, 1938, 8345, 14970, 21289, 26698, 30603, 32583, 32409, 30089, 25802, 19944, 13046, 5641, -1691, -8527, -14580, -19623, -23591, -26557, -28638, -30018, -30857, -31303, -31451, -31338, -30931, -30135, -28790, -26708, -23708, -19574, -14252, -7780, -324, 7636, 15606, 22873, 28598, 32045, 32629, 30080, 24458, 16295, 6619, -3352, -12704, -20610, -26548, -30389, -32331, -32758, -32126, -30853, -29329, -27868, -26704, -25984, -25796, -26153, -27013, -28265, -29735, -31181, -32318, -32776, -32190, -30205, -26573, -21183, -14134, -5709};