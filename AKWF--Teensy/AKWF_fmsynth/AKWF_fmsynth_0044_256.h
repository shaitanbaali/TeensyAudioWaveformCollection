/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0044 256 samples */
 
const int16_t AKWF_fmsynth_0044_256_DATA [256] = 
{1006, 4954, 9124, 13096, 16892, 20409, 23579, 26313, 28598, 30394, 31677, 32462, 32764, 32625, 32089, 31218, 30081, 28738, 27275, 25747, 24207, 22722, 21339, 20093, 19026, 18150, 17484, 17045, 16835, 16856, 17103, 17565, 18233, 19084, 20101, 21250, 22509, 23843, 25210, 26569, 27877, 29098, 30193, 31128, 31873, 32400, 32699, 32763, 32589, 32187, 31577, 30780, 29822, 28736, 27563, 26336, 25103, 23884, 22722, 21649, 20693, 19882, 19234, 18765, 18490, 18420, 18556, 18901, 19453, 20198, 21130, 22220, 23441, 24764, 26147, 27545, 28903, 30152, 31228, 32071, 32606, 32767, 32490, 31729, 30444, 28608, 26229, 23317, 19929, 16172, 12081, 7808, 3502, -721, -4869, -8934, -12829, -16415, -19645, -22466, -24892, -26915, -28560, -29853, -30836, -31559, -32063, -32397, -32601, -32708, -32757, -32768, -32767, -32765, -32765, -32767, -32768, -32761, -32725, -32639, -32479, -32227, -31846, -31314, -30607, -29698, -28579, -27238, -25655, -23849, -21829, -19609, -17244, -14739, -12148, -9527, -6914, -4363, -1938, 365, 2537, 4580, 6470, 8165, 9655, 10934, 11988, 12809, 13397, 13756, 13870, 13747, 13377, 12758, 11876, 10734, 9321, 7633, 5690, 3507, 1090, -1523, -4389, -7486, -10709, -14029, -17351, -20558, -23567, -26282, -28591, -30462, -31803, -32574, -32757, -32354, -31383, -29872, -27879, -25481, -22738, -19762, -16595, -13333, -10060, -6842, -3739, -803, 1942, 4465, 6734, 8746, 10489, 11974, 13201, 14182, 14915, 15410, 15679, 15724, 15550, 15159, 14556, 13735, 12699, 11456, 10000, 8355, 6516, 4492, 2313, 2, -2421, -4908, -7450, -10002, -12523, -14978, -17328, -19543, -21607, -23495, -25186, -26674, -27952, -29040, -29937, -30661, -31226, -31660, -31977, -32202, -32357, -32454, -32509, -32529, -32518, -32472, -32382, -32234, -32012, -31681, -31217, -30586, -29747, -28666, -27325, -25670, -23686, -21358, -18692, -15688, -12360, -8765, -4881, -876};