/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0055 256 samples */
 
const int16_t AKWF_fmsynth_0055_256_DATA [256] = 
{10434, 21718, 28883, 32246, 32649, 31284, 29294, 27574, 26666, 26829, 28013, 29882, 31781, 32763, 31715, 27541, 19604, 8005, -5813, -19445, -29562, -32726, -26840, -12640, 5084, 21571, 31406, 31852, 23984, 10948, -3647, -16696, -26187, -31400, -32761, -31367, -28489, -25315, -22738, -21317, -21292, -22680, -25241, -28435, -31356, -32767, -31307, -25794, -15814, -2078, 13014, 25961, 32583, 29463, 16145, -2853, -20987, -31716, -30999, -20231, -3750, 13132, 25995, 32289, 31529, 25137, 15570, 5545, -3176, -10193, -15281, -18412, -19836, -19716, -18049, -14658, -9332, -2165, 6574, 16533, 25727, 31703, 32237, 26212, 14066, -1929, -17879, -29395, -32672, -26208, -11665, 5662, 21176, 30718, 32582, 28005, 19305, 8979, -1031, -9551, -16018, -20511, -23282, -24614, -24724, -23611, -21103, -16873, -10616, -2261, 7740, 18355, 27492, 32512, 30701, 20655, 4191, -14067, -28346, -32734, -25767, -10408, 8237, 24031, 32218, 30693, 20536, 5855, -8901, -21108, -28911, -32341, -32571, -30990, -28813, -26920, -25851, -25859, -26928, -28816, -30977, -32555, -32378, -29179, -21842, -10231, 3892, 18364, 29297, 32749, 27430, 14509, -2490, -18716, -29835, -32625, -26448, -13481, 1669, 15546, 25969, 31470, 32743, 31143, 28135, 24867, 22182, 20604, 20382, 21547, 23917, 27104, 30352, 32527, 32153, 27746, 18235, 4389, -11288, -25320, -32511, -29890, -17889, -19, 18014, 30189, 32243, 23134, 6546, -11269, -25444, -32251, -31580, -25438, -16406, -6733, 2011, 9026, 14102, 17352, 18952, 19049, 17658, 14683, 9907, 3257, -5138, -14521, -23627, -30496, -32735, -28340, -16706, -535, 16342, 28975, 32734, 26810, 13541, -3040, -18461, -29040, -32791, -29723, -21573, -10855, -357, 8673, 15827, 20797, 23857, 25395, 25671, 24739, 22409, 18332, 12071, 3691, -6422, -17577, -27264, -32465, -30897, -21752, -6488, 11162, 25899, 32728, 28281, 13430, -5868, -23027, -32064, -30942, -21762, -6945};