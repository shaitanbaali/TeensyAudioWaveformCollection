/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0098 256 samples */
 
const int16_t AKWF_fmsynth_0098_256_DATA [256] = 
{495, 1483, 2691, 4105, 5683, 7390, 9166, 10965, 12725, 14387, 15900, 17232, 18374, 19339, 20151, 20855, 21499, 22137, 22828, 23609, 24509, 25537, 26669, 27870, 29082, 30215, 31193, 31948, 32445, 32704, 32770, 32720, 32637, 32579, 32573, 32610, 32670, 32723, 32758, 32768, 32767, 32767, 32766, 32733, 32618, 32337, 31781, 30841, 29424, 27496, 25053, 22203, 19088, 15901, 12821, 9947, 7290, 4791, 2262, -535, -3633, -7103, -10947, -15066, -19257, -23213, -26657, -29411, -31320, -32404, -32765, -32584, -32049, -31349, -30630, -30000, -29515, -29201, -29039, -29001, -29039, -29103, -29139, -29110, -28974, -28703, -28277, -27685, -26942, -26056, -25068, -24036, -23015, -22061, -21229, -20543, -20023, -19669, -19458, -19351, -19298, -19240, -19108, -18847, -18395, -17710, -16769, -15559, -14107, -12462, -10652, -8761, -6859, -4995, -3234, -1607, -138, 1144, 2226, 3120, 3832, 4404, 4871, 5279, 5682, 6126, 6655, 7301, 8087, 9014, 10075, 11239, 12478, 13736, 14958, 16078, 17043, 17809, 18355, 18666, 18757, 18656, 18411, 18082, 17738, 17446, 17274, 17283, 17521, 18018, 18787, 19826, 21091, 22551, 24127, 25731, 27271, 28664, 29851, 30806, 31525, 32033, 32372, 32585, 32711, 32765, 32755, 32663, 32448, 32027, 31287, 30065, 28162, 25374, 21524, 16448, 10211, 2901, -4470, -10152, -14189, -16957, -18672, -19566, -19809, -19558, -18953, -18162, -17373, -16788, -16599, -16952, -17904, -19413, -21342, -23491, -25620, -27570, -29211, -30481, -31394, -31999, -32373, -32584, -32695, -32746, -32766, -32768, -32756, -32715, -32626, -32448, -32120, -31574, -30745, -29584, -28091, -26322, -24331, -22241, -20167, -18202, -16435, -14915, -13649, -12653, -11906, -11376, -11017, -10777, -10594, -10412, -10180, -9851, -9400, -8804, -8071, -7222, -6281, -5301, -4322, -3384, -2540, -1824, -1261, -871, -645, -576, -631, -768, -933, -1074, -1129, -1045, -785, -269};