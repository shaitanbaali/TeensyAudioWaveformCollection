/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0025 256 samples */
 
const int16_t AKWF_fmsynth_0025_256_DATA [256] = 
{7057, 15346, 21194, 25428, 28406, 30429, 31725, 32454, 32736, 32646, 32237, 31535, 30566, 29355, 27921, 26298, 24535, 22666, 20748, 18838, 16966, 15184, 13526, 12006, 10650, 9465, 8439, 7573, 6849, 6243, 5737, 5300, 4904, 4532, 4157, 3764, 3348, 2903, 2436, 1961, 1492, 1054, 674, 377, 191, 137, 238, 507, 949, 1568, 2354, 3291, 4367, 5553, 6822, 8153, 9515, 10885, 12248, 13590, 14898, 16182, 17442, 18692, 19953, 21239, 22566, 23952, 25395, 26881, 28377, 29813, 31090, 32065, 32533, 32246, 30902, 28165, 23648, 17017, 7784, -3735, -13611, -20673, -25645, -28893, -30770, -31559, -31464, -30648, -29221, -27281, -24903, -22149, -19098, -15809, -12340, -8758, -5093, -1369, 2378, 6159, 9954, 13717, 17413, 20968, 24270, 27215, 29666, 31460, 32420, 32316, 30864, 27671, 22251, 13984, 1794, -11293, -20701, -26889, -30357, -31591, -31089, -29312, -26670, -23497, -20071, -16572, -13114, -9778, -6584, -3530, -614, 2195, 4930, 7608, 10265, 12923, 15586, 18266, 20944, 23567, 26081, 28375, 30309, 31733, 32454, 32296, 31093, 28731, 25162, 20382, 14502, 7648, -13, -7007, -12421, -16705, -20107, -22844, -25076, -26897, -28380, -29567, -30473, -31112, -31495, -31635, -31555, -31289, -30878, -30372, -29820, -29276, -28778, -28359, -28047, -27853, -27776, -27809, -27937, -28143, -28398, -28683, -28976, -29259, -29524, -29760, -29971, -30156, -30323, -30480, -30634, -30790, -30954, -31122, -31277, -31395, -31431, -31323, -30978, -30282, -29101, -27276, -24639, -21038, -16307, -10338, -3016, 5021, 12028, 17589, 22004, 25440, 28064, 30023, 31410, 32297, 32724, 32709, 32263, 31385, 30089, 28393, 26330, 23960, 21348, 18558, 15676, 12750, 9833, 6973, 4181, 1471, -1140, -3673, -6129, -8513, -10849, -13152, -15429, -17705, -19975, -22225, -24435, -26537, -28439, -30011, -31068, -31387, -30710, -28760, -25264, -19985, -12775, -3172};