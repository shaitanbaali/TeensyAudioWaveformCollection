/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0049 256 samples */
 
const int16_t AKWF_fmsynth_0049_256_DATA [256] = 
{304, 1886, 3692, 5503, 7311, 9052, 10693, 12172, 13464, 14549, 15407, 16053, 16491, 16735, 16808, 16746, 16581, 16347, 16098, 15877, 15728, 15690, 15802, 16090, 16572, 17248, 18112, 19134, 20292, 21543, 22833, 24113, 25338, 26465, 27476, 28347, 29066, 29640, 30083, 30406, 30626, 30755, 30809, 30803, 30750, 30665, 30560, 30460, 30381, 30344, 30368, 30460, 30632, 30877, 31182, 31526, 31880, 32211, 32487, 32678, 32765, 32741, 32614, 32396, 32117, 31807, 31498, 31221, 30998, 30841, 30760, 30743, 30780, 30857, 30953, 31048, 31128, 31174, 31176, 31120, 30993, 30782, 30468, 30034, 29461, 28744, 27873, 26847, 25687, 24424, 23092, 21755, 20451, 19238, 18166, 17266, 16566, 16074, 15781, 15676, 15726, 15895, 16132, 16397, 16636, 16809, 16865, 16774, 16502, 16020, 15316, 14381, 13213, 11830, 10243, 8506, 6659, 4763, 2893, 1102, -560, -2072, -3407, -4522, -5395, -6035, -6438, -6628, -6634, -6494, -6257, -5970, -5685, -5459, -5341, -5377, -5600, -6042, -6720, -7635, -8780, -10132, -11657, -13305, -15014, -16722, -18386, -19938, -21349, -22586, -23627, -24474, -25133, -25609, -25925, -26093, -26139, -26083, -25953, -25779, -25590, -25425, -25320, -25300, -25396, -25628, -26006, -26514, -27143, -27872, -28651, -29443, -30205, -30889, -31483, -31959, -32312, -32551, -32689, -32755, -32769, -32757, -32735, -32716, -32708, -32710, -32719, -32735, -32746, -32756, -32763, -32765, -32761, -32753, -32734, -32691, -32609, -32465, -32240, -31914, -31474, -30911, -30234, -29461, -28622, -27762, -26908, -26113, -25414, -24833, -24397, -24107, -23959, -23939, -24019, -24171, -24360, -24547, -24701, -24791, -24784, -24657, -24390, -23965, -23361, -22574, -21597, -20440, -19112, -17639, -16056, -14414, -12768, -11168, -9661, -8302, -7126, -6167, -5436, -4928, -4641, -4545, -4609, -4795, -5053, -5335, -5589, -5762, -5809, -5696, -5383, -4851, -4084, -3093, -1856, -417};