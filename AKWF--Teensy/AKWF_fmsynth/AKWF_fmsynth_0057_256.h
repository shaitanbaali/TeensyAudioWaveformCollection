/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0057 256 samples */
 
const int16_t AKWF_fmsynth_0057_256_DATA [256] = 
{4737, 13306, 19677, 24476, 27621, 29480, 30407, 30664, 30349, 29367, 27484, 24391, 19844, 13860, 6557, -1520, -9645, -17103, -23255, -27739, -30625, -32124, -32683, -32765, -32729, -32744, -32756, -32480, -31440, -29074, -24940, -18746, -10655, -1295, 8417, 17359, 24598, 29589, 32191, 32749, 31927, 30487, 29095, 28246, 28196, 28946, 30258, 31693, 32660, 32521, 30753, 27103, 21609, 14729, 7154, -395, -7186, -12825, -17115, -20018, -21634, -22066, -21335, -19352, -15961, -11038, -4569, 3135, 11500, 19653, 26505, 31074, 32767, 31523, 27815, 22525, 16717, 11354, 7108, 4354, 3228, 3769, 5930, 9571, 14362, 19817, 25144, 29520, 32180, 32693, 31010, 27493, 22776, 17607, 12705, 8642, 5740, 4253, 4276, 5838, 8856, 13138, 18336, 23785, 28645, 31906, 32698, 30416, 25046, 17229, 8174, -745, -8634, -14983, -19544, -22447, -23957, -24284, -23477, -21447, -18017, -13046, -6546, 1124, 9402, 17489, 24328, 29211, 31972, 32770, 32127, 30700, 29128, 27928, 27424, 27768, 28877, 30462, 31990, 32764, 31963, 28846, 22960, 14475, 4372, -6119, -15729, -23341, -28508, -31394, -32576, -32750, -32511, -32299, -32326, -32564, -32765, -32493, -31197, -28363, -23580, -16848, -8615, 219, 8740, 16225, 22147, 26294, 28920, 30392, 31062, 31168, 30746, 29616, 27408, 23663, 18009, 10255, 958, -9041, -18595, -26196, -30977, -32751, -31893, -29209, -25627, -22023, -19011, -17046, -16363, -17017, -18903, -21785, -25250, -28709, -31443, -32740, -32040, -29094, -24071, -17568, -10477, -3730, 1979, 6380, 9275, 10582, 10298, 8396, 4840, -284, -6844, -14305, -21733, -27948, -31825, -32695, -30467, -25664, -19118, -11876, -4905, 1122, 5795, 8964, 10631, 10817, 9541, 6813, 2700, -2686, -9014, -15746, -22155, -27489, -31118, -32703, -32256, -30177, -27129, -23873, -21048, -19188, -18595, -19373, -21415, -24420, -27835, -30865, -32621, -32267, -29323, -23690, -15987, -6612};