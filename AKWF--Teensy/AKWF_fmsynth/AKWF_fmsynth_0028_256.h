/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0028 256 samples */
 
const int16_t AKWF_fmsynth_0028_256_DATA [256] = 
{157, 663, 1163, 1667, 2175, 2687, 3205, 3727, 4257, 4793, 5328, 5883, 6449, 7026, 7619, 8228, 8851, 9496, 10160, 10846, 11556, 12292, 13053, 13845, 14664, 15512, 16392, 17299, 18236, 19201, 20190, 21200, 22232, 23274, 24322, 25371, 26407, 27423, 28405, 29336, 30201, 30981, 31651, 32190, 32568, 32754, 32715, 32411, 31805, 30845, 29483, 27674, 25345, 22441, 18901, 14638, 9575, 3698, -1964, -6751, -10789, -14147, -16867, -19013, -20646, -21811, -22564, -22951, -23018, -22807, -22358, -21708, -20887, -19930, -18865, -17713, -16499, -15246, -13964, -12673, -11388, -10112, -8858, -7634, -6441, -5283, -4163, -3081, -2034, -1026, -46, 902, 1826, 2730, 3616, 4491, 5359, 6225, 7091, 7967, 8849, 9744, 10659, 11587, 12535, 13505, 14492, 15499, 16526, 17563, 18616, 19678, 20741, 21806, 22863, 23904, 24930, 25926, 26884, 27801, 28666, 29469, 30202, 30857, 31421, 31890, 32251, 32496, 32618, 32606, 32454, 32153, 31697, 31079, 30288, 29328, 28186, 26857, 25345, 23638, 21736, 19644, 17350, 14857, 12175, 9291, 6202, 3013, 44, -2633, -5052, -7241, -9213, -10983, -12577, -14002, -15275, -16411, -17420, -18312, -19100, -19792, -20397, -20923, -21377, -21765, -22093, -22368, -22595, -22778, -22921, -23027, -23102, -23148, -23168, -23164, -23139, -23095, -23034, -22958, -22869, -22768, -22655, -22533, -22402, -22263, -22118, -21965, -21808, -21645, -21478, -21306, -21130, -20951, -20767, -20581, -20391, -20199, -20003, -19805, -19602, -19397, -19189, -18978, -18762, -18544, -18322, -18095, -17866, -17631, -17392, -17149, -16901, -16648, -16390, -16125, -15856, -15581, -15299, -15012, -14719, -14418, -14111, -13797, -13476, -13148, -12812, -12470, -12121, -11764, -11399, -11028, -10649, -10262, -9870, -9470, -9062, -8649, -8228, -7801, -7370, -6931, -6487, -6039, -5584, -5125, -4663, -4196, -3723, -3250, -2772, -2290, -1807, -1320, -832, -331};