/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0071 256 samples */
 
const int16_t AKWF_fmsynth_0071_256_DATA [256] = 
{1687, 4649, 7870, 11307, 14833, 18376, 21770, 24865, 27537, 29657, 31140, 31953, 32087, 31596, 30571, 29120, 27386, 25497, 23583, 21775, 20132, 18732, 17617, 16806, 16301, 16088, 16138, 16428, 16919, 17588, 18398, 19336, 20373, 21481, 22631, 23784, 24875, 25860, 26651, 27160, 27296, 26977, 26123, 24683, 22641, 20030, 16906, 13410, 9649, 5796, 1887, -2014, -5776, -9305, -12539, -15440, -17979, -20142, -21932, -23360, -24421, -25122, -25471, -25490, -25201, -24636, -23841, -22861, -21772, -20612, -19460, -18380, -17422, -16642, -16069, -15722, -15610, -15717, -16018, -16466, -17015, -17610, -18198, -18738, -19201, -19574, -19864, -20082, -20256, -20410, -20574, -20770, -21012, -21303, -21636, -21993, -22349, -22677, -22937, -23095, -23114, -22965, -22617, -22050, -21247, -20197, -18909, -17380, -15612, -13639, -11465, -9118, -6652, -4061, -1404, 1265, 3904, 6453, 8863, 11080, 13048, 14726, 16081, 17113, 17809, 18187, 18273, 18109, 17743, 17228, 16615, 15962, 15325, 14756, 14294, 13985, 13864, 13960, 14291, 14871, 15709, 16790, 18101, 19611, 21265, 23032, 24835, 26596, 28246, 29696, 30868, 31710, 32157, 32174, 31749, 30898, 29648, 28045, 26164, 24078, 21861, 19614, 17374, 15219, 13208, 11396, 9783, 8411, 7282, 6401, 5762, 5346, 5127, 5081, 5172, 5363, 5606, 5858, 6067, 6178, 6137, 5900, 5427, 4683, 3672, 2413, 843, -1013, -3095, -5324, -7595, -9833, -11985, -13988, -15860, -17594, -19200, -20714, -22158, -23556, -24926, -26264, -27549, -28766, -29873, -30847, -31648, -32248, -32625, -32770, -32696, -32414, -31949, -31337, -30616, -29816, -28955, -28050, -27091, -26065, -24932, -23645, -22163, -20442, -18451, -16210, -13712, -11030, -8259, -5490, -2851, -444, 1647, 3341, 4587, 5374, 5705, 5614, 5135, 4325, 3246, 1966, 548, -937, -2422, -3829, -5085, -6117, -6873, -7289, -7319, -6932, -6111, -4846, -3146, -916};