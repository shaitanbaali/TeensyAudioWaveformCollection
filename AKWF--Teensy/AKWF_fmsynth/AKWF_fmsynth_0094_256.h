/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0094 256 samples */
 
const int16_t AKWF_fmsynth_0094_256_DATA [256] = 
{652, 2708, 5254, 7559, 9782, 11944, 14006, 15982, 17863, 19642, 21308, 22862, 24305, 25633, 26844, 27938, 28906, 29766, 30507, 31135, 31655, 32065, 32375, 32593, 32723, 32769, 32740, 32647, 32496, 32295, 32052, 31775, 31476, 31161, 30838, 30514, 30197, 29894, 29611, 29355, 29130, 28937, 28781, 28666, 28592, 28558, 28568, 28620, 28710, 28838, 29002, 29198, 29422, 29667, 29932, 30211, 30500, 30791, 31080, 31363, 31633, 31885, 32114, 32317, 32486, 32618, 32712, 32763, 32765, 32720, 32622, 32472, 32266, 32008, 31694, 31324, 30897, 30419, 29885, 29298, 28662, 27981, 27248, 26473, 25657, 24804, 23917, 22996, 22042, 21064, 20060, 19036, 18001, 16944, 15876, 14801, 13720, 12641, 11567, 10484, 9411, 8347, 7292, 6261, 5237, 4229, 3244, 2280, 1339, 432, -455, -1311, -2135, -2931, -3689, -4413, -5103, -5753, -6365, -6940, -7476, -7968, -8420, -8830, -9194, -9519, -9795, -10030, -10221, -10364, -10457, -10504, -10506, -10459, -10361, -10213, -10014, -9764, -9463, -9106, -8697, -8237, -7717, -7141, -6512, -5821, -5077, -4275, -3409, -2485, -1508, -469, 621, 1772, 2983, 4247, 5562, 6925, 8334, 9791, 11293, 12826, 14389, 15969, 17571, 19180, 20789, 22378, 23933, 25443, 26890, 28247, 29491, 30582, 31505, 32207, 32644, 32763, 32510, 31816, 30598, 28772, 26245, 22884, 18639, 13265, 6554, -1168, -8972, -15464, -20662, -24864, -28077, -30384, -31875, -32631, -32735, -32253, -31256, -29806, -27969, -25797, -23335, -20628, -17720, -14649, -11464, -8160, -4796, -1374, 2067, 5486, 8875, 12217, 15454, 18575, 21526, 24240, 26714, 28860, 30611, 31898, 32630, 32721, 32059, 30531, 28010, 24373, 19509, 13125, 4970, -3913, -12171, -18625, -23539, -27269, -29911, -31616, -32526, -32767, -32433, -31619, -30404, -28868, -27066, -25042, -22854, -20528, -18103, -15629, -13092, -10530, -7979, -5432, -2737, -582};