/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0065 256 samples */
 
const int16_t AKWF_fmsynth_0065_256_DATA [256] = 
{1941, 6954, 11373, 15362, 18898, 21997, 24656, 26897, 28748, 30218, 31327, 32106, 32574, 32764, 32696, 32400, 31907, 31235, 30411, 29461, 28403, 27265, 26070, 24818, 23539, 22245, 20943, 19658, 18385, 17132, 15909, 14722, 13573, 12470, 11401, 10374, 9392, 8449, 7549, 6688, 5859, 5066, 4310, 3585, 2890, 2225, 1586, 974, 389, -168, -700, -1208, -1693, -2150, -2580, -2982, -3357, -3703, -4019, -4303, -4555, -4772, -4958, -5109, -5223, -5301, -5340, -5344, -5309, -5235, -5123, -4972, -4781, -4553, -4285, -3981, -3640, -3259, -2843, -2390, -1900, -1374, -810, -211, 428, 1108, 1830, 2593, 3406, 4270, 5193, 6174, 7218, 8335, 9533, 10811, 12178, 13637, 15175, 16817, 18539, 20334, 22189, 24060, 25918, 27728, 29398, 30856, 31989, 32657, 32698, 31907, 30044, 26808, 21872, 14918, 5175, -6448, -16073, -23077, -27985, -31024, -32510, -32709, -31895, -30298, -28128, -25572, -22783, -19897, -17026, -14209, -11516, -8958, -6535, -4242, -2035, 147, 2334, 4595, 6975, 9486, 12190, 15075, 18100, 21219, 24316, 27225, 29794, 31728, 32714, 32359, 30239, 25804, 18489, 7385, -6648, -17932, -25316, -29907, -32209, -32758, -32004, -30337, -28053, -25388, -22534, -19645, -16806, -14100, -11537, -9137, -6893, -4806, -2812, -896, 974, 2842, 4731, 6652, 8657, 10725, 12863, 15072, 17305, 19555, 21795, 23965, 26018, 27906, 29558, 30936, 31967, 32596, 32761, 32421, 31522, 30023, 27887, 25101, 21636, 17514, 12704, 7238, 1087, -5029, -10190, -14490, -18074, -21042, -23482, -25474, -27085, -28394, -29436, -30266, -30915, -31417, -31799, -32089, -32301, -32454, -32562, -32636, -32686, -32716, -32735, -32745, -32749, -32751, -32747, -32739, -32723, -32698, -32659, -32599, -32512, -32390, -32224, -32003, -31714, -31340, -30867, -30276, -29548, -28654, -27574, -26271, -24715, -22885, -20725, -18187, -15238, -11822, -7887, -3301};