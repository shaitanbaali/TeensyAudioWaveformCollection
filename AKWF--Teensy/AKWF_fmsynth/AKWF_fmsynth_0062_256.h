/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0062 256 samples */
 
const int16_t AKWF_fmsynth_0062_256_DATA [256] = 
{1241, 4361, 7339, 10233, 13015, 15669, 18165, 20471, 22587, 24487, 26183, 27663, 28932, 29993, 30854, 31530, 32040, 32400, 32628, 32743, 32766, 32719, 32623, 32491, 32341, 32189, 32045, 31917, 31814, 31740, 31697, 31684, 31702, 31745, 31810, 31894, 31988, 32090, 32194, 32297, 32392, 32479, 32555, 32619, 32668, 32706, 32733, 32750, 32763, 32767, 32768, 32767, 32767, 32767, 32767, 32763, 32749, 32721, 32672, 32589, 32459, 32264, 31983, 31597, 31069, 30374, 29474, 28322, 26888, 25115, 22935, 20311, 17166, 13427, 9089, 3985, -1825, -7467, -12514, -16995, -20903, -24229, -26973, -29150, -30783, -31912, -32559, -32769, -32576, -32028, -31168, -30036, -28681, -27141, -25458, -23685, -21830, -19945, -18054, -16181, -14359, -12607, -10922, -9338, -7859, -6490, -5252, -4129, -3130, -2261, -1514, -891, -392, -4, 271, 443, 514, 493, 387, 202, -53, -369, -739, -1151, -1600, -2075, -2564, -3060, -3551, -4027, -4483, -4906, -5286, -5616, -5889, -6094, -6224, -6272, -6232, -6095, -5856, -5509, -5048, -4468, -3770, -2939, -1981, -892, 331, 1678, 3155, 4760, 6482, 8307, 10230, 12217, 14276, 16376, 18486, 20580, 22622, 24581, 26430, 28122, 29613, 30865, 31829, 32477, 32759, 32639, 32081, 31060, 29542, 27514, 24953, 21859, 18242, 14126, 9493, 4400, -1099, -6217, -10606, -14397, -17617, -20335, -22622, -24514, -26090, -27383, -28433, -29280, -29956, -30491, -30913, -31240, -31487, -31672, -31807, -31902, -31961, -31990, -31993, -31972, -31927, -31860, -31769, -31657, -31522, -31362, -31182, -30982, -30765, -30535, -30297, -30055, -29817, -29589, -29381, -29200, -29056, -28955, -28904, -28909, -28975, -29105, -29297, -29551, -29858, -30212, -30601, -31007, -31417, -31812, -32167, -32459, -32667, -32765, -32727, -32532, -32160, -31594, -30812, -29811, -28573, -27100, -25404, -23478, -21327, -18982, -16444, -13745, -10934, -8000, -4997, -1892};