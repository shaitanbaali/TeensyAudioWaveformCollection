/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0046 256 samples */
 
const int16_t AKWF_fmsynth_0046_256_DATA [256] = 
{1450, 4429, 6862, 9039, 10869, 12404, 13678, 14734, 15633, 16437, 17202, 18001, 18882, 19881, 21035, 22340, 23790, 25350, 26951, 28510, 29939, 31138, 32042, 32592, 32770, 32599, 32144, 31497, 30757, 30037, 29434, 29019, 28831, 28880, 29151, 29596, 30148, 30748, 31328, 31835, 32236, 32517, 32683, 32756, 32768, 32747, 32719, 32701, 32702, 32715, 32738, 32760, 32768, 32766, 32750, 32729, 32714, 32713, 32728, 32752, 32769, 32754, 32678, 32513, 32238, 31847, 31353, 30787, 30201, 29657, 29218, 28942, 28870, 29029, 29410, 29975, 30668, 31393, 32058, 32545, 32765, 32644, 32143, 31270, 30062, 28603, 26974, 25277, 23609, 22036, 20614, 19359, 18263, 17303, 16434, 15600, 14743, 13788, 12670, 11324, 9705, 7784, 5535, 2976, 163, -2902, -6198, -9591, -12978, -16190, -19121, -21678, -23805, -25505, -26802, -27725, -28319, -28629, -28679, -28491, -28074, -27428, -26558, -25488, -24251, -22887, -21470, -20070, -18763, -17627, -16709, -16047, -15663, -15549, -15681, -16018, -16509, -17088, -17690, -18248, -18709, -19018, -19131, -19012, -18643, -17998, -17074, -15882, -14436, -12784, -11004, -9147, -7323, -5631, -4156, -2997, -2220, -1868, -1995, -2619, -3757, -5377, -7468, -9963, -12744, -15690, -18660, -21484, -24089, -26352, -28226, -29709, -30816, -31601, -32130, -32459, -32645, -32736, -32767, -32760, -32726, -32663, -32571, -32433, -32221, -31904, -31437, -30776, -29866, -28645, -27087, -25173, -22901, -20355, -17575, -14668, -11772, -9004, -6475, -4310, -2543, -1245, -442, -134, -299, -906, -1910, -3233, -4797, -6527, -8305, -10067, -11726, -13214, -14476, -15487, -16228, -16700, -16910, -16882, -16647, -16244, -15720, -15137, -14552, -14033, -13639, -13427, -13441, -13713, -14258, -15067, -16108, -17349, -18719, -20160, -21585, -22931, -24143, -25170, -25974, -26540, -26850, -26897, -26664, -26126, -25255, -24020, -22397, -20369, -17946, -15178, -12136, -8925, -5653, -2328};