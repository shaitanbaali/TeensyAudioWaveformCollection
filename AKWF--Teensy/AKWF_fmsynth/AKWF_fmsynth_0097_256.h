/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0097 256 samples */
 
const int16_t AKWF_fmsynth_0097_256_DATA [256] = 
{491, 1907, 3645, 5677, 7923, 10292, 12693, 15034, 17226, 19205, 20925, 22373, 23572, 24541, 25330, 25986, 26559, 27106, 27670, 28281, 28955, 29684, 30442, 31184, 31845, 32361, 32679, 32769, 32639, 32333, 31931, 31521, 31187, 30986, 30937, 31022, 31198, 31413, 31619, 31781, 31877, 31888, 31796, 31577, 31182, 30553, 29616, 28311, 26609, 24500, 22021, 19289, 16423, 13577, 10905, 8442, 6222, 4185, 2185, 45, -2347, -5067, -8155, -11588, -15263, -18953, -22480, -25635, -28236, -30212, -31564, -32361, -32714, -32757, -32617, -32406, -32197, -32041, -31952, -31923, -31935, -31965, -31987, -31981, -31926, -31806, -31604, -31296, -30868, -30317, -29649, -28898, -28103, -27305, -26570, -25934, -25433, -25076, -24854, -24737, -24682, -24631, -24525, -24304, -23904, -23276, -22370, -21148, -19602, -17730, -15551, -13132, -10563, -7923, -5334, -2888, -558, 1542, 3178, 4534, 5612, 6465, 7155, 7747, 8317, 8941, 9671, 10549, 11606, 12823, 14192, 15669, 17183, 18671, 20069, 21300, 22339, 23149, 23716, 24045, 24155, 24073, 23846, 23529, 23182, 22876, 22687, 22674, 22889, 23362, 24093, 25052, 26186, 27427, 28680, 29855, 30874, 31680, 32255, 32601, 32753, 32752, 32651, 32483, 32268, 32010, 31691, 31274, 30708, 29906, 28779, 27194, 25040, 22186, 18521, 14025, 8787, 2927, -2929, -7708, -11246, -13742, -15350, -16227, -16504, -16315, -15797, -15096, -14384, -13844, -13634, -13888, -14676, -15980, -17711, -19722, -21843, -23905, -25780, -27379, -28666, -29666, -30403, -30933, -31302, -31560, -31748, -31901, -32047, -32207, -32387, -32569, -32719, -32767, -32638, -32249, -31544, -30500, -29123, -27486, -25679, -23805, -21995, -20322, -18861, -17662, -16734, -16057, -15589, -15273, -15036, -14810, -14523, -14115, -13543, -12779, -11816, -10673, -9383, -7990, -6572, -5192, -3925, -2841, -1975, -1358, -996, -868, -932, -1127, -1378, -1596, -1697, -1596, -1235, -518};