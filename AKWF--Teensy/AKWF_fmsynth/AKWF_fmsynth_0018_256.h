/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0018 256 samples */
 
const int16_t AKWF_fmsynth_0018_256_DATA [256] = 
{1266, 4697, 8344, 12346, 16633, 21005, 25138, 28636, 31178, 32546, 32692, 31738, 29925, 27550, 24871, 22082, 19272, 16385, 13267, 9742, 4843, 1412, 4860, 9079, 13370, 17776, 22004, 25722, 28677, 30763, 32008, 32575, 32682, 32547, 32341, 32161, 32046, 31987, 31954, 31909, 31807, 31593, 31184, 30433, 29094, 26784, 22882, 16556, 6266, -7707, -19428, -27150, -31302, -32369, -31124, -28392, -24905, -21229, -17719, -14594, -11932, -9727, -7960, -6589, -5564, -4851, -4405, -4186, -4147, -4238, -4402, -4581, -4715, -4741, -4602, -4244, -3628, -2724, -1508, 32, 1913, 4190, 6931, 10226, 14179, 18761, 23724, 28466, 31860, 32253, 27605, 15334, -5246, -21572, -29176, -32049, -32160, -30858, -28977, -26979, -25102, -23436, -21988, -20734, -19612, -18553, -17491, -16354, -15080, -13626, -11957, -10065, -7968, -5678, -3218, -590, 2274, 5470, 9119, 13338, 18079, 23075, 27781, 31319, 32638, 30685, 24703, 14397, 97, -12619, -20257, -24831, -27472, -28943, -29702, -30010, -30012, -29782, -29366, -28820, -28230, -27715, -27418, -27475, -27962, -28867, -30039, -31213, -32050, -32204, -31423, -29596, -26808, -23292, -19355, -15333, -11483, -7936, -4747, -1873, 763, 3212, 5508, 7646, 9588, 11302, 12761, 13946, 14877, 15581, 16108, 16519, 16885, 17279, 17782, 18469, 19410, 20679, 22321, 24348, 26721, 29247, 31511, 32712, 31447, 25634, 11033, -11527, -26407, -31814, -31427, -27706, -22591, -17340, -12580, -8508, -5112, -2251, 201, 2320, 4164, 5751, 7086, 8196, 9104, 9849, 10492, 11088, 11702, 12405, 13265, 14345, 15713, 17422, 19508, 21983, 24780, 27719, 30451, 32338, 32415, 29311, 21445, 6159, -12634, -24454, -30200, -32183, -31869, -30381, -28452, -26531, -24855, -23539, -22624, -22095, -21914, -22029, -22370, -22865, -23430, -23983, -24442, -24734, -24792, -24550, -23951, -22934, -21461, -19514, -17112, -14338, -11310, -8151, -4976, -1740};