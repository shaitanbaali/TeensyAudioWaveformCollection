/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0030 256 samples */
 
const int16_t AKWF_fmsynth_0030_256_DATA [256] = 
{415, 1688, 2933, 4153, 5345, 6511, 7643, 8729, 9765, 10747, 11662, 12510, 13287, 13981, 14596, 15129, 15576, 15939, 16216, 16407, 16514, 16536, 16471, 16323, 16090, 15772, 15373, 14890, 14328, 13686, 12968, 12178, 11321, 10402, 9426, 8398, 7332, 6226, 5092, 3936, 2757, 1558, 343, -896, -2165, -3470, -4831, -6260, -7770, -9391, -11133, -13008, -15035, -17207, -19507, -21914, -24362, -26764, -29005, -30907, -32248, -32742, -32030, -29668, -25109, -17786, -6660, 6305, 15824, 21973, 25488, 26880, 26655, 25245, 23027, 20300, 17310, 14254, 11249, 8384, 5705, 3199, 852, -1381, -3570, -5773, -8047, -10452, -13011, -15728, -18593, -21534, -24457, -27232, -29664, -31537, -32585, -32501, -30944, -27531, -21899, -13600, -2171, 8759, 16453, 21645, 24843, 26506, 26997, 26621, 25625, 24205, 22518, 20677, 18775, 16879, 15028, 13256, 11584, 10018, 8563, 7220, 5980, 4842, 3797, 2839, 1964, 1164, 433, -227, -823, -1359, -1834, -2250, -2606, -2902, -3137, -3316, -3433, -3490, -3486, -3423, -3298, -3112, -2868, -2560, -2192, -1763, -1271, -715, -93, 597, 1361, 2200, 3125, 4139, 5250, 6468, 7797, 9245, 10820, 12514, 14327, 16241, 18223, 20229, 22189, 23998, 25523, 26576, 26911, 26214, 24083, 20032, 13469, 3422, -9404, -19807, -26664, -30762, -32579, -32586, -31232, -28914, -25984, -22732, -19371, -16077, -12945, -10005, -7256, -4641, -2064, 567, 3362, 6411, 9744, 13347, 17113, 20800, 24048, 26310, 26843, 24673, 18648, 6974, -10100, -23030, -29825, -32545, -32339, -30229, -27001, -23251, -19395, -15671, -12221, -9077, -6176, -3438, -746, 2031, 4978, 8156, 11572, 15143, 18722, 22070, 24837, 26593, 26797, 24829, 19971, 11464, -1777, -15470, -24363, -29600, -32148, -32723, -31923, -30215, -27955, -25410, -22757, -20133, -17624, -15263, -13076, -11067, -9215, -7509, -5906, -4499, -2371, -722};