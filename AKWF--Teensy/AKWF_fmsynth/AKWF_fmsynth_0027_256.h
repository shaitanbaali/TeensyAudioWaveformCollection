/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0027 256 samples */
 
const int16_t AKWF_fmsynth_0027_256_DATA [256] = 
{1188, 2901, 4545, 6159, 7730, 9244, 10691, 12047, 13305, 14450, 15469, 16358, 17114, 17732, 18215, 18562, 18774, 18853, 18799, 18613, 18295, 17843, 17261, 16546, 15702, 14735, 13646, 12452, 11161, 9783, 8339, 6842, 5300, 3731, 2136, 511, -1146, -2862, -4664, -6583, -8667, -10957, -13480, -16264, -19291, -22489, -25734, -28789, -31278, -32677, -32233, -28954, -21597, -7912, 9119, 20410, 26085, 27785, 26661, 23725, 19797, 15479, 11202, 7195, 3522, 142, -3101, -6412, -9969, -13922, -18293, -22907, -27383, -31016, -32742, -31080, -24223, -8936, 10785, 22547, 27214, 27483, 24996, 21064, 16575, 12108, 7967, 4228, 853, -2294, -5406, -8639, -12114, -15888, -19882, -23921, -27701, -30764, -32541, -32338, -29368, -22809, -11432, 3965, 15888, 22860, 26517, 27790, 27426, 26002, 23939, 21544, 19037, 16545, 14165, 11950, 9910, 8058, 6389, 4883, 3531, 2317, 1225, 249, -621, -1395, -2074, -2658, -3152, -3553, -3860, -4074, -4192, -4216, -4141, -3971, -3706, -3343, -2887, -2333, -1681, -933, -80, 884, 1962, 3175, 4534, 6051, 7754, 9655, 11757, 14073, 16570, 19191, 21841, 24335, 26400, 27635, 27458, 25067, 19415, 8879, -7384, -21235, -29005, -32409, -32472, -30211, -26517, -22119, -17575, -13209, -9180, -5475, -1906, 1775, 5827, 10450, 15608, 20919, 25504, 27744, 25253, 13846, -9238, -26818, -32491, -31631, -27182, -21331, -15437, -10111, -5392, -978, 3638, 8886, 14843, 21041, 26126, 27634, 21857, 1821, -22191, -31824, -32126, -27811, -21710, -15527, -10014, -5188, -692, 3984, 9277, 15221, 21286, 26186, 27661, 22610, 5123, -18782, -30484, -32693, -29988, -24973, -19346, -14028, -9328, -5180, -1338, 2551, 6761, 11387, 16339, 21222, 25322, 27642, 26859, 21496, 9296, -9508, -23560, -30320, -32667, -32113, -29848, -26696, -23214, -19731, -16449, -13457, -10759, -8344, -6164, -4158, -2318, -521};