/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0050 256 samples */
 
const int16_t AKWF_fmsynth_0050_256_DATA [256] = 
{2020, 7013, 11521, 15655, 19142, 21899, 23923, 25242, 25942, 26080, 25678, 24748, 23290, 21334, 18916, 16173, 13288, 10462, 7941, 5913, 4543, 3965, 4246, 5412, 7410, 10163, 13499, 17169, 20886, 24355, 27322, 29636, 31234, 32180, 32629, 32763, 32757, 32739, 32750, 32768, 32708, 32450, 31896, 30991, 29753, 28286, 26752, 25332, 24235, 23615, 23575, 24153, 25294, 26860, 28641, 30375, 31768, 32608, 32727, 32103, 30850, 29194, 27416, 25799, 24587, 23942, 23936, 24537, 25634, 27061, 28608, 30058, 31250, 32089, 32569, 32754, 32756, 32694, 32662, 32702, 32762, 32728, 32418, 31631, 30179, 27954, 24977, 21388, 17463, 13575, 9998, 7039, 4881, 3611, 3256, 3789, 5151, 7230, 9868, 12856, 15911, 18832, 21414, 23506, 25050, 26038, 26487, 26390, 25718, 24401, 22367, 19525, 15886, 11538, 6724, 1827, -2890, -7340, -11227, -14352, -16631, -18048, -18660, -18490, -17573, -15942, -13665, -10860, -7662, -4333, -1128, 1760, 4185, 5992, 7035, 7219, 6497, 4859, 2381, -856, -4787, -9227, -13871, -18318, -22273, -25535, -28004, -29719, -30813, -31431, -31721, -31759, -31564, -31106, -30311, -29115, -27489, -25468, -23186, -20839, -18629, -16816, -15598, -15120, -15460, -16624, -18535, -21021, -23833, -26658, -29158, -31106, -32314, -32763, -32559, -31913, -31071, -30273, -29710, -29501, -29677, -30178, -30894, -31659, -32307, -32694, -32752, -32485, -31978, -31381, -30856, -30553, -30563, -30896, -31473, -32129, -32635, -32752, -32273, -31081, -29179, -26698, -23876, -21008, -18353, -16182, -14670, -13933, -13995, -14815, -16298, -18274, -20554, -22899, -25128, -27073, -28627, -29764, -30508, -30908, -31011, -30817, -30277, -29293, -27754, -25542, -22610, -18999, -14873, -10478, -6092, -1990, 1561, 4397, 6400, 7528, 7790, 7208, 5838, 3765, 1138, -1875, -5087, -8248, -11156, -13624, -15510, -16759, -17301, -17100, -16122, -14346, -11768, -8464, -4174, -738};