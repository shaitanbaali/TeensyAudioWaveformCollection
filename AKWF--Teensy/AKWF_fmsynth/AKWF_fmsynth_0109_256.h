/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0109 256 samples */
 
const int16_t AKWF_fmsynth_0109_256_DATA [256] = 
{817, 2852, 4732, 6505, 8156, 9685, 11090, 12365, 13517, 14548, 15456, 16252, 16937, 17518, 18003, 18398, 18711, 18953, 19128, 19247, 19319, 19350, 19350, 19327, 19285, 19233, 19178, 19123, 19072, 19033, 19001, 18984, 18980, 18990, 19012, 19045, 19086, 19132, 19178, 19220, 19250, 19266, 19259, 19222, 19150, 19035, 18869, 18646, 18361, 18003, 17570, 17056, 16453, 15759, 14971, 14082, 13094, 12006, 10812, 9519, 8128, 6636, 5053, 3383, 1626, -201, -2098, -4058, -6061, -8103, -10172, -12247, -14323, -16382, -18403, -20374, -22275, -24081, -25783, -27353, -28765, -30007, -31048, -31865, -32434, -32730, -32728, -32399, -31719, -30663, -29197, -27304, -24955, -22116, -18776, -14908, -10467, -5516, -808, 3268, 6778, 9771, 12283, 14343, 15995, 17275, 18210, 18837, 19186, 19282, 19156, 18832, 18334, 17685, 16905, 16018, 15036, 13980, 12865, 11704, 10513, 9305, 8087, 6872, 5670, 4484, 3327, 2204, 1118, 77, -914, -1856, -2741, -3569, -4337, -5042, -5684, -6262, -6774, -7218, -7596, -7905, -8147, -8320, -8424, -8459, -8424, -8321, -8146, -7900, -7585, -7199, -6741, -6215, -5616, -4948, -4212, -3405, -2534, -1598, -597, 457, 1570, 2734, 3941, 5186, 6462, 7756, 9063, 10368, 11653, 12911, 14120, 15258, 16308, 17244, 18032, 18652, 19066, 19236, 19123, 18683, 17869, 16623, 14892, 12616, 9712, 6122, 1774, -3481, -9445, -14939, -19613, -23523, -26698, -29171, -30966, -32124, -32682, -32678, -32152, -31144, -29700, -27858, -25665, -23171, -20411, -17435, -14299, -11034, -7696, -4343, -1005, 2255, 5381, 8337, 11054, 13480, 15566, 17242, 18457, 19147, 19249, 18701, 17431, 15382, 12481, 8653, 3857, -2029, -8875, -15135, -20210, -24288, -27438, -29771, -31367, -32305, -32665, -32517, -31927, -30952, -29649, -28072, -26261, -24265, -22127, -19873, -17545, -15170, -12771, -10377, -8012, -5691, -3435, -1217};