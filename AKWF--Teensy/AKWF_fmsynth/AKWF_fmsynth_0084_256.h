/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0084 256 samples */
 
const int16_t AKWF_fmsynth_0084_256_DATA [256] = 
{156, 1491, 3648, 5727, 7901, 10118, 12338, 14537, 16701, 18787, 20763, 22617, 24316, 25857, 27227, 28420, 29435, 30277, 30958, 31497, 31907, 32206, 32416, 32555, 32643, 32696, 32723, 32736, 32739, 32732, 32715, 32684, 32629, 32545, 32425, 32260, 32042, 31769, 31440, 31057, 30625, 30145, 29633, 29100, 28558, 28029, 27519, 27049, 26635, 26288, 26024, 25856, 25788, 25827, 25981, 26242, 26610, 27075, 27633, 28260, 28935, 29640, 30347, 31025, 31641, 32156, 32533, 32740, 32740, 32494, 31975, 31164, 30040, 28584, 26809, 24716, 22324, 19695, 16827, 13787, 10649, 7463, 4312, 1281, -1545, -3918, -5828, -7341, -8466, -9246, -9705, -9851, -9703, -9269, -8559, -7570, -6309, -4779, -2986, -934, 1309, 3609, 5876, 8068, 10157, 12103, 13902, 15532, 16986, 18244, 19323, 20216, 20922, 21445, 21786, 21941, 21909, 21679, 21243, 20576, 19670, 18489, 16994, 15159, 12940, 10288, 7181, 3531, -682, -5028, -9163, -13031, -16587, -19812, -22667, -25130, -27215, -28917, -30269, -31291, -32017, -32480, -32715, -32766, -32670, -32465, -32185, -31864, -31532, -31208, -30916, -30671, -30484, -30366, -30317, -30338, -30426, -30574, -30769, -31007, -31272, -31547, -31822, -32081, -32311, -32502, -32647, -32736, -32768, -32745, -32671, -32553, -32402, -32231, -32055, -31889, -31747, -31643, -31587, -31585, -31639, -31749, -31905, -32092, -32294, -32488, -32649, -32750, -32761, -32655, -32411, -32009, -31424, -30654, -29691, -28531, -27195, -25693, -24028, -22241, -20351, -18384, -16393, -14379, -12383, -10441, -8569, -6798, -5159, -3641, -2278, -1079, -52, 804, 1482, 1983, 2307, 2457, 2441, 2262, 1929, 1449, 837, 109, -732, -1666, -2677, -3748, -4857, -5985, -7125, -8244, -9332, -10373, -11338, -12229, -13029, -13718, -14295, -14745, -15063, -15244, -15277, -15162, -14886, -14452, -13853, -13082, -12139, -11026, -9735, -8287, -6667, -4900, -2990, -826};