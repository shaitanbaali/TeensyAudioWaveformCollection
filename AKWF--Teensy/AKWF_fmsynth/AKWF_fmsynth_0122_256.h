/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0122 256 samples */
 
const int16_t AKWF_fmsynth_0122_256_DATA [256] = 
{1996, 5999, 9617, 12812, 15482, 17588, 19124, 20097, 20536, 20475, 19927, 18921, 17488, 15681, 13565, 11246, 8849, 6501, 4349, 2524, 1128, 260, -19, 328, 1321, 2947, 5169, 7900, 11021, 14384, 17796, 21074, 24058, 26603, 28645, 30179, 31239, 31914, 32304, 32499, 32571, 32555, 32450, 32228, 31845, 31260, 30441, 29392, 28166, 26829, 25493, 24279, 23302, 22672, 22461, 22710, 23417, 24532, 25966, 27579, 29208, 30679, 31821, 32505, 32662, 32294, 31473, 30331, 29042, 27779, 26705, 25945, 25576, 25624, 26058, 26814, 27791, 28864, 29918, 30847, 31578, 32085, 32378, 32502, 32521, 32497, 32478, 32482, 32489, 32431, 32214, 31715, 30812, 29395, 27420, 24901, 21915, 18632, 15250, 11979, 9035, 6568, 4685, 3453, 2879, 2957, 3653, 4913, 6654, 8763, 11115, 13552, 15917, 18090, 19957, 21446, 22525, 23172, 23372, 23107, 22354, 21067, 19202, 16741, 13694, 10116, 6159, 2026, -2086, -6123, -9923, -13291, -16099, -18304, -19900, -20908, -21364, -21295, -20730, -19688, -18192, -16300, -14075, -11632, -9112, -6655, -4424, -2550, -1139, -266, 13, -337, -1337, -2991, -5280, -8127, -11404, -14947, -18524, -21922, -24956, -27481, -29442, -30852, -31775, -32320, -32604, -32728, -32766, -32754, -32691, -32543, -32257, -31781, -31072, -30126, -28976, -27689, -26378, -25169, -24186, -23547, -23332, -23587, -24304, -25427, -26849, -28417, -29952, -31270, -32208, -32652, -32554, -31947, -30924, -29632, -28244, -26926, -25828, -25062, -24690, -24738, -25176, -25942, -26944, -28065, -29193, -30222, -31073, -31711, -32132, -32365, -32471, -32501, -32499, -32483, -32426, -32269, -31917, -31261, -30194, -28635, -26565, -24012, -21066, -17892, -14660, -11552, -8756, -6400, -4592, -3398, -2842, -2920, -3597, -4816, -6492, -8505, -10741, -13054, -15303, -17379, -19175, -20619, -21672, -22304, -22501, -22241, -21499, -20246, -18440, -16080, -13178, -9786, -6021, -1942};