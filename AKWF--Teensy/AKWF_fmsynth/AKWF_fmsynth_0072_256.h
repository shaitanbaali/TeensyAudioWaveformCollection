/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0072 256 samples */
 
const int16_t AKWF_fmsynth_0072_256_DATA [256] = 
{2308, 6286, 10262, 14155, 17789, 21006, 23708, 25765, 27152, 27883, 28018, 27657, 26921, 25930, 24801, 23626, 22473, 21390, 20405, 19533, 18777, 18134, 17624, 17258, 17068, 17089, 17358, 17906, 18753, 19904, 21327, 22953, 24723, 26500, 28141, 29479, 30344, 30580, 30074, 28763, 26650, 23816, 20453, 16707, 12811, 8989, 5390, 2109, -818, -3365, -5445, -7034, -8128, -8719, -8827, -8484, -7743, -6676, -5326, -3767, -2082, -375, 1255, 2728, 3964, 4895, 5457, 5577, 5200, 4292, 2864, 928, -1564, -4478, -7556, -10597, -13350, -15621, -17323, -18439, -19040, -19275, -19302, -19296, -19408, -19747, -20388, -21354, -22622, -24133, -25804, -27507, -29139, -30572, -31698, -32440, -32760, -32671, -32217, -31470, -30532, -29491, -28431, -27391, -26375, -25338, -24198, -22827, -21074, -18804, -15917, -12391, -8294, -3796, 919, 5548, 9851, 13564, 16556, 18763, 20171, 20845, 20890, 20415, 19515, 18275, 16749, 14966, 12961, 10758, 8392, 5933, 3488, 1164, -896, -2594, -3809, -4454, -4467, -3817, -2497, -458, 2349, 5639, 9438, 13585, 17929, 22180, 26070, 29281, 31535, 32644, 32532, 31229, 28898, 25806, 22292, 18616, 15085, 11917, 9257, 7211, 5821, 5085, 4995, 5493, 6502, 7889, 9554, 11362, 13195, 14972, 16649, 18213, 19670, 21040, 22332, 23533, 24611, 25470, 25994, 26027, 25414, 23994, 21673, 18449, 14411, 9834, 5031, -21, -5000, -9599, -13657, -17092, -19933, -22297, -24253, -25907, -27335, -28560, -29603, -30430, -30989, -31225, -31087, -30550, -29604, -28287, -26674, -24853, -22962, -21113, -19418, -17992, -16914, -16230, -15958, -16063, -16478, -17084, -17731, -18264, -18520, -18380, -17772, -16703, -15241, -13491, -11624, -9801, -8167, -6856, -5936, -5453, -5419, -5811, -6583, -7666, -9007, -10509, -12082, -13641, -15079, -16317, -17285, -17910, -18147, -17967, -17359, -16318, -14844, -12948, -10631, -7922, -4837, -1310};