/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0119 256 samples */
 
const int16_t AKWF_fmsynth_0119_256_DATA [256] = 
{2581, 6592, 10284, 13657, 16627, 19160, 21246, 22891, 24128, 24987, 25498, 25693, 25585, 25185, 24488, 23498, 22217, 20650, 18822, 16777, 14562, 12252, 9931, 7675, 5575, 3714, 2151, 949, 157, -194, -78, 516, 1597, 3151, 5153, 7565, 10308, 13306, 16445, 19584, 22609, 25382, 27783, 29740, 31201, 32159, 32654, 32753, 32552, 32157, 31677, 31209, 30828, 30594, 30532, 30643, 30909, 31281, 31706, 32115, 32443, 32633, 32640, 32443, 32044, 31470, 30767, 29996, 29230, 28539, 27991, 27641, 27527, 27668, 28060, 28671, 29450, 30315, 31167, 31895, 32379, 32500, 32166, 31310, 29902, 27968, 25580, 22833, 19875, 16865, 13941, 11250, 8898, 6957, 5489, 4508, 4023, 4031, 4508, 5433, 6760, 8440, 10408, 12572, 14849, 17140, 19344, 21394, 23220, 24780, 26064, 27069, 27802, 28285, 28529, 28543, 28318, 27833, 27050, 25912, 24372, 22379, 19892, 16912, 13474, 9645, 5569, 1423, -2681, -6741, -10625, -14183, -17301, -19943, -22098, -23776, -25024, -25881, -26391, -26581, -26475, -26078, -25383, -24384, -23085, -21476, -19582, -17450, -15126, -12691, -10250, -7882, -5693, -3769, -2169, -957, -163, 187, 72, -526, -1615, -3197, -5263, -7777, -10659, -13814, -17111, -20385, -23488, -26275, -28617, -30447, -31732, -32481, -32762, -32659, -32281, -31744, -31154, -30610, -30181, -29921, -29852, -29978, -30275, -30701, -31203, -31711, -32161, -32489, -32649, -32608, -32360, -31923, -31336, -30658, -29962, -29318, -28799, -28468, -28358, -28493, -28866, -29443, -30159, -30934, -31660, -32220, -32503, -32401, -31834, -30765, -29181, -27128, -24692, -21966, -19092, -16204, -13419, -10866, -8630, -6780, -5369, -4424, -3956, -3961, -4426, -5318, -6592, -8198, -10071, -12126, -14289, -16474, -18588, -20568, -22355, -23902, -25190, -26211, -26968, -27472, -27728, -27743, -27507, -27000, -26191, -25033, -23490, -21525, -19106, -16244, -12969, -9340, -5459, -1352};