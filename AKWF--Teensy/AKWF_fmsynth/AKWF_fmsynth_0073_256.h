/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0073 256 samples */
 
const int16_t AKWF_fmsynth_0073_256_DATA [256] = 
{732, 2697, 4816, 7094, 9528, 12074, 14691, 17324, 19919, 22422, 24774, 26914, 28783, 30319, 31513, 32317, 32721, 32726, 32348, 31608, 30540, 29190, 27605, 25823, 23914, 21893, 19809, 17698, 15586, 13499, 11448, 9434, 7470, 5564, 3706, 1872, 40, -1782, -3597, -5395, -7174, -8936, -10677, -12395, -14078, -15715, -17296, -18827, -20282, -21665, -22964, -24165, -25269, -26279, -27183, -27986, -28687, -29284, -29786, -30193, -30506, -30730, -30863, -30912, -30877, -30757, -30556, -30278, -29924, -29501, -29014, -28473, -27893, -27284, -26660, -26038, -25438, -24876, -24369, -23929, -23569, -23295, -23113, -23018, -23001, -23045, -23129, -23223, -23290, -23289, -23173, -22900, -22427, -21713, -20732, -19465, -17890, -16026, -13883, -11487, -8907, -6154, -3309, -302, 2681, 5502, 8215, 10805, 13218, 15431, 17444, 19233, 20809, 22186, 23360, 24343, 25156, 25806, 26311, 26688, 26943, 27089, 27141, 27104, 26983, 26787, 26520, 26186, 25784, 25322, 24801, 24222, 23598, 22925, 22209, 21466, 20700, 19925, 19162, 18406, 17685, 17010, 16390, 15845, 15382, 15007, 14730, 14555, 14479, 14503, 14621, 14829, 15114, 15468, 15879, 16336, 16830, 17348, 17878, 18415, 18946, 19473, 19985, 20477, 20942, 21370, 21751, 22074, 22318, 22464, 22484, 22354, 22044, 21521, 20754, 19730, 18426, 16827, 14945, 12812, 10459, 7968, 5400, 2740, -9, -2753, -5405, -7897, -10180, -12212, -13960, -15423, -16601, -17518, -18192, -18651, -18925, -19046, -19042, -18942, -18763, -18530, -18258, -17960, -17639, -17305, -16957, -16595, -16221, -15830, -15419, -14987, -14529, -14043, -13535, -12993, -12425, -11838, -11232, -10614, -10000, -9385, -8786, -8212, -7675, -7178, -6732, -6345, -6024, -5769, -5590, -5481, -5443, -5478, -5578, -5738, -5952, -6207, -6495, -6803, -7113, -7411, -7681, -7903, -8063, -8137, -8113, -7970, -7694, -7270, -6685, -5926, -4987, -3851, -2522, -948};