/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0105 256 samples */
 
const int16_t AKWF_fmsynth_0105_256_DATA [256] = 
{5992, 16398, 23560, 28349, 31187, 32503, 32751, 32314, 31508, 30558, 29619, 28787, 28117, 27627, 27312, 27144, 27089, 27107, 27149, 27172, 27131, 26983, 26687, 26205, 25503, 24565, 23355, 21885, 20171, 18262, 16212, 14084, 11952, 9885, 7929, 6123, 4472, 2996, 1701, 603, -290, -973, -1440, -1687, -1721, -1558, -1220, -734, -134, 547, 1279, 2016, 2733, 3395, 3967, 4423, 4737, 4895, 4890, 4722, 4402, 3953, 3399, 2773, 2100, 1425, 781, 203, -267, -606, -778, -756, -520, -59, 627, 1552, 2711, 4100, 5713, 7574, 9665, 11986, 14501, 17135, 19816, 22451, 24906, 27089, 28923, 30356, 31415, 32125, 32543, 32736, 32761, 32663, 32465, 32165, 31729, 31088, 30143, 28698, 26477, 23083, 17912, 10094, -1438, -13576, -22787, -28955, -32145, -32687, -31124, -28102, -24253, -20120, -16066, -12350, -9022, -6090, -3509, -1203, 889, 2822, 4637, 6358, 8000, 9590, 11151, 12729, 14362, 16099, 17961, 20011, 22266, 24696, 27230, 29687, 31704, 32745, 31885, 27865, 18925, 2370, -15969, -26882, -31825, -32681, -30945, -27821, -24119, -20383, -16919, -13855, -11218, -8975, -7062, -5426, -4017, -2778, -1665, -624, 382, 1401, 2470, 3629, 4925, 6400, 8099, 10067, 12338, 14928, 17862, 21056, 24391, 27624, 30395, 32261, 32720, 31250, 27427, 21084, 12215, 1064, -9350, -16436, -21176, -24298, -26322, -27597, -28359, -28776, -28956, -28986, -28932, -28862, -28849, -28948, -29210, -29653, -30260, -30974, -31696, -32305, -32690, -32747, -32423, -31709, -30653, -29333, -27847, -26319, -24843, -23513, -22407, -21558, -21005, -20768, -20852, -21254, -21953, -22931, -24138, -25513, -26984, -28444, -29810, -30985, -31885, -32470, -32739, -32736, -32538, -32241, -31941, -31714, -31602, -31614, -31726, -31902, -32097, -32275, -32415, -32510, -32556, -32554, -32491, -32329, -31992, -31345, -30176, -28196, -25011, -20119, -12716, -2780};