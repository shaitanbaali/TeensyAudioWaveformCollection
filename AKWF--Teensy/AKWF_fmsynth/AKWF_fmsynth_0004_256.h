/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0004 256 samples */
 
const int16_t AKWF_fmsynth_0004_256_DATA [256] = 
{1718, 4305, 6736, 9035, 11168, 13118, 14874, 16425, 17778, 18940, 19914, 20716, 21358, 21848, 22199, 22418, 22507, 22469, 22297, 21986, 21521, 20884, 20054, 19002, 17706, 16139, 14266, 12079, 9564, 6716, 3570, 177, -3393, -7181, -11181, -15257, -19236, -22969, -26293, -29041, -31089, -32317, -32641, -32016, -30433, -27932, -24575, -20476, -15790, -10658, -5276, 150, 5461, 10460, 14982, 18912, 22134, 24579, 26226, 27070, 27153, 26543, 25332, 23627, 21541, 19203, 16727, 14218, 11784, 9498, 7428, 5626, 4123, 2945, 2110, 1625, 1498, 1735, 2344, 3327, 4679, 6401, 8465, 10829, 13436, 16193, 18968, 21620, 23961, 25787, 26893, 27068, 26132, 23939, 20426, 15604, 9578, 2610, -4958, -12665, -19907, -26073, -30514, -32623, -31952, -28280, -21756, -12957, -3144, 6774, 15948, 22855, 26569, 26726, 23407, 17116, 8619, -1071, -10867, -19762, -26795, -31257, -32723, -31074, -26547, -19696, -11419, -2859, 5451, 13067, 19254, 23674, 26246, 27108, 26498, 24719, 22086, 18898, 15437, 11912, 8509, 5373, 2584, 210, -1703, -3145, -4100, -4565, -4537, -4011, -2989, -1466, 549, 3036, 5964, 9254, 12798, 16451, 19986, 23133, 25569, 26916, 26790, 24836, 20817, 14673, 6676, -2299, -11681, -20733, -27913, -32070, -32459, -28872, -21627, -11598, -142, 11137, 20420, 26015, 26662, 21810, 12014, -614, -13619, -24832, -31529, -32422, -27626, -18256, -6180, 6416, 17346, 24660, 27054, 24021, 16061, 4817, -7255, -18615, -27365, -32057, -32400, -28810, -22142, -13502, -3985, 5348, 13606, 20177, 24637, 26817, 26779, 24746, 21081, 16210, 10624, 4798, -843, -6057, -10925, -15302, -19061, -22192, -24732, -26734, -28276, -29439, -30289, -30898, -31321, -31596, -31764, -31846, -31854, -31793, -31659, -31445, -31136, -30713, -30157, -29446, -28559, -27483, -26194, -24688, -22965, -21019, -18871, -16543, -14055, -11454, -8786, -6091, -3454, -848};