/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0112 256 samples */
 
const int16_t AKWF_fmsynth_0112_256_DATA [256] = 
{452, 1341, 2216, 3095, 3969, 4840, 5698, 6540, 7363, 8162, 8928, 9664, 10361, 11017, 11628, 12192, 12704, 13165, 13574, 13927, 14226, 14472, 14666, 14808, 14900, 14947, 14952, 14916, 14844, 14741, 14612, 14459, 14289, 14106, 13914, 13718, 13523, 13333, 13151, 12983, 12828, 12693, 12579, 12487, 12418, 12375, 12358, 12367, 12401, 12459, 12540, 12641, 12762, 12900, 13052, 13214, 13384, 13559, 13734, 13908, 14074, 14232, 14376, 14505, 14614, 14703, 14766, 14802, 14809, 14786, 14729, 14640, 14517, 14359, 14166, 13939, 13677, 13381, 13054, 12694, 12308, 11891, 11449, 10984, 10494, 9987, 9463, 8922, 8370, 7808, 7236, 6659, 6080, 5497, 4915, 4336, 3758, 3188, 2623, 2066, 1519, 981, 452, -64, -567, -1060, -1539, -2006, -2461, -2901, -3330, -3746, -4148, -4540, -4918, -5282, -5637, -5979, -6308, -6627, -6935, -7230, -7516, -7790, -8051, -8304, -8543, -8772, -8989, -9194, -9388, -9570, -9739, -9897, -10040, -10172, -10290, -10395, -10486, -10564, -10627, -10675, -10710, -10729, -10733, -10723, -10697, -10657, -10600, -10528, -10441, -10338, -10219, -10085, -9935, -9770, -9590, -9392, -9181, -8952, -8708, -8449, -8172, -7880, -7570, -7243, -6898, -6535, -6153, -5751, -5329, -4884, -4417, -3927, -3410, -2868, -2299, -1701, -1072, -414, 276, 999, 1753, 2540, 3357, 4201, 5075, 5970, 6881, 7807, 8735, 9656, 10560, 11430, 12250, 13003, 13661, 14200, 14589, 14794, 14774, 14485, 13881, 12903, 11490, 9582, 7097, 3956, 94, -4624, -10204, -15513, -19923, -23557, -26472, -28753, -30454, -31641, -32381, -32726, -32733, -32451, -31929, -31209, -30327, -29323, -28225, -27060, -25856, -24629, -23396, -22175, -20975, -19803, -18668, -17571, -16515, -15503, -14528, -13591, -12690, -11819, -10973, -10150, -9341, -8543, -7754, -6964, -6174, -5380, -4576, -3764, -2941, -2105, -1261, -389};