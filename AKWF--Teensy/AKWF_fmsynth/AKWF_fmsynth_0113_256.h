/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0113 256 samples */
 
const int16_t AKWF_fmsynth_0113_256_DATA [256] = 
{1900, 8349, 13757, 18346, 22169, 25294, 27785, 29695, 31095, 32038, 32578, 32768, 32658, 32289, 31704, 30940, 30034, 29010, 27901, 26730, 25515, 24277, 23033, 21791, 20564, 19362, 18189, 17054, 15959, 14901, 13892, 12926, 12002, 11124, 10288, 9492, 8739, 8022, 7343, 6700, 6090, 5514, 4969, 4455, 3970, 3515, 3089, 2690, 2321, 1979, 1665, 1381, 1124, 896, 697, 528, 388, 280, 200, 152, 135, 150, 195, 271, 380, 519, 690, 893, 1127, 1393, 1692, 2021, 2383, 2777, 3204, 3666, 4162, 4693, 5262, 5871, 6518, 7211, 7950, 8735, 9573, 10466, 11413, 12423, 13495, 14628, 15828, 17091, 18413, 19794, 21219, 22681, 24165, 25645, 27094, 28481, 29757, 30870, 31754, 32329, 32504, 32166, 31193, 29428, 26704, 22835, 17586, 10727, 1912, -7170, -14413, -19999, -24148, -27010, -28760, -29568, -29583, -28950, -27799, -26252, -24413, -22369, -20209, -17993, -15770, -13590, -11475, -9441, -7504, -5658, -3893, -2205, -566, 1042, 2638, 4251, 5901, 7600, 9374, 11228, 13158, 15172, 17252, 19374, 21516, 23631, 25669, 27579, 29284, 30708, 31768, 32368, 32409, 31781, 30380, 28089, 24788, 20376, 14740, 7727, -576, -8232, -14285, -19043, -22701, -25426, -27358, -28638, -29379, -29677, -29620, -29279, -28717, -27986, -27130, -26189, -25186, -24153, -23108, -22064, -21039, -20040, -19073, -18146, -17264, -16425, -15637, -14897, -14205, -13564, -12970, -12425, -11926, -11474, -11066, -10704, -10385, -10108, -9872, -9676, -9522, -9408, -9332, -9295, -9297, -9336, -9414, -9530, -9683, -9876, -10106, -10375, -10683, -11029, -11416, -11841, -12306, -12813, -13360, -13947, -14576, -15243, -15950, -16696, -17477, -18294, -19142, -20016, -20914, -21830, -22752, -23675, -24588, -25475, -26325, -27118, -27833, -28449, -28938, -29268, -29409, -29322, -28964, -28288, -27245, -25782, -23830, -21333, -18220, -14416, -9857, -4287};