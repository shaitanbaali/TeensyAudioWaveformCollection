/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0102 256 samples */
 
const int16_t AKWF_fmsynth_0102_256_DATA [256] = 
{1288, 3608, 5919, 8169, 10218, 11932, 13184, 13893, 14060, 13714, 12955, 11912, 10742, 9588, 8581, 7841, 7456, 7499, 8014, 9041, 10604, 12692, 15269, 18224, 21373, 24461, 27196, 29344, 30818, 31684, 32106, 32236, 32153, 31853, 31306, 30513, 29545, 28548, 27697, 27161, 27066, 27484, 28408, 29728, 31196, 32392, 32738, 31576, 28337, 22775, 15240, 6784, -1173, -6353, -8456, -8162, -5699, -1112, 4837, 10520, 15197, 18570, 20597, 21257, 20465, 17904, 13019, 4549, -7187, -17724, -25349, -30045, -32264, -32762, -32285, -31456, -30699, -30248, -30191, -30496, -31055, -31704, -32273, -32635, -32766, -32737, -32684, -32705, -32766, -32670, -32126, -30884, -28864, -26179, -23141, -20052, -17197, -14782, -12905, -11595, -10853, -10637, -10904, -11586, -12585, -13796, -15070, -16254, -17182, -17709, -17726, -17169, -16028, -14343, -12229, -9864, -7376, -4924, -2611, -489, 1378, 2930, 4126, 4890, 5203, 5081, 4592, 3821, 2882, 1897, 979, 233, -234, -363, -55, 729, 1917, 3511, 5489, 7824, 10454, 13260, 16095, 18728, 20984, 22710, 23831, 24341, 24288, 23732, 22770, 21528, 20167, 18860, 17777, 17042, 16777, 17060, 17930, 19411, 21471, 23982, 26726, 29360, 31443, 32614, 32642, 31633, 30007, 28391, 27345, 27179, 27862, 29079, 30416, 31528, 32265, 32632, 32751, 32766, 32764, 32705, 32372, 31318, 28850, 24041, 15968, 3398, -10464, -19961, -25685, -28907, -30558, -31298, -31490, -31278, -30636, -29466, -27666, -25305, -22655, -20242, -18713, -18615, -20144, -23023, -26543, -29778, -31996, -32772, -32132, -30430, -28169, -25815, -23714, -22090, -21052, -20622, -20763, -21404, -22428, -23690, -25014, -26225, -27181, -27776, -27940, -27611, -26730, -25258, -23175, -20586, -17661, -14631, -11739, -9139, -6907, -5116, -3771, -2885, -2451, -2443, -2813, -3492, -4397, -5418, -6435, -7332, -7975, -8247, -8070, -7417, -6297, -4774, -2945, -851};