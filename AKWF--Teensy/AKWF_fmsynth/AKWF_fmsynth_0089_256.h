/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0089 256 samples */
 
const int16_t AKWF_fmsynth_0089_256_DATA [256] = 
{330, 1411, 2444, 3333, 4099, 4727, 5217, 5584, 5847, 6032, 6171, 6297, 6447, 6653, 6948, 7353, 7882, 8540, 9331, 10232, 11229, 12291, 13376, 14458, 15506, 16481, 17364, 18134, 18779, 19305, 19713, 20013, 20227, 20378, 20489, 20593, 20716, 20887, 21130, 21456, 21884, 22411, 23027, 23722, 24470, 25239, 26014, 26760, 27454, 28082, 28623, 29080, 29454, 29745, 29966, 30124, 30236, 30313, 30371, 30424, 30488, 30577, 30697, 30858, 31062, 31300, 31561, 31835, 32097, 32335, 32528, 32666, 32746, 32769, 32744, 32686, 32607, 32525, 32448, 32382, 32332, 32294, 32265, 32237, 32202, 32148, 32069, 31955, 31791, 31564, 31259, 30864, 30371, 29773, 29078, 28296, 27453, 26581, 25718, 24908, 24175, 23550, 23045, 22660, 22382, 22183, 22029, 21882, 21696, 21437, 21061, 20535, 19832, 18920, 17794, 16440, 14855, 13065, 11108, 9025, 6900, 4782, 2757, 897, -717, -2013, -2994, -3712, -4218, -4570, -4840, -5098, -5418, -5863, -6485, -7321, -8382, -9663, -11133, -12749, -14448, -16163, -17827, -19404, -20839, -22108, -23195, -24094, -24817, -25383, -25804, -26107, -26319, -26464, -26577, -26685, -26821, -27006, -27263, -27604, -28028, -28528, -29081, -29659, -30237, -30783, -31275, -31692, -32030, -32287, -32473, -32598, -32678, -32722, -32747, -32760, -32766, -32767, -32767, -32767, -32768, -32765, -32755, -32737, -32698, -32633, -32528, -32372, -32156, -31880, -31546, -31164, -30745, -30312, -29886, -29487, -29135, -28836, -28598, -28418, -28290, -28197, -28125, -28052, -27957, -27823, -27631, -27367, -27017, -26570, -26023, -25384, -24651, -23843, -22982, -22090, -21198, -20347, -19551, -18837, -18228, -17729, -17342, -17056, -16850, -16705, -16590, -16471, -16323, -16109, -15807, -15395, -14859, -14196, -13407, -12493, -11478, -10391, -9257, -8119, -7012, -5959, -5001, -4162, -3452, -2880, -2437, -2110, -1880, -1717, -1586, -1453, -1280, -1039, -692, -228};