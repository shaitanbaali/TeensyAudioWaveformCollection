/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0052 256 samples */
 
const int16_t AKWF_fmsynth_0052_256_DATA [256] = 
{2639, 7005, 10821, 14412, 17629, 20513, 23024, 25171, 26979, 28456, 29644, 30579, 31288, 31809, 32177, 32425, 32582, 32678, 32728, 32750, 32762, 32764, 32759, 32749, 32722, 32671, 32574, 32416, 32175, 31823, 31336, 30688, 29849, 28794, 27503, 25953, 24134, 22047, 19669, 17023, 14113, 10962, 7623, 4126, 489, -3201, -6912, -10573, -14091, -17464, -20604, -23457, -25980, -28134, -29894, -31242, -32165, -32663, -32755, -32463, -31818, -30852, -29620, -28173, -26550, -24808, -23001, -21170, -19365, -17634, -15992, -14485, -13129, -11948, -10964, -10184, -9609, -9257, -9127, -9221, -9539, -10087, -10861, -11852, -13056, -14452, -16018, -17751, -19600, -21527, -23494, -25423, -27273, -28974, -30446, -31615, -32410, -32758, -32603, -31885, -30569, -28646, -26085, -22927, -19195, -14952, -10310, -5354, -173, 5054, 10218, 15162, 19696, 23751, 27170, 29838, 31685, 32639, 32672, 31798, 30042, 27484, 24197, 20352, 16061, 11475, 6792, 2196, -2220, -6501, -10624, -14451, -17897, -20944, -23563, -25768, -27599, -29069, -30214, -31087, -31721, -32164, -32457, -32635, -32727, -32763, -32768, -32760, -32748, -32743, -32747, -32758, -32767, -32766, -32738, -32662, -32515, -32272, -31902, -31373, -30656, -29726, -28539, -27073, -25312, -23231, -20841, -18137, -15123, -11843, -8357, -4711, -1036, 2694, 6526, 10375, 14124, 17684, 20978, 23945, 26525, 28681, 30381, 31616, 32403, 32748, 32680, 32232, 31449, 30376, 29057, 27553, 25904, 24166, 22393, 20604, 18856, 17173, 15588, 14136, 12833, 11687, 10725, 9951, 9379, 9011, 8853, 8913, 9191, 9679, 10382, 11294, 12407, 13707, 15183, 16805, 18564, 20418, 22334, 24260, 26137, 27916, 29528, 30897, 31945, 32592, 32761, 32380, 31383, 29718, 27352, 24299, 20579, 16224, 11389, 6207, 919, -4374, -9779, -15027, -19855, -24100, -27597, -30219, -31946, -32722, -32561, -31504, -29640, -27048, -23828, -20118, -16042, -11708, -7328, -2740};