/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0063 256 samples */
 
const int16_t AKWF_fmsynth_0063_256_DATA [256] = 
{450, 2079, 4232, 6806, 9636, 12539, 15308, 17778, 19843, 21428, 22522, 23163, 23412, 23350, 23076, 22709, 22385, 22237, 22381, 22895, 23806, 25068, 26574, 28164, 29680, 30956, 31895, 32466, 32722, 32767, 32713, 32653, 32633, 32652, 32692, 32727, 32747, 32750, 32735, 32672, 32496, 32091, 31319, 30038, 28175, 25724, 22824, 19736, 16800, 14347, 12628, 11737, 11625, 12093, 12859, 13620, 14106, 14071, 13307, 11626, 8865, 4838, -569, -6507, -11994, -16709, -20475, -23328, -25327, -26621, -27352, -27643, -27602, -27333, -26948, -26584, -26398, -26523, -27044, -27951, -29130, -30397, -31528, -32335, -32732, -32707, -32354, -31820, -31252, -30785, -30494, -30396, -30462, -30627, -30817, -30964, -31008, -30902, -30597, -30025, -29127, -27842, -26155, -24123, -21855, -19496, -17253, -15291, -13749, -12710, -12167, -12068, -12306, -12732, -13179, -13481, -13492, -13090, -12190, -10736, -8755, -6283, -3455, -312, 2821, 5636, 8079, 10046, 11467, 12338, 12707, 12670, 12348, 11892, 11471, 11252, 11381, 11964, 13056, 14648, 16667, 18947, 21348, 23670, 25740, 27459, 28772, 29688, 30275, 30586, 30686, 30628, 30466, 30261, 30089, 30030, 30149, 30477, 30992, 31619, 32226, 32653, 32758, 32455, 31741, 30716, 29556, 28476, 27657, 27200, 27107, 27299, 27645, 28001, 28238, 28255, 27958, 27240, 25980, 24038, 21282, 17599, 13025, 7707, 1952, -3443, -7526, -10322, -11989, -12721, -12710, -12176, -11368, -10582, -10133, -10302, -11289, -13148, -15764, -18863, -22106, -25132, -27710, -29688, -31057, -31903, -32366, -32586, -32675, -32701, -32691, -32656, -32599, -32545, -32519, -32554, -32644, -32743, -32756, -32562, -32055, -31180, -29965, -28520, -26984, -25539, -24336, -23476, -23003, -22888, -23048, -23373, -23729, -23983, -24026, -23757, -23097, -21991, -20401, -18340, -15885, -13118, -10239, -7438, -4915, -2800, -1213, -187, 298, 328, 25, -447, -911, -1196, -1140, -591};