/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0043 256 samples */
 
const int16_t AKWF_fmsynth_0043_256_DATA [256] = 
{543, 3651, 6921, 10105, 13233, 16246, 19097, 21729, 24116, 26247, 28075, 29601, 30813, 31723, 32338, 32680, 32769, 32646, 32335, 31880, 31311, 30669, 29988, 29303, 28637, 28022, 27472, 27009, 26652, 26403, 26265, 26245, 26340, 26544, 26845, 27236, 27705, 28231, 28800, 29389, 29981, 30561, 31102, 31593, 32012, 32348, 32592, 32735, 32769, 32702, 32530, 32267, 31913, 31487, 31001, 30474, 29926, 29366, 28818, 28302, 27835, 27429, 27098, 26855, 26708, 26663, 26726, 26898, 27172, 27548, 28014, 28553, 29149, 29786, 30432, 31063, 31647, 32141, 32517, 32732, 32754, 32539, 32058, 31282, 30184, 28748, 26973, 24855, 22434, 19718, 16736, 13560, 10248, 6858, 3500, 212, -3015, -6192, -9267, -12172, -14874, -17360, -19601, -21584, -23326, -24821, -26098, -27174, -28063, -28786, -29363, -29816, -30160, -30407, -30575, -30665, -30686, -30641, -30530, -30344, -30088, -29752, -29325, -28802, -28177, -27439, -26591, -25619, -24527, -23318, -21994, -20571, -19058, -17463, -15807, -14117, -12411, -10720, -9053, -7440, -5898, -4453, -3124, -1920, -852, 68, 839, 1456, 1909, 2191, 2291, 2211, 1939, 1478, 828, -9, -1038, -2273, -3701, -5313, -7123, -9093, -11207, -13429, -15723, -18061, -20391, -22649, -24795, -26766, -28528, -30032, -31236, -32105, -32620, -32770, -32554, -31974, -31051, -29810, -28292, -26520, -24549, -22415, -20171, -17874, -15551, -13239, -10992, -8825, -6774, -4879, -3122, -1539, -137, 1082, 2106, 2937, 3586, 4040, 4308, 4391, 4295, 4024, 3582, 2978, 2212, 1299, 256, -930, -2229, -3628, -5123, -6677, -8283, -9935, -11597, -13246, -14870, -16461, -17986, -19440, -20809, -22069, -23236, -24290, -25233, -26065, -26784, -27394, -27907, -28320, -28639, -28868, -29011, -29071, -29047, -28933, -28727, -28418, -28003, -27462, -26788, -25963, -24968, -23802, -22439, -20863, -19076, -17070, -14841, -12419, -9781, -6980, -3964, -909};