/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0035 256 samples */
 
const int16_t AKWF_fmsynth_0035_256_DATA [256] = 
{7331, 21393, 30789, 32228, 23630, 6480, -13446, -28531, -32641, -24740, -8126, 11129, 26631, 32815, 27264, 11771, -7480, -23666, -32033, -31431, -23739, -11886, 1047, 12946, 22286, 28520, 31824, 32770, 32152, 30744, 29202, 28012, 27466, 27679, 28599, 30015, 31536, 32611, 32553, 30655, 26257, 19008, 9074, -2809, -15046, -25555, -31912, -31842, -24173, -9728, 5564, 21017, 31054, 32152, 24892, 11489, -4417, -19006, -29127, -32793, -29627, -20725, -8451, 4301, 15598, 24064, 29417, 32084, 32767, 32258, 31238, 30234, 29579, 29472, 29942, 30863, 31939, 32697, 32463, 30403, 25673, 17588, 6357, -6889, -20009, -29624, -32750, -27994, -15833, 1036, 18142, 30106, 32225, 22479, 3520, -16978, -30471, -31861, -21839, -4693, 13649, 27461, 32800, 28372, 15989, -213, -15474, -26564, -32022, -32397, -29087, -23610, -17329, -11209, -5927, -1770, 1091, 2617, 2802, 1677, -764, -4483, -9371, -15146, -21308, -27039, -31305, -32757, -30102, -22484, -10197, 4766, 19374, 29677, 32733, 27698, 15898, 47, -15856, -27859, -32765, -29132, -17723, -1857, 13955, 26027, 32072, 32121, 27406, 19659, 10600, 1558, -6503, -13090, -18175, -21770, -24100, -25382, -25781, -25334, -23972, -21524, -17763, -12438, -5446, 3056, 12502, 21764, 29155, 32715, 30387, 20962, 5443, -12265, -26753, -32791, -28108, -14152, 4662, 22026, 31992, 30216, 16461, -3935, -22530, -32125, -30481, -19526, -3572, 12703, 25297, 31948, 32006, 26324, 16821, 5861, -4411, -13195, -19901, -24531, -27492, -29214, -30070, -30308, -29994, -29044, -27205, -24141, -19426, -12735, -4112, 5829, 16378, 25634, 31540, 32458, 27580, 17285, 3078, -12188, -25076, -32173, -31072, -21199, -4997, 12542, 26314, 32556, 30588, 21923, 9196, -4606, -17003, -26207, -31426, -32740, -30780, -26591, -21278, -15863, -11022, -7243, -4767, -3694, -4039, -5813, -8978, -13404, -18735, -24337, -29246, -32328, -32305, -28197, -19624, -6845};