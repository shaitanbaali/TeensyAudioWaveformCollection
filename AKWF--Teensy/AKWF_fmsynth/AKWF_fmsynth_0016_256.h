/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0016 256 samples */
 
const int16_t AKWF_fmsynth_0016_256_DATA [256] = 
{3195, 7920, 12264, 16150, 19463, 22172, 24302, 25911, 27095, 27944, 28544, 28982, 29334, 29669, 30052, 30529, 31115, 31775, 32385, 32706, 32351, 30796, 27419, 21627, 13206, 2854, -8524, -19396, -27015, -29388, -25799, -16954, -4708, 8419, 20019, 28273, 32260, 32058, 28458, 22655, 15867, 9107, 3094, -2032, -6443, -10128, -13202, -15802, -18068, -20138, -22092, -23963, -25740, -27333, -28595, -29332, -29317, -28341, -26249, -23005, -18700, -13552, -7920, -2185, 3285, 8153, 12227, 15402, 17652, 19016, 19539, 19252, 18164, 16268, 13582, 10146, 6082, 1602, -3056, -7594, -11731, -15281, -18108, -20171, -21496, -22119, -22051, -21258, -19640, -17059, -13364, -8497, -2523, 4318, 11554, 18582, 24735, 29372, 32066, 32633, 31162, 27977, 23544, 18398, 12991, 7692, 2784, -1758, -6112, -10254, -14215, -17995, -21544, -24756, -27381, -29048, -29285, -27560, -23419, -16608, -7333, 3637, 14975, 24806, 31169, 32498, 28138, 18779, 6671, -5491, -16247, -23976, -28174, -29383, -28496, -26441, -23979, -21651, -19784, -18518, -17875, -17793, -18153, -18816, -19632, -20470, -21216, -21777, -22092, -22107, -21774, -21047, -19873, -18208, -16012, -13294, -10105, -6535, -2753, 1061, 4723, 8042, 10882, 13156, 14803, 15809, 16178, 15919, 15056, 13617, 11667, 9285, 6602, 3793, 1037, -1460, -3506, -4947, -5633, -5438, -4241, -1933, 1559, 6252, 11973, 18313, 24581, 29732, 32559, 31920, 27111, 18274, 6833, -5096, -16148, -24355, -28632, -29055, -26311, -21363, -15153, -8462, -1864, 4333, 9969, 14983, 19422, 23312, 26653, 29418, 31478, 32616, 32530, 30853, 27243, 21458, 13607, 4418, -5316, -14888, -22754, -27746, -29351, -27719, -23497, -17632, -11080, -4668, 992, 5583, 8977, 11163, 12222, 12235, 11286, 9447, 6820, 3557, -168, -4117, -8027, -11680, -14877, -17493, -19488, -20857, -21630, -21836, -21479, -20537, -18960, -16710, -13766, -10158, -6004, -1358};