/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0103 256 samples */
 
const int16_t AKWF_fmsynth_0103_256_DATA [256] = 
{314, 1445, 3197, 5559, 8523, 12124, 16254, 20629, 24818, 28302, 30739, 32104, 32644, 32760, 32766, 32748, 32591, 32116, 31228, 29978, 28544, 27156, 26031, 25339, 25183, 25597, 26553, 27942, 29567, 31147, 32328, 32770, 32223, 30639, 28211, 25344, 22561, 20247, 18674, 17856, 17606, 17624, 17576, 17129, 15954, 13708, 9967, 4168, -3883, -12091, -19119, -24586, -28398, -30746, -31999, -32545, -32721, -32756, -32747, -32669, -32391, -31724, -30505, -28706, -26509, -24378, -22954, -22823, -24220, -26801, -29767, -32040, -32763, -31587, -28774, -24951, -20810, -16960, -13719, -11249, -9546, -8603, -8390, -8869, -9989, -11692, -13886, -16432, -19107, -21646, -23786, -25349, -26209, -26324, -25655, -24176, -21882, -18891, -15449, -11861, -8409, -5272, -2474, -50, 1999, 3638, 4813, 5496, 5709, 5494, 4946, 4177, 3315, 2460, 1717, 1172, 889, 913, 1258, 1925, 2882, 4087, 5491, 7010, 8586, 10127, 11531, 12717, 13627, 14237, 14555, 14631, 14539, 14383, 14267, 14300, 14585, 15214, 16250, 17745, 19716, 22095, 24762, 27475, 29886, 31694, 32639, 32698, 32129, 31380, 30920, 30998, 31561, 32279, 32735, 32631, 31901, 30704, 29341, 28139, 27369, 27226, 27790, 29024, 30692, 32247, 32698, 30498, 23698, 9674, -9488, -22436, -28722, -31523, -32494, -32727, -32750, -32693, -32370, -31371, -29150, -25247, -19523, -12295, -4667, 1652, 4827, 4631, 885, -6174, -14511, -22269, -28166, -31597, -32761, -32190, -30604, -28627, -26721, -25147, -24019, -23363, -23134, -23243, -23575, -24008, -24418, -24692, -24737, -24486, -23897, -22954, -21672, -20119, -18392, -16616, -14902, -13366, -12090, -11132, -10516, -10250, -10307, -10650, -11215, -11910, -12620, -13229, -13597, -13604, -13160, -12208, -10748, -8839, -6593, -4129, -1530, 1339, 4048, 6705, 9217, 11410, 13101, 14144, 14449, 14014, 12914, 11298, 9339, 7247, 5194, 3328, 1764, 597, -87, -175};