/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0059 256 samples */
 
const int16_t AKWF_fmsynth_0059_256_DATA [256] = 
{2280, 10390, 17292, 21959, 24849, 26242, 26353, 25236, 22752, 18646, 12854, 5576, -2568, -10652, -17812, -23466, -27341, -29660, -30804, -31141, -30817, -29658, -27237, -23026, -16727, -8501, 1059, 10718, 19250, 25768, 29906, 31990, 32698, 32755, 32712, 32759, 32692, 32005, 30070, 26401, 20851, 13839, 6104, -1448, -7973, -12944, -16187, -17695, -17518, -15597, -11820, -6132, 1245, 9709, 18223, 25517, 30499, 32650, 32247, 30084, 27300, 24925, 23686, 23899, 25481, 27974, 30607, 32433, 32613, 30694, 26758, 21442, 15642, 10322, 6205, 3738, 3191, 4634, 8003, 12969, 18984, 25070, 29996, 32577, 32120, 28645, 22975, 16412, 10320, 5694, 3049, 2531, 4148, 7759, 12980, 19057, 24974, 29657, 32287, 32663, 31160, 28592, 25841, 23733, 22808, 23302, 25124, 27837, 30676, 32555, 32337, 29212, 23010, 14450, 5043, -3640, -10741, -15787, -18768, -19858, -19200, -16759, -12452, -6257, 1368, 9803, 17944, 24614, 29204, 31734, 32671, 32735, 32572, 32564, 32725, 32686, 31729, 28964, 23696, 15703, 5666, -4855, -14540, -22167, -27223, -30129, -31523, -32034, -32033, -31538, -30229, -27551, -23015, -16434, -8173, 654, 9092, 16285, 21581, 24981, 26784, 27296, 26590, 24478, 20564, 14495, 6216, -3509, -13603, -22469, -28728, -32005, -32762, -31889, -30449, -29296, -28937, -29500, -30747, -32105, -32774, -31920, -28965, -23782, -16943, -9487, -2574, 2885, 6568, 8262, 7847, 5297, 670, -5797, -13634, -21579, -28096, -31962, -32665, -30514, -26473, -21748, -17460, -14388, -12998, -13424, -15594, -19174, -23550, -27877, -31205, -32736, -32049, -29339, -25349, -21035, -17417, -15228, -14876, -16429, -19683, -24038, -28477, -31765, -32747, -30789, -25982, -19131, -11485, -4223, 1735, 5913, 8167, 8456, 6821, 3319, -1836, -8287, -15324, -22021, -27451, -31022, -32608, -32620, -31769, -30835, -30415, -30742, -31655, -32576, -32626, -30875, -26696, -20045, -11287, -1973};