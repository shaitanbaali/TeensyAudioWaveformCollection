/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0042 256 samples */
 
const int16_t AKWF_fmsynth_0042_256_DATA [256] = 
{1680, 5754, 9621, 13303, 16733, 19862, 22655, 25084, 27145, 28841, 30185, 31205, 31934, 32408, 32671, 32767, 32739, 32624, 32463, 32286, 32120, 31984, 31893, 31855, 31873, 31945, 32060, 32203, 32360, 32506, 32615, 32667, 32631, 32483, 32199, 31757, 31145, 30345, 29353, 28173, 26807, 25269, 23585, 21769, 19848, 17865, 15840, 13812, 11817, 9878, 8033, 6306, 4718, 3292, 2049, 996, 151, -480, -890, -1071, -1015, -721, -189, 583, 1601, 2856, 4341, 6052, 7962, 10058, 12311, 14679, 17124, 19595, 22025, 24359, 26527, 28450, 30069, 31310, 32113, 32432, 32227, 31483, 30193, 28375, 26074, 23331, 20228, 16854, 13291, 9656, 6045, 2546, -751, -3891, -6888, -9664, -12186, -14443, -16417, -18118, -19555, -20738, -21687, -22419, -22945, -23279, -23433, -23407, -23210, -22838, -22289, -21559, -20641, -19534, -18226, -16721, -15025, -13136, -11074, -8860, -6515, -4080, -1600, 900, 3446, 6021, 8581, 11071, 13459, 15714, 17801, 19709, 21425, 22941, 24260, 25390, 26340, 27119, 27744, 28226, 28575, 28808, 28925, 28929, 28820, 28593, 28236, 27733, 27066, 26208, 25137, 23827, 22248, 20384, 18219, 15733, 12947, 9877, 6552, 3053, -544, -4281, -8148, -12039, -15841, -19430, -22720, -25628, -28071, -30018, -31437, -32319, -32679, -32546, -31968, -30992, -29683, -28114, -26342, -24439, -22474, -20495, -18561, -16719, -14997, -13433, -12055, -10874, -9908, -9169, -8657, -8374, -8322, -8498, -8894, -9501, -10309, -11304, -12469, -13787, -15228, -16773, -18393, -20049, -21718, -23364, -24947, -26443, -27819, -29045, -30103, -30975, -31648, -32123, -32403, -32497, -32419, -32190, -31836, -31388, -30874, -30328, -29778, -29254, -28786, -28395, -28101, -27919, -27858, -27924, -28113, -28423, -28838, -29336, -29895, -30479, -31053, -31573, -31987, -32246, -32303, -32106, -31603, -30755, -29537, -27916, -25886, -23455, -20633, -17457, -13976, -10247, -6344, -2250};