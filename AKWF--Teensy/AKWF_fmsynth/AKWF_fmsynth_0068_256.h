/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0068 256 samples */
 
const int16_t AKWF_fmsynth_0068_256_DATA [256] = 
{212, 541, 874, 1228, 1595, 1983, 2387, 2808, 3249, 3707, 4183, 4680, 5201, 5740, 6303, 6885, 7492, 8126, 8784, 9468, 10177, 10913, 11677, 12469, 13288, 14135, 15003, 15901, 16823, 17769, 18734, 19712, 20705, 21709, 22718, 23728, 24728, 25710, 26677, 27611, 28504, 29350, 30129, 30834, 31456, 31973, 32374, 32644, 32765, 32719, 32488, 32053, 31397, 30497, 29331, 27874, 26109, 24013, 21572, 18739, 15506, 11836, 7720, 3129, -1861, -6583, -10751, -14460, -17722, -20561, -23043, -25173, -26983, -28502, -29746, -30743, -31523, -32094, -32481, -32701, -32768, -32702, -32514, -32217, -31824, -31348, -30800, -30183, -29512, -28796, -28036, -27249, -26434, -25595, -24741, -23877, -23005, -22136, -21262, -20389, -19525, -18674, -17827, -16994, -16174, -15366, -14579, -13809, -13052, -12315, -11595, -10890, -10211, -9545, -8894, -8263, -7648, -7048, -6469, -5902, -5350, -4813, -4288, -3782, -3288, -2802, -2330, -1871, -1424, -989, -564, -150, 253, 646, 1026, 1397, 1757, 2107, 2444, 2771, 3085, 3389, 3679, 3957, 4224, 4476, 4715, 4940, 5154, 5351, 5534, 5702, 5856, 5996, 6119, 6228, 6322, 6399, 6462, 6510, 6542, 6560, 6563, 6550, 6523, 6482, 6429, 6362, 6282, 6188, 6083, 5966, 5840, 5701, 5551, 5394, 5227, 5053, 4868, 4677, 4481, 4277, 4067, 3855, 3637, 3415, 3188, 2959, 2729, 2497, 2263, 2027, 1793, 1558, 1326, 1093, 861, 632, 404, 180, -39, -257, -470, -680, -884, -1083, -1278, -1465, -1647, -1824, -1992, -2152, -2306, -2453, -2591, -2719, -2841, -2954, -3057, -3151, -3235, -3310, -3374, -3429, -3475, -3510, -3534, -3550, -3553, -3547, -3532, -3505, -3469, -3424, -3367, -3301, -3224, -3140, -3045, -2940, -2827, -2704, -2572, -2434, -2285, -2129, -1964, -1791, -1611, -1422, -1226, -1023, -812, -594, -376, -123};