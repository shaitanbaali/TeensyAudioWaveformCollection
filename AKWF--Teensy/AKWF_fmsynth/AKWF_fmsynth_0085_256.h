/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0085 256 samples */
 
const int16_t AKWF_fmsynth_0085_256_DATA [256] = 
{1256, 3484, 5617, 7693, 9695, 11604, 13436, 15166, 16799, 18330, 19746, 21059, 22273, 23380, 24390, 25307, 26125, 26865, 27524, 28108, 28625, 29081, 29477, 29827, 30131, 30395, 30625, 30824, 30996, 31146, 31276, 31390, 31492, 31581, 31663, 31738, 31808, 31876, 31942, 32008, 32074, 32143, 32213, 32285, 32358, 32432, 32508, 32579, 32644, 32701, 32744, 32766, 32763, 32725, 32642, 32506, 32302, 32017, 31634, 31140, 30514, 29731, 28773, 27617, 26231, 24606, 22691, 20461, 17898, 14955, 11623, 7868, 3626, -1074, -5686, -9908, -13730, -17186, -20263, -22965, -25295, -27271, -28909, -30230, -31252, -31994, -32475, -32722, -32759, -32605, -32285, -31820, -31236, -30549, -29777, -28943, -28057, -27142, -26214, -25272, -24338, -23418, -22523, -21659, -20827, -20033, -19286, -18582, -17928, -17319, -16756, -16239, -15765, -15333, -14941, -14582, -14254, -13954, -13677, -13418, -13172, -12936, -12701, -12465, -12223, -11967, -11693, -11397, -11071, -10713, -10320, -9879, -9392, -8852, -8254, -7597, -6877, -6085, -5224, -4289, -3275, -2195, -1030, 213, 1530, 2923, 4386, 5904, 7496, 9139, 10824, 12538, 14283, 16037, 17796, 19533, 21232, 22882, 24470, 25970, 27370, 28644, 29773, 30751, 31551, 32162, 32567, 32755, 32718, 32442, 31926, 31168, 30160, 28923, 27442, 25735, 23816, 21691, 19388, 16936, 14321, 11592, 8772, 5871, 2947, -3, -2807, -5304, -7529, -9512, -11259, -12818, -14199, -15417, -16495, -17442, -18273, -19010, -19658, -20228, -20733, -21177, -21575, -21934, -22262, -22561, -22844, -23118, -23385, -23655, -23931, -24215, -24518, -24840, -25184, -25556, -25951, -26373, -26824, -27299, -27795, -28310, -28833, -29363, -29891, -30407, -30901, -31360, -31775, -32135, -32425, -32633, -32749, -32759, -32654, -32424, -32058, -31551, -30901, -30100, -29146, -28040, -26784, -25384, -23852, -22183, -20394, -18493, -16495, -14423, -12279, -10075, -7839, -5579, -3337, -1017};