/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0090 256 samples */
 
const int16_t AKWF_fmsynth_0090_256_DATA [256] = 
{189, 859, 1536, 2240, 2967, 3715, 4492, 5283, 6100, 6941, 7791, 8665, 9552, 10450, 11367, 12292, 13216, 14158, 15096, 16039, 16984, 17916, 18844, 19765, 20672, 21566, 22444, 23295, 24130, 24932, 25711, 26460, 27173, 27851, 28492, 29093, 29655, 30171, 30642, 31069, 31449, 31782, 32067, 32303, 32489, 32627, 32720, 32765, 32763, 32715, 32625, 32493, 32321, 32111, 31863, 31582, 31272, 30931, 30564, 30177, 29765, 29339, 28896, 28438, 27975, 27505, 27028, 26552, 26074, 25600, 25133, 24672, 24221, 23778, 23347, 22928, 22526, 22138, 21765, 21406, 21065, 20741, 20431, 20138, 19860, 19596, 19348, 19111, 18886, 18675, 18472, 18276, 18088, 17903, 17725, 17548, 17373, 17196, 17015, 16831, 16638, 16437, 16226, 16003, 15766, 15511, 15238, 14944, 14627, 14286, 13916, 13514, 13080, 12613, 12104, 11560, 10968, 10327, 9641, 8901, 8100, 7246, 6321, 5328, 4271, 3127, 1912, 609, -776, -2183, -3599, -5038, -6468, -7908, -9347, -10768, -12183, -13578, -14946, -16298, -17618, -18892, -20138, -21332, -22482, -23586, -24631, -25616, -26549, -27424, -28230, -28973, -29652, -30257, -30803, -31281, -31688, -32030, -32305, -32515, -32662, -32746, -32769, -32735, -32642, -32495, -32298, -32054, -31760, -31427, -31054, -30641, -30195, -29723, -29217, -28691, -28144, -27574, -26993, -26400, -25795, -25184, -24567, -23948, -23332, -22715, -22105, -21501, -20904, -20318, -19744, -19181, -18633, -18099, -17582, -17083, -16599, -16132, -15684, -15257, -14849, -14457, -14086, -13732, -13395, -13080, -12779, -12499, -12234, -11984, -11749, -11529, -11325, -11132, -10951, -10781, -10620, -10469, -10326, -10190, -10057, -9930, -9806, -9683, -9564, -9442, -9318, -9193, -9062, -8928, -8786, -8637, -8480, -8311, -8131, -7941, -7738, -7519, -7286, -7034, -6767, -6481, -6174, -5850, -5505, -5133, -4746, -4329, -3890, -3432, -2947, -2437, -1899, -1345, -729, -205};