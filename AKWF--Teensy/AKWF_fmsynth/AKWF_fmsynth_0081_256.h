/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0081 256 samples */
 
const int16_t AKWF_fmsynth_0081_256_DATA [256] = 
{1013, 2438, 3259, 3704, 3953, 4163, 4446, 4854, 5383, 6001, 6654, 7287, 7842, 8266, 8526, 8620, 8574, 8456, 8362, 8400, 8676, 9268, 10219, 11548, 13224, 15191, 17419, 19812, 22284, 24757, 27091, 29185, 30913, 32129, 32725, 32625, 31807, 30303, 28238, 25816, 23311, 20991, 19168, 18062, 17809, 18389, 19625, 21203, 22686, 23631, 23670, 22639, 20558, 17674, 14344, 10908, 7666, 4836, 2548, 992, 290, 500, 1555, 3314, 5564, 8067, 10616, 13002, 14970, 16254, 16504, 15420, 12834, 8910, 3903, -1972, -8079, -13824, -18889, -23080, -26399, -28812, -30282, -30741, -30146, -28485, -25862, -22499, -18764, -15100, -11896, -9586, -8447, -8633, -10116, -12746, -16205, -20058, -23851, -27160, -29629, -31101, -31488, -30849, -29327, -27147, -24539, -21747, -19037, -16649, -14773, -13575, -13127, -13464, -14540, -16249, -18417, -20840, -23281, -25480, -27156, -28044, -27911, -26563, -23897, -19911, -14771, -8808, -2430, 3860, 9542, 14194, 17502, 19321, 19654, 18585, 16286, 12994, 9040, 4776, 588, -3048, -5757, -7204, -7211, -5686, -2688, 1608, 6894, 12748, 18619, 23877, 27917, 30334, 31016, 30154, 28175, 25629, 23056, 20872, 19321, 18479, 18312, 18705, 19534, 20710, 22194, 23942, 25900, 27949, 29894, 31480, 32419, 32391, 31159, 28611, 24883, 20206, 15076, 10057, 5657, 2311, 286, -373, 292, 2093, 4761, 7926, 11254, 14385, 16979, 18776, 19612, 19416, 18192, 16028, 13075, 9539, 5578, 1442, -2655, -6463, -9812, -12678, -14933, -16443, -17218, -17360, -17073, -16609, -16230, -16148, -16485, -17247, -18336, -19600, -20833, -21860, -22576, -22943, -23009, -22871, -22643, -22431, -22299, -22226, -22093, -21717, -20916, -19597, -17860, -15970, -14303, -13257, -13118, -14004, -15840, -18424, -21409, -24387, -26932, -28701, -29473, -29209, -28023, -26161, -23912, -21470, -18986, -16479, -13876, -11158, -8316, -5466, -2809, -576};