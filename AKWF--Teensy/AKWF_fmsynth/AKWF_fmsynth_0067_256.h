/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0067 256 samples */
 
const int16_t AKWF_fmsynth_0067_256_DATA [256] = 
{142, 486, 836, 1208, 1599, 2010, 2443, 2893, 3368, 3867, 4385, 4927, 5493, 6084, 6702, 7346, 8013, 8712, 9433, 10185, 10966, 11775, 12613, 13475, 14361, 15275, 16213, 17170, 18143, 19126, 20122, 21121, 22125, 23120, 24100, 25062, 26003, 26911, 27781, 28601, 29365, 30070, 30706, 31269, 31749, 32141, 32443, 32649, 32755, 32762, 32669, 32472, 32173, 31776, 31283, 30701, 30035, 29288, 28467, 27586, 26650, 25672, 24656, 23616, 22559, 21496, 20447, 19409, 18392, 17410, 16468, 15574, 14742, 13962, 13251, 12608, 12036, 11541, 11119, 10769, 10495, 10292, 10157, 10089, 10083, 10134, 10241, 10395, 10592, 10827, 11094, 11389, 11704, 12036, 12376, 12722, 13069, 13412, 13743, 14062, 14365, 14645, 14900, 15126, 15318, 15476, 15594, 15669, 15698, 15678, 15604, 15475, 15282, 15025, 14697, 14296, 13812, 13238, 12569, 11796, 10911, 9910, 8768, 7483, 6039, 4418, 2621, 610, -1578, -3801, -6031, -8261, -10451, -12621, -14739, -16784, -18752, -20619, -22376, -24024, -25545, -26929, -28172, -29264, -30212, -31010, -31655, -32149, -32499, -32704, -32772, -32712, -32525, -32226, -31817, -31310, -30715, -30039, -29301, -28502, -27650, -26759, -25836, -24886, -23930, -22957, -21979, -21010, -20046, -19099, -18170, -17255, -16364, -15500, -14662, -13857, -13077, -12326, -11606, -10915, -10257, -9629, -9028, -8454, -7908, -7393, -6903, -6439, -6000, -5585, -5195, -4832, -4489, -4167, -3868, -3590, -3333, -3098, -2880, -2683, -2505, -2345, -2203, -2076, -1968, -1876, -1799, -1736, -1689, -1654, -1631, -1622, -1624, -1634, -1656, -1688, -1725, -1771, -1822, -1880, -1941, -2006, -2072, -2142, -2212, -2281, -2349, -2415, -2478, -2536, -2590, -2638, -2678, -2711, -2735, -2749, -2753, -2746, -2728, -2696, -2650, -2590, -2518, -2428, -2323, -2200, -2063, -1909, -1736, -1544, -1337, -1111, -866, -604, -307, -75};