/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0006 256 samples */
 
const int16_t AKWF_fmsynth_0006_256_DATA [256] = 
{1596, 6421, 10796, 14787, 18312, 21349, 23896, 25962, 27594, 28842, 29756, 30402, 30835, 31107, 31265, 31349, 31386, 31397, 31398, 31392, 31384, 31369, 31345, 31303, 31240, 31151, 31036, 30896, 30737, 30566, 30395, 30236, 30102, 30009, 29968, 29986, 30069, 30216, 30414, 30648, 30888, 31095, 31215, 31187, 30934, 30378, 29425, 27989, 25996, 23371, 20084, 16147, 11601, 6579, 1313, -4069, -9602, -15029, -20065, -24447, -27993, -30588, -32167, -32738, -32357, -31129, -29180, -26658, -23727, -20529, -17203, -13881, -10655, -7603, -4795, -2260, -25, 1895, 3510, 4823, 5845, 6596, 7092, 7355, 7406, 7266, 6957, 6504, 5931, 5267, 4537, 3770, 3000, 2250, 1555, 944, 445, 84, -111, -117, 87, 521, 1206, 2151, 3371, 4868, 6635, 8671, 10948, 13422, 16056, 18772, 21480, 24087, 26467, 28487, 30021, 30934, 31108, 30447, 28895, 26437, 23101, 18992, 14262, 9100, 3780, -1425, -6534, -11475, -16030, -20070, -23502, -26317, -28530, -30185, -31354, -32117, -32552, -32741, -32757, -32663, -32511, -32345, -32196, -32082, -32016, -32001, -32033, -32106, -32205, -32319, -32434, -32535, -32611, -32656, -32665, -32638, -32580, -32498, -32403, -32310, -32229, -32174, -32154, -32175, -32233, -32323, -32427, -32515, -32551, -32488, -32269, -31828, -31094, -29998, -28475, -26461, -23919, -20833, -17195, -13050, -8477, -3554, 1568, 6736, 11802, 16570, 20875, 24584, 27555, 29709, 31005, 31436, 31042, 29902, 28124, 25836, 23172, 20287, 17301, 14334, 11499, 8859, 6473, 4381, 2591, 1109, -70, -968, -1612, -2010, -2184, -2153, -1938, -1566, -1065, -466, 209, 933, 1676, 2407, 3095, 3707, 4214, 4590, 4804, 4832, 4650, 4238, 3572, 2643, 1433, -57, -1834, -3945, -6386, -9122, -12122, -15309, -18575, -21816, -24881, -27614, -29871, -31498, -32365, -32377, -31473, -29642, -26908, -23359, -19116, -14327, -9186, -3752};