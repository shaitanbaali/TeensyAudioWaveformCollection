/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0026 256 samples */
 
const int16_t AKWF_fmsynth_0026_256_DATA [256] = 
{2641, 9280, 13847, 16511, 17256, 16088, 12993, 8010, 1217, -7351, -17676, -28765, -32255, 3063, 33068, 21517, 2338, -18722, -32815, 10885, 30636, 5832, -20264, -28439, 22576, 23686, -3721, -30269, -11142, 32344, 14677, -8710, -31055, -16159, 29994, 25052, 7031, -8703, -23053, -32190, -28274, -3665, 21681, 29996, 31966, 32148, 32134, 32074, 30752, 24795, 3167, -24735, -32782, -25405, -11385, 4408, 22450, 31978, -11385, -32088, -9547, 15030, 31426, -15440, -27759, 1109, 29864, 5529, -32478, -7218, 22507, 22666, -28588, -19528, 6627, 30704, 12128, -32389, -21610, -2209, 14859, 29199, 30115, -56, -28968, -32630, -29514, -25489, -22494, -21173, -21679, -23955, -27636, -31482, -32462, -17334, 19144, 32656, 22973, 6967, -10326, -30209, -20256, 28238, 23119, -720, -26696, -20106, 29590, 18007, -8841, -32802, 1803, 31992, 7358, -17083, -32711, 10228, 32002, 11296, -7564, -25123, -32933, -3181, 30501, 30577, 22606, 14500, 7953, 3304, 552, -305, 741, 3699, 8573, 15339, 23610, 31436, 28078, -10099, -33582, -22027, -3754, 16393, 33120, -6351, -32270, -8109, 18949, 27546, -23979, -22030, 8127, 31990, -8930, -29550, -705, 27517, 15290, -31824, -16881, 6838, 29007, 21052, -26687, -29090, -12510, 1970, 14995, 25796, 31731, 30760, 23672, 14314, 7669, 7273, 13315, 22583, 30156, 31989, 26918, 16724, 4094, -9948, -25854, -31969, 10305, 32444, 12906, -8710, -32226, -6977, 32560, 11910, -14418, -32265, 13523, 28401, 1366, -24883, -24193, 26573, 23480, 184, -20374, -33594, 249, 33195, 24212, 10425, -1819, -12460, -21356, -27709, -31187, -32457, -32679, -32637, -32092, -29972, -25210, -17559, -7694, 3795, 16985, 31161, 22367, -24406, -29092, -8191, 14042, 32754, -8461, -31011, -4369, 24657, 18691, -30712, -14602, 15667, 29332, -20997, -24319, 4085, 30168, 10626, -32948, -17385, 4090, 23648, 32041, -4365, -33639, -26821, -15588, -5348};