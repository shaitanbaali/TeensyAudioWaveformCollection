/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0087 256 samples */
 
const int16_t AKWF_fmsynth_0087_256_DATA [256] = 
{156, 802, 1517, 2270, 3075, 3925, 4821, 5751, 6715, 7717, 8741, 9787, 10849, 11910, 12982, 14051, 15107, 16150, 17170, 18155, 19119, 20043, 20926, 21768, 22560, 23306, 24005, 24654, 25254, 25804, 26304, 26764, 27177, 27550, 27884, 28177, 28437, 28669, 28870, 29044, 29196, 29327, 29440, 29538, 29623, 29696, 29763, 29824, 29882, 29938, 29996, 30057, 30124, 30198, 30280, 30374, 30478, 30594, 30725, 30866, 31019, 31182, 31353, 31533, 31712, 31894, 32071, 32238, 32393, 32529, 32639, 32719, 32764, 32764, 32715, 32612, 32450, 32224, 31933, 31570, 31137, 30630, 30050, 29402, 28689, 27910, 27077, 26194, 25267, 24309, 23327, 22327, 21325, 20325, 19340, 18386, 17459, 16572, 15730, 14940, 14207, 13535, 12918, 12363, 11863, 11420, 11026, 10678, 10368, 10091, 9840, 9606, 9381, 9153, 8916, 8660, 8377, 8054, 7685, 7259, 6768, 6202, 5553, 4808, 3960, 2998, 1914, 704, -642, -2076, -3572, -5127, -6718, -8336, -9983, -11628, -13266, -14887, -16460, -17996, -19478, -20891, -22232, -23491, -24658, -25746, -26743, -27646, -28461, -29183, -29820, -30379, -30861, -31270, -31614, -31898, -32131, -32317, -32461, -32571, -32650, -32705, -32741, -32761, -32768, -32767, -32759, -32747, -32733, -32716, -32702, -32684, -32669, -32655, -32641, -32627, -32612, -32598, -32581, -32564, -32542, -32517, -32488, -32453, -32409, -32356, -32292, -32215, -32123, -32010, -31877, -31721, -31537, -31323, -31075, -30789, -30464, -30095, -29684, -29225, -28719, -28163, -27560, -26910, -26214, -25474, -24692, -23875, -23029, -22148, -21248, -20332, -19400, -18471, -17545, -16621, -15709, -14820, -13953, -13122, -12319, -11552, -10827, -10145, -9510, -8920, -8375, -7875, -7424, -7016, -6653, -6328, -6041, -5788, -5569, -5377, -5205, -5053, -4916, -4787, -4662, -4536, -4404, -4262, -4105, -3926, -3723, -3491, -3226, -2925, -2584, -2198, -1768, -1295, -752, -201};