/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0039 256 samples */
 
const int16_t AKWF_fmsynth_0039_256_DATA [256] = 
{609, 2295, 3981, 5516, 6715, 7479, 7821, 7837, 7704, 7636, 7826, 8413, 9427, 10797, 12360, 13907, 15239, 16236, 16827, 17050, 17020, 16899, 16877, 17118, 17720, 18682, 19908, 21227, 22471, 23494, 24206, 24598, 24716, 24662, 24574, 24594, 24842, 25370, 26142, 27068, 28005, 28826, 29446, 29849, 30048, 30089, 30046, 29999, 30038, 30225, 30573, 31035, 31527, 31958, 32274, 32474, 32577, 32617, 32621, 32610, 32600, 32617, 32668, 32734, 32770, 32729, 32596, 32394, 32190, 32040, 31975, 31979, 32011, 32018, 31962, 31804, 31504, 31041, 30429, 29733, 29060, 28525, 28199, 28084, 28118, 28193, 28190, 28008, 27575, 26863, 25892, 24752, 23575, 22536, 21778, 21363, 21256, 21338, 21437, 21382, 21033, 20308, 19211, 17804, 16249, 14752, 13518, 12677, 12265, 12201, 12324, 12420, 12283, 11766, 10795, 9411, 7741, 6003, 4431, 3209, 2429, 2095, 2093, 2234, 2295, 2074, 1435, 353, -1110, -2804, -4513, -6031, -7158, -7830, -8077, -8027, -7884, -7871, -8179, -8923, -10107, -11618, -13284, -14870, -16185, -17106, -17610, -17753, -17677, -17560, -17599, -17950, -18689, -19777, -21095, -22453, -23664, -24616, -25240, -25547, -25605, -25527, -25455, -25528, -25851, -26450, -27272, -28181, -29056, -29780, -30299, -30608, -30741, -30751, -30701, -30675, -30741, -30951, -31291, -31701, -32096, -32406, -32600, -32698, -32737, -32749, -32749, -32743, -32740, -32750, -32767, -32760, -32684, -32515, -32255, -31965, -31713, -31553, -31499, -31519, -31559, -31551, -31450, -31213, -30807, -30233, -29520, -28763, -28078, -27573, -27298, -27234, -27295, -27359, -27312, -27055, -26535, -25732, -24692, -23525, -22387, -21439, -20795, -20480, -20442, -20546, -20617, -20492, -20058, -19253, -18096, -16692, -15209, -13842, -12761, -12078, -11790, -11801, -11931, -11977, -11759, -11145, -10101, -8695, -7067, -5420, -3978, -2901, -2273, -2050, -2109, -2248, -2244, -1944, -1114, -230};