/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0082 256 samples */
 
const int16_t AKWF_fmsynth_0082_256_DATA [256] = 
{388, 2033, 3140, 3616, 3700, 3661, 3813, 4454, 5819, 8014, 11033, 14709, 18752, 22771, 26366, 29171, 30925, 31484, 30867, 29233, 26863, 24059, 21184, 18567, 16524, 15314, 15116, 15999, 17913, 20663, 23906, 27182, 30057, 32043, 32799, 32156, 30182, 27150, 23460, 19647, 16180, 13445, 11697, 10976, 11201, 12146, 13493, 14887, 16003, 16575, 16442, 15572, 14075, 12127, 10008, 8005, 6401, 5409, 5148, 5630, 6773, 8380, 10148, 11690, 12606, 12493, 11068, 8254, 4194, -852, -6479, -12153, -17471, -22086, -25706, -28213, -29504, -29599, -28639, -26862, -24603, -22186, -19998, -18353, -17482, -17509, -18439, -20153, -22416, -24912, -27302, -29247, -30523, -30981, -30616, -29550, -27946, -26024, -23972, -21919, -19977, -18221, -16723, -15620, -15007, -14938, -15362, -16135, -17009, -17697, -17937, -17537, -16414, -14597, -12261, -9670, -7135, -5003, -3555, -2990, -3408, -4759, -6865, -9404, -12020, -14281, -15782, -16187, -15285, -12983, -9332, -4537, 1038, 6961, 12663, 17665, 21488, 23855, 24706, 24241, 22827, 20929, 19011, 17476, 16611, 16563, 17357, 18904, 21021, 23421, 25803, 27853, 29273, 29862, 29532, 28339, 26451, 24156, 21815, 19789, 18412, 17920, 18411, 19832, 21945, 24370, 26602, 28159, 28599, 27671, 25364, 21914, 17714, 13260, 9059, 5563, 3129, 1956, 2103, 3485, 5878, 8950, 12287, 15489, 18173, 19968, 20626, 20009, 18157, 15193, 11419, 7198, 2901, -1088, -4500, -7201, -9123, -10366, -11092, -11521, -11862, -12299, -12973, -13977, -15377, -17218, -19491, -22107, -24883, -27541, -29779, -31251, -31712, -31054, -29364, -26882, -23969, -21083, -18626, -16944, -16239, -16571, -17871, -19950, -22550, -25335, -27974, -30163, -31578, -32003, -31291, -29440, -26505, -22699, -18338, -13787, -9474, -5846, -3203, -1835, -1834, -3134, -5488, -8550, -11888, -15023, -17520, -19051, -19417, -18600, -16717, -14023, -10853, -7491, -4274, -1384};