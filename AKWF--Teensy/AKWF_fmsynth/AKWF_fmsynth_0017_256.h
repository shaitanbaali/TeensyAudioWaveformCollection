/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0017 256 samples */
 
const int16_t AKWF_fmsynth_0017_256_DATA [256] = 
{2540, 9784, 16294, 21691, 25681, 28233, 29549, 29969, 29873, 29590, 29352, 29269, 29351, 29539, 29743, 29889, 29944, 29926, 29892, 29893, 29918, 29833, 29297, 27722, 24309, 18204, 8920, -2727, -15537, -26764, -32528, -30639, -21247, -6838, 8731, 21519, 28704, 29395, 24499, 16148, 6753, -1724, -8672, -14107, -17971, -20521, -22099, -22978, -23399, -23574, -23691, -23930, -24451, -25364, -26707, -28410, -30253, -31863, -32734, -32304, -30076, -25775, -19494, -11686, -3102, 5334, 12840, 18887, 23265, 26116, 27766, 28575, 28848, 28709, 28107, 26825, 24576, 21119, 16337, 10380, 3660, -3281, -9821, -15448, -19890, -23054, -25014, -25916, -25826, -24701, -22348, -18507, -12963, -5704, 2858, 11900, 20239, 26526, 29679, 29157, 25149, 18515, 10524, 2573, -4451, -10473, -15305, -18957, -21621, -23534, -24943, -26054, -27040, -28050, -29167, -30393, -31613, -32521, -32615, -31187, -27462, -20813, -11070, 1021, 13687, 24264, 29725, 27849, 18334, 3936, -11096, -23632, -30887, -32635, -30271, -25641, -20359, -15558, -11876, -9559, -8631, -8976, -10394, -12625, -15365, -18300, -21124, -23593, -25568, -26979, -27826, -28134, -27893, -27041, -25442, -22940, -19395, -14743, -9116, -2798, 3783, 10096, 15695, 20269, 23681, 26008, 27439, 28196, 28464, 28328, 27764, 26644, 24814, 22164, 18662, 14454, 9840, 5185, 919, -2579, -5035, -6226, -5999, -4213, -769, 4324, 10843, 18080, 24805, 29274, 29555, 24235, 13310, -724, -14901, -26244, -32004, -31893, -27136, -19597, -11038, -2783, 4380, 10199, 14695, 18061, 20574, 22487, 24013, 25340, 26582, 27781, 28897, 29747, 29992, 29110, 26452, 21374, 13477, 3264, -8085, -19419, -28205, -32433, -31442, -25844, -17153, -7212, 2297, 10313, 16369, 20477, 22964, 24186, 24397, 23697, 22035, 19300, 15397, 10382, 4517, -1804, -8048, -13715, -18464, -22106, -24636, -26171, -26833, -26694, -25725, -23807, -20774, -16500, -11007, -4327};