/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0069 256 samples */
 
const int16_t AKWF_fmsynth_0069_256_DATA [256] = 
{293, 1058, 1954, 3004, 4200, 5570, 7116, 8840, 10763, 12870, 15156, 17610, 20170, 22756, 25286, 27620, 29659, 31267, 32329, 32760, 32524, 31625, 30124, 28124, 25783, 23277, 20799, 18506, 16561, 15074, 14121, 13716, 13836, 14417, 15377, 16613, 18016, 19480, 20936, 22299, 23526, 24579, 25429, 26070, 26497, 26695, 26649, 26329, 25694, 24658, 23118, 20931, 17906, 13783, 8251, 806, -7515, -14893, -21049, -25921, -29427, -31634, -32651, -32656, -31842, -30414, -28566, -26470, -24278, -22111, -20024, -18095, -16348, -14804, -13476, -12355, -11430, -10703, -10160, -9792, -9593, -9548, -9651, -9889, -10250, -10723, -11291, -11945, -12662, -13421, -14207, -14986, -15743, -16455, -17089, -17625, -18042, -18318, -18438, -18390, -18160, -17746, -17138, -16341, -15364, -14218, -12930, -11518, -9999, -8416, -6781, -5117, -3454, -1768, -69, 1644, 3395, 5179, 6991, 8853, 10723, 12584, 14412, 16152, 17786, 19287, 20617, 21764, 22721, 23480, 24055, 24449, 24671, 24735, 24655, 24444, 24117, 23690, 23187, 22626, 22033, 21428, 20836, 20283, 19796, 19391, 19094, 18921, 18891, 19019, 19318, 19798, 20472, 21340, 22411, 23656, 25071, 26617, 28223, 29798, 31209, 32268, 32761, 32388, 30821, 27666, 22564, 15142, 4793, -7114, -16444, -22991, -27425, -30245, -31855, -32603, -32763, -32562, -32161, -31677, -31197, -30777, -30453, -30245, -30156, -30184, -30318, -30538, -30824, -31152, -31493, -31823, -32123, -32370, -32556, -32680, -32747, -32768, -32762, -32746, -32738, -32743, -32760, -32767, -32734, -32615, -32355, -31903, -31211, -30247, -28992, -27450, -25646, -23628, -21457, -19205, -16914, -14660, -12477, -10409, -8478, -6685, -5024, -3499, -2097, -820, 329, 1371, 2288, 3078, 3737, 4256, 4636, 4879, 4985, 4960, 4816, 4566, 4221, 3795, 3312, 2782, 2224, 1663, 1102, 564, 69, -373, -746, -1032, -1222, -1300, -1258, -1085, -778, -316};