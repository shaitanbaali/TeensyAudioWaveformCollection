/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0110 256 samples */
 
const int16_t AKWF_fmsynth_0110_256_DATA [256] = 
{1884, 6993, 11481, 15440, 18857, 21766, 24226, 26289, 28022, 29468, 30642, 31559, 32219, 32618, 32766, 32685, 32404, 31960, 31388, 30717, 29961, 29131, 28231, 27254, 26207, 25100, 23943, 22765, 21590, 20438, 19330, 18275, 17267, 16303, 15368, 14447, 13536, 12628, 11725, 10841, 9985, 9170, 8408, 7702, 7052, 6454, 5892, 5355, 4835, 4318, 3802, 3293, 2792, 2312, 1866, 1459, 1098, 784, 510, 268, 48, -160, -366, -571, -769, -954, -1114, -1239, -1319, -1348, -1328, -1266, -1169, -1051, -921, -785, -644, -494, -326, -129, 107, 390, 725, 1109, 1537, 1997, 2479, 2976, 3482, 3996, 4527, 5083, 5677, 6325, 7035, 7813, 8663, 9574, 10540, 11552, 12595, 13665, 14765, 15895, 17072, 18308, 19606, 20977, 22411, 23879, 25361, 26809, 28176, 29426, 30516, 31406, 32060, 32426, 32432, 31981, 30945, 29173, 26485, 22720, 17719, 11336, 3349, -5418, -12809, -18674, -23297, -26823, -29353, -30993, -31829, -31952, -31471, -30501, -29164, -27563, -25788, -23908, -21959, -19972, -17976, -15975, -13996, -12063, -10188, -8394, -6693, -5078, -3549, -2093, -680, 705, 2091, 3505, 4960, 6477, 8067, 9722, 11438, 13202, 14988, 16783, 18573, 20339, 22085, 23799, 25462, 27059, 28546, 29869, 30977, 31806, 32308, 32447, 32200, 31554, 30490, 28984, 26992, 24445, 21284, 17447, 12881, 7612, 1631, -4409, -9484, -13665, -17131, -20005, -22416, -24460, -26191, -27651, -28863, -29834, -30585, -31138, -31520, -31767, -31910, -31979, -31996, -31974, -31921, -31841, -31736, -31610, -31469, -31322, -31181, -31057, -30958, -30892, -30855, -30843, -30846, -30859, -30876, -30895, -30919, -30950, -30996, -31064, -31152, -31261, -31383, -31505, -31616, -31703, -31760, -31782, -31766, -31711, -31611, -31452, -31221, -30887, -30425, -29804, -28993, -27978, -26753, -25311, -23663, -21804, -19699, -17309, -14560, -11355, -7606, -3072};