/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0088 256 samples */
 
const int16_t AKWF_fmsynth_0088_256_DATA [256] = 
{1299, 3388, 5154, 6624, 7759, 8581, 9139, 9500, 9759, 10015, 10363, 10894, 11673, 12731, 14086, 15693, 17480, 19368, 21235, 22994, 24574, 25910, 26981, 27797, 28389, 28789, 29048, 29215, 29341, 29478, 29673, 29961, 30355, 30844, 31389, 31928, 32383, 32682, 32768, 32622, 32267, 31761, 31188, 30629, 30151, 29792, 29536, 29359, 29204, 29007, 28703, 28220, 27478, 26401, 24910, 22931, 20446, 17436, 13984, 10250, 6439, 2793, -449, -2989, -4766, -5943, -6696, -7219, -7711, -8362, -9338, -10744, -12606, -14878, -17437, -20109, -22704, -25045, -27058, -28668, -29882, -30751, -31337, -31717, -31953, -32093, -32178, -32237, -32297, -32378, -32485, -32610, -32721, -32769, -32691, -32434, -31964, -31285, -30432, -29480, -28503, -27589, -26798, -26175, -25723, -25418, -25210, -25038, -24829, -24515, -24032, -23320, -22347, -21079, -19523, -17721, -15723, -13615, -11513, -9515, -7723, -6218, -5011, -4118, -3504, -3101, -2822, -2564, -2224, -1709, -944, 189, 1627, 3357, 5352, 7516, 9747, 11938, 13987, 15807, 17344, 18568, 19486, 20137, 20568, 20850, 21059, 21275, 21581, 22047, 22714, 23598, 24680, 25901, 27198, 28472, 29635, 30625, 31400, 31952, 32320, 32539, 32656, 32715, 32742, 32755, 32764, 32767, 32768, 32753, 32693, 32548, 32254, 31744, 30948, 29834, 28399, 26687, 24811, 22920, 21153, 19629, 18438, 17578, 16998, 16595, 16219, 15724, 14958, 13768, 12035, 9640, 6467, 2468, -2220, -6866, -11027, -14639, -17624, -19965, -21729, -22994, -23851, -24410, -24763, -25015, -25270, -25617, -26127, -26843, -27751, -28793, -29877, -30885, -31727, -32331, -32671, -32768, -32680, -32479, -32234, -32000, -31810, -31674, -31579, -31500, -31408, -31266, -31038, -30686, -30168, -29445, -28487, -27287, -25883, -24306, -22650, -21014, -19485, -18158, -17074, -16248, -15669, -15286, -15022, -14793, -14500, -14051, -13373, -12406, -11124, -9518, -7614, -5479, -3207, -857};