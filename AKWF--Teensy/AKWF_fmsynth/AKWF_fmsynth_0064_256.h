/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0064 256 samples */
 
const int16_t AKWF_fmsynth_0064_256_DATA [256] = 
{8967, 20708, 27588, 31312, 32698, 32444, 31096, 29078, 26664, 24085, 21497, 18985, 16622, 14432, 12415, 10580, 8923, 7420, 6070, 4845, 3738, 2741, 1849, 1053, 350, -260, -781, -1212, -1549, -1793, -1944, -1998, -1957, -1820, -1588, -1261, -837, -318, 296, 1007, 1813, 2729, 3754, 4900, 6175, 7593, 9183, 10953, 12914, 15091, 17462, 20030, 22746, 25515, 28187, 30533, 32212, 32750, 31457, 27443, 19596, 5897, -11361, -23439, -30090, -32647, -32127, -29478, -25526, -20941, -16223, -11705, -7544, -3674, 13, 3769, 7856, 12438, 17584, 23096, 28295, 32014, 32291, 26622, 9761, -14721, -28778, -32719, -30978, -26154, -20115, -14084, -8612, -3737, 759, 5367, 10509, 16353, 22655, 28566, 32395, 31412, 21476, -2665, -24339, -32094, -31969, -27623, -21553, -15329, -9666, -4661, -142, 4353, 9232, 14667, 20645, 26541, 31175, 32685, 28640, 15018, -8971, -25971, -32089, -32254, -28980, -24088, -18764, -13688, -9122, -5072, -1430, 2084, 5659, 9449, 13545, 17873, 22268, 26449, 29955, 32235, 32660, 30539, 25146, 15756, 1352, -13211, -22802, -28585, -31625, -32723, -32484, -31376, -29723, -27778, -25712, -23634, -21640, -19757, -18010, -16423, -14997, -13726, -12616, -11643, -10810, -10108, -9531, -9076, -8738, -8512, -8397, -8390, -8494, -8706, -9028, -9464, -10017, -10687, -11480, -12403, -13460, -14660, -16004, -17493, -19118, -20885, -22763, -24729, -26715, -28639, -30389, -31803, -32647, -32624, -31330, -28279, -22788, -14109, -957, 12924, 22639, 28811, 31990, 32752, 31667, 29272, 26002, 22250, 18331, 14471, 10809, 7392, 4192, 1129, -1908, -5072, -8479, -12252, -16388, -20802, -25218, -29176, -31984, -32670, -29894, -22099, -6434, 13139, 25657, 31409, 32739, 31090, 27690, 23428, 18890, 14504, 10439, 6747, 3405, 231, -2906, -6145, -9624, -13373, -17346, -21479, -25487, -29030, -31638, -32764, -31717, -27758, -20117, -7310};