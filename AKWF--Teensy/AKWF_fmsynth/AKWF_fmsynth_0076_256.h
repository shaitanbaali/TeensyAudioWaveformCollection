/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0076 256 samples */
 
const int16_t AKWF_fmsynth_0076_256_DATA [256] = 
{1341, 4771, 8038, 11194, 14154, 16882, 19350, 21526, 23412, 25027, 26362, 27440, 28279, 28897, 29322, 29575, 29672, 29632, 29471, 29205, 28841, 28389, 27858, 27249, 26572, 25832, 25021, 24152, 23227, 22250, 21236, 20180, 19097, 18004, 16913, 15845, 14816, 13839, 12937, 12133, 11441, 10868, 10438, 10152, 10019, 10039, 10208, 10519, 10958, 11514, 12165, 12886, 13672, 14489, 15319, 16151, 16960, 17740, 18487, 19192, 19852, 20468, 21034, 21558, 22029, 22437, 22773, 23015, 23133, 23099, 22872, 22410, 21662, 20591, 19149, 17304, 15039, 12362, 9301, 5888, 2271, -1309, -4721, -7870, -10668, -13085, -15066, -16610, -17719, -18418, -18749, -18760, -18501, -18025, -17387, -16625, -15784, -14901, -14002, -13113, -12243, -11401, -10590, -9820, -9082, -8378, -7696, -7029, -6375, -5728, -5083, -4440, -3790, -3138, -2485, -1834, -1196, -569, 32, 601, 1132, 1613, 2034, 2392, 2679, 2887, 3014, 3055, 3009, 2873, 2647, 2334, 1938, 1462, 910, 293, -376, -1088, -1817, -2555, -3277, -3959, -4576, -5107, -5528, -5820, -5955, -5918, -5692, -5263, -4614, -3734, -2617, -1260, 324, 2159, 4234, 6527, 9007, 11618, 14354, 17125, 19872, 22524, 24983, 27175, 29050, 30515, 31526, 32046, 32058, 31563, 30582, 29157, 27331, 25173, 22765, 20136, 17377, 14551, 11694, 8876, 6115, 3461, 975, -1349, -3535, -5574, -7509, -9340, -11078, -12738, -14321, -15841, -17307, -18715, -20060, -21344, -22575, -23736, -24827, -25847, -26782, -27641, -28423, -29122, -29744, -30291, -30767, -31183, -31541, -31846, -32104, -32319, -32493, -32627, -32720, -32765, -32760, -32697, -32565, -32361, -32081, -31714, -31268, -30739, -30135, -29467, -28755, -28015, -27273, -26547, -25865, -25248, -24716, -24288, -23967, -23753, -23640, -23611, -23637, -23681, -23694, -23626, -23417, -23015, -22362, -21405, -20114, -18467, -16448, -14099, -11418, -8462, -5306, -1934};