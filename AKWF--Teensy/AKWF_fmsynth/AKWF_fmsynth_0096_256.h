/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0096 256 samples */
 
const int16_t AKWF_fmsynth_0096_256_DATA [256] = 
{122, 838, 2257, 4092, 6156, 8339, 10428, 12261, 13742, 14840, 15605, 16158, 16649, 17241, 18080, 19256, 20789, 22605, 24552, 26455, 28145, 29517, 30537, 31248, 31720, 32039, 32285, 32497, 32678, 32771, 32647, 32098, 30895, 28861, 25956, 22321, 18318, 14248, 10421, 6886, 3387, -495, -4874, -9705, -14841, -19881, -24387, -27946, -30448, -31932, -32619, -32768, -32622, -32318, -31920, -31415, -30734, -29774, -28435, -26624, -24337, -21638, -18699, -15734, -12932, -10425, -8285, -6470, -4866, -3317, -1624, 353, 2723, 5479, 8557, 11820, 15050, 18036, 20639, 22766, 24452, 25763, 26815, 27741, 28654, 29624, 30648, 31635, 32412, 32767, 32526, 31613, 30116, 28246, 26274, 24398, 22662, 20938, 18979, 16427, 12941, 7913, 1117, -6340, -13229, -18630, -22618, -25405, -27265, -28455, -29237, -29806, -30316, -30873, -31491, -32099, -32573, -32771, -32629, -32172, -31516, -30815, -30198, -29745, -29452, -29267, -29098, -28848, -28419, -27744, -26780, -25542, -24099, -22596, -21171, -19992, -19160, -18706, -18587, -18683, -18838, -18895, -18719, -18220, -17380, -16226, -14868, -13472, -12206, -11230, -10658, -10513, -10750, -11246, -11835, -12337, -12605, -12534, -12086, -11303, -10292, -9218, -8246, -7550, -7248, -7381, -7905, -8712, -9638, -10502, -11138, -11436, -11348, -10901, -10196, -9382, -8644, -8141, -8003, -8287, -8967, -9940, -11043, -12108, -12960, -13483, -13618, -13385, -12864, -12196, -11553, -11107, -10992, -11271, -11936, -12900, -14014, -15100, -15991, -16567, -16770, -16596, -16112, -15447, -14767, -14232, -13987, -14110, -14607, -15400, -16356, -17308, -18093, -18582, -18703, -18444, -17859, -17059, -16193, -15429, -14918, -14749, -14945, -15454, -16147, -16863, -17432, -17728, -17653, -17175, -16341, -15246, -14038, -12892, -11966, -11370, -11150, -11261, -11590, -11977, -12245, -12234, -11834, -11002, -9757, -8206, -6504, -4842, -3372, -2236, -1480, -1080, -933, -892, -706, -258};