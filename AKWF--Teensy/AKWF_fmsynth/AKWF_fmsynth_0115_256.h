/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0115 256 samples */
 
const int16_t AKWF_fmsynth_0115_256_DATA [256] = 
{1253, 5341, 9245, 12998, 16528, 19786, 22734, 25322, 27536, 29359, 30777, 31800, 32436, 32703, 32634, 32251, 31599, 30708, 29625, 28392, 27045, 25626, 24173, 22715, 21289, 19918, 18626, 17434, 16359, 15409, 14598, 13933, 13415, 13052, 12844, 12790, 12889, 13138, 13534, 14071, 14741, 15539, 16450, 17467, 18577, 19756, 20996, 22275, 23565, 24852, 26112, 27316, 28448, 29478, 30383, 31149, 31756, 32186, 32429, 32474, 32318, 31956, 31395, 30637, 29694, 28577, 27302, 25885, 24353, 22721, 21010, 19250, 17455, 15650, 13862, 12102, 10389, 8750, 7189, 5722, 4366, 3124, 2007, 1023, 175, -528, -1085, -1494, -1752, -1854, -1800, -1588, -1216, -683, 10, 865, 1881, 3053, 4380, 5855, 7469, 9212, 11072, 13023, 15052, 17133, 19226, 21308, 23339, 25268, 27061, 28665, 30029, 31109, 31856, 32222, 32171, 31668, 30687, 29212, 27244, 24798, 21890, 18574, 14915, 10978, 6874, 2720, -1383, -5490, -9584, -13541, -17248, -20641, -23666, -26264, -28425, -30142, -31410, -32252, -32692, -32758, -32489, -31928, -31118, -30099, -28917, -27615, -26226, -24791, -23346, -21912, -20523, -19199, -17955, -16815, -15787, -14884, -14111, -13479, -12989, -12645, -12446, -12396, -12489, -12726, -13102, -13610, -14250, -15008, -15877, -16849, -17911, -19044, -20244, -21486, -22752, -24030, -25292, -26517, -27687, -28778, -29766, -30635, -31359, -31924, -32313, -32511, -32509, -32299, -31881, -31253, -30421, -29395, -28188, -26814, -25294, -23653, -21908, -20092, -18226, -16339, -14462, -12608, -10807, -9083, -7444, -5915, -4508, -3228, -2083, -1086, -234, 472, 1033, 1445, 1707, 1810, 1756, 1539, 1162, 625, -69, -927, -1960, -3158, -4527, -6061, -7745, -9575, -11531, -13588, -15721, -17900, -20077, -22219, -24282, -26204, -27952, -29467, -30701, -31614, -32160, -32309, -32030, -31308, -30134, -28507, -26442, -23962, -21093, -17885, -14388, -10653, -6758, -2676};