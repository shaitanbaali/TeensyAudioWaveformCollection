/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0061 256 samples */
 
const int16_t AKWF_fmsynth_0061_256_DATA [256] = 
{1826, 6310, 10591, 14746, 18653, 22237, 25392, 28073, 30199, 31714, 32569, 32749, 32240, 31051, 29206, 26753, 23777, 20309, 16471, 12375, 8107, 3827, -371, -4081, -7064, -9437, -11285, -12654, -13614, -14196, -14425, -14318, -13886, -13130, -12040, -10602, -8807, -6630, -4067, -1064, 2267, 5617, 8874, 11989, 14924, 17650, 20138, 22369, 24333, 26030, 27483, 28695, 29688, 30485, 31105, 31577, 31928, 32177, 32348, 32459, 32525, 32556, 32555, 32524, 32455, 32331, 32129, 31818, 31356, 30691, 29763, 28488, 26780, 24530, 21626, 17942, 13319, 7596, 533, -6956, -13570, -19220, -23918, -27593, -30271, -31963, -32716, -32593, -31672, -30036, -27773, -24987, -21805, -18276, -14530, -10654, -6724, -2843, 924, 4562, 7980, 11158, 14074, 16684, 19015, 21062, 22826, 24326, 25581, 26604, 27435, 28086, 28577, 28926, 29151, 29262, 29265, 29164, 28961, 28652, 28231, 27697, 27042, 26260, 25358, 24319, 23156, 21872, 20470, 18973, 17393, 15731, 14028, 12294, 10551, 8838, 7157, 5536, 4002, 2570, 1262, 101, -915, -1764, -2432, -2912, -3192, -3268, -3128, -2770, -2186, -1371, -330, 947, 2461, 4199, 6153, 8303, 10629, 13111, 15707, 18360, 21021, 23608, 26065, 28290, 30190, 31637, 32534, 32751, 32154, 30607, 27982, 24177, 19011, 12426, 4241, -4951, -12842, -19084, -23963, -27586, -30119, -31732, -32564, -32763, -32449, -31742, -30741, -29543, -28225, -26850, -25478, -24161, -22933, -21834, -20876, -20081, -19460, -19024, -18771, -18701, -18811, -19092, -19535, -20125, -20842, -21676, -22601, -23598, -24645, -25707, -26767, -27804, -28786, -29698, -30508, -31213, -31793, -32239, -32548, -32723, -32768, -32698, -32529, -32284, -31987, -31665, -31345, -31056, -30820, -30659, -30590, -30620, -30749, -30971, -31269, -31617, -31982, -32325, -32598, -32752, -32733, -32495, -31984, -31156, -29978, -28415, -26452, -24104, -21337, -18195, -14706, -10910, -6881, -2605};