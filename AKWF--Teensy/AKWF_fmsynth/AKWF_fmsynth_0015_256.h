/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0015 256 samples */
 
const int16_t AKWF_fmsynth_0015_256_DATA [256] = 
{2750, 8538, 13400, 17396, 20546, 22944, 24719, 25999, 26918, 27586, 28100, 28553, 29019, 29555, 30201, 30948, 31733, 32418, 32765, 32444, 31036, 28109, 23317, 16513, 8053, -1172, -10697, -19442, -26068, -29856, -30624, -28697, -24715, -19461, -13662, -7903, -2615, 1990, 5838, 8934, 11382, 13306, 14835, 16118, 17287, 18464, 19764, 21265, 23007, 24990, 27126, 29251, 31117, 32378, 32645, 31523, 28714, 24105, 17831, 10388, 2598, -5005, -12145, -18220, -22942, -26293, -28467, -29741, -30390, -30667, -30753, -30763, -30757, -30754, -30753, -30740, -30717, -30692, -30681, -30692, -30716, -30696, -30519, -30004, -28907, -26950, -23877, -19488, -13753, -6841, 902, 8891, 16480, 23057, 28092, 31313, 32695, 32425, 30862, 28426, 25543, 22549, 19682, 17091, 14807, 12800, 10999, 9276, 7501, 5545, 3269, 581, -2674, -6623, -11199, -16188, -21231, -25763, -29120, -30651, -29829, -26423, -20546, -12724, -3751, 5465, 13998, 21171, 26605, 30191, 32121, 32741, 32457, 31660, 30667, 29705, 28896, 28288, 27866, 27578, 27346, 27087, 26707, 26111, 25192, 23823, 21867, 19184, 15633, 11158, 5839, -84, -6538, -13212, -19454, -24638, -28335, -30355, -30728, -29700, -27637, -24959, -22051, -19231, -16735, -14691, -13156, -12122, -11526, -11272, -11239, -11294, -11295, -11102, -10579, -9587, -8002, -5696, -2573, 1405, 6231, 11731, 17577, 23287, 28187, 31545, 32699, 31185, 26918, 20251, 12011, 3377, -4836, -12335, -18551, -23262, -26547, -28662, -29894, -30507, -30719, -30682, -30489, -30180, -29759, -29191, -28406, -27301, -25745, -23566, -20591, -16668, -11668, -5613, 1321, 8808, 16276, 23042, 28417, 31773, 32749, 31304, 27739, 22633, 16703, 10694, 5184, 537, -3248, -6221, -8368, -9764, -10530, -10793, -10691, -10366, -9969, -9652, -9565, -9850, -10623, -11972, -13939, -16487, -19510, -22771, -25931, -28579, -30262, -30588, -29303, -26346, -21881, -16249, -9933, -3297};