/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0012 256 samples */
 
const int16_t AKWF_fmsynth_0012_256_DATA [256] = 
{550, 1413, 2242, 3055, 3848, 4622, 5375, 6105, 6811, 7492, 8146, 8774, 9376, 9946, 10489, 11004, 11487, 11941, 12365, 12760, 13127, 13464, 13772, 14057, 14313, 14545, 14753, 14941, 15105, 15252, 15380, 15491, 15587, 15670, 15740, 15798, 15846, 15885, 15917, 15941, 15959, 15971, 15978, 15980, 15977, 15969, 15957, 15941, 15918, 15889, 15856, 15815, 15768, 15712, 15649, 15574, 15491, 15398, 15290, 15170, 15040, 14894, 14735, 14560, 14369, 14163, 13940, 13702, 13447, 13176, 12887, 12584, 12263, 11927, 11576, 11211, 10828, 10436, 10029, 9609, 9180, 8739, 8288, 7827, 7361, 6885, 6404, 5918, 5427, 4933, 4437, 3938, 3438, 2937, 2438, 1942, 1445, 952, 461, -25, -505, -981, -1453, -1917, -2375, -2826, -3269, -3705, -4131, -4549, -4957, -5356, -5744, -6122, -6489, -6845, -7188, -7520, -7838, -8147, -8439, -8719, -8985, -9237, -9475, -9697, -9904, -10094, -10270, -10430, -10572, -10698, -10807, -10898, -10972, -11028, -11066, -11086, -11087, -11068, -11031, -10975, -10900, -10805, -10690, -10555, -10402, -10229, -10034, -9821, -9585, -9331, -9056, -8762, -8447, -8112, -7757, -7379, -6982, -6566, -6127, -5670, -5191, -4692, -4174, -3633, -3073, -2492, -1892, -1270, -630, 30, 710, 1408, 2126, 2860, 3610, 4378, 5160, 5949, 6752, 7562, 8371, 9183, 9989, 10782, 11560, 12312, 13030, 13707, 14329, 14882, 15354, 15729, 15987, 16110, 16074, 15855, 15427, 14760, 13820, 12571, 10981, 9000, 6587, 3701, 279, -3723, -8376, -13045, -17092, -20560, -23513, -25975, -27989, -29598, -30835, -31737, -32339, -32673, -32768, -32655, -32357, -31901, -31308, -30600, -29794, -28908, -27957, -26954, -25908, -24837, -23741, -22631, -21518, -20399, -19283, -18176, -17073, -15981, -14904, -13836, -12782, -11743, -10716, -9702, -8706, -7736, -6763, -5803, -4854, -3920, -2999, -2092, -1200, -306};