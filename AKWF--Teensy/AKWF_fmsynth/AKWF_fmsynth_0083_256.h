/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0083 256 samples */
 
const int16_t AKWF_fmsynth_0083_256_DATA [256] = 
{498, 2498, 5232, 8367, 11461, 14168, 16213, 17516, 18159, 18306, 18197, 18130, 18410, 19252, 20713, 22620, 24673, 26506, 27864, 28699, 29144, 29383, 29553, 29707, 29853, 30000, 30138, 30186, 29960, 29233, 27855, 25897, 23658, 21562, 19976, 19049, 18692, 18625, 18481, 17898, 16564, 14284, 11057, 7122, 2885, -1115, -4424, -6807, -8275, -9037, -9369, -9597, -10048, -10973, -12449, -14318, -16208, -17700, -18523, -18677, -18379, -17935, -17564, -17339, -17204, -17039, -16697, -16006, -14774, -12851, -10173, -6945, -3546, -440, 1994, 3615, 4506, 4904, 5185, 5742, 6892, 8857, 11627, 14972, 18502, 21742, 24329, 26162, 27261, 27791, 27950, 27940, 27969, 28216, 28767, 29546, 30312, 30749, 30642, 29987, 29005, 28028, 27296, 26894, 26729, 26613, 26353, 25761, 24660, 22896, 20391, 17252, 13866, 10656, 8089, 6426, 5659, 5578, 5813, 5938, 5558, 4388, 2300, -581, -4014, -7549, -10681, -13082, -14620, -15325, -15368, -14990, -14518, -14319, -14692, -15800, -17583, -19766, -21954, -23822, -25184, -26047, -26487, -26592, -26440, -26138, -25852, -25785, -26102, -26818, -27776, -28727, -29464, -29912, -30144, -30287, -30425, -30555, -30629, -30624, -30603, -30663, -30871, -31170, -31419, -31491, -31364, -31148, -31013, -31082, -31352, -31715, -32037, -32248, -32365, -32442, -32482, -32420, -32172, -31730, -31211, -30812, -30704, -30932, -31404, -31940, -32379, -32649, -32761, -32736, -32550, -32147, -31516, -30763, -30091, -29713, -29748, -30157, -30772, -31377, -31817, -32035, -32026, -31778, -31259, -30452, -29441, -28431, -27679, -27376, -27569, -28134, -28843, -29466, -29847, -29908, -29618, -28944, -27876, -26494, -25015, -23730, -22907, -22692, -23038, -23742, -24509, -25085, -25274, -24959, -24077, -22637, -20730, -18579, -16547, -14977, -14105, -13971, -14428, -15179, -15873, -16178, -15858, -14783, -12923, -10415, -7543, -4699, -2306, -634, 213, 311, -91, -640, -934, -586};