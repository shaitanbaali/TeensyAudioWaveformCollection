/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0054 256 samples */
 
const int16_t AKWF_fmsynth_0054_256_DATA [256] = 
{2550, 11274, 19454, 25829, 30045, 32186, 32769, 32499, 32035, 31816, 31993, 32424, 32757, 32530, 31343, 28996, 25597, 21510, 17328, 13591, 10828, 9405, 9536, 11265, 14493, 18885, 23843, 28468, 31742, 32757, 31029, 26680, 20481, 13611, 7243, 2201, -1179, -2859, -2827, -1170, 1958, 6392, 11723, 17338, 22501, 26680, 29633, 31392, 32246, 32567, 32628, 32504, 32009, 30702, 27975, 23282, 16362, 7620, -1812, -11143, -19372, -25500, -29433, -31524, -32413, -32682, -32724, -32661, -32353, -31478, -29658, -26627, -22396, -17216, -11716, -6578, -2417, 373, 1640, 1272, -804, -4616, -10044, -16487, -23096, -28635, -32019, -32674, -30674, -26694, -21663, -16626, -12381, -9457, -8083, -8340, -10132, -13215, -17188, -21539, -25681, -29069, -31368, -32519, -32764, -32513, -32200, -32130, -32375, -32712, -32644, -31492, -28609, -23580, -16466, -7952, 1137, 9695, 16879, 22310, 25963, 28122, 29187, 29392, 28835, 27425, 25018, 21450, 16757, 11231, 5344, -337, -5238, -9047, -11491, -12463, -11889, -9715, -5869, -380, 6462, 14000, 21332, 27451, 31399, 32775, 31729, 29001, 25513, 22238, 19894, 18882, 19315, 21051, 23753, 26863, 29749, 31828, 32740, 32452, 31244, 29603, 28081, 27140, 27079, 27948, 29536, 31346, 32613, 32457, 30071, 25044, 17628, 8822, 60, -7774, -14314, -19048, -22025, -23480, -23639, -22571, -20237, -16555, -11604, -5705, 497, 6667, 12324, 16920, 20184, 22102, 22731, 22073, 19994, 16265, 10761, 3607, -4645, -13523, -21750, -27999, -31642, -32772, -31987, -30178, -28215, -26772, -26212, -26650, -27935, -29697, -31422, -32562, -32676, -31564, -29367, -26522, -23657, -21354, -20116, -20222, -21716, -24354, -27616, -30683, -32562, -32378, -29644, -24514, -17571, -9872, -2427, 3956, 8798, 11964, 13513, 13489, 11975, 9027, 4823, -438, -6294, -12180, -17538, -21949, -25221, -27358, -28500, -28788, -28245, -26707, -23880, -19427, -13199, -5129};