/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0111 256 samples */
 
const int16_t AKWF_fmsynth_0111_256_DATA [256] = 
{278, 1234, 2083, 2790, 3326, 3709, 3994, 4260, 4588, 5045, 5664, 6442, 7334, 8257, 9121, 9841, 10362, 10678, 10826, 10876, 10920, 11044, 11310, 11744, 12322, 12979, 13633, 14191, 14588, 14793, 14810, 14684, 14483, 14292, 14191, 14233, 14432, 14760, 15150, 15519, 15792, 15911, 15854, 15628, 15272, 14857, 14463, 14168, 14026, 14043, 14185, 14383, 14553, 14615, 14512, 14220, 13750, 13157, 12518, 11927, 11462, 11165, 11037, 11034, 11081, 11085, 10964, 10660, 10160, 9493, 8725, 7952, 7259, 6715, 6351, 6152, 6066, 6016, 5914, 5684, 5285, 4710, 4005, 3244, 2507, 1872, 1388, 1068, 893, 811, 750, 634, 403, 26, -488, -1100, -1744, -2346, -2849, -3214, -3432, -3527, -3548, -3560, -3626, -3801, -4102, -4524, -5025, -5543, -6017, -6390, -6627, -6722, -6703, -6621, -6539, -6519, -6605, -6815, -7135, -7522, -7916, -8252, -8475, -8554, -8489, -8314, -8084, -7866, -7719, -7681, -7766, -7951, -8191, -8422, -8578, -8610, -8492, -8234, -7874, -7473, -7094, -6794, -6608, -6539, -6563, -6625, -6665, -6618, -6440, -6114, -5653, -5099, -4510, -3951, -3475, -3117, -2877, -2723, -2597, -2434, -2168, -1750, -1167, -432, 414, 1300, 2156, 2914, 3533, 4019, 4414, 4789, 5231, 5818, 6598, 7588, 8754, 10021, 11293, 12468, 13475, 14294, 14946, 15494, 16017, 16582, 17234, 17965, 18703, 19327, 19702, 19730, 19396, 18773, 17974, 17083, 16098, 14924, 13363, 11141, 7941, 3426, -2721, -10000, -16217, -20790, -24047, -26331, -27962, -29206, -30257, -31193, -31992, -32556, -32769, -32571, -31997, -31167, -30229, -29304, -28462, -27703, -26975, -26203, -25307, -24231, -22967, -21552, -20066, -18619, -17297, -16160, -15230, -14481, -13861, -13297, -12708, -12036, -11250, -10349, -9367, -8364, -7392, -6509, -5756, -5144, -4660, -4264, -3892, -3480, -2971, -2330, -1553, -643};