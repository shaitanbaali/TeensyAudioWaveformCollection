/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0048 256 samples */
 
const int16_t AKWF_fmsynth_0048_256_DATA [256] = 
{1860, 6234, 11490, 16999, 21883, 25584, 27955, 29183, 29567, 29338, 28682, 27856, 27217, 27134, 27810, 29147, 30738, 32054, 32708, 32695, 32345, 32076, 32125, 32427, 32713, 32749, 32525, 32244, 32149, 32328, 32627, 32772, 32572, 32091, 31636, 31519, 31847, 32398, 32759, 32589, 31865, 30897, 30135, 29900, 30223, 30875, 31553, 32028, 32231, 32161, 31716, 30637, 28627, 25645, 22045, 18480, 15672, 14057, 13717, 14397, 15580, 16662, 17077, 16406, 14339, 10759, 5800, 13, -5823, -10919, -14708, -17013, -17960, -17858, -17125, -16299, -15973, -16642, -18540, -21540, -25123, -28522, -31040, -32378, -32767, -32665, -32517, -32512, -32611, -32704, -32741, -32729, -32596, -32092, -30812, -28410, -24928, -20920, -17219, -14587, -13408, -13628, -14853, -16465, -17818, -18378, -17793, -15829, -12456, -7945, -2963, 1673, 5411, 7733, 8394, 7477, 5366, 2617, -32, -1962, -2687, -1947, 190, 3422, 7204, 10784, 13452, 14763, 14536, 12760, 9642, 5664, 1593, -1848, -4233, -5185, -4676, -3010, -715, 1541, 3114, 3413, 2103, -838, -5224, -10527, -15830, -20290, -23464, -25357, -26161, -26160, -25668, -25075, -24850, -25404, -26898, -29080, -31267, -32613, -32554, -31098, -28810, -26460, -24654, -23598, -23125, -22853, -22284, -20918, -18328, -14088, -8085, -697, 7240, 14605, 20488, 24676, 27294, 28794, 29646, 30225, 30825, 31597, 32412, 32764, 31802, 28683, 23104, 15668, 7769, 894, -4483, -8399, -11095, -13132, -15147, -17731, -21204, -25357, -29421, -32193, -32629, -30402, -26137, -21020, -16166, -12244, -9368, -7145, -5024, -2354, 1448, 6628, 13065, 20033, 26300, 30688, 32640, 32437, 30960, 29142, 27560, 26316, 25168, 23675, 21293, 17472, 11825, 4450, -3840, -12396, -19851, -25261, -28606, -30413, -31292, -31704, -31940, -32183, -32503, -32757, -32521, -31179, -28218, -23689, -18162, -12613, -7985, -4810, -3137, -2667, -2833, -2981, -2454, -713};