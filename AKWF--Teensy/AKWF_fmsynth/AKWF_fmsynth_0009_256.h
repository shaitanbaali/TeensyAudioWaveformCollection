/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0009 256 samples */
 
const int16_t AKWF_fmsynth_0009_256_DATA [256] = 
{1316, 4932, 7937, 11034, 14068, 16842, 19526, 21961, 24141, 26133, 27816, 29262, 30467, 31378, 32075, 32523, 32731, 32755, 32557, 32187, 31665, 30970, 30168, 29244, 28214, 27124, 25948, 24726, 23479, 22184, 20891, 19595, 18291, 17024, 15769, 14542, 13365, 12217, 11125, 10089, 9101, 8184, 7322, 6525, 5806, 5144, 4560, 4053, 3612, 3254, 2970, 2762, 2642, 2596, 2636, 2758, 2958, 3254, 3631, 4093, 4651, 5292, 6025, 6849, 7756, 8760, 9845, 11012, 12263, 13583, 14977, 16428, 17926, 19468, 21024, 22586, 24139, 25640, 27081, 28431, 29641, 30695, 31544, 32143, 32462, 32446, 32060, 31261, 30008, 28281, 26048, 23311, 20076, 16363, 12244, 7788, 3155, -1545, -6400, -11329, -16076, -20496, -24407, -27623, -30049, -31555, -32068, -31559, -29995, -27433, -23915, -19534, -14464, -8814, -2794, 3357, 9477, 15291, 20564, 25118, 28698, 31150, 32345, 32157, 30591, 27633, 23401, 18113, 11955, 5383, -1206, -7803, -14210, -19978, -24809, -28503, -30912, -31999, -31774, -30292, -27675, -24071, -19633, -14563, -9070, -3323, 2467, 8102, 13444, 18323, 22603, 26200, 29020, 31009, 32148, 32424, 31860, 30500, 28407, 25665, 22360, 18619, 14555, 10283, 5967, 1730, -2395, -6431, -10360, -14066, -17465, -20541, -23250, -25575, -27532, -29109, -30327, -31210, -31769, -32042, -32047, -31813, -31373, -30744, -29963, -29052, -28024, -26918, -25745, -24524, -23280, -22016, -20753, -19511, -18287, -17098, -15956, -14864, -13834, -12863, -11959, -11132, -10377, -9706, -9112, -8600, -8182, -7844, -7595, -7438, -7365, -7388, -7500, -7698, -7995, -8376, -8848, -9412, -10052, -10787, -11603, -12492, -13464, -14496, -15597, -16760, -17953, -19203, -20476, -21750, -23046, -24311, -25542, -26740, -27841, -28867, -29781, -30535, -31153, -31571, -31774, -31769, -31481, -30942, -30121, -28966, -27549, -25794, -23718, -21403, -18737, -15858, -12799, -9450, -6152, -2655};