/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0020 256 samples */
 
const int16_t AKWF_fmsynth_0020_256_DATA [256] = 
{156, 504, 811, 1094, 1375, 1673, 1994, 2324, 2651, 2969, 3284, 3607, 3939, 4273, 4604, 4933, 5267, 5609, 5956, 6302, 6648, 6998, 7354, 7718, 8084, 8451, 8821, 9196, 9579, 9966, 10355, 10747, 11144, 11548, 11958, 12370, 12784, 13203, 13628, 14059, 14494, 14931, 15371, 15815, 16266, 16719, 17175, 17632, 18091, 18554, 19023, 19490, 19959, 20427, 20896, 21369, 21840, 22308, 22774, 23240, 23704, 24167, 24623, 25075, 25522, 25965, 26401, 26831, 27251, 27663, 28067, 28461, 28845, 29216, 29571, 29915, 30246, 30559, 30857, 31136, 31395, 31639, 31863, 32064, 32240, 32392, 32520, 32625, 32702, 32750, 32768, 32755, 32714, 32641, 32533, 32388, 32207, 31991, 31737, 31443, 31105, 30724, 30302, 29838, 29329, 28769, 28159, 27501, 26795, 26040, 25228, 24358, 23434, 22453, 21416, 20322, 19157, 17929, 16643, 15294, 13879, 12391, 10825, 9194, 7500, 5730, 3878, 1943, -42, -2012, -3913, -5716, -7415, -9038, -10601, -12093, -13511, -14852, -16119, -17328, -18482, -19571, -20599, -21564, -22473, -23336, -24148, -24906, -25612, -26270, -26883, -27458, -27989, -28474, -28918, -29324, -29694, -30028, -30325, -30586, -30816, -31014, -31183, -31322, -31429, -31508, -31562, -31591, -31595, -31572, -31525, -31457, -31370, -31260, -31128, -30976, -30805, -30619, -30416, -30196, -29958, -29704, -29438, -29158, -28865, -28558, -28237, -27905, -27566, -27216, -26856, -26484, -26102, -25715, -25323, -24921, -24511, -24095, -23673, -23249, -22821, -22386, -21947, -21504, -21059, -20615, -20165, -19714, -19261, -18808, -18355, -17902, -17446, -16990, -16537, -16086, -15635, -15186, -14736, -14289, -13847, -13406, -12967, -12528, -12092, -11663, -11237, -10813, -10391, -9970, -9555, -9146, -8739, -8334, -7931, -7534, -7141, -6755, -6369, -5983, -5601, -5224, -4853, -4484, -4114, -3746, -3383, -3028, -2674, -2317, -1956, -1602, -1258, -919, -574, -212};