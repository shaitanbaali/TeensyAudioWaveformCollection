/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0047 256 samples */
 
const int16_t AKWF_fmsynth_0047_256_DATA [256] = 
{926, 5083, 9496, 13597, 17514, 21104, 24299, 27026, 29246, 30931, 32073, 32668, 32735, 32307, 31436, 30164, 28566, 26702, 24638, 22455, 20205, 17938, 15719, 13582, 11566, 9718, 8025, 6519, 5206, 4084, 3163, 2439, 1894, 1533, 1346, 1332, 1476, 1778, 2230, 2822, 3547, 4396, 5362, 6432, 7596, 8836, 10133, 11485, 12864, 14263, 15663, 17041, 18389, 19700, 20953, 22145, 23265, 24297, 25259, 26134, 26925, 27637, 28265, 28816, 29298, 29710, 30063, 30359, 30605, 30803, 30958, 31075, 31158, 31210, 31228, 31218, 31179, 31110, 31013, 30884, 30721, 30524, 30291, 30018, 29706, 29354, 28958, 28518, 28038, 27517, 26951, 26343, 25699, 25020, 24312, 23580, 22819, 22042, 21251, 20448, 19646, 18844, 18041, 17248, 16467, 15702, 14962, 14232, 13522, 12838, 12173, 11529, 10907, 10302, 9710, 9134, 8565, 8006, 7448, 6884, 6312, 5729, 5130, 4512, 3863, 3177, 2457, 1694, 888, 29, -891, -1883, -2951, -4101, -5331, -6647, -8049, -9532, -11088, -12704, -14392, -16121, -17884, -19651, -21408, -23141, -24815, -26400, -27876, -29197, -30355, -31316, -32050, -32535, -32758, -32700, -32354, -31714, -30787, -29575, -28104, -26378, -24430, -22279, -19972, -17541, -15015, -12428, -9820, -7225, -4679, -2220, 154, 2397, 4508, 6465, 8245, 9853, 11293, 12547, 13628, 14529, 15250, 15801, 16182, 16396, 16440, 16313, 16024, 15559, 14923, 14113, 13129, 11962, 10613, 9081, 7380, 5514, 3485, 1310, -997, -3412, -5905, -8440, -11011, -13561, -16069, -18495, -20792, -22941, -24922, -26695, -28254, -29579, -30657, -31506, -32125, -32526, -32730, -32762, -32645, -32409, -32086, -31708, -31302, -30901, -30528, -30205, -29951, -29785, -29710, -29738, -29865, -30087, -30393, -30766, -31181, -31612, -32029, -32389, -32649, -32767, -32691, -32378, -31780, -30851, -29570, -27890, -25803, -23304, -20395, -17112, -13503, -9593, -5405, -1091};