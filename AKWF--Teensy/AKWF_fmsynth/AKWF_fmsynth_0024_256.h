/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_fmsynth_0024 256 samples */
 
const int16_t AKWF_fmsynth_0024_256_DATA [256] = 
{371, 902, 1425, 2109, 2859, 3480, 4113, 4822, 5512, 6248, 7025, 7805, 8652, 9524, 10426, 11399, 12392, 13441, 14552, 15681, 16885, 18129, 19393, 20724, 22061, 23415, 24794, 26125, 27445, 28706, 29842, 30890, 31740, 32356, 32730, 32700, 32272, 31341, 29723, 27462, 24293, 20067, 14865, 8080, -10, -7559, -13677, -18619, -22409, -25174, -27100, -28208, -28651, -28544, -27928, -26935, -25627, -24066, -22340, -20484, -18556, -16602, -14644, -12722, -10845, -9031, -7291, -5616, -4011, -2465, -965, 496, 1942, 3389, 4852, 6351, 7898, 9508, 11184, 12939, 14768, 16660, 18618, 20601, 22587, 24562, 26443, 28203, 29789, 31087, 32071, 32632, 32648, 32086, 30770, 28612, 25546, 21342, 16002, 9346, 1323, -6562, -12781, -17620, -21490, -24286, -26298, -27663, -28391, -28701, -28613, -28190, -27568, -26721, -25738, -24676, -23510, -22325, -21120, -19890, -18701, -17519, -16364, -15263, -14185, -13160, -12186, -11242, -10362, -9519, -8715, -7967, -7248, -6573, -5938, -5329, -4766, -4229, -3718, -3247, -2793, -2370, -1976, -1594, -1246, -917, -601, -318, -46, 206, 435, 655, 852, 1032, 1204, 1349, 1486, 1609, 1713, 1810, 1887, 1953, 2010, 2048, 2078, 2098, 2102, 2101, 2087, 2060, 2029, 1983, 1929, 1870, 1798, 1721, 1635, 1539, 1440, 1332, 1216, 1097, 968, 834, 695, 549, 403, 247, 87, -75, -244, -414, -588, -768, -949, -1134, -1322, -1511, -1705, -1897, -2091, -2288, -2484, -2681, -2879, -3075, -3271, -3466, -3658, -3850, -4037, -4221, -4402, -4579, -4752, -4917, -5077, -5233, -5378, -5515, -5645, -5764, -5873, -5972, -6060, -6135, -6197, -6244, -6278, -6297, -6300, -6287, -6256, -6209, -6144, -6059, -5957, -5835, -5693, -5531, -5349, -5146, -4923, -4680, -4415, -4128, -3822, -3498, -3148, -2783, -2396, -1984, -1561, -1112, -642, -154};