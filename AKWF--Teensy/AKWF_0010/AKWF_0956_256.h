/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0956 256 samples */
 
const int16_t AKWF_0956_256_DATA [256] = 
{396, 1146, 1865, 2569, 3255, 3922, 4579, 5319, 6074, 6861, 7645, 8428, 9233, 10061, 10915, 11786, 12665, 13545, 14420, 15290, 16162, 17033, 17900, 18761, 19609, 20440, 21254, 22044, 22805, 23537, 24231, 24884, 25494, 26056, 26568, 27029, 27436, 27791, 28094, 28346, 28549, 28705, 28817, 28888, 28920, 28916, 28879, 28812, 28718, 28598, 28454, 28289, 28103, 27898, 27676, 27436, 27180, 26909, 26622, 26319, 26000, 25661, 25302, 24921, 24512, 24076, 23608, 23105, 22566, 21988, 21369, 20712, 20012, 19271, 18495, 17682, 16835, 15963, 15068, 14159, 13241, 12310, 11370, 10424, 9472, 8521, 7574, 6628, 5691, 4764, 3845, 2941, 2053, 1181, 330, -499, -1305, -2085, -2839, -3566, -4262, -4930, -5570, -6178, -6757, -7307, -7824, -8312, -8770, -9198, -9595, -9962, -10306, -10634, -10953, -11265, -11568, -11852, -12111, -12340, -12538, -12706, -12851, -12976, -13086, -13180, -13262, -13331, -13388, -13430, -13455, -13464, -13450, -13407, -13361, -13371, -13368, -13369, -13335, -13277, -13214, -13154, -13096, -13040, -12987, -12934, -12880, -12819, -12746, -12655, -12539, -12397, -12231, -12047, -11853, -11653, -11448, -11237, -11013, -10776, -10529, -10276, -10021, -9767, -9514, -9263, -9015, -8775, -8542, -8320, -8114, -7925, -7756, -7612, -7493, -7401, -7341, -7312, -7316, -7355, -7429, -7538, -7681, -7859, -8068, -8307, -8575, -8865, -9172, -9492, -9812, -10128, -10436, -10733, -11018, -11290, -11542, -11774, -11986, -12177, -12350, -12507, -12648, -12775, -12891, -12997, -13096, -13187, -13273, -13355, -13435, -13512, -13590, -13668, -13747, -13830, -13915, -14003, -14093, -14183, -14273, -14359, -14439, -14508, -14564, -14603, -14619, -14610, -14569, -14496, -14384, -14233, -14039, -13801, -13518, -13188, -12814, -12396, -11935, -11434, -10895, -10319, -9709, -9068, -8397, -7699, -6978, -6233, -5468, -4689, -3897, -3098, -2342, -1388, -393, 72};