/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0970 256 samples */
 
const int16_t AKWF_0970_256_DATA [256] = 
{707, 2210, 3670, 5117, 6542, 7945, 9323, 10668, 11981, 13260, 14495, 15690, 16841, 17938, 18984, 19975, 20904, 21773, 22578, 23316, 23988, 24590, 25123, 25586, 25979, 26301, 26553, 26735, 26848, 26894, 26876, 26796, 26659, 26469, 26230, 25948, 25630, 25281, 24907, 24515, 24112, 23703, 23295, 22894, 22506, 22138, 21795, 21483, 21208, 20975, 20787, 20650, 20566, 20537, 20565, 20650, 20793, 20991, 21241, 21543, 21891, 22284, 22718, 23186, 23688, 24216, 24768, 25339, 25921, 26513, 27109, 27700, 28284, 28853, 29401, 29924, 30416, 30871, 31286, 31656, 31978, 32248, 32466, 32625, 32727, 32768, 32747, 32661, 32509, 32292, 32004, 31649, 31224, 30729, 30165, 29534, 28835, 28072, 27246, 26358, 25416, 24417, 23365, 22266, 21118, 19924, 18691, 17418, 16107, 14766, 13393, 11993, 10576, 9137, 7686, 6228, 4763, 3298, 1838, 382, -1061, -2489, -3904, -5298, -6669, -8017, -9333, -10618, -11871, -13082, -14251, -15378, -16454, -17482, -18458, -19376, -20239, -21046, -21792, -22479, -23107, -23672, -24176, -24616, -24991, -25303, -25547, -25725, -25835, -25876, -25850, -25757, -25598, -25373, -25083, -24734, -24328, -23866, -23355, -22799, -22200, -21565, -20901, -20211, -19500, -18775, -18041, -17308, -16578, -15859, -15161, -14487, -13846, -13246, -12693, -12191, -11749, -11369, -11055, -10812, -10641, -10543, -10519, -10569, -10691, -10884, -11150, -11482, -11880, -12343, -12865, -13443, -14075, -14754, -15475, -16235, -17025, -17842, -18679, -19529, -20387, -21249, -22105, -22955, -23793, -24611, -25409, -26183, -26925, -27634, -28309, -28939, -29527, -30065, -30551, -30983, -31356, -31669, -31919, -32106, -32228, -32285, -32275, -32198, -32056, -31846, -31569, -31226, -30816, -30339, -29794, -29184, -28507, -27765, -26961, -26096, -25169, -24189, -23153, -22065, -20933, -19752, -18529, -17270, -15969, -14635, -13273, -11878, -10458, -9019, -7557, -6080, -4612, -3068, -1103, -35};