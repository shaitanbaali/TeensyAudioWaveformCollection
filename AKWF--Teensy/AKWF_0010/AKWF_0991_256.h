/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0991 256 samples */
 
const int16_t AKWF_0991_256_DATA [256] = 
{526, 2325, 4044, 5721, 7344, 8911, 10419, 11860, 13234, 14539, 15766, 16922, 18003, 19003, 19927, 20772, 21538, 22227, 22839, 23373, 23831, 24218, 24530, 24773, 24947, 25055, 25100, 25084, 25009, 24879, 24696, 24464, 24185, 23863, 23501, 23101, 22669, 22205, 21713, 21199, 20661, 20106, 19537, 18954, 18362, 17764, 17162, 16559, 15958, 15358, 14766, 14183, 13608, 13045, 12498, 11964, 11449, 10952, 10474, 10016, 9582, 9169, 8779, 8413, 8072, 7755, 7463, 7195, 6952, 6733, 6537, 6366, 6217, 6089, 5984, 5898, 5831, 5783, 5750, 5733, 5730, 5741, 5761, 5791, 5830, 5873, 5923, 5975, 6029, 6083, 6134, 6183, 6227, 6264, 6294, 6315, 6325, 6326, 6313, 6286, 6246, 6191, 6120, 6034, 5931, 5810, 5673, 5519, 5347, 5159, 4954, 4731, 4493, 4240, 3971, 3688, 3391, 3081, 2758, 2425, 2081, 1729, 1368, 999, 625, 245, -137, -522, -910, -1299, -1686, -2072, -2456, -2836, -3211, -3579, -3942, -4298, -4645, -4982, -5311, -5627, -5933, -6227, -6508, -6777, -7032, -7274, -7501, -7714, -7911, -8094, -8262, -8414, -8553, -8676, -8783, -8875, -8953, -9016, -9065, -9100, -9121, -9127, -9121, -9103, -9071, -9028, -8973, -8908, -8832, -8746, -8651, -8546, -8433, -8312, -8184, -8049, -7907, -7760, -7608, -7451, -7291, -7127, -6960, -6789, -6616, -6443, -6268, -6092, -5916, -5741, -5565, -5391, -5218, -5046, -4877, -4709, -4543, -4382, -4223, -4067, -3915, -3766, -3620, -3480, -3343, -3210, -3089, -3063, -3276, -3808, -4685, -5888, -7375, -9101, -11004, -13024, -15115, -17219, -19293, -21301, -23205, -24978, -26603, -28054, -29321, -30399, -31275, -31949, -32422, -32693, -32767, -32651, -32351, -31874, -31228, -30428, -29477, -28389, -27179, -25849, -24417, -22897, -21291, -19616, -17886, -16101, -14281, -12434, -10564, -8687, -6812, -4942, -3092, -1229};