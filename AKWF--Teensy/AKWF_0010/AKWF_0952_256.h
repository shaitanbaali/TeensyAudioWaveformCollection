/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0952 256 samples */
 
const int16_t AKWF_0952_256_DATA [256] = 
{749, 2403, 4307, 6731, 9239, 18005, 23932, 22983, 23157, 23137, 23106, 23064, 23014, 22952, 22880, 22798, 22705, 22602, 22487, 22363, 22227, 22081, 21923, 21755, 21575, 21384, 21181, 20967, 20741, 20502, 20251, 19989, 19713, 19424, 19121, 18806, 18476, 18132, 17772, 17399, 17009, 16601, 16178, 15737, 15278, 14801, 14302, 13782, 13241, 12676, 12085, 11469, 10823, 10146, 9437, 8688, 7899, 7068, 6183, 5241, 4234, 3151, 1980, 637, 1137, 2517, 3622, 4675, 5653, 6569, 7431, 8243, 9013, 9745, 10439, 11103, 11737, 12341, 12921, 13476, 14007, 14518, 15008, 15477, 15928, 16362, 16778, 17177, 17560, 17928, 18281, 18619, 18943, 19253, 19549, 19832, 20103, 20361, 20606, 20840, 21060, 21269, 21468, 21654, 21829, 21992, 22145, 22287, 22418, 22538, 22648, 22746, 22834, 22912, 22980, 23037, 23084, 23121, 23147, 23133, 23220, 23005, 13230, 8029, 5609, 3446, 1670, 130, -1244, -2485, -3622, -4675, -5652, -6569, -7431, -8243, -9014, -9745, -10439, -11103, -11737, -12341, -12921, -13476, -14007, -14518, -15008, -15477, -15929, -16362, -16777, -17178, -17560, -17927, -18281, -18619, -18942, -19253, -19549, -19832, -20103, -20361, -20606, -20839, -21060, -21270, -21468, -21654, -21829, -21992, -22145, -22287, -22418, -22538, -22647, -22746, -22834, -22912, -22981, -23038, -23085, -23121, -23148, -23133, -23220, -23005, -13230, -8029, -5610, -3462, -1637, -353, -1376, -3193, -5248, -7730, -11882, -22120, -23421, -23096, -23150, -23124, -23090, -23044, -22989, -22923, -22846, -22759, -22662, -22554, -22435, -22306, -22166, -22015, -21853, -21680, -21495, -21299, -21091, -20872, -20640, -20397, -20141, -19873, -19591, -19296, -18988, -18667, -18330, -17980, -17613, -17234, -16837, -16422, -15993, -15544, -15077, -14591, -14084, -13554, -13004, -12428, -11826, -11198, -10539, -9847, -9123, -8357, -7550, -6698, -5788, -4820, -3771, -2714, -1171, -369};