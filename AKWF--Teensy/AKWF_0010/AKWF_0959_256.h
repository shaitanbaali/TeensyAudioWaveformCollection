/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0959 256 samples */
 
const int16_t AKWF_0959_256_DATA [256] = 
{191, 663, 1068, 1422, 1735, 2037, 2359, 2716, 3111, 3531, 3969, 4429, 4913, 5427, 5974, 6547, 7134, 7707, 8237, 8710, 9131, 9505, 9839, 10132, 10378, 10574, 10720, 10814, 10866, 10896, 10928, 10982, 11071, 11187, 11323, 11479, 11656, 11861, 12096, 12360, 12654, 12974, 13303, 13620, 13905, 14148, 14350, 14517, 14650, 14750, 14810, 14831, 14809, 14746, 14643, 14501, 14331, 14149, 13973, 13816, 13685, 13574, 13484, 13413, 13365, 13346, 13354, 13392, 13460, 13560, 13690, 13849, 14027, 14214, 14392, 14556, 14701, 14825, 14930, 15014, 15075, 15110, 15116, 15092, 15038, 14953, 14835, 14683, 14497, 14276, 14022, 13745, 13454, 13156, 12858, 12564, 12277, 11997, 11729, 11477, 11243, 11029, 10838, 10674, 10537, 10428, 10352, 10310, 10306, 10342, 10421, 10545, 10713, 10921, 11166, 11440, 11744, 12068, 12410, 12766, 13129, 13496, 13866, 14231, 14589, 14937, 15271, 15586, 15882, 16152, 16395, 16606, 16781, 16916, 17010, 17058, 17056, 17002, 16891, 16723, 16494, 16204, 15849, 15428, 14944, 14392, 13776, 13096, 12352, 11546, 10683, 9763, 8788, 7766, 6693, 5579, 4426, 3234, 2012, 762, -514, -1807, -3119, -4446, -5777, -7114, -8456, -9789, -11119, -12441, -13744, -15033, -16304, -17548, -18769, -19964, -21125, -22259, -23346, -24326, -25222, -26023, -26746, -27401, -27971, -28453, -28877, -29276, -29676, -30074, -30456, -30815, -31152, -31476, -31796, -32111, -32399, -32620, -32744, -32766, -32701, -32563, -32356, -32074, -31710, -31270, -30767, -30245, -29742, -29266, -28811, -28366, -27925, -27498, -27093, -26714, -26354, -25985, -25568, -25080, -24526, -23915, -23262, -22568, -21824, -21026, -20176, -19294, -18420, -17586, -16803, -16066, -15359, -14681, -14039, -13439, -12884, -12374, -11887, -11385, -10842, -10247, -9613, -8952, -8265, -7549, -6801, -6010, -5190, -4360, -3552, -2799, -2107, -1468, -871, -305};