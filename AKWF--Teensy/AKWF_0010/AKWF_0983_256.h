/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0983 256 samples */
 
const int16_t AKWF_0983_256_DATA [256] = 
{755, 2002, 3207, 4401, 5577, 6735, 7871, 8979, 10057, 11105, 12116, 13094, 14036, 14942, 15817, 16660, 17470, 18248, 18989, 19694, 20360, 20983, 21557, 22080, 22545, 22943, 23271, 23522, 23694, 23785, 23800, 23738, 23601, 23394, 23117, 22777, 22381, 21934, 21447, 20928, 20386, 19822, 19246, 18655, 18052, 17441, 16818, 16184, 15540, 14886, 14221, 13548, 12866, 12174, 11477, 10765, 10041, 9299, 8532, 7736, 6906, 6032, 5115, 4156, 3149, 2104, 1026, -82, -1209, -2352, -3507, -4664, -5824, -6984, -8136, -9284, -10424, -11549, -12665, -13766, -14846, -15913, -16962, -17990, -18999, -19987, -20949, -21892, -22810, -23702, -24572, -25416, -26232, -27020, -27773, -28491, -29170, -29806, -30400, -30947, -31437, -31862, -32217, -32490, -32673, -32761, -32751, -32637, -32419, -32097, -31670, -31140, -30511, -29786, -28969, -28068, -27081, -26017, -24886, -23688, -22437, -21144, -19812, -18459, -17095, -15723, -14359, -13006, -11664, -10343, -9039, -7750, -6485, -5239, -4016, -2824, -1660, -529, 566, 1632, 2668, 3671, 4652, 5607, 6540, 7453, 8344, 9211, 10055, 10869, 11648, 12390, 13088, 13731, 14321, 14850, 15317, 15723, 16069, 16357, 16593, 16777, 16913, 17007, 17068, 17101, 17116, 17124, 17130, 17140, 17156, 17179, 17205, 17236, 17267, 17297, 17323, 17343, 17353, 17351, 17335, 17301, 17247, 17167, 17055, 16906, 16712, 16465, 16160, 15790, 15354, 14848, 14272, 13634, 12939, 12191, 11403, 10580, 9725, 8849, 7953, 7040, 6117, 5182, 4241, 3299, 2352, 1407, 465, -475, -1411, -2340, -3261, -4173, -5071, -5960, -6834, -7693, -8540, -9369, -10182, -10976, -11746, -12490, -13208, -13891, -14538, -15144, -15699, -16198, -16631, -16989, -17264, -17450, -17542, -17538, -17434, -17232, -16930, -16530, -16035, -15445, -14766, -14003, -13156, -12232, -11238, -10176, -9059, -7896, -6692, -5462, -4218, -2965, -1716, -447};