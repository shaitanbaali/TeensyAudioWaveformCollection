/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0938 256 samples */
 
const int16_t AKWF_0938_256_DATA [256] = 
{2796, 11391, 17154, 21126, 23822, 25649, 26900, 27772, 28416, 28937, 29401, 29857, 30320, 30784, 31232, 31640, 31991, 32274, 32489, 32638, 32728, 32766, 32757, 32709, 32626, 32519, 32397, 32274, 32158, 32058, 31973, 31895, 31809, 31699, 31543, 31316, 30996, 30555, 29973, 29235, 28343, 27324, 26239, 25161, 24173, 23332, 22639, 22048, 21467, 20766, 19812, 18459, 16547, 13940, 10529, 6267, 1229, -3715, -7419, -9915, -11380, -11975, -11850, -11175, -10154, -9040, -8122, -7666, -7854, -8720, -10136, -11856, -13618, -15187, -16393, -17143, -17391, -17119, -16335, -15080, -13438, -11553, -9639, -7955, -6731, -6124, -6149, -6683, -7517, -8403, -9136, -9552, -9556, -9117, -8262, -7085, -5744, -4466, -3495, -3050, -3255, -4092, -5412, -6973, -8524, -9840, -10758, -11181, -11064, -10417, -9291, -7813, -6182, -4659, -3541, -3075, -3377, -4392, -5906, -7621, -9226, -10464, -11154, -11158, -10383, -8754, -6239, -2845, 1207, 4942, 7822, 9818, 10936, 11244, 10826, 9797, 8316, 6613, 4979, 3726, 3114, 3268, 4140, 5531, 7149, 8716, 10005, 10858, 11196, 10992, 10269, 9099, 7622, 6033, 4580, 3521, 3046, 3232, 4008, 5190, 6533, 7799, 8800, 9417, 9594, 9339, 8718, 7868, 6982, 6294, 6038, 6379, 7363, 8884, 10739, 12667, 14431, 15863, 16850, 17336, 17304, 16758, 15733, 14298, 12592, 10825, 9251, 8137, 7666, 7872, 8630, 9700, 10795, 11640, 12015, 11737, 10655, 8605, 5433, 951, -4234, -8843, -12606, -15540, -17726, -19290, -20394, -21183, -21797, -22372, -23015, -23793, -24728, -25778, -26871, -27929, -28879, -29682, -30329, -30826, -31193, -31456, -31639, -31766, -31859, -31938, -32020, -32114, -32224, -32345, -32469, -32584, -32679, -32742, -32768, -32751, -32683, -32559, -32373, -32119, -31796, -31410, -30976, -30518, -30053, -29597, -29141, -28652, -28072, -27312, -26241, -24687, -22399, -19025, -14105, -6682};