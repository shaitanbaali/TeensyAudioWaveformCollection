/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0989 256 samples */
 
const int16_t AKWF_0989_256_DATA [256] = 
{1052, 3010, 5007, 7065, 9159, 11277, 13398, 15494, 17554, 19558, 21478, 23304, 25015, 26588, 28015, 29279, 30361, 31256, 31950, 32436, 32708, 32762, 32596, 32209, 31604, 30786, 29760, 28535, 27123, 25531, 23777, 21877, 19839, 17691, 15445, 13117, 10737, 8314, 5869, 3430, 1007, -1381, -3708, -5967, -8139, -10204, -12158, -13985, -15672, -17216, -18608, -19840, -20914, -21827, -22574, -23164, -23597, -23876, -24010, -24004, -23866, -23607, -23236, -22763, -22199, -21557, -20847, -20079, -19268, -18421, -17550, -16666, -15777, -14891, -14019, -13162, -12330, -11529, -10758, -10023, -9328, -8669, -8049, -7468, -6922, -6410, -5931, -5479, -5052, -4645, -4255, -3878, -3508, -3143, -2779, -2411, -2038, -1656, -1264, -859, -441, -11, 433, 889, 1355, 1831, 2312, 2795, 3278, 3754, 4222, 4678, 5112, 5526, 5911, 6265, 6583, 6860, 7094, 7281, 7421, 7508, 7543, 7526, 7456, 7333, 7159, 6938, 6670, 6359, 6009, 5625, 5212, 4775, 4319, 3850, 3374, 2897, 2426, 1965, 1520, 1097, 699, 333, 2, -292, -547, -760, -930, -1056, -1139, -1181, -1182, -1145, -1073, -971, -842, -689, -520, -337, -148, 43, 230, 409, 574, 720, 843, 939, 1005, 1038, 1036, 997, 921, 809, 660, 477, 261, 18, -253, -543, -852, -1171, -1495, -1820, -2138, -2445, -2734, -2998, -3233, -3435, -3596, -3714, -3786, -3810, -3781, -3701, -3569, -3385, -3152, -2873, -2550, -2188, -1794, -1373, -930, -476, -17, 440, 885, 1309, 1705, 2062, 2376, 2636, 2835, 2967, 3027, 3010, 2913, 2732, 2467, 2117, 1685, 1173, 583, -76, -799, -1581, -2407, -3272, -4164, -5067, -5973, -6868, -7734, -8562, -9337, -10042, -10669, -11200, -11625, -11932, -12112, -12154, -12050, -11796, -11385, -10815, -10085, -9195, -8145, -6945, -5598, -4113, -2504, -737};