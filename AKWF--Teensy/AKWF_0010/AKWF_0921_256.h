/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0921 256 samples */
 
const int16_t AKWF_0921_256_DATA [256] = 
{535, 1988, 3528, 5174, 6910, 8728, 10612, 12535, 14486, 16441, 18370, 20259, 22081, 23809, 25431, 26922, 28262, 29444, 30454, 31282, 31928, 32388, 32666, 32767, 32700, 32477, 32109, 31611, 30998, 30285, 29490, 28627, 27706, 26744, 25750, 24729, 23695, 22644, 21580, 20508, 19422, 18317, 17195, 16047, 14869, 13662, 12415, 11129, 9809, 8450, 7056, 5638, 4197, 2748, 1305, -124, -1518, -2864, -4148, -5349, -6451, -7444, -8310, -9041, -9628, -10064, -10348, -10482, -10469, -10316, -10033, -9635, -9135, -8551, -7905, -7212, -6493, -5771, -5059, -4377, -3742, -3163, -2652, -2218, -1863, -1590, -1397, -1280, -1232, -1244, -1308, -1412, -1544, -1692, -1844, -1992, -2127, -2241, -2327, -2384, -2412, -2413, -2389, -2347, -2295, -2242, -2196, -2170, -2172, -2214, -2304, -2449, -2655, -2926, -3262, -3660, -4121, -4635, -5194, -5789, -6405, -7031, -7650, -8250, -8814, -9331, -9786, -10169, -10473, -10690, -10819, -10855, -10806, -10674, -10468, -10198, -9876, -9516, -9136, -8748, -8371, -8020, -7707, -7446, -7248, -7121, -7072, -7102, -7211, -7398, -7654, -7973, -8343, -8751, -9185, -9628, -10066, -10484, -10867, -11203, -11480, -11689, -11822, -11877, -11850, -11743, -11559, -11304, -10985, -10613, -10199, -9753, -9287, -8815, -8344, -7888, -7454, -7048, -6673, -6334, -6030, -5757, -5513, -5289, -5079, -4872, -4659, -4429, -4173, -3880, -3544, -3157, -2715, -2218, -1663, -1055, -401, 292, 1015, 1749, 2484, 3203, 3888, 4522, 5088, 5569, 5950, 6221, 6368, 6385, 6268, 6015, 5626, 5109, 4471, 3722, 2876, 1952, 964, -68, -1123, -2187, -3236, -4254, -5228, -6138, -6975, -7732, -8397, -8971, -9450, -9835, -10128, -10336, -10462, -10516, -10505, -10436, -10317, -10154, -9952, -9715, -9443, -9139, -8799, -8418, -7995, -7516, -6979, -6372, -5684, -4908, -4036, -3059, -1976, -749};