/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0940 256 samples */
 
const int16_t AKWF_0940_256_DATA [256] = 
{679, 3198, 5647, 8066, 10435, 12742, 14976, 17113, 19151, 21077, 22875, 24543, 26072, 27448, 28674, 29744, 30650, 31397, 31981, 32401, 32663, 32765, 32714, 32515, 32171, 31690, 31077, 30342, 29493, 28533, 27477, 26331, 25102, 23802, 22440, 21018, 19555, 18053, 16520, 14969, 13404, 11830, 10263, 8701, 7155, 5637, 4143, 2686, 1275, -91, -1403, -2654, -3843, -4960, -6001, -6963, -7840, -8626, -9321, -9918, -10413, -10806, -11093, -11270, -11339, -11295, -11144, -10880, -10507, -10026, -9441, -8756, -7972, -7096, -6136, -5094, -3978, -2801, -1564, -278, 1041, 2393, 3764, 5140, 6519, 7885, 9225, 10538, 11808, 13025, 14187, 15280, 16297, 17235, 18085, 18842, 19506, 20068, 20529, 20888, 21142, 21293, 21340, 21289, 21139, 20893, 20556, 20132, 19625, 19042, 18384, 17660, 16875, 16031, 15136, 14197, 13215, 12195, 11145, 10066, 8963, 7842, 6700, 5547, 4383, 3208, 2029, 846, -338, -1522, -2703, -3881, -5049, -6207, -7355, -8484, -9597, -10687, -11749, -12782, -13783, -14740, -15655, -16522, -17332, -18085, -18772, -19387, -19928, -20388, -20762, -21048, -21239, -21333, -21328, -21221, -21012, -20697, -20280, -19762, -19140, -18423, -17612, -16709, -15726, -14664, -13531, -12337, -11088, -9792, -8463, -7105, -5730, -4353, -2977, -1616, -283, 1019, 2278, 3481, 4625, 5700, 6696, 7609, 8432, 9160, 9790, 10315, 10733, 11044, 11245, 11333, 11313, 11182, 10941, 10594, 10142, 9589, 8934, 8187, 7348, 6421, 5415, 4328, 3168, 1944, 656, -688, -2080, -3519, -4997, -6505, -8042, -9597, -11161, -12735, -14305, -15861, -17405, -18922, -20401, -21843, -23231, -24559, -25820, -27001, -28097, -29099, -29995, -30781, -31447, -31984, -32387, -32649, -32764, -32726, -32533, -32182, -31666, -30989, -30151, -29150, -27989, -26677, -25211, -23601, -21859, -19984, -17993, -15899, -13702, -11426, -9082, -6681, -4246, -1734};