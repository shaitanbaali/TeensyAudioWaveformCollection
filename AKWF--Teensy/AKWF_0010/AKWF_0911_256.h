/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0911 256 samples */
 
const int16_t AKWF_0911_256_DATA [256] = 
{429, 2010, 3549, 5084, 6607, 8120, 9626, 11118, 12603, 14083, 15550, 17013, 18470, 19923, 21329, 22593, 23776, 24896, 25931, 26868, 27703, 28434, 29055, 29576, 29996, 30319, 30551, 30695, 30758, 30744, 30656, 30500, 30279, 29998, 29660, 29269, 28829, 28342, 27810, 27238, 26624, 25983, 25268, 24130, 23232, 22515, 21754, 21003, 20293, 19643, 19070, 18585, 18189, 17884, 17671, 17546, 17506, 17548, 17667, 17859, 18120, 18447, 18835, 19279, 19779, 20329, 20924, 21566, 22248, 22970, 23729, 24520, 25345, 26201, 27083, 27992, 28899, 30007, 29535, 28078, 27914, 27461, 26670, 25627, 24402, 23055, 21631, 20153, 18662, 17048, 16597, 16557, 15572, 14765, 14121, 13567, 13040, 12499, 11913, 11260, 10532, 9717, 8813, 7823, 6743, 5577, 4331, 3005, 1602, 134, -1407, -3011, -4671, -6394, -8190, -9847, -11390, -12900, -14340, -15693, -16937, -18063, -19070, -19955, -20719, -21368, -21906, -22337, -22667, -22901, -23046, -23106, -23086, -22992, -22828, -22600, -22309, -21961, -21559, -21106, -20606, -20062, -19475, -18849, -18189, -17491, -16761, -16002, -15213, -14397, -13557, -12742, -11964, -11193, -10438, -9707, -9007, -8340, -7711, -7117, -6557, -6034, -5544, -5085, -4656, -4257, -3882, -3534, -3209, -2905, -2622, -2358, -2111, -1882, -1666, -1467, -1277, -1124, -1049, -1023, -1037, -1100, -1220, -1398, -1635, -1930, -2283, -2691, -3152, -3665, -4226, -4830, -5480, -6169, -6896, -7661, -8457, -9286, -10147, -11033, -11947, -12887, -13848, -14834, -15840, -16865, -17910, -18974, -20051, -21147, -22259, -23381, -24524, -25659, -26677, -27616, -28509, -29335, -30081, -30738, -31300, -31770, -32144, -32428, -32624, -32735, -32767, -32723, -32607, -32424, -32176, -31867, -31506, -31097, -29695, -28319, -27344, -26163, -24797, -23876, -22913, -21507, -20150, -18824, -17499, -16157, -14786, -13367, -11901, -10384, -8862, -7345, -5804, -4245, -2684, -1091};