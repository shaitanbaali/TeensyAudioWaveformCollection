/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0975 256 samples */
 
const int16_t AKWF_0975_256_DATA [256] = 
{1147, 3438, 5285, 6884, 8286, 9500, 10575, 11544, 12396, 13186, 14009, 14885, 15777, 16668, 17666, 18785, 19916, 20925, 21666, 22154, 22517, 22796, 23015, 23252, 23540, 23865, 24200, 24580, 25039, 25538, 25995, 26363, 26711, 27104, 27489, 27816, 28042, 28140, 28107, 27893, 27458, 26879, 26402, 26198, 26231, 26394, 26622, 26845, 27110, 27513, 27979, 28440, 28875, 29290, 29622, 29809, 29867, 29775, 29575, 29318, 29018, 28661, 28247, 27811, 27410, 27055, 26670, 26227, 25851, 23906, 19095, 13812, 8980, 4641, 890, -2282, -4995, -7349, -9408, -11186, -12684, -13963, -15023, -15884, -16638, -17340, -18006, -18620, -19121, -19519, -19830, -20035, -20100, -20005, -19784, -19443, -19034, -18682, -18512, -18541, -18658, -18746, -18783, -18807, -18845, -18888, -18959, -19134, -19407, -19701, -19975, -20201, -20346, -20375, -20254, -19970, -19546, -19085, -18709, -18443, -18238, -18094, -18037, -18122, -18394, -18810, -19287, -19756, -20201, -20614, -21004, -21361, -21590, -21657, -21585, -21405, -21148, -20820, -20430, -19996, -19542, -18988, -18342, -17712, -17136, -16604, -16073, -15534, -15003, -14487, -13986, -13476, -13021, -12777, -12798, -13013, -13391, -13929, -14519, -15065, -15554, -15949, -16253, -16530, -16848, -17247, -17770, -18452, -19219, -19920, -20553, -21178, -21776, -22304, -22705, -22983, -23175, -23349, -23517, -23644, -23701, -23696, -23645, -23565, -23458, -23317, -23148, -22971, -22834, -22763, -22772, -22935, -23307, -23836, -24464, -25232, -26132, -27075, -27926, -28542, -28932, -29182, -29324, -29419, -29518, -29641, -29826, -30095, -30456, -30913, -31398, -31830, -32131, -32277, -32343, -32412, -32548, -32701, -32768, -32722, -32536, -32227, -31892, -31653, -31596, -31717, -31930, -32115, -32087, -31822, -31460, -31032, -30565, -30122, -29705, -29230, -28684, -28144, -27644, -27192, -26780, -26354, -25847, -25305, -24884, -24657, -24533, -24422, -24264, -24178, -22286, -17674, -12879, -8580, -4780, -1490};