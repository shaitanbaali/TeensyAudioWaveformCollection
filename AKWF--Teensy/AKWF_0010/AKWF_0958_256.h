/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0958 256 samples */
 
const int16_t AKWF_0958_256_DATA [256] = 
{190, 787, 1382, 1985, 2588, 3182, 3748, 4304, 4904, 5519, 6162, 6806, 7443, 8081, 8732, 9401, 10081, 10768, 11457, 12143, 12823, 13491, 14160, 14836, 15505, 16158, 16794, 17404, 17985, 18545, 19092, 19621, 20123, 20586, 21011, 21397, 21743, 22066, 22393, 22731, 23069, 23390, 23685, 23958, 24207, 24432, 24649, 24858, 25047, 25206, 25333, 25422, 25472, 25496, 25525, 25565, 25610, 25646, 25667, 25672, 25664, 25643, 25622, 25605, 25582, 25542, 25481, 25396, 25284, 25158, 25046, 24957, 24883, 24810, 24729, 24642, 24550, 24452, 24361, 24282, 24203, 24112, 24007, 23883, 23736, 23574, 23409, 23235, 23044, 22829, 22586, 22319, 22026, 21710, 21377, 21022, 20639, 20226, 19780, 19302, 18795, 18273, 17760, 17261, 16759, 16236, 15693, 15123, 14531, 13927, 13319, 12702, 12069, 11407, 10718, 10007, 9272, 8530, 7807, 7107, 6417, 5723, 5018, 4305, 3586, 2866, 2160, 1462, 761, 49, -674, -1407, -2147, -2878, -3565, -4254, -4979, -5707, -6438, -7146, -7831, -8500, -9163, -9824, -10480, -11118, -11726, -12308, -12871, -13419, -13968, -14538, -15120, -15692, -16243, -16771, -17281, -17783, -18272, -18755, -19230, -19679, -20094, -20480, -20842, -21189, -21538, -21908, -22297, -22687, -23062, -23425, -23781, -24138, -24498, -24863, -25227, -25584, -25927, -26256, -26572, -26872, -27160, -27444, -27723, -27981, -28211, -28413, -28589, -28740, -28873, -28990, -29084, -29140, -29157, -29140, -29099, -29040, -28973, -28910, -28842, -28744, -28602, -28422, -28212, -27976, -27718, -27441, -27134, -26784, -26391, -25963, -25508, -25036, -24559, -24088, -23619, -23125, -22596, -22037, -21457, -20861, -20254, -19640, -19008, -18347, -17657, -16945, -16224, -15506, -14803, -14138, -13505, -12878, -12250, -11618, -10993, -10383, -9787, -9209, -8649, -8089, -7521, -6949, -6375, -5801, -5236, -4682, -4134, -3579, -3011, -2437, -1868, -1271, -485, -37};