/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0978 256 samples */
 
const int16_t AKWF_0978_256_DATA [256] = 
{14297, 13989, 14802, 16030, 16846, 16781, 16524, 16174, 16042, 15919, 15468, 15608, 16867, 18131, 18848, 20050, 21031, 21591, 21936, 22316, 22515, 22354, 22152, 21914, 21688, 22113, 23636, 24722, 24592, 24392, 24235, 24091, 24647, 24822, 24918, 24430, 24210, 25038, 25879, 25877, 25662, 25126, 24638, 24551, 24422, 23914, 23054, 23270, 24222, 24998, 26276, 27286, 27954, 28764, 30449, 31917, 32632, 32542, 31581, 31377, 31510, 30964, 30211, 29469, 29244, 29443, 29477, 29517, 29779, 29705, 29572, 28395, 26887, 26422, 26196, 26204, 25880, 25467, 25298, 24705, 23986, 23378, 23500, 24560, 25604, 26107, 26459, 26435, 26591, 27303, 27661, 27896, 27696, 27509, 26829, 26163, 26151, 26163, 26449, 26594, 27003, 27578, 27702, 27668, 27728, 27363, 27367, 27225, 31063, 16159, -11052, -7485, -8605, -9222, -8920, -8528, -8504, -8718, -9280, -9546, -9530, -9961, -9871, -9053, -9101, -9307, -9222, -9251, -9214, -9973, -10877, -11262, -11283, -10776, -10023, -9502, -9410, -9546, -9815, -10225, -9822, -9376, -9454, -9647, -9768, -9519, -9444, -10768, -12697, -13481, -13714, -13943, -13556, -12835, -11821, -10467, -9169, -9455, -11061, -12793, -14136, -15647, -17137, -18144, -19102, -19595, -19784, -19859, -20325, -20719, -20920, -21089, -20993, -20968, -20253, -19159, -18210, -17443, -17047, -16568, -16519, -15535, -14514, -13784, -12940, -12310, -11793, -11417, -11329, -11673, -12480, -12651, -12524, -12531, -12560, -12908, -13574, -14796, -15529, -15770, -16671, -17534, -18302, -19396, -19998, -20358, -20769, -20957, -21233, -21460, -22291, -23417, -23609, -23165, -22521, -21830, -21517, -21818, -21769, -21951, -22037, -22124, -22195, -22091, -22148, -21440, -20797, -20405, -20509, -20938, -21197, -21441, -22149, -22533, -22407, -23204, -23619, -23793, -23819, -23721, -22938, -21723, -21043, -21563, -19615, -6599, -6408, -6421, -6344, -6779, -7515, -7769, -7929, -7945, -7834, -8306};