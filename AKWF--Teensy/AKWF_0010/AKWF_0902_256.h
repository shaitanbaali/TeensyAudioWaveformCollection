/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0902 256 samples */
 
const int16_t AKWF_0902_256_DATA [256] = 
{285, 897, 1495, 2092, 2687, 3280, 3870, 4457, 5042, 5623, 6202, 6779, 7355, 7927, 8498, 9070, 9639, 10209, 10779, 11348, 11918, 12491, 13062, 13636, 14211, 14786, 15365, 15944, 16524, 17107, 17690, 18275, 18861, 19447, 20034, 20623, 21210, 21797, 22386, 22973, 23560, 24146, 24732, 25317, 25902, 26484, 27067, 27650, 28230, 28811, 29390, 29968, 30553, 31064, 31395, 31698, 32004, 32269, 32475, 32621, 32714, 32760, 32766, 32734, 32670, 32576, 32453, 32301, 32121, 31913, 31675, 31409, 31113, 30786, 30430, 30043, 29625, 29181, 28708, 28207, 27684, 27138, 26572, 25989, 25390, 24778, 24159, 23531, 22900, 22268, 21634, 21003, 20378, 19756, 19143, 18537, 17937, 17348, 16767, 16193, 15629, 15070, 14517, 13970, 13426, 12885, 12347, 11808, 11269, 10729, 10186, 9639, 9089, 8533, 7973, 7409, 6837, 6262, 5682, 5096, 4506, 3913, 3316, 2717, 2116, 1513, 910, 308, -295, -895, -1495, -2093, -2688, -3280, -3871, -4458, -5042, -5624, -6202, -6780, -7356, -7928, -8499, -9070, -9639, -10210, -10779, -11348, -11919, -12491, -13062, -13636, -14211, -14787, -15365, -15944, -16525, -17108, -17691, -18275, -18862, -19447, -20035, -20623, -21210, -21798, -22386, -22973, -23560, -24146, -24732, -25317, -25903, -26484, -27067, -27650, -28230, -28811, -29390, -29968, -30553, -31064, -31395, -31698, -32004, -32269, -32475, -32621, -32714, -32760, -32766, -32734, -32670, -32576, -32453, -32301, -32122, -31913, -31675, -31409, -31113, -30786, -30430, -30043, -29626, -29181, -28708, -28208, -27684, -27138, -26572, -25990, -25390, -24778, -24160, -23531, -22900, -22268, -21634, -21004, -20378, -19756, -19143, -18537, -17938, -17349, -16768, -16193, -15629, -15070, -14517, -13971, -13427, -12886, -12348, -11809, -11270, -10730, -10186, -9640, -9090, -8534, -7974, -7410, -6838, -6263, -5683, -5097, -4507, -3914, -3317, -2718, -2117, -1515, -914, -301};