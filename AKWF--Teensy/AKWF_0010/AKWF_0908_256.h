/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0908 256 samples */
 
const int16_t AKWF_0908_256_DATA [256] = 
{96, 319, 541, 763, 989, 1217, 1445, 1674, 1904, 2136, 2367, 2601, 2834, 3066, 3300, 3534, 3768, 4003, 4240, 4475, 4712, 4948, 5185, 5422, 5659, 5899, 6137, 6376, 6614, 6854, 7094, 7335, 7573, 7815, 8056, 8298, 8540, 8781, 9040, 9513, 10017, 10474, 10908, 11322, 11726, 12118, 12502, 12881, 13255, 13624, 13990, 14356, 14720, 15081, 15441, 15800, 16157, 16513, 16867, 17220, 17574, 17924, 18275, 18623, 18970, 19317, 19662, 20006, 20349, 20692, 21033, 21372, 21709, 22047, 22384, 22717, 23051, 23381, 23713, 24043, 24371, 24697, 25023, 25346, 25668, 25991, 26310, 26628, 26945, 27261, 27575, 27887, 28199, 28509, 28816, 29123, 29428, 29731, 30036, 30270, 30689, 31987, 19924, 14315, 15176, 14523, 13942, 13247, 12472, 11641, 10759, 9844, 8906, 7942, 6963, 5973, 4967, 3958, 2939, 1909, 878, -159, -1204, -2254, -3309, -4369, -5433, -6503, -7577, -8656, -9736, -10825, -11917, -13011, -14113, -15217, -16325, -17441, -18555, -19676, -20805, -21931, -23066, -24224, -25242, -27162, -26848, -25124, -24089, -23258, -22609, -22092, -21674, -21328, -21032, -20776, -20546, -20336, -20139, -19954, -19775, -19601, -19430, -19261, -19095, -18929, -18760, -18594, -18427, -18258, -18091, -17920, -17752, -17580, -17407, -17235, -17062, -16886, -16710, -16533, -16354, -16174, -15998, -15816, -15634, -15451, -15267, -15083, -14896, -14711, -14525, -14337, -14146, -13956, -13766, -13574, -13383, -13189, -12994, -12800, -12603, -12406, -12210, -12010, -11812, -11611, -11410, -11208, -11007, -10803, -10600, -10394, -10188, -9982, -9777, -9569, -9359, -9152, -8943, -8730, -8520, -8307, -8096, -7883, -7669, -7453, -7238, -7022, -6805, -6588, -6370, -6153, -5934, -5713, -5493, -5272, -5051, -4829, -4606, -4383, -4160, -3933, -3709, -3483, -3251, -3072, -1684, -1315, -1330, -1204, -1064, -901, -720, -527, -325, -112};