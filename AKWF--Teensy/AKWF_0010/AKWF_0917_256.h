/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0917 256 samples */
 
const int16_t AKWF_0917_256_DATA [256] = 
{1448, 4230, 7044, 9813, 12413, 14768, 16838, 18599, 20069, 21275, 22255, 23050, 23696, 24224, 24661, 25021, 25312, 25529, 25658, 25672, 25545, 25250, 24768, 24090, 23233, 22250, 21238, 20360, 19791, 19658, 20026, 20950, 22467, 24412, 26498, 28522, 30312, 31704, 32546, 32767, 32392, 31488, 30152, 28491, 26633, 24714, 22845, 21138, 19676, 18499, 17630, 17067, 16775, 16709, 16816, 17040, 17327, 17634, 17929, 18190, 18411, 18596, 18758, 18919, 19083, 19236, 19361, 19439, 19455, 19397, 19258, 19035, 18723, 18324, 17845, 17289, 16668, 15996, 15280, 14536, 13760, 13020, 12086, 8725, 5538, 3837, 2307, 824, -525, -1693, -2678, -3480, -4112, -4604, -4992, -5334, -5682, -6077, -6543, -7090, -7704, -8368, -9053, -9720, -10341, -10894, -11363, -11746, -12042, -12257, -12418, -12540, -12639, -12722, -12801, -12822, -12751, -12695, -12648, -12593, -12528, -12452, -12369, -12277, -12179, -12075, -11970, -11865, -11761, -11659, -11560, -11464, -11372, -11284, -11200, -11121, -11046, -10974, -10907, -10843, -10784, -10729, -10676, -10628, -10582, -10540, -10501, -10464, -10431, -10401, -10373, -10346, -10323, -10301, -10283, -10266, -10250, -10236, -10225, -10214, -10206, -10198, -10192, -10188, -10184, -10182, -10181, -10181, -10182, -10183, -10186, -10190, -10195, -10200, -10206, -10212, -10220, -10228, -10235, -10245, -10254, -10264, -10274, -10285, -10296, -10307, -10319, -10332, -10344, -10357, -10370, -10383, -10396, -10410, -10424, -10437, -10452, -10467, -10481, -10495, -10511, -10526, -10539, -10555, -10570, -10585, -10600, -10615, -10631, -10646, -10662, -10678, -10692, -10707, -10723, -10739, -10754, -10770, -10785, -10800, -10815, -10831, -10846, -10861, -10876, -10892, -10907, -10922, -10938, -10952, -10967, -10982, -10997, -11012, -11026, -11042, -11056, -11070, -11085, -11100, -11114, -11129, -11143, -11157, -11171, -11185, -11199, -11213, -11226, -11229, -11265, -11147, -8672, -5594, -3378, -1033};