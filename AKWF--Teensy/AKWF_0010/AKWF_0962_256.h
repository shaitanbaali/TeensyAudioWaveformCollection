/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0962 256 samples */
 
const int16_t AKWF_0962_256_DATA [256] = 
{461, 1234, 1977, 2705, 3417, 4114, 4798, 5468, 6125, 6770, 7402, 8024, 8636, 9237, 9833, 10420, 11000, 11576, 12150, 12720, 13290, 13861, 14434, 15014, 15599, 16190, 16795, 17410, 18038, 18683, 19343, 20019, 20735, 21335, 21931, 22511, 23009, 23519, 23976, 24415, 24842, 25247, 25628, 25988, 26333, 26662, 26981, 27290, 27585, 27870, 28142, 28400, 28647, 28879, 29099, 29309, 29508, 29700, 29885, 30065, 30242, 30419, 30597, 30777, 30982, 31059, 31118, 31149, 31088, 31031, 30908, 30761, 30593, 30397, 30172, 29919, 29647, 29357, 29053, 28734, 28404, 28061, 27703, 27333, 26951, 26557, 26152, 25738, 25317, 24891, 24461, 24030, 23601, 23174, 22755, 22342, 21958, 21454, 20936, 20396, 19770, 19153, 18479, 17786, 17077, 16348, 15597, 14826, 14040, 13246, 12442, 11632, 10818, 9996, 9168, 8337, 7498, 6655, 5810, 4960, 4111, 3266, 2422, 1584, 756, -62, -866, -1655, -2428, -3180, -3917, -4638, -5341, -6029, -6705, -7365, -8012, -8648, -9269, -9880, -10482, -11073, -11658, -12235, -12805, -13371, -13934, -14493, -15054, -15616, -16179, -16749, -17326, -17910, -18505, -19112, -19733, -20370, -21024, -21693, -22402, -22998, -23587, -24162, -24654, -25159, -25613, -26048, -26469, -26871, -27248, -27606, -27946, -28274, -28590, -28895, -29189, -29472, -29742, -29998, -30243, -30475, -30694, -30902, -31101, -31291, -31476, -31655, -31832, -32008, -32187, -32366, -32570, -32647, -32706, -32738, -32677, -32619, -32497, -32350, -32182, -31987, -31763, -31511, -31239, -30949, -30645, -30328, -29998, -29654, -29298, -28929, -28548, -28154, -27750, -27337, -26916, -26491, -26061, -25632, -25203, -24778, -24360, -23948, -23564, -23060, -22543, -22003, -21379, -20763, -20088, -19397, -18690, -17960, -17211, -16441, -15654, -14861, -14059, -13249, -12437, -11615, -10789, -9958, -9119, -8276, -7432, -6583, -5736, -4890, -4047, -3210, -2378, -1599, -610, 22};