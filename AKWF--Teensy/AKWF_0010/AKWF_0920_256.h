/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0920 256 samples */
 
const int16_t AKWF_0920_256_DATA [256] = 
{3258, 9429, 15532, 21239, 26115, 29810, 32071, 32769, 31926, 29694, 26350, 22241, 17762, 13322, 9251, 5827, 3229, 1503, 619, 450, 813, 1504, 2320, 3094, 3708, 4108, 4290, 4295, 4195, 4061, 3948, 3887, 3864, 3832, 3717, 3430, 2898, 2069, 938, -441, -1972, -3506, -4870, -5891, -6420, -6357, -5669, -4404, -2693, -717, 1287, 3072, 4422, 5156, 5175, 4474, 3137, 1330, -723, -2767, -4552, -5874, -6591, -6654, -6104, -5070, -3746, -2361, -1152, -316, 9, -230, -994, -2165, -3545, -4906, -6008, -6641, -6659, -6000, -4690, -2843, -660, 1614, 3733, 5451, 6577, 7004, 6707, 5753, 4285, 2511, 656, -1058, -2434, -3341, -3719, -3581, -3006, -2127, -1106, -101, 743, 1328, 1600, 1554, 1234, 707, 46, -678, -1430, -2204, -3032, -3979, -5116, -6507, -8195, -10159, -12320, -14537, -16598, -18254, -19251, -19341, -18337, -16134, -12749, -8308, -3049, 2657, 8418, 13798, 18359, 21757, 23743, 24190, 23121, 20685, 17170, 12916, 8320, 3793, -336, -3789, -6386, -8078, -8901, -8978, -8493, -7652, -6659, -5678, -4831, -4174, -3711, -3400, -3176, -2966, -2715, -2399, -2027, -1654, -1352, -1213, -1314, -1707, -2399, -3341, -4435, -5536, -6472, -7073, -7192, -6729, -5655, -4020, -1954, 357, 2679, 4762, 6385, 7371, 7617, 7119, 5959, 4305, 2376, 432, -1278, -2554, -3251, -3318, -2798, -1818, -571, 711, 1799, 2494, 2658, 2240, 1278, -103, -1705, -3299, -4644, -5528, -5805, -5405, -4356, -2773, -847, 1173, 3041, 4517, 5411, 5618, 5114, 3969, 2324, 393, -1600, -3432, -4903, -5885, -6312, -6200, -5626, -4721, -3649, -2570, -1621, -909, -484, -351, -467, -768, -1177, -1629, -2087, -2549, -3047, -3645, -4418, -5432, -6730, -8293, -10045, -11847, -13489, -14726, -15299, -14966, -13546, -10940, -7172, -2224};