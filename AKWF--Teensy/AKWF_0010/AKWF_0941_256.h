/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0941 256 samples */
 
const int16_t AKWF_0941_256_DATA [256] = 
{742, 3487, 6149, 8771, 11324, 13792, 16160, 18403, 20514, 22480, 24285, 25927, 27395, 28685, 29798, 30729, 31479, 32055, 32459, 32694, 32769, 32689, 32464, 32100, 31607, 30992, 30263, 29430, 28502, 27481, 26382, 25209, 23967, 22666, 21314, 19911, 18473, 17000, 15499, 13983, 12454, 10918, 9392, 7875, 6376, 4911, 3478, 2092, 764, -506, -1707, -2829, -3870, -4823, -5681, -6442, -7103, -7661, -8117, -8469, -8718, -8868, -8921, -8880, -8749, -8536, -8243, -7876, -7443, -6949, -6399, -5800, -5159, -4478, -3768, -3029, -2267, -1490, -698, 101, 902, 1706, 2505, 3293, 4069, 4827, 5560, 6266, 6939, 7572, 8163, 8703, 9189, 9617, 9980, 10276, 10502, 10653, 10730, 10732, 10657, 10509, 10289, 10003, 9652, 9245, 8788, 8287, 7751, 7191, 6613, 6026, 5442, 4865, 4305, 3770, 3263, 2792, 2359, 1965, 1614, 1304, 1032, 795, 591, 411, 251, 104, -38, -181, -334, -506, -699, -922, -1179, -1473, -1807, -2184, -2600, -3057, -3549, -4073, -4624, -5195, -5778, -6366, -6949, -7518, -8066, -8583, -9059, -9489, -9865, -10179, -10429, -10608, -10714, -10745, -10700, -10581, -10386, -10120, -9785, -9383, -8922, -8404, -7834, -7220, -6563, -5869, -5148, -4399, -3629, -2847, -2051, -1248, -446, 356, 1152, 1934, 2705, 3455, 4177, 4873, 5532, 6149, 6722, 7241, 7701, 8098, 8422, 8671, 8838, 8917, 8905, 8796, 8590, 8281, 7869, 7356, 6737, 6017, 5201, 4287, 3281, 2194, 1024, -217, -1521, -2885, -4298, -5750, -7237, -8747, -10269, -11804, -13336, -14858, -16367, -17852, -19306, -20726, -22099, -23423, -24692, -25893, -27026, -28081, -29049, -29923, -30699, -31362, -31909, -32329, -32614, -32756, -32748, -32582, -32250, -31748, -31072, -30217, -29181, -27967, -26572, -25004, -23268, -21367, -19316, -17130, -14810, -12382, -9865, -7269, -4625, -1889};