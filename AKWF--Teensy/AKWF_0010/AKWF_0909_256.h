/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0909 256 samples */
 
const int16_t AKWF_0909_256_DATA [256] = 
{685, 2679, 4773, 6998, 9332, 11762, 14290, 16809, 19160, 21506, 23330, 24566, 25647, 26488, 27033, 27264, 27194, 26849, 26264, 25479, 24521, 23425, 22217, 20914, 19540, 18109, 16627, 15110, 13565, 11991, 10405, 8785, 7343, 6215, 5144, 4139, 3246, 2473, 1821, 1284, 847, 495, 216, -4, -177, -311, -416, -497, -559, -608, -645, -675, -699, -719, -735, -749, -761, -772, -783, -793, -803, -812, -821, -831, -841, -850, -860, -870, -879, -890, -899, -909, -920, -930, -940, -951, -963, -967, -1010, -1390, -1953, -2567, -3283, -4123, -5097, -6196, -7407, -8721, -10120, -11588, -13120, -14700, -16317, -17971, -19650, -21351, -23073, -24807, -26552, -28315, -30077, -31251, -31871, -32958, -28333, -23140, -22442, -20524, -17839, -14768, -11502, -12136, -11390, -8513, -6460, -4786, -3238, -1652, 63, 1960, 4044, 6303, 8748, 11096, 13266, 15517, 17603, 19040, 20197, 21170, 21879, 22301, 22438, 22310, 21950, 21392, 20665, 19799, 18823, 17754, 16611, 15413, 14167, 12883, 11573, 10236, 8882, 7509, 6156, 5084, 4157, 3261, 2448, 1736, 1129, 623, 210, -124, -391, -602, -768, -897, -997, -1074, -1134, -1179, -1215, -1242, -1264, -1281, -1295, -1307, -1316, -1325, -1333, -1340, -1348, -1355, -1362, -1369, -1375, -1382, -1389, -1396, -1404, -1411, -1418, -1426, -1433, -1440, -1448, -1455, -1462, -1471, -1478, -1486, -1493, -1501, -1508, -1516, -1523, -1531, -1538, -1546, -1553, -1560, -1568, -1575, -1582, -1590, -1597, -1604, -1611, -1618, -1625, -1632, -1639, -1648, -1648, -1800, -2142, -2521, -2953, -3463, -4056, -4732, -5484, -6305, -7183, -8110, -9081, -10082, -11114, -12169, -13239, -14327, -15429, -16538, -17658, -18781, -19934, -20834, -21521, -21126, -16490, -14943, -14097, -12085, -11590, -12284, -9961, -7837, -6073, -4448, -2831, -1094};