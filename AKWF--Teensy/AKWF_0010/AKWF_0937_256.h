/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0937 256 samples */
 
const int16_t AKWF_0937_256_DATA [256] = 
{1717, 7453, 11992, 15590, 18358, 20450, 22017, 23193, 24116, 24899, 25634, 26391, 27204, 28070, 28967, 29849, 30666, 31379, 31956, 32380, 32648, 32762, 32735, 32588, 32345, 32039, 31706, 31378, 31083, 30832, 30624, 30437, 30236, 29983, 29632, 29144, 28486, 27637, 26590, 25367, 24008, 22578, 21171, 19870, 18743, 17828, 17102, 16499, 15921, 15242, 14345, 13123, 11486, 9391, 6847, 3915, 743, -2274, -4686, -6411, -7465, -7902, -7810, -7315, -6580, -5797, -5164, -4855, -4982, -5575, -6567, -7814, -9143, -10374, -11357, -11987, -12197, -11965, -11310, -10289, -9004, -7591, -6216, -5051, -4228, -3826, -3842, -4195, -4754, -5358, -5864, -6155, -6158, -5851, -5260, -4464, -3577, -2751, -2136, -1858, -1985, -2513, -3360, -4388, -5440, -6358, -7013, -7320, -7235, -6768, -5972, -4954, -3864, -2875, -2165, -1873, -2062, -2704, -3683, -4824, -5926, -6802, -7300, -7303, -6745, -5599, -3900, -1731, 729, 3053, 4959, 6343, 7142, 7366, 7062, 6326, 5297, 4148, 3081, 2281, 1897, 1993, 2544, 3437, 4505, 5572, 6474, 7084, 7330, 7181, 6662, 5838, 4824, 3766, 2824, 2153, 1855, 1971, 2459, 3216, 4096, 4944, 5630, 6060, 6184, 6005, 5574, 4991, 4395, 3937, 3769, 3994, 4650, 5688, 6999, 8418, 9774, 10922, 11738, 12150, 12123, 11662, 10816, 9670, 8362, 7061, 5944, 5174, 4853, 4994, 5513, 6258, 7039, 7654, 7931, 7727, 6939, 5496, 3370, 577, -2603, -5658, -8372, -10659, -12484, -13867, -14889, -15644, -16249, -16828, -17493, -18326, -19367, -20605, -21979, -23413, -24811, -26096, -27221, -28153, -28888, -29444, -29847, -30135, -30353, -30541, -30737, -30970, -31249, -31567, -31903, -32225, -32498, -32689, -32769, -32715, -32513, -32154, -31638, -30979, -30202, -29342, -28447, -27567, -26731, -25954, -25220, -24467, -23617, -22564, -21176, -19323, -16858, -13625, -9502, -4212};