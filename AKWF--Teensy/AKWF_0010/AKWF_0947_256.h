/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0947 256 samples */
 
const int16_t AKWF_0947_256_DATA [256] = 
{359, 1330, 2041, 2663, 3674, 4726, 5592, 6656, 7915, 9006, 10077, 11339, 12515, 13509, 14585, 15659, 16504, 17294, 18135, 18803, 19310, 19868, 20369, 20682, 20998, 21365, 21590, 21749, 22009, 22221, 22308, 22466, 22677, 22751, 22816, 22994, 23090, 23084, 23189, 23322, 23317, 23360, 23531, 23611, 23655, 23885, 24139, 24282, 24573, 25027, 25363, 25719, 26308, 26849, 27240, 27813, 28452, 28815, 29164, 29671, 29897, 29836, 29920, 29856, 29263, 28643, 28107, 26982, 25500, 24307, 22762, 20458, 18441, 16670, 13839, 10804, 9053, 6505, 1542, -1389, 2155, 9039, 13992, 17323, 21287, 24828, 26738, 28171, 29539, 29887, 29495, 29229, 28704, 27625, 26708, 26076, 25228, 24431, 24065, 23737, 23295, 23121, 23106, 22897, 22710, 22702, 22559, 22276, 22130, 21982, 21642, 21330, 21094, 20682, 20137, 19626, 18969, 18060, 17078, 16004, 14680, 13228, 11781, 10232, 8596, 7069, 5636, 4208, 2921, 1838, 812, -156, -967, -1748, -2615, -3482, -4378, -5451, -6653, -7901, -9285, -10810, -12331, -13832, -15378, -16853, -18156, -19376, -20503, -21410, -22166, -22867, -23415, -23805, -24193, -24550, -24771, -24982, -25251, -25426, -25526, -25707, -25866, -25898, -25987, -26175, -26279, -26405, -26756, -27159, -27530, -28145, -28949, -29636, -30368, -31294, -31987, -32326, -32662, -32714, -31981, -30876, -29599, -27338, -24212, -21321, -17940, -12682, -7719, -7102, -10847, -15401, -19065, -22538, -25789, -28133, -29855, -31341, -32220, -32451, -32475, -32273, -31667, -30936, -30265, -29494, -28681, -28039, -27497, -26963, -26563, -26307, -26071, -25875, -25767, -25671, -25551, -25450, -25345, -25213, -25065, -24896, -24713, -24525, -24299, -24036, -23778, -23474, -23071, -22647, -22186, -21565, -20845, -20120, -19242, -18182, -17148, -16074, -14770, -13481, -12354, -11054, -9657, -8609, -7603, -6259, -5270, -4856, -3740, -1789, -1028, -2008, -2521, -1517, -502, -175};