/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0951 256 samples */
 
const int16_t AKWF_0951_256_DATA [256] = 
{4903, 9789, 13743, 19316, 19928, 21575, 23266, 21706, 15376, 11338, 3621, -1546, -7928, -15811, -15634, -18987, -19748, -21265, -23614, -24501, -24044, -23413, -22193, -20447, -18881, -18046, -16892, -16242, -15304, -14415, -13514, -14482, -14910, -15927, -14848, -14230, -13695, -12515, -10761, -9256, -7100, -5487, -3316, -2153, -1557, -499, 163, 1161, 1229, 1962, 1970, 2345, 2458, 2451, 2452, 2747, 4631, 5676, 7503, 8190, 7749, 8326, 8450, 9152, 10042, 8756, 3856, 1029, -3540, -6110, -10728, -3338, 2057, 6116, -2207, 6722, 9369, 15893, 11067, 8996, 3721, 3931, 2247, 3491, 2339, 1695, 272, -1597, -2598, -1218, 46, 1850, 3388, 3099, 3840, 4153, 4992, 5807, 6324, 6488, 5907, 6288, 6142, 6447, 6310, 7654, 9196, 10695, 12333, 13493, 15238, 15539, 15884, 16371, 16256, 15123, 14324, 13106, 13733, 13297, 13230, 12396, 11723, 11291, 11814, 11716, 11700, 11666, 11524, 11497, 12387, 12727, 12412, 12912, 11000, 2256, -2286, -10239, -15180, -20687, -28384, -28508, -30581, -31756, -30851, -27362, -24398, -18445, -14024, -8002, -4188, -3126, 6, 1300, 4371, 6372, 7229, 7813, 5379, 3138, 643, -1703, -3519, -5801, -8555, -8420, -9352, -9397, -9967, -10708, -10118, -9179, -8595, -8026, -7661, -8550, -8513, -9131, -9407, -9850, -10386, -9769, -9905, -9484, -9658, -8981, -7348, -6021, -4279, -4415, -3710, -3321, -2446, -1570, -937, -622, -1029, -478, -448, -11, 232, 325, 473, 673, 901, 1127, 1448, 1139, 1128, 1504, 1610, 2050, 2149, 2276, 2285, 3358, 4767, 6002, 7215, 6733, 7186, 7239, 8008, 7910, 6935, 6213, 5066, 4351, 3271, 2846, 2881, 2501, 3232, 3360, 3209, 3265, 3291, 3521, 4326, 2492, 493, -1528, -3665, -5188, -7185, -9805, -9635, -10307, -10316, -10705, -11321, -11307, -11094, -9922, -1883, 275};