/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0901 256 samples */
 
const int16_t AKWF_0901_256_DATA [256] = 
{83, 342, 596, 853, 1111, 1371, 1636, 1903, 2173, 2447, 2725, 3005, 3290, 3577, 3867, 4159, 4452, 4747, 5044, 5340, 5637, 5933, 6229, 6524, 6817, 7108, 7399, 7688, 7974, 8259, 8541, 8821, 9101, 9379, 9655, 9931, 10205, 10479, 10754, 11027, 11301, 11576, 11850, 12125, 12401, 12678, 12957, 13236, 13516, 13796, 14080, 14362, 14646, 14930, 15215, 15502, 15788, 16073, 16360, 16645, 16931, 17218, 17502, 17788, 18072, 18356, 18639, 18923, 19204, 19485, 19767, 20048, 20329, 20609, 20888, 21168, 21447, 21727, 22006, 22286, 22565, 22844, 23125, 23405, 23686, 23967, 24248, 24530, 24812, 25093, 25376, 25659, 25942, 26225, 26507, 26790, 27073, 27356, 27640, 27923, 28205, 28488, 28771, 29052, 29335, 29618, 29899, 30181, 30463, 30745, 31026, 31308, 31588, 31870, 32138, 32321, 33220, 25660, 15895, 16959, 16544, 13705, 10216, 6878, 3940, 1402, -783, -2701, -4434, -6035, -7563, -9060, -10550, -12058, -13595, -15155, -16744, -18347, -19946, -21530, -23077, -24560, -25967, -27273, -28459, -29513, -30417, -31162, -31743, -32156, -32402, -32485, -32411, -32191, -31838, -31367, -30796, -30139, -29420, -28654, -27858, -27056, -26260, -25485, -24748, -24058, -23424, -22855, -22355, -21925, -21568, -21280, -21059, -20900, -20794, -20736, -20717, -20728, -20758, -20799, -20842, -20877, -20898, -20898, -20868, -20807, -20708, -20569, -20391, -20172, -19913, -19616, -19283, -18920, -18529, -18114, -17684, -17240, -16788, -16335, -15883, -15438, -15006, -14586, -14184, -13802, -13440, -13099, -12781, -12484, -12208, -11951, -11712, -11488, -11277, -11074, -10880, -10691, -10502, -10314, -10121, -9923, -9718, -9503, -9278, -9043, -8795, -8535, -8264, -7981, -7687, -7384, -7072, -6754, -6430, -6101, -5770, -5438, -5105, -4774, -4447, -4123, -3803, -3490, -3182, -2880, -2585, -2296, -2014, -1738, -1467, -1200, -938, -679, -423, -163};