/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0916 256 samples */
 
const int16_t AKWF_0916_256_DATA [256] = 
{608, 2176, 3645, 5042, 6355, 7582, 8717, 9758, 10709, 11571, 12347, 13045, 13670, 14228, 14729, 15181, 15588, 15960, 16304, 16624, 16928, 17217, 17495, 17766, 18027, 18280, 18524, 18756, 18974, 19174, 19354, 19509, 19637, 19734, 19797, 19826, 19818, 19772, 19690, 19572, 19419, 19236, 19026, 18791, 18536, 18268, 17990, 17708, 17427, 17149, 16882, 16629, 16389, 16168, 15969, 15789, 15632, 15494, 15376, 15274, 15187, 15113, 15047, 14985, 14926, 14864, 14798, 14722, 14637, 14537, 14424, 14293, 14145, 13981, 13800, 13605, 13394, 13172, 12939, 12701, 12460, 12215, 11974, 11739, 11510, 11293, 11088, 10899, 10727, 10572, 10437, 10320, 10222, 10141, 10079, 10031, 9996, 9972, 9958, 9948, 9942, 9935, 9926, 9911, 9887, 9854, 9805, 9742, 9661, 9563, 9446, 9307, 9151, 8972, 8776, 8564, 8333, 8088, 7832, 7563, 7288, 7009, 6727, 6445, 6168, 5896, 5634, 5384, 5147, 4927, 4725, 4543, 4381, 4242, 4125, 4031, 3958, 3908, 3879, 3869, 3877, 3901, 3938, 3987, 4043, 4105, 4166, 4228, 4283, 4329, 4363, 4380, 4378, 4351, 4299, 4216, 4101, 3949, 3760, 3531, 3257, 2941, 2579, 2169, 1715, 1212, 661, 65, -577, -1266, -1996, -2770, -3584, -4433, -5319, -6236, -7181, -8153, -9148, -10160, -11189, -12229, -13275, -14327, -15379, -16425, -17467, -18495, -19508, -20505, -21479, -22427, -23349, -24239, -25094, -25915, -26694, -27433, -28131, -28782, -29388, -29946, -30454, -30914, -31324, -31682, -31989, -32244, -32449, -32603, -32706, -32759, -32764, -32722, -32632, -32496, -32316, -32094, -31829, -31526, -31184, -30806, -30394, -29951, -29476, -28974, -28446, -27891, -27317, -26723, -26109, -25480, -24838, -24183, -23520, -22849, -22171, -21492, -20810, -20128, -19449, -18773, -18100, -17445, -16761, -15673, -14415, -13196, -11903, -10512, -9029, -7475, -5873, -4238, -2598, -942};