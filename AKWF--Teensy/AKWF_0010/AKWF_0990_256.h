/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0990 256 samples */
 
const int16_t AKWF_0990_256_DATA [256] = 
{557, 2373, 4105, 5793, 7423, 8995, 10504, 11941, 13309, 14602, 15816, 16952, 18009, 18981, 19873, 20682, 21406, 22050, 22611, 23090, 23491, 23813, 24058, 24230, 24329, 24357, 24316, 24212, 24045, 23819, 23537, 23201, 22815, 22382, 21907, 21389, 20836, 20249, 19629, 18984, 18314, 17622, 16914, 16190, 15454, 14710, 13957, 13201, 12445, 11688, 10935, 10191, 9451, 8723, 8006, 7302, 6613, 5942, 5287, 4653, 4039, 3446, 2875, 2328, 1805, 1305, 829, 379, -44, -442, -817, -1164, -1487, -1785, -2058, -2306, -2531, -2730, -2907, -3061, -3136, -2989, -2500, -1626, -370, 1230, 3119, 5242, 7530, 9919, 12360, 14793, 17173, 19466, 21632, 23646, 25491, 27141, 28589, 29829, 30848, 31650, 32235, 32602, 32760, 32715, 32472, 32042, 31435, 30662, 29731, 28655, 27450, 26121, 24682, 23152, 21531, 19838, 18087, 16280, 14436, 12564, 10669, 8767, 6867, 4969, 3092, 1241, -584, -2365, -4103, -5794, -7424, -8996, -10505, -11942, -13310, -14603, -15816, -16953, -18009, -18982, -19874, -20683, -21407, -22051, -22612, -23091, -23492, -23814, -24059, -24230, -24329, -24357, -24317, -24213, -24045, -23819, -23537, -23201, -22815, -22383, -21907, -21390, -20837, -20249, -19630, -18985, -18315, -17623, -16915, -16191, -15454, -14710, -13957, -13201, -12446, -11689, -10936, -10191, -9452, -8723, -8007, -7303, -6614, -5943, -5288, -4654, -4040, -3447, -2876, -2329, -1806, -1305, -830, -380, 43, 441, 816, 1163, 1486, 1785, 2057, 2305, 2530, 2729, 2906, 3060, 3135, 2988, 2499, 1625, 369, -1231, -3120, -5243, -7530, -9919, -12361, -14794, -17173, -19467, -21632, -23647, -25491, -27141, -28590, -29829, -30848, -31650, -32235, -32602, -32760, -32715, -32472, -32042, -31435, -30662, -29731, -28655, -27450, -26121, -24683, -23152, -21531, -19838, -18087, -16281, -14436, -12565, -10670, -8768, -6867, -4973, -3101, -1217};