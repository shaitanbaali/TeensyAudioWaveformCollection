/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0988 256 samples */
 
const int16_t AKWF_0988_256_DATA [256] = 
{1035, 2812, 4506, 6154, 7743, 9273, 10739, 12132, 13456, 14706, 15876, 16971, 17985, 18916, 19767, 20537, 21223, 21830, 22356, 22801, 23171, 23462, 23678, 23823, 23895, 23901, 23840, 23716, 23532, 23291, 22995, 22648, 22252, 21811, 21330, 20808, 20252, 19663, 19045, 18402, 17736, 17049, 16348, 15631, 14903, 14169, 13428, 12684, 11942, 11199, 10460, 9730, 9007, 8294, 7595, 6908, 6237, 5583, 4946, 4330, 3735, 3158, 2606, 2077, 1570, 1089, 630, 197, -209, -592, -951, -1283, -1591, -1875, -2133, -2368, -2580, -2768, -2935, -3078, -3202, -3304, -3387, -3449, -3495, -3523, -3533, -3529, -3509, -3475, -3428, -3368, -3298, -3217, -3125, -3026, -2919, -2804, -2682, -2556, -2424, -2289, -2151, -2010, -1866, -1722, -1578, -1434, -1289, -1147, -1005, -866, -729, -595, -465, -338, -215, -97, 16, 126, 230, 329, 423, 511, 595, 673, 744, 812, 873, 929, 979, 1023, 1062, 1096, 1125, 1149, 1167, 1182, 1192, 1197, 1199, 1196, 1190, 1179, 1165, 1148, 1128, 1106, 1080, 1052, 1023, 990, 956, 921, 885, 847, 808, 768, 727, 686, 645, 604, 562, 521, 480, 439, 399, 360, 321, 283, 246, 210, 175, 141, 109, 78, 48, 19, -7, -33, -56, -79, -101, -120, -139, -156, -171, -185, -198, -209, -219, -227, -234, -240, -245, -249, -251, -252, -253, -252, -250, -248, -245, -240, -236, -230, -225, -218, -241, -423, -891, -1700, -2857, -4330, -6070, -8029, -10140, -12345, -14597, -16839, -19027, -21132, -23113, -24946, -26615, -28097, -29384, -30469, -31344, -32008, -32465, -32714, -32761, -32614, -32281, -31767, -31084, -30244, -29255, -28129, -26881, -25516, -24050, -22497, -20862, -19160, -17406, -15601, -13763, -11904, -10024, -8142, -6265, -4398, -2556, -705};