/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0912 256 samples */
 
const int16_t AKWF_0912_256_DATA [256] = 
{1549, 3963, 6247, 8447, 10547, 12541, 14426, 16192, 17843, 19368, 20745, 21961, 22998, 23836, 24465, 24870, 25045, 24989, 24706, 24209, 23510, 22634, 21606, 20445, 19185, 17851, 16465, 15056, 13647, 12257, 10912, 9631, 8426, 7320, 6319, 5432, 4665, 4018, 3486, 3064, 2743, 2515, 2368, 2301, 2314, 2410, 2590, 2858, 3213, 3659, 4191, 4801, 5480, 6211, 6976, 7759, 8539, 9295, 10013, 10670, 11258, 11767, 12182, 12497, 12703, 12792, 12760, 12598, 12304, 11873, 11303, 10609, 9716, 8528, 7164, 5618, 3899, 2065, 168, -1734, -3580, -5329, -6930, -8340, -9539, -10509, -11253, -11792, -12161, -12410, -12594, -12776, -13017, -13368, -13873, -14563, -15460, -16562, -17864, -19347, -20971, -22701, -24485, -26257, -27955, -29503, -30826, -31853, -32520, -32762, -32661, -32354, -31692, -30717, -29487, -28025, -26344, -24476, -22457, -20305, -18050, -15713, -13300, -10837, -8343, -5830, -3329, -852, 1583, 3951, 6243, 8447, 10546, 12541, 14426, 16192, 17842, 19367, 20745, 21961, 22998, 23836, 24465, 24870, 25045, 24988, 24706, 24208, 23510, 22634, 21605, 20445, 19185, 17850, 16463, 15054, 13646, 12256, 10911, 9630, 8425, 7318, 6318, 5430, 4665, 4018, 3486, 3064, 2743, 2515, 2369, 2301, 2314, 2409, 2590, 2857, 3213, 3659, 4190, 4800, 5479, 6211, 6975, 7759, 8538, 9296, 10013, 10669, 11258, 11765, 12182, 12497, 12702, 12792, 12759, 12597, 12303, 11872, 11302, 10607, 9714, 8527, 7163, 5617, 3899, 2065, 166, -1734, -3581, -5330, -6931, -8341, -9540, -10511, -11253, -11793, -12163, -12411, -12595, -12777, -13017, -13369, -13874, -14564, -15461, -16563, -17866, -19348, -20972, -22702, -24487, -26258, -27955, -29505, -30827, -31855, -32522, -32764, -32663, -32355, -31693, -30718, -29488, -28027, -26345, -24477, -22458, -20305, -18050, -15714, -13300, -10838, -8343, -5835, -3339, -820};