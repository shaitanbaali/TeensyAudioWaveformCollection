/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0968 256 samples */
 
const int16_t AKWF_0968_256_DATA [256] = 
{5458, 5141, 4819, 4502, 4204, 3939, 3719, 3555, 3452, 3419, 3454, 3560, 3736, 3973, 4267, 4609, 4986, 5391, 5811, 6233, 6646, 7040, 7402, 7729, 8011, 8241, 8420, 8545, 8615, 8635, 8608, 8541, 8439, 8311, 8164, 8005, 7844, 7686, 7540, 7411, 7304, 7221, 7164, 7132, 7126, 7145, 7183, 7236, 7302, 7373, 7443, 7508, 7565, 7606, 7627, 7627, 7604, 7556, 7482, 7385, 7266, 7128, 6973, 6804, 6628, 6438, 6270, 6140, 6005, 5863, 5711, 5546, 5362, 5156, 4925, 4664, 4376, 4057, 3706, 3328, 2925, 2496, 2048, 1589, 1122, 654, 160, 305, 823, 1284, 1750, 2207, 2647, 3069, 3463, 3832, 4172, 4481, 4759, 5008, 5230, 5429, 5606, 5766, 5914, 6053, 6186, 6323, 6507, 6690, 6865, 7029, 7178, 7310, 7422, 7511, 7576, 7617, 7630, 7622, 7593, 7546, 7486, 7418, 7347, 7277, 7215, 7167, 7135, 7126, 7141, 7181, 7247, 7340, 7455, 7591, 7741, 7901, 8062, 8217, 8358, 8479, 8570, 8623, 8633, 8596, 8506, 8364, 8166, 7918, 7620, 7279, 6905, 6503, 6086, 5663, 5248, 4851, 4484, 4158, 3883, 3667, 3515, 3433, 3423, 3481, 3606, 3791, 4027, 4305, 4612, 4469, 7241, -4594, -29808, -31943, -32722, -31818, -30407, -28810, -27148, -25476, -23820, -22186, -20591, -19046, -17552, -16126, -14774, -13499, -12308, -11211, -10202, -9284, -8458, -7716, -7059, -6478, -5964, -5512, -5109, -4747, -4416, -4103, -3802, -3505, -3200, -2885, -2554, -2201, -1826, -1432, -1017, -566, -178, -452, -924, -1340, -1740, -2120, -2477, -2813, -3131, -3437, -3735, -4035, -4344, -4672, -5024, -5418, -5858, -6357, -6921, -7562, -8282, -9090, -9988, -10974, -12054, -13227, -14479, -15816, -17228, -18703, -20241, -21826, -23447, -25103, -26773, -28437, -30059, -31530, -32492, -32883, -28381, -6951};