/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0930 256 samples */
 
const int16_t AKWF_0930_256_DATA [256] = 
{907, 4255, 7489, 10650, 13693, 16593, 19320, 21836, 24129, 26176, 27956, 29465, 30692, 31629, 32284, 32659, 32763, 32609, 32211, 31592, 30770, 29768, 28618, 27336, 25956, 24505, 23003, 21483, 19967, 18471, 17023, 15639, 14328, 13109, 11987, 10966, 10055, 9248, 8542, 7936, 7418, 6980, 6612, 6301, 6032, 5795, 5574, 5357, 5134, 4892, 4623, 4323, 3983, 3602, 3180, 2719, 2224, 1703, 1163, 616, 76, -445, -930, -1362, -1728, -2009, -2193, -2261, -2203, -2007, -1664, -1169, -514, 299, 1266, 2387, 3651, 5044, 6557, 8172, 9863, 11618, 13409, 15208, 16998, 18746, 20426, 22019, 23493, 24829, 26008, 27007, 27812, 28413, 28799, 28962, 28902, 28621, 28123, 27416, 26515, 25433, 24187, 22803, 21297, 19695, 18029, 16316, 14586, 12869, 11184, 9554, 8007, 6555, 5217, 4012, 2942, 2018, 1244, 618, 138, -203, -419, -520, -522, -445, -308, -133, 59, 244, 400, 505, 539, 481, 315, 28, -392, -956, -1668, -2529, -3538, -4687, -5972, -7378, -8886, -10485, -12151, -13856, -15587, -17310, -18997, -20632, -22182, -23619, -24928, -26082, -27061, -27853, -28441, -28815, -28969, -28900, -28609, -28098, -27379, -26459, -25353, -24083, -22664, -21118, -19473, -17749, -15973, -14177, -12377, -10603, -8884, -7232, -5674, -4229, -2907, -1724, -692, 188, 909, 1472, 1879, 2137, 2253, 2236, 2100, 1859, 1527, 1121, 657, 149, -383, -929, -1474, -2004, -2511, -2987, -3425, -3824, -4182, -4498, -4780, -5032, -5261, -5480, -5698, -5927, -6181, -6474, -6816, -7223, -7706, -8274, -8937, -9700, -10568, -11544, -12623, -13802, -15077, -16431, -17854, -19333, -20841, -22363, -23877, -25351, -26765, -28092, -29300, -30370, -31272, -31979, -32472, -32731, -32739, -32480, -31944, -31127, -30021, -28632, -26967, -25029, -22839, -20416, -17772, -14944, -11959, -8843, -5640, -2307};