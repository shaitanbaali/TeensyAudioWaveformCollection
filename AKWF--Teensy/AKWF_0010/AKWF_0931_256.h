/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0931 256 samples */
 
const int16_t AKWF_0931_256_DATA [256] = 
{774, 3634, 6407, 9134, 11785, 14342, 16788, 19093, 21253, 23250, 25066, 26700, 28144, 29387, 30433, 31281, 31931, 32391, 32668, 32769, 32704, 32485, 32128, 31641, 31045, 30350, 29570, 28721, 27817, 26870, 25893, 24897, 23888, 22879, 21875, 20879, 19901, 18937, 17990, 17065, 16154, 15257, 14374, 13498, 12626, 11758, 10886, 10007, 9123, 8224, 7315, 6394, 5459, 4513, 3564, 2607, 1655, 713, -214, -1118, -1985, -2812, -3585, -4293, -4928, -5478, -5937, -6294, -6541, -6674, -6686, -6574, -6338, -5975, -5490, -4884, -4163, -3338, -2414, -1403, -320, 826, 2019, 3238, 4476, 5711, 6925, 8108, 9239, 10304, 11292, 12186, 12978, 13659, 14220, 14655, 14964, 15141, 15189, 15112, 14912, 14598, 14176, 13658, 13053, 12374, 11635, 10848, 10026, 9185, 8336, 7492, 6668, 5871, 5111, 4398, 3737, 3134, 2591, 2109, 1688, 1328, 1022, 767, 554, 376, 226, 92, -33, -162, -305, -470, -667, -903, -1188, -1525, -1920, -2376, -2892, -3472, -4109, -4800, -5542, -6326, -7140, -7978, -8827, -9672, -10504, -11309, -12069, -12776, -13415, -13970, -14435, -14796, -15045, -15176, -15181, -15059, -14806, -14424, -13917, -13285, -12540, -11688, -10737, -9705, -8600, -7436, -6235, -5005, -3766, -2538, -1331, -163, 947, 1992, 2954, 3822, 4590, 5244, 5781, 6197, 6487, 6652, 6692, 6610, 6411, 6100, 5684, 5171, 4570, 3893, 3147, 2342, 1491, 601, -316, -1252, -2202, -3158, -4110, -5058, -5998, -6923, -7839, -8742, -9631, -10513, -11388, -12256, -13126, -14000, -14879, -15771, -16676, -17595, -18533, -19490, -20463, -21453, -22452, -23460, -24472, -25472, -26460, -27423, -28345, -29219, -30030, -30762, -31403, -31939, -32352, -32632, -32762, -32733, -32533, -32151, -31583, -30819, -29856, -28698, -27339, -25785, -24046, -22122, -20030, -17787, -15395, -12885, -10273, -7574, -4821, -1970};