/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0960 256 samples */
 
const int16_t AKWF_0960_256_DATA [256] = 
{355, 884, 1403, 1926, 2453, 2984, 3520, 4058, 4602, 5153, 5708, 6272, 6845, 7424, 8014, 8614, 9222, 9842, 10471, 11109, 11759, 12419, 13088, 13768, 14458, 15156, 15854, 16547, 17237, 17922, 18607, 19290, 19970, 20640, 21300, 21950, 22585, 23209, 23817, 24408, 24982, 25537, 26069, 26582, 27070, 27533, 27972, 28386, 28770, 29128, 29459, 29760, 30033, 30276, 30491, 30676, 30832, 30957, 31056, 31125, 31166, 31180, 31166, 31126, 31059, 30968, 30852, 30712, 30550, 30364, 30159, 29933, 29688, 29424, 29144, 28846, 28534, 28207, 27866, 27513, 27149, 26773, 26387, 25994, 25591, 25181, 24766, 24344, 23918, 23488, 23054, 22618, 22179, 21740, 21299, 20858, 20417, 19978, 19535, 19077, 18622, 18155, 17684, 17207, 16723, 16234, 15740, 15238, 14729, 14214, 13690, 13158, 12619, 12070, 11512, 10945, 10367, 9778, 9179, 8567, 7943, 7309, 6660, 6001, 5328, 4643, 3946, 3237, 2514, 1780, 1035, 276, -491, -1271, -2063, -2863, -3674, -4497, -5325, -6163, -7010, -7861, -8722, -9581, -10433, -11288, -12142, -12993, -13841, -14679, -15506, -16326, -17137, -17936, -18725, -19499, -20260, -21009, -21739, -22452, -23151, -23829, -24486, -25125, -25740, -26334, -26906, -27451, -27973, -28470, -28940, -29385, -29804, -30194, -30558, -30895, -31203, -31484, -31736, -31962, -32159, -32328, -32470, -32584, -32671, -32729, -32762, -32767, -32747, -32701, -32629, -32532, -32411, -32264, -32095, -31903, -31688, -31451, -31192, -30914, -30614, -30296, -29958, -29604, -29231, -28843, -28437, -28017, -27581, -27129, -26659, -26175, -25675, -25161, -24635, -24093, -23541, -22976, -22399, -21813, -21219, -20614, -20003, -19384, -18758, -18129, -17496, -16856, -16216, -15573, -14928, -14283, -13638, -12993, -12351, -11710, -11073, -10440, -9810, -9185, -8567, -7954, -7347, -6749, -6158, -5575, -5002, -4437, -3881, -3337, -2801, -2277, -1749, -1223, -693, -155};