/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0923 256 samples */
 
const int16_t AKWF_0923_256_DATA [256] = 
{258, 839, 1453, 2117, 2831, 3603, 4436, 5327, 6280, 7294, 8365, 9494, 10675, 11899, 13167, 14467, 15788, 17127, 18473, 19809, 21135, 22432, 23690, 24903, 26057, 27141, 28151, 29074, 29903, 30636, 31264, 31784, 32196, 32496, 32685, 32765, 32740, 32612, 32387, 32070, 31669, 31190, 30644, 30035, 29375, 28673, 27935, 27168, 26384, 25586, 24782, 23979, 23177, 22384, 21602, 20830, 20071, 19326, 18589, 17862, 17141, 16421, 15701, 14977, 14240, 13491, 12723, 11932, 11116, 10270, 9391, 8482, 7537, 6557, 5548, 4506, 3436, 2346, 1236, 112, -1013, -2142, -3261, -4358, -5435, -6475, -7471, -8419, -9308, -10131, -10884, -11557, -12150, -12658, -13079, -13411, -13656, -13814, -13887, -13882, -13802, -13653, -13442, -13178, -12868, -12522, -12150, -11759, -11361, -10964, -10577, -10208, -9867, -9558, -9289, -9064, -8885, -8758, -8683, -8659, -8686, -8762, -8884, -9047, -9246, -9476, -9729, -9999, -10280, -10562, -10838, -11103, -11349, -11569, -11760, -11913, -12026, -12097, -12123, -12104, -12037, -11927, -11773, -11580, -11351, -11091, -10806, -10502, -10184, -9860, -9538, -9220, -8918, -8634, -8375, -8147, -7953, -7795, -7677, -7601, -7566, -7571, -7615, -7695, -7808, -7948, -8110, -8288, -8477, -8670, -8858, -9036, -9195, -9330, -9434, -9502, -9529, -9510, -9442, -9325, -9156, -8935, -8665, -8346, -7983, -7583, -7146, -6684, -6201, -5705, -5206, -4710, -4227, -3768, -3339, -2946, -2600, -2306, -2070, -1898, -1793, -1757, -1792, -1899, -2077, -2321, -2631, -3001, -3424, -3895, -4407, -4949, -5516, -6097, -6682, -7264, -7832, -8377, -8893, -9370, -9801, -10183, -10508, -10774, -10976, -11112, -11183, -11189, -11132, -11012, -10834, -10604, -10324, -9999, -9637, -9242, -8820, -8379, -7923, -7457, -6989, -6518, -6050, -5591, -5137, -4691, -4256, -3827, -3402, -2982, -2559, -2132, -1695, -1243, -770, -259};