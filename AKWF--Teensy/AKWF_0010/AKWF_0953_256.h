/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0953 256 samples */
 
const int16_t AKWF_0953_256_DATA [256] = 
{756, 2065, 3347, 4629, 5899, 7156, 8394, 9603, 10780, 11920, 13013, 14045, 15027, 15976, 16855, 17654, 18368, 19001, 19571, 20101, 20591, 21029, 21389, 21626, 21800, 21889, 21931, 21912, 21822, 21657, 21422, 21127, 20780, 20379, 19995, 19645, 19328, 19061, 18825, 18641, 18517, 18460, 18476, 18568, 18742, 19017, 19315, 19656, 20003, 20395, 20853, 21363, 21930, 22534, 23137, 23742, 24377, 25027, 25698, 26372, 27033, 27682, 28314, 28920, 29498, 30038, 30539, 30996, 31405, 31763, 32069, 32320, 32517, 32656, 32741, 32768, 32744, 32661, 32478, 32246, 31924, 31551, 31120, 30624, 30081, 29505, 28873, 28179, 27452, 26692, 25907, 25103, 24269, 23403, 22461, 21507, 20534, 19554, 18567, 17550, 16514, 15462, 14397, 13327, 12247, 11157, 10066, 8977, 7908, 6901, 5879, 4867, 3830, 2793, 1784, 802, -139, -1045, -1946, -2842, -3697, -4519, -5303, -6052, -6776, -7472, -8134, -8768, -9375, -9954, -10508, -11038, -11545, -12029, -12491, -12929, -13346, -13743, -14116, -14469, -14798, -15107, -15440, -15750, -16074, -16375, -16664, -16947, -17208, -17433, -17647, -17856, -18030, -18171, -18264, -18304, -18288, -18158, -17988, -17753, -17483, -17172, -16876, -16594, -16343, -16125, -15987, -15902, -15863, -15870, -15913, -16012, -16136, -16288, -16486, -16703, -16928, -17154, -17366, -17564, -17758, -17928, -18084, -18260, -18422, -18594, -18755, -18912, -19069, -19230, -19394, -19562, -19733, -19908, -20086, -20269, -20454, -20645, -20840, -21041, -21249, -21460, -21683, -21924, -22151, -22366, -22597, -22835, -23070, -23297, -23493, -23651, -23786, -23904, -24050, -24197, -24314, -24398, -24431, -24437, -24423, -24384, -24314, -24210, -24069, -23895, -23687, -23448, -23177, -22810, -22414, -21975, -21512, -21024, -20498, -19933, -19306, -18635, -17946, -17220, -16456, -15645, -14776, -13855, -12889, -11864, -10791, -9702, -8569, -7419, -6227, -5009, -3762, -2557, -1034, -252};