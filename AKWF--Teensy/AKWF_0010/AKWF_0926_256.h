/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0926 256 samples */
 
const int16_t AKWF_0926_256_DATA [256] = 
{1120, 5219, 9132, 12878, 16377, 19580, 22450, 24946, 27072, 28825, 30213, 31267, 32014, 32486, 32722, 32754, 32618, 32337, 31942, 31454, 30887, 30257, 29577, 28849, 28082, 27279, 26443, 25576, 24678, 23745, 22781, 21787, 20758, 19703, 18626, 17531, 16430, 15333, 14250, 13198, 12180, 11209, 10294, 9430, 8620, 7861, 7141, 6453, 5787, 5130, 4478, 3827, 3174, 2524, 1886, 1265, 676, 132, -362, -795, -1163, -1470, -1720, -1921, -2084, -2225, -2355, -2485, -2620, -2768, -2929, -3096, -3264, -3423, -3565, -3681, -3767, -3819, -3843, -3843, -3828, -3813, -3809, -3834, -3900, -4017, -4191, -4428, -4726, -5080, -5489, -5942, -6432, -6952, -7496, -8057, -8636, -9232, -9843, -10475, -11126, -11801, -12502, -13228, -13981, -14757, -15551, -16358, -17168, -17964, -18737, -19463, -20115, -20665, -21082, -21327, -21362, -21150, -20658, -19852, -18713, -17234, -15406, -13255, -10807, -8103, -5208, -2186, 896, 3950, 6906, 9701, 12258, 14538, 16506, 18130, 19413, 20357, 20978, 21303, 21368, 21208, 20859, 20360, 19746, 19046, 18292, 17504, 16696, 15886, 15087, 14302, 13540, 12802, 12089, 11404, 10743, 10104, 9484, 8883, 8296, 7726, 7176, 6643, 6140, 5671, 5241, 4863, 4540, 4277, 4076, 3935, 3850, 3810, 3802, 3814, 3831, 3840, 3828, 3788, 3717, 3614, 3483, 3331, 3166, 3000, 2838, 2685, 2544, 2414, 2286, 2152, 1999, 1815, 1588, 1305, 963, 556, 86, -437, -1011, -1620, -2252, -2900, -3553, -4205, -4858, -5512, -6172, -6850, -7556, -8296, -9085, -9926, -10819, -11768, -12767, -13804, -14876, -15968, -17069, -18166, -19252, -20316, -21357, -22366, -23344, -24290, -25203, -26084, -26934, -27749, -28533, -29279, -29980, -30633, -31229, -31751, -32188, -32519, -32720, -32762, -32617, -32249, -31622, -30701, -29458, -27860, -25892, -23553, -20836, -17769, -14389, -10740, -6892, -2825};