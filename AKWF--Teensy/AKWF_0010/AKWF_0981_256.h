/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0981 256 samples */
 
const int16_t AKWF_0981_256_DATA [256] = 
{8737, 21133, 27101, 26509, 21365, 14900, 7888, 1191, -3137, -5448, -6597, -5929, -4461, -2796, -2107, -2517, -2393, -1378, 518, 2523, 3904, 3880, 2962, 1151, -1252, -2631, -2562, -2658, -2860, -2318, -1336, -501, -1572, -3405, -3215, -1367, 1098, 3864, 6135, 7285, 7621, 7320, 4449, -1145, -6523, -10053, -11452, -10728, -8667, -6621, -3951, -551, 2850, 5154, 6322, 7018, 6923, 7102, 7123, 6107, 5074, 4311, 3660, 2944, 2234, 483, -935, -1299, -1955, -2029, -2125, -2248, -2582, -3697, -4905, -5926, -5647, -4152, -3337, -2895, -2579, -2369, -2842, -2862, -1259, 1020, 3287, 5073, 5314, 4266, 2184, -122, -2176, -3589, -3217, -1972, -938, 928, 3807, 6634, 8530, 8674, 6224, 2210, -1521, -4073, -4945, -4767, -4199, -2931, -686, 1098, 1750, 1624, 1017, 330, -473, -1942, -3400, -3578, -3371, -2739, -1280, 766, 3267, 5657, 7120, 7007, 5056, 1697, -1710, -3989, -5285, -6243, -6460, -5261, -2760, -266, 1800, 3171, 3575, 2351, 609, 465, 1319, 2259, 3081, 2996, 2007, 106, -2397, -4348, -4727, -2281, 2491, 6377, 8480, 9136, 7124, 3404, -393, -3679, -6469, -8117, -8391, -7269, -4560, -436, 2818, 2947, 848, -1265, -2742, -2286, -1144, 132, 1506, 1968, 1767, 744, -738, -1703, -2619, -3346, -2919, -1111, 1023, 2407, 3480, 4083, 3843, 4337, 5512, 5737, 5066, 4995, 5234, 4111, 1212, -3751, -8800, -11064, -11314, -10292, -7609, -4200, 62, 3873, 6373, 7981, 8006, 6037, 2330, -2575, -5837, -6811, -6313, -4963, -3354, -1209, -8, -435, -1276, -942, 1103, 4060, 5996, 6478, 4634, 1408, -286, -1368, -1565, -712, -246, -1046, -3236, -4414, -4557, -3731, -2006, 339, 2485, 3927, 5171, 6743, 7026, 5817, 3762, 2412, -3252, -27215, -32766, -26974, -19188, -6062};