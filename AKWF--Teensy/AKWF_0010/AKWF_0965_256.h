/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0965 256 samples */
 
const int16_t AKWF_0965_256_DATA [256] = 
{1333, 3680, 5863, 7935, 9884, 11710, 13414, 14988, 16439, 17769, 18974, 20066, 21046, 21914, 22679, 23343, 23911, 24389, 24781, 25091, 25324, 25485, 25578, 25609, 25579, 25495, 25360, 25177, 24949, 24680, 24376, 24036, 23664, 23264, 22837, 22385, 21912, 21419, 20906, 20379, 19836, 19279, 18712, 18132, 17543, 16947, 16342, 15730, 15114, 14491, 13864, 13234, 12599, 11962, 11338, 10743, 10188, 9686, 9238, 8850, 8524, 8260, 8060, 7922, 7846, 7831, 7873, 7971, 8122, 8325, 8577, 8873, 9212, 9592, 10008, 10459, 10943, 11457, 11997, 12563, 13152, 13761, 14390, 15033, 15695, 16369, 17054, 17752, 18459, 19173, 19896, 20623, 21355, 22095, 22836, 23579, 24327, 25074, 25823, 26574, 27323, 28073, 28825, 29568, 30328, 30936, 30949, 30340, 29233, 27716, 25864, 23752, 21447, 18994, 16445, 13848, 11224, 8612, 6042, 3519, 1074, -1276, -3534, -5681, -7710, -9625, -11414, -13078, -14620, -16037, -17332, -18511, -19569, -20517, -21357, -22090, -22724, -23263, -23710, -24072, -24352, -24555, -24686, -24749, -24749, -24690, -24574, -24409, -24195, -23937, -23640, -23304, -22935, -22534, -22102, -21645, -21165, -20661, -20139, -19598, -19041, -18471, -17886, -17289, -16683, -16066, -15441, -14811, -14173, -13529, -12880, -12230, -11583, -10954, -10345, -9766, -9226, -8722, -8263, -7849, -7482, -7165, -6896, -6675, -6505, -6382, -6305, -6275, -6290, -6347, -6444, -6582, -6758, -6969, -7213, -7490, -7796, -8131, -8494, -8880, -9290, -9723, -10174, -10644, -11132, -11635, -12153, -12686, -13230, -13785, -14351, -14926, -15511, -16102, -16700, -17307, -17917, -18532, -19152, -19777, -20405, -21037, -21671, -22307, -22946, -23587, -24229, -24874, -25519, -26164, -26811, -27458, -28105, -28754, -29403, -30051, -30700, -31346, -31998, -32606, -32759, -32256, -31219, -29744, -27908, -25790, -23460, -20964, -18360, -15694, -12990, -10293, -7611, -5119, -1962, 40};