/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0979 256 samples */
 
const int16_t AKWF_0979_256_DATA [256] = 
{428, 1492, 2466, 3347, 4124, 4807, 5400, 5913, 6335, 6675, 6954, 7173, 7351, 7513, 7665, 7824, 8002, 8206, 8458, 8751, 9073, 9414, 9766, 10129, 10510, 10910, 11328, 11776, 12233, 12678, 13115, 13571, 14047, 14540, 15054, 15610, 16232, 16902, 17588, 18279, 18975, 19667, 20345, 20998, 21616, 22214, 22824, 23447, 24063, 24664, 25248, 25818, 26392, 26961, 27513, 28042, 28549, 29051, 29544, 30024, 30470, 30876, 31247, 31579, 31869, 32120, 32327, 32490, 32619, 32717, 32763, 32766, 32729, 32650, 32529, 32365, 32167, 31940, 31682, 31386, 31032, 30621, 30160, 29645, 29068, 28436, 27754, 26996, 26166, 25256, 24260, 23199, 22083, 20918, 19704, 18438, 17128, 15778, 14391, 12986, 11568, 10114, 8628, 7129, 5625, 4146, 2719, 1333, -10, -1308, -2564, -3758, -4895, -5995, -7059, -8079, -9058, -9989, -10869, -11712, -12510, -13255, -13964, -14642, -15290, -15915, -16527, -17133, -17744, -18355, -18967, -19564, -20129, -20669, -21189, -21689, -22153, -22581, -22970, -23336, -23680, -23998, -24299, -24584, -24844, -25076, -25295, -25525, -25759, -25995, -26221, -26422, -26592, -26725, -26818, -26874, -26917, -26971, -27026, -27060, -27081, -27066, -27006, -26891, -26725, -26503, -26222, -25888, -25508, -25101, -24691, -24282, -23849, -23378, -22880, -22372, -21874, -21384, -20894, -20406, -19906, -19399, -18884, -18354, -17819, -17279, -16728, -16175, -15627, -15090, -14563, -14046, -13549, -13067, -12614, -12204, -11833, -11485, -11167, -10897, -10662, -10441, -10211, -9947, -9668, -9391, -9094, -8791, -8485, -8188, -7919, -7668, -7435, -7222, -7024, -6826, -6612, -6388, -6175, -5977, -5799, -5623, -5448, -5269, -5078, -4868, -4657, -4471, -4317, -4184, -4066, -3949, -3823, -3715, -3631, -3563, -3518, -3488, -3454, -3396, -3320, -3238, -3149, -3061, -2980, -2908, -2838, -2771, -2724, -2695, -2672, -2654, -2641, -2640, -1839, -619};