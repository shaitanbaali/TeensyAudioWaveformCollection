/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0925 256 samples */
 
const int16_t AKWF_0925_256_DATA [256] = 
{1092, 3803, 6637, 9600, 12624, 15650, 18608, 21418, 24022, 26359, 28368, 30020, 31289, 32162, 32650, 32771, 32556, 32049, 31295, 30344, 29243, 28040, 26776, 25479, 24179, 22895, 21631, 20400, 19198, 18020, 16864, 15720, 14583, 13448, 12308, 11161, 10009, 8848, 7682, 6520, 5364, 4224, 3112, 2034, 1001, 28, -883, -1725, -2489, -3180, -3797, -4348, -4841, -5286, -5696, -6081, -6451, -6811, -7167, -7518, -7860, -8185, -8485, -8749, -8968, -9131, -9237, -9281, -9267, -9202, -9096, -8960, -8809, -8654, -8506, -8374, -8259, -8165, -8083, -8010, -7936, -7851, -7749, -7625, -7475, -7302, -7112, -6914, -6720, -6542, -6393, -6284, -6224, -6218, -6268, -6371, -6523, -6714, -6936, -7178, -7429, -7683, -7933, -8175, -8410, -8637, -8857, -9077, -9298, -9523, -9756, -9996, -10240, -10486, -10724, -10944, -11133, -11273, -11345, -11325, -11188, -10909, -10459, -9814, -8955, -7859, -6523, -4945, -3129, -1107, 1094, 3434, 5846, 8278, 10664, 12926, 15009, 16854, 18405, 19633, 20514, 21039, 21219, 21074, 20639, 19955, 19070, 18036, 16898, 15705, 14500, 13309, 12160, 11074, 10054, 9108, 8234, 7426, 6678, 5979, 5320, 4695, 4097, 3516, 2953, 2404, 1869, 1349, 849, 371, -74, -483, -849, -1163, -1422, -1621, -1760, -1843, -1874, -1861, -1819, -1757, -1692, -1635, -1598, -1590, -1617, -1679, -1773, -1894, -2033, -2180, -2324, -2458, -2577, -2679, -2764, -2839, -2915, -2997, -3103, -3240, -3417, -3640, -3911, -4224, -4578, -4958, -5354, -5755, -6150, -6530, -6890, -7230, -7550, -7857, -8160, -8467, -8790, -9136, -9509, -9915, -10351, -10811, -11291, -11775, -12254, -12718, -13152, -13549, -13903, -14206, -14458, -14658, -14809, -14916, -14982, -15009, -15000, -14957, -14879, -14763, -14604, -14391, -14114, -13756, -13302, -12729, -12017, -11142, -10078, -8806, -7308, -5569, -3589, -1308};