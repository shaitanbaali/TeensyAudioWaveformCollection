/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1000 256 samples */
 
const int16_t AKWF_1000_256_DATA [256] = 
{15831, 16705, 17561, 18418, 19256, 20195, 20529, 19782, 19080, 18373, 17662, 16813, 16935, 3557, -925, 66, -114, -116, -118, -245, 433, -5457, -9252, -9374, -10310, -10300, -9420, -9491, -4976, 499, -287, -140, -139, -140, -138, -136, -137, -136, -136, -136, -136, -137, -136, -135, -134, -135, -134, -134, -134, -134, -134, -134, -134, -134, -134, -134, -135, -132, -131, -132, -131, -131, -131, -131, -131, -131, -131, -131, -131, -131, -131, -131, -131, -131, -131, -132, -130, -128, -129, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -129, -127, -126, -127, -126, -126, -126, -126, -126, -126, -126, -126, -126, -126, -126, -126, -126, -126, -126, -127, -125, -123, -124, -123, -123, -123, -123, -123, -123, -123, -123, -123, -123, -123, -123, -123, -123, -124, -123, -121, -120, -121, -120, -120, -120, -120, -120, -120, -120, -120, -120, -120, -120, -120, -120, -121, -119, -118, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -116, -115, -116, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -116, -114, -113, -114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -114, -113, -114, -115, -116, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -527, 1666, -16940, -32401, -31371, -28720, -29114, -11609, 1879, -555, -94, -93, -90};