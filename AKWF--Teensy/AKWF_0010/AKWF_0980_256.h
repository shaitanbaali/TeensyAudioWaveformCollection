/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0980 256 samples */
 
const int16_t AKWF_0980_256_DATA [256] = 
{1111, 2911, 4651, 6357, 8010, 9604, 11131, 12574, 13930, 15193, 16352, 17411, 18371, 19231, 20000, 20678, 21274, 21797, 22247, 22624, 22929, 23158, 23308, 23374, 23356, 23258, 23078, 22854, 22629, 22409, 22198, 22001, 21809, 21620, 21426, 21227, 21015, 20784, 20524, 20224, 19874, 19454, 18953, 18362, 17674, 16886, 15998, 15011, 13934, 12759, 11491, 10135, 8690, 7167, 5582, 3940, 2254, 542, -1182, -2899, -4582, -6217, -7772, -9232, -10581, -11791, -12849, -13739, -14448, -14965, -15303, -15582, -15858, -16124, -16380, -16623, -16845, -17041, -17206, -17336, -17431, -17485, -17499, -17474, -17408, -17300, -17153, -16965, -16738, -16476, -16186, -15874, -15540, -15188, -14817, -14427, -14018, -13596, -13161, -12722, -12287, -11852, -11411, -10961, -10500, -10026, -9536, -9029, -8504, -7963, -7406, -6830, -6231, -5599, -4927, -4205, -3418, -2558, -1625, -624, 439, 1558, 2734, 3957, 5218, 6509, 7814, 9119, 10419, 11696, 12938, 14128, 15249, 16294, 17257, 18126, 18899, 19573, 20139, 20599, 20958, 21210, 21363, 21418, 21384, 21267, 21072, 20826, 20554, 20259, 19947, 19618, 19274, 18918, 18554, 18185, 17809, 17430, 17042, 16639, 16216, 15766, 15283, 14763, 14199, 13587, 12912, 12172, 11356, 10453, 9457, 8358, 7157, 5856, 4458, 2975, 1420, -210, -1904, -3649, -5443, -7265, -9097, -10935, -12759, -14557, -16322, -18032, -19675, -21242, -22714, -24082, -25340, -26471, -27468, -28327, -29034, -29582, -29979, -30326, -30670, -31002, -31316, -31608, -31873, -32106, -32307, -32473, -32601, -32693, -32748, -32768, -32753, -32701, -32614, -32491, -32333, -32145, -31926, -31685, -31421, -31128, -30811, -30465, -30093, -29703, -29296, -28877, -28456, -28028, -27585, -27124, -26633, -26107, -25542, -24933, -24279, -23583, -22844, -22060, -21234, -20357, -19425, -18427, -17348, -16186, -14938, -13605, -12197, -10715, -9158, -7541, -5868, -4153, -2413, -617};