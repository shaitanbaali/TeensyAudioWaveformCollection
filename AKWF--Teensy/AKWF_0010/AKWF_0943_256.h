/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0943 256 samples */
 
const int16_t AKWF_0943_256_DATA [256] = 
{774, 3335, 5840, 8298, 10642, 12824, 14798, 16520, 17981, 19175, 20122, 20874, 21487, 22027, 22543, 23060, 23577, 24080, 24561, 24998, 25378, 25687, 25914, 26054, 26120, 26125, 26090, 26033, 25967, 25893, 25811, 25724, 25626, 25521, 25406, 25279, 25141, 24990, 24826, 24648, 24451, 24238, 24006, 23753, 23478, 23179, 22855, 22505, 22126, 21718, 21278, 20808, 20305, 19774, 19212, 18625, 18017, 17395, 16766, 16142, 15538, 14962, 14433, 13962, 13551, 13199, 12890, 12605, 12325, 12027, 11701, 11346, 10952, 10516, 10036, 9507, 8927, 8293, 7603, 6859, 6066, 5224, 4337, 3416, 2490, 1457, 599, 9582, 13601, 16096, 19186, 21380, 22880, 23915, 24637, 25151, 25524, 25796, 26004, 26127, 25974, 25360, 24367, 23218, 22076, 20828, 18993, 16152, 12309, 7776, 2951, -1789, -6193, -10166, -13660, -16683, -19288, -21512, -23406, -25022, -26397, -27563, -28562, -29411, -30136, -30759, -31290, -31745, -32138, -32468, -32702, -32766, -32591, -32161, -31522, -30744, -29894, -29025, -28180, -27378, -26635, -25955, -25342, -24790, -24300, -23863, -23475, -23131, -22815, -22488, -22102, -21611, -21003, -20297, -19521, -18713, -17903, -17110, -16327, -15521, -14639, -13654, -12567, -11399, -10187, -8969, -7775, -6630, -5529, -4450, -3365, -2263, -995, -530, -1685, -2825, -3899, -4949, -5998, -7069, -8182, -9322, -10467, -11594, -12669, -13664, -14567, -15378, -16116, -16819, -17517, -18223, -18937, -19638, -20304, -20917, -21454, -21904, -22272, -22571, -22837, -23098, -23372, -23673, -24002, -24360, -24753, -25179, -25638, -26137, -26670, -27235, -27833, -28457, -29097, -29744, -30381, -30987, -31543, -32020, -32391, -32641, -32759, -32753, -32649, -32475, -32258, -32010, -31738, -31441, -31112, -30751, -30356, -29922, -29447, -28924, -28349, -27721, -27032, -26278, -25451, -24548, -23560, -22484, -21307, -20026, -18638, -17129, -15498, -13744, -11856, -9839, -7677, -5568, -2465, -1027};