/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0984 256 samples */
 
const int16_t AKWF_0984_256_DATA [256] = 
{742, 1773, 2695, 2884, 4122, 5199, 6240, 7024, 7594, 8216, 8380, 8886, 9515, 10203, 10782, 11115, 11243, 11343, 11691, 11938, 12415, 13174, 14027, 14763, 15500, 15981, 16717, 17220, 18108, 18900, 19808, 20089, 20346, 20983, 22032, 23318, 24265, 25142, 25866, 26609, 27402, 27780, 28386, 29105, 29941, 30599, 31059, 31431, 31886, 32420, 32540, 32727, 32640, 32517, 32164, 31611, 31276, 30770, 30668, 30701, 30056, 29238, 28224, 27099, 26285, 25364, 24301, 23794, 23010, 21487, 20985, 19930, 19506, 19203, 18334, 17567, 17246, 16725, 16182, 15751, 14656, 14144, 13125, 12035, 11097, 10362, 9965, 9944, 9609, 8986, 8522, 7637, 7185, 6833, 6559, 5148, 3995, 2729, 1218, -222, -1663, -2842, -3645, -4511, -5175, -5626, -6245, -6908, -7400, -7884, -8278, -8680, -9550, -10132, -10837, -11657, -12048, -12727, -12976, -13422, -13905, -14239, -14020, -13758, -13664, -13494, -13609, -13553, -13800, -14259, -14257, -14292, -14009, -13849, -13686, -13270, -12831, -12231, -11226, -10557, -9978, -9430, -8730, -7752, -7045, -6445, -5889, -5258, -5003, -4556, -4193, -3875, -3475, -3086, -2885, -2256, -1819, -1593, -829, -345, -279, 380, 206, -188, -1273, -2827, -3644, -3971, -4294, -4601, -5067, -5296, -4848, -5105, -5622, -5322, -5525, -5537, -6061, -6811, -7359, -7894, -8204, -8360, -8709, -8801, -9079, -8995, -8954, -8369, -8163, -8040, -8304, -9004, -9369, -9935, -10276, -10774, -11127, -11719, -12196, -12010, -12350, -12437, -12769, -13092, -13083, -13207, -13519, -14033, -14214, -14475, -14894, -15380, -16264, -16615, -17300, -18098, -19057, -20029, -20754, -21625, -22275, -22774, -23352, -23702, -24219, -24564, -25412, -26064, -26378, -26492, -26596, -27360, -26479, -26159, -25147, -24359, -23343, -21787, -20396, -18907, -18272, -17544, -17055, -16330, -14534, -13317, -11903, -10980, -9877, -8348, -6272, -4506, -2579, -1366};