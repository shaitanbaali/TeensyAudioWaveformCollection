/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0936 256 samples */
 
const int16_t AKWF_0936_256_DATA [256] = 
{885, 4100, 7081, 9791, 12149, 14131, 15751, 17056, 18143, 19113, 20065, 21096, 22264, 23585, 25049, 26599, 28146, 29600, 30857, 31833, 32473, 32751, 32688, 32328, 31752, 31046, 30302, 29598, 28984, 28476, 28064, 27701, 27319, 26845, 26208, 25351, 24252, 22913, 21376, 19714, 18012, 16363, 14860, 13560, 12499, 11676, 11045, 10535, 10059, 9513, 8813, 7897, 6728, 5325, 3740, 2052, 378, -1169, -2484, -3482, -4115, -4384, -4327, -4024, -3581, -3121, -2757, -2580, -2653, -2992, -3574, -4328, -5164, -5972, -6639, -7078, -7227, -7063, -6606, -5915, -5076, -4192, -3365, -2693, -2229, -2006, -2015, -2211, -2523, -2867, -3161, -3330, -3332, -3152, -2811, -2360, -1868, -1422, -1096, -950, -1017, -1296, -1751, -2318, -2915, -3450, -3841, -4027, -3975, -3693, -3223, -2637, -2026, -1488, -1111, -958, -1057, -1397, -1927, -2563, -3196, -3713, -4014, -4017, -3680, -3006, -2045, -883, 369, 1583, 2640, 3440, 3918, 4054, 3869, 3430, 2832, 2183, 1599, 1172, 969, 1020, 1311, 1792, 2383, 2991, 3518, 3883, 4032, 3942, 3629, 3145, 2562, 1972, 1461, 1103, 948, 1009, 1267, 1672, 2154, 2631, 3024, 3274, 3347, 3241, 2991, 2658, 2321, 2066, 1973, 2098, 2465, 3058, 3831, 4704, 5574, 6340, 6903, 7194, 7174, 6850, 6268, 5505, 4668, 3869, 3206, 2762, 2580, 2659, 2956, 3390, 3856, 4230, 4401, 4275, 3796, 2946, 1753, 293, -1343, -3040, -4676, -6163, -7433, -8450, -9234, -9835, -10327, -10812, -11383, -12120, -13081, -14284, -15709, -17310, -19001, -20689, -22288, -23715, -24915, -25872, -26595, -27129, -27539, -27902, -28288, -28756, -29327, -30001, -30739, -31472, -32114, -32575, -32770, -32638, -32148, -31307, -30157, -28773, -27255, -25694, -24187, -22806, -21576, -20496, -19522, -18572, -17548, -16347, -14866, -13040, -10837, -8265, -5388, -2227};