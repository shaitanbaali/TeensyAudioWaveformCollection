/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0905 256 samples */
 
const int16_t AKWF_0905_256_DATA [256] = 
{10067, 30856, 32637, 29911, 26613, 24207, 22838, 21746, 20335, 18392, 15867, 12781, 9271, 5559, 1717, -2106, -5554, -8134, -9878, -11064, -11876, -12444, -12851, -13156, -13398, -13598, -13776, -13940, -14097, -14252, -14404, -14556, -14706, -14858, -15009, -15160, -15309, -15457, -15604, -15749, -15890, -16031, -16168, -16303, -16434, -16563, -16690, -16813, -16934, -17052, -17168, -17279, -17390, -17497, -17601, -17702, -17800, -17896, -17991, -18082, -18170, -18255, -18338, -18418, -18495, -18570, -18641, -18710, -18775, -18839, -18897, -18953, -19005, -19054, -19098, -19138, -19175, -19207, -19234, -19257, -19274, -19286, -19290, -19289, -19279, -19263, -19240, -19206, -19162, -19109, -19043, -18965, -18873, -18764, -18640, -18496, -18330, -18140, -17922, -17674, -17390, -17067, -16697, -16274, -15788, -15228, -14584, -13836, -12965, -11946, -10742, -9310, -7598, -5518, -2943, 384, 4404, 8255, 11357, 13755, 15528, 16785, 17641, 18174, 18441, 18373, 18163, 15761, -9619, -30993, -32576, -29904, -26604, -24197, -22830, -21737, -20326, -18382, -15855, -12767, -9253, -5538, -1691, 2133, 5578, 8154, 9894, 11076, 11888, 12453, 12859, 13164, 13404, 13605, 13782, 13946, 14104, 14258, 14410, 14561, 14712, 14864, 15015, 15165, 15314, 15463, 15611, 15754, 15897, 16036, 16173, 16308, 16440, 16569, 16696, 16819, 16939, 17058, 17173, 17284, 17395, 17502, 17605, 17708, 17806, 17903, 17995, 18087, 18175, 18260, 18343, 18422, 18500, 18575, 18647, 18715, 18781, 18843, 18903, 18958, 19010, 19059, 19103, 19144, 19180, 19213, 19239, 19262, 19278, 19290, 19295, 19294, 19285, 19269, 19245, 19211, 19169, 19114, 19049, 18971, 18879, 18771, 18646, 18502, 18336, 18146, 17929, 17680, 17397, 17074, 16705, 16282, 15797, 15237, 14594, 13847, 12977, 11958, 10756, 9325, 7615, 5540, 2968, -357, -4379, -8237, -11344, -13746, -15521, -16781, -17637, -18171, -18437, -18424, -18297, -15071};