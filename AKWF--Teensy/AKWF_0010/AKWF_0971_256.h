/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0971 256 samples */
 
const int16_t AKWF_0971_256_DATA [256] = 
{613, 2033, 3416, 4789, 6147, 7488, 8809, 10101, 11367, 12602, 13798, 14956, 16074, 17141, 18162, 19129, 20038, 20892, 21683, 22411, 23075, 23671, 24196, 24651, 25037, 25352, 25599, 25773, 25875, 25908, 25868, 25758, 25579, 25331, 25016, 24638, 24199, 23701, 23148, 22545, 21895, 21203, 20476, 19722, 18943, 18147, 17337, 16522, 15710, 14904, 14114, 13349, 12612, 11913, 11257, 10651, 10101, 9612, 9187, 8831, 8549, 8342, 8210, 8158, 8184, 8288, 8469, 8726, 9057, 9459, 9931, 10465, 11061, 11716, 12422, 13177, 13977, 14814, 15686, 16587, 17507, 18446, 19395, 20347, 21299, 22244, 23171, 24082, 24967, 25818, 26636, 27413, 28143, 28824, 29452, 30023, 30533, 30977, 31359, 31676, 31924, 32104, 32214, 32253, 32221, 32117, 31941, 31691, 31368, 30977, 30517, 29990, 29399, 28743, 28026, 27251, 26416, 25526, 24585, 23592, 22550, 21466, 20335, 19165, 17959, 16716, 15444, 14144, 12815, 11468, 10100, 8714, 7316, 5906, 4487, 3067, 1641, 213, -1208, -2628, -4042, -5442, -6830, -8202, -9550, -10879, -12178, -13443, -14675, -15866, -17012, -18113, -19161, -20153, -21090, -21963, -22772, -23517, -24192, -24798, -25334, -25797, -26191, -26515, -26767, -26952, -27071, -27125, -27119, -27056, -26938, -26773, -26565, -26320, -26041, -25737, -25414, -25077, -24734, -24392, -24055, -23731, -23425, -23142, -22887, -22668, -22485, -22344, -22247, -22197, -22196, -22245, -22346, -22498, -22701, -22955, -23257, -23604, -23995, -24423, -24886, -25379, -25895, -26431, -26979, -27531, -28086, -28633, -29167, -29684, -30177, -30639, -31069, -31458, -31800, -32096, -32342, -32534, -32671, -32749, -32766, -32721, -32613, -32440, -32199, -31891, -31517, -31079, -30580, -30017, -29394, -28711, -27970, -27173, -26323, -25418, -24463, -23462, -22411, -21318, -20185, -19012, -17802, -16562, -15290, -13990, -12669, -11323, -9961, -8585, -7194, -5796, -4390, -3007, -1488, -98};