/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0934 256 samples */
 
const int16_t AKWF_0934_256_DATA [256] = 
{873, 4002, 6855, 9516, 11981, 14261, 16363, 18286, 20047, 21655, 23113, 24438, 25635, 26708, 27673, 28534, 29295, 29967, 30554, 31060, 31494, 31857, 32155, 32390, 32567, 32686, 32752, 32767, 32732, 32649, 32520, 32344, 32125, 31862, 31557, 31208, 30820, 30390, 29919, 29410, 28860, 28271, 27647, 26983, 26284, 25551, 24782, 23982, 23155, 22296, 21413, 20509, 19583, 18643, 17692, 16731, 15768, 14808, 13853, 12910, 11987, 11085, 10212, 9376, 8577, 7825, 7120, 6470, 5878, 5345, 4874, 4469, 4127, 3849, 3636, 3483, 3391, 3354, 3370, 3434, 3542, 3689, 3867, 4072, 4300, 4543, 4798, 5057, 5317, 5574, 5820, 6055, 6273, 6471, 6648, 6800, 6926, 7024, 7093, 7132, 7141, 7120, 7071, 6992, 6885, 6751, 6591, 6408, 6202, 5976, 5732, 5470, 5194, 4904, 4604, 4294, 3976, 3653, 3323, 2990, 2654, 2316, 1975, 1632, 1291, 944, 599, 251, -99, -447, -794, -1139, -1483, -1826, -2167, -2506, -2843, -3179, -3509, -3837, -4158, -4470, -4776, -5071, -5352, -5622, -5875, -6108, -6324, -6517, -6687, -6832, -6952, -7043, -7106, -7138, -7142, -7115, -7059, -6973, -6860, -6719, -6554, -6363, -6153, -5926, -5683, -5432, -5173, -4912, -4655, -4406, -4171, -3955, -3764, -3604, -3480, -3397, -3360, -3372, -3440, -3567, -3753, -4003, -4318, -4696, -5139, -5646, -6213, -6839, -7520, -8253, -9033, -9854, -10711, -11602, -12516, -13451, -14402, -15360, -16323, -17285, -18241, -19187, -20119, -21032, -21925, -22794, -23634, -24447, -25228, -25976, -26691, -27370, -28011, -28615, -29181, -29708, -30196, -30642, -31049, -31414, -31738, -32019, -32257, -32451, -32600, -32703, -32758, -32766, -32721, -32625, -32472, -32263, -31992, -31657, -31254, -30780, -30227, -29591, -28869, -28051, -27132, -26107, -24963, -23693, -22293, -20749, -19054, -17202, -15175, -12974, -10590, -8012, -5245, -2206};