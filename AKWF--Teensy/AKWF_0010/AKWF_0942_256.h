/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0942 256 samples */
 
const int16_t AKWF_0942_256_DATA [256] = 
{654, 3082, 5441, 7776, 10063, 12291, 14451, 16522, 18500, 20377, 22134, 23774, 25286, 26661, 27902, 29003, 29957, 30772, 31446, 31976, 32369, 32628, 32754, 32755, 32634, 32399, 32053, 31604, 31059, 30420, 29697, 28897, 28021, 27078, 26073, 25008, 23893, 22726, 21513, 20261, 18969, 17641, 16284, 14897, 13484, 12052, 10597, 9129, 7653, 6166, 4677, 3197, 1720, 259, -1177, -2591, -3967, -5299, -6584, -7810, -8969, -10056, -11061, -11976, -12797, -13513, -14122, -14616, -14991, -15245, -15374, -15377, -15253, -15003, -14629, -14135, -13525, -12805, -11979, -11057, -10051, -8963, -7809, -6601, -5345, -4057, -2750, -1431, -118, 1178, 2451, 3685, 4869, 6000, 7062, 8048, 8958, 9779, 10510, 11148, 11688, 12131, 12477, 12725, 12877, 12939, 12911, 12798, 12605, 12338, 12000, 11597, 11138, 10624, 10063, 9463, 8825, 8156, 7461, 6742, 6005, 5256, 4490, 3717, 2937, 2149, 1359, 567, -227, -1019, -1810, -2600, -3383, -4160, -4930, -5686, -6430, -7157, -7862, -8543, -9194, -9812, -10391, -10925, -11407, -11836, -12202, -12501, -12727, -12874, -12939, -12917, -12803, -12596, -12291, -11890, -11391, -10794, -10103, -9321, -8449, -7494, -6463, -5359, -4199, -2984, -1725, -439, 869, 2187, 3499, 4797, 6070, 7298, 8477, 9594, 10635, 11595, 12462, 13227, 13887, 14431, 14856, 15158, 15336, 15388, 15312, 15112, 14787, 14343, 13783, 13112, 12334, 11459, 10493, 9438, 8310, 7112, 5850, 4539, 3179, 1781, 355, -1097, -2569, -4047, -5534, -7022, -8501, -9975, -11435, -12875, -14299, -15697, -17066, -18408, -19715, -20983, -22214, -23401, -24538, -25626, -26657, -27626, -28533, -29365, -30123, -30798, -31383, -31874, -32265, -32549, -32718, -32769, -32697, -32496, -32160, -31690, -31077, -30322, -29427, -28388, -27207, -25890, -24433, -22848, -21141, -19313, -17377, -15346, -13220, -11020, -8758, -6442, -4094, -1672};