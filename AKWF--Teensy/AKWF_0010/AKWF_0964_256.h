/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0964 256 samples */
 
const int16_t AKWF_0964_256_DATA [256] = 
{282, 1229, 2134, 3014, 3869, 4699, 5502, 6275, 7020, 7736, 8421, 9076, 9702, 10296, 10860, 11391, 11891, 12362, 12800, 13207, 13585, 13936, 14266, 14579, 14875, 15154, 15419, 15667, 15901, 16121, 16330, 16529, 16719, 16899, 17073, 17244, 17411, 17575, 17740, 17905, 18073, 18245, 18421, 18604, 18794, 18993, 19201, 19418, 19646, 19889, 20144, 20410, 20693, 20989, 21299, 21628, 21971, 22330, 22708, 23101, 23512, 23940, 24386, 24849, 25331, 25829, 26345, 26881, 27433, 28001, 28588, 29166, 29684, 30084, 30331, 30450, 30499, 30530, 30561, 30575, 30546, 30463, 30331, 30162, 29961, 29717, 29420, 29060, 28641, 28169, 27650, 27087, 26475, 25812, 25102, 24349, 23556, 22730, 21871, 20978, 20057, 19110, 18138, 17152, 16148, 15130, 14104, 13067, 12026, 10985, 9943, 8904, 7874, 6848, 5831, 4830, 3840, 2865, 1911, 973, 56, -838, -1710, -2560, -3382, -4179, -4949, -5691, -6405, -7090, -7746, -8373, -8968, -9532, -10067, -10570, -11042, -11483, -11894, -12277, -12635, -12967, -13279, -13571, -13840, -14089, -14321, -14533, -14731, -14912, -15079, -15234, -15375, -15507, -15630, -15743, -15852, -15955, -16054, -16150, -16245, -16341, -16437, -16535, -16637, -16744, -16856, -16974, -17098, -17231, -17373, -17525, -17686, -17859, -18042, -18239, -18448, -18669, -18904, -19153, -19415, -19693, -19984, -20292, -20614, -20950, -21304, -21673, -22056, -22455, -22870, -23301, -23748, -24208, -24686, -25180, -25688, -26212, -26751, -27305, -27873, -28458, -29055, -29669, -30297, -30925, -31510, -31994, -32327, -32517, -32611, -32668, -32720, -32761, -32762, -32709, -32600, -32447, -32259, -32031, -31749, -31405, -30995, -30529, -30011, -29445, -28829, -28162, -27442, -26677, -25868, -25023, -24141, -23223, -22275, -21295, -20290, -19266, -18223, -17164, -16093, -15009, -13919, -12827, -11731, -10638, -9549, -8464, -7387, -6323, -5268, -4228, -3197, -2264, -929, -76};