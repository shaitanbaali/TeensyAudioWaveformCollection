/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0906 256 samples */
 
const int16_t AKWF_0906_256_DATA [256] = 
{5047, 12874, 13461, 12422, 11546, 11208, 11167, 11148, 11038, 10837, 10591, 10350, 10153, 10015, 9932, 9892, 9883, 9893, 9920, 9960, 10011, 10069, 10133, 10202, 10275, 10349, 10425, 10504, 10609, 10583, 11136, 14530, 16231, 16266, 15998, 15861, 15910, 16039, 16160, 16234, 16265, 16273, 16279, 16297, 16331, 16382, 16444, 16514, 16589, 16670, 16753, 16838, 16924, 17012, 17103, 17193, 17284, 17376, 17466, 17558, 17649, 17741, 17833, 17923, 18015, 18106, 18197, 18287, 18377, 18466, 18555, 18644, 18733, 18821, 18909, 18997, 19084, 19172, 19259, 19345, 19431, 19516, 19603, 19687, 19773, 19857, 19941, 20026, 20110, 20192, 20276, 20359, 20441, 20523, 20605, 20687, 20769, 20849, 20929, 21011, 21091, 21170, 21209, 21018, 22777, -732, -29395, -32854, -31324, -29143, -27485, -26289, -25245, -24231, -23264, -22390, -21643, -21046, -20595, -20269, -20046, -19897, -19807, -19757, -19740, -19749, -19779, -19823, -19882, -19949, -20025, -20104, -20188, -20275, -20363, -20454, -20546, -20638, -20731, -20825, -20919, -21012, -21106, -21199, -21292, -21385, -21477, -21569, -21662, -21754, -21846, -21937, -22028, -22118, -22208, -22298, -22388, -22477, -22566, -22655, -22743, -22832, -22919, -23006, -23094, -23180, -23266, -23353, -23438, -23524, -23609, -23693, -23765, -23920, -23124, -21870, -21801, -22206, -22505, -22615, -22612, -22587, -22596, -22659, -22762, -22881, -23002, -23114, -23213, -23304, -23389, -23473, -23552, -23631, -23706, -23781, -23856, -23928, -24000, -24072, -24142, -24212, -24281, -24350, -24419, -24486, -24521, -24754, -23453, -20455, -19718, -20345, -20844, -20942, -20776, -20555, -20423, -20425, -20535, -20700, -20869, -21015, -21135, -21230, -21313, -21387, -21414, -21591, -21188, -12791, -5155, -5478, -7478, -8109, -7390, -6043, -4837, -4206, -4161, -4496, -4964, -5406, -5752, -5980, -6125, -6227, -6308, -6371, -6419, -6459, -6488, -6498, -6504, -6505, -6499, -6488};