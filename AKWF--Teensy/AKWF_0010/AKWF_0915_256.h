/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0915 256 samples */
 
const int16_t AKWF_0915_256_DATA [256] = 
{568, 1427, 2220, 2968, 3663, 4306, 4897, 5432, 5916, 6346, 6724, 7053, 7338, 7557, 7826, 8353, 8621, 8807, 9014, 9216, 9398, 9557, 9692, 9801, 9881, 9935, 9961, 9963, 9947, 9911, 9859, 9792, 9710, 9614, 9508, 9390, 9253, 9146, 9232, 9239, 9200, 9192, 9209, 9243, 9291, 9351, 9422, 9504, 9592, 9691, 9800, 9921, 10051, 10289, 10561, 10806, 11082, 11392, 11733, 12101, 12492, 12910, 13349, 13808, 14287, 14784, 15298, 15831, 16379, 16943, 17523, 18115, 18721, 19340, 19967, 20605, 21251, 21902, 22560, 23222, 23886, 24552, 25219, 25882, 26545, 27205, 27857, 28507, 29148, 29777, 30409, 30997, 30814, 30695, 30817, 30796, 30658, 30438, 30160, 29833, 29511, 29038, 27821, 26831, 25957, 24934, 23801, 22580, 21291, 19952, 18570, 17174, 16044, 14882, 13596, 12355, 11147, 9967, 8811, 7673, 6557, 5464, 4388, 3337, 2316, 1325, 374, -534, -1400, -2217, -2984, -3702, -4366, -4978, -5539, -6047, -6505, -6913, -7273, -7586, -7856, -8082, -8266, -8413, -8523, -8597, -8639, -8651, -8635, -8592, -8525, -8435, -8325, -8196, -8051, -7891, -7718, -7533, -7337, -7133, -6923, -6707, -6486, -6265, -6031, -5849, -5936, -5934, -5889, -5904, -5964, -6063, -6198, -6365, -6562, -6786, -7036, -7311, -7610, -7936, -8288, -8669, -9076, -9510, -9971, -10457, -10968, -11502, -12059, -12637, -13233, -13847, -14479, -15124, -15782, -16454, -17134, -17823, -18520, -19222, -19928, -20639, -21349, -22063, -22775, -23483, -24191, -24895, -25593, -26287, -26974, -27652, -28324, -28987, -29638, -30281, -30913, -31529, -32144, -32712, -32510, -32366, -32463, -32415, -32248, -31999, -31690, -31332, -30978, -30472, -29222, -28199, -27293, -26238, -25072, -23820, -22499, -21130, -19718, -18293, -17145, -15965, -14660, -13399, -12175, -10980, -9810, -8660, -7531, -6426, -5338, -4277, -3244, -2244, -1282, -310};