/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0945 256 samples */
 
const int16_t AKWF_0945_256_DATA [256] = 
{1268, 4275, 7135, 9889, 12493, 14928, 17181, 19228, 21074, 22718, 24156, 25404, 26465, 27356, 28093, 28687, 29158, 29524, 29801, 30009, 30164, 30278, 30369, 30453, 30535, 30626, 30731, 30853, 30996, 31160, 31341, 31538, 31749, 31957, 32161, 32352, 32520, 32652, 32739, 32768, 32735, 32623, 32426, 32133, 31730, 31212, 30569, 29792, 28877, 27811, 26591, 25219, 23678, 21971, 20110, 18080, 15899, 13581, 11124, 8558, 6234, 1716, 7123, 31459, 32733, 31902, 31034, 30545, 30217, 29516, 27898, 24993, 20619, 14833, 7966, 505, -6890, -13561, -19042, -23047, -25512, -26561, -26375, -25152, -23077, -20352, -17187, -13796, -10416, -7272, -4511, -2259, -563, 587, 1230, 1434, 1279, 840, 201, -561, -1391, -2236, -3058, -3825, -4529, -5165, -5733, -6244, -6699, -7107, -7476, -7811, -8118, -8411, -8707, -9037, -9434, -9926, -10548, -11330, -12290, -13440, -14780, -16293, -17945, -19705, -21514, -23317, -25066, -26685, -28123, -29335, -30272, -30909, -31219, -31187, -30811, -30079, -28997, -27566, -25791, -23692, -21273, -18567, -15618, -12446, -9121, -5722, -2070, -2550, -6291, -9605, -12843, -15896, -18734, -21314, -23611, -25618, -27320, -28711, -29796, -30576, -31056, -31243, -31151, -30790, -30175, -29336, -28289, -27072, -25723, -24269, -22754, -21228, -19709, -18237, -16846, -15548, -14366, -13314, -12387, -11592, -10919, -10354, -9887, -9503, -9179, -8905, -8663, -8440, -8222, -8001, -7771, -7527, -7267, -6987, -6690, -6373, -6029, -5662, -5267, -4845, -4394, -3914, -3409, -2883, -2336, -1781, -1229, -692, -183, 284, 695, 1033, 1279, 1412, 1421, 1296, 1014, 569, -44, -843, -1820, -2971, -4291, -5760, -7360, -9068, -10846, -12674, -14511, -16311, -18054, -19705, -21228, -22605, -23813, -24824, -25627, -26206, -26539, -26621, -26436, -25971, -25218, -24167, -22823, -21183, -19264, -17087, -14671, -12056, -9254, -6514, -2770, -971};