/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0903 256 samples */
 
const int16_t AKWF_0903_256_DATA [256] = 
{776, 2061, 3329, 4590, 5826, 7023, 8171, 9252, 10264, 11198, 12049, 12819, 13508, 14118, 14655, 15126, 15537, 15900, 16223, 16514, 16787, 17049, 17307, 17572, 17851, 18149, 18471, 18821, 19200, 19611, 20052, 20520, 21017, 21536, 22073, 22623, 23182, 23743, 24302, 24851, 25388, 25906, 26399, 26866, 27303, 27706, 28075, 28408, 28705, 28968, 29195, 29390, 29555, 29693, 29805, 29896, 29970, 30029, 30079, 30122, 30158, 30196, 30235, 30277, 30325, 30381, 30445, 30518, 30600, 30691, 30790, 30898, 31012, 31131, 31254, 31379, 31505, 31630, 31753, 31872, 31985, 32093, 32192, 32283, 32365, 32438, 32501, 32555, 32599, 32635, 32663, 32682, 32695, 32703, 32706, 32705, 32702, 32696, 32691, 32685, 32680, 32676, 32675, 32677, 32682, 32689, 32699, 32714, 32635, 33217, 30254, 24945, 27993, 23727, 20926, 19552, 18092, 16444, 14794, 13277, 11955, 10818, 9819, 8910, 8040, 7165, 6259, 5300, 4275, 3185, 2032, 823, -424, -1698, -2985, -4261, -5517, -6737, -7901, -9005, -10039, -10992, -11863, -12651, -13355, -13978, -14527, -15006, -15426, -15793, -16116, -16408, -16678, -16935, -17189, -17449, -17720, -18011, -18326, -18669, -19043, -19447, -19883, -20351, -20845, -21362, -21901, -22453, -23016, -23584, -24148, -24705, -25251, -25776, -26280, -26758, -27203, -27617, -27996, -28338, -28644, -28914, -29149, -29350, -29521, -29662, -29779, -29873, -29949, -30010, -30059, -30100, -30137, -30173, -30210, -30251, -30297, -30351, -30413, -30484, -30564, -30655, -30753, -30860, -30973, -31093, -31217, -31342, -31470, -31597, -31723, -31843, -31959, -32070, -32170, -32264, -32350, -32424, -32490, -32546, -32593, -32630, -32659, -32680, -32694, -32702, -32705, -32705, -32702, -32696, -32690, -32683, -32561, -33275, -27893, -25640, -27240, -22468, -20333, -18973, -17445, -15768, -14136, -12673, -11405, -10316, -9359, -8476, -7623, -6762, -5860, -4905, -3885, -2798, -1653, -430};