/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0914 256 samples */
 
const int16_t AKWF_0914_256_DATA [256] = 
{212, 537, 855, 1172, 1488, 1802, 2115, 2427, 2738, 3047, 3355, 3662, 3967, 4271, 4573, 4875, 5173, 5473, 5769, 6064, 6359, 6652, 6944, 7233, 7521, 7809, 8095, 8379, 8661, 8942, 9222, 9500, 9778, 10053, 10327, 10600, 10871, 11140, 11408, 11674, 11939, 12203, 12464, 12724, 12983, 13239, 13496, 13749, 14001, 14252, 14501, 14749, 14994, 15238, 15481, 15722, 15962, 16198, 16435, 16669, 16901, 17132, 17361, 17589, 17815, 18039, 18261, 18482, 18700, 18917, 19133, 19346, 19558, 19768, 19975, 20182, 20387, 20589, 20789, 20990, 21186, 21381, 21575, 21766, 21955, 22143, 22329, 22513, 22695, 22875, 23053, 23229, 23403, 23576, 23746, 23914, 24081, 24245, 24407, 24568, 24726, 24882, 25037, 25188, 25338, 25487, 25632, 25777, 25919, 26058, 26196, 26332, 26465, 26596, 26726, 26852, 26977, 27100, 27220, 27339, 27454, 27561, 27706, 27130, 26060, 25019, 23584, 21798, 19737, 17448, 14941, 12241, 9408, 6489, 3555, 691, -2136, -4884, -7512, -10026, -12415, -14665, -16788, -18780, -20641, -22397, -24000, -25355, -26619, -27752, -28734, -29588, -30322, -30943, -31459, -31873, -32197, -32440, -32609, -32715, -32763, -32760, -32711, -32621, -32494, -32335, -32146, -31931, -31693, -31434, -31157, -30864, -30555, -30234, -29901, -29557, -29206, -28845, -28478, -28105, -27726, -27343, -26956, -26566, -26172, -25777, -25379, -24980, -24580, -24179, -23776, -23375, -22972, -22570, -22168, -21766, -21366, -20966, -20566, -20169, -19771, -19374, -18980, -18586, -18193, -17803, -17413, -17024, -16637, -16252, -15868, -15486, -15104, -14725, -14348, -13971, -13595, -13223, -12851, -12481, -12113, -11745, -11380, -11017, -10654, -10293, -9934, -9578, -9223, -8869, -8517, -8167, -7817, -7468, -7122, -6776, -6432, -6089, -5746, -5405, -5066, -4726, -4388, -4052, -3716, -3382, -3049, -2717, -2385, -2056, -1727, -1400, -1074, -749, -427, -99};