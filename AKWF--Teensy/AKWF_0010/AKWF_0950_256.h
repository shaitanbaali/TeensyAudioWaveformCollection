/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0950 256 samples */
 
const int16_t AKWF_0950_256_DATA [256] = 
{19746, 20018, 19977, 19994, 20001, 20009, 20017, 20024, 20032, 20039, 20045, 20052, 20059, 20066, 20074, 20080, 20087, 20094, 20100, 20106, 20112, 20117, 20124, 20129, 20135, 20141, 20146, 20151, 20156, 20161, 20166, 20171, 20175, 20181, 20185, 20189, 20193, 20197, 20200, 20204, 20208, 20211, 20216, 20217, 20221, 20224, 20225, 20228, 20231, 20233, 20235, 20236, 20238, 20240, 20242, 20244, 20245, 20246, 20247, 20248, 20248, 20249, 20251, 20252, 20252, 20254, 20254, 20254, 20254, 20254, 20254, 20254, 20254, 20259, 20244, 20321, 20997, 21654, 21706, 21263, 20669, 20297, 20250, 20252, 20242, 20232, 20220, 20206, 20193, 20179, 20162, 20147, 20131, 20114, 20098, 20083, 20065, 20048, 20032, 20016, 19422, 22511, -248, -14462, -11446, -12009, -12007, -12045, -11913, -12160, -30393, -33351, -32598, -32715, -32695, -32672, -32552, -32947, -31527, -3488, -119, -968, -792, -785, -777, -774, -771, -768, -765, -763, -762, -760, -759, -758, -756, -757, -756, -755, -754, -753, -752, -753, -752, -751, -751, -749, -748, -749, -749, -748, -746, -747, -745, -744, -745, -745, -744, -743, -743, -742, -742, -741, -739, -740, -739, -740, -737, -1403, -727, -743, -740, -739, -740, -742, -741, -742, -743, -743, -744, -745, -745, -744, -745, -746, -746, -747, -749, -748, -749, -749, -748, -750, -750, -751, -753, -752, -753, -752, -753, -755, -754, -756, -757, -756, -756, -758, -759, -759, -760, -762, -763, -764, -765, -767, -768, -770, -773, -776, -780, -784, -789, -794, -801, -811, -1366, 1553, -14392, -34989, -32075, -32632, -32650, -32665, -32680, -32693, -32706, -32719, -32730, -32740, -32730, -32581, -33611, -19048, -10778, -12277, -12001, -12003, -12005, -12007, -12008, -12007, -12008, -12006, -11859, -12771, -8299, -10081};