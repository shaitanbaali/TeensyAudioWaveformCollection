/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0982 256 samples */
 
const int16_t AKWF_0982_256_DATA [256] = 
{451, 2032, 3576, 5005, 6243, 7265, 8088, 8749, 9326, 9933, 10679, 11654, 12902, 14449, 16295, 18389, 20633, 22938, 25195, 27296, 29147, 30653, 31751, 32441, 32747, 32704, 32363, 31791, 31065, 30239, 29347, 28389, 27350, 26212, 24932, 23421, 21573, 19350, 16811, 14013, 10988, 7805, 4611, 1596, -1121, -3528, -5596, -7312, -8681, -9813, -10860, -11959, -13190, -14567, -16080, -17702, -19367, -20975, -22424, -23624, -24539, -25192, -25624, -25883, -26024, -26093, -26135, -26152, -26137, -26047, -25825, -25416, -24777, -23885, -22737, -21329, -19689, -17874, -15945, -13949, -11906, -9803, -7679, -5591, -3589, -1717, 6, 1555, 2889, 3991, 4883, 5605, 6199, 6695, 7104, 7443, 7726, 7956, 8118, 8158, 7996, 7593, 6997, 6271, 5488, 4736, 4101, 3645, 3469, 3551, 3805, 4149, 4439, 4597, 4539, 4209, 3579, 2709, 1734, 824, 124, -300, -449, -354, -95, 231, 536, 750, 854, 842, 750, 633, 557, 602, 847, 1345, 2158, 3323, 4837, 6675, 8764, 10990, 13233, 15359, 17251, 18848, 20120, 21062, 21689, 22027, 22137, 22084, 21908, 21624, 21243, 20777, 20252, 19648, 18938, 18091, 17091, 15937, 14609, 13074, 11321, 9375, 7329, 5283, 3285, 1394, -322, -1768, -2927, -3880, -4676, -5366, -5974, -6597, -7334, -8264, -9401, -10698, -12124, -13637, -15154, -16568, -17771, -18688, -19282, -19549, -19523, -19279, -18922, -18570, -18308, -18207, -18313, -18622, -19055, -19496, -19844, -20013, -19929, -19518, -18747, -17661, -16342, -14895, -13417, -11982, -10683, -9599, -8745, -8085, -7557, -7094, -6644, -6154, -5573, -4878, -4081, -3238, -2425, -1706, -1139, -767, -615, -671, -886, -1235, -1714, -2318, -2924, -3541, -4229, -4916, -5531, -5974, -6237, -6337, -6271, -5991, -5508, -4931, -4395, -4010, -3810, -3774, -3872, -4049, -4202, -4196, -3898, -3249, -2265, -970};