/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0992 256 samples */
 
const int16_t AKWF_0992_256_DATA [256] = 
{31472, 26657, 21938, 17207, 12500, 7709, 3214, 2977, 3888, 4566, 5289, 6014, 6740, 7463, 8187, 8912, 9635, 10362, 11087, 11810, 12535, 13260, 13983, 14709, 15433, 16156, 16882, 17606, 18329, 19056, 19780, 20504, 21229, 21953, 22677, 23403, 24126, 24851, 25576, 26299, 27024, 27751, 28474, 29198, 29923, 30638, 31090, 33458, 7141, -1612, 346, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -208, 859, -10134, -3188, -2453, -3399, -4038, -4691, -5346, -5997, -6651, -7306, -7958, -8612, -9266, -9919, -10573, -11227, -11879, -12533, -13187, -13839, -14493, -15147, -15800, -16454, -17107, -17760, -18415, -19067, -19721, -20376, -21028, -21643, -22372, -23008, -3081, 761, -169, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};