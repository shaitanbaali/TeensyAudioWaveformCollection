/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0977 256 samples */
 
const int16_t AKWF_0977_256_DATA [256] = 
{1323, 4641, 7875, 11057, 14139, 17087, 19866, 22430, 24761, 26830, 28607, 30083, 31243, 32076, 32584, 32767, 32635, 32200, 31479, 30497, 29275, 27845, 26241, 24489, 22632, 20705, 18737, 16769, 14837, 12963, 11184, 9524, 8000, 6638, 5449, 4439, 3619, 2984, 2532, 2257, 2143, 2176, 2338, 2605, 2955, 3363, 3803, 4247, 4670, 5046, 5352, 5568, 5673, 5653, 5494, 5187, 4729, 4118, 3354, 2448, 1410, 249, -1011, -2355, -3763, -5205, -6659, -8103, -9505, -10844, -12099, -13240, -14255, -15123, -15829, -16364, -16720, -16893, -16886, -16700, -16345, -15830, -15173, -14393, -13506, -12538, -11514, -10454, -9389, -8345, -7342, -6408, -5564, -4827, -4216, -3744, -3418, -3248, -3234, -3374, -3661, -4089, -4641, -5300, -6048, -6861, -7713, -8581, -9437, -10248, -10993, -11643, -12170, -12556, -12778, -12818, -12662, -12302, -11733, -10949, -9957, -8767, -7383, -5829, -4124, -2285, -348, 1661, 3717, 5776, 7810, 9790, 11673, 13435, 15044, 16469, 17691, 18688, 19441, 19940, 20176, 20149, 19860, 19314, 18528, 17514, 16293, 14895, 13340, 11664, 9902, 8082, 6243, 4425, 2652, 968, -594, -2015, -3260, -4309, -5144, -5748, -6113, -6233, -6109, -5745, -5148, -4339, -3329, -2142, -806, 654, 2211, 3823, 5470, 7112, 8713, 10250, 11688, 12998, 14161, 15152, 15950, 16547, 16929, 17090, 17033, 16756, 16270, 15581, 14709, 13669, 12478, 11166, 9752, 8259, 6720, 5154, 3587, 2048, 555, -874, -2216, -3463, -4601, -5619, -6520, -7299, -7956, -8504, -8947, -9299, -9574, -9790, -9961, -10110, -10253, -10411, -10601, -10842, -11147, -11531, -12004, -12572, -13242, -14011, -14880, -15840, -16878, -17985, -19143, -20327, -21520, -22695, -23821, -24877, -25831, -26654, -27320, -27802, -28076, -28121, -27917, -27451, -26709, -25686, -24382, -22794, -20935, -18817, -16451, -13867, -11088, -8141, -5070, -1832};