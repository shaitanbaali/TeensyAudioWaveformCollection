/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0919 256 samples */
 
const int16_t AKWF_0919_256_DATA [256] = 
{608, 2480, 4330, 6190, 8041, 9877, 11682, 13505, 15055, 15720, 16964, 18293, 19413, 20409, 21327, 22174, 22955, 23679, 24352, 24974, 25549, 26068, 26527, 26925, 27258, 27527, 27733, 27877, 27960, 27986, 27958, 27878, 27749, 27578, 27366, 27118, 26837, 26527, 26192, 25836, 25461, 25071, 24670, 24269, 23651, 23069, 22448, 21679, 21044, 20023, 19158, 18372, 17526, 16637, 15180, 13919, 12858, 11686, 10458, 9207, 7944, 6664, 5381, 4097, 2820, 1531, -3, -1429, -2780, -4182, -5609, -7044, -8484, -9927, -11363, -12794, -14216, -15621, -17016, -18395, -19753, -21098, -22425, -23727, -25011, -26271, -27505, -28716, -29886, -31112, -31859, -31496, -31985, -32485, -32708, -32768, -32716, -32567, -32330, -32016, -31637, -31200, -30704, -30148, -29525, -28836, -28082, -27262, -26380, -25442, -24449, -23405, -22319, -21197, -20043, -18860, -17652, -16426, -15191, -13945, -12697, -11440, -10265, -8601, -6348, -4786, -3173, -1421, 397, 2241, 4099, 5967, 7824, 9664, 11474, 13302, 14858, 15528, 16777, 18112, 19237, 20240, 21162, 22014, 22799, 23529, 24207, 24835, 25414, 25937, 26401, 26802, 27140, 27413, 27622, 27769, 27856, 27886, 27860, 27783, 27658, 27489, 27280, 27033, 26756, 26449, 26115, 25762, 25389, 25001, 24602, 24203, 23588, 23007, 22388, 21620, 20985, 19966, 19103, 18319, 17474, 16586, 15130, 13870, 12810, 11639, 10413, 9163, 7899, 6621, 5338, 4055, 2779, 1491, -43, -1469, -2819, -4220, -5646, -7080, -8520, -9963, -11398, -12830, -14251, -15656, -17049, -18428, -19787, -21132, -22457, -23759, -25043, -26303, -27536, -28748, -29916, -31144, -31882, -31488, -31966, -32458, -32666, -32712, -32645, -32479, -32225, -31895, -31502, -31051, -30542, -29974, -29340, -28640, -27878, -27050, -26161, -25219, -24221, -23174, -22088, -20960, -19799, -18613, -17402, -16176, -14940, -13692, -12445, -11188, -10013, -8350, -6100, -4544, -2938, -1156};