/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0949 256 samples */
 
const int16_t AKWF_0949_256_DATA [256] = 
{659, 3246, 5656, 7827, 9772, 11508, 13055, 14427, 15647, 16733, 17696, 18554, 19316, 19992, 20595, 21131, 21607, 22032, 22410, 22744, 23044, 23312, 23549, 23761, 23950, 24118, 24269, 24404, 24524, 24632, 24728, 24814, 24891, 24960, 25022, 25076, 25130, 25216, 25224, 25280, 25290, 25319, 25347, 25368, 25384, 25395, 25404, 25409, 25413, 25413, 25413, 25411, 25407, 25403, 25396, 25390, 25382, 25373, 25363, 25353, 25341, 25330, 25237, 25661, 23221, 20248, 17938, 15313, 13825, 11812, 9428, 6974, 4577, 2649, -1408, -4676, -8007, -10817, -13052, -15506, -18028, -20466, -22724, -24722, -26770, -27377, -25077, -24605, -22690, -22202, -21260, -19766, -18033, -16283, -14636, -13132, -11776, -10568, -9492, -8534, -7685, -6930, -6259, -5664, -5135, -4665, -4249, -3879, -3550, -3259, -3000, -2770, -2566, -2384, -2223, -2081, -1953, -1840, -1740, -1651, -1572, -1501, -1439, -1383, -1334, -1290, -1251, -1216, -1185, -1157, -1133, -1111, -1092, -1075, -1059, -1046, -1034, -1022, -1013, -1004, -996, -989, -983, -977, -973, -973, -935, -1109, -1024, -1066, -1023, -1005, -1026, -1034, -1033, -1026, -1018, -1009, -1001, -994, -987, -982, -977, -972, -968, -965, -962, -959, -957, -955, -954, -953, -951, -950, -950, -948, -947, -947, -947, -946, -947, -946, -946, -946, -947, -946, -947, -948, -948, -947, -949, -950, -949, -950, -950, -951, -951, -952, -953, -953, -954, -954, -955, -956, -956, -957, -959, -961, -962, -963, -965, -967, -970, -972, -975, -979, -985, -1046, -743, -3824, -6264, -8906, -11159, -12707, -14797, -17192, -19624, -21937, -24051, -25959, -27669, -29189, -30533, -31767, -32700, -31277, -30849, -29668, -29146, -28638, -27733, -26618, -25463, -24362, -23348, -22434, -21617, -20831, -20485, -16516, -13791, -10517, -8005, -6065, -3628, -884};