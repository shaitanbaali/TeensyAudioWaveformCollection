/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0918 256 samples */
 
const int16_t AKWF_0918_256_DATA [256] = 
{896, 2700, 4409, 6060, 7646, 9178, 10675, 12143, 13593, 15028, 16435, 17818, 19169, 20477, 21743, 22959, 24116, 25216, 26250, 27214, 28109, 28931, 29675, 30345, 30937, 31451, 31888, 32246, 32535, 32738, 32269, 32088, 32035, 31720, 31286, 30762, 30155, 29465, 28696, 27855, 26940, 25954, 24898, 23767, 22564, 21293, 19949, 18538, 17067, 15528, 13931, 12272, 10582, 9043, 7502, 5908, 4327, 2773, 1243, -253, -1717, -3152, -4550, -5916, -7251, -8546, -9804, -11023, -12196, -13324, -14405, -15434, -16413, -17340, -18213, -19032, -19798, -20507, -21164, -21768, -22318, -22816, -23263, -23659, -24006, -24306, -24558, -24765, -24929, -25049, -25127, -25165, -25165, -25127, -25053, -24945, -24802, -24627, -24420, -24184, -23920, -23627, -23307, -22962, -22593, -22199, -21784, -21346, -20886, -20408, -19910, -19392, -18858, -18306, -17738, -17155, -16555, -15940, -15303, -14710, -13734, -11635, -9508, -7276, -5762, -4491, -2739, -897, 922, 2691, 4406, 6060, 7646, 9178, 10675, 12143, 13594, 15028, 16435, 17818, 19169, 20477, 21743, 22959, 24116, 25216, 26250, 27214, 28109, 28931, 29675, 30345, 30937, 31451, 31888, 32246, 32535, 32738, 32269, 32088, 32035, 31720, 31286, 30762, 30155, 29465, 28696, 27855, 26940, 25954, 24898, 23767, 22564, 21293, 19949, 18538, 17067, 15528, 13931, 12272, 10582, 9043, 7502, 5908, 4327, 2773, 1243, -253, -1717, -3152, -4550, -5916, -7251, -8546, -9804, -11023, -12196, -13324, -14405, -15434, -16413, -17340, -18213, -19032, -19798, -20507, -21164, -21768, -22318, -22816, -23263, -23659, -24006, -24306, -24558, -24765, -24929, -25049, -25127, -25165, -25165, -25127, -25053, -24945, -24802, -24627, -24420, -24184, -23920, -23627, -23307, -22962, -22593, -22199, -21784, -21346, -20886, -20408, -19910, -19392, -18858, -18306, -17738, -17155, -16555, -15940, -15303, -14710, -13734, -11635, -9508, -7276, -5762, -4494, -2747, -872};