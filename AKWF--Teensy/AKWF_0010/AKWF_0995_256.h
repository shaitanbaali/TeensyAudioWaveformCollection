/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0995 256 samples */
 
const int16_t AKWF_0995_256_DATA [256] = 
{1110, 2813, 4483, 6156, 7829, 9503, 11179, 12850, 14524, 16199, 17870, 19543, 21217, 22886, 24559, 26232, 27900, 29545, 31322, 32461, 30971, 28779, 29629, 12179, -2198, 348, -136, -140, -143, -147, -150, -152, -155, -158, -159, -161, -163, -164, -165, -168, -167, -169, -170, -169, -171, -173, -172, -172, -173, -175, -174, -174, -174, -174, -175, -174, -175, -178, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -178, -177, -174, -175, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -175, -174, -178, -201, -223, -242, -257, -272, -283, -291, -297, -301, -303, -300, -296, -290, -280, -268, -254, -237, -218, -195, -174, -172, -173, -172, -172, -172, -181, -153, -282, -1723, -3431, -5081, -6742, -8405, -10066, -11725, -13389, -15049, -16708, -18370, -20029, -21688, -23350, -25007, -26664, -28325, -29942, -31772, -32282, -30078, -30857, -10322, 1843, -551, -102, -98, -94, -90, -88, -85, -83, -80, -78, -77, -75, -73, -73, -71, -69, -70, -68, -67, -68, -65, -64, -64, -65, -63, -62, -63, -62, -62, -62, -63, -61, -59, -60, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59};