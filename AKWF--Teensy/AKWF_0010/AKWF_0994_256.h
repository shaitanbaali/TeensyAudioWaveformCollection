/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0994 256 samples */
 
const int16_t AKWF_0994_256_DATA [256] = 
{9179, 9182, 9184, 9186, 9186, 9188, 9189, 9192, 9192, 9195, 9197, 9198, 9201, 9203, 9205, 9206, 9208, 9210, 9213, 9215, 9216, 9218, 9220, 9222, 9224, 9224, 9226, 9226, 9229, 9231, 9233, 9234, 9236, 9239, 9241, 9243, 9245, 9247, 9249, 9251, 9252, 9253, 9254, 9256, 9257, 9260, 9264, 9267, 9266, 9267, 9270, 9271, 9273, 9250, 9390, 8527, 7793, 7969, 7984, 8024, 8062, 8102, 8143, 8181, 8220, 8260, 8300, 8340, 8381, 8420, 8458, 8499, 8539, 8579, 8618, 8658, 8698, 8739, 8778, 8818, 8858, 8898, 8937, 8978, 9017, 9059, 9098, 9138, 9178, 9218, 9258, 9298, 9345, 9282, 9154, 9103, 9083, 9018, 9016, 8859, 8569, 8345, 7904, 8034, 8236, 8840, 9419, 9370, 9382, 9383, 9385, 9388, 9390, 9392, 9394, 9396, 9398, 9399, 9401, 9402, 9405, 9406, 9406, 9409, 9411, 9412, 9414, 9416, 9417, 9420, 9422, 9423, 9426, 9427, 9429, 9431, 9432, 9434, 9435, 9435, 9438, 9437, 9439, 9441, 9445, 9445, 9448, 9446, 9447, 9449, 9447, 9448, 9451, 9451, 9451, 9451, 9451, 9451, 9451, 9269, 10267, -596, -5292, -4247, -4393, -4357, -4320, -4284, -4247, -4211, -4174, -4138, -4101, -4066, -4030, -3993, -3958, -3921, -3885, -3849, -3813, -3777, -3741, -3704, -3667, -3632, -3595, -3560, -3523, -3487, -3451, -3413, -3379, -3341, -3306, -3269, -3234, -3198, -3161, -3127, -3116, -3013, -3100, -13843, -15421, -16083, -9088, -1868, -3167, -2150, -5526, -15302, -14570, -14391, -15485, -8107, -1682, -2298, -4123, -14148, -14530, -12234, -2173, -2303, -2267, -2072, -11909, -14007, -13419, -13313, -13958, -4882, -1450, -1524, -10499, -12952, -20144, -24473, -24450, -16643, -11996, -12180, -15004, -23624, -23638, -19998, -11623, -12363, -7664, -11131, -18136, -22702, -31438, -27593, -18580, -6678};