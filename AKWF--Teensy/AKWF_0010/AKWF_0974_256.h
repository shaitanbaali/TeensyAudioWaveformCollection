/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0974 256 samples */
 
const int16_t AKWF_0974_256_DATA [256] = 
{590, 1501, 2400, 3308, 4223, 5143, 6072, 7004, 7944, 8890, 9838, 10795, 11756, 12720, 13692, 14669, 15646, 16632, 17622, 18614, 19612, 20614, 21618, 22629, 23642, 24657, 25679, 26702, 27729, 28761, 29792, 30825, 31871, 32652, 32710, 32157, 31266, 30196, 29042, 27865, 26698, 25561, 24469, 23423, 22427, 21488, 20599, 19763, 18981, 18247, 17564, 16931, 16343, 15801, 15306, 14852, 14442, 14075, 13746, 13456, 13206, 12992, 12816, 12673, 12566, 12491, 12450, 12440, 12460, 12512, 12591, 12700, 12836, 12999, 13188, 13403, 13642, 13906, 14193, 14504, 14836, 15190, 15566, 15962, 16379, 16814, 17268, 17742, 18233, 18741, 19267, 19810, 20367, 20942, 21530, 22130, 22755, 23127, 22785, 21844, 20576, 19137, 17624, 16101, 14594, 13126, 11712, 10353, 9052, 7817, 6639, 5521, 4467, 3467, 2524, 1638, 804, 24, -703, -1383, -2014, -2596, -3135, -3627, -4075, -4481, -4847, -5171, -5457, -5704, -5915, -6090, -6228, -6333, -6405, -6443, -6450, -6427, -6374, -6291, -6180, -6042, -5877, -5685, -5468, -5227, -4960, -4671, -4359, -4024, -3669, -3290, -2893, -2476, -2038, -1582, -1108, -614, -105, 417, 966, 1265, 852, -159, -1493, -2998, -4575, -6161, -7728, -9255, -10725, -12140, -13495, -14784, -16013, -17181, -18285, -19333, -20322, -21252, -22130, -22953, -23723, -24444, -25113, -25735, -26310, -26838, -27322, -27763, -28161, -28519, -28837, -29114, -29355, -29558, -29726, -29858, -29957, -30022, -30055, -30056, -30027, -29969, -29880, -29765, -29622, -29451, -29255, -29033, -28786, -28516, -28223, -27906, -27568, -27207, -26826, -26425, -26003, -25562, -25103, -24624, -24129, -23616, -23085, -22538, -21977, -21397, -20804, -20196, -19573, -18937, -18286, -17622, -16946, -16257, -15554, -14842, -14117, -13380, -12634, -11875, -11106, -10330, -9540, -8741, -7935, -7118, -6293, -5459, -4616, -3765, -2908, -2042, -1171, -275};