/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0935 256 samples */
 
const int16_t AKWF_0935_256_DATA [256] = 
{1340, 5971, 9885, 13166, 15823, 17920, 19548, 20806, 21818, 22694, 23533, 24414, 25381, 26437, 27561, 28701, 29790, 30769, 31585, 32197, 32589, 32758, 32719, 32501, 32146, 31704, 31229, 30768, 30359, 30015, 29733, 29481, 29213, 28878, 28419, 27787, 26954, 25905, 24648, 23227, 21697, 20144, 18662, 17329, 16202, 15304, 14601, 14025, 13478, 12842, 12012, 10898, 9438, 7616, 5471, 3077, 576, -1772, -3699, -5110, -5987, -6353, -6275, -5861, -5250, -4605, -4089, -3836, -3939, -4423, -5239, -6279, -7405, -8466, -9325, -9881, -10068, -9863, -9283, -8391, -7286, -6092, -4950, -3996, -3329, -3006, -3019, -3303, -3754, -4246, -4659, -4899, -4902, -4649, -4166, -3520, -2807, -2149, -1664, -1445, -1545, -1961, -2634, -3460, -4313, -5067, -5609, -5865, -5794, -5406, -4748, -3916, -3038, -2248, -1686, -1457, -1606, -2113, -2891, -3811, -4711, -5434, -5848, -5851, -5387, -4443, -3065, -1345, 565, 2388, 3921, 5053, 5716, 5903, 5649, 5040, 4195, 3265, 2411, 1778, 1475, 1551, 1985, 2695, 3553, 4421, 5162, 5669, 5873, 5750, 5318, 4639, 3811, 2957, 2207, 1677, 1442, 1533, 1919, 2519, 3223, 3908, 4468, 4821, 4923, 4775, 4422, 3947, 3464, 3096, 2961, 3142, 3671, 4515, 5596, 6788, 7947, 8942, 9661, 10026, 10002, 9594, 8849, 7856, 6741, 5650, 4725, 4096, 3836, 3949, 4373, 4984, 5630, 6145, 6378, 6207, 5547, 4358, 2640, 447, -2032, -4491, -6750, -8714, -10324, -11574, -12514, -13218, -13787, -14338, -14978, -15791, -16825, -18078, -19507, -21044, -22594, -24068, -25401, -26539, -27460, -28172, -28698, -29079, -29369, -29621, -29887, -30205, -30588, -31032, -31510, -31972, -32370, -32651, -32770, -32690, -32390, -31869, -31134, -30218, -29168, -28042, -26905, -25819, -24815, -23903, -23057, -22208, -21269, -20128, -18667, -16780, -14367, -11351, -7707, -3322};