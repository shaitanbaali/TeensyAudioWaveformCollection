/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0907 256 samples */
 
const int16_t AKWF_0907_256_DATA [256] = 
{19562, 15538, 12715, 10643, 9131, 8034, 7238, 6666, 6256, 5965, 5762, 5623, 5529, 5471, 5438, 5422, 5420, 5429, 5443, 5463, 5487, 5514, 5542, 5572, 5603, 5634, 5666, 5698, 5731, 5763, 5796, 5828, 5861, 5893, 5925, 5958, 5990, 6022, 6054, 6086, 6117, 6149, 6179, 6211, 6242, 6273, 6304, 6335, 6366, 6396, 6427, 6456, 6488, 6517, 6547, 6577, 6606, 6636, 6665, 6694, 6724, 6753, 6781, 6810, 6839, 6868, 6896, 6925, 6952, 6980, 7008, 7036, 7063, 7091, 7119, 7146, 7174, 7201, 7228, 7255, 7282, 7309, 7335, 7361, 7389, 7415, 7440, 7466, 7493, 7519, 7544, 7569, 7595, 7621, 7646, 7671, 7696, 7721, 7746, 7771, 7795, 7820, 7845, 7869, 7893, 7917, 7941, 8084, 7445, 10753, 15760, 14090, 13577, 13106, 12771, 12536, 12374, 12265, 12195, 12155, 12135, 12131, 12137, 12152, 12172, 12013, 13020, 9377, -28204, -25332, -20091, -17087, -14763, -13072, -11846, -10964, -10331, -9881, -9566, -9348, -9203, -9110, -9055, -9029, -8936, -9449, -7187, -1424, -2933, -3590, -4142, -4557, -4870, -5108, -5292, -5435, -5548, -5640, -5716, -5780, -5836, -5886, -5929, -5971, -6010, -6046, -6081, -6115, -6148, -6181, -6213, -6245, -6277, -6308, -6339, -6370, -6399, -6430, -6460, -6490, -6520, -6550, -6579, -6609, -6639, -6668, -6697, -6727, -6756, -6784, -6812, -6841, -6870, -6898, -6926, -6955, -6982, -7010, -7038, -7065, -7093, -7121, -7148, -7175, -7202, -7229, -7256, -7283, -7309, -7335, -7363, -7389, -7415, -7440, -7467, -7493, -7519, -7544, -7569, -7595, -7620, -7645, -7670, -7695, -7720, -7745, -7770, -7794, -7818, -7843, -7867, -7892, -7916, -7940, -7963, -7987, -8011, -8035, -8058, -8082, -8105, -8128, -8150, -8174, -8197, -8219, -8242, -8265, -8287, -8310, -8332, -8354, -8377, -8399, -8420, -8442};