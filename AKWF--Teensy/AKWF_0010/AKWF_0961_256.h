/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0961 256 samples */
 
const int16_t AKWF_0961_256_DATA [256] = 
{1173, 5465, 9448, 13088, 16301, 19071, 21415, 23365, 24986, 26324, 27423, 28332, 29085, 29709, 30229, 30663, 31027, 31331, 31589, 31806, 31989, 32144, 32275, 32385, 32477, 32554, 32617, 32667, 32707, 32736, 32757, 32766, 32768, 32761, 32745, 32719, 32685, 32639, 32581, 32510, 32425, 32323, 32202, 32058, 31888, 31685, 31445, 31161, 30824, 30421, 29940, 29365, 28669, 27830, 26817, 25585, 24091, 22291, 20115, 17532, 14509, 11036, 7276, 2711, 1113, 5483, 9455, 13088, 16301, 19071, 21415, 23365, 24986, 26324, 27423, 28332, 29085, 29709, 30229, 30663, 31027, 31331, 31589, 31806, 31989, 32144, 32275, 32385, 32477, 32554, 32617, 32667, 32707, 32736, 32757, 32766, 32768, 32761, 32745, 32719, 32685, 32639, 32581, 32510, 32425, 32323, 32202, 32058, 31888, 31685, 31445, 31161, 30824, 30421, 29940, 29365, 28669, 27830, 26817, 25585, 24092, 22289, 20115, 17532, 14509, 11036, 7180, 3041, -1234, -5448, -9441, -13090, -16302, -19073, -21416, -23368, -24987, -26325, -27424, -28333, -29086, -29709, -30230, -30664, -31026, -31332, -31591, -31807, -31990, -32146, -32276, -32385, -32479, -32555, -32618, -32667, -32708, -32737, -32757, -32767, -32768, -32762, -32746, -32721, -32685, -32639, -32583, -32512, -32426, -32324, -32203, -32059, -31888, -31686, -31446, -31163, -30826, -30423, -29943, -29366, -28670, -27833, -26819, -25586, -24093, -22291, -20117, -17534, -14510, -11044, -7248, -2819, -2825, -7256, -11052, -14516, -17539, -20122, -22294, -24097, -25589, -26821, -27833, -28672, -29366, -29942, -30424, -30827, -31163, -31447, -31688, -31888, -32059, -32205, -32325, -32427, -32513, -32584, -32640, -32685, -32722, -32746, -32763, -32768, -32766, -32757, -32736, -32707, -32667, -32617, -32554, -32477, -32385, -32275, -32144, -31989, -31806, -31589, -31331, -31027, -30663, -30229, -29709, -29086, -28332, -27423, -26322, -24984, -23364, -21413, -19068, -16297, -13041, -9670, -4349, -1884};