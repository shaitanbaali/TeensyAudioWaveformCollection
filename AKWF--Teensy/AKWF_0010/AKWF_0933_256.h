/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0933 256 samples */
 
const int16_t AKWF_0933_256_DATA [256] = 
{551, 2596, 4588, 6566, 8514, 10429, 12303, 14121, 15884, 17583, 19208, 20757, 22227, 23606, 24899, 26099, 27198, 28203, 29107, 29908, 30611, 31212, 31711, 32113, 32418, 32626, 32741, 32767, 32705, 32560, 32336, 32035, 31661, 31219, 30713, 30146, 29526, 28852, 28130, 27368, 26566, 25728, 24863, 23969, 23054, 22122, 21174, 20215, 19255, 18287, 17321, 16363, 15411, 14471, 13550, 12645, 11761, 10906, 10077, 9280, 8518, 7790, 7103, 6457, 5853, 5293, 4779, 4311, 3891, 3519, 3192, 2914, 2682, 2493, 2349, 2248, 2186, 2162, 2173, 2216, 2287, 2385, 2505, 2645, 2799, 2965, 3140, 3319, 3499, 3679, 3852, 4017, 4171, 4313, 4440, 4548, 4639, 4710, 4759, 4788, 4795, 4780, 4744, 4687, 4610, 4513, 4398, 4267, 4122, 3961, 3789, 3605, 3414, 3214, 3007, 2795, 2580, 2362, 2142, 1920, 1698, 1476, 1255, 1034, 814, 594, 376, 157, -61, -279, -498, -718, -938, -1158, -1380, -1602, -1824, -2045, -2265, -2485, -2702, -2915, -3125, -3328, -3524, -3712, -3890, -4055, -4208, -4345, -4467, -4572, -4657, -4724, -4770, -4793, -4796, -4777, -4736, -4674, -4592, -4491, -4372, -4236, -4087, -3926, -3756, -3579, -3399, -3219, -3042, -2872, -2712, -2566, -2436, -2329, -2246, -2190, -2166, -2174, -2220, -2305, -2430, -2598, -2812, -3071, -3377, -3730, -4130, -4577, -5072, -5612, -6198, -6825, -7495, -8206, -8953, -9736, -10551, -11394, -12267, -13163, -14078, -15011, -15959, -16914, -17877, -18844, -19808, -20769, -21722, -22660, -23584, -24487, -25365, -26215, -27034, -27812, -28552, -29246, -29890, -30481, -31013, -31482, -31886, -32218, -32476, -32656, -32752, -32764, -32687, -32519, -32255, -31894, -31438, -30880, -30220, -29462, -28600, -27638, -26580, -25421, -24167, -22827, -21393, -19876, -18284, -16614, -14878, -13085, -11231, -9334, -7400, -5432, -3447, -1406};