/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0999 256 samples */
 
const int16_t AKWF_0999_256_DATA [256] = 
{378, 384, 390, 394, 399, 403, 406, 409, 412, 415, 418, 420, 421, 675, -743, 5607, 25160, 24171, 24536, 24713, 24883, 25053, 25221, 25391, 25557, 25722, 25889, 26053, 26217, 26380, 26543, 26704, 26866, 27027, 27186, 27345, 27504, 27661, 27820, 27976, 28131, 28293, 28455, 28654, 28866, 29072, 29280, 29486, 29692, 29898, 30104, 30308, 30513, 30715, 30916, 31119, 31321, 31520, 31720, 31920, 32117, 32312, 32528, 32662, 31817, 31604, 31497, 31363, 31233, 31103, 30972, 30843, 30713, 30582, 30452, 30322, 30193, 30063, 29933, 29803, 29673, 29543, 29413, 29284, 29153, 29024, 28894, 28764, 28634, 28505, 28375, 28245, 28116, 27987, 27857, 27728, 27597, 27469, 27339, 27210, 27081, 26951, 26822, 26693, 26563, 26434, 26305, 26176, 26047, 25919, 25789, 25660, 25531, 25402, 25273, 25144, 25016, 24887, 24758, 24629, 24501, 24373, 24243, 24114, 23986, 23760, 24111, 22222, 1040, -718, -247, -349, -354, -358, -361, -364, -367, -370, -372, -374, -376, -633, 796, -5599, -25276, -24268, -24624, -24790, -24953, -25113, -25274, -25436, -25595, -25754, -25914, -26073, -26231, -26390, -26548, -26706, -26864, -27021, -27179, -27337, -27494, -27650, -27807, -27964, -28121, -28277, -28435, -28589, -28747, -28903, -29058, -29215, -29371, -29526, -29681, -29838, -29995, -30150, -30305, -30460, -30615, -30770, -30926, -31081, -31236, -31391, -31546, -31706, -31665, -31523, -31396, -31268, -31139, -31010, -30881, -30751, -30622, -30493, -30364, -30235, -30106, -29977, -29848, -29719, -29589, -29460, -29331, -29203, -29074, -28945, -28816, -28686, -28558, -28429, -28300, -28172, -28043, -27914, -27786, -27657, -27529, -27401, -27271, -27142, -27014, -26886, -26757, -26629, -26501, -26372, -26244, -26115, -25987, -25859, -25731, -25603, -25475, -25346, -25219, -25091, -24963, -24835, -24707, -24579, -24451, -24323, -24196, -24068, -23940, -23813, -23686, -23555};