/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0928 256 samples */
 
const int16_t AKWF_0928_256_DATA [256] = 
{749, 3513, 6195, 8837, 11411, 13901, 16293, 18558, 20692, 22679, 24500, 26156, 27635, 28924, 30029, 30946, 31671, 32210, 32565, 32743, 32750, 32596, 32291, 31844, 31271, 30582, 29790, 28909, 27956, 26938, 25874, 24776, 23652, 22519, 21386, 20262, 19158, 18079, 17034, 16030, 15071, 14158, 13300, 12494, 11742, 11049, 10408, 9824, 9295, 8817, 8391, 8015, 7685, 7402, 7162, 6962, 6803, 6683, 6598, 6548, 6531, 6545, 6591, 6666, 6767, 6894, 7045, 7217, 7408, 7616, 7837, 8067, 8304, 8540, 8774, 8999, 9212, 9403, 9570, 9704, 9802, 9856, 9861, 9811, 9702, 9529, 9288, 8976, 8590, 8133, 7599, 6994, 6317, 5571, 4765, 3900, 2985, 2028, 1038, 23, -1001, -2028, -3047, -4039, -4998, -5911, -6761, -7542, -8241, -8848, -9353, -9751, -10031, -10191, -10228, -10138, -9920, -9580, -9119, -8539, -7850, -7062, -6178, -5216, -4188, -3102, -1976, -825, 338, 1495, 2634, 3739, 4793, 5785, 6702, 7531, 8264, 8891, 9401, 9794, 10064, 10207, 10223, 10115, 9884, 9535, 9073, 8509, 7846, 7099, 6276, 5386, 4447, 3466, 2455, 1432, 404, -617, -1617, -2590, -3526, -4412, -5243, -6016, -6721, -7357, -7921, -8411, -8828, -9170, -9440, -9641, -9777, -9850, -9867, -9833, -9753, -9633, -9478, -9297, -9092, -8872, -8641, -8403, -8167, -7933, -7706, -7493, -7294, -7113, -6954, -6816, -6702, -6617, -6559, -6531, -6534, -6570, -6640, -6745, -6889, -7071, -7293, -7559, -7870, -8225, -8631, -9087, -9595, -10156, -10772, -11443, -12171, -12955, -13791, -14682, -15623, -16607, -17637, -18702, -19795, -20914, -22044, -23178, -24307, -25417, -26497, -27538, -28519, -29432, -30263, -30996, -31621, -32123, -32488, -32708, -32770, -32665, -32385, -31924, -31278, -30442, -29416, -28205, -26804, -25223, -23472, -21551, -19479, -17269, -14926, -12477, -9937, -7320, -4656, -1902};