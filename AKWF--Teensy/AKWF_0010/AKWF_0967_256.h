/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0967 256 samples */
 
const int16_t AKWF_0967_256_DATA [256] = 
{17729, 17453, 17183, 16913, 16643, 16372, 16101, 15831, 15561, 15289, 15019, 14748, 14477, 14207, 13937, 13665, 13396, 13125, 12854, 12584, 12313, 12042, 11771, 11501, 11230, 10960, 10689, 10418, 10148, 9877, 9607, 9336, 9065, 8795, 8524, 8252, 7983, 7712, 7441, 7171, 6900, 6629, 6359, 6088, 5818, 5547, 5276, 5005, 4734, 4464, 4193, 3922, 3651, 3380, 3110, 2838, 2568, 2297, 2026, 1754, 1484, 1213, 941, 670, 404, 108, 148, 449, 714, 985, 1257, 1528, 1799, 2070, 2340, 2612, 2883, 3153, 3425, 3696, 3966, 4237, 4508, 4778, 5049, 5320, 5590, 5862, 6132, 6402, 6674, 6944, 7214, 7486, 7756, 8026, 8297, 8568, 8838, 9109, 9380, 9651, 9921, 10192, 10462, 10733, 11004, 11274, 11545, 11815, 12086, 12357, 12627, 12898, 13169, 13439, 13710, 13980, 14251, 14522, 14792, 15063, 15333, 15605, 15875, 16146, 16417, 16686, 16958, 17045, 18149, 15024, -11613, -21280, -22940, -23026, -22356, -21475, -20572, -19702, -18886, -18127, -17420, -16759, -16143, -15563, -15018, -14505, -14017, -13552, -13110, -12687, -12280, -11890, -11511, -11144, -10789, -10442, -10104, -9774, -9449, -9132, -8820, -8510, -8207, -7907, -7610, -7316, -7025, -6735, -6448, -6163, -5879, -5597, -5316, -5036, -4758, -4479, -4202, -3926, -3650, -3375, -3100, -2826, -2552, -2279, -2005, -1733, -1460, -1187, -916, -646, -370, -116, -245, -537, -804, -1076, -1348, -1620, -1893, -2167, -2440, -2713, -2988, -3262, -3537, -3813, -4088, -4365, -4644, -4921, -5201, -5482, -5763, -6046, -6331, -6617, -6906, -7196, -7488, -7785, -8084, -8385, -8692, -9003, -9318, -9640, -9968, -10303, -10646, -10997, -11358, -11732, -12117, -12518, -12934, -13368, -13822, -14300, -14803, -15335, -15900, -16500, -17142, -17830, -18567, -19360, -20208, -21102, -22005, -22798, -22988, -23131, -13148, 1169};