/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0939 256 samples */
 
const int16_t AKWF_0939_256_DATA [256] = 
{737, 3462, 6105, 8707, 11238, 13683, 16028, 18246, 20332, 22274, 24055, 25676, 27131, 28410, 29522, 30462, 31233, 31841, 32291, 32589, 32741, 32755, 32638, 32398, 32041, 31574, 31002, 30333, 29571, 28717, 27780, 26760, 25661, 24488, 23242, 21925, 20546, 19104, 17604, 16059, 14466, 12837, 11184, 9510, 7828, 6152, 4489, 2851, 1257, -292, -1776, -3185, -4512, -5744, -6870, -7889, -8790, -9568, -10224, -10752, -11153, -11428, -11579, -11610, -11525, -11329, -11028, -10626, -10131, -9551, -8888, -8153, -7347, -6477, -5550, -4567, -3533, -2457, -1335, -174, 1018, 2244, 3498, 4770, 6062, 7365, 8668, 9971, 11261, 12527, 13765, 14962, 16105, 17188, 18196, 19119, 19951, 20678, 21293, 21791, 22164, 22409, 22525, 22507, 22359, 22085, 21689, 21175, 20552, 19833, 19021, 18131, 17175, 16160, 15102, 14012, 12894, 11764, 10628, 9489, 8357, 7238, 6125, 5029, 3947, 2873, 1810, 754, -300, -1355, -2415, -3484, -4563, -5654, -6760, -7876, -9005, -10141, -11278, -12414, -13538, -14641, -15716, -16751, -17733, -18653, -19500, -20259, -20926, -21486, -21933, -22262, -22463, -22535, -22477, -22286, -21968, -21522, -20956, -20275, -19486, -18601, -17628, -16576, -15459, -14283, -13061, -11808, -10526, -9227, -7924, -6620, -5323, -4043, -2779, -1540, -334, 842, 1981, 3076, 4131, 5136, 6087, 6983, 7816, 8583, 9279, 9895, 10427, 10870, 11215, 11457, 11590, 11609, 11510, 11286, 10940, 10465, 9863, 9137, 8288, 7318, 6237, 5047, 3759, 2385, 931, -592, -2168, -3790, -5444, -7114, -8797, -10475, -12136, -13778, -15386, -16952, -18473, -19939, -21345, -22690, -23965, -25170, -26303, -27356, -28328, -29219, -30020, -30729, -31345, -31857, -32261, -32552, -32723, -32766, -32674, -32439, -32055, -31514, -30813, -29946, -28906, -27700, -26317, -24766, -23053, -21176, -19151, -16989, -14694, -12290, -9794, -7219, -4594, -1877};