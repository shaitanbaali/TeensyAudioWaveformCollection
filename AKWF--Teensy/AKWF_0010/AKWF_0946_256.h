/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0946 256 samples */
 
const int16_t AKWF_0946_256_DATA [256] = 
{7831, 18717, 26982, 31861, 32270, 26160, 13183, -13456, 3432, -12818, -5783, 28959, 12917, -1325, -5719, -5015, 23957, 21651, -15875, -27076, -22693, -11485, -1994, 3433, 5847, 5227, 2065, -25188, -30200, -6515, 18032, 26346, 25398, 21119, 12029, 4199, -292, -4215, -6032, -5063, -4997, 285, 25232, 32524, 19669, -1309, -19182, -25975, -25968, -24209, -19405, -11766, -5242, -1251, 2050, 4973, 6039, 5380, 4353, 4819, -7042, -28703, -32317, -23130, -6842, 10705, 22323, 26161, 25991, 24714, 21557, 15776, 9264, 4361, 1157, -1655, -4323, -5872, -5873, -5107, -4538, -3738, -3310, -4349, -4799, -5553, -6039, -5367, -3347, -748, 1845, 4965, 9549, 15364, 20688, 24020, 25548, 26264, 25750, 21621, 11980, -2005, -16380, -27302, -32606, -29704, -14413, 2084, 4342, 4471, 5144, 5814, 5996, 5109, 3182, 839, -1487, -4128, -7836, -12799, -18060, -22202, -24591, -25729, -26297, -25740, -22267, -13862, -2708, 8403, 20872, 29364, 32773, 28774, 14231, -1551, -4306, -4367, -4938, -5566, -6016, -5755, -4510, -2533, -363, 1789, 4291, 7737, 12280, 17203, 21346, 24009, 25378, 26101, 26267, 24797, 20051, 11215, -657, -13109, -23628, -30564, -32709, -27978, -13953, 1217, 4277, 4293, 4811, 5381, 5912, 5973, 5205, 3630, 1623, -415, -2486, -5048, -8559, -12978, -17614, -21472, -23976, -25311, -26039, -26316, -25348, -21723, -14455, -3908, 8060, 19135, 27559, 32205, 31772, 24082, 8388, -3145, -4153, -4415, -4885, -5442, -5934, -5968, -5231, -3742, -1829, 138, 2105, 4440, 7593, 11662, 16178, 20250, 23168, 24857, 25755, 26263, 26085, 24126, 19134, 10656, -345, -11913, -22016, -29238, -32640, -30788, -21613, -5687, 3695, 4109, 4464, 4917, 5465, 5939, 5967, 5261, 3823, 1960, 35, -1886, -4107, -7064, -10943, -15359, -19505, -22650, -24555, -25575, -26167, -26258, -24973, -21062, -13778, -3350};