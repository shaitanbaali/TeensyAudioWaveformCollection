/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0922 256 samples */
 
const int16_t AKWF_0922_256_DATA [256] = 
{402, 1027, 1634, 2230, 2806, 3359, 3884, 4378, 4844, 5282, 5696, 6092, 6478, 6862, 7254, 7666, 8107, 8591, 9125, 9719, 10383, 11122, 11938, 12838, 13816, 14870, 15997, 17185, 18423, 19701, 21001, 22307, 23606, 24872, 26093, 27253, 28330, 29314, 30191, 30947, 31579, 32078, 32440, 32669, 32766, 32737, 32589, 32332, 31980, 31542, 31035, 30474, 29869, 29236, 28588, 27935, 27286, 26652, 26035, 25440, 24869, 24318, 23789, 23276, 22772, 22273, 21769, 21253, 20720, 20161, 19569, 18941, 18271, 17558, 16804, 16004, 15165, 14294, 13391, 12467, 11531, 10587, 9647, 8722, 7817, 6943, 6105, 5307, 4557, 3857, 3203, 2601, 2044, 1529, 1051, 603, 178, -232, -634, -1039, -1450, -1877, -2325, -2796, -3295, -3824, -4379, -4961, -5567, -6189, -6823, -7462, -8097, -8721, -9327, -9906, -10453, -10960, -11424, -11842, -12212, -12535, -12812, -13046, -13243, -13410, -13552, -13680, -13800, -13921, -14052, -14199, -14369, -14566, -14795, -15055, -15347, -15669, -16015, -16379, -16754, -17126, -17490, -17830, -18135, -18395, -18597, -18729, -18784, -18753, -18631, -18415, -18105, -17702, -17210, -16638, -15996, -15292, -14545, -13766, -12971, -12178, -11404, -10664, -9974, -9347, -8795, -8328, -7955, -7678, -7500, -7421, -7438, -7543, -7729, -7986, -8301, -8662, -9055, -9466, -9881, -10287, -10672, -11025, -11337, -11601, -11813, -11969, -12070, -12117, -12113, -12065, -11978, -11860, -11721, -11570, -11414, -11262, -11123, -11003, -10906, -10837, -10798, -10787, -10806, -10851, -10915, -10995, -11083, -11172, -11253, -11321, -11365, -11381, -11361, -11301, -11199, -11052, -10859, -10624, -10348, -10036, -9695, -9330, -8949, -8562, -8174, -7794, -7432, -7091, -6778, -6496, -6249, -6036, -5858, -5712, -5593, -5497, -5416, -5343, -5270, -5188, -5089, -4966, -4810, -4614, -4375, -4088, -3752, -3367, -2933, -2454, -1935, -1382, -803, -192};