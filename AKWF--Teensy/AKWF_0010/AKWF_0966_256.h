/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0966 256 samples */
 
const int16_t AKWF_0966_256_DATA [256] = 
{296, 1396, 2491, 3611, 4752, 5922, 7120, 8347, 9609, 10910, 12247, 13629, 15060, 16531, 18082, 19568, 20774, 22140, 23386, 24414, 25262, 25934, 26436, 26781, 26978, 27037, 26971, 26790, 26506, 26126, 25664, 25126, 24521, 23860, 23146, 22389, 21594, 20767, 19912, 19037, 18142, 17231, 16312, 15382, 14445, 13506, 12563, 11617, 10696, 9867, 9148, 8538, 8034, 7636, 7342, 7148, 7051, 7047, 7134, 7307, 7563, 7900, 8313, 8801, 9360, 9988, 10685, 11448, 12274, 13165, 14120, 15136, 16215, 17357, 18559, 19828, 21162, 22554, 24039, 25471, 26635, 27966, 29185, 30192, 31025, 31687, 32181, 32520, 32713, 32768, 32698, 32514, 32224, 31838, 31369, 30821, 30206, 29531, 28803, 28026, 27211, 26362, 25481, 24578, 23652, 22708, 21754, 20786, 19810, 18829, 17843, 16852, 15862, 14869, 13874, 12882, 11887, 10892, 9898, 8900, 7900, 6899, 5891, 4879, 3860, 2830, 1793, 743, -322, -1402, -2501, -3623, -4764, -5933, -7132, -8358, -9620, -10921, -12257, -13639, -15070, -16542, -18092, -19579, -20785, -22150, -23396, -24423, -25271, -25943, -26446, -26791, -26987, -27047, -26981, -26799, -26514, -26135, -25673, -25135, -24530, -23867, -23155, -22396, -21603, -20775, -19920, -19044, -18149, -17239, -16319, -15389, -14452, -13513, -12570, -11625, -10722, -9915, -9219, -8632, -8151, -7775, -7502, -7329, -7253, -7270, -7376, -7569, -7843, -8199, -8630, -9135, -9714, -10360, -11074, -11857, -12702, -13612, -14587, -15622, -16723, -17887, -19112, -20404, -21762, -23181, -24692, -25977, -27187, -28517, -29637, -30567, -31325, -31914, -32341, -32616, -32748, -32749, -32629, -32399, -32068, -31645, -31141, -30566, -29923, -29225, -28477, -27683, -26854, -25991, -25100, -24188, -23256, -22306, -21348, -20377, -19398, -18416, -17428, -16436, -15447, -14453, -13459, -12467, -11472, -10477, -9483, -8484, -7483, -6480, -5471, -4456, -3423, -2472, -1034, -95};