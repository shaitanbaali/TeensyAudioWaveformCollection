/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0998 256 samples */
 
const int16_t AKWF_0998_256_DATA [256] = 
{447, 2013, 3543, 5070, 6585, 8087, 9575, 11037, 12476, 13890, 15270, 16618, 17931, 19199, 20427, 21610, 22742, 23825, 24855, 25826, 26741, 27596, 28385, 29113, 29775, 30367, 30891, 31344, 31726, 32035, 32271, 32433, 32520, 32533, 32470, 32333, 32121, 31835, 31475, 31043, 30538, 29961, 29317, 28603, 27822, 26978, 26069, 25099, 24072, 22987, 21848, 20660, 19420, 18134, 16809, 15440, 14035, 12600, 11131, 9637, 8122, 6582, 5030, 3467, 1891, 314, -1265, -2844, -4413, -5974, -7524, -9051, -10559, -12045, -13498, -14922, -16312, -17659, -18967, -20231, -21443, -22608, -23718, -24768, -25762, -26694, -27560, -28361, -29094, -29755, -30346, -30863, -31304, -31671, -31960, -32171, -32305, -32359, -32334, -32231, -32048, -31787, -31448, -31031, -30538, -29969, -29327, -28612, -27825, -26972, -26049, -25061, -24012, -22901, -21733, -20512, -19237, -17913, -16546, -15134, -13683, -12200, -10682, -9137, -7569, -5977, -4366, -2762, -1080, 1807, 5046, 8172, 11229, 14182, 17004, 19657, 22124, 24379, 26392, 28152, 29637, 30828, 31717, 32293, 32547, 32477, 32070, 31248, 30114, 28716, 27066, 25171, 23055, 20738, 18232, 15568, 12769, 9849, 6846, 3782, 676, -2430, -5520, -8568, -11533, -14399, -17140, -19719, -22122, -24323, -26293, -28020, -29483, -30661, -31545, -32122, -32384, -32324, -31940, -31235, -30209, -28874, -27241, -25317, -23127, -20693, -18029, -15171, -12149, -8982, -5745, -2275, 150, 2687, 6019, 9146, 12199, 15135, 17928, 20538, 22952, 25142, 27082, 28761, 30160, 31261, 32058, 32543, 32709, 32555, 32083, 31299, 30207, 28820, 27155, 25220, 23040, 20639, 18029, 15246, 12318, 9262, 6121, 2920, -316, -3542, -6736, -9869, -12899, -15806, -18563, -21133, -23500, -25641, -27526, -29146, -30483, -31520, -32250, -32667, -32764, -32543, -32004, -31154, -29998, -28550, -26828, -24837, -22608, -20162, -17511, -14696, -11740, -8666, -5519, -2250};