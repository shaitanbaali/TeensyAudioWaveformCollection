/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0910 256 samples */
 
const int16_t AKWF_0910_256_DATA [256] = 
{1592, 4157, 6714, 9327, 11735, 13977, 16132, 18139, 19968, 21595, 23002, 24191, 25160, 25912, 26458, 26805, 26962, 26939, 26747, 26396, 25894, 25251, 24477, 23578, 22561, 21440, 20328, 19248, 18141, 17026, 15932, 14869, 13847, 12874, 11953, 11081, 10264, 9497, 8776, 8104, 7476, 6887, 6339, 5826, 5348, 4902, 4485, 4095, 3733, 3393, 3075, 2779, 2502, 2242, 2000, 1772, 1560, 1362, 1175, 999, 835, 681, 537, 401, 273, 153, 40, -66, -165, -261, -352, -431, -552, -820, -1167, -1578, -2076, -2672, -3377, -4195, -5121, -6160, -7306, -8553, -9902, -11343, -12871, -14488, -16183, -17949, -19792, -21698, -23663, -25701, -27741, -29531, -31222, -32678, -31439, -30716, -30736, -30119, -29056, -27571, -26159, -26032, -24854, -23204, -21683, -20186, -18644, -17012, -15259, -13356, -11297, -9077, -6696, -4286, -1841, 711, 3194, 5462, 7640, 9701, 11605, 13333, 14861, 16186, 17310, 18234, 18963, 19506, 19872, 20069, 20107, 19995, 19742, 19355, 18846, 18219, 17483, 16642, 15746, 14887, 14016, 13121, 12230, 11359, 10514, 9707, 8940, 8213, 7528, 6886, 6282, 5718, 5190, 4696, 4236, 3806, 3404, 3030, 2682, 2355, 2050, 1766, 1500, 1252, 1021, 804, 602, 412, 235, 69, -86, -232, -368, -495, -616, -728, -834, -933, -1027, -1115, -1198, -1275, -1349, -1418, -1483, -1545, -1604, -1658, -1710, -1760, -1807, -1851, -1894, -1934, -1972, -2009, -2043, -2076, -2108, -2138, -2167, -2195, -2222, -2247, -2272, -2296, -2318, -2340, -2366, -2475, -2656, -2878, -3152, -3488, -3896, -4374, -4924, -5549, -6244, -7006, -7836, -8726, -9675, -10683, -11741, -12850, -14007, -15206, -16449, -17731, -19049, -20242, -21442, -21612, -20524, -20454, -20177, -19440, -19518, -19405, -18337, -17275, -16186, -15024, -13757, -12363, -10821, -9127, -7280, -5278, -3132, -787};