/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0993 256 samples */
 
const int16_t AKWF_0993_256_DATA [256] = 
{927, 1994, 2541, 3371, 5028, 6964, 7972, 8357, 8872, 9759, 10935, 12037, 12752, 14040, 17592, 22133, 20880, 12044, 5970, 6435, 7033, 6565, 6274, 6641, 7024, 7342, 7567, 7632, 7464, 6765, 5381, 3559, 1615, 338, -6, -283, -597, -922, -1262, -1620, -1994, -2386, -2803, -3245, -3702, -4154, -4595, -5019, -5441, -5892, -6328, -6663, -6948, -7068, -6412, -4261, -1722, -916, -825, -607, -359, -81, 213, 518, 822, 1110, 1395, 1694, 2028, 2415, 2833, 3197, 3192, 2272, 621, 7, 993, 3030, 4943, 5567, 5437, 4340, 2923, 2714, 3253, 4423, 6580, 8381, 8454, 7255, 5623, 5283, 6037, 6948, 7415, 7282, 6201, 4173, 2843, 2534, 2542, 3395, 5114, 5958, 4979, 2921, 680, -1332, -2393, -1446, 548, 1568, 382, -1513, -2268, -689, 2420, 4906, 5046, 4944, 5513, 5353, 4732, 4795, 7558, 11466, 11378, 6791, 4265, 4915, 5534, 5947, 5767, 4669, 2759, 173, -1236, -1309, -1367, -1346, -1233, -1119, -1007, -896, -788, -695, -620, -560, -527, -527, -552, -585, -625, -747, -1211, -2231, -3204, -3453, -3475, -3449, -3215, -2676, -2102, -1800, -1560, -1297, -1030, -767, -520, -289, -66, 159, 385, 595, 787, 961, 1125, 1262, 1294, 1126, 860, 860, 1166, 1683, 2123, 2309, 2355, 2210, 2097, 2290, 2633, 3151, 3876, 4446, 4630, 4555, 4452, 4681, 5116, 5566, 5901, 6077, 5968, 5651, 5553, 5637, 5788, 6164, 6692, 6855, 6488, 5839, 5235, 4729, 4571, 4944, 5476, 5371, 4219, 3143, 3968, 6709, 9061, 9819, 9731, 9596, 9338, 8618, 7771, 7252, 7509, 7754, 6454, 3732, 757, -5153, -14966, -21321, -21308, -19181, -18747, -21262, -23788, -25884, -27930, -29659, -30771, -31482, -32383, -32756, -31510, -29619, -28655, -25944, -17401, -5159};