/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0954 256 samples */
 
const int16_t AKWF_0954_256_DATA [256] = 
{2445, 6111, 9027, 11576, 13547, 15427, 16999, 18123, 18001, 18308, 18867, 18321, 15504, 13683, 14835, 16311, 18640, 19000, 18165, 16993, 15727, 14340, 12772, 11048, 9307, 7769, 6700, 6395, 7089, 9332, 11551, 11837, 11801, 10932, 10657, 10798, 10874, 10702, 10312, 9813, 9315, 8888, 8566, 8331, 8131, 7887, 7493, 6828, 5768, 4175, 1954, -1251, -3215, -3909, -3737, -2834, -2048, -1065, 344, 2175, 4296, 6536, 8710, 10670, 12297, 13498, 14217, 14424, 14115, 13303, 12028, 10344, 8312, 6006, 3521, 935, -1650, -4132, -6421, -8416, -10019, -11145, -11670, -12561, -13789, -15270, -16912, -18414, -19910, -21501, -23204, -24961, -26701, -28348, -29819, -31048, -31981, -32568, -32774, -32576, -31964, -30936, -29499, -27681, -25506, -23015, -20272, -17321, -14242, -11120, -8026, -5064, -2343, 44, 1975, 3330, 3989, 3823, 2729, 419, -2368, -4401, -6361, -7799, -9359, -10946, -12279, -13221, -13751, -13912, -13768, -13393, -12859, -12232, -11570, -10926, -10339, -9844, -9470, -9236, -9149, -9215, -9428, -9776, -10240, -10793, -11401, -12023, -12613, -13115, -13471, -13613, -13470, -12967, -12019, -10544, -8450, -5658, -1940, 1846, 4787, 7388, 9313, 11126, 12679, 13732, 14175, 13996, 13245, 11995, 10329, 8322, 6053, 3606, 1039, -1579, -4179, -6719, -9140, -11392, -13445, -15254, -16787, -18025, -18941, -19518, -19749, -19628, -19154, -18333, -17175, -15697, -13915, -11864, -9570, -7066, -4404, -1622, 1230, 4087, 6899, 9602, 12115, 14380, 16317, 17843, 18881, 19346, 19150, 18201, 16430, 13643, 10270, 7603, 4991, 2877, 725, -1413, -3296, -4780, -5838, -6500, -6818, -6852, -6666, -6316, -5855, -5332, -4792, -4271, -3798, -3406, -3114, -2938, -2892, -2982, -3210, -3570, -4054, -4651, -5338, -6097, -6897, -7702, -8479, -9182, -9765, -10177, -10362, -10262, -9809, -8940, -7565, -5783, -2563, -638};