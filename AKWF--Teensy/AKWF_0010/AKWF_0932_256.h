/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0932 256 samples */
 
const int16_t AKWF_0932_256_DATA [256] = 
{765, 3585, 6322, 9016, 11640, 14178, 16613, 18916, 21082, 23094, 24933, 26596, 28071, 29347, 30425, 31299, 31967, 32432, 32695, 32762, 32638, 32333, 31854, 31210, 30417, 29486, 28427, 27259, 25994, 24643, 23226, 21754, 20238, 18699, 17145, 15586, 14041, 12514, 11015, 9559, 8148, 6791, 5497, 4266, 3105, 2022, 1013, 83, -763, -1530, -2215, -2815, -3334, -3772, -4128, -4405, -4604, -4728, -4776, -4754, -4660, -4501, -4278, -3994, -3651, -3255, -2809, -2317, -1787, -1218, -619, 3, 642, 1296, 1951, 2606, 3253, 3880, 4484, 5056, 5589, 6075, 6508, 6882, 7191, 7429, 7592, 7677, 7679, 7600, 7435, 7189, 6860, 6451, 5969, 5416, 4798, 4125, 3403, 2639, 1848, 1035, 213, -605, -1412, -2195, -2941, -3643, -4289, -4868, -5375, -5800, -6136, -6380, -6527, -6576, -6526, -6375, -6129, -5788, -5360, -4849, -4265, -3615, -2911, -2160, -1379, -575, 238, 1046, 1838, 2604, 3329, 4004, 4617, 5158, 5622, 6000, 6286, 6476, 6570, 6563, 6456, 6251, 5953, 5563, 5090, 4540, 3921, 3242, 2512, 1742, 944, 129, -694, -1513, -2314, -3091, -3832, -4527, -5171, -5751, -6263, -6704, -7066, -7348, -7547, -7663, -7694, -7643, -7513, -7306, -7026, -6680, -6270, -5805, -5291, -4734, -4142, -3523, -2883, -2230, -1575, -918, -272, 358, 969, 1551, 2098, 2609, 3075, 3492, 3858, 4168, 4419, 4606, 4726, 4778, 4761, 4669, 4501, 4257, 3935, 3531, 3046, 2480, 1831, 1098, 286, -610, -1586, -2637, -3768, -4969, -6236, -7570, -8958, -10395, -11878, -13394, -14933, -16489, -18045, -19593, -21122, -22612, -24054, -25437, -26738, -27950, -29058, -30042, -30896, -31605, -32153, -32534, -32736, -32750, -32570, -32190, -31610, -30822, -29829, -28638, -27244, -25660, -23895, -21952, -19852, -17606, -15223, -12728, -10138, -7470, -4753, -1941};