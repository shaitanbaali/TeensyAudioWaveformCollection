/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0929 256 samples */
 
const int16_t AKWF_0929_256_DATA [256] = 
{938, 4399, 7738, 10997, 14127, 17098, 19880, 22433, 24741, 26781, 28532, 29987, 31137, 31977, 32515, 32753, 32705, 32385, 31814, 31014, 30008, 28827, 27503, 26059, 24531, 22950, 21342, 19740, 18172, 16656, 15221, 13883, 12656, 11557, 10590, 9760, 9072, 8519, 8099, 7802, 7617, 7530, 7527, 7591, 7703, 7847, 8005, 8161, 8297, 8399, 8457, 8458, 8397, 8266, 8067, 7799, 7465, 7075, 6634, 6157, 5660, 5154, 4660, 4194, 3775, 3423, 3155, 2988, 2938, 3019, 3242, 3614, 4144, 4833, 5678, 6676, 7821, 9097, 10495, 11994, 13570, 15209, 16880, 18554, 20211, 21818, 23346, 24773, 26070, 27210, 28177, 28948, 29505, 29840, 29943, 29805, 29429, 28819, 27981, 26925, 25671, 24234, 22636, 20906, 19066, 17145, 15180, 13192, 11215, 9285, 7421, 5653, 4012, 2509, 1168, 5, -973, -1758, -2346, -2743, -2951, -2982, -2850, -2573, -2170, -1666, -1086, -458, 191, 832, 1435, 1975, 2423, 2756, 2951, 2990, 2859, 2543, 2035, 1332, 435, -650, -1920, -3356, -4941, -6661, -8487, -10391, -12355, -14341, -16318, -18264, -20142, -21921, -23581, -25089, -26422, -27565, -28496, -29204, -29681, -29919, -29918, -29680, -29216, -28533, -27647, -26578, -25345, -23968, -22481, -20903, -19262, -17594, -15916, -14261, -12658, -11120, -9677, -8349, -7145, -6083, -5173, -4417, -3821, -3381, -3095, -2956, -2952, -3070, -3296, -3615, -4008, -4456, -4940, -5444, -5946, -6434, -6891, -7304, -7663, -7959, -8188, -8348, -8438, -8463, -8428, -8343, -8220, -8071, -7912, -7761, -7633, -7547, -7519, -7570, -7711, -7960, -8328, -8823, -9454, -10225, -11133, -12178, -13354, -14645, -16041, -17527, -19074, -20665, -22276, -23870, -25425, -26909, -28286, -29533, -30616, -31505, -32177, -32605, -32770, -32655, -32245, -31534, -30514, -29187, -27562, -25640, -23444, -20993, -18302, -15409, -12343, -9134, -5827, -2383};