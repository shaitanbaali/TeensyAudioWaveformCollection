/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0924 256 samples */
 
const int16_t AKWF_0924_256_DATA [256] = 
{1197, 3182, 5184, 7234, 9306, 11386, 13460, 15500, 17498, 19436, 21289, 23050, 24700, 26222, 27610, 28849, 29927, 30840, 31581, 32144, 32529, 32734, 32760, 32611, 32291, 31809, 31169, 30385, 29466, 28421, 27268, 26016, 24679, 23276, 21817, 20313, 18786, 17243, 15695, 14163, 12648, 11165, 9726, 8332, 6995, 5720, 4508, 3365, 2295, 1295, 369, -482, -1265, -1980, -2626, -3211, -3735, -4202, -4618, -4984, -5303, -5583, -5824, -6031, -6206, -6353, -6473, -6570, -6646, -6703, -6741, -6764, -6772, -6768, -6752, -6726, -6694, -6655, -6611, -6568, -6525, -6484, -6452, -6428, -6419, -6425, -6452, -6502, -6579, -6686, -6826, -7001, -7214, -7468, -7761, -8094, -8469, -8883, -9334, -9820, -10335, -10876, -11438, -12013, -12594, -13172, -13739, -14286, -14804, -15281, -15709, -16078, -16376, -16596, -16729, -16766, -16699, -16525, -16237, -15829, -15302, -14656, -13888, -13003, -12006, -10898, -9691, -8393, -7010, -5558, -4047, -2489, -903, 699, 2306, 3894, 5454, 6970, 8421, 9800, 11092, 12279, 13359, 14317, 15143, 15835, 16384, 16787, 17046, 17157, 17124, 16949, 16640, 16202, 15642, 14970, 14198, 13332, 12391, 11384, 10321, 9221, 8094, 6949, 5804, 4669, 3551, 2468, 1421, 422, -519, -1403, -2221, -2970, -3648, -4255, -4787, -5249, -5642, -5966, -6228, -6429, -6574, -6669, -6719, -6729, -6704, -6648, -6567, -6467, -6351, -6224, -6090, -5952, -5814, -5677, -5544, -5418, -5300, -5191, -5092, -5005, -4928, -4866, -4818, -4784, -4765, -4762, -4777, -4810, -4864, -4938, -5036, -5157, -5305, -5481, -5685, -5920, -6186, -6484, -6815, -7178, -7572, -7996, -8448, -8925, -9424, -9941, -10467, -11000, -11535, -12058, -12567, -13050, -13496, -13900, -14249, -14533, -14743, -14869, -14901, -14830, -14649, -14351, -13927, -13374, -12689, -11867, -10909, -9817, -8589, -7233, -5757, -4163, -2467, -634};