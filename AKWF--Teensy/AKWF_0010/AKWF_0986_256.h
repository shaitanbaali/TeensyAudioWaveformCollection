/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0986 256 samples */
 
const int16_t AKWF_0986_256_DATA [256] = 
{1434, 3982, 6550, 9165, 11788, 14394, 16950, 19411, 21755, 23947, 25950, 27743, 29297, 30583, 31588, 32292, 32684, 32756, 32506, 31935, 31046, 29855, 28378, 26627, 24633, 22427, 20028, 17479, 14819, 12071, 9290, 6514, 3770, 1112, -1429, -3822, -6024, -8012, -9764, -11249, -12457, -13378, -14002, -14331, -14367, -14121, -13606, -12839, -11845, -10640, -9259, -7730, -6077, -4337, -2543, -719, 1096, 2873, 4590, 6212, 7715, 9084, 10289, 11317, 12156, 12791, 13217, 13432, 13436, 13234, 12836, 12257, 11511, 10617, 9602, 8484, 7290, 6047, 4776, 3503, 2253, 1042, -107, -1176, -2156, -3032, -3792, -4437, -4961, -5362, -5645, -5816, -5884, -5857, -5748, -5573, -5345, -5083, -4799, -4509, -4229, -3971, -3743, -3556, -3414, -3320, -3275, -3275, -3316, -3387, -3482, -3588, -3690, -3777, -3830, -3838, -3783, -3650, -3426, -3096, -2651, -2081, -1377, -540, 431, 1536, 2764, 4104, 5544, 7061, 8636, 10249, 11865, 13461, 15008, 16470, 17822, 19033, 20074, 20921, 21551, 21943, 22081, 21954, 21554, 20876, 19921, 18700, 17213, 15484, 13531, 11368, 9031, 6547, 3941, 1256, -1474, -4220, -6935, -9584, -12138, -14551, -16795, -18843, -20659, -22223, -23515, -24514, -25211, -25600, -25674, -25439, -24902, -24075, -22973, -21616, -20037, -18254, -16302, -14215, -12018, -9751, -7452, -5143, -2866, -654, 1474, 3481, 5341, 7037, 8542, 9842, 10926, 11779, 12399, 12784, 12933, 12853, 12552, 12042, 11335, 10448, 9402, 8213, 6901, 5493, 4005, 2460, 885, -705, -2290, -3846, -5364, -6823, -8208, -9515, -10729, -11842, -12858, -13767, -14574, -15283, -15898, -16428, -16882, -17272, -17607, -17899, -18158, -18390, -18603, -18796, -18976, -19139, -19283, -19403, -19490, -19537, -19532, -19464, -19321, -19087, -18752, -18302, -17723, -17004, -16137, -15109, -13915, -12555, -11020, -9317, -7451, -5427, -3264, -918};