/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0997 256 samples */
 
const int16_t AKWF_0997_256_DATA [256] = 
{234, 239, 245, 250, 255, 259, 262, 266, 269, 272, 275, 277, 279, 281, 283, 284, 286, 287, 288, 289, 290, 290, 291, 292, 293, 293, 294, 293, 294, 296, 295, 296, 296, 295, 296, 297, 296, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 297, 296, 297, 296, 295, 296, 296, 296, 296, 296, 296, 296, 299, 290, 329, 897, 1620, 2373, 3130, 3889, 4647, 5404, 6163, 6922, 7678, 8437, 9194, 9951, 10710, 11467, 12224, 12982, 13739, 14496, 15254, 16010, 16766, 17524, 18280, 19036, 19794, 20549, 21306, 22062, 22817, 23574, 24330, 25084, 25840, 26596, 27349, 28105, 28862, 29615, 30370, 31120, 31881, 32611, 32197, 31375, 30626, 29863, 29103, 28340, 27578, 26483, 27584, 17996, -1472, 435, 82, 77, 73, 69, 64, 61, 58, 55, 52, 50, 48, 46, 44, 43, 41, 40, 38, 37, 37, 35, 34, 34, 34, 33, 31, 32, 31, 30, 30, 31, 30, 28, 29, 29, 28, 29, 28, 28, 27, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 27, 28, 27, 25, 26, 26, 26, 26, 26, 26, 26, 26, 26, 26, 26, 26, 17, 56, -205, -981, -1734, -2491, -3246, -4002, -4760, -5515, -6272, -7028, -7783, -8540, -9296, -10050, -10806, -11562, -12315, -13071, -13826, -14579, -15335, -16090, -16843, -17598, -18351, -19104, -19859, -20611, -21363, -22117, -22869, -23621, -24374, -25125, -25877, -26630, -27380, -28131, -28883, -29633, -30385, -31119, -31938, -32283, -31516, -30752, -29991, -29227, -28464, -27699, -26935, -26172, -25408, -24647, -23870};