/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0996 256 samples */
 
const int16_t AKWF_0996_256_DATA [256] = 
{159, 160, 162, 164, 165, 166, 167, 168, 169, 170, 171, 171, 171, 172, 174, 173, 174, 174, 175, 174, 175, 174, 175, 176, 177, 176, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 177, 182, 161, 267, 972, 1744, 2498, 3257, 4016, 4773, 5532, 6291, 7048, 7807, 8565, 9321, 10080, 10837, 11594, 12351, 13108, 13864, 14622, 15378, 16134, 16891, 17646, 18402, 19158, 19913, 20668, 21424, 22177, 22933, 23688, 24441, 25196, 25950, 26703, 27457, 28211, 28963, 29715, 30469, 31212, 31993, 32617, 32039, 31234, 30479, 29713, 28946, 28180, 27415, 26648, 25882, 25117, 24350, 23585, 22820, 22052, 21288, 20522, 19756, 18992, 18226, 17461, 16697, 15932, 15167, 14404, 13639, 12874, 12112, 11347, 10583, 9821, 9058, 8281, 7588, 6388, 5283, 4601, 3931, 3493, 2676, 1869, 1069, 262, -506, -682, -688, -723, -751, -775, -795, -813, -828, -840, -849, -855, -858, -859, -856, -851, -843, -832, -818, -801, -782, -759, -734, -706, -675, -641, -605, -565, -523, -478, -429, -379, -326, -269, -208, -234, -298, -356, -386, -582, -1307, -2074, -2828, -3587, -4347, -5104, -5862, -6621, -7378, -8137, -8895, -9651, -10410, -11167, -11924, -12682, -13439, -14196, -14952, -15707, -16464, -17222, -17976, -18732, -19488, -20243, -20998, -21754, -22508, -23262, -24017, -24770, -25526, -26280, -27031, -27787, -28541, -29292, -30044, -30798, -31532, -32365, -32522, -31699, -30945, -30180, -29415, -28648, -27882, -27117, -26350, -25584, -24818, -24051, -23286, -22521, -21753, -20989, -20224, -19457, -18693, -17928, -17162, -16398, -15633, -14868, -14104, -13340, -12576, -11813, -11049, -10285, -9522, -8759, -7996, -7234, -6470, -5708, -4947, -4184, -3422, -2661, -1901, -1142, -368};