/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0948 256 samples */
 
const int16_t AKWF_0948_256_DATA [256] = 
{5113, 5632, 6155, 6690, 7232, 7781, 8335, 8889, 9444, 9999, 10548, 11092, 11629, 12158, 12703, 13076, 15876, 17122, 17442, 17949, 18422, 18885, 19338, 19785, 20220, 20643, 21057, 21461, 21852, 22233, 22601, 22926, 23443, 23008, 19644, 19708, 20092, 20381, 20683, 20980, 21274, 21565, 21854, 22144, 22433, 22721, 23010, 23303, 23593, 23884, 24175, 24463, 24747, 25024, 25292, 25551, 25795, 26022, 26234, 26429, 26606, 26776, 26824, 28967, 31600, 31757, 31799, 31866, 31910, 31945, 31972, 31993, 32007, 32027, 31999, 31739, 31448, 31165, 30879, 30592, 30304, 30014, 29722, 29430, 29135, 28835, 28532, 28225, 27913, 27596, 27273, 26944, 26609, 26219, 26131, 24346, 22328, 21458, 17344, 16709, 16396, 15992, 15600, 15206, 14808, 14408, 14007, 13605, 13201, 12769, 12518, 11404, 8993, 8293, 5343, 5167, 4646, 2533, 2032, 2662, 7072, 6817, 6528, 6262, 5976, 5658, 5286, 6748, 6417, 5898, 5526, 5111, 4686, 4247, 3798, 3340, 2871, 2395, 1911, 1421, 925, 425, -315, 504, -11874, -24640, -24349, -24245, -23938, -23682, -23510, -23411, -23377, -23392, -23449, -23539, -23655, -23788, -23939, -24132, -24131, -25078, -28945, -29379, -29485, -29680, -29855, -30026, -30196, -30363, -30528, -30693, -30853, -31014, -31172, -31331, -31488, -31643, -31795, -31943, -32085, -32219, -32342, -32453, -32550, -32630, -32692, -32736, -32759, -32752, -32829, -30773, -28193, -28057, -28004, -27897, -27787, -27665, -27530, -27385, -27229, -27062, -26888, -26703, -26509, -26306, -26093, -25871, -25640, -25397, -25147, -24887, -24618, -24340, -24057, -23767, -23473, -23182, -22794, -22256, -21719, -21126, -20839, -18924, -16372, -16855, -19937, -19632, -18999, -18454, -17891, -17331, -16770, -16211, -15655, -15102, -14553, -13980, -13591, -12361, -9717, -9315, -8772, -8258, -7746, -7280, -6568, -6952, -11133, -10646, -10124, -9586, -9282, -7347, -5850, -3824};