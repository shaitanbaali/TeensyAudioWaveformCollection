/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0973 256 samples */
 
const int16_t AKWF_0973_256_DATA [256] = 
{175, 454, 727, 1002, 1276, 1550, 1825, 2100, 2374, 2649, 2922, 3197, 3472, 3746, 4020, 4295, 4569, 4844, 5118, 5393, 5667, 5942, 6216, 6491, 6765, 7039, 7314, 7588, 7863, 8137, 8412, 8685, 8961, 9235, 9509, 9784, 10058, 10332, 10607, 10881, 11156, 11431, 11704, 11979, 12254, 12528, 12802, 13077, 13351, 13626, 13900, 14174, 14449, 14724, 14998, 15272, 15547, 15821, 16096, 16370, 16644, 16919, 17193, 17467, 17742, 18017, 18291, 18565, 18840, 19114, 19389, 19663, 19938, 20212, 20486, 20760, 21036, 21310, 21584, 21859, 22133, 22408, 22682, 22956, 23231, 23505, 23779, 24055, 24329, 24603, 24877, 25152, 25426, 25701, 25975, 26249, 26524, 26798, 27073, 27347, 27621, 27896, 28171, 28445, 28719, 28994, 29268, 29542, 29817, 30091, 30366, 30641, 30915, 31189, 31464, 31738, 32013, 32271, 32553, 32747, 29048, 21741, 14795, 8676, 3338, -1314, -5343, -8834, -11861, -14469, -16718, -18656, -20312, -21728, -22937, -23955, -24815, -25533, -26125, -26610, -27001, -27307, -27542, -27713, -27828, -27894, -27919, -27905, -27859, -27784, -27685, -27564, -27422, -27266, -27094, -26909, -26713, -26507, -26293, -26072, -25843, -25609, -25370, -25126, -24879, -24628, -24374, -24118, -23859, -23599, -23336, -23072, -22807, -22541, -22274, -22005, -21736, -21466, -21196, -20926, -20654, -20383, -20112, -19839, -19565, -19294, -19020, -18747, -18474, -18200, -17927, -17653, -17379, -17105, -16832, -16557, -16283, -16010, -15735, -15461, -15187, -14912, -14639, -14364, -14090, -13816, -13541, -13266, -12993, -12718, -12443, -12170, -11895, -11620, -11347, -11072, -10797, -10523, -10248, -9974, -9700, -9425, -9151, -8877, -8602, -8328, -8054, -7778, -7505, -7230, -6955, -6681, -6407, -6132, -5858, -5583, -5309, -5035, -4760, -4486, -4211, -3937, -3662, -3388, -3113, -2839, -2565, -2290, -2016, -1742, -1467, -1193, -918, -644, -371, -92};