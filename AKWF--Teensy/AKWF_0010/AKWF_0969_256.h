/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0969 256 samples */
 
const int16_t AKWF_0969_256_DATA [256] = 
{469, 1682, 2833, 3968, 5083, 6177, 7252, 8302, 9328, 10330, 11302, 12245, 13159, 14039, 14886, 15699, 16474, 17214, 17915, 18575, 19197, 19778, 20313, 20808, 21257, 21661, 22020, 22331, 22595, 22811, 22977, 23092, 23156, 23168, 23126, 23030, 22877, 22668, 22399, 22070, 21677, 21220, 20696, 20102, 19432, 18689, 17862, 16946, 15940, 14827, 13597, 12233, 10700, 8937, 7059, 3451, 2613, 6551, 8531, 10352, 11921, 13322, 14577, 15713, 16743, 17677, 18521, 19282, 19965, 20575, 21115, 21585, 21991, 22334, 22615, 22837, 23002, 23110, 23164, 23162, 23110, 23005, 22849, 22644, 22391, 22089, 21742, 21346, 20907, 20423, 19895, 19324, 18711, 18059, 17367, 16635, 15864, 15061, 14221, 13346, 12441, 11504, 10536, 9543, 8522, 7475, 6408, 5316, 4204, 3074, 1922, 742, -504, -1698, -2844, -3965, -5068, -6144, -7195, -8223, -9222, -10193, -11136, -12049, -12928, -13779, -14594, -15375, -16122, -16833, -17508, -18148, -18749, -19313, -19840, -20328, -20779, -21191, -21564, -21898, -22194, -22450, -22668, -22847, -22985, -23086, -23148, -23170, -23154, -23100, -23005, -22875, -22704, -22496, -22248, -21964, -21641, -21281, -20885, -20451, -19978, -19471, -18927, -18348, -17736, -17087, -16404, -15691, -14943, -14163, -13355, -12515, -11646, -10752, -9829, -8881, -7911, -6915, -5897, -4861, -3803, -2729, -1641, -467, -673, -1888, -2961, -4032, -5085, -6119, -7132, -8120, -9089, -10030, -10946, -11837, -12698, -13531, -14336, -15106, -15846, -16555, -17229, -17870, -18477, -19047, -19583, -20083, -20546, -20973, -21362, -21714, -22029, -22306, -22544, -22745, -22907, -23029, -23115, -23162, -23169, -23137, -23067, -22958, -22811, -22624, -22398, -22133, -21829, -21487, -21105, -20686, -20227, -19729, -19196, -18623, -18013, -17367, -16683, -15963, -15210, -14420, -13597, -12743, -11854, -10934, -9988, -9009, -8003, -6972, -5913, -4832, -3722, -2629, -1196, -79};