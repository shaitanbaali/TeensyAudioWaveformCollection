/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0955 256 samples */
 
const int16_t AKWF_0955_256_DATA [256] = 
{1000, 3274, 5738, 8444, 11389, 14584, 18037, 21743, 25536, 30673, 28376, 26174, 23200, 20388, 19074, 16524, 12938, 8809, 4536, 355, -3640, -7393, -10880, -14123, -17076, -20033, -21135, -21398, -15070, -12421, -6481, -3088, -7427, -641, -2326, 1810, 2783, 2928, 3065, 3023, 2768, 2379, 1963, 1602, 1352, 1231, 1239, 1359, 1565, 1830, 2128, 2428, 2711, 2956, 3149, 3278, 3340, 3328, 3247, 3098, 2887, 2621, 2311, 1966, 1594, 1208, 819, 436, 70, -271, -583, -853, -1080, -1258, -1382, -1453, -1469, -1430, -1338, -1195, -1005, -771, -499, -197, 131, 478, 835, 1195, 1552, 1893, 2213, 2503, 2754, 2957, 3106, 3190, 3204, 3138, 2987, 2743, 2399, 1949, 1386, 709, -92, -1024, -2081, -3013, -3851, -4570, -5206, -5803, -6308, -6694, -6951, -7081, -7097, -7010, -6835, -6583, -6267, -5901, -5491, -5049, -4586, -4105, -3619, -3133, -2652, -2184, -1733, -1302, -897, -521, -177, 132, 405, 641, 836, 993, 1109, 1187, 1224, 1223, 1185, 1110, 1001, 862, 691, 493, 271, 26, -237, -516, -810, -1111, -1420, -1732, -2045, -2353, -2657, -2949, -3232, -3498, -3747, -3975, -4181, -4363, -4518, -4646, -4742, -4807, -4841, -4842, -4810, -4744, -4644, -4511, -4345, -4148, -3919, -3660, -3374, -3060, -2722, -2363, -1982, -1585, -1174, -749, -315, 122, 564, 1004, 1441, 1870, 2288, 2692, 3079, 3445, 3787, 4100, 4384, 4636, 4850, 5027, 5163, 5258, 5307, 5310, 5265, 5172, 5030, 4838, 4597, 4306, 3965, 3577, 3143, 2665, 2143, 1582, 984, 353, -309, -996, -1705, -2431, -3166, -3907, -4649, -5382, -6102, -6802, -7472, -8110, -8703, -9243, -9726, -10139, -10475, -10726, -10882, -10934, -10873, -10691, -10377, -9922, -9319, -8557, -7626, -6520, -5215, -3826, -1675, -557};