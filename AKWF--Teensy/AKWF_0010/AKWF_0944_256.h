/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0944 256 samples */
 
const int16_t AKWF_0944_256_DATA [256] = 
{276, 1735, 3361, 5014, 6711, 8441, 10201, 11972, 13753, 15533, 17285, 19013, 20699, 22321, 23878, 25353, 26727, 27993, 29133, 30138, 30997, 31697, 32226, 32578, 32750, 32741, 32556, 32198, 31690, 31048, 30310, 29500, 28648, 27785, 26917, 26043, 25175, 24308, 23447, 22590, 21735, 20885, 20044, 19209, 18384, 17565, 16753, 15952, 15161, 14380, 13609, 12853, 12105, 11370, 10647, 9934, 9237, 8555, 7883, 7225, 6582, 5952, 5336, 4736, 4147, 3575, 3014, 2470, 1936, 1420, 1041, -47, 2776, 10995, 15804, 20149, 24023, 27539, 30629, 32515, 32568, 30926, 28018, 24285, 20065, 15659, 11293, 7110, 3226, -298, -3450, -6229, -8637, -10716, -12477, -13951, -15175, -16173, -16972, -17598, -18069, -18406, -18629, -18752, -18789, -18756, -18657, -18505, -18307, -18074, -17809, -17521, -17213, -16889, -16555, -16214, -15867, -15520, -15170, -14818, -14471, -14129, -13787, -13453, -13121, -12794, -12472, -12154, -11841, -11530, -11224, -10920, -10614, -10310, -10006, -9701, -9392, -9079, -8766, -8445, -8117, -7784, -7443, -7093, -6732, -6364, -5981, -5586, -5182, -4764, -4331, -3878, -3413, -2934, -2437, -1923, -1393, -839, -299, -547, -1144, -1665, -2178, -2668, -3138, -3592, -4029, -4449, -4853, -5239, -5612, -5974, -6322, -6659, -6984, -7301, -7605, -7903, -8192, -8476, -8752, -9021, -9286, -9548, -9805, -10058, -10309, -10561, -10808, -11054, -11299, -11543, -11791, -12035, -12281, -12531, -12776, -13026, -13276, -13527, -13777, -14031, -14281, -14533, -14786, -15038, -15289, -15536, -15780, -16025, -16264, -16498, -16731, -16954, -17171, -17379, -17577, -17767, -17945, -18111, -18260, -18395, -18514, -18615, -18693, -18752, -18782, -18788, -18770, -18722, -18645, -18535, -18390, -18207, -17985, -17721, -17415, -17062, -16661, -16211, -15707, -15147, -14532, -13861, -13124, -12327, -11464, -10533, -9536, -8473, -7341, -6140, -4871, -3536, -2139, -653};