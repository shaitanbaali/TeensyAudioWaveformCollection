/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0976 256 samples */
 
const int16_t AKWF_0976_256_DATA [256] = 
{654, 2615, 4858, 7315, 9883, 12471, 15000, 17389, 19584, 21526, 23163, 24473, 25428, 26011, 26231, 26094, 25625, 24851, 23810, 22555, 21123, 19560, 17910, 16203, 14488, 12807, 11197, 9708, 8374, 7210, 6234, 5448, 4859, 4465, 4253, 4207, 4316, 4566, 4929, 5363, 5827, 6277, 6672, 6973, 7146, 7162, 7020, 6730, 6311, 5778, 5151, 4452, 3708, 2951, 2210, 1499, 836, 239, -274, -686, -995, -1202, -1315, -1341, -1291, -1179, -1019, -827, -621, -410, -211, -44, 84, 157, 169, 113, -10, -191, -422, -688, -979, -1287, -1599, -1901, -2179, -2420, -2608, -2731, -2789, -2781, -2710, -2581, -2391, -2134, -1809, -1414, -954, -434, 135, 748, 1396, 2063, 2722, 3344, 3912, 4410, 4834, 5190, 5475, 5688, 5830, 5903, 5914, 5868, 5763, 5598, 5379, 5115, 4818, 4496, 4164, 3836, 3525, 3240, 2987, 2767, 2578, 2416, 2267, 2121, 1966, 1793, 1606, 1406, 1200, 988, 775, 570, 383, 223, 92, -3, -66, -91, -78, -19, 87, 236, 414, 612, 818, 1032, 1251, 1477, 1709, 1940, 2160, 2340, 2446, 2452, 2338, 2090, 1698, 1166, 500, -296, -1211, -2226, -3335, -4525, -5791, -7140, -8567, -10047, -11562, -13092, -14621, -16156, -17676, -19171, -20637, -22046, -23387, -24651, -25822, -26887, -27845, -28684, -29404, -30012, -30511, -30910, -31218, -31443, -31596, -31698, -31769, -31821, -31868, -31924, -32005, -32120, -32262, -32410, -32547, -32661, -32740, -32769, -32739, -32647, -32496, -32291, -32035, -31733, -31387, -30992, -30541, -30021, -29428, -28770, -28055, -27291, -26483, -25637, -24752, -23831, -22876, -21898, -20920, -19960, -19025, -18130, -17264, -16429, -15630, -14866, -14143, -13463, -12815, -12189, -11565, -10929, -10274, -9596, -8896, -8181, -7450, -6711, -5973, -5251, -4551, -3886, -3262, -2690, -2004, -862};