/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0957 256 samples */
 
const int16_t AKWF_0957_256_DATA [256] = 
{407, 1121, 1815, 2505, 3188, 3863, 4532, 5189, 5838, 6476, 7102, 7716, 8319, 8905, 9478, 10035, 10575, 11098, 11603, 12087, 12551, 12992, 13408, 13799, 14159, 14486, 14716, 15109, 15436, 15800, 16115, 16382, 16649, 16917, 17184, 17443, 17689, 17923, 18146, 18357, 18558, 18750, 18934, 19112, 19282, 19446, 19604, 19757, 19905, 20048, 20185, 20318, 20446, 20569, 20687, 20800, 20908, 21010, 21108, 21199, 21285, 21364, 21438, 21506, 21567, 21621, 21669, 21711, 21745, 21773, 21794, 21807, 21814, 21814, 21807, 21794, 21773, 21747, 21714, 21676, 21631, 21581, 21525, 21462, 21392, 21316, 21235, 21147, 21053, 20953, 20846, 20732, 20612, 20484, 20349, 20205, 20053, 19891, 19718, 19530, 19326, 19109, 18746, 18410, 18080, 17751, 17438, 17071, 16669, 16248, 15812, 15362, 14899, 14416, 13915, 13394, 12852, 12289, 11707, 11103, 10482, 9842, 9183, 8508, 7819, 7113, 6395, 5665, 4924, 4176, 3420, 2656, 1890, 1121, 349, -421, -1191, -1959, -2720, -3478, -4228, -4968, -5699, -6420, -7125, -7818, -8494, -9151, -9791, -10408, -11001, -11569, -12107, -12601, -13072, -13622, -14139, -14670, -15157, -15613, -16066, -16516, -16962, -17399, -17824, -18238, -18640, -19031, -19413, -19788, -20153, -20513, -20867, -21215, -21558, -21895, -22227, -22554, -22876, -23190, -23499, -23800, -24093, -24380, -24658, -24928, -25188, -25439, -25679, -25909, -26127, -26334, -26528, -26708, -26875, -27027, -27163, -27282, -27383, -27466, -27531, -27575, -27599, -27599, -27571, -27525, -27345, -27136, -26962, -26758, -26577, -26341, -26061, -25753, -25428, -25084, -24722, -24340, -23935, -23508, -23060, -22588, -22097, -21585, -21054, -20505, -19940, -19359, -18765, -18155, -17533, -16899, -16253, -15596, -14932, -14257, -13574, -12886, -12189, -11487, -10781, -10069, -9353, -8636, -7914, -7191, -6469, -5743, -5018, -4294, -3570, -2849, -2129, -1422, -657, -9};