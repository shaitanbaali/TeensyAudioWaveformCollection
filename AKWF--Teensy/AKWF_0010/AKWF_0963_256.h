/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0963 256 samples */
 
const int16_t AKWF_0963_256_DATA [256] = 
{32418, 31936, 31466, 30993, 30521, 30049, 29576, 29105, 28632, 28159, 27688, 27216, 26744, 26273, 25802, 25330, 24859, 24387, 23915, 23445, 22973, 22501, 22031, 21560, 21088, 20618, 20147, 19675, 19205, 18734, 18263, 17793, 17322, 16851, 16382, 15910, 15440, 14970, 14499, 14030, 13558, 13088, 12618, 12148, 11677, 11208, 10738, 10267, 9797, 9327, 8856, 8387, 7917, 7447, 6977, 6507, 6037, 5568, 5096, 4627, 4158, 3687, 3217, 2748, 2278, 1808, 1338, 898, 287, 577, 2308, 3311, 4224, 5060, 5844, 6593, 7316, 8014, 8697, 9365, 10017, 10661, 11296, 11919, 12537, 13147, 13750, 14349, 14942, 15529, 16113, 16692, 17267, 17840, 18408, 18972, 19535, 20093, 20650, 21205, 21754, 22303, 22852, 23396, 23939, 24480, 25018, 25556, 26092, 26625, 27158, 27689, 28218, 28747, 29273, 29798, 30323, 30846, 31322, 31569, 34164, -20579, -34903, -30965, -31059, -30543, -30030, -29518, -29006, -28495, -27985, -27475, -26967, -26460, -25952, -25447, -24940, -24434, -23931, -23428, -22925, -22423, -21921, -21419, -20919, -20420, -19920, -19422, -18923, -18425, -17928, -17431, -16934, -16439, -15943, -15449, -14955, -14460, -13967, -13475, -12981, -12490, -11998, -11506, -11016, -10525, -10034, -9545, -9056, -8565, -8078, -7589, -7100, -6613, -6125, -5639, -5152, -4664, -4178, -3694, -3207, -2721, -2237, -1752, -1269, -789, -287, -372, -896, -1370, -1853, -2335, -2819, -3300, -3782, -4264, -4745, -5226, -5707, -6188, -6669, -7151, -7630, -8110, -8590, -9069, -9548, -10028, -10507, -10985, -11464, -11942, -12421, -12899, -13376, -13854, -14332, -14809, -15287, -15764, -16241, -16718, -17194, -17670, -18148, -18623, -19099, -19576, -20051, -20526, -21003, -21477, -21953, -22428, -22903, -23378, -23853, -24326, -24801, -25276, -25749, -26225, -26699, -27171, -27646, -28120, -28593, -29068, -29541, -30013, -30488, -30961, -31041, -33783, -23294, -22163};