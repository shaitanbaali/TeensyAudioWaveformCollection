/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0927 256 samples */
 
const int16_t AKWF_0927_256_DATA [256] = 
{794, 3717, 6550, 9336, 12041, 14649, 17141, 19487, 21678, 23699, 25530, 27168, 28602, 29823, 30834, 31629, 32210, 32583, 32753, 32731, 32521, 32140, 31602, 30915, 30099, 29167, 28137, 27024, 25845, 24614, 23348, 22061, 20762, 19469, 18190, 16934, 15711, 14526, 13384, 12293, 11253, 10263, 9329, 8446, 7614, 6833, 6096, 5405, 4755, 4140, 3558, 3009, 2487, 1991, 1518, 1065, 634, 223, -169, -542, -892, -1222, -1529, -1811, -2067, -2296, -2496, -2667, -2807, -2918, -3000, -3053, -3080, -3085, -3069, -3037, -2994, -2945, -2898, -2859, -2834, -2830, -2855, -2916, -3022, -3176, -3385, -3655, -3991, -4393, -4866, -5407, -6018, -6698, -7438, -8235, -9083, -9969, -10890, -11831, -12777, -13717, -14640, -15526, -16363, -17136, -17830, -18430, -18922, -19292, -19533, -19631, -19579, -19371, -19000, -18469, -17771, -16911, -15896, -14726, -13415, -11974, -10410, -8745, -6991, -5160, -3282, -1370, 560, 2480, 4376, 6229, 8014, 9721, 11330, 12823, 14191, 15422, 16501, 17428, 18196, 18796, 19235, 19511, 19628, 19591, 19409, 19092, 18648, 18091, 17437, 16696, 15882, 15014, 14104, 13171, 12224, 11279, 10349, 9448, 8580, 7761, 6996, 6291, 5652, 5080, 4578, 4146, 3784, 3486, 3253, 3075, 2951, 2872, 2833, 2825, 2842, 2878, 2923, 2971, 3019, 3056, 3079, 3086, 3069, 3027, 2958, 2860, 2732, 2574, 2386, 2169, 1925, 1654, 1358, 1037, 695, 332, -53, -455, -878, -1323, -1787, -2274, -2786, -3322, -3890, -4491, -5126, -5800, -6518, -7279, -8091, -8953, -9863, -10832, -11850, -12919, -14042, -15209, -16415, -17660, -18930, -20219, -21517, -22810, -24086, -25336, -26537, -27680, -28748, -29722, -30589, -31333, -31935, -32384, -32668, -32770, -32682, -32394, -31902, -31196, -30276, -29147, -27800, -26246, -24498, -22554, -20433, -18153, -15718, -13157, -10491, -7736, -4923, -2009};