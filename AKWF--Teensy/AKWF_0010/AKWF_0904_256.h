/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0904 256 samples */
 
const int16_t AKWF_0904_256_DATA [256] = 
{1373, 3662, 3175, 2051, 1257, 1355, 2361, 4023, 6145, 8574, 11163, 13799, 16378, 18815, 21073, 23113, 24917, 26498, 27857, 29002, 29948, 30696, 31254, 31635, 31855, 31939, 31911, 31801, 31636, 31441, 31238, 31042, 30866, 30720, 30608, 30532, 30492, 30484, 30506, 30552, 30616, 30692, 30777, 30865, 30953, 31038, 31119, 31196, 31268, 31337, 31405, 31472, 31539, 31605, 31669, 31730, 31786, 31836, 31879, 31915, 31943, 31965, 31984, 31998, 32010, 32023, 32034, 32046, 32057, 32067, 32075, 32080, 32079, 32074, 32059, 32039, 32009, 31972, 31927, 31877, 31825, 31772, 31720, 31675, 31635, 31603, 31580, 31564, 31552, 31541, 31530, 31515, 31495, 31471, 31441, 31406, 31366, 31324, 31278, 31227, 31172, 31112, 31043, 30962, 30867, 30756, 30624, 30466, 30277, 30053, 29784, 29457, 29145, 27179, 23315, 19531, 16609, 14966, 14461, 14727, 15483, 16511, 17629, 18661, 19473, 19964, 20055, 19689, 18828, 17465, 15597, 13236, 10412, 7149, 3491, -499, -4759, -9422, -12681, -12662, -11361, -9926, -9144, -9223, -9974, -11217, -12833, -14706, -16733, -18810, -20858, -22822, -24647, -26297, -27757, -29010, -30055, -30904, -31563, -32054, -32398, -32616, -32732, -32768, -32742, -32670, -32565, -32439, -32300, -32153, -32006, -31866, -31736, -31621, -31525, -31448, -31394, -31361, -31349, -31356, -31379, -31415, -31459, -31509, -31561, -31611, -31658, -31696, -31727, -31749, -31765, -31772, -31773, -31772, -31770, -31770, -31773, -31780, -31790, -31803, -31817, -31829, -31838, -31842, -31843, -31839, -31831, -31819, -31805, -31790, -31773, -31755, -31736, -31714, -31688, -31657, -31619, -31571, -31514, -31445, -31363, -31267, -31161, -31044, -30920, -30794, -30670, -30556, -30458, -30377, -30317, -30276, -30248, -30227, -30207, -30181, -30145, -30097, -30039, -29970, -29894, -29811, -29721, -29625, -29520, -29405, -29271, -29111, -28916, -28631, -28439, -26933, -21838, -15330, -8823, -3096};