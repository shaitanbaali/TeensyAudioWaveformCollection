/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0913 256 samples */
 
const int16_t AKWF_0913_256_DATA [256] = 
{558, 1691, 2802, 3913, 5019, 6121, 7216, 8300, 9375, 10441, 11493, 12533, 13561, 14571, 15569, 16550, 17514, 18464, 19395, 20307, 21203, 22079, 22936, 23775, 24594, 25391, 26171, 26928, 27663, 28381, 29075, 29747, 30399, 31027, 31609, 32276, 32486, 28537, 26768, 25284, 22541, 19724, 16988, 14235, 11436, 8666, 6010, 3556, 1352, -604, -2310, -3777, -5021, -6052, -6882, -7529, -8003, -8320, -8493, -8534, -8457, -8272, -7990, -7621, -7172, -6655, -6075, -5440, -4758, -4033, -3271, -2481, -1663, -824, 30, 898, 1777, 2659, 3545, 4432, 5312, 6190, 7060, 7917, 8763, 9595, 10409, 11207, 11985, 12741, 13476, 14185, 14869, 15530, 16159, 16639, 17032, 17382, 17634, 17798, 17879, 17883, 17810, 17663, 17446, 17167, 16834, 16452, 16028, 15568, 15074, 14553, 14010, 13444, 12861, 12267, 11657, 11040, 10416, 9786, 9152, 8518, 7881, 7246, 6614, 5983, 5357, 4737, 4121, 3512, 2911, 2317, 1732, 1157, 589, 34, -511, -1046, -1568, -2080, -2580, -3065, -3539, -4000, -4447, -4880, -5300, -5705, -6097, -6473, -6835, -7182, -7513, -7830, -8133, -8421, -8694, -8956, -9204, -9440, -9665, -9879, -10083, -10277, -10461, -10637, -10806, -10967, -11121, -11268, -11409, -11545, -11676, -11801, -11922, -12038, -12150, -12259, -12364, -12465, -12564, -12659, -12752, -12842, -12930, -13016, -13099, -13180, -13260, -13338, -13414, -13489, -13562, -13634, -13704, -13773, -13842, -13908, -13974, -14039, -14103, -14166, -14228, -14289, -14350, -14409, -14469, -14528, -14585, -14642, -14699, -14755, -14810, -14865, -14920, -14974, -15027, -15080, -15133, -15185, -15237, -15289, -15340, -15390, -15441, -15491, -15540, -15590, -15639, -15687, -15736, -15784, -15831, -15877, -15934, -15887, -15678, -15466, -15170, -14779, -14306, -13755, -13129, -12429, -11656, -10820, -9931, -8994, -8018, -7011, -5973, -4915, -3839, -2749, -1652, -525};