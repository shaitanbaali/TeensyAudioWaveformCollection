/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0972 256 samples */
 
const int16_t AKWF_0972_256_DATA [256] = 
{552, 1595, 2608, 3616, 4612, 5598, 6573, 7532, 8478, 9410, 10324, 11224, 12106, 12968, 13814, 14640, 15445, 16231, 16997, 17737, 18457, 19155, 19825, 20472, 21090, 21679, 22238, 22764, 23255, 23711, 24127, 24499, 24826, 25104, 25331, 25507, 25633, 25708, 25734, 25718, 25660, 25567, 25447, 25304, 25144, 24978, 24808, 24643, 24490, 24354, 24239, 24150, 24092, 24066, 24075, 24119, 24200, 24317, 24470, 24655, 24871, 25117, 25387, 25680, 25993, 26318, 26656, 27002, 27349, 27696, 28041, 28376, 28700, 29011, 29304, 29577, 29828, 30054, 30253, 30424, 30565, 30675, 30752, 30796, 30806, 30781, 30722, 30627, 30496, 30330, 30128, 29891, 29619, 29311, 28969, 28594, 28184, 27741, 27266, 26757, 26218, 25648, 25047, 24418, 23758, 23070, 22358, 21617, 20849, 20059, 19243, 18404, 17544, 16661, 15758, 14838, 13898, 12940, 11969, 10980, 9978, 8964, 7937, 6900, 5856, 4801, 3741, 2676, 1604, 532, -542, -1618, -2692, -3764, -4835, -5897, -6956, -8008, -9049, -10082, -11104, -12112, -13108, -14089, -15052, -15999, -16926, -17829, -18713, -19571, -20400, -21202, -21971, -22703, -23398, -24052, -24661, -25225, -25735, -26190, -26587, -26920, -27191, -27397, -27539, -27619, -27640, -27607, -27524, -27397, -27236, -27046, -26837, -26619, -26396, -26179, -25976, -25793, -25636, -25513, -25425, -25377, -25373, -25412, -25498, -25626, -25799, -26012, -26263, -26551, -26869, -27214, -27582, -27966, -28363, -28768, -29175, -29579, -29977, -30361, -30730, -31078, -31401, -31697, -31962, -32193, -32388, -32545, -32661, -32735, -32767, -32755, -32698, -32597, -32450, -32259, -32023, -31743, -31419, -31053, -30645, -30193, -29704, -29177, -28610, -28008, -27370, -26698, -25995, -25259, -24494, -23702, -22883, -22038, -21170, -20280, -19368, -18439, -17490, -16524, -15547, -14553, -13547, -12533, -11507, -10475, -9438, -8393, -7345, -6297, -5246, -4194, -3159, -2066, -677, 107};