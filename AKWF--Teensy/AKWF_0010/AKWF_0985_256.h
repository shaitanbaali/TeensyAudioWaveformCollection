/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0985 256 samples */
 
const int16_t AKWF_0985_256_DATA [256] = 
{440, 1188, 1917, 2644, 3369, 4091, 4810, 5527, 6240, 6952, 7659, 8364, 9068, 9765, 10462, 11155, 11843, 12528, 13210, 13887, 14561, 15229, 15892, 16552, 17206, 17853, 18495, 19130, 19758, 20378, 20990, 21593, 22189, 22774, 23349, 23914, 24466, 25007, 25537, 26052, 26554, 27045, 27518, 27979, 28425, 28853, 29264, 29657, 30028, 30379, 30708, 31014, 31295, 31552, 31785, 31991, 32174, 32331, 32465, 32573, 32657, 32718, 32755, 32768, 32759, 32728, 32672, 32596, 32499, 32380, 32237, 32077, 31896, 31695, 31474, 31234, 30976, 30700, 30405, 30092, 29763, 29414, 29048, 28665, 28263, 27845, 27410, 26957, 26490, 26006, 25506, 24992, 24465, 23922, 23367, 22799, 22219, 21626, 21023, 20405, 19778, 19139, 18487, 17827, 17155, 16473, 15783, 15081, 14372, 13659, 12936, 12208, 11476, 10738, 9997, 9253, 8506, 7758, 7011, 6259, 5509, 4759, 4009, 3261, 2514, 1768, 1025, 285, -452, -1185, -1917, -2645, -3370, -4091, -4811, -5527, -6240, -6952, -7660, -8365, -9068, -9766, -10462, -11156, -11844, -12529, -13211, -13887, -14562, -15231, -15893, -16553, -17207, -17854, -18495, -19130, -19758, -20378, -20990, -21594, -22189, -22774, -23349, -23914, -24466, -25008, -25537, -26053, -26555, -27045, -27519, -27979, -28425, -28853, -29264, -29657, -30028, -30379, -30708, -31014, -31295, -31553, -31785, -31992, -32174, -32331, -32465, -32574, -32657, -32718, -32755, -32768, -32759, -32728, -32672, -32596, -32499, -32380, -32239, -32077, -31896, -31695, -31474, -31234, -30976, -30700, -30405, -30092, -29763, -29414, -29048, -28665, -28263, -27845, -27410, -26957, -26490, -26007, -25506, -24992, -24465, -23922, -23367, -22800, -22219, -21626, -21023, -20406, -19778, -19139, -18487, -17828, -17155, -16473, -15783, -15082, -14373, -13659, -12937, -12209, -11477, -10738, -9997, -9254, -8507, -7759, -7011, -6259, -5509, -4760, -4010, -3262, -2515, -1770, -1029, -276};