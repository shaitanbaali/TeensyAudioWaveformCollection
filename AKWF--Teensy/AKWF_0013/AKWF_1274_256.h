/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1274 256 samples */
 
const int16_t AKWF_1274_256_DATA [256] = 
{3143, 11405, 16379, 17378, 20225, 24910, 29599, 33175, 23616, 4416, 10335, 27008, 23412, 12417, 3820, -2807, -7922, -12129, -15722, -18759, -21221, -23076, -24327, -25028, -25239, -25028, -24466, -23611, -22511, -21210, -19756, -18171, -16485, -14734, -12934, -11105, -9271, -7449, -5648, -3886, -2170, -512, 1076, 2595, 4035, 5382, 6649, 7826, 8904, 9886, 10771, 11558, 12248, 12839, 13336, 13736, 14043, 14254, 14381, 14420, 14373, 14246, 14042, 13762, 13411, 12993, 12508, 11959, 11358, 10696, 9986, 9227, 8422, 7573, 6684, 5757, 4799, 3809, 2788, 1741, 679, -408, -1516, -2632, -3756, -4884, -6018, -7146, -8260, -9362, -10440, -11482, -12481, -13430, -14305, -15098, -15790, -16355, -16771, -17000, -17015, -16756, -16177, -15218, -13783, -11777, -9076, -5502, -870, 4996, 13099, 17199, 4358, -713, 18095, 30452, 28104, 22704, 17312, 13713, 12552, 7834, 43, -3791, -10795, -1341, 7362, 1655, -3206, -11292, -16287, -17309, -20163, -24846, -29528, -33093, -23554, -4393, -10304, -26957, -23354, -12376, -3781, 2843, 7958, 12161, 15759, 18799, 21263, 23117, 24373, 25078, 25293, 25085, 24524, 23671, 22579, 21283, 19829, 18249, 16562, 14812, 13015, 11187, 9355, 7529, 5730, 3969, 2252, 592, -994, -2516, -3957, -5310, -6578, -7756, -8835, -9821, -10710, -11495, -12185, -12780, -13276, -13676, -13984, -14202, -14325, -14363, -14319, -14194, -13990, -13711, -13354, -12937, -12451, -11903, -11301, -10641, -9925, -9162, -8357, -7504, -6617, -5687, -4727, -3732, -2713, -1665, -597, 493, 1598, 2712, 3839, 4971, 6100, 7229, 8345, 9439, 10515, 11556, 12556, 13501, 14375, 15167, 15855, 16418, 16828, 17055, 17064, 16802, 16224, 15263, 13825, 11818, 9118, 5543, 910, -4949, -13037, -17144, -4324, 741, -18039, -30385, -28035, -22629, -17246, -13647, -12487, -7776, 9, 3848, 10901, 1483, -7286, -1422};