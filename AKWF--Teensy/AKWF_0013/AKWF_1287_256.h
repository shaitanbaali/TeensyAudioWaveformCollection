/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1287 256 samples */
 
const int16_t AKWF_1287_256_DATA [256] = 
{20194, 28291, 32471, 31760, 27307, 23143, 23971, 26929, 11059, 12955, 12129, 6350, 413, -2179, -1737, 2779, 25966, 25327, 20050, 15917, 13315, 11491, 9739, 3946, -22408, -26282, -25014, -23376, -22688, -23816, -26348, -24484, 551, 6094, 7267, 6011, 3045, 2296, 7899, 16177, 5330, 11226, 12922, 8121, 1889, -1719, -2345, 1672, 25335, 26255, 23393, 22029, 21932, 21744, 20353, 13546, -14945, -21523, -22797, -22783, -22228, -21735, -21035, -14846, 14810, 24324, 27971, 27096, 22203, 17428, 17497, 19589, 2801, 3795, 2163, -4251, -10582, -13255, -12528, -7327, 16953, 17815, 14412, 12461, 12287, 13034, 13885, 10627, -13387, -15223, -12312, -9516, -8216, -9310, -12401, -11669, 11702, 15126, 13809, 9796, 3934, 264, 3041, 8709, -4442, -463, -232, -6021, -12757, -16403, -16640, -11876, 12813, 14951, 13399, 13340, 14459, 15315, 14733, 8462, -19787, -26418, -28019, -28560, -28731, -29066, -29214, -23817, 5178, 14229, 17668, 16870, 12357, 8259, 9278, 12542, -2914, -504, -728, -5821, -11008, -12799, -11509, -6117, 17957, 18212, 13818, 10541, 8766, 7722, 6693, 1561, -24203, -27566, -25868, -23886, -22943, -23904, -26355, -24498, 451, 5831, 6769, 5215, 1896, 746, 5913, 13726, 2398, 7806, 9017, 3744, -2937, -6962, -7965, -4278, 19110, 19814, 16798, 15348, 15233, 15095, 13821, 7197, -21049, -27326, -28246, -27836, -26849, -25894, -24715, -18038, 12104, 22093, 26193, 25738, 21224, 16778, 17115, 19411, 2752, 3795, 2129, -4407, -10946, -13914, -13572, -8840, 14893, 15130, 11035, 8333, 7357, 7262, 7243, 3094, -21811, -24530, -22484, -20516, -19994, -21810, -25548, -25379, -2476, 582, -986, -5132, -11002, -14551, -11522, -5470, -18105, -13479, -12480, -17382, -23116, -25660, -24702, -18660, 7370, 10909, 10799, 12204, 14804, 17137, 18010, 13165, -13710, -19029, -19387, -18776, -17892, -17382, -16300, -11520};