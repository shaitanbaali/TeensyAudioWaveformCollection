/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1207 256 samples */
 
const int16_t AKWF_1207_256_DATA [256] = 
{-30193, -22030, -16206, -11858, -8629, -6232, -4452, -3136, -2158, -1433, -898, -500, -206, 11, 172, 291, 379, 444, 492, 526, 551, 569, 582, 591, 598, 602, 604, 606, 607, 606, 607, 605, 604, 603, 602, 600, 598, 597, 595, 593, 591, 590, 588, 586, 585, 583, 580, 579, 577, 575, 574, 573, 570, 569, 567, 565, 563, 562, 560, 558, 557, 555, 553, 552, 550, 548, 547, 544, 543, 541, 540, 538, 537, 535, 534, 532, 530, 529, 527, 525, 524, 522, 520, 519, 517, 515, 514, 513, 511, 509, 508, 507, 504, 503, 502, 501, 498, 497, 496, 495, 492, 491, 490, 488, 486, 485, 484, 483, 481, 479, 478, 476, 475, 474, 472, 470, 469, 468, 466, 464, 463, 463, 461, 459, 458, 457, 455, 453, 452, 451, 450, 448, 447, 446, 445, 443, 441, 440, 439, 437, 436, 435, 434, 432, 431, 429, 429, 427, 425, 424, 423, 421, 420, 419, 418, 416, 415, 414, 413, 412, 410, 409, 408, 407, 406, 404, 403, 401, 400, 399, 398, 397, 395, 394, 393, 392, 391, 390, 388, 387, 386, 385, 384, 382, 381, 380, 379, 378, 376, 375, 374, 373, 372, 370, 369, 369, 368, 366, 365, 364, 363, 362, 361, 359, 358, 357, 357, 356, 354, 353, 352, 352, 350, 349, 348, 347, 346, 345, 343, 342, 341, 340, 340, 339, 337, 336, 335, 334, 334, 333, 331, 330, 329, 328, 327, 326, 325, 324, 323, 323, 321, 320, 319, 318, 318, 317, 316, 314, 313, 313, 312, 311, 309, 309, 308, 307};