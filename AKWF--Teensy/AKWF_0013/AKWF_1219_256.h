/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1219 256 samples */
 
const int16_t AKWF_1219_256_DATA [256] = 
{332, 1357, 2409, 3492, 4575, 5631, 6621, 7501, 8237, 8799, 9162, 9323, 9301, 9133, 8867, 8554, 8249, 8003, 7846, 7844, 8036, 8333, 8744, 9278, 9910, 10620, 11392, 12207, 13054, 13930, 14829, 15753, 16709, 17701, 18739, 19830, 20974, 22174, 23423, 24702, 25993, 27266, 28483, 29608, 30603, 31432, 32075, 32512, 32736, 32755, 32585, 32249, 31775, 31195, 30537, 29824, 29079, 28316, 27541, 26762, 25975, 25174, 24354, 23501, 22598, 21631, 20583, 19437, 18184, 16819, 15346, 13788, 12168, 10528, 8921, 7394, 6000, 4787, 3782, 3003, 2454, 2113, 1948, 1919, 1977, 2077, 2177, 2246, 2260, 2211, 2091, 1898, 1632, 1299, 911, 473, 1, -490, -985, -1467, -1906, -2283, -2569, -2739, -2772, -2648, -2362, -1917, -1333, -641, 125, 921, 1708, 2444, 3097, 3636, 4047, 4319, 4446, 4430, 4278, 4000, 3603, 3099, 2494, 1797, 1019, 166, -754, -1727, -2739, -3772, -4797, -5787, -6708, -7523, -8200, -8710, -9034, -9165, -9118, -8918, -8611, -8255, -7911, -7636, -7478, -7463, -7598, -7880, -8298, -8830, -9454, -10150, -10903, -11697, -12520, -13369, -14238, -15128, -16049, -17001, -17995, -19042, -20144, -21307, -22528, -23790, -25081, -26369, -27614, -28778, -29815, -30680, -31351, -31809, -32044, -32071, -31910, -31589, -31138, -30583, -29956, -29276, -28563, -27833, -27092, -26346, -25593, -24828, -24047, -23236, -22379, -21467, -20480, -19400, -18221, -16931, -15529, -14032, -12455, -10837, -9232, -7692, -6279, -5051, -4042, -3269, -2732, -2403, -2241, -2204, -2246, -2331, -2419, -2486, -2509, -2472, -2368, -2196, -1956, -1651, -1293, -890, -451, 4, 466, 915, 1329, 1686, 1964, 2139, 2188, 2094, 1846, 1445, 898, 231, -529, -1340, -2151, -2923, -3609, -4176, -4608, -4892, -5024, -5005, -4847, -4558, -4147, -3626, -3005, -2289, -1491, -593};