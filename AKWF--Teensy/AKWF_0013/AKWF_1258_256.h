/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1258 256 samples */
 
const int16_t AKWF_1258_256_DATA [256] = 
{823, 2938, 4684, 6011, 6851, 7335, 7667, 7986, 8332, 8708, 9093, 9477, 9854, 10215, 10564, 10898, 11219, 11521, 11742, 11833, 11850, 11888, 11992, 12163, 12379, 12622, 12878, 13138, 13399, 13660, 13917, 14171, 14424, 14673, 14920, 15166, 15409, 15649, 15888, 16125, 16361, 16595, 16826, 17058, 17287, 17515, 17742, 17967, 18191, 18414, 18637, 18857, 19077, 19297, 19514, 19732, 19948, 20163, 20379, 20593, 20805, 21019, 21231, 21442, 21653, 21863, 22073, 22282, 22490, 22699, 22907, 23114, 23321, 23528, 23734, 23940, 24147, 24352, 24558, 24764, 24969, 25174, 25380, 25585, 25791, 25996, 26201, 26408, 26614, 26820, 27027, 27235, 27442, 27652, 27860, 28070, 28282, 28493, 28707, 28922, 29138, 29356, 29578, 29802, 30030, 30262, 30501, 30754, 31003, 31216, 31396, 31554, 31696, 31824, 31944, 32056, 32162, 32266, 32365, 32465, 32561, 32650, 32757, 32495, 32376, 24854, 14814, 9266, 3217, -1515, -5435, -8522, -10886, -12745, -14307, -15718, -17072, -18314, -19334, -20182, -20895, -21508, -22164, -22987, -23835, -24547, -25088, -25478, -25758, -25961, -26111, -26223, -26307, -26373, -26424, -26466, -26502, -26532, -26557, -26576, -26591, -26600, -26603, -26601, -26597, -26587, -26572, -26555, -26534, -26508, -26480, -26449, -26413, -26375, -26335, -26289, -26241, -26190, -26136, -26077, -25937, -25658, -25316, -25010, -24781, -24622, -24508, -24421, -24347, -24277, -24210, -24141, -24069, -23995, -23918, -23839, -23757, -23673, -23585, -23495, -23403, -23308, -23210, -23108, -23003, -22898, -22789, -22676, -22562, -22444, -22325, -22201, -22077, -21948, -21817, -21681, -21546, -21406, -21261, -21115, -20966, -20779, -20481, -20068, -19630, -19252, -18948, -18705, -18501, -18317, -18141, -17967, -17791, -17609, -17425, -17219, -16895, -16363, -15709, -15089, -14585, -14190, -13873, -13601, -13350, -13113, -12889, -12687, -12525, -12415, -12325, -12048, -10831, -8282, -4728, -1528};