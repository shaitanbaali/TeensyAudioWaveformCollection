/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1293 256 samples */
 
const int16_t AKWF_1293_256_DATA [256] = 
{29839, 29262, 28707, 28162, 27627, 27101, 26585, 26081, 25585, 25098, 24621, 24153, 23693, 23244, 22801, 22367, 21942, 21525, 21115, 20715, 20320, 19933, 19555, 19183, 18818, 18460, 18109, 17765, 17427, 17095, 16770, 16452, 16139, 15832, 15531, 15236, 14946, 14662, 14382, 14110, 13841, 13578, 13320, 13066, 12817, 12575, 12335, 12100, 11871, 11645, 11423, 11206, 10993, 10784, 10579, 10378, 10181, 9987, 9797, 9611, 9428, 9248, 9072, 8900, 8731, 8565, 8402, 8242, 8086, 7932, 7781, 7633, 7488, 7345, 7206, 7069, 6934, 6803, 6673, 6546, 6422, 6299, 6180, 6063, 5947, 5833, 5723, 5614, 5507, 5402, 5300, 5199, 5100, 5003, 4908, 4815, 4722, 4633, 4545, 4458, 4374, 4291, 4209, 4129, 4051, 3973, 3898, 3824, 3751, 3680, 3610, 3541, 3474, 3408, 3343, 3279, 3216, 3156, 3096, 3037, 2979, 2922, 2867, 2813, 2759, 2706, 2024, 5372, -17751, -34933, -31000, -31017, -30428, -29849, -29281, -28725, -28179, -27642, -27118, -26602, -26095, -25600, -25113, -24635, -24168, -23708, -23256, -22815, -22381, -21955, -21538, -21128, -20726, -20332, -19946, -19567, -19195, -18830, -18472, -18121, -17776, -17438, -17106, -16781, -16462, -16149, -15841, -15541, -15245, -14955, -14671, -14392, -14118, -13851, -13587, -13328, -13075, -12826, -12582, -12343, -12108, -11878, -11653, -11431, -11213, -11001, -10791, -10586, -10384, -10187, -9994, -9804, -9617, -9434, -9255, -9079, -8906, -8737, -8570, -8408, -8248, -8091, -7937, -7786, -7638, -7493, -7351, -7211, -7074, -6939, -6807, -6678, -6551, -6426, -6304, -6184, -6066, -5951, -5838, -5727, -5618, -5511, -5407, -5304, -5203, -5104, -5007, -4912, -4818, -4727, -4637, -4549, -4462, -4377, -4294, -4213, -4132, -4054, -3977, -3901, -3827, -3754, -3663, -3674, -3142, -947, 1331, 3510, 5629, 7896, 9826, 11828, 13906, 15783, 17746, 9811};