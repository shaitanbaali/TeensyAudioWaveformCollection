/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1213 256 samples */
 
const int16_t AKWF_1213_256_DATA [256] = 
{1331, 4056, 6886, 9739, 12473, 14985, 17213, 19134, 20794, 22264, 23616, 24918, 26198, 27444, 28618, 29653, 30463, 30965, 31083, 30774, 30038, 28929, 27538, 25961, 24297, 22602, 20874, 19081, 17143, 14972, 12522, 9782, 6785, 3627, 399, -2798, -5868, -8772, -11509, -14101, -16609, -19073, -21500, -23878, -26146, -28213, -29991, -31380, -32305, -32739, -32689, -32211, -31385, -30312, -29089, -27795, -26495, -25226, -23993, -22793, -21605, -20395, -19136, -17801, -16361, -14805, -13118, -11291, -9342, -7279, -5133, -2954, -785, 1313, 3274, 5050, 6595, 7879, 8906, 9691, 10273, 10714, 11085, 11463, 11919, 12513, 13280, 14234, 15361, 16622, 17964, 19302, 20549, 21611, 22392, 22818, 22835, 22420, 21584, 20377, 18883, 17206, 15471, 13814, 12347, 11172, 10352, 9906, 9812, 10008, 10394, 10847, 11225, 11390, 11220, 10622, 9542, 7977, 5969, 3591, 966, -1759, -4434, -6879, -8941, -10493, -11439, -11741, -11413, -10525, -9191, -7561, -5817, -4139, -2696, -1634, -1038, -953, -1367, -2222, -3420, -4829, -6300, -7663, -8759, -9460, -9670, -9349, -8499, -7174, -5463, -3474, -1350, 751, 2682, 4287, 5440, 6056, 6073, 5480, 4308, 2638, 593, -1679, -4007, -6245, -8272, -9992, -11353, -12317, -12866, -13002, -12755, -12187, -11389, -10471, -9541, -8684, -7967, -7433, -7105, -6990, -7079, -7335, -7696, -8081, -8388, -8520, -8388, -7929, -7114, -5948, -4461, -2715, -767, 1324, 3507, 5757, 8042, 10312, 12515, 14562, 16344, 17770, 18762, 19288, 19375, 19089, 18529, 17788, 16944, 16035, 15062, 13998, 12804, 11432, 9870, 8125, 6226, 4245, 2255, 315, -1523, -3252, -4897, -6489, -8080, -9713, -11410, -13181, -14998, -16796, -18490, -19970, -21130, -21906, -22283, -22303, -22051, -21624, -21105, -20530, -19897, -19164, -18201, -16916, -15428, -13865, -12313, -10831, -9421, -8046, -6617, -5033, -3214, -1038};