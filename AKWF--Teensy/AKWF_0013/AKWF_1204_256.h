/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1204 256 samples */
 
const int16_t AKWF_1204_256_DATA [256] = 
{1701, 6863, 12570, 17850, 22069, 25203, 27466, 29073, 30219, 31036, 31617, 32033, 32328, 32532, 32666, 32743, 32768, 32748, 32676, 32544, 32331, 32005, 31506, 30729, 29505, 27585, 24737, 21122, 17471, 14526, 12472, 11082, 10095, 9336, 8687, 8072, 7443, 6752, 5956, 5012, 3859, 2437, 697, -1399, -3807, -6377, -8902, -11141, -12897, -14023, -14340, -13636, -11835, -9378, -7141, -5687, -5001, -4831, -4958, -5246, -5610, -6005, -6405, -6795, -7170, -7523, -7856, -8175, -8481, -8784, -9096, -9437, -9839, -10356, -11076, -12157, -13828, -16323, -19600, -22998, -25672, -27306, -28024, -28034, -27471, -26399, -24877, -23000, -20952, -18951, -17167, -15693, -14531, -13626, -12922, -12354, -11861, -11391, -10879, -10238, -9346, -8003, -5939, -2979, 619, 4049, 6645, 8353, 9414, 10067, 10473, 10725, 10877, 10961, 10997, 10992, 10950, 10872, 10753, 10581, 10344, 10018, 9566, 8938, 8049, 6766, 4900, 2169, -1740, -6854, -12563, -17850, -22069, -25203, -27466, -29073, -30219, -31036, -31617, -32033, -32328, -32532, -32666, -32743, -32768, -32748, -32676, -32544, -32331, -32005, -31506, -30729, -29505, -27585, -24737, -21122, -17472, -14527, -12472, -11083, -10096, -9337, -8688, -8073, -7444, -6753, -5957, -5013, -3860, -2438, -698, 1398, 3806, 6376, 8901, 11140, 12896, 14023, 14339, 13636, 11834, 9377, 7141, 5686, 5000, 4830, 4958, 5245, 5609, 6004, 6404, 6794, 7169, 7522, 7856, 8175, 8480, 8783, 9095, 9436, 9838, 10355, 11075, 12156, 13827, 16323, 19600, 22998, 25672, 27306, 28024, 28034, 27471, 26399, 24876, 23000, 20952, 18951, 17167, 15693, 14530, 13626, 12922, 12354, 11861, 11390, 10878, 10237, 9345, 8002, 5938, 2978, -619, -4050, -6646, -8354, -9415, -10068, -10474, -10726, -10877, -10962, -10998, -10992, -10951, -10873, -10753, -10582, -10345, -10019, -9567, -8938, -8050, -6773, -4926, -2099};