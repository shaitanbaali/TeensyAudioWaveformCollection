/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1275 256 samples */
 
const int16_t AKWF_1275_256_DATA [256] = 
{1630, 3788, 4971, 5849, 6716, 7591, 8376, 9008, 9514, 9960, 10404, 10873, 11363, 11860, 12364, 12877, 13403, 13945, 14500, 15066, 15640, 16218, 16795, 17376, 17954, 18525, 19094, 19652, 20202, 20741, 21267, 21780, 22280, 22765, 23235, 23691, 24129, 24553, 24961, 25353, 25730, 26091, 26437, 26768, 27086, 27388, 27468, 28791, 24167, 1772, 3092, 7272, 6198, 2630, -1468, -4682, -6626, -7686, -8423, -9145, -9884, -10545, -11061, -11453, -11791, -12132, -12501, -12896, -13307, -13728, -14161, -14611, -15082, -15572, -16075, -16590, -17112, -17638, -18168, -18699, -19227, -19754, -20274, -20786, -21257, -21606, -23213, -4030, 5298, -1343, -2036, 548, 4453, 7929, 10167, 11321, 11949, 12481, 13049, 13588, 14002, 14284, 14487, 14677, 14899, 15155, 15435, 15733, 16047, 16381, 16741, 17125, 17529, 17950, 18385, 18828, 19281, 19740, 20201, 20663, 21124, 21580, 22032, 22478, 22916, 23345, 23763, 24171, 24569, 24952, 25325, 25686, 26033, 26350, 26429, 28277, 10286, -1228, 5340, 6181, 3587, -456, -4158, -6643, -8005, -8801, -9478, -10185, -10864, -11420, -11833, -12160, -12468, -12797, -13157, -13539, -13932, -14338, -14760, -15201, -15665, -16145, -16638, -17140, -17650, -18164, -18682, -19199, -19715, -20227, -20732, -21230, -21719, -22198, -22666, -23122, -23565, -23995, -24412, -24814, -25203, -25578, -25937, -26285, -26617, -26934, -27240, -27532, -27810, -28077, -28331, -28573, -28804, -29023, -29232, -29431, -29620, -29799, -29969, -30131, -30285, -30430, -30568, -30698, -30822, -30938, -31049, -31154, -31253, -31347, -31436, -31519, -31598, -31673, -31744, -31810, -31873, -31933, -31989, -32042, -32092, -32139, -32184, -32226, -32266, -32303, -32338, -32371, -32403, -32433, -32461, -32487, -32511, -32535, -32557, -32577, -32597, -32616, -32634, -32650, -32665, -32680, -32694, -32706, -32718, -32730, -32741, -32514, -33725, -27934, -5574, -7481, -11152, -9742, -5921, -1610};