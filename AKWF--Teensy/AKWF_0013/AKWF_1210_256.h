/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1210 256 samples */
 
const int16_t AKWF_1210_256_DATA [256] = 
{1554, 5232, 7813, 8764, 7992, 6424, 5544, 6169, 8015, 10200, 11790, 12359, 12388, 12872, 14483, 17217, 20678, 24369, 27691, 30093, 31338, 31635, 31483, 31353, 31463, 31796, 32277, 32709, 32640, 31661, 30062, 28645, 27791, 27198, 26504, 25572, 24230, 22366, 20208, 18199, 16626, 15437, 14132, 12071, 9084, 5542, 1967, -1267, -4168, -7072, -9944, -12244, -13566, -13928, -13484, -12565, -11910, -12274, -13916, -16424, -18967, -20826, -21889, -22493, -23024, -23863, -25133, -26350, -26827, -26376, -25037, -22817, -20068, -17573, -15779, -14620, -14106, -14435, -15566, -16914, -17559, -16811, -14668, -11643, -8368, -5529, -3710, -3063, -3221, -3577, -3606, -2985, -1606, 410, 2705, 4815, 6318, 7024, 7158, 7153, 7318, 7797, 8696, 9905, 10998, 11573, 11621, 11400, 11196, 11244, 11671, 12546, 13886, 15438, 16621, 17175, 17304, 17020, 16003, 14466, 13187, 12572, 12388, 12318, 12157, 11720, 10996, 10094, 9121, 8270, 7802, 7622, 7302, 6542, 5360, 3882, 2240, 650, -633, -1473, -1864, -1902, -1807, -1942, -2605, -3791, -5229, -6598, -7578, -7941, -7748, -7261, -6705, -6222, -5879, -5528, -4909, -3936, -2716, -1240, 761, 3145, 5139, 6448, 7157, 7485, 7775, 8527, 9914, 11590, 13064, 13911, 13802, 12918, 12069, 11944, 12633, 13771, 14754, 14952, 14222, 13011, 11895, 11207, 10972, 10839, 10249, 8914, 7007, 4938, 3080, 1580, 400, -361, -526, -362, -579, -1375, -2162, -2562, -2960, -3880, -5384, -7251, -9343, -11821, -14716, -17296, -18684, -19030, -19149, -19368, -19797, -20558, -21235, -21101, -20339, -19505, -18810, -18762, -19947, -21698, -22800, -23259, -23663, -24281, -25438, -27345, -29125, -29645, -28538, -26025, -22811, -20047, -18343, -17263, -16328, -15237, -13689, -11866, -10540, -10091, -10391, -11321, -12471, -13077, -12824, -12042, -10937, -9575, -8215, -7172, -6525, -5971, -4734, -2017};