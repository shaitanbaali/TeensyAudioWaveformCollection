/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1272 256 samples */
 
const int16_t AKWF_1272_256_DATA [256] = 
{22117, 12383, 13188, 13587, 6221, -7990, -6250, -10355, 8855, 30797, 4307, 7023, 7209, 6480, 5939, 5455, 5033, 4673, 4383, 4165, 4017, 3942, 3942, 4014, 4157, 4368, 4646, 4985, 5381, 5831, 6326, 6862, 7433, 8028, 8644, 9274, 9906, 10335, 12421, -3079, 2066, 15028, 13509, 14287, 14674, 15000, 15263, 15456, 15574, 15619, 15585, 15472, 15277, 15003, 14649, 14217, 13708, 13128, 12474, 11757, 10980, 10143, 9258, 8328, 7358, 6358, 5334, 4288, 3237, 2179, 1124, 84, -942, -1944, -2912, -3847, -4740, -5582, -6375, -7112, -7785, -8399, -8946, -9424, -9835, -10176, -10435, -10561, -11270, 3819, 7568, 6303, 6226, 6045, 5927, 5871, 5874, 5932, 6040, 6194, 6392, 6626, 6893, 7188, 7504, 7838, 8183, 8536, 8890, 9240, 9583, 9914, 10228, 10521, 10791, 11034, 11248, 11430, 11577, 11690, 11767, 11807, 11811, 11778, 11709, 11606, 11471, 11304, 11110, 10889, 10646, 10383, 10104, 9812, 9511, 9205, 8898, 8593, 8294, 8006, 7690, 7761, 6048, 4774, 7324, 6644, 6606, 6511, 6450, 6426, 6439, 6490, 6580, 6707, 6873, 7075, 7313, 7587, 7893, 8228, 8594, 8347, 12200, -11429, -27596, -24733, -11892, -2510, -3365, -2288, -1546, -832, -154, 485, 1083, 1636, 2140, 2596, 3000, 3349, 3646, 3889, 4077, 4212, 4295, 4328, 4312, 4248, 4142, 3995, 3810, 3592, 3343, 3069, 2773, 2459, 2132, 1796, 1693, 79, 6610, 18971, 17457, 16911, 16293, 15692, 15130, 14611, 14143, 13726, 13363, 13060, 12813, 12627, 12501, 12438, 12434, 12489, 12603, 12771, 12992, 13264, 13584, 13946, 14347, 14782, 15248, 15740, 16251, 16779, 17319, 17864, 17876, 21360, 7510, -18171, -13825, -13174, -11999, -10876, -9817, -8820, -7894, -7045, -6273, -5583, -4979, -4459, -4023, -3674, -3408, -3225, -3121, -3092, -3135, -3250};