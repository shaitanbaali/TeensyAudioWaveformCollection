/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1282 256 samples */
 
const int16_t AKWF_1282_256_DATA [256] = 
{512, 1851, 3000, 4038, 4989, 5879, 6723, 7530, 8311, 9072, 9815, 10545, 11266, 11974, 12673, 13364, 14046, 14720, 15386, 16040, 16686, 17320, 17940, 18547, 19135, 19702, 20245, 20759, 21233, 21659, 22021, 22300, 22472, 22498, 22339, 21948, 21303, 20412, 19356, 18274, 17305, 16543, 16019, 15709, 15573, 15567, 15655, 15808, 16004, 16232, 16476, 16730, 16988, 17246, 17499, 17748, 17988, 18219, 18440, 18650, 18847, 19036, 19212, 19378, 19534, 19680, 19819, 19955, 20087, 20222, 20366, 20526, 20714, 20945, 21242, 21631, 22153, 22847, 23756, 24900, 26236, 27670, 29056, 30258, 31210, 31898, 32355, 32626, 32751, 32760, 32686, 32543, 32345, 32104, 31825, 31514, 31176, 30814, 30428, 30023, 29597, 29154, 28692, 28214, 27717, 27203, 26674, 26125, 25557, 24970, 24358, 23720, 23052, 22346, 21594, 20787, 19902, 18920, 17811, 16528, 15036, 13298, 11307, 9126, 6876, 4695, 2713, 972, -536, -1844, -2998, -4039, -4990, -5879, -6724, -7531, -8312, -9072, -9816, -10546, -11266, -11974, -12674, -13365, -14046, -14720, -15386, -16040, -16686, -17320, -17941, -18547, -19135, -19703, -20245, -20759, -21233, -21659, -22021, -22301, -22473, -22499, -22339, -21948, -21303, -20412, -19356, -18275, -17305, -16544, -16020, -15710, -15574, -15568, -15655, -15808, -16004, -16233, -16476, -16730, -16989, -17246, -17500, -17748, -17988, -18219, -18440, -18650, -18848, -19036, -19213, -19379, -19534, -19680, -19820, -19955, -20087, -20222, -20367, -20527, -20715, -20946, -21242, -21632, -22153, -22847, -23757, -24900, -26236, -27670, -29056, -30258, -31210, -31898, -32355, -32626, -32751, -32760, -32686, -32543, -32345, -32104, -31825, -31514, -31176, -30814, -30428, -30023, -29597, -29154, -28693, -28214, -27717, -27203, -26674, -26125, -25557, -24970, -24358, -23720, -23053, -22347, -21594, -20788, -19903, -18920, -17811, -16529, -15037, -13298, -11308, -9127, -6877, -4699, -2719, -955};