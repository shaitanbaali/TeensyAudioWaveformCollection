/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1300 256 samples */
 
const int16_t AKWF_1300_256_DATA [256] = 
{3814, 7550, 7571, 8262, 8913, 10429, 12239, 13995, 15763, 17531, 19291, 21151, 22332, 27401, 30641, 29037, 28190, 27215, 26241, 25270, 24296, 23322, 22238, 21846, 18309, 3085, 2620, 3759, 4461, 5252, 6038, 6826, 7614, 8399, 9185, 9971, 10755, 11539, 12323, 13103, 13884, 14665, 15442, 16221, 16998, 17773, 18548, 19322, 20092, 20969, 21138, 24955, 29619, 28326, 27862, 27267, 26672, 26081, 25490, 24899, 24310, 23720, 23149, 22487, 21513, 20526, 19547, 18565, 17587, 16610, 15634, 14596, 13994, 11395, 4929, 4447, 3659, 2913, 2166, 1434, 1244, 1270, 1262, 1262, 1259, 1259, 1259, 1259, 1258, 1258, 1259, 1258, 1259, 1260, 1259, 1260, 1262, 1261, 1262, 1265, 1266, 1266, 1268, 1269, 1271, 1272, 1273, 1273, 1272, 1276, 1278, 1277, 1278, 1272, 1309, 987, 288, -369, -1029, -1690, -2349, -3004, -3656, -4306, -4953, -5599, -6241, -6879, -7516, -8150, -8780, -9409, -10033, -10656, -11276, -11893, -12508, -13273, -13069, -18334, -24127, -24161, -25152, -25991, -26824, -27656, -28482, -29303, -30141, -30182, -29688, -28827, -27921, -27029, -26136, -25245, -24352, -23457, -22725, -14981, -12775, -12604, -11983, -11433, -10886, -10344, -9802, -9266, -8734, -8205, -7679, -7157, -6638, -6124, -5613, -5224, -4083, -6091, -22238, -20639, -17643, -18814, -19472, -20198, -20920, -21639, -22356, -23068, -23779, -24485, -25189, -25887, -26585, -27278, -27968, -28656, -29339, -30018, -30695, -31364, -32041, -32668, -32687, -32546, -32433, -32312, -32185, -32056, -31921, -31784, -31559, -31489, -32019, -5357, 3857, 2269, 3009, 3376, 3738, 4098, 4454, 4807, 5155, 5500, 5842, 6180, 6513, 6841, 7169, 7491, 7809, 8125, 8437, 8744, 9048, 9346, 9645, 9933, 10019, 11975, -278, -8822, -6376, -6163, -5616, -5093, -4578, -4067, -3565, -3072, -2584, -2105, -1632, -1166, -708, -249};