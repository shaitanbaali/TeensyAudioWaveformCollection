/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1276 256 samples */
 
const int16_t AKWF_1276_256_DATA [256] = 
{16456, 16535, 16608, 16681, 16752, 16937, 17293, 17724, 18186, 18417, 20199, 14043, -4721, -3975, -3509, -3119, -2698, -2293, -1902, -1526, -1089, -1052, 300, 22327, 25247, 24871, 25283, 25555, 25814, 26062, 26297, 26520, 26524, 27787, 22968, -19, -2372, -2784, -3076, -3104, -3018, -2863, -2668, -2098, -3799, 5318, 24122, 22602, 23082, 23062, 25757, 29827, 31541, 32304, 32656, 32766, 32717, 32559, 32325, 32042, 31733, 31406, 31075, 30745, 30422, 30107, 29800, 29501, 29212, 28932, 28657, 28386, 28122, 27858, 27596, 27335, 27031, 26714, 27086, 7775, 202, 1501, 938, 668, 396, 122, -152, -429, -708, -986, -1266, -1547, -1828, -2109, -2389, -2669, -2957, -3281, -3251, -8348, -14758, -17414, -18777, -19549, -19984, -20200, -20271, -20251, -20179, -20080, -19978, -19884, -19809, -19755, -19726, -19723, -19744, -19787, -19849, -19929, -20023, -20128, -20242, -20362, -20487, -20615, -20743, -20870, -20995, -21117, -21235, -21350, -21458, -21561, -21658, -21749, -21833, -21912, -21983, -22048, -22106, -22158, -22202, -22241, -22274, -22299, -22318, -22331, -22338, -22338, -22333, -22322, -22305, -22283, -22255, -22167, -22385, -20703, -16282, -14164, -13252, -12779, -12547, -12466, -12481, -12556, -12664, -12786, -12907, -13019, -13115, -13191, -13246, -13278, -13288, -13277, -13248, -13200, -13137, -13084, -12901, -13175, -15990, -17863, -18474, -18703, -18726, -18623, -18437, -18194, -17921, -17630, -17331, -17033, -16742, -16460, -16192, -15936, -15692, -15461, -15242, -15034, -14835, -14644, -14462, -14286, -14115, -13949, -13787, -13629, -13473, -13321, -13171, -13022, -12873, -12728, -12584, -12443, -12301, -12161, -12021, -11883, -11748, -11613, -11479, -11347, -11216, -11087, -10959, -10833, -10707, -10583, -10463, -10342, -10224, -10108, -9993, -9879, -9768, -9658, -9551, -9445, -9341, -9239, -9139, -9038, -8949, -9002, -9144, -9220, -9175, -9018, -8785, -8533, -8312, -8165};