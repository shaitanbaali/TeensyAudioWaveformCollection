/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1267 256 samples */
 
const int16_t AKWF_1267_256_DATA [256] = 
{152, 436, 719, 1006, 1297, 1593, 1894, 2205, 2527, 2860, 3206, 3564, 3932, 4307, 4688, 5076, 5468, 5866, 6272, 6686, 7109, 7538, 7977, 8422, 8868, 9317, 9768, 10221, 10676, 11134, 11595, 12059, 12528, 12997, 13471, 13945, 14419, 14894, 15369, 15842, 16319, 16799, 17279, 17763, 18250, 18737, 19226, 19715, 20203, 20684, 21061, 22010, 16760, 139, -18081, -29150, -29726, -22553, -13635, -8167, -7864, -10986, -14503, -16530, -17404, -18871, -22300, -27272, -31586, -32671, -29312, -22600, -15408, -10848, -10581, -14008, -18764, -22060, -22116, -18831, -13542, -8067, -3818, -1297, -211, 11, -180, -596, -1153, -1637, -1645, -790, 1018, 3381, 5492, 6505, 5941, 3953, 1255, -1200, -2647, -2812, -1944, -633, 490, 1006, 808, 48, -985, -1986, -2705, -2961, -2658, -1798, -506, 969, 2320, 3265, 3660, 3576, 3256, 3027, 3171, 3800, 4835, 6048, 7150, 7907, 8211, 8087, 7668, 7131, 6648, 6334, 6236, 6328, 6521, 6686, 6699, 6473, 5989, 5309, 4554, 3871, 3386, 3151, 3144, 3273, 3420, 3478, 3390, 3161, 2848, 2537, 2312, 2231, 2305, 2509, 2780, 3044, 3231, 3299, 3240, 3082, 2878, 2687, 2556, 2504, 2513, 2541, 2533, 2443, 2244, 1942, 1567, 1165, 780, 447, 177, -39, -228, -422, -647, -919, -1231, -1567, -1896, -2189, -2422, -2590, -2700, -2772, -2836, -2910, -3010, -3138, -3276, -3411, -3522, -3598, -3636, -3647, -3644, -3649, -3675, -3729, -3813, -3916, -4028, -4131, -4218, -4285, -4336, -4380, -4429, -4490, -4569, -4660, -4759, -4851, -4928, -4981, -5010, -5014, -5001, -4980, -4953, -4926, -4897, -4862, -4813, -4745, -4654, -4539, -4402, -4252, -4094, -3932, -3768, -3606, -3440, -3266, -3083, -2887, -2678, -2458, -2233, -2003, -1775, -1548, -1322, -1096, -865, -624, -377, -112};