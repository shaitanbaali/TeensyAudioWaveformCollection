/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1211 256 samples */
 
const int16_t AKWF_1211_256_DATA [256] = 
{2156, 6244, 9899, 13202, 16121, 18643, 20761, 22466, 23772, 24681, 25208, 25373, 25193, 24699, 23915, 22871, 21603, 20136, 18505, 16746, 14886, 12958, 10999, 9024, 7071, 5161, 3313, 1556, -102, -1640, -3047, -4313, -5432, -6400, -7211, -7868, -8371, -8724, -8932, -9006, -8950, -8772, -8489, -8107, -7641, -7103, -6501, -5849, -5164, -4452, -3729, -3001, -2279, -1575, -896, -250, 358, 920, 1436, 1900, 2306, 2654, 2946, 3181, 3360, 3481, 3548, 3563, 3532, 3459, 3345, 3192, 3007, 2799, 2568, 2317, 2055, 1782, 1505, 1228, 955, 688, 427, 184, -45, -259, -454, -629, -785, -916, -1027, -1116, -1181, -1232, -1258, -1265, -1255, -1229, -1185, -1132, -1067, -991, -904, -813, -718, -618, -516, -416, -317, -214, -100, -19, 62, 138, 207, 267, 322, 364, 403, 430, 451, 464, 468, 466, 459, 443, 423, 397, 369, 340, 305, 267, 228, 188, 148, 108, 68, 30, -9, -41, -75, -105, -131, -158, -182, -200, -215, -228, -237, -246, -252, -252, -254, -250, -246, -241, -232, -225, -216, -205, -196, -184, -174, -162, -152, -142, -131, -123, -114, -109, -103, -99, -97, -94, -93, -93, -95, -101, -103, -109, -116, -124, -131, -139, -151, -161, -173, -187, -198, -210, -223, -237, -253, -268, -282, -298, -313, -329, -343, -359, -376, -391, -408, -425, -444, -462, -482, -501, -521, -544, -567, -592, -618, -646, -678, -711, -746, -786, -829, -874, -924, -980, -1039, -1110, -1185, -1269, -1366, -1472, -1592, -1731, -1888, -2064, -2276, -2521, -2810, -3151, -3565, -4071, -4704, -5499, -6513, -7840, -9630, -12047, -15356, -19790, -25176, -30414, -32748, -30749, -26269, -21302, -16332, -11421, -6666, -2035};