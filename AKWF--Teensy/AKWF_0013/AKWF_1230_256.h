/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1230 256 samples */
 
const int16_t AKWF_1230_256_DATA [256] = 
{1246, 3565, 5744, 8022, 10401, 12815, 15203, 17500, 19662, 21637, 23374, 24842, 26014, 26885, 27488, 27846, 27978, 27882, 27537, 26927, 26033, 24842, 23348, 21536, 19405, 16951, 14199, 11314, 8506, 5891, 3407, 884, -1794, -4599, -7469, -10348, -13164, -15874, -18432, -20785, -22905, -24757, -26308, -27553, -28506, -29188, -29630, -29857, -29895, -29770, -29484, -29032, -28404, -27591, -26590, -25391, -23990, -22387, -20569, -18545, -16313, -13864, -11211, -8351, -5317, -2243, 742, 3518, 5971, 8125, 10142, 12203, 14379, 16616, 18849, 21034, 23118, 25045, 26784, 28292, 29533, 30486, 31153, 31558, 31728, 31687, 31443, 30979, 30278, 29327, 28109, 26617, 24841, 22771, 20409, 17749, 14815, 11769, 8806, 6057, 3493, 946, -1718, -4513, -7389, -10285, -13135, -15902, -18534, -20981, -23217, -25204, -26912, -28325, -29431, -30248, -30808, -31135, -31255, -31196, -30980, -30620, -30105, -29430, -28585, -27562, -26358, -24967, -23380, -21599, -19622, -17442, -15067, -12491, -9712, -6750, -3655, -558, 2398, 5112, 7496, 9579, 11549, 13582, 15719, 17916, 20114, 22254, 24301, 26198, 27905, 29389, 30616, 31557, 32215, 32607, 32762, 32708, 32456, 31999, 31315, 30394, 29218, 27777, 26066, 24072, 21790, 19225, 16368, 13307, 10237, 7329, 4653, 2109, -476, -3197, -6026, -8914, -11797, -14617, -17338, -19906, -22279, -24433, -26328, -27940, -29255, -30265, -30994, -31474, -31726, -31780, -31661, -31392, -30923, -30139, -28977, -27394, -25421, -23262, -21132, -19007, -16682, -14133, -11473, -8814, -6233, -3821, -1657, 241, 1875, 3252, 4365, 5172, 5636, 5730, 5427, 4712, 3564, 2005, 194, -1634, -3390, -5215, -7267, -9531, -11930, -14386, -16818, -19167, -21373, -23374, -25133, -26610, -27789, -28692, -29341, -29755, -29963, -29984, -29815, -29445, -28863, -28062, -27029, -25763, -24259, -22509, -20517, -18283, -15800, -13080, -10143, -7091, -4087, -1222};