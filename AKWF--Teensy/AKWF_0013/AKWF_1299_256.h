/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1299 256 samples */
 
const int16_t AKWF_1299_256_DATA [256] = 
{2673, 3833, 4933, 5998, 7019, 8005, 8971, 9916, 10849, 11773, 12680, 13570, 14442, 15284, 16099, 16883, 17628, 18336, 19003, 19625, 20201, 20729, 21210, 21642, 22023, 22355, 22638, 22870, 23056, 23188, 22887, 22772, 22739, 22537, 22259, 21923, 21534, 21092, 20598, 20058, 19482, 18819, 18192, 22734, 23031, 22155, 21495, 20751, 19968, 19142, 18279, 17374, 16451, 15622, 14804, 13733, 12545, 11393, 10253, 9136, 8039, 6961, 5905, 4871, 3856, 2765, 2357, -2483, -6111, -6292, -7089, -7751, -8379, -8976, -9536, -10063, -10554, -11011, -11433, -11822, -12174, -12493, -12779, -13034, -13256, -13446, -13607, -13741, -13844, -13919, -13967, -13991, -13899, -14368, -9271, -6732, -6945, -6566, -6253, -5923, -5573, -5206, -4822, -4421, -4007, -3555, -3292, -3234, -3138, -3034, -2919, -2790, -2652, -2501, -2458, -1662, -5305, -8516, -7477, -7213, -6583, -5234, -3864, -2426, -1451, -633, 495, 1681, 2853, 3993, 5096, 6161, 7184, 8170, 9134, 10080, 11014, 11937, 12844, 13734, 14604, 15447, 16263, 17045, 17791, 18500, 19166, 19786, 20364, 20893, 21371, 21804, 22187, 22517, 22798, 23029, 23216, 23347, 23046, 22929, 22896, 22694, 22415, 22077, 21686, 21243, 20748, 20206, 19617, 18982, 18303, 17575, 16800, 15982, 15117, 14210, 13261, 12270, 11241, 10169, 9033, 8353, 684, -2479, -3296, -4604, -5822, -7018, -8192, -9348, -10480, -11585, -12706, -13538, -14024, -14515, -14971, -15398, -15794, -16081, -16839, -15259, -9215, -10053, -10498, -10953, -11377, -11765, -12120, -12441, -12731, -12987, -13212, -13406, -13571, -13706, -13815, -13894, -14248, -12660, -21203, -33076, -31606, -32088, -32240, -32371, -32482, -32575, -32647, -32703, -32741, -32763, -32768, -32759, -32735, -32697, -32645, -32580, -32504, -32414, -32313, -32201, -32071, -31971, -31630, -30740, -29837, -28963, -27840, -25996, -24133, -22201, -20733, -19421, -17802, -16091};