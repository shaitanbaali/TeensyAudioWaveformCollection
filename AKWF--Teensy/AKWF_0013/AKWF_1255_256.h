/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1255 256 samples */
 
const int16_t AKWF_1255_256_DATA [256] = 
{1193, 2883, 4479, 6024, 7517, 8958, 10351, 11691, 12987, 14238, 15437, 16595, 17704, 18760, 19765, 20705, 21568, 22335, 22969, 23419, 23605, 23403, 22629, 21355, 19991, 18681, 17411, 16184, 14998, 13850, 12744, 11675, 10639, 9641, 8678, 7743, 6844, 5974, 5132, 4323, 3538, 2781, 2051, 1346, 665, 8, -628, -1241, -1833, -2406, -2958, -3489, -4006, -4503, -4981, -5445, -5891, -6323, -6739, -7141, -7528, -7904, -8264, -8613, -8949, -9274, -9587, -9890, -10182, -10463, -10901, -11627, -12540, -13557, -14628, -15721, -16813, -17890, -18949, -19980, -20980, -21953, -22896, -23805, -24686, -25538, -26360, -27155, -27922, -28664, -29380, -30072, -30739, -31375, -32029, -32368, -31588, -30139, -28339, -26306, -24167, -21854, -20589, -21215, -21800, -21824, -20913, -19206, -17164, -15023, -12870, -10754, -8700, -6705, -4776, -2915, -1114, 625, 2302, 3922, 5487, 6995, 8453, 9858, 11210, 12516, 13769, 14971, 16123, 17217, 18250, 19215, 20095, 20874, 21524, 21998, 22237, 22156, 21616, 20558, 19260, 17994, 16767, 15582, 14437, 13330, 12261, 11228, 10229, 9263, 8334, 7433, 6564, 5726, 4914, 4132, 3376, 2644, 1940, 1259, 602, -33, -645, -1239, -1809, -2360, -2894, -3408, -3903, -4383, -4845, -5291, -5724, -6140, -6541, -6929, -7302, -7664, -8012, -8347, -8673, -8986, -9286, -9579, -9861, -10131, -10392, -10645, -10888, -11124, -11349, -11568, -11779, -11983, -12179, -12369, -12550, -12727, -12896, -13059, -13218, -13369, -13515, -13657, -13793, -13924, -14050, -14173, -14291, -14399, -14560, -14922, -15479, -16168, -16949, -17793, -18673, -19573, -20483, -21390, -22286, -23171, -24035, -24880, -25704, -26505, -27281, -28035, -28765, -29472, -30156, -30817, -31454, -32069, -32672, -32448, -31132, -29362, -27248, -25293, -25194, -25662, -25587, -24708, -23036, -20975, -18771, -16527, -14309, -12146, -10038, -7999, -6028, -4121, -2286, -479};