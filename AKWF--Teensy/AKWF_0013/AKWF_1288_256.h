/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1288 256 samples */
 
const int16_t AKWF_1288_256_DATA [256] = 
{7350, 8347, 9322, 10296, 11267, 12235, 13198, 14155, 15104, 16045, 16965, 17862, 18729, 19567, 20379, 21163, 21918, 22647, 23349, 24023, 24669, 25288, 25881, 26445, 26980, 27486, 27965, 28418, 28847, 29252, 29633, 29990, 30326, 30641, 30933, 31203, 31452, 31678, 31885, 32069, 32229, 32368, 32482, 32576, 32651, 32707, 32745, 32765, 32767, 32752, 32721, 32647, 32764, 31840, 31826, 32482, 32200, 32094, 31951, 31798, 31633, 31458, 31272, 31077, 30873, 30662, 30442, 30213, 29978, 29736, 29488, 29234, 28834, 29370, 18219, 14004, 14237, 19296, 20917, 20206, 19989, 19694, 19394, 19094, 18790, 18483, 18174, 17864, 17555, 17245, 16931, 16615, 16295, 15971, 15640, 15304, 14962, 14614, 14258, 13896, 13526, 13150, 12766, 12374, 11976, 11571, 11160, 10740, 10309, 9965, 8984, 12217, 15619, 14640, 14218, 13696, 13155, 12596, 12023, 11444, 10866, 10289, 9712, 9134, 8559, 7981, 7405, 6830, 6254, 5679, 5104, 4528, 3955, 3379, 2803, 2229, 1654, 1081, 516, -30, -558, -1069, -1566, -2295, -1440, -9814, -17988, -17098, -17763, -18172, -18570, -18963, -19349, -19728, -20102, -20468, -20827, -21179, -21525, -21864, -22197, -22523, -22844, -23159, -23344, -24435, -21232, -15535, -18371, -18279, -17994, -22062, -26413, -25822, -27472, -17850, -13390, -22726, -20655, -21157, -21387, -21655, -21917, -22175, -22431, -22679, -22922, -23159, -23390, -23613, -23829, -24037, -24237, -24428, -24611, -24783, -24945, -25096, -25236, -25364, -25479, -25582, -25671, -25760, -25771, -25826, -32369, -28494, -25376, -25974, -25830, -25772, -25697, -25601, -25486, -25347, -25187, -25001, -24795, -24566, -24316, -24044, -23749, -23433, -23094, -22733, -22349, -21941, -21510, -21053, -20571, -20062, -19525, -18958, -18362, -17739, -17087, -16409, -15702, -14967, -14207, -13416, -12596, -11753, -10878, -9974, -9048, -8106, -7157, -6202, -5238, -4269, -3299, -2325, -1350, -354};