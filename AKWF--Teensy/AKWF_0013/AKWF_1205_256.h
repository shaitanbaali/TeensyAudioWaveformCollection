/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1205 256 samples */
 
const int16_t AKWF_1205_256_DATA [256] = 
{850, 2599, 4313, 6032, 7598, 10127, 6000, 3662, 6161, 7737, 9453, 11173, 12894, 14610, 16330, 18050, 19763, 21354, 23736, 17428, -5214, -5934, -3561, -1981, -262, 1454, 3175, 4894, 6610, 8332, 10050, 11767, 13489, 15206, 16924, 18646, 20363, 22081, 23802, 25087, 29140, 13448, 3590, 8039, 7155, 1732, 3831, 5493, 7205, 8926, 10646, 12363, 14084, 15802, 17519, 19096, 21594, 19256, 15129, 17658, 18898, 22441, 15622, -2273, 1252, 2646, 4364, 5584, 9837, -2522, -24294, -23885, -21900, -20323, -18608, -16888, -15167, -13450, -11730, -10010, -8294, -6574, -4854, -3138, -1418, 301, 2017, 3739, 5458, 7175, 8895, 10614, 12331, 14016, 15907, 16991, 11098, 12182, 14073, 15759, 17475, 19194, 20915, 22200, 26254, 10560, 701, 5152, 4267, -1153, 946, 2606, 4319, 6039, 7759, 9475, 11196, 12916, 14632, 16209, 18707, 16370, 12243, 14772, 16011, 19553, 12735, -5159, -1633, -240, 1476, 2696, 7100, -6069, -21994, -17531, -16326, -14604, -12887, -11168, -9447, -7731, -6011, -4291, -2578, -987, 1394, -4913, -27555, -28276, -25902, -24322, -22603, -20887, -19166, -17446, -15729, -14044, -12154, -11070, -16963, -15879, -13988, -12302, -10585, -8867, -7145, -5429, -3710, -1989, -362, 1852, 1381, -4041, -1940, -280, 1432, 3152, 4872, 6589, 8308, 10029, 11745, 13467, 15185, 16901, 18623, 20341, 21731, 25274, 18455, 559, 4085, 5478, 7197, 8417, 12671, 311, -21462, -21052, -19067, -17491, -15774, -14054, -12333, -10618, -8898, -7178, -5465, -3873, -1493, -7801, -30442, -31163, -28789, -27209, -25489, -23773, -22052, -20333, -18617, -16932, -15042, -13956, -19850, -18766, -16875, -15189, -13472, -11754, -10033, -8748, -4695, -20387, -30158, -26203, -24894, -23178, -21458, -19738, -18022, -16301, -14581, -12866, -11145, -9425, -7709, -6131, -3634, -5972, -10098, -7569, -6003, -4285, -2571, -823};