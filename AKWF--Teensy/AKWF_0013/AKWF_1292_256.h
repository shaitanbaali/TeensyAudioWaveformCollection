/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1292 256 samples */
 
const int16_t AKWF_1292_256_DATA [256] = 
{968, 4026, 6814, 9448, 11928, 14272, 16456, 16890, 16472, 16181, 15874, 15572, 15276, 14986, 14701, 14421, 14147, 13878, 13614, 13355, 13101, 12852, 12608, 12368, 12133, 11902, 11675, 11453, 11236, 11022, 10813, 10607, 10405, 10208, 10013, 9823, 9637, 9453, 9273, 9097, 8924, 8754, 8588, 8424, 8264, 8107, 7953, 7802, 7653, 7508, 7365, 7225, 7088, 6952, 6821, 6691, 6564, 6439, 6316, 6196, 6079, 5963, 5849, 5738, 5629, 5522, 5417, 5314, 5213, 5114, 5016, 4921, 4827, 4736, 4645, 4557, 4471, 4378, 4321, 4134, 3023, 1221, -1388, -4857, -11878, 2349, 4944, 4205, 4187, 4108, 4029, 3953, 3878, 3804, 3732, 3660, 3591, 3522, 3456, 3390, 3325, 3262, 3200, 3139, 3079, 3021, 2964, 2907, 2851, 2797, 2744, 2692, 2641, 2591, 2541, 2493, 2446, 2399, 2354, 2309, 2265, 2222, 2179, 2138, 2097, 2057, 2018, 1980, 1942, 1905, 1869, 1834, 1799, 1764, 1731, 1698, 1666, 1634, 1603, 1572, 1543, 1513, 1484, 1456, 1428, 1401, 1374, 1348, 1323, 1298, 1273, 1249, 1225, 1202, 1179, 1156, 1135, 1113, 1092, 1071, 1050, 1031, 1011, 992, 973, 954, 936, 918, 901, 884, 866, 850, 834, 818, 802, 787, 772, 758, 743, 729, 715, 701, 688, 676, 662, 649, 637, 626, 614, 601, 590, 579, 568, 557, 546, 536, 526, 516, 506, 496, 487, 477, 469, 459, 450, 442, 433, 426, 418, 410, 401, -114, 2662, -21759, -34388, -31067, -30962, -30374, -29796, -29229, -28674, -28128, -27594, -27069, -26554, -26049, -25555, -25068, -24592, -24124, -23665, -23216, -22774, -22341, -21916, -21500, -21090, -20690, -20296, -19910, -19532, -19160, -18796, -18439, -18088, -17743, -17407, -17075, -16751, -16429, -16089, -15914, -13367, -9226, -5610, -2134};