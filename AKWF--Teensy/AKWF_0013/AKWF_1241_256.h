/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1241 256 samples */
 
const int16_t AKWF_1241_256_DATA [256] = 
{3527, 8106, 11268, 13587, 15322, 16641, 17675, 18511, 19210, 19815, 20356, 20851, 21315, 21756, 22181, 22600, 23008, 23412, 23814, 24209, 24605, 24985, 25410, 25665, 22720, 18561, 14519, 10996, 4463, 1347, 3243, 3313, 3749, 4150, 4550, 4951, 5348, 5747, 6148, 6548, 6948, 6920, 9585, -2028, -29202, -28547, -29059, -29510, -29910, -30310, -30709, -31106, -31503, -31792, -32301, -32886, 1617, 16021, 13673, 14606, 15000, 15403, 15802, 16201, 16601, 17001, 17400, 17799, 18194, 18593, 18989, 19386, 19783, 20178, 20572, 20968, 21363, 21757, 22151, 22544, 22938, 23332, 23725, 24118, 24510, 24885, 25310, 25563, 22617, 18431, 14229, 11720, 211, -17631, -10545, -6678, -3999, -2141, -887, -44, 620, -718, -3743, -6766, -9928, -13140, -16370, -19594, -23079, -23719, -21294, -19141, -16930, -14710, -12488, -10268, -8048, -5833, -3612, -1404, 897, 1940, 1707, 2423, -851, -15172, -11069, -6566, -3961, -2098, -833, 33, 621, 1021, 1293, 1478, 1604, 1689, 1748, 1788, 1813, 1830, 1843, 1850, 1856, 1859, 1861, 1862, 1862, 1862, 1862, 1861, 1861, 1859, 1858, 1857, 1856, 1856, 1855, 1853, 1852, 1851, 1851, 1850, 1849, 1848, 1847, 1847, 1846, 1569, 3039, -4754, -22280, -21567, -21645, -21676, -21674, -21672, -21669, -21666, -21663, -21605, -21665, -21739, -4109, 3011, 1614, 1888, 1887, 1889, 1892, 1894, 1897, 1898, 1899, 1900, 1903, 1905, 1905, 1907, 1908, 1910, 1911, 1912, 1913, 1914, 1915, 1915, 1916, 1918, 1919, 1920, 1920, 1921, 1922, 1923, 1925, 1926, 1740, 2771, -2305, -16464, -10818, -6166, -2981, -576, 1241, 2635, 3733, 4623, 5366, 6004, 6574, 7092, 7574, 8033, 8472, 8900, 9319, 9733, 10143, 10548, 10951, 11354, 11755, 12156, 12555, 12953, 13352, 13750, 13864, 15732, 9174, -21127, -12358, -2451};