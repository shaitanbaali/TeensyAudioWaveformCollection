/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1284 256 samples */
 
const int16_t AKWF_1284_256_DATA [256] = 
{175, 677, 1165, 1648, 2126, 2601, 3070, 3532, 3990, 4442, 4886, 5325, 5757, 6183, 6601, 7013, 7416, 7813, 8202, 8584, 8957, 9324, 9680, 10030, 10371, 10702, 11025, 11340, 11645, 11942, 12229, 12508, 12776, 13036, 13285, 13526, 13757, 13978, 14190, 14391, 14583, 14765, 14937, 15099, 15251, 15393, 15525, 15647, 15760, 15862, 15954, 16037, 16110, 16173, 16225, 16268, 16301, 16325, 16339, 16344, 16339, 16326, 16301, 16269, 16227, 16177, 16118, 16048, 15972, 15886, 15793, 15690, 15580, 15462, 15335, 15202, 15061, 14912, 14756, 14593, 14423, 14248, 14065, 13876, 13680, 13479, 13273, 13060, 12842, 12620, 12392, 12160, 11924, 11683, 11438, 11189, 10937, 10682, 10423, 10161, 9897, 9632, 9363, 9093, 8821, 8547, 8273, 7997, 7720, 7444, 7168, 6890, 6615, 6339, 6063, 5789, 5515, 5244, 4974, 4707, 4442, 4179, 3918, 3662, 3408, 3157, 2910, 2667, 2427, 2193, 1963, 1737, 1517, 1301, 1091, 887, 688, 496, 309, 129, -44, -210, -371, -524, -669, -807, -938, -1060, -1176, -1284, -1382, -1472, -1554, -1627, -1692, -1748, -1795, -1833, -1862, -1882, -1892, -1893, -1884, -1866, -1839, -1801, -1753, -1697, -1630, -1554, -1467, -1370, -1264, -1147, -1021, -885, -738, -582, -416, -257, -260, 1209, -26260, -34028, -31983, -32071, -31827, -31573, -31310, -31037, -30755, -30464, -30164, -29855, -29537, -29209, -28874, -28530, -28177, -27817, -27448, -27070, -26686, -26294, -25894, -25487, -25072, -24651, -24223, -23788, -23347, -22899, -22446, -21986, -21521, -21050, -20574, -20093, -19606, -19116, -18622, -18121, -17618, -17112, -16600, -16087, -15570, -15049, -14527, -14002, -13475, -12947, -12416, -11882, -11351, -10817, -10281, -9747, -9211, -8675, -8141, -7606, -7072, -6540, -6008, -5478, -4950, -4424, -3900, -3379, -2859, -2344, -1832, -1322, -818, -309};