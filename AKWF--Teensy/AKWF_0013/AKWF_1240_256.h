/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1240 256 samples */
 
const int16_t AKWF_1240_256_DATA [256] = 
{207, 733, 1190, 1588, 1927, 2218, 2436, 2603, 7440, 6500, 5566, 4972, 4391, 3864, 3392, 2977, 2620, 2321, 2079, 1893, 1761, 1685, 1662, 1692, 1770, 1895, 2065, 2278, 2530, 2819, 3140, 3490, 3868, 4266, 4683, 5117, 5559, 6010, 6465, 6918, 7369, 7813, 8243, 8662, 9061, 9440, 9797, 10127, 10429, 10703, 10945, 11156, 11337, 11484, 11601, 11689, 11747, 11779, 11787, 11776, 11748, 11708, 11658, 11605, 11555, 11511, 11481, 11467, 11477, 11516, 11373, 12630, 7908, -2841, -1711, -2051, -2236, -2484, -2790, -3145, -3542, -3973, -4433, -4908, -5402, -5903, -6403, -6895, -7377, -7841, -8281, -8692, -9066, -9401, -9695, -9941, -10141, -10286, -10376, -10413, -10394, -10292, -10625, -8153, -5186, -28254, -26361, -26486, -26184, -25811, -25363, -24839, -24247, -23583, -22855, -22069, -21219, -20322, -19379, -18391, -17370, -16320, -15237, -14135, -13016, -11881, -10746, -9603, -8459, -7322, -6194, -5081, -3988, -2912, -1859, -838, 150, 1109, 2028, 2907, 3748, 4538, 5286, 5988, 6640, 7243, 7795, 8291, 8740, 9135, 9475, 9764, 9996, 10176, 10303, 10377, 10399, 10370, 10291, 10165, 9993, 9779, 9523, 9228, 8899, 8538, 8149, 7734, 7298, 6845, 6377, 5901, 5416, 4930, 4444, 3962, 3486, 3020, 2565, 2123, 1697, 1286, 894, 517, 156, -189, -520, -839, -1146, -1449, -1744, -2039, -2336, -2638, -2949, -3273, -3613, -3981, -4146, -5711, -3879, 6181, 3580, 2388, 1038, -240, -1446, -2579, -3643, -4633, -5547, -6380, -7131, -7807, -8401, -8915, -9348, -9700, -9971, -10168, -10291, -10338, -10313, -10219, -10059, -9840, -9563, -9230, -8847, -8395, -8305, -5880, -3054, -21743, -19411, -18868, -17968, -17034, -16060, -15056, -14033, -12985, -11929, -10873, -9824, -8782, -7757, -6753, -5780, -4843, -3948, -3094, -2292, -1542, -848, -207};