/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1232 256 samples */
 
const int16_t AKWF_1232_256_DATA [256] = 
{2154, 1203, 1346, 1892, 2899, 2791, 3951, 4385, 4327, 4391, 4331, 4816, 6003, 5987, 6046, 6022, 6364, 7681, 7755, 7793, 7848, 7903, 7943, 8016, 9392, 9785, 9768, 9844, 9904, 9982, 9954, 10434, 11858, 11910, 11977, 12051, 12122, 12193, 12264, 12335, 12406, 12477, 12573, 12504, 13404, 14700, 14639, 14746, 14827, 14908, 14989, 15069, 15150, 15232, 15312, 15394, 15475, 15555, 15637, 15724, 15769, 15808, 18246, 2101, 392, 1620, 1305, 1891, 2898, 2791, 3951, 4385, 4327, 4391, 4331, 4816, 6003, 5987, 6047, 6023, 6363, 7681, 7756, 7793, 7848, 7903, 7942, 8021, 9393, 9785, 9768, 9843, 9904, 9982, 9954, 10434, 11858, 11910, 11977, 12051, 12122, 12193, 12264, 12335, 12406, 12477, 12573, 12504, 13404, 14700, 14639, 14746, 14827, 14908, 14989, 15069, 15150, 15232, 15312, 15394, 15475, 15555, 15637, 15724, 15785, 15924, 17657, 18119, 18122, 18230, 18321, 18412, 18502, 18594, 18686, 18776, 18868, 18959, 19050, 19141, 19233, 19324, 19415, 19506, 19597, 19688, 19779, 19870, 19961, 20053, 20144, 20235, 20356, 20287, 21232, 23006, 22966, 23091, 23193, 23294, 23395, 23497, 23598, 23699, 23800, 23901, 24003, 24104, 24206, 24307, 24408, 24510, 24611, 24712, 24813, 24914, 25016, 25117, 25219, 25320, 25421, 25522, 25623, 25710, 25736, 26131, 17779, 4668, -12483, -16981, -19593, -22985, -24186, -26350, -26777, -27843, -29854, -29831, -29967, -30079, -30190, -30302, -30413, -30524, -30637, -30748, -30860, -30971, -31081, -31194, -31305, -31416, -31528, -31639, -31751, -31862, -31973, -32084, -32195, -32307, -32417, -32499, -32785, -30909, -29679, -30024, -30079, -30182, -30283, -30384, -30486, -30587, -30688, -30790, -30890, -30991, -31093, -31194, -31296, -31397, -31497, -31600, -31701, -31802, -31904, -32005, -32106, -32207, -32308, -32410, -32480, -32746, -32060, -29170, -31137, -17603};