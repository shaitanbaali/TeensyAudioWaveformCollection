/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1237 256 samples */
 
const int16_t AKWF_1237_256_DATA [256] = 
{2967, 8963, 10495, 8502, 6606, 5491, 4186, 1874, 254, 1040, 4021, 7433, 9311, 9343, 8696, 7836, 7032, 6583, 6713, 7731, 9774, 11019, 10387, 10230, 8955, 7137, 5928, 4803, 4021, 3907, 3958, 4231, 4808, 5442, 6238, 7145, 7634, 9374, 10891, 11824, 13013, 13258, 13468, 13321, 11836, 16661, 24566, 23123, 15105, 6711, 1706, -676, -1237, -1048, -15187, -31207, -30896, -24675, -21090, -20946, -14785, -8579, -15608, -22069, -13617, -2328, -4135, -9848, -12765, -10747, -12611, -19976, -19194, -15743, -17191, -14906, -12702, -2895, 6398, 4650, 1926, -316, -961, -1702, -3415, -2640, -4268, -8135, -8413, -5304, -1578, 1028, 2677, 3778, 1382, -1642, 1209, 4966, 5898, 4686, 3532, 2847, 2048, 613, -394, 100, 1928, 4484, 3853, 1491, 7374, 6338, 2735, -28, -823, -1743, -3843, -2887, -4877, -9595, -9924, -6131, -1597, 1575, 3565, 4891, 1983, -1679, 1770, 6301, 7404, 5937, 4539, 3712, 2742, 1020, -187, 402, 2675, 5025, 7519, 6259, 3307, 3405, 2910, 2695, 2778, 3327, 4413, 5080, 4768, 4709, 4050, 3101, 2472, 1880, 1473, 1420, 1457, 1614, 1937, 2294, 2739, 3251, 3534, 4507, 5363, 5900, 6582, 6741, 6880, 6820, 6005, 8750, 13251, 12464, 7928, 3178, 338, -1019, -1336, -1249, -9419, -18687, -18518, -14928, -12891, -12826, -9252, -5632, -9784, -13608, -8629, -1966, -3051, -6451, -8186, -6999, -8139, -12555, -12101, -10059, -10950, -9541, -8390, 179, 9417, 7671, 3506, 228, -713, -1798, -4276, -3141, -5494, -11058, -11424, -6937, -1606, 2112, 4443, 5996, 2568, -1725, 2327, 7618, 8896, 7180, 5540, 4572, 3440, 1430, 23, 716, 3250, 6772, 5892, 2647, 10719, 9253, 4300, 502, -592, -1849, -4709, -3399, -6111, -12524, -12939, -7768, -1632, 2641, 5317, 7086, 3117, -1618};