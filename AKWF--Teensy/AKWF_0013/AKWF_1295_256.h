/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1295 256 samples */
 
const int16_t AKWF_1295_256_DATA [256] = 
{28745, 28189, 27655, 27130, 26614, 26108, 25610, 25125, 24646, 24177, 23718, 23267, 22824, 22391, 21965, 21547, 21138, 20735, 20341, 19955, 19575, 19203, 18838, 18479, 18128, 17783, 17445, 17114, 16788, 16469, 16156, 15849, 15547, 15252, 14962, 14677, 14397, 14124, 13855, 13592, 13334, 13081, 12832, 12587, 12348, 12113, 11882, 11657, 11435, 11218, 11004, 10796, 10590, 10388, 10191, 9997, 9807, 9620, 9437, 9258, 9082, 8909, 8740, 8573, 8411, 8251, 8094, 7940, 7789, 7641, 7495, 7353, 7213, 7076, 6942, 6809, 6680, 6553, 6428, 6307, 6187, 6068, 5952, 5840, 5729, 5620, 5513, 5408, 5305, 5205, 5106, 5008, 4913, 4820, 4728, 4638, 4550, 4463, 4378, 4295, 4213, 4134, 4054, 3977, 3902, 3828, 3756, 3684, 3613, 3545, 3477, 3412, 3347, 3283, 3220, 3159, 3099, 3039, 2982, 2925, 2870, 2815, 2761, 2709, 2658, 2607, 2557, 2509, 2461, 2415, 2369, 2323, 2279, 2236, 2193, 2152, 2110, 2070, 2031, 1992, 1954, 1917, 1881, 1845, 1810, 1775, 1742, 1709, 1676, 1644, 1614, 1582, 1552, 1523, 1494, 1465, 1437, 1410, 1384, 1357, 1332, 1305, 1280, 1256, 1233, 1209, 1186, 1163, 1140, 1077, 1242, -529, -5150, -9566, -13901, -18171, -22334, -26398, -30620, -32766, -32068, -31474, -30883, -30295, -29719, -29155, -28599, -28056, -27523, -26999, -26486, -25983, -25488, -25004, -24529, -24062, -23604, -23156, -22715, -22283, -21860, -21444, -21037, -20636, -20244, -19859, -19481, -19111, -18748, -18391, -18041, -17699, -17362, -17032, -16708, -16390, -16079, -15773, -15473, -15179, -14891, -14607, -14329, -14057, -13790, -13528, -13270, -13018, -12771, -12528, -12289, -12056, -11827, -11602, -11382, -11165, -10952, -10745, -10540, -10340, -10143, -9950, -9760, -9576, -9393, -9214, -9040, -8867, -8699, -8534, -8371, -8212, -8056, -7902, -7753, -7603};