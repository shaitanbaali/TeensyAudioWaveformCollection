/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1268 256 samples */
 
const int16_t AKWF_1268_256_DATA [256] = 
{1142, 3416, 5604, 7753, 9838, 11855, 13792, 15631, 17370, 19002, 20511, 21899, 23156, 24273, 25256, 26095, 26787, 27336, 27740, 27999, 28115, 28092, 27933, 27643, 27230, 26697, 26048, 25297, 24448, 23508, 22491, 21403, 20250, 19047, 17802, 16520, 15216, 13898, 12572, 11251, 9940, 8645, 7381, 6147, 4953, 3807, 2706, 1661, 677, -248, -1109, -1903, -2636, -3300, -3897, -4431, -4901, -5308, -5659, -5953, -6193, -6386, -6535, -6642, -6715, -6757, -6771, -6766, -6741, -6704, -6660, -6613, -6564, -6520, -6484, -6456, -6442, -6441, -6459, -6495, -6550, -6622, -6716, -6828, -6958, -7105, -7266, -7441, -7628, -7820, -8019, -8221, -8423, -8620, -8807, -8985, -9147, -9292, -9415, -9515, -9587, -9628, -9638, -9613, -9551, -9452, -9313, -9135, -8916, -8661, -8363, -8028, -7657, -7252, -6811, -6342, -5845, -5323, -4781, -4220, -3646, -3066, -2476, -1888, -1301, -721, -155, 397, 930, 1441, 1926, 2381, 2806, 3195, 3550, 3864, 4142, 4380, 4579, 4738, 4857, 4939, 4985, 4998, 4978, 4930, 4858, 4764, 4651, 4525, 4389, 4246, 4105, 3969, 3840, 3725, 3627, 3551, 3503, 3482, 3497, 3548, 3636, 3767, 3939, 4156, 4419, 4725, 5077, 5471, 5904, 6377, 6887, 7428, 7997, 8590, 9200, 9823, 10454, 11081, 11704, 12312, 12900, 13457, 13980, 14458, 14887, 15257, 15561, 15794, 15949, 16018, 16000, 15885, 15671, 15356, 14936, 14408, 13769, 13024, 12169, 11204, 10139, 8967, 7697, 6335, 4883, 3347, 1743, 67, -1666, -3443, -5264, -7113, -8974, -10846, -12711, -14555, -16376, -18151, -19874, -21535, -23116, -24610, -26010, -27299, -28471, -29520, -30432, -31202, -31824, -32293, -32603, -32753, -32740, -32558, -32211, -31702, -31026, -30191, -29201, -28057, -26769, -25347, -23790, -22112, -20326, -18435, -16453, -14399, -12271, -10091, -7873, -5624, -3364, -1056};