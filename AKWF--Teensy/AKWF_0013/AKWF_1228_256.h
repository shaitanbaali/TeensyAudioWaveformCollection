/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1228 256 samples */
 
const int16_t AKWF_1228_256_DATA [256] = 
{973, 3503, 6040, 8608, 11171, 13709, 16196, 18595, 20884, 23026, 24971, 26687, 28128, 29250, 30032, 30452, 30510, 30220, 29617, 28746, 27658, 26416, 25081, 23700, 22323, 20980, 19685, 18453, 17282, 16160, 15081, 14034, 13012, 12017, 11049, 10110, 9206, 8333, 7478, 6628, 5747, 4796, 3736, 2513, 1093, -551, -2443, -4574, -6916, -9440, -12081, -14769, -17446, -20034, -22467, -24705, -26699, -28420, -29861, -31009, -31867, -32439, -32729, -32740, -32473, -31930, -31111, -30016, -28660, -27053, -25217, -23194, -21014, -18725, -16383, -14020, -11682, -9404, -7196, -5070, -3030, -1056, 861, 2735, 4591, 6435, 8267, 10098, 11913, 13696, 15440, 17114, 18699, 20180, 21536, 22756, 23836, 24767, 25553, 26194, 26688, 27037, 27236, 27274, 27142, 26824, 26304, 25563, 24588, 23371, 21902, 20187, 18244, 16084, 13743, 11267, 8691, 6074, 3477, 935, -1493, -3771, -5884, -7803, -9524, -11054, -12392, -13551, -14545, -15378, -16063, -16609, -17019, -17303, -17472, -17536, -17517, -17439, -17332, -17233, -17175, -17190, -17301, -17518, -17837, -18238, -18683, -19127, -19517, -19796, -19909, -19811, -19467, -18857, -17973, -16824, -15429, -13807, -11994, -10015, -7892, -5655, -3313, -873, 1642, 4227, 6864, 9506, 12121, 14650, 17020, 19178, 21057, 22599, 23780, 24579, 24999, 25070, 24833, 24342, 23656, 22836, 21938, 21003, 20068, 19153, 18263, 17404, 16568, 15747, 14941, 14145, 13360, 12595, 11854, 11144, 10473, 9835, 9222, 8620, 8005, 7351, 6631, 5818, 4891, 3840, 2654, 1340, -84, -1603, -3187, -4798, -6410, -7989, -9502, -10940, -12280, -13516, -14653, -15689, -16631, -17489, -18263, -18957, -19572, -20100, -20534, -20870, -21098, -21213, -21214, -21108, -20903, -20613, -20260, -19863, -19443, -19021, -18609, -18218, -17851, -17501, -17154, -16789, -16378, -15887, -15285, -14535, -13608, -12484, -11142, -9583, -7813, -5844, -3707, -1371};