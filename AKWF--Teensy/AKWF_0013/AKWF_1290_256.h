/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1290 256 samples */
 
const int16_t AKWF_1290_256_DATA [256] = 
{7200, 17104, 20623, 21739, 21127, 21188, 21139, 21049, 20982, 20883, 20795, 20701, 20592, 20480, 20377, 20263, 20130, 20007, 19895, 19761, 19639, 19521, 19391, 19255, 19134, 19010, 18867, 18740, 18618, 18478, 18341, 18221, 18088, 17944, 17819, 17688, 17545, 17417, 17293, 17150, 17016, 16891, 16767, 16625, 16538, 16433, 16321, 16219, 16126, 16017, 15909, 15817, 15718, 15608, 15513, 15421, 15313, 15215, 15128, 15028, 14922, 14832, 14742, 14638, 14542, 14458, 14358, 14248, 13062, 13553, 13343, 13733, 13853, 14061, 14242, 14444, 14637, 14821, 15022, 15217, 15401, 15601, 15802, 15986, 16178, 16378, 16569, 16755, 16957, 17154, 17336, 17533, 17733, 17918, 18106, 18306, 18500, 18678, 18870, 19069, 19249, 19438, 19637, 19824, 20003, 20200, 20394, 20569, 20759, 20953, 21126, 21311, 21486, 21921, 20726, -741, 4892, -1992, 1298, -5, 321, 165, 163, 123, 93, 93, 73, 49, -449, 2070, -12511, -16169, -22353, -20034, -21045, -20567, -20656, -20519, -20427, -20333, -20249, -20146, -20055, -19960, -19847, -19741, -19642, -19529, -19408, -19303, -19194, -19064, -18950, -18839, -18707, -18592, -18482, -18353, -18228, -18117, -17997, -17863, -17747, -17633, -17498, -17375, -17263, -17137, -17004, -16887, -16769, -16632, -16510, -16395, -16264, -16132, -16017, -15895, -15758, -15641, -15523, -15390, -15261, -15144, -15018, -14883, -14763, -14644, -14507, -14384, -14267, -14137, -14005, -13891, -13760, -13627, -13508, -13385, -13248, -13126, -13006, -12873, -12744, -12625, -12504, -12340, -12392, -12572, -12737, -12933, -13129, -13316, -13500, -13700, -13895, -14078, -14273, -14473, -14660, -14847, -15043, -15237, -15421, -15616, -15816, -15998, -16189, -16389, -16578, -16761, -16959, -17155, -17333, -17521, -17715, -17893, -18084, -18282, -18464, -18645, -18843, -19032, -19207, -19398, -19593, -19769, -19949, -20140, -20324, -20497, -20032, -23770, -4180, -3204, 1159, -798};