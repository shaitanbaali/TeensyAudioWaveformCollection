/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1269 256 samples */
 
const int16_t AKWF_1269_256_DATA [256] = 
{179, 543, 892, 1232, 1567, 1895, 2218, 2536, 2849, 3159, 3463, 3765, 4063, 4356, 4647, 4934, 5216, 5496, 5773, 6045, 6314, 6580, 6841, 7099, 7352, 7602, 7849, 8089, 8325, 8559, 8787, 9011, 9230, 9444, 9652, 9856, 10055, 10248, 10436, 10617, 10793, 10964, 11129, 11289, 11441, 11587, 11728, 11861, 11988, 12109, 12223, 12331, 12431, 12524, 12611, 12690, 12761, 12826, 12884, 12934, 12976, 13013, 13039, 13060, 13073, 13078, 13075, 13040, 12882, 13689, 539, -18570, -26687, -30399, -32024, -32653, -32754, -32537, -32106, -31516, -30804, -29992, -29095, -28131, -27104, -26026, -24905, -23744, -22550, -21331, -20089, -18831, -17564, -16286, -15010, -13738, -12469, -11216, -9978, -8760, -7568, -6404, -5270, -4176, -3119, -2103, -1136, -217, 651, 1462, 2218, 2912, 3539, 4100, 4588, 4993, 5308, 5522, 5551, 5442, 5502, 5652, 5845, 6066, 6301, 6545, 6790, 7033, 7270, 7499, 7715, 7920, 8110, 8284, 8443, 8584, 8707, 8812, 8900, 8968, 9018, 9050, 9063, 9058, 9036, 8997, 8939, 8866, 8775, 8670, 8550, 8413, 8265, 8102, 7926, 7737, 7538, 7327, 7105, 6874, 6633, 6383, 6126, 5861, 5589, 5310, 5025, 4735, 4442, 4142, 3841, 3535, 3226, 2916, 2604, 2290, 1977, 1662, 1348, 1035, 722, 410, 101, -206, -511, -812, -1110, -1405, -1696, -1982, -2264, -2540, -2812, -3077, -3337, -3591, -3836, -4076, -4309, -4534, -4752, -4962, -5164, -5358, -5542, -5717, -5883, -6043, -6189, -6327, -6457, -6576, -6684, -6782, -6870, -6947, -7012, -7068, -7113, -7145, -7167, -7178, -7177, -7164, -7140, -7105, -7057, -6998, -6927, -6845, -6750, -6644, -6524, -6392, -6251, -6095, -5928, -5750, -5558, -5354, -5138, -4909, -4668, -4415, -4148, -3867, -3573, -3265, -2942, -2602, -2243, -1862, -1444, -987, -573, -181};