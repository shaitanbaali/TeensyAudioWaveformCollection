/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1239 256 samples */
 
const int16_t AKWF_1239_256_DATA [256] = 
{768, 1467, 2537, 3417, 4197, 4851, 5378, 5770, 6041, 6203, 6264, 6251, 6186, 6091, 5984, 5891, 5831, 5819, 5868, 5988, 6184, 6458, 6807, 7226, 7708, 8241, 8815, 9419, 10039, 10664, 11284, 11892, 12482, 13049, 13592, 14110, 14608, 15089, 15562, 16028, 16499, 16979, 17469, 17982, 18517, 19073, 19653, 20254, 20867, 21489, 22110, 22726, 23324, 23892, 24424, 24915, 25353, 25737, 26064, 26328, 26567, 25943, 30355, -4227, -20437, -15469, -15162, -14137, -13100, -12039, -10937, -9780, -8564, -7270, -5904, -4472, -2963, -1401, 203, 1846, 3502, 5156, 6780, 8332, 9903, 11047, 10067, 8680, 7463, 6320, 5263, 4316, 3599, 2003, 5852, -1456, -10567, -9712, -10709, -11263, -11691, -12003, -12230, -12390, -12499, -12560, -12678, -12916, -13095, -13220, -13276, -13258, -13157, -12971, -12692, -12327, -11877, -11345, -10751, -10098, -9407, -8695, -7970, -7252, -6554, -5887, -5266, -4691, -4168, -3702, -3282, -2908, -2572, -2263, -1970, -1678, -1376, -1050, -688, -282, 173, 686, 1256, 1884, 2559, 3279, 4034, 4805, 5586, 6364, 7118, 7840, 8518, 9139, 9704, 10205, 10641, 11019, 11343, 11623, 11875, 12110, 12342, 12590, 12866, 13183, 13554, 13981, 14471, 15004, 15267, 17872, -2179, -21258, -24687, -27217, -28165, -28436, -28304, -27875, -27208, -26329, -25257, -24020, -22650, -21172, -19624, -18023, -16463, -14413, -14903, -14768, -10783, -9444, -7666, -6106, -4751, -3629, -2763, -2182, -1882, -1847, -2076, -2535, -3185, -3988, -4907, -5881, -6881, -7859, -8778, -9594, -10281, -10810, -11182, -11375, -11387, -11224, -10897, -10417, -9584, -10669, -917, -12973, -28333, -23664, -22974, -21710, -20498, -19364, -18320, -17388, -16567, -15854, -15247, -14737, -14309, -13946, -13623, -13328, -13038, -12726, -12386, -12008, -11566, -11060, -10488, -9850, -9146, -8385, -7575, -6724, -5680, -5927, 483, 4375};