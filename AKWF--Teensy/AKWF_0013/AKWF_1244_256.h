/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1244 256 samples */
 
const int16_t AKWF_1244_256_DATA [256] = 
{2132, 5753, 9652, 13658, 17520, 21008, 23877, 25993, 27233, 27575, 27075, 25837, 24035, 21859, 19514, 17188, 15085, 13300, 11977, 11195, 10985, 11373, 12325, 13799, 15672, 17793, 19941, 21814, 23105, 23414, 22387, 19696, 15207, 8973, 1368, -6791, -14880, -22385, -28216, -31761, -32762, -31333, -27881, -22984, -17282, -11363, -5735, -784, 3274, 6357, 8523, 9870, 10552, 10736, 10568, 10187, 9666, 9077, 8432, 7744, 6984, 6125, 5148, 4019, 2748, 1339, -175, -1743, -3286, -4735, -6015, -7066, -7852, -8345, -8553, -8500, -8228, -7785, -7219, -6577, -5894, -5197, -4496, -3800, -3110, -2436, -1785, -1194, -680, -331, -203, -397, -1009, -2045, -3815, -5201, -6456, -9034, -11578, -14179, -16365, -17845, -18261, -17345, -15020, -11366, -6907, -2100, 2703, 6885, 10017, 11834, 12354, 11702, 10147, 7947, 5401, 2751, 214, -2063, -4009, -5520, -6603, -7210, -7358, -7035, -6253, -5024, -3357, -1318, 1043, 3641, 6267, 9286, 10423, -2777, -4216, -2140, -728, 800, 2254, 3570, 4742, 5752, 6614, 7364, 8032, 8663, 9287, 9921, 10552, 11143, 11614, 11846, 11670, 10882, 9260, 6602, 2794, -2121, -7824, -14172, -20686, -26420, -30589, -32509, -31795, -28443, -22709, -15176, -6680, 1929, 9799, 16165, 20667, 23015, 23268, 21692, 18727, 14860, 10554, 6279, 2368, -967, -3574, -5434, -6524, -6864, -6457, -5338, -3511, -1012, 2099, 5686, 9590, 13579, 17252, 21702, 20543, -4159, -4051, -2191, -746, 777, 2231, 3553, 4718, 5726, 6587, 7337, 8007, 8638, 9258, 9892, 10522, 11114, 11584, 11815, 11640, 10852, 9229, 6571, 2763, -2152, -7855, -14204, -20717, -26453, -30621, -32541, -31832, -28452, -22717, -15213, -6711, 1896, 9766, 16168, 20637, 22982, 23235, 21662, 18683, 14808, 10525, 6246, 2334, -998, -3620, -5469, -6557, -6896, -6491, -5371, -3550, -999};