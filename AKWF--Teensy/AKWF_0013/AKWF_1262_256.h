/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1262 256 samples */
 
const int16_t AKWF_1262_256_DATA [256] = 
{3469, 6930, 4547, 4065, 5260, 6847, 8358, 9701, 10901, 11993, 13001, 13952, 14855, 15718, 16550, 17354, 18130, 18884, 19612, 20316, 20999, 21660, 22296, 22912, 23504, 24072, 24621, 25147, 25650, 26135, 26596, 27038, 27461, 27862, 28246, 28611, 28958, 29287, 29600, 29897, 30178, 30444, 30698, 30935, 31161, 31373, 31574, 31763, 31941, 32110, 32266, 32413, 32547, 32657, 32736, 32526, 31286, 30660, 30738, 30871, 31024, 31175, 31318, 31452, 31544, 31574, 31570, 31580, 31616, 31674, 31747, 31824, 31899, 31970, 32035, 32095, 32149, 32196, 32221, 32173, 32051, 31917, 31802, 31682, 31556, 31426, 31287, 31135, 30967, 30784, 30583, 30361, 30117, 29845, 29544, 29202, 28804, 28328, 27501, 26307, 25076, 23828, 22575, 21321, 20054, 18768, 17459, 16107, 14704, 13243, 11703, 10077, 8354, 6511, 4534, 2397, 145, -1750, -2998, -3994, -5025, -6147, -7333, -8527, -9695, -10822, -11897, -12924, -13904, -14837, -15725, -16574, -17377, -18141, -18861, -19534, -20154, -20719, -21219, -21718, -23183, -25769, -26284, -24637, -22327, -23227, -25410, -26429, -26901, -27213, -27486, -27757, -28026, -28290, -28548, -28798, -29035, -29265, -29483, -29688, -29885, -30070, -30247, -30415, -30572, -30723, -30864, -30997, -31123, -31243, -31356, -31463, -31562, -31656, -31746, -31831, -31910, -31986, -32058, -32127, -32190, -32250, -32308, -32364, -32417, -32465, -32513, -32558, -32602, -32643, -32683, -32720, -32756, -32768, -32737, -32682, -32632, -32580, -32521, -31905, -30364, -29800, -29759, -29780, -29830, -29884, -29942, -29971, -29891, -29698, -29488, -29337, -29260, -29243, -29264, -29305, -29356, -29406, -29457, -29505, -29542, -29535, -29488, -29415, -29322, -29214, -29091, -28956, -28807, -28646, -28471, -28280, -28073, -27847, -27599, -27327, -27026, -26692, -26314, -25878, -25377, -24679, -23364, -21761, -20138, -18553, -17187, -16046, -14943, -13693, -12201, -10374, -9214, -12016, -13047, -6847};