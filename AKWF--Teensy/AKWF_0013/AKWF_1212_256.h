/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1212 256 samples */
 
const int16_t AKWF_1212_256_DATA [256] = 
{779, 3268, 5775, 8370, 10975, 13512, 15904, 18101, 20134, 22103, 24106, 26158, 28126, 29818, 31079, 31868, 32290, 32523, 32687, 32769, 32632, 32114, 31132, 29731, 28067, 26317, 24562, 22756, 20762, 18490, 16008, 13476, 11024, 8693, 6431, 4188, 1959, -253, -2436, -4581, -6725, -8906, -11105, -13261, -15257, -16965, -18289, -19200, -19776, -20213, -20744, -21522, -22520, -23515, -24213, -24355, -23849, -22836, -21582, -20289, -19024, -17769, -16552, -15456, -14545, -13792, -13053, -12152, -10961, -9441, -7660, -5786, -4010, -2496, -1304, -367, 409, 1061, 1540, 1792, 1871, 1993, 2427, 3319, 4610, 6057, 7322, 8089, 8195, 7671, 6672, 5421, 4138, 3010, 2211, 1883, 2060, 2618, 3336, 3960, 4272, 4156, 3633, 2838, 1947, 1102, 389, -163, -548, -782, -894, -931, -957, -1040, -1225, -1516, -1867, -2183, -2330, -2155, -1531, -416, 1113, 2854, 4536, 5861, 6563, 6506, 5711, 4335, 2603, 772, -886, -2169, -2958, -3227, -3015, -2406, -1513, -438, 739, 1973, 3238, 4485, 5636, 6594, 7244, 7476, 7214, 6420, 5107, 3332, 1218, -1065, -3321, -5323, -6862, -7788, -8008, -7514, -6349, -4616, -2451, -25, 2451, 4776, 6755, 8218, 9051, 9181, 8589, 7308, 5421, 3073, 429, -2309, -4929, -7248, -9088, -10307, -10816, -10587, -9669, -8159, -6200, -3953, -1574, 748, 2847, 4585, 5853, 6614, 6876, 6678, 6094, 5218, 4174, 3079, 2058, 1236, 717, 579, 845, 1501, 2505, 3788, 5264, 6822, 8340, 9713, 10836, 11618, 11990, 11920, 11420, 10540, 9352, 7907, 6222, 4340, 2326, 261, -1779, -3769, -5693, -7514, -9215, -10786, -12217, -13497, -14620, -15601, -16496, -17351, -18186, -19007, -19795, -20499, -21058, -21437, -21663, -21788, -21820, -21693, -21287, -20530, -19426, -17987, -16315, -14558, -12781, -10934, -8888, -6590, -4133, -1602};