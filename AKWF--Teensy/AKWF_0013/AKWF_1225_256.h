/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1225 256 samples */
 
const int16_t AKWF_1225_256_DATA [256] = 
{1132, 3645, 6129, 8579, 10925, 13107, 15083, 16818, 18319, 19588, 20622, 21407, 21904, 22045, 21747, 20916, 19478, 17382, 14648, 11361, 7665, 3793, 15, -3469, -6502, -8954, -10667, -11431, -11091, -9670, -7469, -4922, -2380, -99, 1773, 3170, 4082, 4553, 4655, 4471, 4083, 3565, 2982, 2372, 1762, 1162, 565, -45, -690, -1402, -2206, -3125, -4189, -5406, -6785, -8332, -10032, -11870, -13830, -15875, -17968, -20079, -22153, -24149, -26026, -27731, -29224, -30471, -31437, -32125, -32553, -32747, -32745, -32577, -32266, -31823, -31247, -30523, -29620, -28502, -27134, -25467, -23476, -21148, -18472, -15482, -12232, -8781, -5236, -1718, 1662, 4762, 7468, 9669, 11325, 12414, 13167, 13868, 14042, 13562, 12682, 11572, 10369, 9176, 8052, 7030, 6126, 5330, 4632, 4021, 3481, 3006, 2600, 2267, 2021, 1880, 1863, 1990, 2280, 2742, 3385, 4206, 5196, 6335, 7595, 8944, 10338, 11731, 13080, 14327, 15430, 16352, 17076, 17612, 17987, 18227, 18368, 18438, 18461, 18447, 18401, 18315, 18170, 17942, 17599, 17102, 16417, 15507, 14339, 12888, 11145, 9097, 6757, 4152, 1305, -1721, -4868, -8075, -11248, -14307, -17175, -19753, -21982, -23835, -25312, -26452, -27300, -27902, -28315, -28582, -28739, -28818, -28838, -28809, -28738, -28623, -28460, -28241, -27962, -27615, -27192, -26689, -26103, -25431, -24672, -23829, -22900, -21889, -20799, -19630, -18390, -17081, -15707, -14274, -12786, -11246, -9667, -8049, -6398, -4730, -3047, -1357, 319, 1983, 3616, 5201, 6732, 8191, 9560, 10833, 11994, 13029, 13932, 14689, 15293, 15737, 16013, 16117, 16044, 15796, 15366, 14681, 13611, 12029, 10238, 8559, 6491, 4045, 2173, 1455, 1612, 2067, 2034, 1167, -334, -2236, -4327, -6427, -8411, -10183, -11679, -12875, -13759, -14334, -14616, -14618, -14352, -13829, -13057, -12042, -10782, -9290, -7573, -5642, -3528, -1205};