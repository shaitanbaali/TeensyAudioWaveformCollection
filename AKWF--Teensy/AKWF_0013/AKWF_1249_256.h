/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1249 256 samples */
 
const int16_t AKWF_1249_256_DATA [256] = 
{8458, 18255, 23482, 26548, 28352, 29422, 30053, 30406, 30569, 30586, 30479, 30252, 29898, 29420, 28815, 28117, 27383, 26709, 26219, 26040, 26250, 26844, 27733, 28771, 29795, 30686, 31386, 31892, 32230, 32445, 32575, 32652, 32698, 32723, 32739, 32749, 32754, 32757, 32759, 32760, 32760, 32759, 32758, 32755, 32752, 32748, 32741, 32733, 32723, 32713, 32702, 32693, 32686, 32686, 32690, 32699, 32710, 32722, 32734, 32744, 32752, 32758, 32761, 32764, 32766, 32767, 32767, 32768, 32767, 32768, 32768, 32767, 32768, 32767, 32767, 32766, 32764, 32760, 32756, 32749, 32739, 32725, 32709, 32688, 32666, 32647, 32632, 32625, 32626, 32638, 32653, 32670, 32688, 32704, 32716, 32726, 32734, 32739, 32743, 32744, 32745, 32742, 32737, 32730, 32716, 32695, 32656, 32589, 32472, 32265, 31905, 31287, 30271, 28668, 26301, 23069, 19033, 14536, 10156, 6563, 4363, 3821, 4849, 7047, 9891, 12880, 15639, 17964, 19756, 20979, 21633, 21699, 21097, 19639, 16943, 12431, 4566, -6635, -15966, -22363, -26559, -29133, -30661, -31540, -32038, -32320, -32482, -32573, -32629, -32661, -32679, -32689, -32693, -32691, -32684, -32672, -32656, -32630, -32598, -32558, -32513, -32465, -32423, -32393, -32384, -32397, -32433, -32484, -32543, -32600, -32648, -32686, -32715, -32733, -32747, -32754, -32759, -32763, -32764, -32766, -32767, -32766, -32766, -32766, -32766, -32767, -32766, -32765, -32763, -32760, -32757, -32750, -32743, -32733, -32722, -32711, -32701, -32693, -32689, -32691, -32698, -32708, -32719, -32729, -32740, -32746, -32753, -32757, -32760, -32762, -32763, -32765, -32764, -32765, -32764, -32763, -32762, -32759, -32754, -32747, -32735, -32715, -32682, -32629, -32548, -32428, -32263, -32055, -31817, -31577, -31371, -31235, -31192, -31243, -31368, -31538, -31722, -31896, -32049, -32171, -32261, -32324, -32363, -32378, -32367, -32328, -32249, -32112, -31878, -31482, -30799, -29611, -27518, -23847, -17492, -5977};