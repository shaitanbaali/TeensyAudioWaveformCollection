/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1208 256 samples */
 
const int16_t AKWF_1208_256_DATA [256] = 
{989, 2560, 4030, 5427, 6741, 7967, 9098, 10124, 11044, 11856, 12552, 13133, 13599, 13950, 14185, 14307, 14318, 14222, 14023, 13726, 13334, 12857, 12298, 11663, 10962, 10202, 9389, 8531, 7638, 6715, 5772, 4817, 3854, 2896, 1947, 1013, 105, -775, -1621, -2425, -3184, -3893, -4548, -5145, -5684, -6159, -6570, -6916, -7194, -7408, -7556, -7636, -7654, -7609, -7504, -7342, -7124, -6855, -6537, -6177, -5775, -5336, -4866, -4369, -3848, -3309, -2756, -2191, -1623, -1055, -488, 69, 616, 1149, 1663, 2154, 2622, 3062, 3473, 3852, 4196, 4507, 4782, 5017, 5216, 5376, 5498, 5581, 5626, 5634, 5605, 5543, 5446, 5316, 5157, 4968, 4753, 4514, 4251, 3968, 3668, 3352, 3023, 2683, 2334, 1979, 1621, 1262, 902, 547, 196, -148, -482, -807, -1119, -1417, -1700, -1967, -2214, -2445, -2655, -2844, -3013, -3160, -3286, -3391, -3472, -3531, -3571, -3588, -3585, -3563, -3521, -3461, -3382, -3289, -3181, -3058, -2923, -2775, -2618, -2453, -2281, -2102, -1919, -1732, -1544, -1356, -1169, -984, -802, -625, -453, -288, -130, 18, 158, 288, 409, 518, 616, 702, 777, 840, 892, 931, 959, 976, 982, 977, 961, 937, 902, 860, 810, 752, 688, 619, 544, 465, 384, 299, 213, 126, 38, -48, -134, -219, -301, -379, -455, -525, -592, -654, -710, -761, -806, -844, -876, -903, -924, -937, -943, -945, -940, -930, -913, -892, -865, -834, -799, -758, -716, -669, -620, -568, -516, -461, -406, -349, -293, -237, -182, -128, -75, -24, 24, 71, 115, 156, 193, 228, 259, 287, 312, 332, 349, 303, 314, 826, -21058, -30789, -17389, -17642, -19436, -17602, -15033, -13657, -12489, -10748, -8905, -7252, -5611, -3899, -2211, -554};