/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1266 256 samples */
 
const int16_t AKWF_1266_256_DATA [256] = 
{183, 522, 843, 1159, 1469, 1779, 2097, 2426, 2772, 3139, 3525, 3931, 4356, 4792, 5239, 5690, 6140, 6588, 7032, 7469, 7905, 8339, 8775, 9218, 9672, 10138, 10619, 11116, 11626, 12152, 12686, 13226, 13770, 14313, 14852, 15389, 15918, 16443, 16964, 17483, 18006, 18530, 19058, 19595, 20139, 20687, 21245, 21805, 22366, 22921, 23401, 24280, 20628, 9409, -3148, -13372, -20277, -24624, -27640, -30047, -31887, -32755, -32223, -30187, -26972, -23228, -19688, -16979, -15495, -15324, -16316, -18133, -20336, -22456, -24046, -24745, -24296, -22600, -19702, -15807, -11261, -6460, -1865, 2100, 5111, 6937, 7501, 6873, 5248, 2927, 255, -2394, -4691, -6383, -7306, -7418, -6780, -5553, -3960, -2257, -696, 516, 1235, 1400, 1034, 249, -787, -1875, -2798, -3370, -3451, -2966, -1918, -377, 1519, 3590, 5645, 7481, 8936, 9901, 10315, 10188, 9589, 8639, 7484, 6283, 5192, 4331, 3779, 3574, 3698, 4088, 4651, 5278, 5856, 6283, 6489, 6437, 6131, 5612, 4947, 4231, 3557, 3014, 2678, 2586, 2754, 3159, 3746, 4442, 5160, 5813, 6323, 6630, 6703, 6536, 6152, 5597, 4935, 4233, 3559, 2975, 2520, 2212, 2051, 2015, 2065, 2155, 2232, 2249, 2174, 1982, 1675, 1265, 782, 261, -247, -706, -1079, -1341, -1481, -1507, -1438, -1301, -1138, -985, -878, -848, -911, -1074, -1330, -1662, -2044, -2445, -2837, -3188, -3483, -3708, -3860, -3949, -3991, -4004, -4011, -4035, -4094, -4195, -4345, -4539, -4764, -5004, -5237, -5448, -5618, -5734, -5789, -5782, -5725, -5624, -5496, -5362, -5235, -5129, -5056, -5019, -5017, -5041, -5084, -5133, -5171, -5188, -5175, -5125, -5035, -4909, -4754, -4577, -4390, -4200, -4017, -3848, -3694, -3555, -3425, -3298, -3166, -3019, -2851, -2654, -2424, -2162, -1868, -1550, -1210, -860, -507, -149};