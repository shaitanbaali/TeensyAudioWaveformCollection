/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1245 256 samples */
 
const int16_t AKWF_1245_256_DATA [256] = 
{4105, 10522, 15639, 19574, 22403, 24258, 25358, 25908, 26085, 26014, 25758, 25312, 24600, 23517, 21880, 19486, 16173, 11807, 6400, 285, -6310, -12875, -18664, -22971, -25284, -25372, -23308, -19381, -14115, -8231, -1022, 5143, 9417, 12714, 14757, 15702, 15755, 15160, 14169, 13011, 11867, 10862, 10062, 9496, 9147, 8967, 8885, 8815, 8657, 8315, 7714, 6815, 5590, 4086, 2387, 603, -1106, -2612, -3823, -4640, -5042, -5055, -4751, -4228, -3594, -2954, -2386, -1941, -1635, -1457, -1375, -1346, -1317, -1237, -1056, -724, -205, 530, 1483, 2618, 3877, 5131, 6215, 6932, 7095, 6535, 5150, 2930, -3, -3408, -7006, -10427, -13276, -15244, -16111, -15806, -14389, -12066, -9122, -5910, -2779, 135, 2691, 4798, 6434, 7601, 8333, 8648, 8541, 7988, 6949, 5386, 3240, 521, -2695, -6329, -10166, -13920, -17208, -19498, -22053, -6016, 1012, 1444, 3597, 5247, 6501, 7270, 7538, 7341, 6755, 5889, 4875, 3835, 2872, 2097, 1578, 1396, 1599, 2240, 3341, 4911, 6932, 9315, 11891, 14479, 16729, 18285, 18712, 17628, 14735, 9977, 3617, -3668, -11170, -18045, -23346, -26565, -27540, -26397, -23463, -19230, -14239, -8970, -3824, 860, 4956, 8311, 10907, 12790, 13967, 14475, 14323, 13494, 11942, 9608, 6487, 2518, -2182, -7519, -13246, -18961, -24233, -28298, -33198, -10998, 1703, 1288, 3592, 5242, 6496, 7267, 7535, 7338, 6751, 5886, 4871, 3826, 2869, 2095, 1576, 1393, 1596, 2237, 3339, 4909, 6930, 9313, 11890, 14477, 16728, 18284, 18711, 17627, 14734, 9975, 3617, -3677, -11218, -18042, -23349, -26565, -27543, -26385, -23455, -19233, -14240, -8972, -3824, 888, 4954, 8310, 10907, 12788, 13967, 14476, 14322, 13494, 11941, 9607, 6462, 2517, -2183, -7521, -13243, -18979, -24272, -28631, -31619, -32804, -31922, -28910, -24004, -17613, -10308, -2744};