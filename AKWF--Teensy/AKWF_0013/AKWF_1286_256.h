/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1286 256 samples */
 
const int16_t AKWF_1286_256_DATA [256] = 
{1518, 4807, 8652, 12603, 16192, 19055, 20950, 21797, 21702, 20915, 19795, 18741, 18133, 18255, 19258, 21123, 23650, 26515, 29278, 31470, 32672, 32556, 30961, 27899, 23588, 18403, 12808, 7357, 2547, -1225, -3688, -4774, -4599, -3443, -1706, 156, 1696, 2558, 2516, 1513, -339, -2775, -5418, -7864, -9722, -10692, -10622, -9522, -7585, -5135, -2606, -467, 860, 1048, -69, -2484, -5986, -10209, -14694, -18904, -22350, -24644, -25533, -24963, -23058, -20122, -16566, -12857, -9467, -6762, -4982, -4204, -4325, -5094, -6152, -7100, -7562, -7249, -6013, -3875, -1035, 2183, 5339, 7961, 9631, 10016, 8957, 6466, 2756, -1798, -6731, -11496, -15593, -18629, -20334, -20641, -19667, -17696, -15130, -12424, -10030, -8304, -7474, -7602, -8572, -10126, -11888, -13454, -14436, -14536, -13603, -11650, -8872, -5591, -2247, 688, 2797, 3746, 3366, 1669, -1139, -4695, -8537, -12133, -14993, -16730, -17094, -16029, -13661, -10296, -6344, -2273, 1442, 4439, 6478, 7478, 7543, 6926, 5984, 5117, 4703, 5028, 6242, 8324, 11078, 14177, 17182, 19622, 21079, 21227, 19901, 17115, 13086, 8190, 2891, -2259, -6762, -10222, -12367, -13131, -12627, -11138, -9064, -6858, -4972, -3760, -3448, -4094, -5585, -7656, -9933, -12009, -13495, -14090, -13643, -12166, -9848, -7015, -4104, -1582, 130, 702, -31, -2060, -5178, -9018, -13119, -16947, -20012, -21925, -22437, -21490, -19210, -15903, -11977, -7902, -4149, -1083, 1054, 2184, 2413, 1990, 1272, 660, 532, 1171, 2729, 5184, 8336, 11861, 15317, 18232, 20189, 20857, 20072, 17848, 14400, 10099, 5414, 888, -2977, -5788, -7275, -7374, -6198, -4034, -1284, 1599, 4161, 6045, 7026, 7041, 6203, 4774, 3126, 1668, 784, 770, 1783, 3805, 6643, 9975, 13361, 16328, 18459, 19421, 19046, 17344, 14519, 10938, 7063, 3424, 511, -1291, -1740, -693};