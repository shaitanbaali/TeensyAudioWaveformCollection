/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1223 256 samples */
 
const int16_t AKWF_1223_256_DATA [256] = 
{769, 1871, 2920, 3963, 4994, 6015, 7033, 8041, 9052, 10063, 11069, 12077, 13083, 14073, 15065, 16047, 17012, 17966, 18896, 19808, 20700, 21566, 22405, 23218, 23998, 24753, 25478, 26172, 26835, 27466, 28068, 28638, 29178, 29684, 30158, 30596, 31001, 31370, 31701, 31990, 32238, 32439, 32596, 32705, 32761, 32764, 32717, 32614, 32457, 32244, 31975, 31654, 31276, 30846, 30367, 29836, 29262, 28640, 27974, 27267, 26523, 25746, 24933, 24085, 23203, 22291, 21345, 20372, 19361, 18319, 17240, 16129, 14986, 13809, 12599, 11357, 10084, 8786, 7468, 6122, 4759, 3380, 1988, 600, -789, -2182, -3563, -4935, -6291, -7614, -8922, -10201, -11448, -12662, -13838, -14971, -16071, -17130, -18143, -19112, -20041, -20926, -21770, -22566, -23315, -24020, -24680, -25297, -25868, -26391, -26867, -27298, -27682, -28022, -28315, -28560, -28760, -28918, -29031, -29102, -29133, -29124, -29078, -28999, -28885, -28740, -28566, -28367, -28139, -27888, -27615, -27317, -27002, -26660, -26295, -25907, -25490, -25047, -24580, -24077, -23544, -22981, -22382, -21753, -21092, -20399, -19671, -18920, -18144, -17339, -16517, -15676, -14823, -13969, -13104, -12240, -11382, -10527, -9689, -8869, -8059, -7272, -6508, -5763, -5050, -4361, -3695, -3054, -2438, -1846, -1281, -732, -208, 294, 780, 1241, 1684, 2110, 2514, 2899, 3264, 3605, 3927, 4224, 4499, 4750, 4973, 5171, 5343, 5489, 5609, 5701, 5768, 5810, 5827, 5822, 5794, 5746, 5678, 5593, 5492, 5374, 5265, 5199, 5210, 5323, 5555, 5909, 6381, 6957, 7609, 8299, 8986, 9613, 10132, 10486, 10618, 10481, 10033, 9243, 8087, 6563, 4689, 2486, 15, -2683, -5524, -8430, -11290, -14006, -16485, -18640, -20372, -21622, -22407, -22777, -22781, -22463, -21869, -21041, -20030, -18872, -17595, -16241, -14832, -13397, -11967, -10535, -9125, -7747, -6411, -5116, -3859, -2645, -1473, -312};