/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1215 256 samples */
 
const int16_t AKWF_1215_256_DATA [256] = 
{243, 722, 1350, 2211, 3311, 4768, 6638, 8902, 11627, 14638, 18106, 20636, 23224, 26616, 29345, 31370, 32533, 32699, 31849, 30056, 27395, 24036, 20148, 15927, 11567, 7236, 3050, -860, -4426, -7621, -10414, -12816, -14858, -16527, -17876, -18943, -19743, -20283, -20605, -20734, -20678, -20427, -20028, -19483, -18800, -17985, -17091, -16120, -15113, -14079, -13012, -11979, -10927, -9910, -8926, -7968, -7025, -6138, -5269, -4467, -3706, -2993, -2314, -1694, -1089, -555, -70, 381, 803, 1177, 1516, 1817, 2066, 2286, 2481, 2637, 2772, 2882, 2956, 3022, 3086, 3118, 3137, 3165, 3146, 3148, 3126, 3094, 3051, 3000, 2943, 2880, 2818, 2737, 2633, 2537, 2453, 2335, 2248, 2131, 2032, 1899, 1801, 1705, 1609, 1506, 1428, 1324, 1229, 1133, 1050, 946, 850, 770, 671, 576, 478, 401, 296, 227, 129, 50, -40, -121, -216, -263, -338, -389, -444, -483, -515, -559, -598, -636, -665, -707, -701, -725, -716, -747, -739, -734, -705, -712, -699, -681, -650, -620, -571, -535, -511, -461, -417, -357, -322, -251, -213, -153, -109, -44, -4, 37, 73, 119, 170, 227, 255, 292, 339, 369, 397, 420, 459, 483, 495, 522, 546, 556, 563, 570, 581, 575, 584, 564, 562, 533, 518, 490, 485, 445, 416, 380, 344, 309, 262, 228, 179, 148, 107, 56, 18, -7, -63, -98, -159, -207, -269, -332, -394, -475, -559, -613, -689, -757, -826, -891, -975, -1061, -1133, -1196, -1258, -1337, -1393, -1448, -1513, -1589, -1672, -1751, -1837, -1940, -2037, -2139, -2250, -2369, -2454, -2525, -2597, -2646, -2688, -2705, -2722, -2702, -2661, -2586, -2498, -2354, -2206, -2017, -1816, -1613, -1388, -1163, -939, -705, -430, -125};