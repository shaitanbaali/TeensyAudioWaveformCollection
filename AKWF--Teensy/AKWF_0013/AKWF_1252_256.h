/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1252 256 samples */
 
const int16_t AKWF_1252_256_DATA [256] = 
{400, 1571, 2676, 3748, 4782, 5781, 6747, 7678, 8578, 9447, 10286, 11096, 11879, 12633, 13364, 14069, 14748, 15406, 16041, 16652, 17244, 17816, 18366, 18900, 19414, 19911, 20391, 20854, 21300, 21733, 22150, 22552, 22941, 23317, 23680, 24030, 24368, 24694, 25010, 25315, 25608, 25891, 26165, 26431, 26687, 26932, 27171, 27401, 27623, 27838, 28045, 28244, 28438, 28625, 28803, 28978, 29145, 29306, 29462, 29612, 29757, 29896, 30030, 30160, 30283, 30402, 30515, 30623, 30726, 30823, 30915, 30999, 31076, 31146, 31207, 31258, 31298, 31323, 31335, 31329, 31303, 31255, 31180, 31077, 30943, 30771, 30563, 30313, 30020, 29684, 29300, 28871, 28398, 27883, 27327, 26736, 26113, 25464, 24796, 24110, 23416, 22715, 22016, 21324, 20639, 19966, 19309, 18665, 18037, 17428, 16837, 16263, 15707, 15164, 14630, 14099, 13567, 13029, 12481, 11917, 11332, 10722, 10083, 9412, 8708, 7967, 7190, 6381, 5536, 4662, 3762, 2837, 1897, 943, -19, -984, -1948, -2908, -3856, -4794, -5719, -6622, -7508, -8374, -9216, -10038, -10836, -11608, -12361, -13090, -13793, -14477, -15137, -15776, -16394, -16992, -17569, -18128, -18666, -19187, -19691, -20177, -20646, -21101, -21539, -21961, -22371, -22766, -23146, -23515, -23871, -24215, -24546, -24866, -25175, -25474, -25762, -26041, -26309, -26570, -26821, -27063, -27296, -27523, -27742, -27952, -28155, -28351, -28541, -28723, -28902, -29072, -29237, -29396, -29550, -29699, -29841, -29980, -30114, -30243, -30368, -30488, -30605, -30717, -30826, -30931, -31031, -31129, -31224, -31314, -31402, -31487, -31569, -31648, -31724, -31799, -31870, -31939, -32005, -32069, -32131, -32191, -32248, -32304, -32359, -32411, -32460, -32508, -32555, -32600, -32642, -32682, -32720, -32751, -32763, -32720, -32277, -30837, -28796, -26698, -24640, -22636, -20697, -18827, -17016, -15268, -13582, -11950, -10376, -8859, -7389, -5971, -4605, -3283, -2010, -759};