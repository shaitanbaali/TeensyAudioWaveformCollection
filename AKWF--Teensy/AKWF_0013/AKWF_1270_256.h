/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1270 256 samples */
 
const int16_t AKWF_1270_256_DATA [256] = 
{1792, 4605, 5547, 16060, 26863, 23644, 23339, 29867, 31432, 30478, 31474, 32703, 32508, 31571, 31014, 30518, 29209, 27558, 26194, 24608, 22246, 20616, 20339, 15073, 8023, 10007, 11030, 6269, 5076, 6336, 6140, 5639, 6003, 6856, 7245, 7115, 7310, 7388, 6709, 5824, 4816, 3457, 1836, 122, -1622, -3398, -5201, -6958, -8646, -10280, -11815, -13219, -14479, -15564, -16435, -17056, -17405, -17447, -17161, -16519, -15532, -14200, -12555, -10665, -8594, -6438, -4280, -2202, -274, 1486, 3033, 4340, 5377, 6108, 6484, 6499, 6168, 5562, 4722, 3663, 2413, 988, -563, -2202, -3894, -5574, -7175, -8661, -9964, -11035, -11853, -12391, -12635, -12595, -12297, -11788, -11122, -10363, -9596, -8871, -8244, -7759, -7454, -7351, -7467, -7780, -8283, -8919, -9645, -10426, -11230, -12033, -12809, -13544, -14201, -14765, -15201, -15482, -15554, -15375, -14911, -14117, -12945, -11387, -9447, -7147, -4567, -1855, 828, 2463, 2327, 14746, 28649, 23786, 22717, 30124, 31531, 29908, 30769, 31944, 31493, 30288, 29577, 28978, 27558, 25829, 24374, 22761, 20804, 18848, 17032, 15226, 13467, 11903, 10606, 9530, 8699, 8172, 7907, 7821, 7847, 7927, 7968, 7900, 7680, 7284, 6684, 5855, 4812, 3573, 2163, 606, -1055, -2794, -4585, -6396, -8210, -9999, -11744, -13405, -14947, -16323, -17499, -18426, -19051, -19340, -19210, -18593, -17449, -15812, -13818, -11565, -9194, -6826, -4551, -2429, -531, 1133, 2531, 3629, 4438, 4957, 5190, 5162, 4904, 4431, 3760, 2920, 1915, 759, -524, -1907, -3357, -4840, -6281, -7640, -8854, -9893, -10711, -11288, -11611, -11651, -11393, -10826, -10027, -9126, -8213, -7383, -6695, -6184, -5893, -5818, -5953, -6288, -6721, -7386, -8426, -8628, -8169, -13339, -18818, -15688, -15621, -19726, -19947, -18984, -19133, -19189, -18271, -16787, -15261, -13465, -10941, -8009, -5017, -1767};