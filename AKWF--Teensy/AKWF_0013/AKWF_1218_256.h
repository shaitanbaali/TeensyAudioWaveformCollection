/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1218 256 samples */
 
const int16_t AKWF_1218_256_DATA [256] = 
{394, 1150, 1879, 2596, 3317, 4072, 4895, 5802, 6805, 7899, 9063, 10281, 11527, 12770, 13997, 15202, 16382, 17559, 18748, 19954, 21187, 22432, 23664, 24864, 26000, 27043, 27977, 28790, 29483, 30057, 30520, 30878, 31136, 31289, 31322, 31217, 30956, 30522, 29906, 29114, 28146, 27013, 25735, 24316, 22773, 21117, 19342, 17453, 15451, 13328, 11093, 8763, 6344, 3871, 1370, -1145, -3648, -6118, -8556, -10938, -13260, -15520, -17693, -19767, -21734, -23568, -25257, -26790, -28152, -29341, -30354, -31190, -31853, -32340, -32647, -32767, -32700, -32444, -31994, -31351, -30519, -29495, -28289, -26921, -25401, -23750, -21995, -20135, -18194, -16183, -14108, -11985, -9823, -7623, -5409, -3195, -994, 1163, 3259, 5285, 7224, 9085, 10871, 12581, 14230, 15820, 17341, 18790, 20158, 21420, 22562, 23572, 24440, 25173, 25784, 26288, 26703, 27035, 27285, 27444, 27501, 27435, 27226, 26862, 26331, 25627, 24775, 23813, 22767, 21673, 20547, 19397, 18212, 16980, 15689, 14335, 12907, 11413, 9877, 8323, 6794, 5328, 3944, 2649, 1439, 277, -856, -1985, -3124, -4270, -5409, -6524, -7579, -8546, -9409, -10147, -10775, -11316, -11800, -12258, -12705, -13140, -13544, -13891, -14152, -14302, -14323, -14205, -13951, -13586, -13146, -12668, -12188, -11720, -11260, -10789, -10288, -9734, -9124, -8467, -7769, -7081, -6451, -5877, -5399, -5045, -4811, -4678, -4611, -4578, -4548, -4523, -4504, -4507, -4552, -4660, -4851, -5135, -5513, -5962, -6453, -6942, -7393, -7786, -8131, -8439, -8743, -9060, -9407, -9805, -10247, -10723, -11206, -11661, -12057, -12364, -12577, -12714, -12803, -12874, -12951, -13050, -13170, -13299, -13411, -13479, -13473, -13370, -13158, -12847, -12465, -12053, -11639, -11252, -10895, -10564, -10236, -9889, -9498, -9046, -8528, -7947, -7329, -6703, -6104, -5557, -5076, -4649, -4256, -3860, -3429, -2942, -2387, -1761, -1075, -333};