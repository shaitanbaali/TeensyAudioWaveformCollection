/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1280 256 samples */
 
const int16_t AKWF_1280_256_DATA [256] = 
{417, 1211, 1983, 2742, 3487, 4215, 4923, 5604, 6260, 6889, 7486, 8052, 8587, 9087, 9552, 9983, 10376, 10736, 11059, 11348, 11605, 11829, 12023, 12187, 12323, 12432, 12517, 12583, 12628, 12655, 12665, 12662, 12651, 12632, 12606, 12578, 12547, 12518, 12493, 12469, 12451, 12444, 12446, 12458, 12482, 12516, 12564, 12628, 12704, 12793, 12898, 13016, 13148, 13292, 13448, 13616, 13792, 13980, 14174, 14376, 14580, 14789, 15000, 15211, 15422, 15627, 15828, 16024, 16210, 16388, 16554, 16706, 16844, 16968, 17075, 17164, 17234, 17285, 17316, 17325, 17313, 17280, 17223, 17146, 17047, 16926, 16783, 16619, 16437, 16233, 16008, 15768, 15511, 15235, 14944, 14640, 14324, 13995, 13655, 13308, 12951, 12585, 12217, 11843, 11466, 11088, 10709, 10327, 9948, 9571, 9197, 8825, 8460, 8097, 7738, 7386, 7040, 6698, 6365, 6037, 5714, 5399, 5089, 4784, 4486, 4190, 3902, 3618, 3334, 3056, 2780, 2506, 2233, 1961, 1685, 1422, 1024, 133, -1388, -3485, -6071, -8972, -12068, -16209, 7664, 16648, 14771, 17746, 21071, 22191, 19364, 13221, 6002, 229, -2875, -3807, -4186, -5588, -8593, -12644, -16581, -19416, -20913, -21587, -22242, -23475, -25331, -27385, -29084, -30100, -30478, -30561, -30728, -31168, -31807, -32409, -32739, -32718, -32439, -32089, -31826, -31694, -31616, -31473, -31182, -30632, -29767, -28668, -27423, -26074, -24637, -23116, -21531, -19951, -18446, -17067, -15851, -14782, -13834, -12983, -12207, -11516, -10920, -10421, -10015, -9685, -9413, -9186, -9003, -8871, -8795, -8774, -8807, -8883, -8996, -9137, -9305, -9497, -9715, -9953, -10202, -10456, -10705, -10948, -11175, -11386, -11580, -11747, -11887, -11992, -12059, -12087, -12070, -12008, -11904, -11752, -11553, -11307, -11012, -10665, -10277, -9839, -9358, -8839, -8279, -7678, -7047, -6382, -5689, -4973, -4235, -3480, -2711, -1932, -1150, -350};