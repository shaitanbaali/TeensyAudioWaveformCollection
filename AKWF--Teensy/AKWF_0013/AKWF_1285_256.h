/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1285 256 samples */
 
const int16_t AKWF_1285_256_DATA [256] = 
{442, 1524, 2560, 3576, 4564, 5531, 6474, 7390, 8282, 9149, 9989, 10805, 11595, 12358, 13099, 13812, 14499, 15161, 15797, 16405, 16990, 17549, 18081, 18588, 19071, 19526, 19958, 20363, 20743, 21099, 21431, 21737, 22019, 22278, 22512, 22722, 22911, 23075, 23217, 23336, 23433, 23508, 23562, 23595, 23607, 23598, 23571, 23523, 23457, 23372, 23269, 23147, 23008, 22852, 22681, 22493, 22289, 22072, 21840, 21594, 21335, 21063, 20779, 20483, 20177, 19860, 19533, 19196, 18851, 18498, 18139, 17771, 17398, 17018, 16635, 16246, 15853, 15458, 15060, 14661, 14260, 13859, 13457, 13057, 12657, 12259, 11865, 11473, 11084, 10702, 10323, 9951, 9585, 9224, 8873, 8529, 8191, 7865, 7562, 6647, 5446, 4307, 3168, 2044, 932, -165, -1247, -2315, -3369, -4404, -5424, -6430, -7413, -8383, -9334, -10264, -11176, -12070, -12941, -13794, -14626, -15435, -16226, -16992, -17737, -18459, -19160, -19836, -20489, -21118, -21725, -22307, -22863, -23397, -23906, -24388, -24847, -25279, -25687, -26070, -26427, -26758, -27063, -27343, -27597, -27824, -28027, -28203, -28354, -28480, -28579, -28653, -28700, -28723, -28720, -28693, -28641, -28563, -28461, -28334, -28182, -28007, -27809, -27585, -27340, -27071, -26779, -26466, -26130, -25771, -25392, -24991, -24570, -24129, -23667, -23185, -22686, -22166, -21629, -21076, -20503, -19914, -19309, -18689, -18051, -17400, -16734, -16056, -15363, -14657, -13940, -13212, -12471, -11721, -10960, -10191, -9413, -8626, -7832, -7033, -6225, -5412, -4596, -3774, -2947, -2120, -1288, -454, 377, 1214, 2048, 2881, 3715, 4547, 5373, 6199, 7021, 7837, 8649, 9456, 10254, 11048, 11834, 12610, 13381, 14141, 14878, 16226, 17860, 19432, 21007, 22561, 24108, 25639, 27154, 28656, 29130, 36018, 5712, -25390, -18535, -18149, -16765, -15403, -14056, -12729, -11425, -10137, -8873, -7630, -6406, -5206, -4029, -2873, -1743, -615};