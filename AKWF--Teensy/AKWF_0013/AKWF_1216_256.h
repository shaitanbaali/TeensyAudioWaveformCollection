/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1216 256 samples */
 
const int16_t AKWF_1216_256_DATA [256] = 
{-3247, -9575, -15813, -21648, -26595, -30262, -32360, -32701, -31236, -28037, -23323, -17385, -10595, -3426, 3754, 10503, 16400, 21178, 24599, 26519, 26878, 25735, 23245, 19601, 15054, 9941, 4566, -754, -5734, -10112, -13688, -16248, -17778, -18170, -17496, -15842, -13355, -10178, -6567, -2734, 1074, 4645, 7773, 10325, 12152, 13212, 13453, 12887, 11609, 9730, 7368, 4695, 1866, -955, -3591, -5897, -7761, -9094, -9830, -9984, -9540, -8543, -7102, -5322, -3275, -1162, 948, 2921, 4627, 5999, 6964, 7495, 7565, 7219, 6458, 5353, 3980, 2485, 869, -682, -2146, -3404, -4435, -5141, -5498, -5531, -5238, -4648, -3815, -2820, -1692, -516, 627, 1667, 2594, 3294, 3786, 4008, 4025, 3760, 3327, 2689, 1928, 1081, 205, -662, -1423, -2079, -2593, -2926, -3083, -3037, -2846, -2493, -2031, -1455, -860, -187, 422, 1018, 1481, 1860, 2117, 2259, 2234, 2079, 1830, 1484, 1080, 634, 182, -289, -691, -1041, -1294, -1484, -1543, -1534, -1419, -1236, -965, -667, -345, -13, 305, 617, 877, 1073, 1180, 1257, 1231, 1149, 991, 812, 586, 327, 75, -159, -384, -577, -728, -814, -870, -849, -809, -703, -584, -426, -261, -67, 98, 244, 379, 470, 541, 554, 552, 498, 431, 335, 208, 77, -31, -169, -281, -391, -481, -546, -597, -608, -615, -602, -540, -467, -385, -291, -193, -113, -55, 5, 57, 99, 97, 95, 84, 40, -24, -120, -207, -312, -418, -528, -614, -701, -771, -799, -769, -726, -642, -534, -399, -256, -97, 76, 255, 424, 604, 757, 893, 995, 1051, 1063, 1041, 964, 860, 766, 681, 657, 731, 953, 1415, 2115, 3129, 4524, 6217, 8232, 10338, 12576, 13883, 14012, 14961, 14847, 13606, 11105, 7360, 2323};