/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1271 256 samples */
 
const int16_t AKWF_1271_256_DATA [256] = 
{1254, 3306, 5404, 7578, 9798, 12040, 14289, 16506, 18672, 20761, 22742, 24601, 26303, 27810, 29110, 30156, 30878, 31174, 30841, 29601, 16996, 11789, 16248, 16282, 15820, 15125, 14233, 13195, 12049, 10814, 9526, 8202, 6850, 5493, 4141, 2796, 1472, 171, -1107, -2345, -3556, -4727, -5861, -6957, -8005, -9002, -9955, -10851, -11681, -12447, -13144, -13756, -14290, -14728, -15068, -15316, -15443, -15462, -15373, -15155, -14825, -14383, -13825, -13164, -12394, -11543, -10624, -9634, -8604, -7551, -6490, -5454, -4467, -3550, -2735, -2048, -1525, -1194, -1090, -1258, -1742, -2604, -3958, -6060, -7843, -8715, -9015, -8845, -8288, -7412, -6264, -4913, -3394, -1752, -25, 1749, 3538, 5318, 7055, 8728, 10313, 11797, 13177, 14434, 15546, 16529, 17362, 18061, 18628, 19057, 19365, 19565, 19654, 19653, 19600, 19503, 19425, 19475, 19360, 22042, 28177, 26361, 24517, 23746, 23011, 22113, 22477, 16195, -10516, -10605, -7701, -9060, -10400, -11910, -13535, -15241, -17013, -18827, -20648, -22448, -24199, -25873, -27446, -28873, -30134, -31194, -32030, -32574, -32772, -32490, -31697, -29070, -14646, -11411, -14783, -14018, -12961, -11648, -10170, -8570, -6886, -5162, -3426, -1692, 3, 1651, 3236, 4721, 6131, 7439, 8632, 9724, 10691, 11548, 12288, 12910, 13421, 13824, 14109, 14291, 14374, 14359, 14240, 14042, 13754, 13388, 12945, 12428, 11854, 11214, 10531, 9802, 9042, 8255, 7458, 6649, 5852, 5076, 4329, 3632, 2993, 2434, 1975, 1614, 1393, 1315, 1407, 1698, 2208, 2985, 4073, 5661, 7586, 8821, 9432, 9599, 9375, 8821, 7971, 6875, 5564, 4074, 2433, 673, -1169, -3077, -5027, -6993, -8944, -10875, -12767, -14594, -16333, -18005, -19563, -21023, -22370, -23588, -24689, -25661, -26518, -27250, -27870, -28367, -28786, -29124, -29390, -29608, -29830, -30800, -21826, -7872, -5564, -4314, -2525, -636};