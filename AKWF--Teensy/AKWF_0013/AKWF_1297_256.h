/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1297 256 samples */
 
const int16_t AKWF_1297_256_DATA [256] = 
{18568, 18209, 17863, 17524, 17191, 16864, 16543, 16229, 15920, 15617, 15320, 15029, 14744, 14463, 14188, 13918, 13654, 13394, 13139, 12889, 12644, 12404, 12168, 11936, 11710, 11487, 11269, 11055, 10844, 10638, 10436, 10237, 10042, 9852, 9665, 9481, 9300, 9123, 8949, 8780, 8613, 8449, 8288, 8131, 7976, 7824, 7675, 7530, 7386, 7246, 7109, 6973, 6840, 6711, 6583, 6457, 6334, 6215, 6096, 5980, 5867, 5755, 5645, 5538, 5433, 5329, 5227, 5129, 5031, 4936, 4841, 4750, 4659, 4571, 4484, 4399, 4314, 4232, 4152, 4073, 3996, 3920, 3846, 3772, 3700, 3630, 3560, 3493, 3426, 3361, 3297, 3235, 2691, 5311, -22238, -34352, -31051, -30938, -30351, -29773, -29207, -28652, -28107, -27573, -27048, -26533, -26030, -25535, -25048, -24573, -24106, -23647, -23198, -22756, -22323, -21900, -21483, -21074, -20674, -20281, -19895, -19518, -19145, -18781, -18425, -17927, -18308, -15302, 16507, 18777, 17716, 17524, 17191, 16864, 16543, 16229, 15920, 15617, 15320, 15029, 14744, 14463, 14188, 13918, 13654, 13394, 13139, 12889, 12644, 12404, 12168, 11936, 11710, 11487, 11269, 11055, 10844, 10638, 10436, 10237, 10042, 9852, 9665, 9481, 9300, 9123, 8949, 8780, 8613, 8449, 8288, 8131, 7976, 7824, 7675, 7530, 7386, 7246, 7109, 6973, 6840, 6711, 6583, 6457, 6334, 6215, 6096, 5980, 5867, 5755, 5645, 5538, 5433, 5329, 5227, 5129, 5031, 4936, 4841, 4750, 4659, 4571, 4484, 4399, 4314, 4232, 4152, 4073, 3996, 3920, 3846, 3772, 3700, 3630, 3560, 3493, 3426, 3361, 3297, 3235, 2691, 5311, -22238, -34352, -31051, -30938, -30351, -29773, -29207, -28652, -28107, -27573, -27048, -26533, -26030, -25535, -25048, -24573, -24106, -23647, -23198, -22756, -22323, -21900, -21483, -21074, -20674, -20281, -19895, -19518, -19145, -18781, -18425, -18074, -17731, -17390};