/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1264 256 samples */
 
const int16_t AKWF_1264_256_DATA [256] = 
{159, 453, 745, 1046, 1351, 1663, 1981, 2303, 2629, 2960, 3296, 3640, 3984, 4332, 4685, 5042, 5402, 5765, 6131, 6500, 6872, 7246, 7622, 7998, 8378, 8760, 9143, 9528, 9912, 10296, 10683, 11070, 11454, 11841, 12226, 12612, 12995, 13376, 13760, 14139, 14517, 14895, 15266, 15640, 16010, 16373, 16739, 17096, 17448, 17804, 18148, 18492, 18834, 19161, 19492, 19744, 19848, 21690, -7892, -34312, -30671, -30088, -29125, -28149, -27171, -26217, -25269, -24331, -23411, -22497, -21599, -20717, -19842, -18984, -18138, -17303, -16487, -15680, -14887, -14108, -13344, -12594, -11859, -11136, -10429, -9737, -9059, -8395, -7746, -7115, -6494, -5890, -5303, -4727, -4169, -3628, -3097, -2584, -2087, -1602, -1137, -683, -244, 176, 585, 978, 1357, 1721, 2069, 2403, 2725, 3028, 3320, 3597, 3860, 4109, 4344, 4564, 4775, 4968, 5148, 5316, 5470, 5610, 5740, 5857, 5960, 6050, 6132, 6200, 6255, 6299, 6333, 6356, 6366, 6367, 6357, 6339, 6308, 6269, 6221, 6162, 6095, 6022, 5936, 5844, 5744, 5636, 5522, 5399, 5271, 5136, 4992, 4848, 4674, 4601, 4491, 4165, 4013, 3829, 3645, 3458, 3268, 3074, 2876, 2679, 2476, 2271, 2065, 1856, 1649, 1437, 1225, 1015, 801, 588, 378, 166, -46, -255, -463, -672, -877, -1080, -1282, -1483, -1681, -1874, -2065, -2251, -2435, -2614, -2789, -2961, -3126, -3289, -3447, -3598, -3745, -3886, -4021, -4152, -4276, -4393, -4506, -4610, -4709, -4802, -4887, -4966, -5037, -5100, -5159, -5209, -5251, -5285, -5312, -5332, -5342, -5345, -5341, -5329, -5307, -5278, -5242, -5197, -5144, -5083, -5014, -4935, -4846, -4753, -4650, -4539, -4418, -4291, -4155, -4013, -3860, -3701, -3532, -3356, -3174, -2983, -2784, -2577, -2364, -2144, -1914, -1679, -1437, -1187, -931, -667, -398, -120};