/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1220 256 samples */
 
const int16_t AKWF_1220_256_DATA [256] = 
{914, 3765, 6173, 7948, 8881, 8897, 8106, 6811, 5439, 4424, 4053, 4396, 5353, 6719, 8301, 9938, 11530, 13040, 14462, 15826, 17201, 18661, 20285, 22141, 24222, 26432, 28551, 30232, 31120, 31006, 29974, 28418, 26883, 25860, 25620, 26139, 27127, 28153, 28805, 28830, 28173, 26912, 25183, 23102, 20762, 18224, 15511, 12651, 9678, 6629, 3611, 795, -1607, -3337, -4200, -4144, -3318, -2058, -784, 116, 390, -45, -1095, -2550, -4156, -5682, -6974, -7956, -8619, -9003, -9176, -9229, -9284, -9483, -9978, -10896, -12276, -14019, -15887, -17520, -18535, -18675, -17918, -16534, -15041, -14012, -13809, -14426, -15562, -16818, -17854, -18460, -18545, -18108, -17198, -15884, -14234, -12327, -10233, -8042, -5882, -3900, -2276, -1201, -820, -1192, -2224, -3656, -5090, -6087, -6348, -5801, -4618, -3099, -1562, -259, 663, 1133, 1148, 747, -11, -1053, -2299, -3636, -4936, -6038, -6757, -6919, -6412, -5254, -3644, -1975, -756, -377, -917, -2073, -3331, -4188, -4328, -3684, -2421, -830, 774, 2141, 3124, 3690, 3860, 3684, 3238, 2616, 1938, 1345, 1000, 1069, 1679, 2854, 4475, 6291, 7951, 9110, 9523, 9115, 8015, 6517, 4997, 3797, 3131, 3069, 3577, 4573, 5957, 7659, 9617, 11773, 14087, 16477, 18822, 20959, 22646, 23641, 23767, 23011, 21607, 19992, 18666, 18026, 18220, 19086, 20189, 21001, 21120, 20422, 19038, 17241, 15288, 13369, 11603, 10031, 8650, 7428, 6293, 5155, 3916, 2462, 712, -1349, -3663, -6024, -8121, -9610, -10228, -9923, -8886, -7483, -6119, -5118, -4681, -4868, -5632, -6861, -8431, -10239, -12206, -14296, -16507, -18835, -21284, -23831, -26386, -28797, -30839, -32241, -32784, -32376, -31154, -29501, -27988, -27140, -27170, -27899, -28884, -29653, -29891, -29503, -28444, -26817, -24801, -22549, -20189, -17791, -15362, -12897, -10360, -7704, -4915, -1949};