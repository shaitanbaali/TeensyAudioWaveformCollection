/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1214 256 samples */
 
const int16_t AKWF_1214_256_DATA [256] = 
{404, 1730, 3078, 4473, 5906, 7373, 8870, 10382, 11906, 13431, 14942, 16438, 17907, 19333, 20718, 22050, 23316, 24519, 25651, 26705, 27683, 28580, 29392, 30121, 30762, 31314, 31779, 32152, 32436, 32633, 32741, 32767, 32712, 32583, 32384, 32119, 31794, 31409, 30966, 30471, 29921, 29319, 28672, 27977, 27235, 26453, 25629, 24767, 23877, 22961, 22024, 21076, 20116, 19150, 18181, 17207, 16230, 15251, 14265, 13272, 12275, 11269, 10264, 9262, 8265, 7281, 6310, 5353, 4413, 3485, 2565, 1660, 764, -120, -990, -1848, -2688, -3506, -4302, -5070, -5809, -6525, -7221, -7901, -8577, -9250, -9924, -10599, -11272, -11942, -12608, -13263, -13902, -14524, -15122, -15698, -16255, -16797, -17332, -17871, -18411, -18959, -19510, -20058, -20598, -21123, -21627, -22108, -22562, -22988, -23390, -23773, -24144, -24510, -24878, -25248, -25619, -25984, -26331, -26651, -26931, -27165, -27350, -27484, -27571, -27616, -27626, -27609, -27570, -27515, -27445, -27358, -27248, -27110, -26934, -26715, -26449, -26137, -25785, -25398, -24987, -24559, -24119, -23671, -23215, -22748, -22265, -21763, -21232, -20668, -20066, -19421, -18738, -18023, -17282, -16531, -15779, -15034, -14305, -13596, -12907, -12242, -11599, -10971, -10359, -9753, -9147, -8539, -7923, -7295, -6660, -6013, -5355, -4691, -4013, -3323, -2625, -1917, -1204, -493, 215, 913, 1595, 2261, 2906, 3529, 4134, 4720, 5291, 5854, 6412, 6971, 7539, 8114, 8703, 9306, 9922, 10551, 11190, 11830, 12465, 13083, 13672, 14222, 14720, 15150, 15505, 15773, 15948, 16027, 16010, 15900, 15702, 15424, 15074, 14653, 14172, 13634, 13041, 12396, 11700, 10947, 10140, 9276, 8351, 7376, 6353, 5291, 4205, 3100, 1984, 871, -236, -1328, -2391, -3417, -4394, -5303, -6135, -6872, -7494, -7993, -8353, -8565, -8626, -8538, -8302, -7925, -7416, -6784, -6029, -5164, -4201, -3153, -2032, -816};