/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1202 256 samples */
 
const int16_t AKWF_1202_256_DATA [256] = 
{2269, 5545, 8696, 11769, 14719, 17525, 20158, 22582, 24786, 26750, 28448, 29878, 31025, 31883, 32453, 32734, 32731, 32455, 31915, 31129, 30112, 28887, 27480, 25908, 24203, 22395, 20504, 18567, 16613, 14662, 12751, 10903, 9136, 7485, 5962, 4586, 3375, 2338, 1486, 826, 358, 83, -1, 98, 371, 805, 1388, 2102, 2926, 3845, 4835, 5873, 6938, 8009, 9059, 10073, 11026, 11900, 12679, 13346, 13889, 14297, 14563, 14682, 14650, 14467, 14140, 13673, 13076, 12360, 11537, 10629, 9647, 8614, 7553, 6482, 5425, 4406, 3443, 2561, 1783, 1123, 601, 234, 34, 12, 177, 534, 1085, 1825, 2758, 3871, 5153, 6595, 8175, 9877, 11683, 13560, 15490, 17448, 19398, 21317, 23179, 24945, 26596, 28102, 29433, 30572, 31494, 32177, 32605, 32767, 32649, 32245, 31552, 30571, 29302, 27755, 25944, 23874, 21572, 19059, 16347, 13476, 10471, 7351, 4162, 932, -2315, -5531, -8691, -11770, -14720, -17525, -20158, -22582, -24787, -26750, -28449, -29878, -31025, -31883, -32453, -32734, -32731, -32455, -31915, -31129, -30112, -28887, -27480, -25908, -24204, -22395, -20504, -18567, -16613, -14662, -12751, -10903, -9137, -7486, -5963, -4586, -3376, -2339, -1487, -827, -359, -84, 0, -99, -372, -806, -1389, -2103, -2927, -3846, -4836, -5874, -6939, -8009, -9060, -10074, -11027, -11901, -12680, -13347, -13890, -14298, -14564, -14682, -14650, -14468, -14141, -13674, -13077, -12361, -11538, -10629, -9648, -8614, -7554, -6483, -5426, -4407, -3444, -2562, -1784, -1124, -602, -235, -35, -13, -178, -535, -1085, -1826, -2759, -3872, -5154, -6596, -8176, -9877, -11683, -13561, -15491, -17448, -19398, -21317, -23179, -24945, -26596, -28102, -29433, -30572, -31494, -32177, -32605, -32767, -32649, -32245, -31552, -30571, -29303, -27755, -25944, -23875, -21573, -19060, -16348, -13476, -10471, -7357, -4177, -888};