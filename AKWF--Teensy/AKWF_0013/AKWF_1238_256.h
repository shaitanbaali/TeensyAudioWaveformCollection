/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1238 256 samples */
 
const int16_t AKWF_1238_256_DATA [256] = 
{10374, 13421, 12792, 12864, 12821, 12772, 12717, 12655, 12587, 12513, 12435, 12350, 12259, 12163, 12063, 11956, 11844, 11726, 11604, 11478, 11345, 11208, 11067, 10920, 10769, 10411, 11525, 5374, -5334, -457, -1460, -1379, 7103, 9695, 8931, 8845, 8651, 8451, 8248, 8044, 7836, 7624, 7410, 7195, 6977, 6758, 6535, 6310, 6086, 5859, 5629, 5399, 5168, 4936, 4704, 4469, 4235, 4001, 3765, 3533, 3290, 3082, 3170, 3002, 2574, 2104, 1896, 1660, 1389, 1388, -266, -2247, -2046, -2095, -2153, -2305, -2306, -2305, -2306, -2306, -2314, -2266, -2596, -2823, -2587, -2421, -2248, -2078, -1911, -1748, -1587, -1430, -1278, -1130, -985, -844, -707, -573, -445, -319, -209, 43, 261, 193, 1210, 3271, 3352, 3550, 3727, 3870, 4116, 4446, 4569, 4693, 4807, 4908, 4998, 5077, 5144, 5200, 5240, 5236, 5446, 3814, -1928, -1827, -1811, -1847, 3137, 4961, 4862, 5153, 5382, 5610, 5836, 6059, 6281, 6503, 6722, 6939, 7154, 7365, 7575, 7783, 7987, 8189, 8387, 8582, 8775, 8965, 9151, 9334, 9511, 9482, 10928, 5105, -5439, -531, -1508, -1420, 8210, 11463, 10958, 11212, 11340, 11464, 11582, 11694, 11802, 11904, 12002, 12094, 12180, 12261, 12338, 12408, 12474, 12533, 12585, 12634, 12676, 12713, 12744, 12769, 12789, 12705, 13270, 10713, 2686, 3797, 4287, 4657, 4648, 4536, 4801, 5022, 5141, 5958, 2496, -2249, -1696, -1746, -1890, -2455, -2463, -2460, -2463, -2463, -2605, -1824, -7158, -13157, -12577, -12891, -13063, -13232, -13396, -13558, -13716, -13870, -14021, -14167, -14309, -14447, -14582, -14711, -14837, -14966, -15030, -15923, -16598, -15758, -20511, -30356, -29952, -30220, -30413, -30492, -31058, -32025, -32101, -32227, -32335, -32430, -32514, -32586, -32647, -32696, -32719, -32763, -32333, -31530, -7813, 351, -1443, -1082};