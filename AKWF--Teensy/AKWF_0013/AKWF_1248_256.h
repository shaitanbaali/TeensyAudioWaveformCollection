/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1248 256 samples */
 
const int16_t AKWF_1248_256_DATA [256] = 
{173, 506, 786, 1030, 1253, 1453, 1646, 1838, 2033, 2239, 2463, 2707, 2975, 3271, 3595, 3947, 4324, 4727, 5156, 5602, 6064, 6541, 7024, 7516, 8007, 8494, 8979, 9453, 9915, 10367, 10802, 11221, 11627, 12012, 12381, 12733, 13068, 13386, 13692, 13983, 14260, 14528, 14786, 15034, 15275, 15511, 15741, 15967, 16190, 16412, 16631, 16851, 17070, 17289, 17509, 17731, 17952, 18172, 18395, 18618, 18841, 19064, 19285, 19506, 19725, 19943, 20158, 20370, 20580, 20786, 20989, 21188, 21384, 21575, 21761, 21945, 22123, 22297, 22468, 22635, 22797, 22957, 23112, 23263, 23413, 23560, 23703, 23844, 23983, 24120, 24255, 24387, 24518, 24647, 24776, 24901, 25028, 25152, 25274, 25395, 25516, 25635, 25753, 25869, 25984, 26098, 26210, 26321, 26430, 26537, 26643, 26748, 26850, 26951, 27051, 27149, 27245, 27339, 27432, 27523, 27614, 27701, 27785, 27858, 27911, 27927, 27888, 27770, 27542, 27167, 26585, 25715, 24440, 22575, 19832, 15799, 9805, 605, -9441, -16881, -22161, -25798, -28255, -29883, -30950, -31650, -32107, -32402, -32589, -32701, -32756, -32765, -32728, -32643, -32499, -32277, -31950, -31475, -30800, -29856, -28559, -26834, -24609, -21856, -18632, -15065, -11396, -7949, -5053, -3011, -2022, -2127, -3234, -5129, -7563, -10267, -12997, -15600, -17960, -20017, -21766, -23214, -24383, -25312, -26029, -26564, -26944, -27186, -27306, -27313, -27217, -27021, -26727, -26337, -25851, -25271, -24599, -23839, -22996, -22086, -21117, -20108, -19085, -18062, -17066, -16126, -15254, -14474, -13802, -13246, -12812, -12499, -12306, -12217, -12228, -12324, -12487, -12701, -12956, -13230, -13513, -13793, -14058, -14298, -14505, -14671, -14792, -14862, -14877, -14836, -14732, -14568, -14340, -14050, -13695, -13279, -12803, -12269, -11679, -11037, -10356, -9636, -8881, -8107, -7319, -6524, -5738, -4966, -4219, -3504, -2829, -2198, -1620, -1091, -618, -188};