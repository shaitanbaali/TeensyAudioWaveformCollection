/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1229 256 samples */
 
const int16_t AKWF_1229_256_DATA [256] = 
{836, 2388, 3874, 5327, 6734, 8092, 9397, 10641, 11822, 12939, 13987, 14967, 15877, 16715, 17485, 18188, 18821, 19391, 19900, 20347, 20738, 21074, 21359, 21599, 21795, 21950, 22068, 22153, 22208, 22235, 22235, 22212, 22167, 22102, 22021, 21923, 21812, 21690, 21559, 21420, 21279, 21135, 20989, 20845, 20702, 20563, 20429, 20299, 20178, 20063, 19957, 19859, 19771, 19694, 19627, 19572, 19527, 19490, 19461, 19438, 19419, 19404, 19387, 19367, 19345, 19314, 19276, 19229, 19167, 19092, 19000, 18888, 18755, 18598, 18417, 18206, 17969, 17703, 17407, 17084, 16735, 16359, 15957, 15535, 15091, 14626, 14146, 13650, 13139, 12618, 12085, 11543, 10996, 10441, 9884, 9324, 8762, 8203, 7648, 7097, 6559, 6032, 5524, 5039, 4580, 4148, 3750, 3385, 3056, 2765, 2511, 2293, 2113, 1969, 1861, 1787, 1745, 1734, 1750, 1792, 1857, 1940, 2039, 2152, 2271, 2396, 2521, 2642, 2757, 2860, 2949, 3021, 3072, 3098, 3100, 3072, 3015, 2928, 2809, 2656, 2471, 2255, 2004, 1722, 1409, 1065, 692, 293, -134, -585, -1058, -1553, -2067, -2597, -3143, -3701, -4270, -4848, -5431, -6019, -6608, -7198, -7786, -8370, -8946, -9515, -10072, -10615, -11145, -11657, -12148, -12618, -13064, -13484, -13877, -14242, -14576, -14879, -15151, -15390, -15597, -15772, -15913, -16024, -16104, -16154, -16175, -16171, -16139, -16083, -16006, -15908, -15792, -15668, -15541, -15427, -15343, -15302, -15322, -15417, -15604, -15891, -16284, -16782, -17382, -18073, -18846, -19688, -20582, -21521, -22488, -23466, -24451, -25425, -26375, -27297, -28174, -28998, -29762, -30454, -31065, -31594, -32028, -32366, -32604, -32737, -32766, -32687, -32505, -32218, -31828, -31341, -30757, -30080, -29317, -28469, -27541, -26541, -25468, -24327, -23129, -21867, -20553, -19192, -17782, -16332, -14849, -13328, -11784, -10221, -8637, -7045, -5450, -3855, -2274, -675};