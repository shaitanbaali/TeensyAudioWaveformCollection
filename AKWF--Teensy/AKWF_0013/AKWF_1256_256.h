/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1256 256 samples */
 
const int16_t AKWF_1256_256_DATA [256] = 
{1096, 3148, 5087, 6965, 8779, 10532, 12228, 13861, 15440, 16967, 18437, 19858, 21230, 22548, 23819, 25040, 26206, 27323, 28382, 29376, 30309, 31161, 31904, 32480, 32754, 32433, 31104, 28918, 26341, 23617, 20881, 18184, 15547, 12992, 10516, 8115, 5802, 3566, 1404, -677, -2685, -4622, -6480, -8266, -9973, -11587, -13101, -14490, -15716, -16742, -17520, -18013, -18205, -18097, -17711, -17040, -16067, -14776, -13178, -11334, -9322, -7212, -5073, -2945, -851, 1188, 3168, 5090, 6942, 8732, 10459, 12117, 13710, 15240, 16697, 18086, 19403, 20630, 21759, 22755, 23556, 24051, 24016, 23115, 21389, 19210, 16831, 14374, 11921, 9512, 7154, 4861, 2637, 485, -1589, -3592, -5529, -7392, -9184, -10906, -12563, -14176, -15746, -17260, -18726, -20142, -21503, -22807, -24049, -25227, -26339, -27358, -28245, -28927, -29259, -28859, -27328, -25052, -22484, -19813, -17153, -14550, -12011, -9555, -7181, -4881, -2662, -521, 1553, 3551, 5481, 7350, 9149, 10888, 12570, 14191, 15759, 17274, 18732, 20142, 21502, 22808, 24067, 25277, 26429, 27529, 28571, 29549, 30459, 31286, 32003, 32543, 32771, 32385, 30995, 28785, 26202, 23479, 20746, 18054, 15421, 12870, 10398, 8003, 5694, 3463, 1305, -772, -2779, -4716, -6578, -8372, -10098, -11746, -13324, -14824, -16234, -17555, -18774, -19884, -20887, -21775, -22550, -23204, -23700, -23965, -23862, -23158, -21757, -19847, -17647, -15307, -12914, -10537, -8201, -5919, -3710, -1567, 506, 2503, 4433, 6294, 8083, 9807, 11463, 13045, 14555, 15977, 17282, 18427, 19306, 19696, 19170, 17642, 15562, 13252, 10877, 8517, 6197, 3935, 1744, -378, -2422, -4397, -6306, -8144, -9909, -11605, -13239, -14829, -16376, -17868, -19313, -20709, -22051, -23335, -24559, -25721, -26814, -27817, -28688, -29354, -29667, -29280, -27840, -25620, -23064, -20389, -17716, -15096, -12540, -10066, -7674, -5361, -3132, -936};