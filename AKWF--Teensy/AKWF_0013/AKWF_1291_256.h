/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1291 256 samples */
 
const int16_t AKWF_1291_256_DATA [256] = 
{10895, 15941, 14686, 14583, 14306, 14034, 13768, 13506, 13249, 12997, 12750, 12508, 12269, 12036, 11807, 11582, 11363, 11147, 10935, 10727, 10523, 10322, 10126, 9934, 9745, 9559, 9377, 9199, 9025, 8853, 8684, 8519, 8357, 8199, 8043, 7890, 7739, 7592, 7448, 7306, 7167, 7031, 6897, 6766, 6638, 6511, 6388, 6266, 6147, 6030, 5906, 5775, 5821, 2240, -2516, 3180, 5990, 5315, 5313, 5212, 5112, 5014, 4919, 4826, 4734, 4644, 4556, 4470, 4384, 4301, 4219, 4139, 4060, 3983, 3907, 3833, 3760, 3688, 3618, 3550, 3482, 3416, 3351, 3287, 3225, 3163, 3103, 3043, 2986, 2929, 2874, 2819, 2766, 2713, 2661, 2611, 2561, 2512, 2464, 2417, 2372, 2326, 2282, 2239, 2196, 2155, 2113, 2073, 2033, 1995, 1957, 1919, 1883, 1848, 1812, 1778, 1744, 1711, 1678, 1646, 1615, 1585, 1554, 1525, 1496, 1467, 1439, 1411, 1385, 1359, 1332, 1307, 1282, 1258, 1234, 1211, 1187, 1165, 1143, 1121, 1100, 1079, 1058, 1038, 1018, 999, 980, 961, 943, 925, 907, 890, 873, 857, 840, 824, 809, 793, 778, 763, 749, 734, 721, 707, 694, 680, 667, 655, 641, 630, 618, 606, 595, 583, 572, 561, 550, 540, 529, 472, 714, -929, -4209, -220, 790, 546, 574, 563, 552, 542, 531, 521, 511, 501, 492, 482, 473, 464, 456, 447, 438, 430, 421, 413, 406, 398, 390, 383, 375, 368, 362, 354, 348, 342, 335, 328, 322, 316, 309, 304, 298, 176, 624, -1681, -15899, -28896, -32952, -31950, -31436, -30843, -30256, -29682, -29117, -28563, -28021, -27487, -26965, -26452, -25949, -25455, -24972, -24497, -24031, -23574, -23126, -22686, -22255, -21832, -21417, -21009, -20610, -20218, -19833, -19252, -19993, -13128};