/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1206 256 samples */
 
const int16_t AKWF_1206_256_DATA [256] = 
{177, 851, 1581, 2422, 3445, 4764, 6514, 8705, 11070, 13182, 14827, 16073, 17051, 17863, 18578, 19231, 19844, 20434, 21006, 21562, 22110, 22649, 23176, 23693, 24193, 24670, 25117, 25511, 25823, 26002, 25957, 25563, 24706, 23477, 22250, 21400, 21011, 20970, 21151, 21464, 21860, 22306, 22784, 23285, 23801, 24329, 24867, 25415, 25960, 26287, 28427, -125, -8431, -5692, -5238, -4368, -2609, -2729, -29721, -30469, -27469, -25885, -24571, -23551, -22710, -21980, -21318, -20695, -20103, -19530, -18969, -18420, -17879, -17349, -16832, -16328, -15843, -15391, -14983, -14651, -14440, -14432, -14746, -15505, -16683, -17949, -18889, -19364, -19464, -19320, -19027, -18645, -18208, -17734, -17237, -16723, -16197, -15661, -15116, -14559, -13992, -13407, -12798, -12154, -11453, -10662, -9723, -8537, -6973, -4947, -2598, -341, 1492, 2883, 3953, 4821, 5570, 6244, 6871, 7469, 8047, 8609, 9162, 9703, 10234, 10757, 11263, 11751, 12212, 12630, 12980, 13220, 13277, 13040, 11740, 14023, -6394, -29021, -26137, -26947, -26842, -26574, -26207, -25777, -25311, -24817, -24307, -23784, -23249, -22705, -22152, -21586, -21004, -20402, -19765, -19079, -18310, -17405, -16279, -14804, -12865, -10554, -8247, -6313, -4844, -3722, -2818, -2052, -1366, -730, -128, 452, 1019, 1572, 2115, 2650, 3172, 3683, 4176, 4643, 5071, 5438, 5705, 5806, 5637, 5067, 4032, 2748, 1642, 983, 749, 811, 1052, 1404, 1822, 2283, 2771, 3279, 3800, 4332, 4874, 5426, 5989, 6567, 7165, 7792, 8468, 9218, 10088, 11162, 12559, 14397, 16659, 19005, 21025, 22585, 23766, 24702, 25493, 25909, 28125, 22096, -7554, -6535, -5974, -5471, -4935, -4409, -3896, -3400, -2926, -2490, -2108, -1817, -1676, -1779, -2260, -3207, -4474, -5649, -6402, -6710, -6698, -6485, -6152, -5744, -5291, -4807, -4303, -3784, -3253, -2713, -2164, -1604, -1032, -427};