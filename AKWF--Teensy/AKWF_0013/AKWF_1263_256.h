/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1263 256 samples */
 
const int16_t AKWF_1263_256_DATA [256] = 
{26216, 30103, 28372, 27771, 27007, 26249, 25487, 24810, 24057, 23310, 22568, 21829, 21098, 20372, 19652, 18938, 18231, 17530, 16835, 16150, 15469, 14798, 14136, 13479, 12832, 12193, 11561, 10941, 10330, 9727, 9134, 8551, 7976, 7413, 6861, 6317, 5784, 5262, 4751, 4251, 3761, 3282, 2817, 2362, 1917, 1484, 1064, 653, 256, -129, -503, -865, -1216, -1553, -1880, -2195, -2497, -2787, -3063, -3330, -3584, -3826, -4055, -4274, -4481, -4674, -4857, -5027, -5186, -5333, -5470, -5594, -5708, -5811, -5902, -5981, -6051, -6109, -6157, -6193, -6220, -6238, -6244, -6240, -6228, -6205, -6174, -6133, -6083, -6024, -5957, -5880, -5797, -5706, -5606, -5499, -5385, -5263, -5135, -4999, -4858, -4710, -4556, -4396, -4231, -4063, -3887, -3708, -3524, -3336, -3143, -2948, -2748, -2546, -2341, -2133, -1922, -1710, -1498, -1282, -1065, -848, -629, -410, -191, 28, 246, 464, 681, 897, 1111, 1325, 1535, 1743, 1951, 2155, 2355, 2553, 2747, 2938, 3124, 3305, 3484, 3658, 3827, 3990, 4148, 4301, 4448, 4589, 4724, 4852, 4975, 5090, 5200, 5301, 5395, 5483, 5562, 5634, 5699, 5752, 5801, 5840, 5870, 5893, 5908, 5912, 5909, 5894, 5871, 5842, 5800, 5749, 5691, 5621, 5544, 5454, 5357, 5249, 5131, 5002, 4867, 4718, 4562, 4396, 4218, 4032, 3836, 3629, 3413, 3186, 2951, 2706, 2451, 2186, 1912, 1628, 1336, 1033, 721, 399, 70, -268, -615, -973, -1338, -1711, -2093, -2483, -2883, -3289, -3703, -4126, -4555, -4992, -5436, -5887, -6345, -6811, -7281, -7759, -8243, -8732, -9228, -9728, -10235, -10748, -11263, -11784, -12311, -12840, -13374, -13914, -14454, -14999, -15548, -16098, -16654, -17210, -17768, -18330, -18893, -19457, -20022, -20589, -21156, -21725, -22292, -22850, -23437, -23997, -24562, -24986, -26363, -23127};