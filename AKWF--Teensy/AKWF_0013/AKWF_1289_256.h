/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1289 256 samples */
 
const int16_t AKWF_1289_256_DATA [256] = 
{206, 570, 927, 1286, 1641, 1997, 2354, 2709, 3061, 3404, 3754, 4105, 4455, 4801, 5146, 5493, 5832, 6171, 6510, 6846, 7176, 7508, 7828, 8149, 8470, 8792, 9111, 9419, 9731, 10041, 10339, 10641, 10943, 11230, 11521, 11809, 12082, 12356, 12635, 12909, 13168, 13434, 13698, 13949, 14195, 14447, 14692, 14922, 15159, 15390, 15604, 15822, 16046, 16259, 16457, 16667, 16872, 17056, 17248, 17440, 17611, 17789, 17969, 18127, 18284, 18452, 18612, 18751, 18902, 19053, 19183, 19313, 19452, 19579, 19689, 19814, 19932, 20028, 20135, 20247, 20342, 20426, 20526, 20619, 20688, 20771, 20859, 20923, 20986, 21063, 21115, 21168, 21235, 21291, 21326, 21381, 21435, 21465, 21502, 21550, 21581, 21601, 21639, 21672, 21681, 21705, 21735, 21748, 21755, 21780, 21797, 21792, 21807, 21825, 21820, 21821, 21836, 21837, 21826, 21836, 21843, 21828, 21828, 21836, 21829, 21816, 21117, 24528, -2793, -10251, -25482, -19350, -22181, -21342, -21745, -21710, -21805, -21850, -21889, -21923, -21957, -21976, -21986, -21998, -21982, -21979, -21986, -21986, -21964, -21954, -21947, -21919, -21890, -21873, -21845, -21798, -21769, -21737, -21681, -21634, -21596, -21543, -21476, -21427, -21373, -21295, -21230, -21167, -21078, -21002, -20931, -20841, -20745, -20664, -20571, -20457, -20361, -20263, -20142, -20024, -19916, -19793, -19654, -19533, -19408, -19257, -19116, -18980, -18824, -18660, -18510, -18352, -18171, -18003, -17836, -17646, -17458, -17279, -17091, -16881, -16686, -16487, -16265, -16050, -15840, -15613, -15376, -15152, -14922, -14669, -14427, -14190, -13936, -13672, -13422, -13150, -12876, -12612, -12337, -12046, -11767, -11486, -11186, -10890, -10600, -10304, -9991, -9689, -9382, -9059, -8742, -8428, -8100, -7770, -7447, -7117, -6776, -6442, -6114, -5775, -5431, -5092, -4744, -4392, -4046, -3698, -3342, -2988, -2637, -2281, -1922, -1567, -1222, -864, -507, -144};