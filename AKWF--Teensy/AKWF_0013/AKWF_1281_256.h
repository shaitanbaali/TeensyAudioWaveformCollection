/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1281 256 samples */
 
const int16_t AKWF_1281_256_DATA [256] = 
{1149, 3083, 5078, 7179, 9329, 11484, 13601, 15631, 17548, 19315, 20900, 22285, 23448, 24375, 25081, 25581, 25898, 26053, 26065, 25958, 25736, 25399, 24945, 24368, 23666, 22836, 21873, 20778, 19550, 18185, 16685, 15044, 13257, 11331, 9287, 7196, 5159, 3251, 1550, 71, -1299, -2703, -4209, -5795, -7415, -9005, -10538, -11980, -13321, -14536, -15579, -16393, -16980, -17386, -17656, -17813, -17790, -17555, -17071, -16467, -15722, -14870, -13690, -12218, -10425, -8616, -6784, -4967, -3032, -1027, 683, 1966, 2676, 3852, 5419, 8012, 9993, 11718, 12154, 13571, 15434, 18142, 21746, 12185, 2055, 7200, 6086, 5401, 4769, 4425, 4295, 4206, 4051, 3770, 3333, 2728, 1965, 1061, 14, -1151, -2357, -3542, -4757, -6045, -7456, -8942, -10787, -13709, -16647, -19506, -22229, -24800, -27067, -31062, -27370, -14790, -17769, -17850, -18691, -19539, -20414, -21264, -22051, -22732, -23288, -23720, -24031, -24230, -24317, -24277, -24090, -23736, -23204, -22479, -21546, -20405, -19046, -17464, -15661, -13680, -11651, -9715, -7928, -6228, -4506, -2672, -735, 1253, 3262, 5248, 7168, 9001, 10711, 12268, 13656, 14851, 15838, 16614, 17190, 17587, 17823, 17915, 17881, 17738, 17463, 16970, 16207, 15146, 13794, 12276, 10771, 9281, 7656, 5871, 3992, 2100, 268, -1453, -3003, -4350, -5503, -6468, -7233, -7776, -8065, -8080, -7798, -7208, -6296, -5060, -3606, -2099, -615, 928, 2658, 4599, 6697, 8912, 11234, 13643, 16035, 18194, 20025, 21526, 22701, 23579, 24198, 24590, 24778, 24744, 24683, 22661, 16600, 13729, 13201, 12920, 12463, 11627, 10471, 9147, 7736, 6263, 4747, 3241, 1815, 542, -510, -1388, -2297, -3446, -4816, -6309, -7857, -9398, -10874, -12248, -13476, -14524, -15373, -16014, -16461, -16736, -16849, -16799, -16570, -16147, -15519, -14671, -13597, -12291, -10745, -8957, -6944, -4806, -2698, -685};