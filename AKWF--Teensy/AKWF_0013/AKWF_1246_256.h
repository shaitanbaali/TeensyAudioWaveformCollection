/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1246 256 samples */
 
const int16_t AKWF_1246_256_DATA [256] = 
{1091, 2728, 4306, 5857, 7365, 8824, 10229, 11577, 12870, 14101, 15270, 16374, 17420, 18410, 19351, 20233, 21066, 21860, 22614, 23327, 24011, 24656, 25276, 25868, 26434, 26977, 27499, 27995, 28470, 28923, 29351, 29755, 30131, 30486, 30817, 31122, 31402, 31653, 31876, 32078, 32251, 32397, 32520, 32620, 32487, 33328, 30612, -15111, -21013, -18676, -18241, -17393, -16424, -15349, -14191, -12930, -11585, -10168, -8682, -7149, -5589, -3978, -2357, -727, 891, 2495, 4078, 5630, 7138, 8596, 10000, 11349, 12640, 13871, 15039, 16143, 17190, 18180, 19118, 20004, 20837, 21627, 22382, 23096, 23778, 24427, 25044, 25635, 26201, 26745, 27268, 27765, 28237, 28690, 29117, 29521, 29902, 30255, 30584, 30889, 31169, 31421, 31644, 31845, 32019, 32164, 32288, 32387, 32462, 32510, 32534, 32537, 32514, 32465, 32383, 32275, 32137, 31954, 31734, 31466, 31147, 30766, 30320, 29798, 29200, 28514, 27731, 26845, 25849, 24745, 23522, 22176, 20712, 19123, 17415, 15604, 13681, 11649, 9535, 7342, 5096, 2815, 499, -1835, -4147, -6438, -8650, -10816, -12901, -14879, -16742, -18471, -20058, -21518, -22859, -24081, -25177, -26135, -26972, -27678, -28258, -28713, -29048, -29271, -29392, -29415, -29346, -29197, -28972, -28680, -28330, -27928, -27484, -27004, -26489, -25950, -25393, -24822, -24244, -23661, -23076, -22494, -21917, -21349, -20794, -20248, -19710, -19187, -18675, -18172, -17678, -17190, -16704, -16219, -15733, -15239, -14733, -14212, -13670, -13105, -12516, -11892, -11232, -10533, -9790, -9008, -8186, -7311, -6394, -5434, -4433, -3408, -2347, -1258, -158, 953, 2058, 3141, 4214, 5247, 6233, 7155, 8012, 8788, 9474, 10062, 10545, 10913, 11169, 11308, 11327, 11229, 11019, 10700, 10278, 9759, 9076, 8572, 7470, -14639, -20960, -18916, -18427, -17566, -16595, -15518, -14350, -13084, -11737, -10326, -8837, -7302, -5732, -4121, -2510, -852};