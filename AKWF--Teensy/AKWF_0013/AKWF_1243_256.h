/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1243 256 samples */
 
const int16_t AKWF_1243_256_DATA [256] = 
{566, 1626, 2534, 3353, 4087, 4710, 5284, 5846, 6365, 6888, 7425, 7940, 8534, 9198, 9853, 10424, 10874, 11275, 11667, 11987, 12282, 12605, 12928, 13179, 13343, 13441, 13492, 13530, 13579, 13617, 13616, 13602, 13584, 13560, 13523, 13478, 13416, 13358, 13299, 13196, 13074, 12936, 12836, 12781, 12749, 12752, 12797, 12855, 12946, 13067, 13223, 13410, 13591, 13425, 15368, 5318, -12975, -9898, -8267, -6584, -4979, -3473, -2052, -726, 463, 1494, 2404, 3224, 3955, 4578, 5149, 5710, 6228, 6749, 7285, 7799, 8393, 9056, 9710, 10280, 10730, 11131, 11521, 11841, 12138, 12459, 12781, 13033, 13197, 13294, 13344, 13382, 13432, 13468, 13468, 13454, 13435, 13412, 13375, 13329, 13267, 13209, 13150, 13047, 12925, 12787, 12687, 12633, 12600, 12603, 12648, 12707, 12798, 12918, 13075, 13262, 13443, 13611, 13743, 13834, 13889, 13934, 13986, 14050, 14164, 14355, 14584, 14836, 15084, 15320, 15539, 15725, 15869, 15977, 16054, 16108, 16101, 16042, 15966, 15846, 15673, 15482, 15270, 15018, 14777, 14555, 14307, 13400, 16672, -9159, -30824, -26263, -26063, -25151, -24351, -23684, -23103, -22558, -21975, -21384, -20764, -20131, -19547, -19007, -18502, -18033, -17593, -17147, -16655, -16168, -15759, -15405, -14936, -15287, -6046, 314, -1237, -1442, -1806, -2121, -2419, -2732, -3059, -3381, -3688, -3946, -4156, -4350, -4553, -4801, -5057, -5283, -5481, -5628, -5723, -5838, -6020, -6213, -6378, -6513, -6633, -6773, -6939, -7113, -7292, -7461, -7597, -7687, -7737, -7812, -7971, -8149, -8332, -8514, -8635, -8689, -8713, -8764, -8839, -8908, -8981, -9080, -9187, -9298, -9426, -9460, -9404, -9332, -9295, -9305, -9372, -9516, -9716, -9930, -10142, -10327, -10482, -10642, -10841, -11115, -11423, -11715, -11996, -12229, -12424, -12544, -13199, -10683, -11073, -10381, -8288, -6603, -4995, -3492, -2076, -730};