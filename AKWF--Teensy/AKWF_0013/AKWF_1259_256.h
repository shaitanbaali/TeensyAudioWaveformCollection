/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1259 256 samples */
 
const int16_t AKWF_1259_256_DATA [256] = 
{2571, 7756, 11493, 13321, 13837, 14231, 14950, 15892, 16896, 17876, 18796, 19659, 20469, 21230, 21953, 22641, 23299, 23931, 24538, 25121, 25684, 26225, 26746, 27247, 27728, 28189, 28632, 29056, 29462, 29850, 30221, 30577, 30922, 31224, 31468, 31673, 31846, 31997, 32129, 32247, 32355, 32452, 32541, 32622, 32697, 32757, 32766, 32735, 32674, 32587, 32477, 32344, 32193, 32021, 31829, 31617, 31383, 31129, 30853, 30553, 30229, 29879, 29502, 29099, 28664, 28201, 27702, 27155, 26517, 25456, 23027, 19547, 14361, 10101, 8686, 5861, 41, -5129, -8346, -10566, -12299, -13775, -15077, -16321, -17630, -18931, -20100, -21099, -21944, -22673, -23323, -23913, -24455, -24962, -25435, -25877, -26291, -26697, -27209, -27845, -28474, -28999, -29406, -29716, -29961, -30164, -30336, -30488, -30621, -30738, -30843, -30932, -31009, -31074, -31126, -31168, -31199, -31217, -31225, -31225, -31214, -31192, -31162, -31124, -31075, -31019, -30955, -30882, -30802, -30713, -30616, -30511, -30400, -30279, -30152, -30006, -29788, -29477, -29136, -28817, -28539, -28297, -28073, -27858, -27643, -27418, -27131, -26724, -26240, -25765, -25336, -24951, -24598, -24256, -23912, -23559, -23197, -22825, -22455, -22110, -21774, -21323, -20704, -19900, -18755, -17095, -14832, -11712, -6958, -1736, 2675, 6139, 8877, 11002, 12530, 13516, 14122, 14541, 14910, 15295, 15707, 16133, 16559, 16978, 17379, 17758, 18116, 18452, 18765, 19057, 19327, 19576, 19805, 20013, 20200, 20368, 20514, 20642, 20720, 20651, 20440, 20192, 19992, 19857, 19766, 19693, 19618, 19529, 19413, 19261, 19062, 18800, 18440, 17928, 17185, 16149, 14894, 13678, 12588, 11279, 8575, 3708, -880, -4073, -6159, -7672, -9070, -10563, -12069, -13425, -14542, -15416, -16100, -16640, -17074, -17429, -17721, -17959, -18152, -18304, -18415, -18488, -18522, -18517, -18475, -18398, -18296, -18186, -18098, -18071, -18072, -17859, -16938, -14821, -10281, -3420};