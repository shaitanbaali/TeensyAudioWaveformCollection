/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1231 256 samples */
 
const int16_t AKWF_1231_256_DATA [256] = 
{3844, 10882, 14795, 16057, 18330, 20739, 22352, 23545, 24692, 25715, 26540, 27233, 27846, 28379, 28838, 29236, 29586, 29894, 30165, 30404, 30616, 30806, 30973, 31125, 31261, 31383, 31492, 31593, 31683, 31765, 31839, 31908, 31970, 32027, 32079, 32127, 32170, 32211, 32250, 32284, 32316, 32345, 32373, 32399, 32422, 32444, 32465, 32484, 32502, 32518, 32534, 32548, 32561, 32575, 32586, 32597, 32607, 32617, 32626, 32635, 32642, 32650, 32656, 32663, 32668, 32674, 32679, 32684, 32687, 32692, 32695, 32697, 32700, 32702, 32703, 32705, 32706, 32705, 32706, 32705, 32703, 32701, 32699, 32694, 32689, 32683, 32675, 32665, 32652, 32632, 32593, 32528, 32445, 32342, 32206, 32033, 31813, 31538, 31191, 30756, 30214, 29540, 28705, 27679, 26421, 24886, 23036, 20806, 18143, 14996, 11280, 6936, 1922, -3884, -10533, -14301, -15680, -17972, -20343, -21967, -23198, -24366, -25409, -26259, -26975, -27609, -28163, -28640, -29056, -29421, -29743, -30027, -30278, -30501, -30700, -30878, -31037, -31180, -31309, -31425, -31529, -31624, -31711, -31790, -31862, -31927, -31987, -32043, -32093, -32139, -32182, -32222, -32259, -32292, -32324, -32353, -32380, -32405, -32428, -32450, -32470, -32489, -32507, -32524, -32539, -32554, -32567, -32580, -32592, -32603, -32613, -32624, -32633, -32642, -32651, -32658, -32665, -32673, -32679, -32686, -32691, -32697, -32702, -32707, -32712, -32716, -32721, -32725, -32728, -32731, -32735, -32738, -32741, -32744, -32747, -32749, -32751, -32754, -32756, -32757, -32759, -32761, -32762, -32763, -32764, -32765, -32766, -32767, -32766, -32767, -32768, -32768, -32767, -32766, -32767, -32766, -32765, -32763, -32763, -32761, -32759, -32756, -32754, -32751, -32746, -32743, -32737, -32731, -32724, -32716, -32708, -32696, -32682, -32661, -32621, -32553, -32463, -32351, -32203, -32012, -31768, -31457, -31063, -30566, -29938, -29151, -28174, -26959, -25464, -23640, -21418, -18746, -15554, -11770, -7335, -2010};