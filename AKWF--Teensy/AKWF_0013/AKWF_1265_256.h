/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1265 256 samples */
 
const int16_t AKWF_1265_256_DATA [256] = 
{13519, 17788, 20319, 25502, 30507, 32834, 31326, 27007, 22091, 18763, 17829, 18532, 19318, 18899, 16965, 14209, 11726, 10283, 9937, 10119, 10079, 9374, 8067, 6598, 5459, 4884, 4757, 4742, 4520, 3968, 3206, 2470, 1953, 1701, 1604, 1491, 1243, 851, 401, 8, -260, -418, -532, -680, -901, -1173, -1447, -1678, -1842, -1964, -2078, -2215, -2383, -2562, -2730, -2868, -2974, -3063, -3152, -3251, -3359, -3465, -3557, -3631, -3688, -3737, -3787, -3837, -3887, -3930, -3964, -3985, -3997, -4003, -4007, -4009, -4008, -3999, -3982, -3958, -3927, -3892, -3855, -3812, -3766, -3714, -3656, -3594, -3525, -3453, -3378, -3299, -3217, -3131, -3040, -2945, -2848, -2746, -2643, -2537, -2428, -2315, -2200, -2083, -1963, -1842, -1720, -1595, -1467, -1340, -1211, -1080, -948, -816, -683, -550, -415, -281, -146, -13, 120, 252, 385, 517, 649, 780, 908, 1037, 1162, 1287, 1408, 1529, 1648, 1764, 1879, 1991, 2101, 2207, 2310, 2412, 2509, 2604, 2694, 2781, 2865, 2945, 3022, 3095, 3163, 3227, 3289, 3343, 3394, 3442, 3485, 3523, 3555, 3583, 3606, 3625, 3637, 3644, 3649, 3645, 3638, 3624, 3607, 3582, 3553, 3517, 3477, 3431, 3378, 3320, 3257, 3189, 3114, 3033, 2947, 2856, 2758, 2655, 2546, 2431, 2311, 2186, 2053, 1916, 1773, 1625, 1471, 1312, 1146, 976, 800, 619, 433, 241, 44, -156, -362, -574, -790, -1011, -1237, -1468, -1703, -1942, -2186, -2434, -2687, -2942, -3203, -3467, -3735, -4006, -4282, -4559, -4841, -5126, -5415, -5705, -5998, -6295, -6594, -6895, -7199, -7505, -7813, -8124, -8437, -8749, -9065, -9382, -9699, -10018, -10339, -10659, -10981, -11304, -11627, -11950, -12274, -12597, -12920, -13243, -13565, -13889, -14209, -14523, -14855, -15169, -15483, -15722, -16487, -14694};