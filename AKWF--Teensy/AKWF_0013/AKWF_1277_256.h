/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1277 256 samples */
 
const int16_t AKWF_1277_256_DATA [256] = 
{16608, 17047, 17474, 17901, 18325, 18748, 19170, 19590, 20009, 20181, 21903, 15676, -3172, -2474, -2043, -1680, -1276, -876, -476, -135, 608, -766, -1872, 20515, 23453, 23150, 23646, 24008, 24365, 24719, 25067, 25410, 25563, 26876, 22583, 2504, 2336, 2852, 3096, 3402, 3640, 4278, 2903, 449, -839, 8291, 27194, 25755, 26310, 26577, 26825, 27066, 27300, 27529, 27750, 27968, 28178, 28382, 28582, 28775, 28962, 29166, 29074, 30520, 27583, 23801, 24710, 24723, 24865, 25001, 25133, 25259, 25379, 25493, 25602, 25705, 25761, 25798, 26525, 7535, 296, 1940, 1718, 1785, 1848, 1906, 1959, 2009, 2055, 2095, 2133, 2165, 2192, 2217, 2237, 2255, 2267, 2277, 2282, 2284, 2282, 2277, 2269, 2257, 2226, 2291, 1944, -1120, -1401, -1360, -1405, -1439, -1474, -1512, -1551, -1592, -1635, -1680, -1725, -1773, -1821, -1869, -1920, -1973, -2025, -2116, -1977, -2736, -11289, -12033, -11929, -13588, -14532, -14872, -15016, -14668, -14715, -15031, -15095, -15056, -15211, -15420, -15456, -15449, -15519, -15556, -15495, -15480, -15174, -16579, -19021, -18712, -18767, -18777, -18795, -18834, -18889, -18935, -18970, -18998, -19011, -18997, -18962, -18911, -18847, -18771, -18691, -18615, -18543, -18480, -18427, -18382, -18344, -18308, -18271, -18226, -18172, -18104, -18021, -17922, -17807, -17682, -17547, -17405, -17260, -17116, -16974, -16836, -16699, -16544, -16676, -15262, -18220, -22007, -21088, -21045, -20857, -20656, -20445, -20223, -19994, -19761, -19526, -19288, -19050, -18812, -18572, -18329, -18084, -17831, -17572, -17369, -16739, -19548, -20918, -20272, -20020, -19702, -19378, -19049, -18718, -18385, -18051, -17714, -17374, -17032, -16685, -16332, -15974, -15609, -15235, -14856, -14488, -14014, -13945, -16585, -16437, -15966, -15576, -15169, -14761, -14354, -13944, -13532, -13117, -12697, -12283, -12007, -11814, -11552, -11163, -10658, -10076, -9473, -8900, -8392};