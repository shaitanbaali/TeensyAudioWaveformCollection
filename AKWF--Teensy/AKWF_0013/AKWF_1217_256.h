/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1217 256 samples */
 
const int16_t AKWF_1217_256_DATA [256] = 
{1159, 3389, 5571, 7742, 9925, 12144, 14367, 16558, 18648, 20535, 22208, 23656, 24929, 26117, 27197, 28164, 28957, 29489, 29733, 29637, 29205, 28444, 27387, 26086, 24582, 22939, 21141, 19111, 16826, 14199, 11278, 8188, 4993, 1889, -1044, -3735, -6094, -8062, -9592, -10681, -11362, -11751, -11930, -12009, -12065, -12144, -12301, -12589, -13041, -13671, -14474, -15384, -16337, -17203, -17861, -18147, -17932, -17182, -15863, -14096, -12003, -9709, -7373, -5059, -2855, -780, 1176, 3068, 4962, 6884, 8886, 10884, 12788, 14513, 15930, 17010, 17705, 18006, 17921, 17438, 16554, 15272, 13589, 11554, 9207, 6624, 3894, 1068, -1780, -4592, -7332, -9923, -12279, -14342, -16001, -17213, -17926, -18111, -17768, -16915, -15647, -14027, -12198, -10264, -8263, -6251, -4184, -2063, 76, 2188, 4137, 5819, 7115, 7948, 8347, 8335, 8029, 7540, 6985, 6480, 6052, 5738, 5497, 5283, 5035, 4677, 4167, 3429, 2456, 1237, -164, -1669, -3179, -4535, -5712, -6647, -7347, -7848, -8132, -8201, -8012, -7485, -6587, -5255, -3515, -1406, 987, 3492, 6002, 8344, 10419, 12171, 13545, 14554, 15196, 15472, 15398, 14985, 14263, 13255, 11987, 10455, 8665, 6561, 4152, 1435, -1569, -4765, -8097, -11426, -14632, -17550, -20013, -21840, -22881, -23038, -22239, -20560, -18100, -15051, -11613, -8019, -4507, -1223, 1645, 4024, 5863, 7177, 8026, 8485, 8685, 8667, 8525, 8259, 7881, 7428, 6914, 6384, 5867, 5398, 5008, 4726, 4590, 4633, 4894, 5353, 5994, 6748, 7519, 8259, 8899, 9430, 9867, 10194, 10422, 10521, 10458, 10215, 9759, 9093, 8209, 7098, 5740, 4127, 2226, 58, -2366, -5026, -7872, -10870, -13965, -17077, -20115, -22992, -25598, -27870, -29752, -31198, -32191, -32704, -32700, -32167, -31080, -29459, -27370, -24899, -22218, -19454, -16751, -14227, -11847, -9616, -7475, -5341, -3206, -983};