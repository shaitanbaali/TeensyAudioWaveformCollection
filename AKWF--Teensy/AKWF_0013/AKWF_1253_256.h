/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1253 256 samples */
 
const int16_t AKWF_1253_256_DATA [256] = 
{385, 1764, 3067, 4329, 5548, 6726, 7864, 8961, 10022, 11048, 12035, 12990, 13913, 14802, 15663, 16494, 17295, 18070, 18817, 19540, 20236, 20910, 21559, 22187, 22794, 23379, 23944, 24490, 25017, 25527, 26018, 26492, 26951, 27394, 27821, 28233, 28632, 29016, 29389, 29747, 30094, 30428, 30751, 31063, 31364, 31655, 31937, 32206, 32452, 32774, 32038, 29683, 27282, 24982, 22758, 20605, 18528, 16524, 14586, 12716, 10912, 9165, 7482, 5857, 4286, 2770, 1307, -108, -1472, -2790, -4065, -5292, -6480, -7627, -8733, -9803, -10835, -11831, -12794, -13725, -14621, -15487, -16325, -17132, -17913, -18667, -19394, -20098, -20776, -21430, -22065, -22675, -23265, -23835, -24385, -24916, -25431, -25925, -26404, -26866, -27311, -27742, -28158, -28559, -28949, -29324, -29672, -30058, -30161, -28467, -26065, -23815, -21633, -19520, -17479, -15513, -13610, -11773, -10003, -8288, -6635, -5042, -3497, -2009, -574, 816, 2156, 3449, 4701, 5907, 7072, 8198, 9284, 10333, 11349, 12327, 13270, 14165, 15120, 15330, 13722, 11852, 10087, 8370, 6717, 5115, 3569, 2080, 638, -752, -2094, -3392, -4645, -5852, -7022, -8150, -9238, -10292, -11305, -12285, -13233, -14147, -15030, -15883, -16706, -17500, -18250, -19064, -19167, -17449, -15451, -13563, -11727, -9960, -8248, -6595, -5002, -3460, -1972, -538, 849, 2191, 3481, 4731, 5939, 7100, 8226, 9312, 10359, 11374, 12351, 13294, 14208, 15087, 15936, 16759, 17551, 18317, 19056, 19770, 20459, 21125, 21767, 22389, 22988, 23566, 24126, 24665, 25186, 25689, 26176, 26643, 27098, 27534, 27939, 28417, 27799, 25573, 23315, 21153, 19059, 17032, 15080, 13195, 11370, 9611, 7914, 6270, 4687, 3157, 1678, 254, -1123, -2455, -3738, -4980, -6178, -7333, -8451, -9531, -10571, -11578, -12550, -13485, -14376, -15313, -15682, -14202, -12304, -10529, -8797, -7126, -5515, -3957, -2456, -981};