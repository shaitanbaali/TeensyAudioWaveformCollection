/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1209 256 samples */
 
const int16_t AKWF_1209_256_DATA [256] = 
{2178, 8831, 15183, 21009, 25922, 29623, 31930, 32774, 32196, 30295, 27202, 23099, 18239, 12900, 7389, 2140, -2440, -6065, -8539, -9881, -10289, -10031, -9428, -8757, -8175, -7733, -7382, -7016, -6561, -6035, -5445, -4730, -3819, -2680, -1328, 201, 1828, 3479, 5075, 6540, 7768, 8592, 8800, 8204, 6766, 4626, 1999, -842, -3590, -5997, -7873, -9068, -9484, -9062, -7816, -5905, -3636, -1367, 578, 1953, 2677, 2821, 2519, 1958, 1276, 564, -59, -451, -494, -130, 637, 1722, 2966, 4111, 4862, 4964, 4255, 2678, 263, -2827, -6304, -9827, -13058, -15706, -17531, -18329, -17988, -16511, -14046, -10837, -7152, -3286, 492, 3991, 7075, 9654, 11682, 13154, 14106, 14573, 14589, 14185, 13397, 12308, 11038, 9718, 8453, 7288, 6200, 5113, 3937, 2637, 1205, -363, -2002, -3588, -4995, -6074, -6708, -6845, -6504, -5766, -4760, -3658, -2609, -1704, -977, -407, 56, 445, 774, 1007, 1092, 980, 647, 131, -508, -1149, -1650, -1924, -2002, -2013, -2098, -2338, -2766, -3342, -3924, -4338, -4440, -4139, -3419, -2283, -726, 1243, 3594, 6238, 9030, 11778, 14226, 16134, 17275, 17456, 16578, 14659, 11839, 8309, 4285, -6, -4376, -8627, -12570, -16075, -18991, -21193, -22630, -23274, -23179, -22424, -21056, -19119, -16694, -13935, -10997, -8029, -5142, -2374, 296, 2935, 5614, 8317, 10866, 13059, 14775, 16028, 16904, 17473, 17782, 17822, 17603, 17106, 16356, 15363, 14106, 12581, 10763, 8665, 6307, 3913, 1682, -288, -1920, -3149, -4000, -4674, -5448, -6492, -7877, -9572, -11353, -12843, -13691, -13745, -13032, -11696, -9924, -7788, -5261, -2317, 1015, 4569, 7969, 10761, 12603, 13293, 12755, 11072, 8523, 5527, 2383, -786, -3954, -7194, -10534, -13924, -17225, -20184, -22504, -24043, -24803, -24769, -23850, -21960, -19018, -14996, -9980, -4016};