/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1294 256 samples */
 
const int16_t AKWF_1294_256_DATA [256] = 
{14868, 14580, 14304, 14032, 13765, 13504, 13246, 12995, 12747, 12505, 12268, 12034, 11805, 11581, 11361, 11144, 10933, 10725, 10521, 10321, 10125, 9932, 9743, 9557, 9376, 9198, 9024, 8851, 8683, 8518, 8356, 8198, 8041, 7889, 7738, 7591, 7447, 7305, 7166, 7030, 6896, 6765, 6636, 6510, 6386, 6265, 6146, 6029, 5914, 5802, 5691, 5583, 5477, 5373, 5271, 5170, 5073, 4976, 4881, 4788, 4697, 4607, 4520, 4435, 4350, 4267, 4186, 4106, 4028, 3952, 3877, 3803, 3731, 3660, 3590, 3522, 3455, 3389, 3324, 3261, 3200, 3138, 3078, 3020, 2963, 2906, 2851, 2797, 2744, 2691, 2640, 2590, 2541, 2493, 2445, 2398, 2353, 2308, 2264, 2222, 2180, 2138, 2097, 2057, 2018, 1980, 1941, 1905, 1869, 1833, 1798, 1764, 1730, 1697, 1665, 1634, 1603, 1572, 1542, 1512, 1484, 1456, 1428, 1401, 1374, 1348, 1323, 1297, 1273, 1249, 1224, 1201, 1178, 1156, 1134, 1112, 1091, 1070, 1050, 1030, 1010, 991, 972, 954, 936, 918, 901, 883, 866, 850, 834, 818, 802, 787, 772, 758, 744, 730, 716, 701, 688, 675, 662, 649, 637, 625, 614, 601, 590, 579, 567, 557, 546, 536, 526, 516, 506, 496, 487, 477, 468, 459, 451, 442, 434, 426, 417, 409, 402, 394, 386, 379, 371, 364, 357, 351, 344, 338, 331, 325, 319, 312, 307, 301, 295, 290, 284, 279, 273, 268, 263, 258, 253, 248, 243, 239, 234, 230, 225, 221, 217, 213, -71, 1493, -5191, -33088, -31791, -31239, -30677, -30094, -29521, -28961, -28410, -27869, -27339, -26820, -26310, -25810, -25319, -24837, -24366, -23902, -23447, -23002, -22564, -22135, -21715, -21301, -20896, -20499, -20109, -19727, -19352, -18984, -18625, -18265};