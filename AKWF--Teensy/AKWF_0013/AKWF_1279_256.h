/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1279 256 samples */
 
const int16_t AKWF_1279_256_DATA [256] = 
{563, 1892, 3315, 4768, 6165, 7422, 8470, 9248, 9724, 9883, 9735, 9313, 8678, 7911, 7094, 6312, 5636, 5112, 4778, 4652, 4744, 5056, 5571, 6262, 7078, 7960, 8849, 9692, 10450, 11097, 11617, 12000, 12253, 12388, 12438, 12442, 12455, 12528, 12715, 13051, 13557, 14239, 15074, 16043, 17109, 18236, 19402, 20589, 21777, 22948, 24073, 25103, 25991, 26676, 27115, 27289, 27200, 26881, 26383, 25760, 25057, 24299, 23493, 22629, 21681, 20632, 19465, 18179, 16798, 15346, 13865, 12398, 10968, 9585, 8248, 6932, 5615, 4278, 2898, 1473, 21, -1437, -2848, -4149, -5282, -6193, -6862, -7312, -7586, -7741, -7832, -7887, -7914, -7888, -7745, -7405, -6906, -6325, -5700, -5040, -4318, -3593, -2974, -2362, -1632, -742, 320, 1544, 2881, 4263, 5629, 6903, 8033, 9003, 9819, 10505, 11109, 11668, 12204, 12726, 13212, 13629, 13931, 14069, 13997, 13685, 13125, 12337, 11365, 10265, 9088, 7867, 6617, 5318, 3930, 2417, 735, -1120, -3128, -5254, -7442, -9624, -11763, -13819, -15777, -17659, -19485, -21274, -23044, -24784, -26459, -28034, -29450, -30651, -31599, -32264, -32646, -32769, -32675, -32415, -32040, -31598, -31126, -30645, -30167, -29685, -29191, -28672, -28106, -27482, -26787, -26006, -25136, -24174, -23119, -21982, -20782, -19530, -18260, -17008, -15799, -14667, -13641, -12734, -11952, -11289, -10725, -10230, -9768, -9295, -8774, -8172, -7461, -6638, -5703, -4674, -3583, -2470, -1378, -368, 514, 1223, 1724, 2000, 2054, 1903, 1590, 1166, 700, 256, -99, -312, -351, -204, 116, 584, 1155, 1766, 2354, 2838, 3156, 3246, 3065, 2597, 1849, 864, -311, -1631, -3046, -4389, -5421, -6112, -6479, -6501, -6185, -5563, -4697, -3675, -2589, -1535, -599, 147, 653, 896, 878, 620, 169, -414, -1050, -1645, -2111, -2369, -2362, -2058, -1453, -538};