/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1203 256 samples */
 
const int16_t AKWF_1203_256_DATA [256] = 
{1008, 3217, 5478, 7808, 10173, 12548, 14908, 17213, 19447, 21581, 23582, 25437, 27121, 28608, 29889, 30948, 31770, 32351, 32684, 32765, 32598, 32185, 31535, 30654, 29559, 28266, 26787, 25146, 23366, 21462, 19465, 17400, 15282, 13149, 11019, 8912, 6859, 4877, 2983, 1203, -454, -1974, -3342, -4554, -5603, -6483, -7198, -7749, -8140, -8379, -8476, -8442, -8292, -8042, -7708, -7305, -6854, -6375, -5884, -5402, -4947, -4534, -4182, -3903, -3711, -3616, -3629, -3755, -3997, -4360, -4842, -5437, -6143, -6952, -7850, -8828, -9873, -10964, -12089, -13229, -14361, -15472, -16537, -17537, -18457, -19275, -19974, -20541, -20960, -21220, -21311, -21225, -20959, -20509, -19876, -19065, -18078, -16930, -15629, -14185, -12624, -10957, -9202, -7392, -5540, -3672, -1821, -2, 1758, 3427, 4989, 6419, 7691, 8792, 9701, 10401, 10883, 11136, 11151, 10926, 10460, 9756, 8815, 7652, 6276, 4699, 2943, 1025, -1036, -3209, -5475, -7808, -10173, -12549, -14908, -17214, -19448, -21581, -23582, -25437, -27121, -28608, -29889, -30948, -31770, -32351, -32684, -32765, -32598, -32185, -31535, -30654, -29559, -28267, -26787, -25147, -23366, -21462, -19466, -17400, -15283, -13150, -11020, -8912, -6860, -4878, -2984, -1204, 453, 1973, 3341, 4553, 5602, 6482, 7198, 7749, 8139, 8378, 8475, 8442, 8292, 8041, 7707, 7304, 6853, 6374, 5883, 5401, 4946, 4534, 4181, 3902, 3710, 3615, 3628, 3754, 3996, 4359, 4841, 5437, 6142, 6951, 7849, 8828, 9872, 10963, 12088, 13228, 14360, 15471, 16537, 17537, 18457, 19275, 19973, 20541, 20960, 21219, 21310, 21225, 20959, 20509, 19876, 19065, 18078, 16930, 15628, 14185, 12624, 10956, 9202, 7391, 5539, 3671, 1820, 1, -1759, -3428, -4990, -6420, -7692, -8793, -9702, -10402, -10884, -11136, -11152, -10927, -10460, -9756, -8816, -7653, -6277, -4703, -2954, -996};