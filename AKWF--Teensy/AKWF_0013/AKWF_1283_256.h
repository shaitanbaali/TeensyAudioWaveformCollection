/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1283 256 samples */
 
const int16_t AKWF_1283_256_DATA [256] = 
{2, 17, 46, 87, 141, 207, 286, 378, 482, 600, 728, 870, 1024, 1189, 1368, 1557, 1759, 1973, 2197, 2434, 2681, 2941, 3210, 3492, 3784, 4085, 4398, 4721, 5052, 5394, 5746, 6107, 6478, 6856, 7244, 7641, 8045, 8457, 8877, 9304, 9738, 10180, 10627, 11082, 11544, 12009, 12481, 12958, 13440, 13926, 14418, 14912, 15412, 15914, 16419, 16929, 17440, 17953, 18469, 18987, 19504, 20024, 20544, 21064, 21586, 22106, 22626, 23146, 23663, 24179, 24695, 25207, 25716, 26224, 26729, 27230, 27728, 28220, 28711, 29196, 29674, 30150, 30620, 31083, 31541, 31450, 34817, 18751, -10785, -8355, -8246, -7872, -7471, -7078, -6694, -6320, -5953, -5596, -5248, -4910, -4583, -4265, -3955, -3659, -3371, -3094, -2830, -2575, -2332, -2101, -1881, -1672, -1476, -1291, -1118, -958, -809, -673, -549, -437, -338, -252, -179, -118, -69, -33, -10, -1, -3, -18, -47, -88, -142, -208, -287, -379, -483, -601, -729, -871, -1025, -1190, -1369, -1558, -1760, -1974, -2198, -2435, -2682, -2942, -3211, -3493, -3784, -4086, -4399, -4721, -5053, -5395, -5747, -6108, -6478, -6857, -7245, -7641, -8045, -8458, -8877, -9305, -9739, -10181, -10627, -11083, -11544, -12009, -12482, -12959, -13440, -13927, -14419, -14913, -15413, -15915, -16420, -16929, -17440, -17953, -18470, -18987, -19505, -20025, -20545, -21065, -21586, -22106, -22626, -23146, -23664, -24180, -24696, -25207, -25716, -26224, -26729, -27230, -27728, -28220, -28711, -29196, -29674, -30150, -30620, -31083, -31541, -31450, -34816, -18752, 10784, 8354, 8245, 7871, 7471, 7078, 6693, 6319, 5952, 5595, 5247, 4910, 4582, 4264, 3955, 3658, 3370, 3094, 2829, 2574, 2331, 2100, 1880, 1671, 1475, 1290, 1117, 957, 808, 672, 548, 436, 337, 251, 178, 117, 68, 32, 9, 0};