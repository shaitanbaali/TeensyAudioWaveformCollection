/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1251 256 samples */
 
const int16_t AKWF_1251_256_DATA [256] = 
{-2, -1, -1, 0, -1, 1, 555, -2421, 14371, 33320, 30296, 30862, 30861, 30861, 30861, 30861, 30862, 30874, 30794, 32289, 32749, 32645, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32663, 32630, 32807, 31750, 30717, 30893, 30860, 30861, 30861, 30860, 30861, 30421, 32845, 9416, -1946, 430, -2, -398, 1814, -22225, -32692, -30459, -30861, -30861, -30861, -30861, -30861, -30862, -30860, -30861, -30862, -30861, -30861, -30861, -30861, -30862, -30861, -30862, -30861, -30861, -30862, -30861, -30861, -30861, -30861, -30860, -30861, -30862, -30861, -30861, -30862, -30861, -30861, -30862, -30861, -30861, -30862, -30861, -30860, -30861, -30861, -30862, -30861, -30861, -30861, -30862, -30861, -30860, -30861, -30860, -30891, -30731, -31553, -32800, -32633, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32660, -32670, -32652, -31080, -30807, -30874, -30861, -30861, -30862, -30861, -30861, -30861, -30861, -30860, -30402, -32921, -9809, 1999, -444, -2, 0, -2, 0, 1, 0, 2, -2, 0, -2, 0, 0, -2, -1, -2, 0, 0, -1, 0, -2, 1, 1, -1, 1, -3, 0, 1, 0, 0, -236, 1065, -4368, -31046, -30872, -30817, -30861, -30861, -30861, -30861, -30861, -30893, -30720, -31675, -32807, -32631, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32664, -32662, -32668, -32760, -32770, -32767, -32767, -32767, -32767, -32767, -32767, -32772, -32749, -32661, -32664, -32664, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32663, -32637, -32784, -31434, -30745, -30887, -30861, -30860, -30861, -30860, -30861};