/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1222 256 samples */
 
const int16_t AKWF_1222_256_DATA [256] = 
{246, 629, 972, 1271, 1525, 1750, 1961, 2171, 2393, 2639, 2907, 3194, 3491, 3789, 4091, 4399, 4719, 5053, 5406, 5781, 6183, 6614, 7075, 7570, 8097, 8658, 9255, 9884, 10546, 11237, 11957, 12702, 13472, 14260, 15065, 15885, 16713, 17550, 18389, 19225, 20061, 20889, 21703, 22507, 23294, 24060, 24805, 25525, 26217, 26883, 27518, 28118, 28687, 29222, 29719, 30181, 30605, 30991, 31340, 31649, 31921, 32156, 32351, 32510, 32629, 32712, 32757, 32767, 32740, 32679, 32582, 32449, 32282, 32082, 31852, 31586, 31289, 30961, 30602, 30212, 29795, 29345, 28865, 28360, 27826, 27263, 26676, 26061, 25420, 24758, 24068, 23358, 22625, 21871, 21098, 20308, 19498, 18674, 17836, 16985, 16127, 15259, 14387, 13517, 12650, 11794, 10964, 10167, 9411, 8692, 7999, 7322, 6655, 5990, 5325, 4675, 4056, 3481, 2958, 2490, 2103, 1855, 1802, 1720, 1397, 979, 560, 146, -252, -628, -973, -1272, -1526, -1751, -1962, -2172, -2394, -2640, -2908, -3195, -3492, -3790, -4091, -4400, -4719, -5054, -5407, -5782, -6184, -6615, -7076, -7570, -8098, -8659, -9256, -9885, -10547, -11238, -11957, -12703, -13473, -14261, -15065, -15885, -16714, -17549, -18389, -19225, -20062, -20888, -21703, -22508, -23295, -24060, -24805, -25525, -26217, -26883, -27518, -28118, -28688, -29222, -29719, -30181, -30605, -30991, -31340, -31649, -31921, -32156, -32351, -32510, -32629, -32712, -32758, -32767, -32739, -32679, -32581, -32449, -32282, -32082, -31852, -31586, -31289, -30961, -30602, -30212, -29795, -29345, -28866, -28360, -27826, -27263, -26676, -26061, -25420, -24757, -24069, -23358, -22625, -21871, -21099, -20308, -19498, -18674, -17837, -16985, -16127, -15260, -14387, -13518, -12651, -11794, -10965, -10168, -9412, -8693, -7999, -7322, -6656, -5990, -5326, -4676, -4057, -3482, -2959, -2491, -2104, -1856, -1803, -1721, -1398, -980, -562, -141};