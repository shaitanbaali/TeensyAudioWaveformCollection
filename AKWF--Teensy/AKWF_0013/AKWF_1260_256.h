/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1260 256 samples */
 
const int16_t AKWF_1260_256_DATA [256] = 
{1686, 4875, 7447, 10165, 12493, 14075, 15604, 16994, 18055, 19250, 20344, 21137, 21865, 22876, 23760, 24418, 24935, 25396, 25788, 26110, 26404, 26693, 26954, 27186, 27404, 27634, 27853, 28053, 28238, 28429, 28629, 28815, 28988, 29151, 29311, 29482, 29651, 29809, 29953, 30050, 30090, 30111, 30161, 30252, 30366, 30487, 30612, 30736, 30856, 30971, 31082, 31189, 31291, 31389, 31482, 31572, 31659, 31743, 31822, 31899, 31973, 32045, 32113, 32180, 32233, 32275, 32316, 32358, 32399, 32439, 32480, 32519, 32547, 32566, 32585, 32604, 32625, 32645, 32657, 32659, 32661, 32665, 32667, 32656, 32643, 32634, 32622, 32598, 32572, 32551, 32528, 32486, 32456, 32324, 32073, 31871, 31683, 31384, 31079, 30844, 30614, 30262, 29901, 29606, 29182, 28665, 28323, 27764, 27254, 25368, 19868, 19160, 18795, 16265, 13675, 8762, 4638, -124, -2512, -4186, -6745, -9021, -10602, -12382, -14357, -15668, -16626, -17693, -18936, -19817, -20496, -21213, -22296, -23142, -23785, -24375, -25059, -25727, -26288, -26730, -27065, -27355, -27597, -27799, -27982, -28150, -28318, -28499, -28662, -28817, -28966, -29107, -29242, -29393, -29542, -29679, -29811, -29939, -30060, -30174, -30286, -30391, -30502, -30624, -30735, -30843, -30947, -31046, -31141, -31232, -31320, -31403, -31484, -31541, -31553, -31536, -31526, -31540, -31576, -31625, -31685, -31746, -31808, -31870, -31930, -31988, -32046, -32100, -32154, -32205, -32255, -32303, -32350, -32395, -32439, -32483, -32523, -32549, -32571, -32595, -32617, -32639, -32660, -32682, -32704, -32725, -32736, -32739, -32746, -32751, -32756, -32762, -32768, -32760, -32750, -32744, -32737, -32730, -32723, -32703, -32680, -32664, -32645, -32628, -32606, -32567, -32539, -32511, -32488, -32434, -32202, -31984, -31818, -31678, -31399, -31105, -30886, -30712, -30411, -30025, -29779, -29471, -28884, -28438, -28018, -27013, -26221, -25933, -24429, -23169, -20745, -16918, -6380, -3782, -3321, -1576};