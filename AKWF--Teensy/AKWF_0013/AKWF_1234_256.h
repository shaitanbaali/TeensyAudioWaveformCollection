/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1234 256 samples */
 
const int16_t AKWF_1234_256_DATA [256] = 
{1084, 4167, 6674, 8613, 10104, 11215, 12028, 12617, 13079, 13502, 13956, 14492, 15142, 15896, 16695, 17448, 18201, 18871, 19378, 19689, 19816, 19721, 19428, 18966, 18378, 17703, 16860, 17104, 3936, -1632, -6883, -7975, -5560, -4671, -3809, -3142, -2631, -2251, -1973, -1770, -1612, -1468, -1312, -1128, -905, -645, -370, -111, 148, 378, 596, 672, 560, 14620, 20322, 18698, 18337, 17671, 16978, 16282, 15791, 14392, 10741, 8227, 6799, 5921, 5395, 5112, 4999, 4938, 4889, 4813, 4732, 4574, 4369, 4108, 3802, 3461, 3091, 2702, 2308, 1902, 1496, 1094, 699, 314, -55, -404, -736, -1045, -1308, -1724, -1035, 2041, 2127, -4375, -9354, -11925, -13481, -14334, -14735, -14852, -14778, -14573, -14280, -13932, -13544, -13128, -12705, -12289, -11854, -11381, -10998, -10697, -10476, -10360, -10396, -10556, -10859, -11300, -11879, -12584, -13419, -14404, -15228, -17878, -20589, -6755, -3515, -847, 1774, 4084, 6045, 7666, 8976, 10023, 10886, 11652, 12388, 13164, 14007, 14926, 15863, 16734, 17589, 18347, 18930, 19309, 19493, 19447, 19194, 18769, 18209, 17567, 16894, 16212, 15443, 15747, -3085, -5569, 1457, 4044, 6548, 8495, 9980, 11089, 11900, 12488, 12946, 13367, 13818, 14355, 15003, 15756, 16553, 17304, 18056, 18727, 19232, 19541, 19668, 19570, 19276, 18814, 18224, 17559, 16865, 16166, 15549, 14861, 6635, -2011, -402, 177, 788, 1361, 1907, 2374, 2757, 3042, 3257, 3347, 3349, 3259, 3092, 2867, 2590, 2278, 1944, 1587, 1220, 850, 479, 115, -238, -576, -897, -1198, -1454, -1866, -1173, 1908, 1987, -4523, -9475, -12051, -13603, -14453, -14855, -14972, -14898, -14692, -14399, -14050, -13663, -13249, -12825, -12410, -11974, -11501, -11119, -10819, -10596, -10481, -10516, -10678, -10980, -11422, -12000, -12706, -13543, -14528, -15408, -17719, -25660, -4620};