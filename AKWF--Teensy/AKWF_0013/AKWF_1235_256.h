/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1235 256 samples */
 
const int16_t AKWF_1235_256_DATA [256] = 
{7877, 6916, 7151, 7112, 7111, 7110, 7109, 7107, 7104, 7101, 7096, 7092, 7087, 7082, 7076, 7070, 7064, 7058, 7051, 7045, 7038, 7031, 7024, 7017, 7010, 7003, 6978, 7001, 6971, 803, -734, -2424, -316, -322, -325, -326, -328, -330, -331, -333, -335, -336, -338, -340, -342, -345, -346, -349, -351, -352, -355, -327, -443, 7, 5874, 7245, 6930, 6986, 6979, 6972, 6965, 6958, 6951, 6944, 6937, 6930, 6922, 6915, 6908, 6900, 6893, 6886, 6878, 6871, 6863, 6855, 6848, 6840, 6833, 6824, 6817, 6809, 6802, 6795, 6787, 6779, 6771, 6763, 6755, 6749, 6740, 6733, 6725, 6717, 6710, 6702, 6694, 6687, 6679, 6672, 6663, 6399, 7821, -4215, -13960, -12441, -12724, -12724, -12723, -12721, -12718, -12715, -12711, -12707, -12702, -12697, -12692, -12685, -12947, -11460, -22080, -33209, -31734, -31990, -31962, -31612, -33541, -13692, 2964, 1735, 3015, 3732, 4320, 4802, 5202, 5531, 5801, 6023, 6203, 6351, 6474, 6572, 6652, 6719, 6771, 6812, 6846, 6873, 6893, 6908, 6920, 6929, 6934, 6937, 6939, 6939, 6927, 6995, 6700, 777, 7094, 7082, 7076, 7076, 7072, 7069, 7065, 7060, 7055, 7049, 7043, 7037, 7031, 7023, 7016, 7010, 7002, 6995, 6988, 6980, 6972, 6965, 6957, 6949, 6941, 6934, 6926, 6918, 6909, 6828, 7255, 3705, 537, 2113, 2855, 3552, 4125, 4596, 4982, 5298, 5560, 5774, 5949, 6092, 6208, 6304, 6380, 6442, 6492, 6531, 6562, 6588, 6607, 6621, 6631, 6639, 6643, 6647, 6647, 6645, 6644, 6642, 6637, 6632, 6628, 6622, 6616, 6611, 6604, 6341, 7763, -4270, -14012, -12493, -12776, -12776, -12775, -12774, -12771, -12768, -12764, -12760, -12755, -12750, -12745, -12738, -13002, -11502, -22262, -33284, -31781, -32043, -32019, -31594, -33883, -15040};