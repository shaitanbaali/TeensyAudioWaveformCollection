/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1273 256 samples */
 
const int16_t AKWF_1273_256_DATA [256] = 
{894, 5439, 10748, 15274, 18571, 20848, 22604, 24109, 25259, 25960, 26733, 27958, 28250, 24700, 12653, -3458, -14598, -21542, -26221, -29352, -31381, -32496, -32760, -32225, -31008, -29509, -27516, -22128, -16534, -13783, -12053, -9820, -6314, -1618, 3086, 6582, 8559, 9176, 8909, 8151, 6961, 5519, 4503, 4091, 3485, 2046, -265, -3203, -6648, -10872, -15751, -19656, -21062, -20620, -19569, -18397, -17217, -16055, -14892, -13729, -12587, -11452, -10233, -8744, -6820, -4491, -1918, 706, 3245, 5711, 8200, 10738, 13256, 15666, 18097, 20749, 22954, 23011, 16507, 2115, -10469, -16977, -19840, -20500, -19736, -18006, -15591, -12717, -9638, -6603, -3792, -1321, 776, 2543, 4024, 5265, 6296, 7135, 7795, 8254, 8437, 8300, 7890, 7270, 6431, 5413, 4527, 4164, 4135, 3470, 1566, -1223, -4462, -7966, -11353, -14142, -16142, -17434, -18217, -18637, -18761, -18663, -18412, -18171, -18220, -18642, -19135, -19228, -18559, -16939, -14348, -11042, -7543, -4115, -456, 3725, 7990, 11763, 15896, 20745, 23408, 18303, 5409, -5404, -12282, -16934, -20207, -22522, -24112, -25040, -25258, -24720, -23451, -21786, -19400, -12327, -4037, 1032, 4872, 9032, 13082, 16465, 18989, 20463, 20796, 20152, 18866, 17203, 15220, 13057, 11163, 9670, 8099, 6049, 3491, 588, -2572, -6133, -9964, -13130, -14804, -15298, -15277, -15035, -14653, -14168, -13583, -12916, -12204, -11456, -10606, -9499, -7977, -6047, -3866, -1614, 582, 2721, 4871, 7067, 9252, 11327, 13406, 15698, 17567, 17403, 11220, -3034, -16423, -23831, -27390, -28640, -28386, -27098, -25057, -22485, -19636, -16765, -14066, -11673, -9629, -7893, -6401, -5092, -3922, -2850, -1844, -933, -222, 209, 420, 498, 408, 200, 491, 2280, 5483, 7644, 6618, 3085, -1674, -7054, -12066, -15704, -17651, -18082, -17353, -15660, -13067, -9718, -5869, -2273, -249, -292, -1249, -1214};