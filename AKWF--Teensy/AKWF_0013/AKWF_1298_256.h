/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1298 256 samples */
 
const int16_t AKWF_1298_256_DATA [256] = 
{588, 1804, 2989, 4169, 5342, 6518, 7707, 8909, 10134, 11383, 12648, 13929, 15220, 16511, 17803, 19087, 20350, 21595, 22808, 23982, 25114, 26194, 27216, 28176, 29066, 29881, 30619, 31272, 31843, 32321, 32401, 32574, 32757, 32749, 32625, 32399, 32076, 31658, 31151, 30561, 29890, 29143, 28325, 27438, 26488, 25482, 24421, 23310, 22160, 20968, 19742, 18487, 17217, 16027, 14843, 13636, 12442, 11270, 10114, 8980, 7865, 6767, 5686, 4620, 3564, 2522, 1488, 463, -550, -1557, -2557, -3545, -4526, -5499, -6459, -7408, -8344, -9261, -10163, -11044, -11898, -12728, -13526, -14288, -15015, -15698, -16334, -16923, -17461, -17941, -18365, -18728, -19029, -19269, -19446, -19561, -19613, -19604, -19536, -19414, -19237, -19012, -18742, -18431, -18084, -17707, -17305, -16883, -16445, -15999, -15548, -15096, -14650, -14210, -13783, -13371, -12974, -12595, -12232, -11918, -11433, -10402, -9380, -8324, -7654, -7123, -6358, -5557, -4772, -4013, -3280, -2572, -1888, -1219, -552, 116, 798, 1494, 2198, 2914, 3637, 4360, 5084, 5803, 6509, 7203, 7876, 8523, 9141, 9725, 10269, 10773, 11229, 11636, 11991, 12290, 12536, 12720, 12541, 12488, 12479, 12316, 12072, 11763, 11396, 10973, 10498, 9978, 9416, 8814, 8179, 7512, 6818, 6100, 5362, 4608, 3843, 3069, 2289, 1503, 727, 54, -592, -1243, -1864, -2453, -3010, -3537, -4037, -4516, -4975, -5419, -5853, -6279, -6702, -7123, -7544, -7970, -8402, -8838, -9284, -9739, -10202, -10674, -11155, -11641, -12135, -12631, -13128, -13622, -14111, -14590, -15056, -15505, -15931, -16333, -16707, -17047, -17350, -17612, -17832, -18008, -18135, -18216, -18246, -18226, -18157, -18040, -17876, -17665, -17411, -17118, -16787, -16420, -16024, -15599, -15149, -14681, -14194, -13692, -13182, -12659, -12131, -11599, -11062, -10522, -9975, -9454, -8738, -7454, -6154, -4797, -3803, -2925, -1793, -576};