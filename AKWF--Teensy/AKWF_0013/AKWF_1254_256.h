/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1254 256 samples */
 
const int16_t AKWF_1254_256_DATA [256] = 
{657, 1792, 2868, 3912, 4922, 5901, 6848, 7761, 8646, 9502, 10327, 11127, 11899, 12643, 13365, 14063, 14734, 15385, 16013, 16617, 17203, 17769, 18301, 18803, 19289, 19760, 20219, 20663, 21092, 21510, 21914, 22305, 22684, 23049, 23404, 23748, 24079, 24400, 24711, 25010, 25300, 25581, 25851, 26115, 26375, 26626, 26869, 27105, 27330, 27549, 27760, 27964, 28161, 28351, 28535, 28712, 28884, 29049, 29209, 29363, 29512, 29656, 29795, 29929, 30059, 30184, 30304, 30421, 30533, 30641, 30747, 30848, 30945, 31040, 31131, 31220, 31305, 31386, 31465, 31543, 31616, 31687, 31756, 31822, 31885, 31948, 32006, 32063, 32119, 32172, 32223, 32273, 32319, 32364, 32408, 32449, 32488, 32526, 32561, 32594, 32627, 32655, 32683, 32706, 32728, 32731, 32810, 32288, 30277, 28073, 25975, 23936, 21969, 20065, 18224, 16451, 14732, 13072, 11472, 9922, 8427, 6984, 5587, 4240, 2939, 1680, 468, -704, -1838, -2931, -3986, -5008, -5992, -6943, -7862, -8748, -9606, -10434, -11232, -12004, -12749, -13468, -14164, -14835, -15482, -16107, -16712, -17295, -17860, -18403, -18927, -19436, -19926, -20397, -20856, -21297, -21722, -22135, -22531, -22915, -23285, -23643, -23988, -24322, -24644, -24955, -25256, -25545, -25824, -26097, -26357, -26607, -26844, -27073, -27291, -27503, -27708, -27904, -28094, -28277, -28452, -28621, -28784, -28940, -29090, -29233, -29371, -29503, -29627, -29747, -29860, -29967, -30069, -30185, -30305, -30420, -30531, -30638, -30743, -30842, -30937, -31031, -31119, -31205, -31286, -31365, -31440, -31511, -31580, -31643, -31704, -31761, -31813, -31862, -31905, -31944, -31977, -32002, -32021, -32031, -32031, -32020, -31994, -31954, -31892, -31808, -31695, -31549, -31361, -31124, -30826, -30455, -29994, -29424, -28725, -27862, -26820, -25623, -24308, -22908, -21454, -19959, -18444, -16927, -15410, -13907, -12425, -10964, -9534, -8137, -6769, -5438, -4145, -2886, -1667, -462};