/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1242 256 samples */
 
const int16_t AKWF_1242_256_DATA [256] = 
{19588, 21662, 20791, 20507, 20034, 19429, 18712, 17865, 16756, 15939, 15134, 14285, 13370, 12369, 11313, 10228, 9165, 8163, 7191, 6248, 5305, 4313, 3289, 2276, 1308, 444, -341, -1025, -1647, -2275, -2882, -3438, -3914, -4306, -4665, -4620, -6242, -8536, -4218, -1160, 1420, 3631, 5566, 7296, 8841, 10217, 11465, 12634, 13784, 14936, 16059, 17118, 18092, 19015, 19758, 20418, 21051, 21620, 22134, 22549, 22814, 22916, 22887, 22757, 22573, 22337, 21580, 24112, 4255, -17523, -2899, 3643, 8056, 10670, 11865, 12455, 12488, 12055, 11341, 10465, 9532, 8578, 7624, 6655, 5647, 4597, 3518, 2466, 1475, 560, -256, -971, -1644, -2297, -2935, -3547, -4030, -4423, -4636, -5534, -1321, 4210, 4411, 5284, 6135, 7068, 8066, 9092, 10107, 11095, 12054, 13014, 14012, 14522, 18541, -8527, -30694, -28321, -29637, -30284, -30908, -31471, -31981, -32393, -32656, -32320, -34444, -23793, 20158, 22915, 21777, 21641, 21153, 20516, 19780, 18962, 18130, 17255, 16108, 15209, 14267, 13190, 12057, 10911, 9800, 8742, 7720, 6706, 5672, 4601, 3509, 2455, 1460, 544, -273, -994, -1663, -2316, -2953, -3565, -4050, -4444, -4754, -5109, -4964, -4678, -5058, -5483, -5916, -6286, -6584, -6822, -7041, -7278, -7510, -7717, -7839, -7884, -7865, -7813, -7791, -7773, -7772, -7762, -7686, -7556, -7394, -7217, -7066, -6969, -6906, -6852, -6761, -6615, -6418, -6364, -5371, -4403, -5032, -5306, -5482, -5524, -5502, -5437, -5378, -5338, -5353, -5348, -5298, -5189, -5018, -4815, -4623, -4447, -4292, -4120, -3874, -3539, -3131, -2649, -2151, -1662, -1167, -612, 37, 786, 1607, 2459, 3267, 4034, 4770, 5512, 6310, 7182, 8128, 9110, 10091, 11025, 11931, 12829, 13743, 14187, 18088, -8403, -30080, -27654, -28904, -29487, -30022, -30518, -30962, -31321, -31554, -31341, -32867, -24134};