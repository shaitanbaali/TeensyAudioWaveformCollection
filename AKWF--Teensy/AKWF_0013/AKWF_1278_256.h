/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1278 256 samples */
 
const int16_t AKWF_1278_256_DATA [256] = 
{25820, 25128, 24453, 23776, 23102, 22425, 21748, 21074, 20397, 19332, 20728, 9539, -21635, -21840, -22465, -23185, -23826, -24462, -25091, -25631, -26575, -25388, -20409, 12978, 16602, 14947, 14564, 13983, 13407, 12837, 12273, 11715, 10867, 11880, 4029, -28809, -30093, -30279, -30879, -31365, -31746, -32755, -30577, -25566, -29619, -15834, 13242, 10116, 10172, 9784, 9384, 8993, 8610, 8237, 7872, 7514, 7167, 6828, 6495, 6173, 5859, 5520, 5647, 3338, 7973, 13943, 12485, 12444, 12203, 11967, 11739, 11522, 11313, 11112, 10922, 10738, 10493, 10236, 11089, -19267, -30997, -28644, -29232, -29345, -29447, -29545, -29630, -29708, -29780, -29842, -29897, -29945, -29985, -30018, -30046, -30065, -30081, -30089, -30089, -30085, -30077, -30061, -30039, -30013, -29956, -30050, -29494, -24633, -24180, -24236, -24154, -24094, -24031, -23963, -23892, -23820, -23744, -23664, -23584, -23501, -23417, -23330, -23243, -23152, -23061, -22909, -23121, -21911, -8360, -7172, -7329, -4694, -3190, -2646, -2409, -2952, -2872, -2364, -2255, -2309, -2058, -1718, -1653, -1659, -1542, -1476, -1565, -1581, -2059, 172, 4046, 3564, 3657, 3679, 3711, 3782, 3876, 3954, 4016, 4067, 4092, 4076, 4027, 3953, 3857, 3741, 3621, 3506, 3399, 3304, 3225, 3159, 3105, 3053, 2998, 2934, 2853, 2751, 2625, 2474, 2298, 2102, 1892, 1673, 1449, 1224, 1004, 789, 578, 337, 550, -1687, 3005, 9006, 7553, 7492, 7198, 6882, 6549, 6204, 5845, 5478, 5111, 4737, 4363, 3989, 3614, 3233, 2847, 2450, 2043, 1725, 727, 5179, 7354, 6332, 5936, 5433, 4921, 4404, 3884, 3359, 2832, 2299, 1764, 1225, 677, 119, -446, -1024, -1611, -2209, -2792, -3542, -3649, 533, 301, -444, -1061, -1703, -2347, -2994, -3643, -4293, -4952, -5611, -6287, -7194, -8243, -9187, -9944, -10518, -10971, -11391, -11854, -12444};