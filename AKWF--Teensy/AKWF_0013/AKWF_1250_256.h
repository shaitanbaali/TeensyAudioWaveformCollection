/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1250 256 samples */
 
const int16_t AKWF_1250_256_DATA [256] = 
{31615, 31615, 31615, 31615, 31616, 31617, 31621, 31580, 31759, 32472, 31591, 31619, 31616, 31616, 31615, 31615, 31615, 31615, 31616, 31616, 31616, 31616, 31616, 31616, 31616, 31617, 31616, 31616, 31615, 31615, 31615, 31616, 31616, 31055, 34071, 12990, -2918, 2964, -19060, -33944, -31098, -31561, -32458, -32788, -32716, -32728, -32728, -32728, -32728, -32725, -32738, -32699, -31622, -31912, -30544, -2639, 936, -1260, 4477, 31806, 31627, 31571, 31615, 31615, 31636, 31530, 32103, 32816, 32708, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32728, 32720, 32769, 32559, 31602, 31191, 33551, 22375, -2390, 2420, -9642, -33649, -31186, -31528, -32134, -32817, -32708, -32728, -32728, -32729, -32726, -32754, -32770, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32769, -32759, -32742, -32682, -31160, -33960, -18635, 2456, -559, -3};