/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1261 256 samples */
 
const int16_t AKWF_1261_256_DATA [256] = 
{909, 2404, 3796, 5139, 6436, 7691, 8914, 10106, 11262, 12368, 13555, 15017, 16702, 18491, 22020, 26559, 27791, 28236, 28596, 28901, 29181, 29441, 29689, 29922, 30158, 30466, 30849, 31218, 31518, 31748, 31926, 32069, 32192, 32302, 32399, 32469, 32513, 32545, 32564, 32572, 32573, 32580, 32594, 32607, 32605, 32590, 32575, 32565, 32551, 32529, 32495, 32453, 32404, 32352, 32286, 32197, 31997, 31645, 31301, 30984, 30674, 30383, 30117, 29829, 29494, 29152, 28821, 28481, 27646, 25784, 25493, 26921, 28334, 28262, 26992, 25935, 25382, 25071, 24863, 24700, 24553, 24416, 24288, 24162, 24034, 23900, 23760, 23614, 23460, 23296, 23123, 22935, 22729, 22503, 22262, 22015, 21768, 21511, 21229, 20920, 20593, 20255, 19903, 19525, 19119, 18687, 18230, 17751, 17246, 16715, 16147, 15543, 14910, 14242, 13538, 12792, 12003, 11169, 10293, 9367, 8394, 7370, 6286, 5148, 3954, 2695, 1376, -7, -1399, -2738, -4021, -5244, -6413, -7550, -8665, -9754, -10814, -11851, -12881, -13950, -15138, -17307, -22600, -25792, -26455, -26984, -27386, -27736, -28060, -28367, -28659, -28936, -29199, -29481, -29823, -30189, -30521, -30795, -31018, -31206, -31370, -31517, -31653, -31780, -31903, -32000, -32069, -32151, -32277, -32428, -32559, -32653, -32718, -32757, -32768, -32757, -32731, -32697, -32662, -32628, -32588, -32532, -32453, -32351, -32212, -31915, -31543, -31181, -30826, -30489, -30178, -29891, -29623, -29354, -29042, -28652, -28564, -29402, -29803, -28825, -26473, -25359, -26482, -27019, -26992, -26814, -26530, -26146, -25740, -25392, -25126, -24929, -24777, -24645, -24522, -24400, -24271, -24131, -23980, -23813, -23634, -23459, -23286, -23096, -22866, -22610, -22348, -22083, -21800, -21488, -21147, -20781, -20395, -19992, -19567, -19106, -18609, -18078, -17520, -16929, -16300, -15626, -14907, -14143, -13335, -12479, -11571, -10602, -9576, -8494, -7347, -6137, -4860, -3511, -2096, -578};