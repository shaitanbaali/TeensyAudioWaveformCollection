/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1257 256 samples */
 
const int16_t AKWF_1257_256_DATA [256] = 
{722, 1928, 3068, 4174, 5238, 6265, 7253, 8191, 9059, 9845, 10574, 11254, 11881, 12460, 12995, 13493, 13968, 14368, 14649, 14888, 15125, 15373, 15641, 15931, 16243, 16568, 16904, 17242, 17574, 17894, 18191, 18454, 18669, 18811, 18837, 18888, 19153, 19552, 20008, 20487, 20972, 21449, 21907, 22350, 22775, 23183, 23576, 23955, 24317, 24672, 25019, 25357, 25686, 26007, 26318, 26621, 26913, 27197, 27473, 27739, 27996, 28246, 28486, 28719, 28944, 29160, 29370, 29572, 29767, 29956, 30138, 30313, 30483, 30646, 30804, 30956, 31104, 31246, 31383, 31515, 31643, 31765, 31883, 31997, 32105, 32209, 32307, 32400, 32487, 32566, 32638, 32686, 32801, 32193, 30185, 27965, 25805, 23713, 21690, 19731, 17845, 16022, 14260, 12565, 10927, 9348, 7826, 6352, 4930, 3560, 2234, 954, -276, -1466, -2605, -3694, -4736, -5723, -6649, -7511, -8293, -8982, -9560, -9998, -10263, -10313, -10095, -9586, -8851, -7962, -6964, -6061, -5764, -6173, -6931, -7805, -8712, -9609, -10477, -11321, -12137, -12924, -13686, -14423, -15134, -15823, -16488, -17130, -17751, -18351, -18929, -19489, -20029, -20548, -21052, -21537, -22006, -22460, -22897, -23319, -23729, -24123, -24504, -24873, -25228, -25569, -25896, -26205, -26492, -26761, -27021, -27278, -27527, -27771, -28008, -28239, -28465, -28679, -28880, -29069, -29244, -29405, -29547, -29669, -29762, -29814, -29802, -29694, -29439, -28960, -28144, -26929, -25428, -23772, -22034, -20340, -18893, -17899, -17506, -17264, -17129, -17278, -17454, -17632, -17821, -18022, -18236, -18466, -18707, -19007, -19392, -19809, -20244, -20689, -21135, -21581, -22021, -22453, -22875, -23287, -23687, -24077, -24454, -24821, -25176, -25518, -25849, -26169, -26474, -26760, -27019, -27222, -27286, -27174, -26976, -26691, -26295, -25767, -25073, -24184, -23120, -21801, -20229, -18578, -16892, -15208, -13548, -11917, -10328, -8786, -7285, -5833, -4430, -3071, -1762, -472};