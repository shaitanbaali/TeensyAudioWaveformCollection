/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1227 256 samples */
 
const int16_t AKWF_1227_256_DATA [256] = 
{1068, 3734, 6216, 8552, 10721, 12729, 14585, 16297, 17891, 19378, 20768, 22079, 23318, 24484, 25585, 26617, 27577, 28466, 29277, 30005, 30652, 31213, 31685, 32072, 32370, 32584, 32716, 32768, 32744, 32649, 32487, 32263, 31981, 31646, 31264, 30838, 30377, 29882, 29357, 28810, 28235, 27509, 26550, 25360, 23974, 22451, 20841, 19199, 17582, 16019, 14545, 13177, 11924, 10791, 9777, 8872, 8071, 7368, 6750, 6214, 5750, 5354, 5022, 4749, 4533, 4374, 4265, 4207, 4196, 4230, 4306, 4420, 4567, 4742, 4941, 5160, 5392, 5632, 5877, 6120, 6356, 6583, 6793, 6984, 7151, 7293, 7405, 7484, 7528, 7535, 7506, 7437, 7327, 7177, 6988, 6758, 6488, 6180, 5836, 5457, 5046, 4602, 4129, 3634, 3113, 2573, 2016, 1446, 865, 278, -312, -905, -1493, -2076, -2650, -3210, -3756, -4285, -4793, -5281, -5743, -6180, -6590, -6970, -7321, -7643, -7933, -8192, -8421, -8619, -8786, -8925, -9034, -9118, -9174, -9207, -9217, -9206, -9176, -9131, -9071, -8998, -8915, -8823, -8728, -8628, -8527, -8427, -8331, -8240, -8157, -8081, -8016, -7963, -7924, -7899, -7890, -7896, -7921, -7962, -8022, -8100, -8195, -8309, -8439, -8587, -8751, -8930, -9125, -9333, -9553, -9784, -10026, -10275, -10532, -10794, -11059, -11329, -11599, -11867, -12134, -12398, -12655, -12908, -13152, -13387, -13614, -13830, -14033, -14224, -14402, -14566, -14716, -14852, -14971, -15078, -15168, -15245, -15306, -15354, -15388, -15409, -15417, -15413, -15399, -15375, -15341, -15299, -15251, -15195, -15134, -15070, -15001, -14930, -14860, -14787, -14716, -14648, -14581, -14517, -14458, -14404, -14355, -14312, -14275, -14246, -14223, -14207, -14199, -14198, -14206, -14220, -14241, -14269, -14303, -14345, -14393, -14445, -14502, -14564, -14629, -14697, -14768, -14841, -14914, -14987, -15058, -15137, -15021, -14399, -13211, -11504, -9373, -6933, -4312, -1557};