/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1224 256 samples */
 
const int16_t AKWF_1224_256_DATA [256] = 
{2319, 7374, 12309, 16899, 20935, 24322, 27037, 29104, 30605, 31629, 32268, 32618, 32758, 32748, 32640, 32463, 32233, 31957, 31633, 31257, 30815, 30301, 29709, 29032, 28268, 27423, 26494, 25495, 24434, 23317, 22148, 21027, 19105, 15425, 10627, 5302, -61, -5128, -9670, -13538, -16705, -19188, -21042, -22365, -23247, -23783, -24059, -24143, -24084, -23921, -23676, -23358, -22967, -22498, -21947, -21303, -20561, -19719, -18773, -17728, -16593, -15379, -14044, -13310, -13847, -15159, -16835, -18556, -20080, -21263, -22031, -22369, -22311, -21921, -21276, -20460, -19548, -18614, -17711, -16880, -16154, -15544, -15060, -14699, -14453, -14314, -14270, -14306, -14414, -14581, -14802, -15067, -15372, -15714, -16087, -16489, -16919, -17372, -17846, -18338, -18843, -19361, -19884, -20409, -20932, -21450, -21955, -22444, -22915, -23363, -23784, -24175, -24533, -24855, -25141, -25388, -25594, -25753, -25879, -25940, -24471, -21018, -16447, -11389, -6347, -1655, 2412, 5460, 7821, 9772, 11320, 12685, 13939, 15059, 16058, 17178, 18478, 19822, 21113, 22284, 23282, 24076, 24656, 25023, 25188, 25172, 24991, 24671, 24232, 23693, 23074, 22383, 21638, 20846, 20014, 19149, 18260, 17348, 16422, 15488, 14547, 13610, 12697, 11229, 8933, 6179, 3242, 361, -2313, -4674, -6656, -8256, -9484, -10372, -10973, -11334, -11500, -11521, -11406, -11307, -11907, -13154, -14711, -16344, -17859, -19122, -20059, -20622, -21565, -23229, -25191, -27176, -28979, -30447, -31511, -32149, -32376, -32240, -31804, -31135, -30302, -29364, -28379, -27380, -26400, -25464, -24577, -23747, -22976, -22259, -21595, -20980, -20410, -19882, -19397, -18951, -18548, -18189, -17877, -17614, -17402, -17243, -17139, -17093, -17092, -17368, -18076, -19061, -20198, -21390, -22565, -23668, -24675, -25578, -26374, -27079, -27709, -28277, -28814, -29295, -29652, -29900, -30069, -30183, -30261, -30320, -30363, -30395, -30440, -28987, -25349, -20565, -15602, -10917, -6406, -2111};