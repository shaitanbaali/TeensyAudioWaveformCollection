/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1247 256 samples */
 
const int16_t AKWF_1247_256_DATA [256] = 
{4405, 7994, 10260, 12081, 13591, 14875, 15992, 16974, 17821, 18558, 19258, 20083, 20923, 21650, 22396, 23162, 23934, 24704, 25446, 26142, 26781, 27347, 27848, 28297, 28710, 29096, 29468, 29820, 30146, 30443, 30705, 30930, 31120, 31275, 31401, 31499, 31570, 31628, 31682, 31743, 31817, 31905, 32005, 32111, 32211, 32303, 32383, 32448, 32500, 32543, 32578, 32607, 32633, 32654, 32674, 32691, 32705, 32717, 32728, 32735, 32740, 32744, 32744, 32741, 32736, 32730, 32720, 32709, 32695, 32678, 32659, 32637, 32613, 32584, 32554, 32520, 32484, 32444, 32399, 32351, 32300, 32244, 32183, 32118, 32047, 31971, 31891, 31802, 31709, 31607, 31500, 31383, 31260, 31128, 30985, 30833, 30670, 30496, 30310, 30110, 29899, 29672, 29427, 29169, 28892, 28595, 28278, 27940, 27577, 27189, 26774, 26330, 25853, 25340, 24792, 24201, 23566, 22877, 22139, 21333, 20454, 19500, 18451, 17289, 15990, 14525, 12854, 10864, 8460, 4979, -2847, -7441, -9683, -11685, -13420, -15196, -16883, -18354, -19719, -20984, -22158, -23230, -24210, -25090, -25881, -26585, -27215, -27779, -28292, -28769, -29210, -29615, -29981, -30303, -30583, -30820, -31015, -31176, -31304, -31400, -31477, -31544, -31616, -31700, -31798, -31908, -32024, -32137, -32241, -32331, -32405, -32467, -32517, -32558, -32593, -32623, -32649, -32672, -32692, -32711, -32727, -32740, -32751, -32759, -32764, -32767, -32768, -32767, -32763, -32756, -32748, -32738, -32724, -32709, -32691, -32670, -32647, -32622, -32594, -32561, -32526, -32488, -32447, -32401, -32352, -32300, -32243, -32181, -32116, -32045, -31969, -31886, -31798, -31705, -31603, -31494, -31379, -31256, -31124, -30982, -30832, -30670, -30498, -30314, -30119, -29910, -29685, -29447, -29194, -28921, -28632, -28324, -27994, -27644, -27269, -26866, -26436, -25978, -25488, -24963, -24399, -23793, -23143, -22440, -21682, -20858, -19964, -18988, -17910, -16732, -15414, -13915, -12200, -10135, -7636, -3531};