/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1236 256 samples */
 
const int16_t AKWF_1236_256_DATA [256] = 
{18168, 15994, 16506, 16399, 16372, 16341, 16303, 16259, 16209, 16153, 16091, 16022, 15948, 15869, 15786, 15697, 15603, 15504, 15401, 15293, 15180, 15063, 14942, 14817, 14687, 14554, 14417, 14277, 14112, 14104, 13371, 1348, 13848, 13676, 13510, 13351, 13185, 13016, 12843, 12666, 12486, 12303, 12117, 11928, 11736, 11543, 11346, 11149, 10950, 10748, 10545, 10341, 10135, 9929, 9722, 9513, 9304, 9094, 8884, 8675, 8464, 8253, 8042, 7833, 7623, 7412, 7203, 6994, 6787, 6580, 6373, 6169, 5965, 5762, 5563, 5363, 5165, 4970, 4775, 4584, 4395, 4208, 4022, 3839, 3658, 3482, 3307, 3135, 2966, 2799, 2636, 2277, 3173, -2629, -19325, -19272, -19036, -18953, -18826, -18700, -18576, -18455, -18338, -18224, -18113, -18006, -17903, -17804, -17709, -17617, -17531, -17447, -17368, -17295, -17225, -17159, -17098, -17042, -16989, -16942, -16899, -16860, -16827, -16798, -16774, -16417, -18241, -10007, 9816, 8217, 8740, 8942, 9139, 9335, 9528, 9720, 9910, 10099, 10284, 10466, 10648, 10826, 11003, 11177, 11349, 11517, 11684, 11849, 12010, 12169, 12324, 12476, 12626, 12772, 12916, 13056, 13173, 13447, 12996, 1271, 14038, 14151, 14267, 14392, 14508, 14620, 14727, 14828, 14925, 15017, 15103, 15185, 15261, 15333, 15400, 15462, 15519, 15571, 15619, 15661, 15699, 15732, 15760, 15783, 15802, 15814, 15822, 15826, 15817, 15753, 16130, 9224, 7466, 8235, 8309, 8492, 8675, 8858, 9040, 9220, 9399, 9577, 9754, 9930, 10103, 10275, 10445, 10614, 10780, 10944, 11105, 11265, 11422, 11576, 11727, 11877, 12022, 12165, 12305, 12042, 14266, 3177, -30148, -30493, -30415, -30639, -30764, -30882, -30994, -31101, -31200, -31295, -31386, -31471, -31552, -31627, -31697, -31763, -31823, -31879, -31931, -31978, -32020, -32057, -32089, -32117, -32139, -32159, -32171, -32180, -32184, -32183, -32178, -31630, -34514, -18556};