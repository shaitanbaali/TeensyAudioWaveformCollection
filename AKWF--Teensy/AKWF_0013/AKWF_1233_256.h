/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1233 256 samples */
 
const int16_t AKWF_1233_256_DATA [256] = 
{3, 2, 4, 6, 6, 7, 7, 8, 7, 6, 7, 6, 5, 5, 5, 4, 2, 3, 3, 2, 3, 2, 1, 2, 1, 2, 2, 2, 2, 1, 2, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 5, 6, 5, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 8, 37, -45, 1186, 7404, 12926, 13921, 15203, 17369, 19254, 20831, 22204, 23376, 24333, 25096, 25695, 26152, 26483, 26699, 26818, 26852, 26817, 26727, 26592, 26423, 26100, 26519, 23257, 9615, 8491, 8714, 8566, 8496, 8431, 8372, 8319, 8270, 8229, 8193, 8164, 8142, 8125, 8117, 8115, 8119, 8131, 8152, 8179, 8216, 8261, 8441, 7829, 10926, 24852, 25171, 25402, 25766, 26135, 26532, 26956, 27411, 27894, 28406, 28949, 29519, 30112, 30684, 31265, 32093, 16384, -14917, -16720, -12301, -23824, -26986, -26069, -28855, -31070, -32021, -32527, -32755, -32714, -32446, -32004, -31437, -30777, -30063, -29317, -28574, -27850, -27163, -26525, -25942, -25417, -24956, -24559, -24224, -23954, -23741, -23581, -23472, -23407, -23381, -23390, -23428, -23491, -23576, -23676, -23784, -23901, -24022, -24143, -24261, -24373, -24474, -24564, -24637, -24693, -24725, -24731, -24708, -24649, -24547, -24195, -25054, -19851, 7, 51, -44, 5, 6, 7, 8, 8, 8, 8, 7, 7, 6, 6, 5, 5, 4, 3, 3, 3, 3, 3, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 4, 6, 5, 5, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 1, 26, 26};