/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1221 256 samples */
 
const int16_t AKWF_1221_256_DATA [256] = 
{1489, 3727, 5947, 8155, 10270, 12188, 13783, 14916, 15481, 15421, 14764, 13638, 12281, 11008, 10105, 9723, 9931, 10621, 11522, 12330, 12789, 12734, 12128, 11053, 9694, 8283, 7047, 6166, 5733, 5770, 6240, 7078, 8206, 9549, 11046, 12652, 14325, 16054, 17829, 19644, 21507, 23414, 25339, 27249, 29062, 30660, 31903, 32635, 32738, 32176, 31041, 29554, 28016, 26746, 25997, 25867, 26257, 26870, 27289, 27148, 26316, 24952, 23427, 22133, 21360, 21224, 21646, 22388, 23126, 23556, 23483, 22861, 21754, 20304, 18673, 16990, 15368, 13890, 12597, 11513, 10640, 9957, 9432, 9019, 8658, 8285, 7828, 7212, 6376, 5274, 3891, 2266, 498, -1261, -2793, -3882, -4371, -4203, -3477, -2423, -1338, -510, -157, -375, -1106, -2158, -3239, -4056, -4384, -4143, -3385, -2263, -962, 340, 1498, 2402, 2994, 3242, 3147, 2730, 2025, 1075, -79, -1382, -2780, -4216, -5613, -6892, -7965, -8729, -9093, -8984, -8380, -7321, -5940, -4471, -3206, -2432, -2310, -2809, -3686, -4577, -5127, -5093, -4437, -3346, -2194, -1409, -1277, -1815, -2786, -3839, -4637, -4955, -4707, -3942, -2807, -1504, -248, 786, 1490, 1811, 1739, 1297, 526, -528, -1819, -3297, -4922, -6645, -8408, -10155, -11809, -13271, -14442, -15210, -15486, -15214, -14410, -13180, -11701, -10217, -8977, -8192, -7988, -8356, -9147, -10087, -10843, -11133, -10822, -9959, -8739, -7430, -6280, -5483, -5155, -5323, -5944, -6918, -8129, -9450, -10767, -12000, -13092, -14013, -14765, -15365, -15846, -16260, -16665, -17130, -17727, -18517, -19535, -20787, -22220, -23721, -25135, -26259, -26907, -26944, -26335, -25192, -23783, -22492, -21676, -21523, -21955, -22653, -23215, -23302, -22750, -21613, -20160, -18772, -17824, -17517, -17825, -18546, -19403, -20144, -20579, -20600, -20168, -19306, -18074, -16545, -14804, -12924, -10953, -8938, -6900, -4842, -2767, -613};