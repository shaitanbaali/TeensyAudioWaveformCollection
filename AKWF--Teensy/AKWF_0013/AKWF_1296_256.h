/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1296 256 samples */
 
const int16_t AKWF_1296_256_DATA [256] = 
{21682, 21263, 20861, 20464, 20075, 19694, 19318, 18952, 18592, 18238, 17891, 17551, 17217, 16890, 16569, 16252, 15945, 15641, 15343, 15052, 14766, 14485, 14210, 13939, 13674, 13414, 13159, 12909, 12664, 12423, 12185, 11955, 11727, 11504, 11286, 11071, 10861, 10654, 10451, 10253, 10058, 9866, 9679, 9495, 9314, 9137, 8963, 8793, 8626, 8461, 8301, 8143, 7988, 7835, 7688, 7541, 7397, 7257, 7118, 6983, 6850, 6720, 6593, 6467, 6344, 6223, 6105, 5989, 5875, 5764, 5654, 5546, 5441, 5337, 5236, 5136, 5039, 4943, 4849, 4756, 4666, 4577, 4490, 4405, 4321, 4239, 4158, 4079, 4002, 3926, 3851, 3778, 3706, 3635, 3566, 3498, 3431, 3366, 3303, 3240, 3178, 3117, 3058, 3000, 2943, 2887, 2832, 2778, 2725, 2674, 2623, 2573, 2524, 2476, 2429, 2382, 2337, 2293, 2250, 2206, 2164, 2123, 2082, 2043, 2005, 1966, 1929, 1892, 1856, 1821, 1786, 1752, 1719, 1686, 1654, 1623, 1592, 1561, 1532, 1503, 1474, 1446, 1418, 1391, 1365, 1339, 1314, 1289, 1264, 1240, 1217, 1194, 1171, 1148, 1126, 1105, 1084, 1063, 1043, 1024, 1004, 984, 966, 948, 930, 911, 894, 877, 861, 844, 828, 813, 797, 782, 767, 752, 739, 724, 710, 697, 683, 671, 658, 645, 633, 621, 609, 597, 585, 575, 564, 553, 543, 532, 522, 512, 503, 493, -114, 3086, -14989, -35198, -12707, -29462, -31333, -30181, -29696, -29131, -28578, -28034, -27500, -26978, -26465, -25961, -25468, -24984, -24508, -24043, -23585, -23137, -22698, -22265, -21842, -21427, -21019, -20620, -20228, -19843, -19466, -19096, -18732, -18377, -18027, -17684, -17348, -17018, -16694, -16378, -16065, -15760, -15461, -15167, -14878, -14596, -14318, -14045, -13779, -13516, -13259, -13008, -12760, -12518, -12279, -12046, -11818, -11590};