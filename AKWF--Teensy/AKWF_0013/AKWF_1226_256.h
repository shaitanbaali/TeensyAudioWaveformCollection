/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1226 256 samples */
 
const int16_t AKWF_1226_256_DATA [256] = 
{3611, 10684, 16794, 21895, 25900, 28848, 30852, 32057, 32641, 32769, 32588, 32220, 31755, 31259, 30767, 30293, 29839, 29389, 28928, 28435, 27891, 27280, 26591, 25821, 24948, 23059, 19934, 16126, 12015, 7896, 4015, 508, -2555, -5142, -7277, -9011, -10393, -11492, -12368, -13068, -13637, -14102, -14478, -14777, -15000, -15140, -15194, -15151, -15006, -14751, -14383, -13903, -13310, -12609, -11809, -10915, -9940, -8898, -7793, -6644, -5461, -4255, -3042, -1831, -629, 547, 1692, 2797, 3849, 4844, 5777, 6635, 7419, 8121, 8736, 9264, 9701, 10043, 10293, 10450, 10513, 10484, 10367, 10164, 9879, 9514, 9078, 8573, 8006, 7385, 6713, 6000, 5252, 4485, 3665, 2994, 3861, 6231, 9394, 12861, 16228, 19232, 21713, 23594, 24886, 25644, 25954, 25916, 25636, 25206, 24705, 24196, 23725, 23317, 22985, 22732, 22550, 22428, 22351, 22306, 22279, 22257, 22201, 22275, 21157, 16977, 10800, 3643, -3716, -10649, -16779, -21893, -25897, -28845, -30849, -32054, -32639, -32767, -32586, -32217, -31753, -31258, -30766, -30292, -29837, -29388, -28927, -28435, -27890, -27280, -26591, -25821, -24949, -23065, -19944, -16139, -12029, -7909, -4026, -518, 2548, 5136, 7273, 9008, 10391, 11491, 12368, 13069, 13638, 14102, 14479, 14779, 15001, 15142, 15195, 15152, 15007, 14752, 14385, 13905, 13311, 12611, 11812, 10918, 9944, 8900, 7795, 6646, 5465, 4258, 3045, 1833, 631, -544, -1689, -2794, -3845, -4841, -5773, -6632, -7415, -8118, -8734, -9261, -9699, -10043, -10293, -10449, -10513, -10485, -10369, -10166, -9880, -9516, -9081, -8576, -8008, -7388, -6715, -6002, -5255, -4487, -3668, -2997, -3864, -6234, -9397, -12863, -16229, -19233, -21714, -23594, -24887, -25645, -25954, -25916, -25635, -25206, -24705, -24196, -23725, -23316, -22983, -22730, -22548, -22425, -22349, -22304, -22276, -22255, -22199, -22273, -21154, -16988, -10828, -3539};