/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0010 256 samples */
 
const int16_t AKWF_flute_0010_256_DATA [256] = 
{150, 552, 1080, 1649, 2184, 2678, 3158, 3633, 4104, 4569, 5023, 5470, 5914, 6351, 6783, 7211, 7630, 8048, 8463, 8873, 9281, 9686, 10085, 10487, 10886, 11282, 11680, 12075, 12469, 12866, 13260, 13655, 14051, 14443, 14838, 15235, 15630, 16025, 16420, 16815, 17210, 17605, 17999, 18392, 18782, 19170, 19559, 19945, 20324, 20703, 21077, 21446, 21812, 22171, 22522, 22870, 23210, 23540, 23865, 24178, 24483, 24779, 25063, 25337, 25598, 25846, 26080, 26302, 26508, 26699, 26872, 27029, 27168, 27288, 27387, 27467, 27526, 27563, 27578, 27569, 27538, 27483, 27403, 27301, 27173, 27021, 26844, 26643, 26417, 26165, 25890, 25589, 25266, 24918, 24546, 24153, 23736, 23300, 22842, 22363, 21866, 21351, 20818, 20270, 19704, 19122, 18528, 17919, 17302, 16672, 16031, 15381, 14725, 14064, 13396, 12722, 12044, 11364, 10683, 10003, 9320, 8639, 7958, 7279, 6606, 5937, 5270, 4608, 3950, 3300, 2660, 2021, 1392, 768, 151, -456, -1057, -1653, -2241, -2824, -3402, -3969, -4535, -5097, -5655, -6211, -6766, -7315, -7867, -8419, -8969, -9520, -10074, -10629, -11189, -11752, -12316, -12885, -13460, -14042, -14628, -15219, -15812, -16417, -17025, -17636, -18254, -18874, -19495, -20124, -20752, -21381, -22011, -22634, -23257, -23877, -24488, -25093, -25688, -26267, -26838, -27392, -27928, -28447, -28942, -29415, -29865, -30289, -30684, -31049, -31380, -31681, -31947, -32178, -32372, -32528, -32646, -32726, -32765, -32763, -32723, -32641, -32519, -32358, -32154, -31914, -31633, -31314, -30958, -30565, -30137, -29679, -29184, -28659, -28106, -27522, -26917, -26287, -25630, -24954, -24259, -23546, -22822, -22081, -21328, -20566, -19795, -19020, -18243, -17459, -16673, -15889, -15106, -14330, -13557, -12786, -12021, -11266, -10519, -9782, -9052, -8333, -7625, -6929, -6249, -5578, -4919, -4274, -3647, -3034, -2415, -1772, -1157, -654, -325, -97};