/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0011 256 samples */
 
const int16_t AKWF_flute_0011_256_DATA [256] = 
{136, 516, 1089, 1772, 2449, 3073, 3661, 4238, 4815, 5384, 5941, 6490, 7029, 7560, 8084, 8600, 9108, 9608, 10101, 10588, 11070, 11546, 12014, 12474, 12931, 13381, 13828, 14269, 14703, 15132, 15558, 15978, 16395, 16805, 17212, 17614, 18011, 18405, 18793, 19176, 19557, 19932, 20302, 20668, 21028, 21383, 21733, 22077, 22414, 22744, 23067, 23382, 23690, 23991, 24282, 24563, 24836, 25100, 25353, 25597, 25830, 26053, 26264, 26465, 26653, 26828, 26990, 27140, 27274, 27395, 27501, 27592, 27667, 27727, 27771, 27799, 27811, 27807, 27784, 27743, 27685, 27607, 27508, 27391, 27252, 27093, 26912, 26711, 26488, 26242, 25975, 25685, 25375, 25041, 24685, 24307, 23907, 23485, 23046, 22582, 22100, 21596, 21073, 20534, 19979, 19401, 18810, 18203, 17580, 16948, 16299, 15637, 14969, 14288, 13600, 12909, 12206, 11498, 10787, 10068, 9352, 8635, 7912, 7188, 6468, 5747, 5033, 4319, 3607, 2901, 2200, 1507, 820, 138, -539, -1206, -1865, -2522, -3168, -3808, -4442, -5063, -5681, -6292, -6895, -7492, -8083, -8663, -9241, -9814, -10379, -10942, -11495, -12046, -12595, -13139, -13681, -14221, -14753, -15289, -15822, -16355, -16889, -17420, -17951, -18485, -19020, -19554, -20089, -20623, -21160, -21696, -22233, -22767, -23298, -23828, -24355, -24879, -25398, -25909, -26412, -26909, -27394, -27871, -28334, -28780, -29211, -29626, -30021, -30398, -30749, -31079, -31383, -31662, -31913, -32134, -32326, -32487, -32613, -32707, -32763, -32767, -32769, -32736, -32651, -32532, -32375, -32181, -31950, -31682, -31377, -31037, -30662, -30252, -29809, -29331, -28821, -28282, -27714, -27114, -26489, -25839, -25163, -24470, -23751, -23016, -22263, -21492, -20711, -19919, -19112, -18299, -17478, -16649, -15825, -14993, -14160, -13328, -12500, -11676, -10855, -10037, -9226, -8424, -7633, -6846, -6072, -5305, -4556, -3825, -3091, -2326, -1552, -870, -388, -100};