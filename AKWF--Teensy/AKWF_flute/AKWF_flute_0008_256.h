/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0008 256 samples */
 
const int16_t AKWF_flute_0008_256_DATA [256] = 
{341, 822, 1329, 1918, 2563, 3207, 3814, 4392, 4955, 5507, 6044, 6570, 7081, 7580, 8069, 8549, 9016, 9474, 9923, 10366, 10800, 11228, 11649, 12064, 12475, 12881, 13283, 13681, 14073, 14462, 14848, 15232, 15612, 15989, 16364, 16738, 17109, 17478, 17845, 18209, 18570, 18931, 19290, 19647, 20000, 20351, 20700, 21046, 21388, 21726, 22060, 22390, 22717, 23038, 23352, 23659, 23961, 24254, 24541, 24819, 25086, 25344, 25592, 25827, 26052, 26264, 26461, 26647, 26816, 26972, 27112, 27235, 27342, 27433, 27505, 27560, 27596, 27614, 27613, 27592, 27551, 27491, 27411, 27310, 27188, 27046, 26882, 26697, 26492, 26265, 26017, 25747, 25457, 25144, 24810, 24455, 24077, 23680, 23265, 22827, 22371, 21894, 21397, 20887, 20358, 19809, 19245, 18665, 18069, 17464, 16843, 16207, 15561, 14903, 14236, 13565, 12877, 12184, 11486, 10779, 10071, 9358, 8638, 7916, 7193, 6467, 5745, 5020, 4295, 3574, 2855, 2143, 1436, 730, 30, -661, -1348, -2023, -2694, -3357, -4011, -4656, -5289, -5912, -6528, -7133, -7729, -8311, -8888, -9454, -10010, -10559, -11096, -11624, -12146, -12661, -13168, -13669, -14161, -14651, -15136, -15616, -16094, -16567, -17036, -17506, -17975, -18442, -18910, -19376, -19845, -20316, -20789, -21262, -21739, -22217, -22697, -23179, -23663, -24145, -24626, -25108, -25588, -26066, -26539, -27005, -27465, -27919, -28363, -28796, -29217, -29621, -30013, -30386, -30740, -31072, -31380, -31663, -31920, -32146, -32342, -32504, -32634, -32730, -32769, -32766, -32769, -32728, -32627, -32488, -32308, -32084, -31823, -31518, -31173, -30787, -30361, -29898, -29396, -28857, -28283, -27676, -27037, -26372, -25673, -24949, -24200, -23427, -22635, -21827, -20996, -20154, -19297, -18428, -17559, -16678, -15789, -14903, -14013, -13125, -12246, -11363, -10488, -9623, -8761, -7915, -7079, -6250, -5435, -4639, -3860, -3089, -2320, -1548, -816, -173};