/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0012 256 samples */
 
const int16_t AKWF_flute_0012_256_DATA [256] = 
{555, 1715, 2841, 3959, 5046, 6097, 7104, 8047, 8941, 9788, 10584, 11334, 12041, 12710, 13344, 13945, 14518, 15065, 15597, 16110, 16614, 17101, 17560, 18000, 18423, 18828, 19223, 19606, 19979, 20350, 20717, 21085, 21455, 21827, 22205, 22592, 22981, 23374, 23766, 24148, 24526, 24892, 25241, 25573, 25883, 26168, 26429, 26662, 26870, 27056, 27224, 27377, 27521, 27662, 27802, 27947, 28100, 28267, 28448, 28646, 28858, 29083, 29316, 29555, 29797, 30037, 30270, 30493, 30701, 30890, 31056, 31195, 31310, 31407, 31481, 31533, 31560, 31558, 31526, 31461, 31364, 31227, 31054, 30841, 30588, 30291, 29951, 29568, 29150, 28694, 28208, 27696, 27162, 26612, 26048, 25476, 24895, 24314, 23728, 23139, 22543, 21940, 21327, 20706, 20074, 19429, 18767, 18087, 17388, 16671, 15936, 15178, 14406, 13614, 12815, 12003, 11175, 10341, 9500, 8654, 7810, 6962, 6111, 5264, 4416, 3570, 2726, 1880, 1035, 193, -647, -1482, -2317, -3150, -3982, -4810, -5630, -6447, -7257, -8062, -8862, -9657, -10443, -11231, -12013, -12796, -13575, -14349, -15121, -15897, -16669, -17441, -18207, -18958, -19704, -20435, -21147, -21841, -22509, -23146, -23761, -24342, -24891, -25412, -25897, -26358, -26795, -27208, -27602, -27979, -28342, -28695, -29041, -29378, -29709, -30036, -30356, -30668, -30968, -31255, -31527, -31783, -32018, -32232, -32422, -32584, -32722, -32771, -32766, -32767, -32767, -32767, -32767, -32767, -32767, -32770, -32719, -32613, -32500, -32375, -32238, -32090, -31931, -31757, -31570, -31370, -31155, -30927, -30684, -30424, -30149, -29858, -29550, -29228, -28891, -28540, -28172, -27791, -27389, -26968, -26527, -26064, -25579, -25073, -24539, -23982, -23398, -22785, -22153, -21495, -20815, -20121, -19414, -18696, -17977, -17247, -16517, -15789, -15061, -14346, -13639, -12934, -12225, -11511, -10783, -10040, -9267, -8463, -7622, -6742, -5822, -4854, -3836, -2776, -1685, -543};