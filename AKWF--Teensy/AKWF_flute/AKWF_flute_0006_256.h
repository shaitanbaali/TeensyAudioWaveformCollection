/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0006 256 samples */
 
const int16_t AKWF_flute_0006_256_DATA [256] = 
{174, 799, 1518, 2192, 2775, 3325, 3904, 4514, 5149, 5788, 6434, 7100, 7788, 8496, 9204, 9892, 10572, 11269, 11986, 12736, 13537, 14396, 15245, 16002, 16640, 17227, 17846, 18500, 19162, 19819, 20465, 21092, 21691, 22264, 22861, 23505, 24173, 24822, 25435, 26027, 26639, 27272, 27915, 28564, 29204, 29815, 30376, 30872, 31278, 31567, 31758, 31948, 32199, 32475, 32680, 32763, 32768, 32767, 32767, 32765, 32682, 32506, 32281, 32046, 31802, 31526, 31202, 30833, 30430, 29998, 29546, 29106, 28697, 28299, 27877, 27412, 26927, 26451, 25985, 25511, 25007, 24464, 23893, 23295, 22671, 22009, 21302, 20562, 19816, 19077, 18351, 17652, 16985, 16327, 15631, 14881, 14094, 13303, 12513, 11688, 10793, 9837, 8870, 7939, 7050, 6193, 5375, 4589, 3825, 3084, 2344, 1560, 724, -112, -864, -1500, -2071, -2617, -3140, -3633, -4090, -4513, -4928, -5340, -5749, -6156, -6567, -6959, -7282, -7509, -7680, -7864, -8080, -8319, -8569, -8830, -9073, -9265, -9410, -9544, -9697, -9876, -10105, -10408, -10765, -11127, -11462, -11789, -12166, -12605, -13065, -13486, -13855, -14236, -14715, -15286, -15888, -16461, -17004, -17562, -18162, -18784, -19377, -19911, -20401, -20902, -21427, -21945, -22407, -22798, -23135, -23439, -23714, -23962, -24193, -24407, -24612, -24814, -25005, -25164, -25278, -25354, -25416, -25484, -25530, -25492, -25345, -25182, -25138, -25237, -25332, -25261, -25019, -24720, -24458, -24233, -24016, -23785, -23553, -23328, -23119, -22904, -22633, -22281, -21898, -21557, -21275, -21015, -20721, -20390, -20077, -19842, -19674, -19478, -19173, -18791, -18459, -18259, -18125, -17906, -17533, -17082, -16681, -16372, -16085, -15735, -15309, -14863, -14456, -14082, -13714, -13328, -12922, -12500, -12064, -11602, -11085, -10495, -9867, -9276, -8747, -8240, -7699, -7109, -6508, -5936, -5392, -4836, -4239, -3605, -2951, -2272, -1596, -1016, -600, -252};