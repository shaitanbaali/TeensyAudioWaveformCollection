/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0017 256 samples */
 
const int16_t AKWF_flute_0017_256_DATA [256] = 
{257, 1029, 1729, 2292, 2808, 3288, 3766, 4229, 4632, 4963, 5234, 5473, 5671, 5837, 5988, 6134, 6276, 6433, 6619, 6806, 6981, 7155, 7373, 7643, 7931, 8200, 8470, 8813, 9301, 9946, 10645, 11286, 11789, 12160, 12461, 12763, 13105, 13457, 13738, 13881, 13931, 13962, 14029, 14141, 14279, 14419, 14553, 14707, 14920, 15228, 15642, 16120, 16606, 17061, 17454, 17789, 18100, 18494, 19037, 19703, 20432, 21170, 21876, 22545, 23185, 23784, 24318, 24755, 25087, 25363, 25654, 25967, 26251, 26434, 26538, 26641, 26838, 27177, 27682, 28310, 28978, 29602, 30143, 30614, 31039, 31442, 31836, 32215, 32546, 32748, 32774, 32665, 32357, 31941, 31500, 31055, 30570, 29990, 29304, 28516, 27643, 26717, 25809, 24984, 24283, 23718, 23233, 22728, 22150, 21533, 20920, 20265, 19485, 18584, 17686, 16845, 16024, 15143, 14175, 13145, 12102, 11064, 10011, 8917, 7800, 6692, 5607, 4536, 3466, 2347, 1163, -36, -1129, -2041, -2785, -3404, -3938, -4382, -4694, -4877, -4988, -5113, -5299, -5520, -5736, -5939, -6137, -6368, -6684, -7128, -7659, -8185, -8664, -9103, -9511, -9884, -10258, -10640, -10982, -11240, -11450, -11655, -11825, -11950, -12057, -12196, -12345, -12490, -12662, -12937, -13341, -13827, -14294, -14688, -15036, -15405, -15814, -16270, -16739, -17159, -17471, -17680, -17859, -18092, -18395, -18732, -19061, -19368, -19668, -19978, -20304, -20727, -21333, -22077, -22831, -23506, -24163, -24798, -25357, -25772, -26080, -26293, -26402, -26416, -26372, -26306, -26239, -26195, -26153, -26089, -26043, -26040, -26065, -26056, -26010, -25977, -26035, -26248, -26605, -27032, -27455, -27780, -27931, -27886, -27700, -27411, -27025, -26555, -25988, -25292, -24441, -23484, -22462, -21386, -20217, -18956, -17645, -16295, -14921, -13586, -12371, -11303, -10340, -9432, -8587, -7802, -7069, -6392, -5773, -5167, -4504, -3783, -3010, -2124, -1015, -223};