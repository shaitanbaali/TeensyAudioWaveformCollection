/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0013 256 samples */
 
const int16_t AKWF_flute_0013_256_DATA [256] = 
{761, 1864, 2911, 3919, 4876, 5785, 6661, 7493, 8287, 9047, 9765, 10456, 11120, 11756, 12371, 12967, 13540, 14105, 14648, 15170, 15670, 16150, 16612, 17054, 17474, 17873, 18253, 18614, 18957, 19282, 19587, 19867, 20129, 20373, 20605, 20830, 21051, 21274, 21506, 21749, 22008, 22287, 22585, 22909, 23259, 23627, 24015, 24415, 24818, 25227, 25630, 26022, 26397, 26750, 27077, 27375, 27644, 27888, 28109, 28304, 28477, 28628, 28757, 28865, 28954, 29024, 29077, 29115, 29138, 29140, 29121, 29083, 29027, 28956, 28873, 28779, 28675, 28566, 28454, 28340, 28225, 28110, 27995, 27879, 27761, 27639, 27509, 27370, 27219, 27054, 26870, 26669, 26445, 26195, 25923, 25631, 25318, 24983, 24625, 24241, 23835, 23400, 22941, 22453, 21935, 21388, 20813, 20208, 19574, 18911, 18220, 17502, 16762, 16003, 15221, 14423, 13605, 12775, 11937, 11089, 10226, 9354, 8469, 7582, 6682, 5778, 4874, 3968, 3065, 2167, 1272, 381, -498, -1371, -2231, -3085, -3929, -4766, -5590, -6403, -7205, -7999, -8784, -9559, -10322, -11072, -11816, -12545, -13265, -13972, -14663, -15341, -16008, -16660, -17299, -17923, -18527, -19121, -19699, -20259, -20804, -21331, -21843, -22345, -22834, -23311, -23781, -24239, -24691, -25139, -25579, -26015, -26444, -26859, -27272, -27675, -28067, -28449, -28822, -29183, -29532, -29868, -30190, -30496, -30792, -31077, -31350, -31608, -31846, -32064, -32259, -32426, -32564, -32668, -32737, -32767, -32763, -32718, -32632, -32510, -32354, -32166, -31953, -31715, -31458, -31188, -30904, -30611, -30313, -30009, -29703, -29390, -29068, -28737, -28397, -28044, -27680, -27297, -26898, -26479, -26039, -25579, -25096, -24589, -24060, -23512, -22949, -22365, -21770, -21163, -20546, -19928, -19302, -18669, -18039, -17408, -16784, -16167, -15541, -14911, -14267, -13600, -12913, -12192, -11431, -10627, -9778, -8879, -7934, -6934, -5888, -4808, -3701, -2583, -1459, -313};