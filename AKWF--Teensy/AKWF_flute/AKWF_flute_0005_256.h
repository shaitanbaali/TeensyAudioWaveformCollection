/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0005 256 samples */
 
const int16_t AKWF_flute_0005_256_DATA [256] = 
{248, 1008, 2034, 3261, 4470, 5633, 6788, 7933, 9065, 10184, 11281, 12396, 13517, 14614, 15678, 16670, 17515, 18238, 19047, 20066, 21086, 21843, 22395, 22952, 23581, 24217, 24820, 25410, 26006, 26603, 27202, 27799, 28352, 28817, 29203, 29555, 29886, 30233, 30628, 31037, 31396, 31702, 32005, 32316, 32587, 32748, 32777, 32698, 32398, 32092, 31914, 31706, 31212, 30470, 29696, 28982, 28281, 27573, 26799, 25789, 24535, 23290, 22228, 21208, 20060, 18778, 17414, 15983, 14606, 13407, 12287, 11038, 9638, 8203, 6800, 5458, 4209, 3056, 1934, 816, -335, -1570, -2842, -4048, -5163, -6142, -6946, -7708, -8587, -9537, -10373, -11047, -11702, -12461, -13221, -13821, -14265, -14673, -15101, -15570, -16126, -16705, -17111, -17309, -17526, -17928, -18423, -18876, -19278, -19639, -19958, -20306, -20769, -21285, -21686, -21931, -22162, -22459, -22752, -22947, -23050, -23133, -23222, -23306, -23374, -23427, -23477, -23514, -23450, -23224, -22965, -22880, -22913, -22787, -22409, -22005, -21758, -21593, -21363, -21034, -20636, -20177, -19638, -19005, -18308, -17615, -16962, -16318, -15671, -15019, -14337, -13627, -12906, -12182, -11476, -10818, -10201, -9597, -9004, -8344, -7545, -6723, -6062, -5558, -5010, -4318, -3619, -3051, -2585, -2160, -1763, -1371, -960, -590, -370, -282, -176, 13, 181, 229, 201, 218, 292, 338, 311, 205, -15, -294, -411, -284, -140, -195, -379, -535, -630, -680, -690, -682, -676, -706, -877, -1218, -1536, -1650, -1659, -1770, -2008, -2263, -2484, -2709, -2975, -3268, -3546, -3802, -4054, -4316, -4600, -4937, -5321, -5683, -5983, -6290, -6689, -7140, -7530, -7824, -8075, -8321, -8546, -8725, -8863, -8994, -9127, -9274, -9451, -9614, -9643, -9519, -9382, -9335, -9295, -9133, -8848, -8491, -8076, -7633, -7199, -6751, -6238, -5645, -4950, -4156, -3276, -2307, -1307, -421};