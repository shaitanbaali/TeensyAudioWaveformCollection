/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0014 256 samples */
 
const int16_t AKWF_flute_0014_256_DATA [256] = 
{430, 1349, 2217, 3050, 3851, 4620, 5358, 6066, 6744, 7404, 8042, 8667, 9279, 9881, 10478, 11078, 11677, 12279, 12879, 13469, 14060, 14646, 15227, 15800, 16368, 16929, 17483, 18028, 18563, 19086, 19600, 20104, 20599, 21085, 21562, 22033, 22503, 22970, 23438, 23906, 24372, 24845, 25320, 25800, 26286, 26770, 27253, 27733, 28203, 28663, 29106, 29525, 29925, 30299, 30644, 30958, 31240, 31492, 31718, 31916, 32089, 32238, 32367, 32475, 32566, 32642, 32703, 32754, 32769, 32767, 32767, 32767, 32769, 32756, 32695, 32610, 32499, 32363, 32198, 32002, 31776, 31519, 31230, 30915, 30570, 30198, 29801, 29378, 28934, 28472, 27987, 27486, 26970, 26434, 25890, 25331, 24753, 24162, 23555, 22931, 22297, 21639, 20965, 20273, 19561, 18834, 18089, 17321, 16535, 15734, 14917, 14094, 13261, 12422, 11580, 10743, 9909, 9082, 8262, 7452, 6653, 5865, 5090, 4321, 3557, 2796, 2043, 1288, 529, -231, -996, -1769, -2541, -3326, -4114, -4904, -5695, -6482, -7264, -8044, -8815, -9573, -10320, -11049, -11764, -12464, -13146, -13809, -14457, -15092, -15716, -16335, -16946, -17551, -18154, -18758, -19364, -19975, -20587, -21199, -21813, -22426, -23032, -23632, -24219, -24786, -25339, -25869, -26376, -26855, -27303, -27721, -28117, -28483, -28826, -29144, -29438, -29712, -29966, -30202, -30421, -30626, -30817, -30994, -31155, -31298, -31423, -31533, -31626, -31706, -31771, -31822, -31859, -31884, -31897, -31896, -31885, -31866, -31836, -31794, -31737, -31662, -31566, -31446, -31297, -31118, -30905, -30656, -30374, -30051, -29690, -29296, -28867, -28410, -27930, -27422, -26897, -26357, -25802, -25243, -24677, -24104, -23528, -22943, -22348, -21752, -21147, -20537, -19924, -19313, -18697, -18081, -17464, -16848, -16233, -15628, -15028, -14433, -13839, -13241, -12639, -12018, -11378, -10716, -10024, -9302, -8551, -7756, -6925, -6058, -5158, -4241, -3307, -2362, -1417, -465};