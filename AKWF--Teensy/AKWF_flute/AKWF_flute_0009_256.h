/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0009 256 samples */
 
const int16_t AKWF_flute_0009_256_DATA [256] = 
{253, 780, 1266, 1734, 2192, 2643, 3105, 3581, 4080, 4610, 5175, 5780, 6428, 7107, 7821, 8558, 9307, 10071, 10837, 11595, 12342, 13066, 13758, 14426, 15066, 15683, 16279, 16851, 17399, 17928, 18435, 18921, 19389, 19836, 20268, 20684, 21080, 21452, 21803, 22136, 22456, 22768, 23071, 23374, 23679, 23989, 24309, 24640, 24979, 25333, 25695, 26064, 26439, 26816, 27188, 27561, 27924, 28278, 28620, 28944, 29252, 29546, 29825, 30089, 30339, 30576, 30802, 31019, 31226, 31425, 31616, 31799, 31977, 32149, 32314, 32469, 32607, 32732, 32772, 32766, 32768, 32767, 32766, 32772, 32732, 32574, 32377, 32142, 31867, 31555, 31207, 30825, 30412, 29970, 29498, 29001, 28478, 27933, 27355, 26751, 26123, 25472, 24805, 24119, 23416, 22700, 21976, 21240, 20502, 19754, 18998, 18234, 17466, 16693, 15913, 15129, 14339, 13544, 12746, 11947, 11139, 10331, 9519, 8708, 7899, 7086, 6264, 5437, 4599, 3752, 2898, 2025, 1139, 238, -676, -1600, -2532, -3478, -4426, -5380, -6338, -7286, -8238, -9183, -10121, -11048, -11968, -12883, -13791, -14686, -15566, -16428, -17276, -18099, -18903, -19681, -20427, -21147, -21839, -22503, -23139, -23747, -24324, -24878, -25405, -25905, -26383, -26835, -27263, -27672, -28057, -28417, -28753, -29063, -29355, -29629, -29884, -30125, -30351, -30564, -30768, -30963, -31148, -31322, -31485, -31636, -31778, -31907, -32025, -32132, -32226, -32308, -32377, -32431, -32473, -32504, -32523, -32528, -32518, -32488, -32436, -32361, -32258, -32127, -31962, -31767, -31536, -31270, -30973, -30643, -30283, -29895, -29477, -29033, -28566, -28073, -27562, -27030, -26478, -25908, -25316, -24706, -24083, -23438, -22778, -22105, -21419, -20724, -20019, -19303, -18578, -17849, -17113, -16375, -15630, -14882, -14128, -13373, -12616, -11858, -11098, -10335, -9572, -8808, -8043, -7271, -6502, -5736, -4985, -4246, -3520, -2818, -2141, -1491, -875, -279};