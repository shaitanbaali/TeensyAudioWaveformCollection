/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0002 256 samples */
 
const int16_t AKWF_flute_0002_256_DATA [256] = 
{328, 1251, 2085, 2777, 3298, 3644, 3804, 3776, 3627, 3491, 3466, 3539, 3631, 3742, 4000, 4531, 5280, 6079, 6780, 7359, 7847, 8263, 8598, 8866, 9102, 9344, 9608, 9875, 10095, 10183, 10137, 10038, 10017, 10084, 10189, 10282, 10408, 10603, 10873, 11214, 11627, 12105, 12594, 13067, 13529, 13985, 14430, 14839, 15187, 15461, 15710, 16025, 16457, 16948, 17399, 17807, 18205, 18634, 19093, 19554, 20008, 20491, 21028, 21623, 22256, 22920, 23634, 24417, 25272, 26174, 27102, 28047, 28978, 29846, 30595, 31253, 31843, 32334, 32652, 32768, 32745, 32635, 32469, 32257, 31988, 31665, 31329, 31050, 30884, 30831, 30844, 30890, 30951, 31011, 31025, 30971, 30859, 30733, 30613, 30474, 30264, 29945, 29498, 28930, 28244, 27460, 26600, 25701, 24807, 23922, 23036, 22119, 21137, 20055, 18921, 17770, 16618, 15418, 14130, 12743, 11261, 9685, 8045, 6413, 4843, 3351, 1982, 762, -297, -1185, -1914, -2507, -3000, -3430, -3831, -4214, -4569, -4859, -5073, -5257, -5479, -5803, -6262, -6846, -7503, -8158, -8733, -9212, -9628, -10038, -10438, -10795, -11099, -11393, -11704, -11994, -12224, -12390, -12520, -12625, -12766, -13024, -13429, -13891, -14281, -14532, -14673, -14793, -14996, -15322, -15722, -16102, -16451, -16778, -17090, -17381, -17633, -17840, -18010, -18210, -18489, -18843, -19250, -19702, -20218, -20806, -21443, -22076, -22647, -23189, -23787, -24471, -25208, -25944, -26657, -27302, -27878, -28442, -28989, -29420, -29636, -29751, -29883, -30087, -30283, -30458, -30646, -30874, -31117, -31336, -31503, -31613, -31656, -31618, -31479, -31227, -30873, -30460, -30033, -29630, -29226, -28824, -28462, -28184, -27977, -27802, -27619, -27427, -27229, -27040, -26913, -26909, -27041, -27235, -27377, -27357, -27100, -26552, -25706, -24612, -23358, -22008, -20586, -19084, -17447, -15687, -13877, -12058, -10273, -8553, -6939, -5494, -4204, -2990, -1816, -653};