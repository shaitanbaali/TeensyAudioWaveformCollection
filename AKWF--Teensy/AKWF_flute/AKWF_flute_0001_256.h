/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0001 256 samples */
 
const int16_t AKWF_flute_0001_256_DATA [256] = 
{398, 1130, 1933, 2675, 3296, 3766, 4105, 4390, 4738, 5165, 5559, 5815, 5912, 5915, 5891, 5928, 6074, 6271, 6450, 6593, 6757, 6984, 7321, 7786, 8340, 8889, 9362, 9777, 10177, 10589, 10996, 11358, 11638, 11822, 11922, 11985, 12081, 12268, 12526, 12769, 12915, 12973, 13013, 13137, 13363, 13660, 13998, 14383, 14791, 15185, 15557, 15924, 16322, 16777, 17322, 17946, 18607, 19259, 19903, 20556, 21205, 21801, 22322, 22831, 23387, 23972, 24496, 24947, 25372, 25860, 26447, 27100, 27750, 28360, 28905, 29400, 29868, 30342, 30857, 31386, 31867, 32229, 32442, 32572, 32682, 32765, 32719, 32515, 32194, 31816, 31353, 30798, 30210, 29699, 29308, 29003, 28754, 28521, 28264, 27957, 27644, 27369, 27132, 26859, 26479, 25970, 25337, 24600, 23767, 22837, 21757, 20511, 19133, 17674, 16193, 14732, 13316, 11982, 10719, 9459, 8175, 6848, 5490, 4112, 2731, 1382, 121, -1040, -2082, -3000, -3786, -4433, -4953, -5373, -5706, -5942, -6056, -6063, -6027, -6084, -6288, -6586, -6849, -7051, -7256, -7542, -7918, -8365, -8872, -9434, -10038, -10677, -11333, -11965, -12525, -12971, -13287, -13488, -13590, -13651, -13735, -13887, -14075, -14267, -14467, -14719, -15006, -15279, -15522, -15771, -16067, -16410, -16764, -17088, -17370, -17623, -17878, -18165, -18466, -18735, -18961, -19234, -19629, -20126, -20598, -20989, -21379, -21918, -22628, -23390, -24057, -24617, -25151, -25740, -26421, -27176, -27918, -28546, -29045, -29417, -29683, -29829, -29877, -29869, -29836, -29815, -29844, -29959, -30150, -30386, -30635, -30902, -31183, -31461, -31690, -31834, -31887, -31875, -31805, -31672, -31450, -31109, -30617, -29974, -29225, -28415, -27574, -26736, -25927, -25158, -24414, -23697, -22997, -22312, -21676, -21108, -20615, -20142, -19606, -18966, -18256, -17465, -16574, -15550, -14431, -13269, -12068, -10785, -9433, -8039, -6632, -5232, -3840, -2532, -1315, -283};