/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0015 256 samples */
 
const int16_t AKWF_flute_0015_256_DATA [256] = 
{555, 1466, 2419, 3373, 4238, 4959, 5527, 5974, 6343, 6628, 6810, 6885, 6878, 6815, 6739, 6691, 6685, 6723, 6795, 6880, 6960, 7060, 7244, 7588, 8074, 8614, 9128, 9631, 10140, 10613, 11039, 11448, 11873, 12260, 12575, 12811, 12987, 13154, 13340, 13529, 13737, 13980, 14263, 14565, 14906, 15316, 15760, 16201, 16644, 17162, 17752, 18375, 18970, 19529, 20080, 20646, 21207, 21724, 22184, 22619, 23049, 23466, 23853, 24203, 24508, 24769, 25015, 25306, 25674, 26094, 26541, 26981, 27379, 27710, 28001, 28339, 28790, 29326, 29866, 30345, 30783, 31238, 31714, 32165, 32503, 32673, 32721, 32734, 32763, 32766, 32676, 32432, 32050, 31618, 31193, 30772, 30268, 29642, 28918, 28157, 27383, 26576, 25702, 24771, 23833, 22922, 22006, 21069, 20147, 19302, 18495, 17683, 16873, 16082, 15314, 14566, 13858, 13208, 12615, 12070, 11573, 11103, 10601, 10035, 9368, 8563, 7624, 6555, 5403, 4255, 3183, 2177, 1140, 59, -999, -1930, -2725, -3410, -4000, -4516, -5000, -5476, -5939, -6394, -6825, -7207, -7508, -7767, -8058, -8404, -8733, -8977, -9160, -9367, -9637, -9927, -10203, -10484, -10790, -11109, -11406, -11672, -11939, -12203, -12449, -12686, -12975, -13325, -13704, -14078, -14463, -14864, -15240, -15577, -15896, -16225, -16566, -16879, -17126, -17323, -17549, -17859, -18228, -18558, -18788, -18944, -19118, -19400, -19847, -20466, -21138, -21734, -22180, -22521, -22845, -23209, -23633, -24103, -24572, -25000, -25377, -25703, -25993, -26206, -26287, -26225, -26093, -25924, -25695, -25392, -25110, -24949, -24903, -24868, -24736, -24481, -24183, -23950, -23845, -23835, -23821, -23707, -23476, -23211, -22991, -22829, -22684, -22501, -22241, -21863, -21345, -20690, -19907, -19074, -18276, -17561, -16894, -16213, -15471, -14693, -13916, -13166, -12409, -11643, -10885, -10147, -9350, -8440, -7434, -6395, -5355, -4315, -3302, -2306, -1317, -333};