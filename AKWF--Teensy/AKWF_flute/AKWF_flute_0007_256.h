/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0007 256 samples */
 
const int16_t AKWF_flute_0007_256_DATA [256] = 
{322, 1066, 1832, 2638, 3451, 4229, 4968, 5665, 6316, 6923, 7515, 8130, 8775, 9424, 10047, 10647, 11247, 11876, 12541, 13205, 13831, 14418, 14986, 15571, 16178, 16785, 17380, 17953, 18515, 19080, 19647, 20193, 20696, 21146, 21558, 21957, 22344, 22731, 23121, 23515, 23929, 24379, 24868, 25372, 25843, 26267, 26668, 27067, 27476, 27881, 28265, 28624, 28973, 29338, 29720, 30101, 30442, 30733, 30993, 31245, 31496, 31736, 31954, 32144, 32312, 32456, 32581, 32679, 32743, 32767, 32764, 32753, 32736, 32710, 32661, 32583, 32477, 32342, 32176, 31979, 31753, 31496, 31205, 30866, 30470, 30036, 29590, 29150, 28688, 28151, 27514, 26821, 26162, 25581, 25012, 24333, 23490, 22553, 21662, 20878, 20148, 19380, 18534, 17626, 16668, 15662, 14632, 13601, 12602, 11616, 10592, 9516, 8411, 7319, 6271, 5260, 4259, 3269, 2288, 1339, 435, -434, -1297, -2172, -3044, -3866, -4612, -5304, -5984, -6681, -7377, -8033, -8627, -9172, -9698, -10221, -10731, -11207, -11634, -12021, -12393, -12757, -13115, -13461, -13796, -14116, -14397, -14622, -14810, -15007, -15241, -15508, -15781, -16045, -16305, -16562, -16813, -17066, -17340, -17646, -17979, -18323, -18665, -19005, -19326, -19618, -19892, -20190, -20536, -20926, -21334, -21746, -22163, -22567, -22944, -23300, -23661, -24052, -24462, -24858, -25214, -25534, -25840, -26155, -26466, -26751, -26997, -27201, -27365, -27488, -27574, -27658, -27768, -27894, -27991, -28022, -27988, -27916, -27819, -27702, -27569, -27426, -27275, -27118, -26961, -26798, -26598, -26334, -26014, -25663, -25303, -24940, -24582, -24243, -23925, -23590, -23209, -22789, -22381, -22039, -21755, -21461, -21103, -20682, -20210, -19709, -19175, -18635, -18113, -17611, -17125, -16654, -16188, -15706, -15188, -14628, -14026, -13372, -12664, -11961, -11326, -10753, -10174, -9502, -8733, -7938, -7179, -6463, -5763, -5058, -4347, -3616, -2839, -2017, -1188, -389};