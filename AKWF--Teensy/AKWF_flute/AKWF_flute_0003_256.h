/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0003 256 samples */
 
const int16_t AKWF_flute_0003_256_DATA [256] = 
{680, 1973, 2841, 3689, 4310, 4968, 5990, 6375, 6304, 6650, 6789, 6801, 7242, 7256, 6957, 7293, 7666, 7856, 8163, 8523, 8837, 9022, 9616, 10529, 10856, 11220, 11985, 12747, 13356, 13832, 14369, 14897, 15325, 15670, 15818, 15797, 15926, 16240, 16543, 16323, 16020, 16097, 16202, 16206, 16133, 16231, 16275, 16073, 16194, 16624, 17036, 17184, 17351, 17887, 18093, 18154, 18636, 19149, 19562, 19952, 20283, 20720, 21461, 21962, 22274, 22916, 23515, 23995, 24630, 25046, 25306, 25943, 26524, 26870, 27279, 27752, 28249, 28732, 29063, 29201, 29253, 29517, 29985, 30100, 30190, 30437, 30306, 30082, 30045, 29967, 29682, 29219, 28993, 28810, 28416, 28033, 27757, 27557, 27206, 26724, 26237, 25708, 25275, 25030, 24579, 23919, 23267, 22585, 21968, 21471, 20640, 19554, 18626, 17643, 16608, 15674, 14448, 12906, 11399, 10020, 8726, 7410, 5880, 4307, 3136, 1915, 457, -895, -2144, -3203, -3880, -4631, -5591, -6145, -6503, -6837, -6842, -6795, -6871, -6733, -6310, -5693, -5118, -4719, -4506, -4384, -4135, -3755, -3927, -4357, -4548, -4931, -5576, -6311, -6856, -7364, -8177, -9430, -10685, -11393, -12170, -13045, -13632, -14004, -14239, -14409, -14560, -14646, -14567, -14375, -14153, -13971, -13859, -13742, -13496, -13643, -14192, -14474, -14854, -15489, -16014, -16687, -17589, -18374, -19154, -20038, -20959, -21910, -22840, -23593, -24293, -25016, -25530, -26082, -26776, -26966, -27324, -28343, -28626, -28596, -29068, -29373, -29602, -30056, -30422, -30640, -30823, -31284, -31706, -31637, -31700, -32058, -32475, -32675, -32691, -32758, -32731, -32602, -32472, -32160, -31696, -31308, -30914, -30546, -30369, -29944, -29326, -29141, -28870, -28344, -28067, -27890, -27667, -27446, -27038, -26409, -25838, -25307, -24704, -23933, -23077, -22150, -20970, -19524, -17916, -16452, -15031, -13445, -11687, -9890, -8199, -6490, -4965, -3782, -2523, -963};