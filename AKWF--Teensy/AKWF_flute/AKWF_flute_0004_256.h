/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0004 256 samples */
 
const int16_t AKWF_flute_0004_256_DATA [256] = 
{241, 939, 1933, 3058, 4235, 5297, 6192, 7089, 8049, 8974, 9805, 10585, 11338, 12125, 13045, 13973, 14685, 15251, 15856, 16526, 17298, 18125, 18759, 19141, 19537, 20073, 20633, 21135, 21516, 21710, 21802, 21917, 22060, 22207, 22372, 22600, 22863, 23015, 23048, 23168, 23462, 23811, 24145, 24558, 25112, 25708, 26241, 26732, 27232, 27713, 28064, 28356, 28865, 29587, 30221, 30662, 30940, 31077, 31276, 31682, 32099, 32338, 32413, 32327, 32197, 32263, 32421, 32289, 31872, 31470, 31157, 30785, 30301, 29736, 29099, 28374, 27556, 26689, 25825, 24906, 23805, 22586, 21412, 20279, 19098, 17836, 16444, 14922, 13369, 11846, 10424, 9184, 7938, 6494, 4930, 3307, 1711, 324, -914, -2242, -3649, -4976, -6177, -7391, -8662, -9788, -10659, -11450, -12294, -13087, -13711, -14207, -14659, -15026, -15210, -15224, -15155, -15027, -14839, -14593, -14252, -13799, -13288, -12765, -12145, -11334, -10508, -9901, -9406, -8790, -8060, -7287, -6520, -5890, -5406, -4892, -4278, -3664, -3106, -2664, -2390, -2245, -2175, -2117, -1969, -1777, -1700, -1703, -1566, -1304, -1237, -1454, -1696, -1836, -2034, -2395, -2723, -2826, -2908, -3245, -3736, -4154, -4507, -4899, -5341, -5806, -6299, -6853, -7472, -8072, -8598, -9146, -9794, -10437, -10973, -11418, -11792, -12149, -12602, -13105, -13469, -13663, -13799, -13927, -14077, -14277, -14490, -14696, -14895, -15073, -15334, -15822, -16443, -16985, -17466, -18044, -18712, -19309, -19841, -20638, -21798, -22796, -23312, -23837, -24770, -25808, -26612, -27314, -28114, -28978, -29793, -30508, -31061, -31441, -31684, -31836, -32022, -32303, -32569, -32734, -32768, -32650, -32397, -32049, -31659, -31334, -31020, -30539, -29901, -29295, -28741, -28004, -27001, -26019, -25222, -24337, -23161, -21848, -20574, -19334, -18115, -16875, -15497, -14019, -12595, -11272, -10037, -8856, -7678, -6465, -5241, -4053, -2885, -1715, -724, -145};