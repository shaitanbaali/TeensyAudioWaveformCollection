/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_flute_0016 256 samples */
 
const int16_t AKWF_flute_0016_256_DATA [256] = 
{346, 1035, 1771, 2516, 3264, 4017, 4762, 5456, 6043, 6485, 6790, 7003, 7163, 7273, 7320, 7308, 7267, 7205, 7123, 7034, 6992, 7034, 7175, 7416, 7743, 8129, 8548, 8968, 9404, 9878, 10397, 10927, 11457, 12011, 12560, 13055, 13460, 13815, 14129, 14402, 14663, 14950, 15244, 15485, 15693, 15911, 16163, 16399, 16639, 16953, 17404, 17929, 18474, 19017, 19580, 20153, 20696, 21203, 21696, 22184, 22662, 23107, 23498, 23840, 24186, 24529, 24836, 25106, 25380, 25688, 26002, 26325, 26657, 26992, 27340, 27723, 28159, 28659, 29217, 29783, 30296, 30749, 31170, 31584, 31978, 32322, 32580, 32733, 32770, 32690, 32477, 32132, 31677, 31145, 30578, 29944, 29201, 28356, 27508, 26734, 26037, 25310, 24503, 23629, 22751, 21880, 20999, 20090, 19186, 18296, 17400, 16531, 15716, 14966, 14224, 13435, 12594, 11745, 10914, 10137, 9437, 8801, 8162, 7471, 6754, 6038, 5269, 4341, 3227, 2031, 891, -162, -1125, -2024, -2836, -3568, -4233, -4833, -5378, -5856, -6240, -6511, -6705, -6885, -7123, -7438, -7795, -8155, -8537, -8949, -9365, -9745, -10094, -10436, -10794, -11186, -11627, -12112, -12603, -13049, -13425, -13740, -14019, -14281, -14533, -14812, -15148, -15527, -15899, -16244, -16524, -16700, -16836, -17040, -17384, -17793, -18192, -18528, -18747, -18885, -19050, -19352, -19755, -20170, -20511, -20766, -20977, -21204, -21485, -21834, -22242, -22688, -23134, -23573, -24036, -24579, -25192, -25789, -26265, -26588, -26825, -27069, -27307, -27464, -27490, -27422, -27343, -27301, -27274, -27182, -26968, -26641, -26292, -26007, -25844, -25807, -25874, -25982, -26055, -26079, -26103, -26180, -26297, -26406, -26440, -26349, -26108, -25751, -25332, -24836, -24224, -23475, -22636, -21723, -20730, -19636, -18502, -17402, -16339, -15247, -14115, -12950, -11818, -10725, -9669, -8669, -7760, -6917, -6133, -5415, -4710, -3948, -3046, -2078, -1155, -329};