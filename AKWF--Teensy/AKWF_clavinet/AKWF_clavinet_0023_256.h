/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0023 256 samples */
 
const int16_t AKWF_clavinet_0023_256_DATA [256] = 
{1059, 2443, 2961, 2906, 2742, 2691, 2877, 3228, 3480, 3787, 4473, 5845, 8184, 11483, 15502, 19777, 23711, 26804, 28823, 29778, 29835, 29469, 29059, 28915, 29228, 29461, 28890, 27178, 24274, 20781, 17372, 14680, 13089, 12306, 12188, 12642, 13321, 14107, 15014, 15972, 16926, 18039, 19552, 21504, 23607, 25453, 26581, 26536, 25411, 23546, 21169, 18566, 16046, 13873, 12084, 10787, 9819, 9051, 8406, 7563, 6469, 5366, 4494, 4475, 5386, 6933, 8855, 10627, 11941, 12744, 12891, 12580, 12175, 12035, 12448, 13262, 14117, 14696, 14455, 13188, 11177, 8949, 6709, 4741, 2866, 769, -1588, -4408, -7384, -10068, -12055, -12998, -12708, -11286, -8788, -5354, -1627, 2115, 5747, 8884, 11194, 12691, 13232, 12663, 11013, 8205, 4209, -701, -5989, -11155, -15944, -20002, -23276, -25823, -27693, -28927, -29397, -28903, -27330, -24597, -20796, -16199, -11263, -6170, -1253, 3119, 6975, 9961, 11763, 12446, 12068, 10847, 9037, 6891, 4711, 2561, 558, -826, -1437, -1229, -302, 1187, 3190, 5618, 8566, 12037, 15836, 19647, 23079, 25893, 28107, 29839, 31080, 31592, 31032, 29008, 25393, 20441, 14736, 8911, 3211, -2155, -7129, -11426, -14955, -17430, -18619, -18602, -17483, -15610, -13418, -11291, -9474, -8257, -7726, -7958, -8816, -10009, -11399, -12730, -13842, -14784, -15478, -15936, -16341, -16545, -16586, -16693, -16893, -17247, -17778, -18312, -18603, -18551, -18068, -17072, -15586, -13539, -10996, -8033, -4740, -1344, 1831, 4426, 6194, 6947, 6881, 6155, 4980, 3633, 2159, 751, -528, -1575, -2195, -2488, -2714, -3142, -4068, -5598, -7611, -10067, -12840, -15774, -18778, -21712, -24437, -26829, -28687, -29797, -30257, -30166, -29647, -28916, -27843, -26696, -25695, -25121, -25319, -26258, -27617, -29138, -30615, -31799, -32570, -32761, -32252, -30829, -28199, -24626, -20502, -16215, -12057, -8026, -4243, -1086};