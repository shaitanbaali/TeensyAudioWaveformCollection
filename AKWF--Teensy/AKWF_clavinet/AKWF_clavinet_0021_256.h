/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0021 256 samples */
 
const int16_t AKWF_clavinet_0021_256_DATA [256] = 
{3719, 9196, 14766, 20471, 25713, 29788, 32252, 32696, 31040, 27961, 24231, 20472, 17160, 14808, 13791, 13887, 14333, 14538, 14110, 12956, 11809, 11548, 12534, 14515, 16859, 18873, 19947, 19907, 19015, 17642, 16129, 14752, 13781, 13239, 12688, 12026, 11218, 10064, 8624, 7121, 5907, 5326, 5266, 5050, 4267, 3178, 2543, 2811, 3573, 4249, 4414, 3936, 3188, 2636, 2577, 2837, 2977, 2757, 2264, 2038, 2472, 3165, 3386, 2725, 1451, 312, -53, 463, 1308, 1786, 1604, 1017, 399, 75, 262, 746, 860, 95, -1169, -2067, -2063, -1240, -377, -218, -877, -1961, -2908, -3482, -3603, -3200, -2413, -1640, -990, -351, 234, 451, 29, -1037, -2474, -3713, -4058, -3454, -2403, -1386, -821, -937, -1606, -2236, -1951, -572, 1225, 2821, 3627, 3132, 1230, -1829, -5399, -8434, -10038, -9845, -8237, -6080, -3960, -2233, -1090, -304, 762, 2581, 4830, 6966, 8751, 10031, 10602, 10167, 8778, 6971, 5461, 4660, 4405, 4179, 3788, 3477, 3283, 3010, 2522, 2025, 1907, 2305, 3290, 4974, 7402, 10453, 13519, 15916, 17259, 17562, 16963, 15622, 13775, 11824, 10007, 8093, 5777, 2796, -918, -5205, -9711, -13975, -17576, -20215, -21651, -21939, -21418, -20391, -19049, -17559, -16060, -14618, -13325, -12244, -11206, -10198, -9329, -8886, -9225, -10327, -11914, -13590, -14937, -15838, -16339, -16357, -15751, -14612, -13208, -11917, -11148, -11128, -11971, -13414, -14848, -15755, -15864, -15048, -13407, -10971, -7524, -3009, 2125, 7136, 11311, 14139, 15545, 15576, 14511, 12453, 9109, 4416, -1228, -7136, -12506, -16960, -20460, -23122, -24920, -25361, -24192, -21637, -18189, -14463, -11309, -9155, -7814, -6953, -6216, -5515, -4844, -4169, -3543, -3013, -2600, -2689, -3945, -6648, -10455, -14584, -18047, -20124, -20787, -20476, -19493, -17741, -14926, -11200, -6749, -1509};