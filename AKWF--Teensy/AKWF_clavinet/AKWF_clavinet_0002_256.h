/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0002 256 samples */
 
const int16_t AKWF_clavinet_0002_256_DATA [256] = 
{5632, 12920, 18864, 24678, 29829, 32656, 31730, 26567, 17746, 10630, 10087, 14828, 19403, 20043, 16668, 12221, 7429, 2261, -1804, -2976, -699, 2008, 2696, 1469, 1668, 6724, 15460, 22747, 24733, 21992, 16258, 9798, 4258, -757, -6983, -13614, -19000, -21335, -20820, -18654, -14651, -10781, -9763, -11791, -15341, -17924, -18326, -17130, -14052, -10406, -7700, -5881, -5820, -7124, -9135, -11754, -14216, -15432, -15318, -13790, -11668, -9098, -6691, -5209, -3572, -1565, 144, 1822, 2515, 2507, 2882, 3587, 4284, 4805, 5113, 5275, 4950, 4666, 4716, 4748, 4810, 5169, 4993, 5022, 5439, 5630, 6328, 7016, 7568, 6987, 6074, 5456, 5119, 4981, 4465, 3391, 2790, 1942, 1630, 1273, 458, 372, -307, -1657, -1482, -2105, -1966, -1155, -1552, -1097, -709, -369, 543, 611, 1087, 471, -308, -848, -1067, -1054, -759, -1067, -802, -853, -609, 302, 908, 601, 164, -365, -472, 124, 656, 996, 1529, 1215, 1946, 2389, 2110, 2777, 1964, 1309, 798, -110, 327, -571, -385, 746, 384, 146, -214, -743, 271, -193, -593, -901, -1245, -817, -1612, -1743, -123, -285, 583, 155, -1264, -1061, -29, -54, 582, 400, -2424, -2078, -237, 99, 2361, 143, -486, 1133, -2018, -2781, -2168, -1157, 3090, 3684, 1717, 255, -1546, -3114, -4690, -2914, 620, 760, 3, -310, 1436, 6069, 9512, 7516, 3876, -1171, -5372, -5, 5973, 6610, 5411, -1732, -4755, -1031, -623, 2250, 4129, 2804, 409, -6990, -13069, -10937, -1768, 9164, 15633, 18241, 17009, 12767, 6909, -382, -7040, -13190, -19907, -25254, -25333, -21890, -16769, -9279, -4898, -4884, -8200, -13153, -12900, -8064, -4591, -1938, 1184, 3720, 5898, 6708, 6691, 7526, 7625, 4511, -945, -6886, -14434, -22559, -26972, -24654, -15423, -3889};