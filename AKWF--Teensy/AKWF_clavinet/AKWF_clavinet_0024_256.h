/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0024 256 samples */
 
const int16_t AKWF_clavinet_0024_256_DATA [256] = 
{2311, 5998, 7883, 7676, 5929, 3758, 2428, 2783, 4979, 8385, 12334, 16112, 18995, 20752, 21527, 21975, 23153, 25484, 28609, 31410, 32760, 32012, 29482, 25971, 22443, 19718, 17706, 15754, 13342, 10197, 6756, 3652, 1326, 0, -451, -162, 707, 1725, 2636, 3373, 3641, 3530, 2973, 2196, 1508, 907, 106, -1399, -3774, -6680, -9496, -11515, -12466, -12434, -11711, -10615, -9142, -7263, -5030, -2892, -1407, -1069, -1610, -2374, -2719, -2243, -1204, -249, -94, -1029, -3072, -5348, -7012, -7532, -6797, -5289, -3696, -2715, -2770, -3869, -5669, -7510, -8914, -9568, -9240, -8044, -6357, -4635, -3390, -2650, -2103, -1111, 483, 2422, 3954, 4354, 3457, 1424, -1164, -3700, -5701, -7067, -7837, -8224, -8391, -8291, -7628, -6300, -4124, -1101, 2599, 6499, 10157, 12965, 14337, 14024, 11902, 8153, 3339, -1704, -6211, -9411, -10804, -10600, -9187, -7065, -4823, -2539, 15, 3140, 6980, 11222, 14996, 17376, 17658, 15758, 12078, 7377, 2607, -1814, -5727, -9061, -11773, -13468, -13864, -12625, -9914, -5946, -997, 4332, 9459, 13580, 15876, 15900, 13712, 10156, 6108, 2526, -248, -2568, -4933, -7835, -11150, -14197, -16218, -16477, -14895, -11725, -7566, -3172, 889, 4185, 6615, 8255, 9014, 8834, 7562, 5317, 2506, -434, -3150, -5405, -6955, -7610, -7275, -6088, -4482, -2994, -1950, -1380, -993, -286, 1102, 3256, 5989, 8722, 10820, 11814, 11595, 10456, 9028, 7808, 7128, 6907, 6832, 6542, 5884, 5148, 4772, 5183, 6458, 8259, 9950, 10897, 10661, 9191, 7011, 4899, 3428, 2788, 2827, 2938, 2415, 821, -2070, -5855, -9762, -12876, -14488, -14442, -13295, -12081, -11658, -12509, -14488, -17012, -19299, -20861, -21571, -21735, -21882, -22332, -23110, -23916, -24202, -23503, -21682, -18959, -15814, -13110, -11382, -10584, -10021, -8686, -5933, -1883};