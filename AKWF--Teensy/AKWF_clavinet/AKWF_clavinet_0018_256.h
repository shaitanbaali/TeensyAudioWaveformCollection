/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0018 256 samples */
 
const int16_t AKWF_clavinet_0018_256_DATA [256] = 
{221, 973, 1703, 2431, 3145, 3855, 4556, 5245, 5927, 6598, 7256, 7911, 8556, 9193, 9825, 10446, 11058, 11663, 12263, 12849, 13428, 14002, 14564, 15119, 15666, 16199, 16727, 17247, 17757, 18260, 18752, 19233, 19708, 20173, 20628, 21076, 21510, 21936, 22354, 22761, 23160, 23548, 23923, 24292, 24652, 25001, 25340, 25667, 25985, 26292, 26589, 26872, 27144, 27401, 27648, 27882, 28103, 28310, 28502, 28681, 28846, 28996, 29129, 29249, 29353, 29443, 29517, 29576, 29620, 29649, 29662, 29658, 29638, 29601, 29548, 29476, 29388, 29282, 29158, 29019, 28861, 28684, 28492, 28283, 28055, 27813, 27553, 27275, 26980, 26669, 26342, 25999, 25639, 25262, 24870, 24461, 24040, 23601, 23146, 22676, 22191, 21692, 21179, 20651, 20109, 19553, 18986, 18409, 17815, 17211, 16595, 15965, 15326, 14675, 14009, 13334, 12646, 11945, 11241, 10521, 9792, 9055, 8310, 7558, 6797, 6025, 5249, 4466, 3681, 2886, 2086, 1280, 472, -339, -1155, -1976, -2804, -3638, -4474, -5310, -6154, -6997, -7843, -8687, -9522, -10354, -11185, -12008, -12824, -13634, -14429, -15220, -16002, -16772, -17532, -18277, -19005, -19727, -20431, -21122, -21799, -22454, -23096, -23723, -24331, -24922, -25493, -26041, -26574, -27086, -27574, -28042, -28490, -28915, -29320, -29703, -30062, -30397, -30713, -31004, -31274, -31522, -31745, -31947, -32128, -32285, -32421, -32534, -32625, -32695, -32742, -32765, -32767, -32747, -32704, -32639, -32553, -32445, -32317, -32169, -32001, -31812, -31604, -31377, -31130, -30865, -30579, -30275, -29952, -29610, -29253, -28876, -28480, -28068, -27639, -27194, -26733, -26255, -25760, -25250, -24727, -24191, -23637, -23071, -22489, -21900, -21295, -20675, -20045, -19404, -18751, -18092, -17417, -16734, -16043, -15342, -14635, -13923, -13201, -12473, -11741, -11002, -10265, -9520, -8770, -8019, -7266, -6514, -5763, -5008, -4253, -3500, -2748, -2002, -1256, -497};