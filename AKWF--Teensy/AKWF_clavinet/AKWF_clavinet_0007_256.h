/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0007 256 samples */
 
const int16_t AKWF_clavinet_0007_256_DATA [256] = 
{3085, 6914, 10685, 14161, 16496, 17357, 16633, 14579, 11808, 9316, 8215, 9329, 12858, 18196, 24083, 29006, 32023, 32796, 31420, 27941, 22877, 17098, 11650, 7335, 4529, 3202, 3011, 3484, 4145, 4649, 4862, 4862, 4855, 5044, 5506, 6136, 6696, 6894, 6437, 5076, 2629, -947, -5482, -10618, -15833, -20493, -24136, -26459, -27358, -26850, -24989, -21890, -17762, -12927, -7839, -2999, 1114, 4181, 6022, 6558, 5743, 3595, 248, -3987, -8672, -13274, -17278, -20314, -22107, -22499, -21383, -18724, -14607, -9312, -3357, 2701, 8369, 13155, 16777, 19000, 19709, 18892, 16658, 13235, 8926, 4117, -766, -5401, -9370, -12388, -14254, -14819, -14049, -12025, -8968, -5188, -1029, 3107, 6938, 10118, 12421, 13720, 13967, 13176, 11493, 9176, 6563, 3895, 1311, -1062, -3119, -4697, -5660, -5998, -5810, -5243, -4366, -3170, -1649, 149, 2050, 3849, 5304, 6193, 6414, 6034, 5273, 4365, 3432, 2453, 1287, -137, -1692, -3009, -3658, -3445, -2618, -1746, -1291, -1268, -1272, -871, -17, 920, 1535, 1806, 2125, 2885, 4027, 5009, 5202, 4370, 2833, 1349, 718, 1296, 2759, 4185, 4609, 3661, 1812, 64, -787, -587, 67, 304, -405, -1937, -3600, -4628, -4701, -4132, -3620, -3754, -4660, -5937, -7009, -7540, -7533, -7089, -6172, -4661, -2570, -277, 1566, 2230, 1349, -838, -3490, -5454, -5740, -3885, -176, 4339, 8123, 9974, 9490, 7172, 4150, 1766, 893, 1561, 3303, 5633, 8319, 11286, 14174, 16241, 16684, 15196, 12150, 8485, 5227, 3061, 2139, 2197, 2852, 3793, 4912, 6143, 7197, 7376, 5732, 1601, -4704, -11677, -17311, -20179, -19754, -16753, -12629, -8759, -6005, -4880, -5703, -8461, -12817, -17903, -22544, -25478, -26078, -24504, -21413, -17652, -13963, -11006, -9066, -8089, -7845, -8067, -8492, -8810, -8630, -7514, -5213, -1393};