/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0005 256 samples */
 
const int16_t AKWF_clavinet_0005_256_DATA [256] = 
{3191, 8514, 12373, 14796, 15607, 14970, 13440, 11566, 9645, 7700, 5794, 4307, 3689, 4217, 5975, 8515, 11319, 14207, 17084, 19990, 22917, 25594, 27628, 28681, 28983, 28874, 28228, 26901, 24990, 22741, 20278, 17531, 14675, 12238, 10586, 9403, 7993, 6310, 4764, 3424, 2064, 328, -1762, -3802, -5788, -7791, -9595, -11287, -12944, -14189, -15143, -16426, -18449, -20848, -22267, -22358, -22237, -22465, -22763, -22402, -21082, -19593, -18312, -16710, -14908, -13878, -13878, -14012, -13656, -12854, -11632, -9940, -7874, -6206, -5984, -6726, -6709, -4908, -1247, 2682, 4154, 2517, -66, -266, 3538, 8825, 11561, 10720, 8485, 7814, 9224, 10756, 10976, 9827, 7664, 5113, 3654, 4750, 8161, 11487, 11740, 7906, 2016, -2454, -2949, 901, 6541, 9817, 8690, 4219, -566, -2825, -1918, 992, 3694, 3753, 737, -3080, -4886, -3811, -1300, 836, 1868, 1796, 753, -618, -1582, -2464, -4167, -6443, -7110, -4365, 837, 5821, 8981, 10169, 9126, 5495, -417, -7240, -12050, -12053, -6406, 3391, 12140, 14823, 11789, 6696, 2556, -83, -2691, -6184, -9186, -9487, -6271, -597, 5667, 10814, 13392, 12327, 7413, 174, -6420, -10032, -10835, -10997, -12070, -13118, -11314, -4445, 6731, 17616, 23418, 21816, 13833, 3934, -4274, -9944, -12598, -12419, -10772, -8569, -5646, -1726, 2087, 3826, 2341, -1884, -6934, -10265, -9976, -5804, 976, 8240, 14257, 18084, 19627, 19150, 16631, 11689, 3963, -5892, -15869, -23975, -28769, -29678, -26348, -18594, -7389, 4938, 15334, 22079, 24947, 24275, 21039, 17225, 14657, 13928, 14539, 15380, 15091, 12509, 7296, 21, -8388, -16578, -23381, -27765, -28949, -26640, -21111, -13488, -5347, 2044, 7869, 11932, 14109, 14169, 12130, 8169, 2670, -3676, -10064, -16013, -21346, -25875, -29402, -31756, -32762, -32264, -30158, -26518, -21575, -15646, -9063, -2443};