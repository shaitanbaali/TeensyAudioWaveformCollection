/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0017 256 samples */
 
const int16_t AKWF_clavinet_0017_256_DATA [256] = 
{621, 1575, 2486, 3379, 4247, 5087, 5903, 6697, 7469, 8220, 8949, 9659, 10358, 11035, 11698, 12344, 12970, 13582, 14182, 14765, 15336, 15895, 16437, 16970, 17494, 18007, 18515, 19013, 19502, 19989, 20467, 20940, 21403, 21862, 22314, 22759, 23197, 23628, 24051, 24465, 24872, 25270, 25658, 26033, 26401, 26754, 27098, 27428, 27741, 28039, 28320, 28585, 28830, 29058, 29264, 29451, 29615, 29758, 29879, 29974, 30047, 30096, 30120, 30119, 30093, 30041, 29963, 29857, 29728, 29573, 29394, 29193, 28967, 28719, 28452, 28162, 27855, 27529, 27185, 26827, 26456, 26073, 25682, 25279, 24867, 24447, 24022, 23589, 23150, 22709, 22262, 21813, 21366, 20913, 20460, 20008, 19557, 19110, 18663, 18216, 17773, 17333, 16894, 16463, 16033, 15607, 15185, 14765, 14350, 13937, 13525, 13113, 12704, 12293, 11883, 11472, 11058, 10638, 10211, 9776, 9332, 8876, 8408, 7930, 7438, 6936, 6417, 5886, 5337, 4775, 4200, 3608, 3000, 2376, 1734, 1079, 404, -288, -995, -1717, -2450, -3194, -3951, -4714, -5483, -6260, -7038, -7823, -8611, -9398, -10183, -10964, -11740, -12513, -13282, -14040, -14789, -15522, -16248, -16957, -17653, -18333, -18994, -19640, -20270, -20882, -21479, -22057, -22613, -23155, -23679, -24185, -24676, -25147, -25603, -26046, -26473, -26885, -27281, -27660, -28028, -28382, -28720, -29047, -29360, -29656, -29943, -30216, -30476, -30722, -30958, -31181, -31391, -31588, -31771, -31939, -32096, -32236, -32363, -32472, -32566, -32642, -32702, -32743, -32764, -32765, -32744, -32703, -32638, -32551, -32438, -32301, -32138, -31946, -31728, -31481, -31207, -30903, -30566, -30199, -29798, -29363, -28899, -28400, -27866, -27301, -26702, -26070, -25410, -24712, -23983, -23226, -22436, -21623, -20784, -19917, -19029, -18123, -17199, -16251, -15292, -14316, -13326, -12336, -11330, -10319, -9305, -8286, -7270, -6261, -5247, -4241, -3245, -2255, -1282, -299};