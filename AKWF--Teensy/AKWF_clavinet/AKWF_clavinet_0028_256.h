/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0028 256 samples */
 
const int16_t AKWF_clavinet_0028_256_DATA [256] = 
{3568, 9582, 14096, 16993, 18325, 18497, 17958, 16855, 14883, 11655, 7449, 3166, 63, -1140, -405, 1795, 4732, 7803, 10768, 13503, 15967, 17926, 19064, 19245, 18743, 18222, 18095, 18270, 18155, 17381, 16256, 15367, 15114, 15373, 15759, 16015, 16395, 17374, 19276, 21824, 24413, 26369, 27378, 27544, 27200, 26398, 24671, 21341, 16136, 9758, 3788, -480, -2813, -3909, -4566, -4836, -4100, -1821, 1952, 6312, 10145, 12765, 14203, 14934, 15286, 14986, 13444, 10233, 5789, 898, -3564, -7382, -10849, -14321, -18025, -21712, -24716, -26384, -26696, -26178, -25410, -24416, -22701, -19986, -16773, -14094, -12675, -12431, -12633, -12746, -12827, -13424, -15120, -18144, -22030, -25791, -28627, -30325, -31370, -32241, -32779, -32396, -30676, -28109, -25605, -23793, -22505, -20909, -18175, -14281, -9980, -6351, -3932, -2577, -1666, -858, -349, -499, -1318, -2324, -2754, -2238, -1277, -888, -1831, -3841, -5768, -6396, -5200, -2663, 349, 3174, 5708, 8088, 10337, 12010, 12614, 12038, 10730, 9422, 8464, 7710, 6594, 4815, 2471, -8, -2107, -3407, -3557, -2306, 189, 3497, 6855, 9654, 11390, 11856, 11158, 9651, 7788, 5903, 4086, 2538, 1446, 791, 391, 55, -304, -505, -325, 335, 1420, 2954, 4763, 6589, 8230, 9636, 10697, 11351, 11374, 10684, 9340, 7575, 5589, 3541, 1645, 73, -1166, -2042, -2489, -2370, -1715, -711, 408, 1668, 3163, 4826, 6431, 7656, 8219, 8014, 6982, 5182, 2794, 133, -2417, -4514, -5730, -5768, -4776, -3114, -1219, 645, 2390, 3912, 5049, 5703, 5786, 5375, 4537, 3405, 1911, -133, -2849, -6083, -9305, -11866, -13446, -13984, -13530, -12059, -9498, -5987, -2088, 1378, 3919, 5446, 6143, 6184, 5620, 4361, 2351, -319, -3606, -7538, -12223, -17594, -23141, -27969, -31143, -31988, -30448, -27025, -22251, -16464, -9940, -2942};