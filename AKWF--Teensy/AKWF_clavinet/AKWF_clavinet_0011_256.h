/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0011 256 samples */
 
const int16_t AKWF_clavinet_0011_256_DATA [256] = 
{1088, 3858, 6884, 10372, 14330, 18686, 23315, 27627, 30794, 32464, 32777, 32028, 30389, 28209, 25565, 22549, 19296, 16000, 12976, 10414, 8639, 7960, 8314, 9601, 11678, 14109, 16073, 17208, 17644, 17655, 17434, 16966, 16161, 14945, 13365, 11619, 9859, 8209, 6785, 5599, 4479, 3445, 2741, 2394, 2085, 1488, 810, 517, 601, 676, 506, 238, 47, -165, -513, -970, -1313, -1532, -1821, -2252, -2676, -2922, -2985, -3006, -3106, -3106, -2799, -2500, -2648, -3087, -3314, -3334, -3426, -3619, -3828, -3970, -4052, -4205, -4547, -4991, -5165, -5005, -4868, -5011, -5254, -5336, -5304, -5169, -4887, -4624, -4639, -4903, -5091, -4866, -4105, -3106, -2612, -3003, -3764, -4046, -3586, -2803, -2320, -2582, -3516, -4576, -5000, -4478, -3491, -2803, -2872, -3417, -3738, -3394, -2694, -2314, -2552, -2959, -2837, -1935, -630, 147, -432, -2283, -4138, -4591, -3396, -1563, -215, 188, -117, -753, -1287, -1451, -1422, -1517, -2051, -2918, -3535, -3518, -2967, -2252, -1572, -606, 954, 2938, 5054, 7308, 9629, 11759, 13257, 13802, 13362, 11974, 9582, 6380, 3073, 475, -885, -1096, -602, 430, 2031, 4113, 6407, 8676, 10716, 12437, 13787, 14761, 15420, 15737, 15421, 14271, 12391, 10183, 7908, 5345, 2130, -1906, -6493, -10958, -14717, -17514, -19416, -20519, -20998, -20824, -19803, -17802, -14993, -11845, -8745, -5903, -3407, -1516, -714, -1533, -4180, -8268, -12944, -17213, -20351, -22368, -23683, -24799, -25778, -26158, -25618, -24393, -22926, -21322, -19190, -16029, -11793, -7238, -3391, -829, 559, 1348, 1845, 1766, 602, -2099, -6075, -10399, -14113, -16907, -18849, -20088, -20521, -19813, -17617, -13942, -9282, -4281, 534, 4919, 8693, 11495, 12992, 12891, 11125, 8357, 5508, 3062, 1044, -576, -1907, -3177, -4359, -5119, -5194, -4590, -3322, -1281};