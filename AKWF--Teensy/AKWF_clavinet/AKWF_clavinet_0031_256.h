/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0031 256 samples */
 
const int16_t AKWF_clavinet_0031_256_DATA [256] = 
{3601, 9102, 12065, 12409, 11399, 10781, 11570, 13828, 17482, 22515, 27812, 31006, 30675, 27877, 24345, 20479, 15989, 11573, 8725, 7939, 8403, 9423, 11197, 14166, 18204, 22564, 26456, 29577, 31912, 32781, 30719, 24956, 16525, 7467, -625, -6987, -11437, -14278, -16107, -17638, -19410, -21387, -22748, -22418, -20185, -17122, -14578, -13120, -12618, -12951, -14123, -15853, -17582, -18881, -19712, -20198, -20399, -20443, -20734, -21741, -23516, -25403, -26234, -25132, -22359, -19300, -17092, -15650, -14387, -13148, -11837, -9698, -6257, -2359, 710, 2751, 4206, 5079, 5193, 4983, 5291, 6462, 8207, 10032, 11332, 11479, 10374, 8465, 6182, 3904, 2325, 2093, 3105, 4552, 5493, 5300, 3939, 1937, 258, 91, 2177, 6172, 10542, 13357, 13424, 10984, 7359, 3987, 1819, 1151, 1780, 3128, 4118, 3384, 381, -3950, -7854, -9849, -9263, -6193, -1528, 3241, 6516, 7256, 5653, 3077, 1188, 849, 1986, 4260, 7237, 9841, 10533, 8513, 4561, 643, -1431, -1074, 991, 3531, 5480, 6005, 4535, 1317, -2258, -4429, -4338, -2500, 94, 2685, 4510, 4692, 2931, -1, -2669, -3915, -3411, -1574, 768, 2718, 3583, 3148, 1545, -915, -3612, -5560, -6024, -5191, -3831, -2370, -788, 600, 1082, 509, -292, -530, -345, -286, -487, -748, -1106, -1810, -2878, -4041, -4912, -5043, -4030, -1736, 1648, 5787, 10152, 13842, 15777, 15435, 13220, 9888, 5921, 1657, -2377, -5723, -8501, -11087, -13499, -15227, -15548, -13885, -9999, -4198, 2629, 9416, 14992, 18222, 18310, 15328, 10355, 4833, 0, -3509, -5762, -7329, -8838, -10601, -12676, -14880, -16561, -16672, -14543, -10614, -6191, -2474, -40, 834, -7, -2093, -4102, -4754, -3781, -1873, 21, 1178, 1124, -303, -2800, -5628, -7989, -9225, -9163, -8456, -8188, -8923, -10222, -11268, -11521, -10525, -7625, -2436};