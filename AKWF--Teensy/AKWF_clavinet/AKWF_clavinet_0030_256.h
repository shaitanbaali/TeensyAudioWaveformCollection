/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0030 256 samples */
 
const int16_t AKWF_clavinet_0030_256_DATA [256] = 
{1407, 3719, 6107, 8494, 10869, 13207, 15443, 17597, 19610, 21341, 22838, 24084, 25110, 25888, 26504, 26992, 27438, 27815, 28041, 28220, 28384, 28470, 28556, 28587, 28662, 28744, 28903, 29088, 29356, 29674, 30020, 30431, 30892, 31330, 31812, 32211, 32571, 32733, 32745, 32453, 31895, 30890, 29507, 27747, 25613, 23192, 20625, 17900, 15244, 12667, 10308, 8207, 6338, 4661, 3342, 2274, 1383, 649, 2, -583, -1087, -1673, -2315, -3049, -3963, -5133, -6412, -8025, -9909, -12008, -14246, -16626, -19003, -21347, -23510, -25428, -27045, -28215, -28918, -29081, -28743, -28040, -27034, -25894, -24660, -23419, -22469, -21832, -21522, -21532, -21910, -22470, -23164, -23821, -24397, -24848, -24946, -24657, -23950, -22836, -21219, -19139, -16645, -13828, -10821, -7790, -4840, -2253, -124, 1417, 2287, 2433, 1908, 755, -797, -2702, -4751, -6757, -8403, -9657, -10395, -10494, -9857, -8618, -6748, -4431, -1942, 588, 3017, 4990, 6433, 7210, 7270, 6578, 5243, 3335, 1044, -1430, -3886, -6136, -8044, -9444, -10298, -10469, -9909, -8803, -7194, -5121, -2860, -497, 1753, 3869, 5663, 7057, 7997, 8478, 8513, 8105, 7435, 6561, 5547, 4495, 3518, 2699, 2063, 1633, 1430, 1410, 1552, 1813, 2155, 2531, 2857, 3115, 3298, 3387, 3341, 3177, 2922, 2669, 2447, 2314, 2296, 2491, 2904, 3430, 3991, 4504, 4809, 4810, 4403, 3496, 2119, 314, -1858, -4238, -6759, -9161, -11339, -13086, -14198, -14678, -14470, -13496, -11845, -9615, -6995, -4088, -1296, 1194, 3176, 4508, 5026, 4691, 3525, 1539, -1027, -4026, -7372, -10809, -14141, -17177, -19645, -21495, -22527, -22624, -21809, -20069, -17606, -14534, -11094, -7631, -4354, -1427, 821, 2396, 3155, 3123, 2455, 1220, -372, -2223, -4215, -6209, -7967, -9381, -10431, -10994, -11069, -10650, -9770, -8478, -6853, -4928, -2850, -677};