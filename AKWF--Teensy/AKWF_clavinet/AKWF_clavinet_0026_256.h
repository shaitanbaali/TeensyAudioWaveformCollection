/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0026 256 samples */
 
const int16_t AKWF_clavinet_0026_256_DATA [256] = 
{879, 3400, 5790, 7990, 9896, 11412, 12584, 13516, 14349, 15295, 16429, 17746, 19201, 20694, 22025, 23063, 23732, 24049, 24092, 23916, 23589, 23171, 22693, 22186, 21661, 21150, 20703, 20347, 19962, 19488, 18947, 18368, 17793, 17280, 16891, 16624, 16375, 15996, 15355, 14412, 13208, 11847, 10516, 9403, 8691, 8492, 8735, 9347, 10222, 11209, 12202, 13168, 14037, 14689, 15064, 15144, 14844, 14174, 13234, 12106, 10815, 9494, 8258, 7080, 5978, 5041, 4257, 3576, 3031, 2658, 2502, 2587, 2972, 3745, 4777, 5936, 7121, 8183, 8941, 9310, 9258, 8797, 8035, 7064, 6049, 5108, 4239, 3449, 2650, 1734, 695, -355, -1389, -2276, -2834, -2979, -2731, -2188, -1434, -574, 207, 788, 1117, 1080, 622, -57, -862, -1746, -2641, -3509, -4448, -5450, -6536, -7710, -8818, -9752, -10304, -10339, -9901, -9003, -7786, -6508, -5404, -4583, -4175, -4124, -4236, -4312, -4223, -3901, -3397, -2859, -2426, -2140, -1889, -1544, -1003, -130, 1211, 3001, 5169, 7657, 10304, 12918, 15407, 17791, 19944, 21890, 23629, 25072, 26112, 26663, 26604, 25879, 24497, 22507, 20121, 17472, 14746, 12170, 9829, 7829, 6252, 5090, 4279, 3752, 3425, 3224, 3097, 3038, 3042, 3096, 3138, 3070, 2848, 2373, 1574, 423, -1053, -2803, -4733, -6674, -8467, -10074, -11447, -12630, -13704, -14685, -15603, -16472, -17259, -17876, -18218, -18242, -17895, -17163, -16130, -14913, -13622, -12380, -11283, -10310, -9559, -9047, -8744, -8678, -8918, -9482, -10377, -11606, -13053, -14672, -16375, -18042, -19596, -20972, -22123, -23020, -23675, -24183, -24635, -25049, -25465, -25972, -26605, -27385, -28353, -29470, -30598, -31611, -32381, -32754, -32748, -32386, -31658, -30707, -29635, -28516, -27388, -26264, -25125, -23935, -22674, -21399, -20108, -18791, -17455, -16041, -14598, -13127, -11541, -9852, -8052, -6061, -3862, -1487};