/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0022 256 samples */
 
const int16_t AKWF_clavinet_0022_256_DATA [256] = 
{1861, 6545, 11985, 17601, 22647, 26809, 29924, 31913, 32743, 32410, 31108, 29145, 26667, 23495, 19696, 15720, 12119, 9119, 6906, 5888, 6305, 7889, 10024, 12101, 13832, 15195, 16229, 16701, 16453, 15826, 15333, 15119, 14688, 13575, 12061, 10416, 8680, 7013, 5546, 4416, 3725, 3439, 3599, 3909, 3968, 3756, 3216, 2407, 1824, 1795, 2227, 2727, 3063, 3393, 3701, 3842, 3794, 3484, 2854, 2096, 1593, 1573, 1888, 2438, 3024, 3265, 2743, 1608, 648, 228, 74, 5, 58, 209, 297, 265, 187, -6, -528, -1441, -2375, -2871, -2654, -1964, -1596, -2056, -2962, -3494, -3354, -2877, -2586, -2826, -3590, -4608, -5318, -5273, -4401, -2998, -1799, -1565, -2419, -3680, -4759, -5720, -6415, -6355, -5436, -4040, -2807, -2271, -2621, -3539, -4516, -5306, -5571, -4927, -3647, -2576, -2367, -2950, -3853, -4827, -5883, -6942, -7672, -7480, -5875, -2938, 650, 4048, 6783, 8581, 9285, 9105, 8521, 7602, 6442, 5488, 4979, 4871, 4723, 4038, 2577, 596, -993, -1461, -785, 847, 3215, 5840, 8161, 9963, 10966, 10889, 9928, 8764, 8102, 8256, 9070, 10092, 10504, 9396, 6655, 2862, -1393, -5459, -8902, -11883, -14710, -17152, -18740, -19369, -19361, -19158, -19165, -19322, -18994, -17499, -14880, -11942, -9481, -7817, -6952, -6598, -6244, -5824, -5836, -6704, -8435, -10484, -12150, -13004, -13055, -12854, -13005, -13448, -13626, -13065, -11578, -9484, -7544, -6273, -5556, -4830, -3732, -2355, -936, 253, 1061, 1775, 2819, 4315, 6146, 7978, 9366, 10021, 9832, 8769, 6719, 3472, -952, -6100, -11438, -16471, -20677, -23684, -25402, -25806, -24947, -22786, -19305, -14899, -10210, -5818, -2307, 72, 1382, 1736, 1360, 543, -719, -2521, -4765, -7249, -9599, -11390, -12501, -12716, -12072, -10989, -9759, -8569, -7389, -6049, -4235, -1565};