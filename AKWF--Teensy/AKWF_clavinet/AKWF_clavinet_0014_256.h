/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0014 256 samples */
 
const int16_t AKWF_clavinet_0014_256_DATA [256] = 
{3429, 8790, 13616, 16423, 15926, 12869, 7945, 2838, 1419, 6647, 16023, 24016, 28908, 32140, 32411, 26569, 16268, 8061, 6301, 8026, 8976, 10134, 13488, 17188, 17289, 13686, 10750, 11132, 13318, 14365, 13381, 11304, 8580, 5024, 1073, -2180, -3886, -4031, -3793, -3775, -4412, -5872, -8250, -12277, -17855, -23071, -25898, -25837, -24058, -21858, -19844, -18570, -18109, -17786, -16854, -14424, -11076, -7945, -5673, -4841, -5901, -8706, -12369, -15715, -18176, -19688, -19612, -18152, -15752, -12838, -9895, -6668, -3510, -1205, 281, 1562, 2662, 3078, 2865, 2608, 2882, 3092, 3279, 3632, 3956, 4100, 4133, 4213, 4287, 4420, 4499, 4774, 5179, 5490, 5103, 4683, 4991, 4958, 4763, 4811, 5107, 5453, 5454, 5033, 4746, 4701, 4472, 4377, 4444, 4682, 4429, 3879, 3519, 3450, 3222, 2633, 2925, 3288, 2959, 2426, 2213, 2134, 1654, 953, 607, 978, 1437, 1281, 954, 1083, 1127, 949, 655, 475, 730, 674, 378, 441, 687, 276, -477, -515, -383, -949, -1447, -982, -423, -690, -964, -651, -406, -691, -1103, -659, -164, -554, -494, 97, -19, -385, -423, -623, -527, -100, -38, -152, 60, 362, 152, -271, -569, -148, 396, 13, -205, 344, 647, 380, -48, -542, -396, 340, 727, 469, 374, 829, 1014, 680, 456, 424, 255, 508, 1079, 785, 86, 113, 890, 890, -596, -1372, -279, 709, 398, -243, -528, -593, -514, -715, -1320, -1291, -263, 911, 1071, -514, -2536, -2781, -1682, -855, -480, 435, 2762, 4896, 4012, 955, -1523, -3651, -6481, -9017, -10529, -11200, -10365, -8103, -7350, -9266, -10257, -7499, -3504, -1981, -1064, 3196, 8597, 9278, 5104, 447, -3190, -6563, -9252, -10241, -9920, -8533, -6536, -6598, -9206, -10615, -7770, -2067};