/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0010 256 samples */
 
const int16_t AKWF_clavinet_0010_256_DATA [256] = 
{664, 1682, 2730, 3807, 4829, 5903, 7037, 8132, 9149, 10088, 10960, 11776, 12539, 13261, 13935, 14585, 15282, 15995, 16639, 17120, 17439, 17599, 17559, 17305, 16863, 16332, 15753, 15153, 14547, 13996, 13552, 13044, 12470, 11947, 11390, 10762, 10090, 9322, 8444, 7469, 6369, 5193, 4055, 2981, 1978, 1036, 281, -216, -592, -838, -931, -924, -834, -671, -472, -232, 84, 550, 1191, 2007, 3108, 4485, 6029, 7754, 9594, 11414, 13132, 14698, 16087, 17311, 18375, 19307, 20104, 20775, 21381, 21928, 22465, 23100, 23792, 24529, 25459, 26531, 27642, 28747, 29785, 30707, 31495, 32116, 32537, 32734, 32768, 32696, 32416, 31905, 31207, 30372, 29396, 28246, 26960, 25567, 24089, 22495, 20789, 19075, 17310, 15520, 13838, 12291, 10853, 9486, 8199, 6979, 5685, 4339, 3007, 1687, 384, -918, -2269, -3686, -5146, -6617, -8078, -9510, -10786, -11878, -12806, -13574, -14174, -14606, -14948, -15224, -15392, -15472, -15480, -15434, -15330, -15186, -15046, -14932, -14855, -14814, -14848, -14958, -15068, -15158, -15230, -15311, -15318, -15187, -14998, -14762, -14470, -14102, -13703, -13338, -12986, -12665, -12410, -12203, -12051, -11981, -11942, -11890, -11810, -11734, -11684, -11661, -11661, -11696, -11802, -11967, -12166, -12384, -12574, -12685, -12695, -12583, -12313, -11834, -11152, -10311, -9347, -8287, -7201, -6196, -5319, -4589, -4018, -3616, -3382, -3251, -3170, -3107, -3065, -3014, -2894, -2774, -2721, -2783, -2955, -3260, -3764, -4434, -5216, -6079, -6962, -7797, -8527, -9101, -9501, -9773, -9946, -10056, -10160, -10338, -10656, -11132, -11776, -12573, -13529, -14610, -15751, -16920, -18067, -19118, -20012, -20741, -21364, -21826, -22118, -22301, -22444, -22545, -22520, -22361, -22078, -21660, -21040, -20189, -19159, -17967, -16621, -15122, -13544, -11978, -10440, -8969, -7595, -6357, -5222, -4148, -3151, -2213, -1286, -307};