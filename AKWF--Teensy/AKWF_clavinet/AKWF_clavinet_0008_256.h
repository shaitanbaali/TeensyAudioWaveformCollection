/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0008 256 samples */
 
const int16_t AKWF_clavinet_0008_256_DATA [256] = 
{1447, 4212, 4903, 4442, 3352, 2629, 3124, 5322, 9200, 14295, 19833, 24913, 28637, 30420, 30102, 28043, 24953, 21724, 19171, 17963, 18318, 20006, 22408, 24762, 26386, 26775, 25702, 23165, 19320, 14560, 9542, 5016, 1670, -144, -519, 66, 821, 857, -525, -3640, -8272, -13696, -18939, -23164, -25878, -26975, -26669, -25518, -24277, -23682, -24173, -25784, -28131, -30530, -32258, -32758, -31727, -29125, -25198, -20480, -15714, -11530, -8476, -6761, -6310, -6829, -7883, -9018, -9811, -9975, -9369, -8016, -6008, -3519, -741, 2180, 5111, 7922, 10574, 12944, 14931, 16437, 17373, 17649, 17247, 16225, 14731, 12958, 11168, 9644, 8621, 8301, 8801, 10154, 12262, 14935, 17885, 20763, 23251, 25095, 26051, 25994, 24843, 22628, 19402, 15351, 10784, 6057, 1595, -2176, -4967, -6471, -6559, -5229, -2672, 808, 4778, 8691, 12008, 14296, 15195, 14511, 12158, 8240, 3026, -3032, -9401, -15510, -20810, -24855, -27338, -28115, -27094, -24319, -19960, -14429, -8138, -1698, 4233, 9100, 12435, 13915, 13419, 10954, 6785, 1350, -4671, -10623, -15882, -19908, -22381, -23121, -22063, -19239, -14806, -9126, -2719, 3749, 9658, 14517, 17981, 19888, 20196, 18928, 16141, 12007, 6815, 989, -5021, -10809, -15978, -20110, -22817, -23802, -22980, -20544, -16966, -12829, -8690, -4909, -1588, 1302, 3703, 5469, 6327, 6066, 4669, 2382, -374, -3183, -5753, -7933, -9649, -10796, -11209, -10686, -9066, -6316, -2576, 1816, 6426, 10794, 14505, 17280, 19058, 19988, 20376, 20581, 20868, 21276, 21554, 21288, 20049, 17626, 14135, 10007, 5942, 2705, 787, 351, 1068, 2304, 3333, 3542, 2595, 468, -2552, -5966, -9141, -11584, -12970, -13262, -12752, -11962, -11459, -11672, -12790, -14739, -17257, -19987, -22449, -24152, -24636, -23606, -20996, -17132, -12735, -8734, -5959, -4813, -5143, -6362, -7598, -8007, -7130, -3519};