/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0012 256 samples */
 
const int16_t AKWF_clavinet_0012_256_DATA [256] = 
{1393, 4088, 7234, 10611, 13935, 16977, 19538, 21515, 22867, 23686, 23978, 23801, 23162, 22078, 20667, 19115, 17680, 16545, 15887, 15721, 16033, 16832, 18105, 19777, 21734, 23726, 25485, 26728, 27347, 27328, 26750, 25781, 24600, 23314, 21971, 20550, 18930, 17040, 14913, 12686, 10557, 8715, 7291, 6263, 5539, 5020, 4625, 4381, 4261, 4236, 4292, 4413, 4558, 4632, 4544, 4184, 3478, 2463, 1278, 127, -888, -1695, -2354, -2910, -3314, -3409, -3087, -2360, -1443, -652, -375, -674, -1529, -2693, -3824, -4790, -5543, -6157, -6654, -7035, -7230, -7189, -6943, -6567, -6166, -5756, -5336, -4935, -4622, -4475, -4550, -4760, -4902, -4693, -4054, -3000, -1780, -511, 656, 1677, 2542, 3036, 2947, 2071, 489, -1470, -3507, -5253, -6523, -7222, -7438, -7299, -6827, -6231, -5614, -5107, -4692, -4212, -3595, -2747, -1733, -629, 479, 1551, 2621, 3674, 4639, 5320, 5471, 4979, 3776, 1986, -176, -2562, -4993, -7207, -8955, -10047, -10388, -10008, -9006, -7472, -5501, -3126, -497, 2196, 4703, 6837, 8457, 9591, 10335, 10708, 10711, 10343, 9621, 8672, 7565, 6452, 5366, 4366, 3504, 2840, 2514, 2615, 3238, 4360, 5950, 7896, 10051, 12334, 14567, 16560, 18080, 18845, 18701, 17473, 15254, 12113, 8244, 3952, -457, -4705, -8511, -11752, -14346, -16336, -17747, -18615, -18908, -18664, -17919, -16748, -15273, -13568, -11755, -9965, -8350, -7084, -6263, -6026, -6417, -7506, -9285, -11746, -14805, -18247, -21865, -25389, -28503, -30984, -32474, -32742, -31594, -29068, -25373, -20893, -16155, -11712, -7962, -5131, -3389, -2745, -3141, -4505, -6715, -9571, -12833, -16136, -19116, -21408, -22777, -23028, -22212, -20532, -18289, -15774, -13198, -10694, -8269, -5977, -3920, -2178, -940, -303, -202, -521, -1073, -1645, -2115, -2462, -2714, -2880, -2906, -2646, -1973, -576};