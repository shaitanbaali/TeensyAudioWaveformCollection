/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0015 256 samples */
 
const int16_t AKWF_clavinet_0015_256_DATA [256] = 
{2829, 5473, 5900, 5278, 5139, 6333, 8627, 11708, 15862, 20837, 24559, 25147, 23530, 21829, 20305, 17950, 14952, 12944, 12742, 13405, 14008, 14912, 16840, 19817, 23224, 26287, 28790, 30967, 32593, 32282, 28846, 22996, 16576, 10848, 6167, 2542, -137, -2258, -4297, -6659, -9377, -11856, -13009, -12388, -10872, -9838, -9716, -10134, -10870, -12142, -13917, -15686, -17067, -18056, -18878, -19540, -20027, -20576, -21681, -23497, -25581, -26969, -26772, -25020, -22898, -21680, -21200, -20568, -19653, -18820, -17536, -14888, -11480, -8797, -7157, -5701, -4322, -3579, -3312, -2627, -1103, 865, 2861, 4540, 5389, 5134, 4270, 3200, 1971, 1004, 1029, 2110, 3512, 4479, 4530, 3630, 2184, 839, 514, 1955, 5069, 8683, 11205, 11553, 9868, 7318, 5040, 3675, 3348, 3877, 4935, 5887, 5612, 3328, -248, -3549, -5376, -5330, -3473, -315, 3083, 5512, 6068, 4778, 2698, 1259, 1188, 2189, 3853, 6102, 8414, 9433, 8199, 5217, 2143, 567, 978, 2678, 4594, 6018, 6512, 5589, 3152, 189, -1710, -1698, -287, 1473, 3177, 4545, 4839, 3548, 1200, -985, -2004, -1667, -352, 1333, 2746, 3377, 3040, 1928, 185, -1882, -3566, -4053, -3441, -2527, -1788, -904, 155, 627, 66, -792, -952, -559, -392, -617, -856, -1015, -1453, -2294, -3255, -4044, -4365, -3873, -2382, -37, 2898, 6201, 9304, 11263, 11487, 10270, 8380, 6089, 3390, 611, -1747, -3699, -5728, -7960, -9897, -10888, -10441, -8329, -4643, 32, 4844, 9107, 11968, 12694, 11100, 7971, 4432, 1337, -896, -2305, -3364, -4616, -6219, -8111, -10238, -12191, -13125, -12227, -9733, -6754, -4349, -2831, -2175, -2650, -4212, -5876, -6374, -5463, -3824, -2302, -1338, -1203, -2077, -3827, -5899, -7670, -8689, -8703, -8101, -7890, -8687, -10078, -11182, -11622, -11303, -9691, -6240, -1415};