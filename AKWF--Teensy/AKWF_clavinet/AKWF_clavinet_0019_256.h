/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0019 256 samples */
 
const int16_t AKWF_clavinet_0019_256_DATA [256] = 
{439, 1293, 2124, 2946, 3767, 4580, 5386, 6181, 6967, 7746, 8516, 9282, 10040, 10787, 11534, 12272, 12998, 13718, 14424, 15120, 15808, 16482, 17143, 17793, 18427, 19050, 19661, 20257, 20837, 21400, 21950, 22484, 23004, 23507, 23993, 24461, 24915, 25352, 25773, 26175, 26559, 26927, 27277, 27608, 27923, 28219, 28494, 28755, 28996, 29222, 29428, 29615, 29787, 29943, 30078, 30197, 30300, 30382, 30449, 30497, 30529, 30542, 30538, 30517, 30479, 30425, 30355, 30268, 30166, 30047, 29912, 29762, 29597, 29418, 29224, 29016, 28793, 28556, 28306, 28042, 27764, 27471, 27164, 26845, 26512, 26163, 25803, 25429, 25042, 24646, 24233, 23811, 23376, 22928, 22471, 22005, 21522, 21032, 20530, 20018, 19499, 18967, 18425, 17873, 17313, 16740, 16162, 15570, 14969, 14361, 13742, 13120, 12491, 11851, 11206, 10558, 9904, 9241, 8575, 7901, 7223, 6546, 5859, 5168, 4475, 3777, 3077, 2377, 1668, 959, 246, -469, -1180, -1897, -2615, -3331, -4048, -4764, -5471, -6181, -6890, -7596, -8303, -9007, -9711, -10418, -11124, -11827, -12531, -13226, -13920, -14609, -15291, -15967, -16633, -17293, -17946, -18591, -19228, -19856, -20472, -21082, -21681, -22272, -22846, -23412, -23967, -24509, -25037, -25551, -26048, -26534, -27007, -27462, -27902, -28324, -28729, -29118, -29491, -29844, -30180, -30496, -30794, -31074, -31335, -31576, -31796, -31996, -32175, -32334, -32470, -32585, -32676, -32748, -32765, -32753, -32746, -32737, -32732, -32695, -32605, -32495, -32362, -32207, -32028, -31827, -31603, -31357, -31088, -30799, -30486, -30153, -29797, -29421, -29027, -28610, -28173, -27717, -27243, -26749, -26237, -25703, -25154, -24588, -24007, -23407, -22790, -22157, -21508, -20847, -20170, -19478, -18772, -18052, -17321, -16583, -15830, -15073, -14305, -13528, -12748, -11962, -11163, -10362, -9552, -8735, -7919, -7091, -6259, -5426, -4587, -3749, -2914, -2071, -1232, -374};