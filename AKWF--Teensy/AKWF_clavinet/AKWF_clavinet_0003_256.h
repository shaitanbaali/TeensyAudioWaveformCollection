/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0003 256 samples */
 
const int16_t AKWF_clavinet_0003_256_DATA [256] = 
{7139, 17241, 22512, 22156, 19816, 20004, 23171, 26788, 28561, 27409, 23436, 20247, 20984, 23708, 24475, 20869, 12771, 3756, -2300, -4756, -4391, -2764, -601, 2539, 7338, 14601, 22417, 27655, 29318, 27289, 21542, 12446, 2227, -5320, -9103, -10582, -10835, -11026, -11595, -13025, -15579, -18035, -20148, -21728, -21757, -20396, -17535, -13836, -11170, -9948, -9802, -10193, -10971, -12457, -14068, -15569, -16914, -17375, -16805, -15738, -13964, -12041, -10522, -8807, -7125, -5295, -3623, -1632, 220, 1184, 1806, 2417, 3355, 4874, 5475, 5516, 5056, 4435, 4736, 4762, 4744, 5624, 5551, 5946, 6687, 6789, 7756, 8203, 7999, 7796, 7148, 7058, 6717, 6435, 6173, 5423, 4577, 3835, 3075, 2931, 2138, 1099, 2, -1492, -2279, -1977, -1604, -1179, -1084, -1135, -544, 247, 550, 1075, 262, -767, -896, -1537, -1176, -798, -829, -392, -926, -302, 244, -422, -396, -327, -489, -494, -1207, -606, 572, 1626, 2316, 1789, 2197, 2942, 2108, 2064, 1674, 1289, 1584, 951, -300, 116, 669, 558, 2075, 1532, -717, -944, -1744, 132, 1302, -1416, -1582, -1498, -1755, -744, -1380, -421, 1780, 1797, -410, -2928, -2975, -2421, -1930, 834, 3220, 3501, 1210, -2795, -5243, -2678, 94, 1221, 2058, -1623, -3300, 848, 4473, 7595, 3998, -5418, -8966, -8130, -3919, 1128, 2486, 3047, 2525, -238, -2704, -1005, 5299, 10401, 10568, 5559, -1888, -6312, -5434, -531, 6922, 12860, 12197, 7684, 2296, -4161, -8291, -10564, -12402, -11922, -9786, -4860, 5692, 17838, 24786, 23996, 18642, 11787, 3199, -5994, -12203, -13726, -14141, -15815, -17068, -17104, -16274, -15648, -16236, -16493, -14570, -12633, -13175, -15493, -16559, -13382, -5175, 6172, 15347, 18534, 15966, 11282, 8136, 4790, -3084, -14438, -24858, -31735, -31932, -25066, -14812, -3417};