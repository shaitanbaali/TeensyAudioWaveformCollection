/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0032 256 samples */
 
const int16_t AKWF_clavinet_0032_256_DATA [256] = 
{1509, 3424, 4450, 4941, 5326, 6076, 7555, 9882, 12907, 16277, 19513, 22229, 24146, 25181, 25376, 24809, 23561, 21685, 19313, 16699, 14273, 12571, 12122, 13237, 15879, 19613, 23705, 27301, 29706, 30542, 29802, 27767, 24805, 21212, 17086, 12359, 6969, 983, -5256, -11106, -15821, -18711, -19324, -17620, -13954, -9034, -3704, 1208, 5058, 7464, 8251, 7382, 4875, 845, -4480, -10704, -17189, -23215, -28101, -31323, -32702, -32364, -30645, -27939, -24567, -20774, -16730, -12663, -8902, -5847, -3911, -3420, -4526, -7157, -10993, -15559, -20272, -24527, -27836, -29807, -30227, -29056, -26405, -22508, -17676, -12344, -7008, -2165, 1712, 4309, 5584, 5685, 4919, 3614, 1996, 211, -1674, -3564, -5285, -6562, -7052, -6446, -4575, -1479, 2591, 7223, 11921, 16241, 19853, 22561, 24317, 25178, 25211, 24508, 23153, 21255, 18963, 16508, 14173, 12210, 10818, 10053, 9845, 10072, 10635, 11541, 12853, 14670, 17002, 19674, 22344, 24508, 25636, 25359, 23563, 20465, 16533, 12322, 8369, 5009, 2401, 551, -640, -1280, -1471, -1311, -900, -364, 170, 584, 784, 739, 432, -172, -1132, -2523, -4419, -6842, -9696, -12795, -15846, -18495, -20421, -21380, -21267, -20145, -18229, -15860, -13398, -11180, -9484, -8471, -8201, -8611, -9542, -10775, -12052, -13191, -14067, -14663, -15064, -15353, -15577, -15667, -15457, -14726, -13268, -10950, -7776, -3901, 323, 4458, 8088, 10867, 12629, 13372, 13198, 12265, 10752, 8835, 6672, 4477, 2487, 943, 77, 36, 876, 2544, 4909, 7816, 11083, 14528, 17985, 21222, 23954, 25835, 26465, 25509, 22769, 18291, 12401, 5648, -1228, -7504, -12583, -16094, -17932, -18194, -17142, -15099, -12437, -9532, -6743, -4407, -2817, -2190, -2649, -4183, -6668, -9806, -13196, -16435, -19122, -21013, -22054, -22339, -22059, -21372, -20354, -18953, -17049, -14565, -11507, -8036, -4451, -1106};