/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0027 256 samples */
 
const int16_t AKWF_clavinet_0027_256_DATA [256] = 
{1130, 2804, 4437, 6070, 7671, 9243, 10778, 12250, 13674, 15037, 16326, 17537, 18667, 19714, 20671, 21534, 22300, 22962, 23525, 23981, 24334, 24580, 24718, 24751, 24678, 24501, 24223, 23856, 23410, 22890, 22305, 21660, 20965, 20235, 19480, 18702, 17911, 17111, 16307, 15513, 14720, 13938, 13176, 12430, 11709, 11019, 10352, 9717, 9120, 8561, 8047, 7575, 7142, 6749, 6397, 6083, 5806, 5560, 5338, 5133, 4939, 4752, 4569, 4387, 4201, 4009, 3808, 3597, 3378, 3149, 2914, 2673, 2427, 2176, 1928, 1684, 1443, 1214, 994, 791, 611, 453, 322, 217, 136, 82, 56, 57, 86, 144, 232, 350, 497, 672, 876, 1111, 1375, 1666, 1984, 2319, 2671, 3035, 3408, 3787, 4170, 4553, 4936, 5316, 5686, 6048, 6397, 6734, 7055, 7359, 7638, 7889, 8110, 8298, 8451, 8570, 8652, 8699, 8709, 8685, 8628, 8544, 8435, 8305, 8157, 7993, 7821, 7644, 7463, 7284, 7110, 6946, 6797, 6665, 6550, 6458, 6390, 6351, 6343, 6364, 6413, 6487, 6582, 6692, 6817, 6956, 7101, 7251, 7398, 7541, 7676, 7806, 7925, 8035, 8132, 8212, 8275, 8314, 8329, 8317, 8274, 8198, 8086, 7934, 7739, 7501, 7215, 6882, 6498, 6065, 5582, 5042, 4445, 3786, 3065, 2287, 1446, 538, -429, -1463, -2558, -3701, -4902, -6149, -7432, -8754, -10100, -11457, -12834, -14205, -15570, -16924, -18247, -19547, -20812, -22032, -23207, -24329, -25388, -26397, -27345, -28224, -29037, -29775, -30440, -31034, -31552, -31991, -32347, -32626, -32766, -32759, -32752, -32744, -32740, -32632, -32399, -32121, -31797, -31436, -31044, -30622, -30170, -29687, -29175, -28627, -28045, -27432, -26781, -26090, -25361, -24581, -23760, -22900, -21997, -21059, -20084, -19065, -18008, -16915, -15780, -14618, -13414, -12164, -10868, -9519, -8122, -6678, -5185, -3650, -2084, -447};