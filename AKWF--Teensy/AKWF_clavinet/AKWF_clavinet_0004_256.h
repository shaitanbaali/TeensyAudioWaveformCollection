/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0004 256 samples */
 
const int16_t AKWF_clavinet_0004_256_DATA [256] = 
{163, 715, 1418, 1899, 2183, 2424, 2492, 2844, 3708, 4609, 5194, 5426, 5345, 5427, 5897, 6398, 6864, 6889, 6671, 7020, 7335, 7705, 7916, 7373, 6467, 5073, 4054, 3294, 2005, 1181, 806, 531, 400, -61, -21, 542, 788, 572, -330, -720, -595, -947, -849, -623, -350, 364, 282, -379, -435, -455, -590, -21, -539, -2073, -2578, -2431, -549, 930, -20, 7, 476, 671, 1172, 765, 1156, 2585, 2582, 1141, -171, 78, 753, 1176, 2612, 4000, 3658, 1457, -1923, -3650, -1786, 1062, 2943, 3233, -79, -3108, -2100, 540, 3016, 1337, -4275, -6271, -3957, 466, 4362, 4760, 3399, 953, -3382, -7080, -6734, -2096, 2858, 4328, 1818, -2158, -4201, -3060, 751, 5672, 8246, 5625, -173, -5548, -8907, -8482, -4948, -532, 3080, 3563, 2196, 2425, 3659, 2820, -1276, -6883, -10187, -9134, -4344, 3376, 12193, 18103, 18490, 14423, 8624, 1619, -6194, -11856, -13773, -12171, -8749, -5990, -4265, -2116, 2011, 8355, 15078, 18527, 16293, 9782, 3655, 1661, 3142, 4175, 2657, -27, -1738, -1973, -2234, -4022, -8014, -13912, -21023, -28009, -32383, -31830, -24700, -12303, 15, 9195, 14103, 14203, 12346, 10874, 8947, 4392, -3393, -11897, -17948, -20317, -19594, -17206, -14610, -12973, -12105, -10759, -8266, -4628, -298, 4248, 7934, 10944, 14247, 18523, 23726, 28635, 31477, 31724, 29624, 24732, 16772, 7503, 195, -3760, -4677, -2694, 1762, 7412, 12710, 16149, 17417, 17463, 17227, 17155, 17218, 17255, 16978, 15994, 14272, 11836, 8443, 4315, -205, -4972, -9064, -12044, -13939, -14859, -14870, -14251, -13598, -13047, -12484, -11756, -10983, -10823, -11376, -12377, -13455, -14082, -14613, -15050, -15020, -15254, -15448, -15212, -14974, -14076, -12871, -11798, -10506, -9150, -7434, -5590, -3821, -2120, -1030, -336};