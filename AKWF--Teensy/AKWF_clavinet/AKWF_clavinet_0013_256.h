/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0013 256 samples */
 
const int16_t AKWF_clavinet_0013_256_DATA [256] = 
{1300, 3440, 5337, 6873, 8044, 8872, 9328, 9470, 9316, 9040, 8806, 8755, 9018, 9709, 10887, 12530, 14630, 17119, 19871, 22707, 25473, 27998, 30092, 31646, 32547, 32762, 32348, 31279, 29688, 27672, 25377, 22946, 20511, 18207, 16162, 14487, 13198, 12400, 12094, 12273, 12898, 13927, 15281, 16857, 18493, 20080, 21388, 22290, 22700, 22490, 21700, 20313, 18315, 15878, 13110, 10089, 7038, 4047, 1288, -1077, -3035, -4518, -5524, -6138, -6377, -6358, -6092, -5677, -5156, -4479, -3749, -2985, -2217, -1466, -791, -278, 67, 214, 115, -201, -801, -1651, -2698, -3921, -5227, -6546, -7745, -8795, -9545, -9957, -9980, -9616, -8920, -7839, -6497, -4976, -3328, -1710, -147, 1269, 2502, 3400, 4004, 4332, 4384, 4193, 3815, 3345, 2806, 2250, 1765, 1365, 1126, 1023, 1089, 1324, 1642, 2056, 2468, 2894, 3294, 3533, 3709, 3709, 3561, 3233, 2745, 2081, 1212, 197, -944, -2102, -3226, -4258, -5088, -5654, -5889, -5693, -5070, -4012, -2655, -1110, 507, 2074, 3480, 4663, 5571, 6193, 6601, 6704, 6605, 6371, 6096, 5886, 5800, 5905, 6238, 6789, 7508, 8367, 9314, 10201, 11027, 11709, 12215, 12538, 12647, 12588, 12311, 11830, 11131, 10199, 9053, 7671, 6092, 4292, 2398, 453, -1458, -3229, -4779, -6036, -6952, -7507, -7776, -7865, -7820, -7743, -7715, -7799, -8087, -8574, -9329, -10289, -11404, -12679, -14010, -15323, -16530, -17623, -18533, -19268, -19843, -20202, -20439, -20522, -20432, -20167, -19680, -18998, -18124, -17077, -15873, -14605, -13378, -12290, -11543, -11214, -11417, -12142, -13342, -14973, -16776, -18591, -20254, -21583, -22490, -22879, -22709, -22060, -21013, -19668, -18190, -16782, -15554, -14665, -14140, -14032, -14307, -14859, -15630, -16443, -17183, -17723, -17983, -17936, -17505, -16720, -15567, -14064, -12275, -10203, -7955, -5602, -3238, -869};