/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0016 256 samples */
 
const int16_t AKWF_clavinet_0016_256_DATA [256] = 
{1341, 3866, 5504, 6225, 6196, 5697, 4986, 4338, 3936, 3748, 3479, 2971, 2341, 2034, 2651, 4780, 8673, 14020, 19909, 25282, 29410, 31884, 32742, 32610, 32217, 32038, 32053, 31807, 31006, 29366, 26589, 22596, 17957, 13787, 11135, 10351, 11150, 12901, 14785, 15990, 15941, 14673, 12786, 11008, 9822, 9467, 9755, 10322, 10631, 10201, 8710, 5961, 2011, -2748, -7699, -12476, -16922, -20856, -24038, -26307, -27744, -28400, -28273, -27398, -25932, -24435, -23255, -22510, -22060, -21645, -21160, -20531, -19623, -18311, -16748, -15378, -14728, -14927, -15585, -16288, -16924, -17428, -17597, -17356, -16875, -16334, -15481, -14019, -11855, -9110, -5945, -2557, 839, 3963, 6287, 7406, 7341, 6490, 5216, 3799, 2256, 603, -1089, -2662, -3905, -4554, -4304, -2917, -417, 2743, 5843, 8259, 9453, 9007, 6888, 3546, -211, -3633, -6046, -7281, -7594, -7337, -6723, -5878, -4727, -3052, -625, 2600, 6296, 9735, 12242, 13284, 12699, 10570, 7542, 4621, 2667, 2030, 2541, 3632, 4607, 4817, 4066, 2741, 1655, 1469, 2514, 4797, 7680, 10293, 11901, 12178, 11308, 9792, 8366, 7633, 7841, 8672, 9436, 9426, 8169, 5655, 2305, -1109, -3729, -4924, -4620, -3438, -2293, -2052, -3076, -5173, -7680, -9610, -10114, -8914, -6384, -3301, -592, 1098, 1714, 1680, 1715, 2306, 3614, 5394, 7054, 7855, 7307, 5426, 2722, -66, -2244, -3346, -3141, -1811, 169, 2303, 4304, 6019, 7488, 8851, 10271, 11769, 13156, 14206, 14641, 14321, 13170, 11308, 9046, 6720, 4447, 2284, 139, -2042, -4282, -6484, -8491, -9975, -10689, -10554, -9718, -8492, -7151, -5948, -5065, -4604, -4556, -4886, -5598, -6770, -8382, -10226, -12004, -13608, -14945, -16139, -17389, -18750, -20017, -20834, -20966, -20248, -18636, -16270, -13638, -11306, -9595, -8490, -7820, -7385, -6819, -5745, -3926, -1347};