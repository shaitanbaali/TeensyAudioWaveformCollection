/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0033 256 samples */
 
const int16_t AKWF_clavinet_0033_256_DATA [256] = 
{2259, 7002, 11411, 15081, 17760, 19631, 21189, 22914, 24956, 27049, 28696, 29529, 29449, 28607, 27238, 25542, 23731, 22099, 21027, 20796, 21339, 22189, 22703, 22472, 21609, 20712, 20501, 21409, 23366, 25903, 28392, 30298, 31235, 30927, 29223, 26167, 22105, 17598, 13260, 9513, 6422, 3813, 1468, -725, -2651, -4010, -4449, -3702, -1757, 1068, 4125, 6605, 7742, 7030, 4373, 95, -5141, -10550, -15426, -19206, -21607, -22633, -22519, -21668, -20480, -19247, -18091, -17004, -15909, -14741, -13510, -12324, -11320, -10656, -10451, -10791, -11721, -13226, -15209, -17469, -19731, -21706, -23114, -23774, -23601, -22625, -20932, -18649, -15956, -13080, -10228, -7584, -5241, -3242, -1663, -617, -232, -623, -1817, -3721, -6089, -8561, -10689, -11987, -12046, -10620, -7753, -3777, 742, 5167, 8967, 11758, 13348, 13734, 13046, 11533, 9494, 7225, 4928, 2667, 454, -1660, -3489, -4699, -4945, -3986, -1759, 1634, 5960, 10797, 15575, 19616, 22280, 23191, 22306, 19895, 16380, 12225, 7843, 3495, -652, -4557, -8287, -11839, -15018, -17393, -18318, -17192, -13709, -8036, -759, 7323, 15302, 22357, 27835, 31201, 32148, 30646, 27001, 21822, 15872, 9868, 4229, -866, -5269, -8696, -10650, -10613, -8326, -4007, 1648, 7704, 13195, 17384, 19866, 20486, 19323, 16655, 12998, 9031, 5404, 2541, 514, -859, -1774, -2304, -2428, -2139, -1537, -771, 81, 1080, 2341, 3866, 5430, 6620, 7003, 6326, 4563, 1822, -1851, -6496, -12054, -18156, -23958, -28401, -30688, -30570, -28375, -24697, -20085, -14929, -9542, -4419, -216, 2449, 3213, 2134, -431, -4059, -8452, -13407, -18625, -23641, -27889, -30875, -32436, -32753, -32195, -31075, -29490, -27358, -24578, -21234, -17586, -13856, -10169, -6593, -3277, -584, 1066, 1468, 757, -648, -2312, -4006, -5765, -7718, -9815, -11723, -12919, -12963, -11722, -9350, -6105, -2072};