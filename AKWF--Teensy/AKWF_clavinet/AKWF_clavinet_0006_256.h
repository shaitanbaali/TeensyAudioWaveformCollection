/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0006 256 samples */
 
const int16_t AKWF_clavinet_0006_256_DATA [256] = 
{2169, 6245, 8535, 8440, 7345, 7707, 10774, 15150, 18351, 19223, 19059, 19899, 22247, 24959, 26742, 27177, 26510, 25311, 24664, 25844, 28958, 32056, 32787, 30313, 25092, 19491, 16041, 15844, 17768, 19221, 17982, 13545, 7421, 2049, -706, -576, 780, 759, -2170, -7001, -11161, -12679, -12011, -11136, -11423, -12888, -14861, -16765, -18387, -19922, -21779, -24124, -26243, -27060, -26022, -23073, -18724, -14304, -11584, -12174, -16557, -23060, -28276, -28986, -24313, -15304, -5122, 1826, 3531, 1518, -1267, -3081, -4282, -5967, -8052, -9058, -7412, -2818, 3655, 10191, 14864, 16384, 14373, 9888, 5046, 2024, 1408, 1924, 1787, 567, -50, 2432, 8916, 17174, 23500, 25093, 20809, 11460, 354, -8910, -14295, -15149, -12188, -6691, 476, 8589, 15764, 19744, 19222, 14409, 6597, -2117, -9154, -12702, -12454, -9600, -5689, -1944, 997, 2915, 3750, 3489, 2138, -120, -2779, -5081, -6223, -5562, -2683, 2437, 9188, 16076, 20979, 22287, 19191, 11829, 1269, -10075, -19397, -24849, -25866, -22659, -15940, -7192, 1597, 8961, 14103, 16756, 17118, 15805, 13797, 11956, 10618, 9525, 8071, 5703, 2133, -2587, -7987, -13491, -18423, -22120, -24006, -23607, -20659, -15178, -7705, 779, 9186, 16487, 22044, 25574, 26932, 26067, 22988, 17945, 11363, 3867, -3887, -11313, -17917, -23256, -26954, -28675, -28237, -25654, -21190, -15201, -8178, -542, 7106, 13963, 19262, 22557, 23763, 23083, 20762, 16979, 11989, 6246, 408, -4752, -8776, -11511, -12876, -12840, -11461, -8950, -5490, -1217, 3676, 8700, 13198, 16712, 19122, 20394, 20438, 19190, 16778, 13444, 9462, 4984, 267, -4230, -7963, -10522, -11920, -12763, -13683, -14690, -15273, -15097, -14506, -14075, -13918, -13818, -13703, -13699, -13768, -13670, -13396, -13413, -14143, -15431, -16829, -17985, -18559, -18084, -16424, -14220, -12551, -11879, -11512, -10069, -6694, -1984};