/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0020 256 samples */
 
const int16_t AKWF_clavinet_0020_256_DATA [256] = 
{2081, 7995, 13360, 15822, 14795, 12411, 10232, 7709, 4893, 3810, 5877, 11037, 17738, 23857, 27883, 28295, 24124, 17804, 14411, 16533, 22713, 28627, 30570, 28958, 26494, 23962, 21192, 18650, 16757, 15696, 15286, 14228, 11770, 8717, 5795, 2995, 711, 15, 1459, 4213, 5708, 3194, -3210, -10836, -16557, -17701, -13286, -5336, 1789, 3400, -2413, -12857, -21983, -25215, -21753, -13936, -5329, 772, 2862, 862, -3929, -8824, -11218, -10323, -7133, -3243, -263, 567, -1240, -5361, -9907, -12010, -10336, -5991, -1189, 2142, 2491, -462, -5363, -9819, -10963, -7291, -665, 5519, 8903, 8459, 4518, -1198, -6230, -8535, -7110, -2815, 1585, 3402, 1927, -1630, -5311, -7153, -6578, -4443, -1984, -54, 1123, 2148, 3302, 3967, 3590, 2346, 815, -85, 223, 1985, 4588, 5970, 4466, 664, -3334, -5302, -4888, -3240, -1719, -1099, -1177, -680, 1183, 3996, 6258, 6198, 3531, -137, -2220, -1163, 1883, 3988, 3239, 482, -1794, -2035, -277, 2496, 4613, 4539, 1989, -1500, -3930, -4341, -3047, -1359, -149, 736, 1478, 2071, 2340, 1803, 197, -1577, -2138, -914, 1993, 5446, 7376, 6783, 4118, 505, -3027, -6168, -8707, -10130, -10255, -9146, -6681, -2976, 1008, 4149, 6103, 7109, 7886, 8720, 8986, 7905, 5470, 2259, -919, -3664, -6427, -9687, -12877, -15122, -15879, -14528, -11163, -6404, -814, 5161, 11329, 17504, 22662, 25691, 25711, 22712, 17131, 9918, 2241, -5194, -11637, -16153, -18298, -18058, -15765, -11945, -6997, -1096, 5450, 12447, 19498, 25757, 30094, 31819, 30882, 27435, 22012, 15565, 8848, 2088, -4817, -12467, -20659, -27641, -31822, -32685, -30359, -26089, -20516, -13521, -6091, -555, 1827, 1441, -1262, -5480, -9847, -13135, -14624, -15623, -18616, -23418, -27427, -29485, -30487, -31045, -30703, -27703, -21008, -13246, -7434, -2825};