/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0025 256 samples */
 
const int16_t AKWF_clavinet_0025_256_DATA [256] = 
{1362, 5578, 9461, 12992, 15924, 18402, 20360, 21921, 22802, 22835, 21924, 20147, 17940, 15897, 14713, 14670, 16070, 18537, 21481, 24320, 26596, 28096, 28984, 29476, 29721, 29674, 28945, 27108, 23919, 19199, 13292, 7094, 1225, -3509, -6605, -7999, -7584, -5848, -3172, -21, 3321, 6699, 9941, 12688, 14745, 15557, 14735, 12543, 9161, 5276, 1430, -1960, -4637, -6569, -8060, -9035, -9391, -8832, -7260, -4724, -1519, 1742, 4671, 6770, 7746, 7549, 6104, 3580, 380, -3255, -7106, -10720, -13845, -16262, -17776, -18365, -17860, -16328, -14068, -11411, -8765, -6517, -4847, -3777, -2892, -2384, -2302, -2747, -4086, -6042, -8579, -11360, -13903, -15779, -16671, -16556, -15527, -13682, -11435, -8894, -6187, -3624, -1030, 1377, 3397, 5103, 6098, 6360, 5908, 4865, 3412, 1865, 445, -813, -1932, -3006, -4015, -4703, -4810, -4006, -2303, 360, 3551, 6803, 9620, 11469, 12251, 12115, 11274, 10153, 9016, 7723, 6455, 5131, 3737, 2454, 1414, 733, 436, 471, 793, 1244, 1822, 2486, 3166, 3966, 4613, 4838, 4621, 3786, 2253, 203, -2129, -4544, -6690, -8371, -9396, -9703, -9394, -8583, -7419, -6168, -4873, -3697, -2786, -2220, -2019, -2050, -2263, -2633, -2968, -3496, -4199, -5161, -6511, -7980, -9311, -10221, -10460, -9946, -8519, -6148, -3149, 216, 3542, 6541, 9234, 11495, 13241, 14528, 15185, 15098, 14361, 12990, 11122, 9160, 7304, 5755, 4727, 4229, 4354, 5060, 6479, 8575, 11308, 14605, 18224, 21739, 24751, 26639, 27047, 25844, 23017, 18820, 13787, 8391, 2975, -2004, -6453, -10425, -13554, -15795, -17277, -17852, -17756, -17162, -16425, -15703, -15280, -15483, -16219, -17555, -19431, -21394, -23324, -25133, -26623, -27966, -29327, -30658, -31866, -32598, -32710, -31908, -30191, -27806, -24879, -21805, -18939, -16562, -14601, -12907, -11143, -8961, -6126, -2532};