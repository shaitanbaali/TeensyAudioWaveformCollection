/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0001 256 samples */
 
const int16_t AKWF_clavinet_0001_256_DATA [256] = 
{6039, 14074, 21352, 28295, 32672, 31229, 26244, 20482, 17429, 12928, 8677, 7866, 7636, 7181, 6640, 6279, 8560, 11329, 8270, 566, -6678, -8719, -3539, 5475, 12771, 17298, 17482, 14017, 13090, 14767, 13860, 9447, 2681, -5139, -12766, -19060, -21362, -21328, -20003, -15867, -13097, -13307, -13995, -12816, -9501, -6565, -7813, -12248, -16277, -17052, -13778, -8143, -2940, -1699, -3896, -7787, -12333, -14772, -14823, -13435, -10581, -7220, -4097, -1496, 497, 2654, 3419, 3457, 3473, 3101, 3444, 4180, 4800, 5194, 4725, 4431, 4467, 4413, 5186, 5280, 4763, 4709, 4232, 4409, 5345, 6151, 6292, 5952, 5543, 5767, 5445, 5231, 4727, 3516, 2902, 1991, 831, 755, 668, 429, 80, -603, -1138, -1717, -1866, -1391, -1340, -1261, -1268, -1426, -817, 510, 760, 618, 486, 88, 174, -446, -403, -1033, -1019, -1196, -1316, -850, 6, 469, 1109, 330, 596, 486, 106, 944, 939, 405, 1525, 731, 1381, 2581, 2250, 2610, 1527, 619, 510, -271, 345, -113, -497, -804, -906, -202, 481, 25, 294, -503, -810, -995, -1108, -1315, -838, -812, -582, -449, -560, -388, 226, -245, 638, 293, -1093, -766, -1142, -69, 46, -832, 674, -279, -264, -215, -786, 592, 688, -840, -1262, -1810, 71, 1374, 1455, 1676, -1131, -2723, -2102, -2368, 601, 2632, 3748, 6475, 7411, 4394, 1916, 1714, 1057, 2615, 1076, -2433, 75, -1347, -434, 3257, 1705, 3020, -480, -6860, -5605, -1207, 3871, 5582, 2370, 301, -965, 4135, 11708, 14389, 12349, 3157, -10010, -17587, -22071, -24228, -22282, -18126, -14635, -8419, -8124, -8497, -697, 1702, 1701, 648, -6559, -5734, -3651, -1389, 6004, 10609, 11166, 7069, 327, -5032, -8846, -9854, -11561, -13446, -13991, -15612, -13530, -4414};