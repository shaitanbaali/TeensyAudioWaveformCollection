/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0029 256 samples */
 
const int16_t AKWF_clavinet_0029_256_DATA [256] = 
{838, 1941, 2725, 3382, 4014, 4705, 5457, 6230, 7032, 7867, 8879, 10044, 11444, 12986, 14555, 15947, 16962, 17416, 17241, 16368, 14917, 13098, 11226, 9577, 8452, 7954, 8217, 9154, 10737, 12830, 15350, 18202, 21295, 24458, 27433, 29932, 31752, 32692, 32662, 31600, 29513, 26580, 23122, 19365, 15586, 11967, 8649, 5751, 3415, 1790, 1028, 1154, 2148, 3906, 6239, 8964, 11786, 14392, 16403, 17523, 17517, 16369, 14199, 11152, 7441, 3277, -1060, -5291, -9061, -12088, -14271, -15592, -16147, -16138, -15719, -15018, -14196, -13420, -12881, -12739, -13053, -13829, -15003, -16496, -18235, -20096, -21928, -23613, -24980, -25911, -26311, -26258, -25722, -24847, -23734, -22438, -21182, -20064, -19115, -18363, -17734, -17274, -17075, -17200, -17695, -18472, -19386, -20202, -20749, -20793, -20191, -18826, -16604, -13581, -9973, -6057, -2213, 1212, 4000, 6140, 7544, 8306, 8428, 7977, 7018, 5682, 4072, 2341, 551, -1098, -2455, -3340, -3528, -3021, -1926, -515, 978, 2447, 3678, 4611, 5305, 5802, 6048, 6191, 6234, 6214, 6047, 5611, 4834, 3663, 2223, 688, -759, -1874, -2628, -2928, -2815, -2293, -1516, -553, 424, 1398, 2307, 3141, 3938, 4649, 5210, 5583, 5648, 5456, 4982, 4301, 3518, 2772, 2247, 2074, 2314, 2996, 4044, 5340, 6709, 8017, 9113, 9933, 10397, 10542, 10388, 9979, 9352, 8497, 7383, 5970, 4208, 2099, -249, -2759, -5269, -7562, -9400, -10598, -11061, -10717, -9579, -7717, -5314, -2506, 478, 3491, 6314, 8757, 10642, 11820, 12183, 11650, 10250, 8042, 5144, 1783, -1802, -5386, -8718, -11613, -13897, -15533, -16476, -16719, -16237, -15102, -13363, -11095, -8447, -5609, -2786, -185, 2020, 3600, 4378, 4278, 3327, 1645, -604, -3261, -6150, -8984, -11557, -13644, -14988, -15503, -15116, -13921, -12088, -9810, -7294, -4802, -2517, -582};