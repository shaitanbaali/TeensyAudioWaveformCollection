/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clavinet_0009 256 samples */
 
const int16_t AKWF_clavinet_0009_256_DATA [256] = 
{3528, 13146, 22785, 27198, 25295, 22191, 19756, 15859, 11877, 10186, 9301, 8234, 6180, 2808, 2732, 7742, 12913, 14973, 14887, 13113, 11489, 11449, 10843, 9912, 10174, 8929, 5283, 2453, 1452, 2481, 4645, 3585, -578, -3850, -4887, -4799, -3833, -3061, -3981, -4719, -5286, -7429, -7557, -5009, -4183, -4521, -5446, -7897, -8543, -5960, -3985, -3405, -2849, -3822, -5434, -4831, -4036, -3803, -2472, -2495, -4310, -4622, -3368, -2011, -207, 779, -521, -1474, -1037, -1709, -2679, -2499, -2411, -1665, 222, 365, -1099, -1632, -1519, -1036, -81, 143, -370, -238, 83, -571, -942, -58, 872, 1646, 1685, -176, -2293, -2258, -810, 157, 588, -143, -1900, -2019, -117, 1897, 2969, 2607, 202, -3093, -3644, -1102, 2485, 4976, 3845, 675, -1268, -1459, 17, 1592, 1216, -8, -872, -1668, -1905, -1168, 204, 1184, 1376, 989, 286, 577, 1809, 1629, -228, -1302, -1201, -658, 946, 2984, 3980, 3380, 674, -3280, -5269, -4048, -1222, 1445, 3138, 3939, 3555, 2169, -1326, -5546, -6118, -2879, 1864, 6010, 7730, 6095, 1310, -4630, -8442, -7555, -2329, 3281, 5922, 5566, 3338, 19, -2837, -4079, -4088, -2351, 853, 3183, 3257, 1393, -1747, -4658, -5447, -3532, 1008, 6782, 10513, 9859, 5332, -1042, -7285, -10649, -9340, -4698, 582, 4479, 5060, 2467, -1258, -4575, -5683, -3311, 1532, 6910, 11672, 14610, 14508, 11698, 7756, 3485, -52, -1910, -3624, -5261, -6207, -7280, -7839, -7039, -4964, -1584, 3370, 9041, 14193, 17886, 18127, 14622, 10103, 6104, 2221, -708, -3022, -6384, -11499, -18032, -25051, -30573, -32739, -32078, -28441, -20586, -10981, -2914, 4550, 10804, 13426, 12625, 8003, 43, -6409, -9005, -9637, -9085, -8475, -9648, -11834, -13591, -15151, -14760, -10754, -6864, -5188, -2427};