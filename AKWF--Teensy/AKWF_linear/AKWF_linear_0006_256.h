/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0006 256 samples */
 
const int16_t AKWF_linear_0006_256_DATA [256] = 
{303, 754, 1195, 1637, 2079, 2522, 2971, 3391, 3951, 5296, 6817, 8308, 9806, 11302, 12800, 14298, 15793, 17290, 18789, 20283, 21781, 23280, 24774, 26273, 27767, 29261, 30768, 31341, 31368, 31465, 31549, 31634, 31717, 31801, 31885, 31969, 32052, 32137, 32221, 32304, 32388, 32473, 32557, 32616, 32804, 31979, 29799, 27683, 25564, 23435, 21308, 19185, 17057, 14931, 12808, 10679, 8552, 6429, 4301, 2175, 52, -2061, -4248, -6046, -6440, -6710, -7010, -7302, -7593, -7886, -8178, -8469, -8761, -9053, -9344, -9637, -9928, -10220, -10513, -10804, -11096, -11382, -11439, -11411, -11399, -11383, -11368, -11353, -11339, -11324, -11309, -11293, -11278, -11263, -11248, -11233, -11217, -11202, -11183, -11186, -10883, -10289, -9723, -9154, -8584, -8013, -7444, -6873, -6303, -5733, -5163, -4593, -4023, -3454, -2882, -2314, -1737, -1191, -438, 772, 1996, 3212, 4434, 5654, 6872, 8095, 9314, 10534, 11756, 12974, 14194, 15416, 16635, 17855, 19064, 20326, 21313, 20588, 19442, 18374, 17289, 16206, 15122, 14036, 12954, 11868, 10783, 9700, 8614, 7530, 6447, 5361, 4278, 3196, 2104, 1502, 1205, 868, 540, 212, -116, -444, -772, -1101, -1428, -1757, -2086, -2413, -2741, -3070, -3398, -3725, -4064, -4300, -4394, -4494, -4592, -4690, -4789, -4887, -4985, -5084, -5181, -5280, -5379, -5476, -5575, -5673, -5771, -5873, -5959, -6122, -6578, -7065, -7545, -8029, -8509, -8991, -9474, -9956, -10437, -10920, -11401, -11884, -12365, -12847, -13329, -13809, -14293, -14768, -14635, -14269, -13947, -13616, -13286, -12956, -12625, -12294, -11964, -11633, -11303, -10972, -10642, -10311, -9980, -9650, -9321, -8987, -8696, -8449, -8196, -7944, -7694, -7441, -7191, -6939, -6688, -6437, -6185, -5934, -5683, -5431, -5179, -4929, -4675, -4431, -4128, -3689, -3246, -2804, -2361, -1919, -1477, -1034, -593, -143};