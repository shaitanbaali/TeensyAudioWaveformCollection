/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0035 256 samples */
 
const int16_t AKWF_linear_0035_256_DATA [256] = 
{446, 1671, 2869, 4069, 5271, 6472, 7673, 8869, 10079, 11243, 11504, 11418, 11386, 11346, 11304, 11262, 11220, 11179, 11135, 11092, 11050, 11009, 10965, 10923, 10879, 10837, 10797, 10739, 10870, 11180, 11470, 11763, 12057, 12349, 12643, 12936, 13229, 13522, 13814, 14107, 14400, 14693, 14985, 15278, 15566, 15879, 16039, 15836, 15633, 15432, 15228, 15025, 14823, 14620, 14416, 14213, 14010, 13808, 13604, 13401, 13199, 12995, 12793, 12590, 12389, 12203, 12021, 11838, 11655, 11472, 11289, 11107, 10925, 10742, 10560, 10377, 10194, 10012, 9830, 9647, 9462, 9276, 9114, 7642, 5315, 3102, 871, -1365, -3599, -5829, -8064, -10296, -12526, -14761, -16991, -19221, -21453, -23683, -25911, -28118, -30452, -31641, -31165, -30733, -30298, -29858, -29419, -28979, -28537, -28098, -27657, -27215, -26776, -26334, -25893, -25452, -25010, -24558, -24163, -23456, -21638, -19674, -17734, -15791, -13850, -11905, -9963, -8022, -6076, -4136, -2196, -253, 1686, 3626, 5568, 7500, 9450, 11352, 12077, 12324, 12644, 12949, 13255, 13561, 13865, 14170, 14475, 14778, 15082, 15386, 15689, 15993, 16296, 16598, 16879, 17284, 16448, 14405, 12481, 10538, 8589, 6646, 4700, 2752, 809, -1135, -3082, -5024, -6968, -8915, -10856, -12799, -14703, -16814, -17753, -15756, -13731, -11723, -9703, -7689, -5669, -3650, -1637, 383, 2401, 4415, 6435, 8451, 10465, 12484, 14487, 16537, 18363, 18280, 17714, 17244, 16755, 16266, 15775, 15286, 14796, 14306, 13817, 13326, 12835, 12346, 11855, 11364, 10872, 10375, 9912, 8289, 5866, 3546, 1213, -1127, -3466, -5799, -8138, -10475, -12808, -15147, -17480, -19812, -22149, -24481, -26813, -29115, -31590, -32589, -31320, -30098, -28874, -27642, -26414, -25182, -23949, -22720, -21489, -20256, -19026, -17795, -16563, -15335, -14103, -12871, -11642, -10415, -9207, -8005, -6798, -5596, -4393, -3190, -1991, -768};