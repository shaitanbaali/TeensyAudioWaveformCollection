/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0020 256 samples */
 
const int16_t AKWF_linear_0020_256_DATA [256] = 
{109, 343, 573, 804, 1083, 1389, 1690, 1993, 2295, 2597, 2899, 3201, 3503, 3804, 4105, 4407, 4708, 5010, 5312, 5612, 5915, 6212, 6557, 6960, 7360, 7760, 8160, 8559, 8959, 9358, 9758, 10156, 10556, 10955, 11353, 11753, 12151, 12550, 12950, 13346, 13760, 14230, 14703, 15176, 15649, 16121, 16594, 17066, 17538, 18011, 18483, 18954, 19426, 19898, 20368, 20840, 21312, 21784, 22254, 22695, 23128, 23563, 23998, 24432, 24866, 25300, 25734, 26169, 26602, 27036, 27471, 27903, 28336, 28770, 29202, 29634, 30075, 30344, 30470, 30613, 30753, 30893, 31034, 31174, 31314, 31453, 31592, 31733, 31872, 32011, 32151, 32290, 32429, 32562, 32729, 32647, 32102, 31555, 31011, 30463, 29918, 29373, 28826, 28280, 27733, 27186, 26642, 26096, 25547, 25003, 24457, 23905, 23384, 22707, 21257, 19654, 18077, 16495, 14918, 13336, 11755, 10176, 8595, 7015, 5439, 3858, 2280, 704, -877, -2452, -4028, -5606, -6933, -8129, -9345, -10553, -11763, -12972, -14179, -15389, -16599, -17804, -19013, -20222, -21426, -22634, -23841, -25044, -26240, -27492, -28257, -28435, -28645, -28850, -29054, -29257, -29460, -29663, -29866, -30069, -30271, -30474, -30675, -30878, -31079, -31280, -31479, -31695, -31816, -31635, -31433, -31236, -31038, -30839, -30640, -30441, -30242, -30044, -29845, -29646, -29448, -29248, -29050, -28851, -28651, -28454, -28247, -27843, -27375, -26918, -26460, -26001, -25542, -25085, -24626, -24168, -23710, -23251, -22794, -22337, -21879, -21420, -20965, -20506, -20047, -19596, -19147, -18697, -18250, -17800, -17351, -16904, -16455, -16007, -15559, -15110, -14662, -14214, -13767, -13319, -12872, -12425, -11977, -11529, -11074, -10620, -10167, -9712, -9259, -8805, -8351, -7897, -7444, -6991, -6538, -6086, -5631, -5179, -4727, -4276, -3819, -3391, -3130, -2903, -2670, -2438, -2207, -1975, -1743, -1513, -1281, -1050, -820, -588, -358, -124};