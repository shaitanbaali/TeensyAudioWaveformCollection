/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0061 256 samples */
 
const int16_t AKWF_linear_0061_256_DATA [256] = 
{334, 877, 1410, 1943, 2476, 3010, 3544, 4077, 4610, 5145, 5683, 6226, 6768, 7309, 7851, 8393, 8933, 9475, 10016, 10556, 11097, 11638, 12177, 12719, 13259, 13798, 14338, 14878, 15417, 15957, 16496, 17035, 17575, 18113, 18651, 19190, 19728, 20267, 20806, 21343, 21881, 22419, 22956, 23493, 24031, 24567, 25105, 25642, 26178, 26715, 27252, 27787, 28324, 28860, 29395, 29931, 30467, 31001, 31536, 32065, 32630, 32659, 32213, 31809, 31398, 30987, 30577, 30165, 29753, 29342, 28930, 28519, 28107, 27695, 27284, 26874, 26462, 26051, 25640, 25228, 24818, 24407, 23996, 23586, 23174, 22764, 22353, 21943, 21532, 21122, 20712, 20302, 19893, 19482, 19072, 18664, 18253, 17844, 17435, 17025, 16616, 16207, 15798, 15390, 14981, 14572, 14164, 13755, 13347, 12939, 12527, 12135, 11588, 10805, 10025, 9248, 8468, 7688, 6910, 6131, 5352, 4574, 3796, 3018, 2240, 1462, 685, -92, -870, -1646, -2422, -3200, -3975, -4752, -5529, -6304, -7080, -7855, -8630, -9405, -10181, -10954, -11729, -12504, -13277, -14051, -14826, -15598, -16372, -17145, -17917, -18690, -19463, -20234, -21007, -21779, -22549, -23322, -24092, -24863, -25635, -26397, -27199, -27771, -27704, -27586, -27480, -27370, -27261, -27150, -27039, -26930, -26820, -26709, -26598, -26488, -26377, -26267, -26155, -26045, -25934, -25823, -25713, -25603, -25491, -25380, -25269, -25159, -25048, -24938, -24827, -24716, -24605, -24495, -24384, -24274, -24164, -24052, -23942, -23831, -23721, -23611, -23500, -23390, -23279, -23169, -23058, -22948, -22838, -22728, -22617, -22507, -22394, -22293, -22138, -21661, -21111, -20576, -20036, -19496, -18958, -18419, -17881, -17343, -16803, -16266, -15727, -15188, -14651, -14113, -13574, -13038, -12500, -11962, -11425, -10887, -10350, -9814, -9277, -8739, -8204, -7667, -7130, -6595, -6058, -5522, -4987, -4451, -3916, -3381, -2845, -2310, -1776, -1241, -708, -164};