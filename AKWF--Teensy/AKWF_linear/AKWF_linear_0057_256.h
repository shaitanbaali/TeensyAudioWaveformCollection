/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0057 256 samples */
 
const int16_t AKWF_linear_0057_256_DATA [256] = 
{208, 578, 943, 1301, 1700, 2244, 2806, 3363, 3921, 4479, 5037, 5595, 6153, 6709, 7267, 7824, 8381, 8938, 9495, 10051, 10607, 11165, 11712, 12062, 12332, 12616, 12897, 13176, 13456, 13737, 14018, 14297, 14577, 14857, 15136, 15416, 15694, 15973, 16253, 16529, 16821, 16901, 16782, 16679, 16571, 16465, 16359, 16252, 16145, 16039, 15931, 15825, 15718, 15611, 15505, 15398, 15291, 15180, 15087, 14887, 14455, 14013, 13573, 13133, 12692, 12252, 11812, 11372, 10932, 10492, 10052, 9612, 9172, 8733, 8294, 7854, 7414, 6977, 6549, 6124, 5700, 5273, 4847, 4423, 3998, 3574, 3150, 2725, 2301, 1877, 1452, 1028, 604, 181, -242, -667, -1058, -1429, -1803, -2178, -2551, -2924, -3297, -3670, -4042, -4416, -4788, -5161, -5533, -5905, -6278, -6650, -7018, -7405, -7671, -7753, -7846, -7935, -8027, -8117, -8208, -8298, -8388, -8478, -8568, -8658, -8748, -8838, -8928, -9018, -9107, -9202, -9255, -9126, -8975, -8829, -8683, -8536, -8389, -8243, -8096, -7949, -7803, -7656, -7509, -7363, -7215, -7070, -6922, -6777, -6624, -6253, -5790, -5344, -4894, -4442, -3994, -3544, -3093, -2644, -2194, -1746, -1295, -844, -395, 53, 503, 956, 1384, 2146, 3243, 4315, 5391, 6466, 7543, 8620, 9694, 10770, 11846, 12919, 13994, 15070, 16143, 17218, 18292, 19337, 20523, 20813, 19026, 17126, 15259, 13383, 11503, 9627, 7748, 5868, 3993, 2116, 236, -1637, -3513, -5392, -7266, -9137, -11027, -12835, -14057, -15123, -16212, -17298, -18384, -19467, -20553, -21637, -22719, -23804, -24888, -25969, -27052, -28134, -29214, -30294, -31362, -32505, -31980, -30347, -28852, -27331, -25810, -24290, -22767, -21249, -19727, -18205, -16686, -15165, -13643, -12125, -10604, -9084, -7579, -6000, -4901, -4565, -4191, -3822, -3456, -3089, -2723, -2358, -1991, -1626, -1260, -896, -532, -161};