/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0080 256 samples */
 
const int16_t AKWF_linear_0080_256_DATA [256] = 
{1021, 3110, 5153, 7204, 9252, 11300, 13354, 15393, 17464, 19412, 20031, 20322, 20680, 21024, 21367, 21711, 22053, 22396, 22741, 23081, 23424, 23766, 24106, 24449, 24790, 25130, 25472, 25812, 26153, 26493, 26833, 27174, 27513, 27843, 28227, 28259, 27672, 27108, 26542, 25975, 25408, 24840, 24273, 23705, 23137, 22571, 22003, 21436, 20869, 20302, 19734, 19168, 18600, 18034, 17467, 16900, 16333, 15769, 15204, 14640, 14062, 14276, 14892, 15441, 16004, 16566, 17127, 17690, 18253, 18814, 19377, 19938, 20500, 21063, 21623, 22185, 22748, 23308, 23871, 24432, 24992, 25555, 26115, 26676, 27222, 27844, 28066, 26913, 25662, 24439, 23205, 21973, 20742, 19509, 18277, 17047, 15814, 14583, 13353, 12120, 10890, 9660, 8428, 7200, 5969, 4739, 3511, 2281, 1051, -174, -1390, -2677, -3200, -3017, -2914, -2798, -2681, -2564, -2446, -2329, -2212, -2093, -1975, -1857, -1740, -1621, -1503, -1386, -1267, -1149, -1030, -912, -794, -675, -557, -440, -317, -224, -392, -623, -841, -1061, -1282, -1502, -1722, -1943, -2162, -2383, -2602, -2823, -3043, -3263, -3483, -3703, -3924, -4142, -4362, -4582, -4802, -5022, -5242, -5470, -5651, -6152, -7174, -8175, -9180, -10184, -11188, -12193, -13197, -14201, -15205, -16208, -17212, -18216, -19218, -20222, -21225, -22225, -23229, -24232, -25232, -26235, -27236, -28236, -29234, -30235, -31237, -31125, -30475, -29914, -29335, -28757, -28179, -27600, -27021, -26443, -25864, -25286, -24708, -24128, -23551, -22973, -22393, -21817, -21237, -20658, -20081, -19502, -18925, -18348, -17780, -17161, -16831, -17416, -18060, -18687, -19320, -19952, -20584, -21217, -21849, -22481, -23114, -23745, -24377, -25011, -25641, -26273, -26906, -27537, -28168, -28800, -29430, -30062, -30693, -31321, -31931, -32662, -31843, -29655, -27627, -25576, -23517, -21461, -19409, -17352, -15296, -13245, -11188, -9134, -7083, -5030, -2983, -896};