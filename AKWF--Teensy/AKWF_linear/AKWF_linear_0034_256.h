/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0034 256 samples */
 
const int16_t AKWF_linear_0034_256_DATA [256] = 
{1164, 2969, 4739, 6511, 8281, 10072, 11174, 11861, 12605, 13338, 14070, 14802, 15535, 16266, 16997, 17729, 18459, 19190, 19921, 20650, 21380, 22110, 22829, 23600, 24027, 23964, 23932, 23895, 23859, 23822, 23784, 23746, 23709, 23671, 23633, 23596, 23558, 23520, 23482, 23444, 23406, 23365, 23342, 23383, 23431, 23476, 23522, 23569, 23615, 23662, 23707, 23753, 23800, 23846, 23893, 23938, 23985, 24031, 24077, 24122, 24170, 24222, 24277, 24333, 24389, 24443, 24499, 24554, 24609, 24664, 24720, 24775, 24830, 24884, 24940, 24996, 25049, 25095, 25195, 24523, 23103, 21745, 20378, 19011, 17642, 16274, 14909, 13540, 12173, 10808, 9439, 8072, 6708, 5340, 3976, 2607, 1258, -233, -2039, -3865, -5681, -7499, -9320, -11136, -12954, -14774, -16589, -18406, -20225, -22037, -23855, -25671, -27482, -29283, -31149, -32702, -32175, -31124, -30167, -29187, -28209, -27232, -26252, -25274, -24297, -23317, -22339, -21361, -20382, -19404, -18426, -17446, -16467, -15498, -14232, -12781, -11352, -9918, -8489, -7058, -5624, -4195, -2763, -1331, 95, 1526, 2957, 4384, 5815, 7245, 8634, 10230, 10418, 8500, 6688, 4862, 3035, 1203, -625, -2452, -4284, -6112, -7940, -9770, -11597, -13425, -15256, -17081, -18887, -20796, -22191, -21399, -20367, -19395, -18407, -17419, -16432, -15443, -14454, -13468, -12478, -11491, -10504, -9515, -8528, -7541, -6553, -5565, -4582, -3713, -2895, -2070, -1245, -422, 400, 1225, 2048, 2871, 3695, 4517, 5340, 6164, 6985, 7807, 8627, 9425, 10356, 9604, 7131, 4797, 2441, 88, -2271, -4629, -6982, -9341, -11697, -14051, -16409, -18764, -21117, -23474, -25827, -28153, -30617, -32194, -31708, -31112, -30547, -29970, -29393, -28816, -28238, -27661, -27084, -26506, -25927, -25351, -24772, -24193, -23616, -23031, -22473, -21796, -20225, -18412, -16646, -14865, -13087, -11312, -9532, -7755, -5981, -4205, -2435, -629};