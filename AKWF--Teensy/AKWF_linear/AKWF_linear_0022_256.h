/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0022 256 samples */
 
const int16_t AKWF_linear_0022_256_DATA [256] = 
{290, 731, 1162, 1594, 2027, 2457, 2829, 3177, 3531, 3884, 4237, 4589, 4942, 5293, 5645, 5997, 6349, 6700, 7052, 7403, 7755, 8107, 8464, 8787, 9604, 10890, 12135, 13385, 14636, 15889, 17138, 18388, 19640, 20889, 22138, 23390, 24637, 25885, 27136, 28382, 29607, 30958, 31438, 30038, 28566, 27118, 25660, 24200, 22746, 21287, 19828, 18373, 16914, 15455, 14001, 12541, 11085, 9630, 8172, 6718, 5260, 3771, 2278, 787, -706, -2196, -3686, -5179, -6668, -8158, -9650, -11137, -12626, -14117, -15603, -17091, -18575, -20054, -21582, -21230, -19715, -18343, -16945, -15549, -14149, -12751, -11355, -9954, -8556, -7160, -5761, -4363, -2967, -1567, -171, 1218, 2647, 3799, 4556, 5332, 6104, 6875, 7648, 8418, 9190, 9961, 10731, 11502, 12273, 13042, 13812, 14582, 15350, 16121, 16888, 17666, 18498, 19335, 20169, 21004, 21838, 22671, 23507, 24341, 25174, 26008, 26841, 27673, 28507, 29340, 30170, 30998, 31839, 32631, 31858, 30446, 29144, 27820, 26500, 25177, 23853, 22533, 21210, 19886, 18566, 17243, 15921, 14601, 13279, 11957, 10634, 9329, 7753, 5906, 4078, 2249, 423, -1408, -3235, -5061, -6891, -8716, -10542, -12370, -14195, -16021, -17848, -19669, -21476, -23373, -24684, -24662, -24578, -24511, -24438, -24365, -24291, -24217, -24143, -24069, -23994, -23919, -23844, -23769, -23694, -23619, -23544, -23470, -23388, -23254, -23107, -22961, -22815, -22670, -22524, -22378, -22231, -22085, -21940, -21793, -21648, -21502, -21356, -21210, -21063, -20918, -20773, -20519, -20193, -19874, -19552, -19234, -18913, -18591, -18272, -17952, -17631, -17311, -16991, -16670, -16351, -16031, -15711, -15389, -15079, -14684, -14160, -13642, -13124, -12604, -12084, -11566, -11048, -10528, -10011, -9492, -8972, -8455, -7937, -7418, -6901, -6383, -5862, -5358, -4918, -4485, -4051, -3616, -3183, -2750, -2316, -1882, -1450, -1016, -585, -145};