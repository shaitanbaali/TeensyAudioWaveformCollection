/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0005 256 samples */
 
const int16_t AKWF_linear_0005_256_DATA [256] = 
{205, 735, 1253, 1772, 2291, 2810, 3330, 3850, 4373, 4879, 5472, 6679, 8034, 9357, 10690, 12022, 13350, 14683, 16015, 17344, 18676, 20009, 21338, 22671, 24002, 25331, 26663, 27988, 29346, 29934, 30044, 30221, 30387, 30552, 30717, 30883, 31047, 31211, 31377, 31541, 31707, 31872, 32037, 32202, 32367, 32504, 32792, 32032, 29696, 27452, 25194, 22940, 20679, 18421, 16166, 13905, 11647, 9394, 7132, 4874, 2620, 358, -1899, -4139, -6460, -8357, -8586, -8617, -8692, -8758, -8823, -8889, -8955, -9020, -9084, -9150, -9216, -9281, -9346, -9411, -9476, -9541, -9607, -9670, -9676, -9659, -9645, -9630, -9616, -9600, -9586, -9571, -9557, -9542, -9527, -9512, -9497, -9482, -9468, -9453, -9437, -9428, -9322, -9121, -8927, -8731, -8537, -8341, -8145, -7949, -7754, -7559, -7363, -7168, -6973, -6778, -6581, -6387, -6178, -6038, -5456, -3878, -2245, -626, 993, 2617, 4237, 5858, 7483, 9104, 10726, 12349, 13969, 15591, 17216, 18835, 20441, 22114, 23498, 22757, 21469, 20282, 19072, 17862, 16655, 15444, 14233, 13025, 11814, 10605, 9397, 8186, 6977, 5769, 4559, 3354, 2119, 1559, 1443, 1267, 1102, 938, 772, 607, 444, 278, 113, -51, -216, -380, -544, -710, -874, -1038, -1209, -1333, -1383, -1438, -1492, -1545, -1599, -1654, -1707, -1762, -1815, -1869, -1923, -1977, -2031, -2085, -2139, -2198, -2230, -2411, -3245, -4164, -5061, -5963, -6868, -7769, -8672, -9575, -10477, -11380, -12285, -13185, -14088, -14992, -15894, -16793, -17702, -18574, -18399, -17748, -17173, -16584, -15994, -15405, -14816, -14227, -13638, -13048, -12458, -11870, -11279, -10691, -10103, -9512, -8927, -8325, -7915, -7711, -7492, -7275, -7057, -6842, -6624, -6407, -6191, -5974, -5757, -5541, -5324, -5106, -4890, -4672, -4454, -4248, -3952, -3445, -2923, -2403, -1885, -1365, -847, -319};