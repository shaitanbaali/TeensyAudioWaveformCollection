/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0045 256 samples */
 
const int16_t AKWF_linear_0045_256_DATA [256] = 
{850, 2124, 3376, 4576, 5708, 6845, 7984, 9118, 10253, 11391, 12525, 13660, 14796, 15928, 17063, 18197, 19329, 20463, 21597, 22722, 23880, 24853, 25317, 25740, 26171, 26600, 27029, 27457, 27885, 28314, 28740, 29168, 29596, 30024, 30451, 30878, 31304, 31723, 32171, 32496, 31588, 30273, 29029, 27769, 26508, 25251, 23991, 22731, 21474, 20214, 18954, 17697, 16438, 15179, 13923, 12664, 11402, 10167, 8499, 6500, 4536, 2563, 593, -1375, -3347, -5315, -7283, -9254, -11220, -13188, -15158, -17122, -19088, -21057, -23002, -25046, -26478, -26773, -27086, -27399, -27708, -28018, -28327, -28635, -28944, -29252, -29558, -29867, -30174, -30481, -30788, -31095, -31394, -31731, -31890, -30969, -29873, -28819, -27754, -26689, -25626, -24562, -23496, -22433, -21369, -20304, -19241, -18178, -17113, -16052, -14988, -13924, -12863, -11927, -11059, -10182, -9305, -8430, -7556, -6680, -5805, -4933, -4057, -3183, -2310, -1436, -563, 308, 1182, 2055, 2924, 3823, 4756, 5686, 6620, 7547, 8478, 9410, 10338, 11268, 12198, 13127, 14056, 14984, 15912, 16842, 17770, 18694, 19631, 20504, 21189, 21857, 22529, 23199, 23871, 24541, 25210, 25880, 26549, 27218, 27888, 28556, 29224, 29894, 30561, 31223, 31908, 32493, 31938, 30981, 30092, 29188, 28284, 27382, 26477, 25573, 24671, 23767, 22863, 21962, 21057, 20154, 19252, 18347, 17438, 16572, 15032, 12942, 10909, 8861, 6816, 4773, 2726, 683, -1359, -3406, -5446, -7488, -9533, -11571, -13614, -15656, -17679, -19785, -21390, -22022, -22657, -23294, -23927, -24560, -25194, -25824, -26458, -27091, -27721, -28353, -28984, -29614, -30245, -30874, -31496, -32155, -32650, -32048, -31256, -30505, -29745, -28983, -28224, -27463, -26702, -25943, -25182, -24421, -23661, -22901, -22140, -21382, -20620, -19859, -19106, -18014, -16733, -15485, -14227, -12972, -11718, -10461, -9206, -7953, -6697, -5444, -4191, -2938, -1688, -414};