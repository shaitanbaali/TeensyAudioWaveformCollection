/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0083 256 samples */
 
const int16_t AKWF_linear_0083_256_DATA [256] = 
{412, 1352, 2273, 3195, 4118, 5041, 5966, 6886, 7809, 8733, 9652, 10575, 11495, 12421, 13309, 14078, 14837, 15600, 16361, 17120, 17882, 18643, 19402, 20162, 20922, 21680, 22442, 23200, 23958, 24717, 25476, 26233, 26992, 27749, 28507, 29265, 30021, 30777, 31516, 32358, 31941, 30467, 29114, 27738, 26360, 24986, 23609, 22232, 20857, 19480, 18102, 16729, 15353, 13977, 12604, 11227, 9852, 8480, 7104, 5730, 4358, 2983, 1610, 249, -1159, -2364, -2140, -1618, -1155, -678, -201, 275, 752, 1230, 1706, 2184, 2661, 3138, 3616, 4093, 4570, 5048, 5525, 6002, 6479, 6956, 7433, 7911, 8387, 8868, 9325, 9966, 10882, 11788, 12694, 13599, 14507, 15413, 16319, 17225, 18130, 19035, 19942, 20846, 21751, 22656, 23560, 24464, 25370, 26272, 27176, 28081, 28983, 29886, 30784, 31691, 32580, 31705, 30068, 28552, 27014, 25478, 23939, 22402, 20866, 19326, 17790, 16253, 14714, 13179, 11643, 10105, 8571, 7035, 5497, 3965, 2431, 892, -637, -2171, -3698, -5265, -6594, -7241, -7855, -8479, -9100, -9719, -10338, -10958, -11577, -12197, -12815, -13433, -14052, -14670, -15287, -15905, -16522, -17139, -17757, -18372, -18989, -19606, -20221, -20837, -21449, -22087, -22381, -22406, -22463, -22515, -22566, -22616, -22667, -22718, -22768, -22820, -22870, -22920, -22970, -23021, -23071, -23121, -23172, -23221, -23272, -23321, -23371, -23422, -23471, -23521, -23572, -23614, -23593, -23561, -23530, -23499, -23469, -23438, -23407, -23376, -23346, -23315, -23283, -23253, -23222, -23191, -23160, -23130, -23099, -23068, -23037, -23007, -22975, -22945, -22914, -22878, -22870, -22660, -22160, -21678, -21193, -20709, -20223, -19739, -19253, -18769, -18285, -17800, -17315, -16832, -16347, -15863, -15379, -14895, -14411, -13928, -13444, -12960, -12477, -11993, -11509, -11029, -10541, -9727, -8784, -7861, -6936, -6011, -5085, -4161, -3236, -2313, -1391, -451};