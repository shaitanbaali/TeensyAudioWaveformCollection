/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0077 256 samples */
 
const int16_t AKWF_linear_0077_256_DATA [256] = 
{672, 1914, 3130, 4343, 5591, 6589, 7072, 7549, 8027, 8506, 8982, 9460, 9938, 10413, 10890, 11367, 11843, 12318, 12795, 13270, 13746, 14221, 14696, 15171, 15646, 16119, 16596, 17070, 17542, 18013, 18500, 18244, 17519, 16861, 16189, 15517, 14846, 14174, 13502, 12832, 12159, 11487, 10818, 10146, 9473, 8804, 8133, 7461, 6791, 6120, 5449, 4779, 4109, 3438, 2782, 2062, 1697, 2762, 4023, 5237, 6460, 7688, 8912, 10136, 11363, 12587, 13810, 15037, 16260, 17484, 18710, 19932, 21156, 22382, 23602, 24825, 26050, 27270, 28492, 29715, 30922, 32202, 32703, 32349, 32063, 31766, 31469, 31170, 30871, 30574, 30276, 29975, 29677, 29379, 29080, 28781, 28483, 28183, 27884, 27586, 27287, 26988, 26690, 26391, 26092, 25788, 25506, 25123, 23692, 21933, 20231, 18517, 16807, 15094, 13381, 11671, 9958, 8246, 6539, 4826, 3116, 1408, -304, -2012, -3719, -5429, -7136, -8843, -10553, -12257, -13962, -15655, -17426, -18613, -18678, -18738, -18803, -18863, -18925, -18985, -19045, -19106, -19166, -19226, -19285, -19345, -19404, -19463, -19523, -19581, -19640, -19699, -19757, -19816, -19875, -19933, -19990, -20049, -20109, -19868, -19447, -19052, -18652, -18250, -17850, -17450, -17050, -16650, -16249, -15848, -15449, -15049, -14648, -14248, -13848, -13448, -13049, -12649, -12249, -11850, -11451, -11051, -10656, -10242, -9922, -9936, -9990, -10035, -10083, -10130, -10178, -10225, -10273, -10320, -10369, -10416, -10463, -10512, -10559, -10607, -10655, -10703, -10751, -10798, -10846, -10894, -10942, -10990, -11042, -11073, -11360, -11914, -12447, -12984, -13520, -14056, -14592, -15127, -15663, -16199, -16734, -17270, -17806, -18341, -18877, -19411, -19947, -20482, -21017, -21551, -22086, -22620, -23155, -23681, -24238, -24647, -23755, -22477, -21267, -20042, -18821, -17596, -16372, -15151, -13925, -12702, -11481, -10257, -9034, -7813, -6590, -5368, -4148, -2927, -1710, -468};