/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0084 256 samples */
 
const int16_t AKWF_linear_0084_256_DATA [256] = 
{185, 752, 1307, 1862, 2418, 2975, 3531, 4087, 4642, 5198, 5753, 6308, 6866, 7413, 8009, 8776, 9559, 10340, 11124, 11903, 12685, 13467, 14247, 15028, 15809, 16589, 17369, 18150, 18929, 19710, 20489, 21267, 22048, 22826, 23604, 24384, 25161, 25939, 26712, 27514, 27973, 28091, 28235, 28375, 28513, 28652, 28791, 28930, 29068, 29206, 29345, 29482, 29620, 29759, 29896, 30035, 30172, 30310, 30448, 30585, 30722, 30860, 30997, 31130, 31282, 31351, 30676, 29789, 28942, 28086, 27230, 26376, 25520, 24663, 23809, 22953, 22098, 21245, 20390, 19534, 18681, 17826, 16971, 16119, 15264, 14410, 13558, 12704, 11850, 11007, 10119, 9527, 9449, 9368, 9286, 9205, 9126, 9045, 8965, 8885, 8806, 8726, 8646, 8567, 8488, 8407, 8329, 8249, 8171, 8091, 8012, 7932, 7854, 7775, 7695, 7616, 7539, 7217, 6766, 6331, 5895, 5458, 5021, 4584, 4147, 3711, 3275, 2838, 2401, 1965, 1529, 1092, 657, 222, -214, -649, -1085, -1521, -1956, -2391, -2833, -3243, -3814, -4913, -6060, -7199, -8340, -9479, -10619, -11760, -12899, -14040, -15179, -16316, -17457, -18596, -19733, -20872, -22009, -23146, -24286, -25421, -26557, -27696, -28831, -29965, -31093, -32275, -32791, -32685, -32635, -32574, -32513, -32451, -32390, -32328, -32266, -32204, -32142, -32080, -32018, -31956, -31893, -31831, -31768, -31706, -31643, -31580, -31517, -31455, -31393, -31326, -31275, -31155, -30464, -29626, -28816, -28001, -27184, -26369, -25553, -24736, -23922, -23106, -22289, -21475, -20661, -19845, -19032, -18215, -17400, -16588, -15773, -14959, -14147, -13332, -12518, -11712, -10868, -10286, -10136, -9976, -9816, -9658, -9500, -9343, -9186, -9027, -8870, -8713, -8555, -8398, -8242, -8085, -7928, -7771, -7614, -7458, -7301, -7144, -6987, -6831, -6675, -6518, -6362, -5927, -5353, -4799, -4241, -3685, -3127, -2569, -2013, -1456, -901, -333};