/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0042 256 samples */
 
const int16_t AKWF_linear_0042_256_DATA [256] = 
{992, 2579, 4134, 5693, 7255, 8790, 10150, 11461, 12782, 14104, 15420, 16739, 18058, 19373, 20692, 22010, 23324, 24641, 25958, 27272, 28588, 29899, 31208, 32549, 32104, 30547, 29125, 27679, 26235, 24786, 23341, 21895, 20447, 19003, 17557, 16109, 14665, 13219, 11772, 10328, 8883, 7438, 5981, 4501, 3021, 1544, 66, -1413, -2888, -4367, -5845, -7319, -8797, -10273, -11748, -13225, -14699, -16172, -17623, -19195, -20154, -18734, -17072, -15465, -13840, -12219, -10598, -8973, -7352, -5731, -4105, -2487, -863, 759, 2377, 4000, 5617, 7242, 8839, 8942, 8462, 8088, 7694, 7299, 6905, 6511, 6116, 5720, 5325, 4931, 4535, 4140, 3746, 3350, 2955, 2561, 2161, 1833, 1577, 1314, 1052, 790, 527, 266, 5, -257, -518, -780, -1041, -1302, -1564, -1826, -2086, -2340, -2638, -2629, -1908, -1159, -420, 323, 1065, 1807, 2551, 3294, 4035, 4779, 5521, 6263, 7007, 7748, 8490, 9230, 9981, 10668, 10912, 11035, 11182, 11324, 11464, 11606, 11747, 11888, 12029, 12170, 12311, 12452, 12593, 12733, 12874, 13013, 13154, 13299, 13203, 12948, 12712, 12473, 12234, 11995, 11755, 11516, 11276, 11037, 10799, 10558, 10320, 10080, 9840, 9602, 9351, 9162, 8496, 7119, 5760, 4404, 3042, 1680, 323, -1037, -2398, -3756, -5116, -6476, -7833, -9194, -10552, -11907, -13258, -14652, -15813, -16029, -16127, -16251, -16368, -16485, -16602, -16720, -16836, -16952, -17069, -17185, -17301, -17417, -17532, -17649, -17764, -17879, -17994, -17934, -17801, -17681, -17559, -17436, -17315, -17193, -17070, -16947, -16825, -16703, -16580, -16458, -16335, -16212, -16091, -15971, -15835, -15876, -16103, -16313, -16525, -16738, -16950, -17164, -17376, -17589, -17801, -18013, -18226, -18439, -18650, -18863, -19075, -19272, -19548, -19310, -17795, -16219, -14664, -13099, -11537, -9977, -8412, -6850, -5290, -3728, -2172, -584};