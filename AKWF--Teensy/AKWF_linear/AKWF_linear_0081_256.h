/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0081 256 samples */
 
const int16_t AKWF_linear_0081_256_DATA [256] = 
{659, 2832, 4961, 7095, 9227, 11360, 13497, 15627, 17744, 19940, 21678, 22012, 22230, 22474, 22711, 22948, 23184, 23421, 23658, 23892, 24128, 24362, 24597, 24832, 25067, 25300, 25535, 25770, 26003, 26237, 26471, 26704, 26938, 27170, 27398, 27656, 27467, 26875, 26324, 25765, 25208, 24650, 24092, 23533, 22975, 22417, 21859, 21301, 20744, 20184, 19628, 19071, 18512, 17956, 17399, 16840, 16283, 15727, 15169, 14618, 14044, 13588, 13981, 14578, 15135, 15700, 16264, 16831, 17395, 17960, 18526, 19091, 19655, 20220, 20785, 21350, 21915, 22478, 23043, 23608, 24172, 24737, 25301, 25864, 26428, 26974, 27614, 27513, 26252, 25031, 23804, 22576, 21349, 20119, 18892, 17664, 16434, 15208, 13981, 12753, 11526, 10298, 9071, 7846, 6618, 5391, 4168, 2942, 1714, 492, -728, -1958, -3163, -3436, -3260, -3155, -3038, -2917, -2799, -2679, -2560, -2442, -2322, -2202, -2083, -1962, -1843, -1723, -1603, -1484, -1363, -1244, -1124, -1004, -884, -764, -647, -516, -470, -668, -886, -1097, -1310, -1523, -1736, -1951, -2165, -2377, -2590, -2803, -3016, -3229, -3442, -3655, -3869, -4081, -4294, -4508, -4720, -4932, -5145, -5359, -5576, -5766, -6416, -7459, -8460, -9466, -10475, -11484, -12490, -13498, -14507, -15512, -16520, -17528, -18532, -19539, -20545, -21549, -22556, -23563, -24566, -25572, -26577, -27580, -28585, -29581, -30614, -31452, -31090, -30455, -29875, -29285, -28692, -28099, -27508, -26916, -26322, -25733, -25141, -24547, -23957, -23363, -22771, -22180, -21589, -20997, -20406, -19814, -19222, -18631, -18040, -17461, -16820, -16708, -17376, -18015, -18659, -19302, -19944, -20590, -21235, -21879, -22523, -23166, -23811, -24456, -25098, -25741, -26386, -27029, -27673, -28316, -28957, -29602, -30246, -30887, -31521, -32176, -32758, -31388, -29134, -27024, -24882, -22742, -20607, -18464, -16326, -14190, -12049, -9911, -7776, -5640, -3509, -1336};