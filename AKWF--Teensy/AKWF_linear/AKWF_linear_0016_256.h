/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0016 256 samples */
 
const int16_t AKWF_linear_0016_256_DATA [256] = 
{828, 2201, 3545, 4891, 6251, 7304, 8150, 9021, 9888, 10758, 11624, 12490, 13358, 14222, 15089, 15955, 16819, 17685, 18551, 19414, 20280, 21125, 22071, 22232, 21124, 20054, 18978, 17902, 16826, 15748, 14670, 13595, 12517, 11440, 10365, 9286, 8212, 7135, 6058, 4996, 3869, 3105, 3835, 4799, 5713, 6637, 7563, 8488, 9412, 10338, 11264, 12187, 13113, 14039, 14961, 15888, 16812, 17731, 18664, 19554, 19374, 18694, 18090, 17471, 16850, 16232, 15613, 14992, 14373, 13754, 13134, 12515, 11896, 11276, 10657, 10037, 9404, 8850, 7433, 5110, 2855, 584, -1686, -3952, -6224, -8494, -10757, -13028, -15296, -17559, -19829, -22095, -24358, -26627, -28844, -31299, -32364, -29924, -27300, -24716, -22125, -19529, -16930, -14339, -11743, -9144, -6553, -3958, -1362, 1229, 3824, 6420, 8993, 11633, 14025, 13794, 12866, 12070, 11250, 10425, 9602, 8779, 7956, 7131, 6308, 5483, 4661, 3837, 3013, 2190, 1367, 546, -294, -818, -1116, -1445, -1769, -2094, -2416, -2739, -3063, -3386, -3709, -4033, -4356, -4677, -5001, -5324, -5647, -5956, -6334, -6219, -5256, -4316, -3374, -2430, -1488, -543, 400, 1341, 2286, 3229, 4171, 5115, 6056, 6999, 7943, 8867, 9870, 10458, 9198, 7625, 6118, 4598, 3076, 1554, 36, -1486, -3008, -4525, -6048, -7568, -9086, -10607, -12128, -13639, -15167, -16650, -16626, -15854, -15191, -14509, -13822, -13139, -12454, -11770, -11087, -10402, -9717, -9034, -8350, -7665, -6981, -6297, -5620, -4907, -4576, -4676, -4749, -4826, -4902, -4978, -5055, -5133, -5210, -5287, -5365, -5442, -5520, -5596, -5674, -5751, -5833, -5889, -6102, -6735, -7394, -8049, -8704, -9359, -10015, -10671, -11326, -11982, -12636, -13291, -13948, -14601, -15256, -15911, -16555, -17234, -17781, -16807, -15393, -14058, -12708, -11356, -10004, -8655, -7303, -5952, -4604, -3255, -1909, -536};