/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0085 256 samples */
 
const int16_t AKWF_linear_0085_256_DATA [256] = 
{635, 2000, 3338, 4675, 6032, 7243, 8147, 9044, 9945, 10845, 11742, 12640, 13539, 14435, 15333, 16232, 17127, 18024, 18922, 19817, 20713, 21610, 22503, 23399, 24295, 25188, 26082, 26977, 27868, 28761, 29664, 30061, 30138, 30258, 30370, 30483, 30595, 30706, 30819, 30929, 31041, 31153, 31263, 31374, 31485, 31596, 31707, 31817, 31928, 32039, 32149, 32261, 32370, 32481, 32579, 32738, 32553, 30976, 29207, 27483, 25750, 24013, 22279, 20547, 18810, 17078, 15345, 13609, 11878, 10146, 8411, 6683, 4951, 3216, 1488, -241, -1974, -3700, -5431, -7160, -8876, -10649, -11839, -12377, -12969, -13552, -14134, -14716, -15297, -15877, -16459, -17038, -17618, -18199, -18778, -19357, -19937, -20515, -21093, -21673, -22251, -22828, -23407, -23984, -24562, -25134, -25725, -26230, -25793, -25059, -24379, -23686, -22996, -22304, -21612, -20922, -20230, -19538, -18848, -18156, -17464, -16774, -16082, -15392, -14702, -14010, -13320, -12630, -11939, -11250, -10560, -9865, -9192, -8376, -7281, -6187, -5093, -3998, -2905, -1812, -717, 374, 1467, 2562, 3652, 4746, 5839, 6929, 8022, 9114, 10203, 11295, 12386, 13475, 14565, 15656, 16742, 17831, 18927, 19154, 18861, 18641, 18407, 18173, 17938, 17703, 17469, 17234, 17000, 16764, 16530, 16294, 16060, 15825, 15589, 15354, 15120, 14885, 14649, 14414, 14179, 13944, 13699, 13504, 13025, 11506, 9854, 8234, 6608, 4979, 3353, 1727, 98, -1525, -3150, -4779, -6403, -8028, -9654, -11277, -12902, -14528, -16149, -17772, -19396, -21016, -22640, -24262, -25868, -27548, -28360, -28262, -28241, -28208, -28173, -28138, -28101, -28066, -28031, -27995, -27958, -27921, -27885, -27848, -27811, -27775, -27738, -27701, -27664, -27627, -27590, -27553, -27515, -27472, -27453, -27324, -26225, -24838, -23501, -22153, -20809, -19462, -18115, -16771, -15424, -14078, -12735, -11388, -10042, -8700, -7354, -6010, -4667, -3324, -1986, -620};