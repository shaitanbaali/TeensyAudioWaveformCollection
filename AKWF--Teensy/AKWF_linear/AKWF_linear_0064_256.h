/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0064 256 samples */
 
const int16_t AKWF_linear_0064_256_DATA [256] = 
{391, 1812, 3418, 5148, 6858, 8573, 10290, 12003, 13717, 15434, 17143, 18858, 20565, 22299, 23887, 24269, 24307, 24410, 24500, 24588, 24678, 24766, 24853, 24942, 25030, 25096, 25272, 24791, 22122, 19210, 16358, 13494, 10623, 7760, 4895, 2024, -837, -3701, -6559, -9467, -11928, -13611, -15297, -16987, -18675, -20358, -22046, -23732, -25414, -27100, -28782, -30441, -32226, -32320, -30774, -29373, -27949, -26527, -25099, -23672, -22248, -20820, -19394, -17969, -16541, -15115, -13425, -11589, -9779, -7963, -6146, -4333, -2517, -701, 1111, 2926, 4737, 6563, 8297, 9315, 10132, 10989, 11838, 12684, 13533, 14381, 15226, 16074, 16921, 17757, 18637, 19274, 19149, 18945, 18759, 18569, 18379, 18188, 17998, 17806, 17615, 17424, 17222, 17072, 16539, 15366, 14206, 13045, 11880, 10719, 9555, 8391, 7230, 6066, 4904, 3744, 2574, 1538, 627, -298, -1219, -2138, -3060, -3980, -4900, -5821, -6740, -7656, -8578, -9488, -9724, -9605, -9538, -9461, -9384, -9307, -9230, -9152, -9075, -8997, -8916, -8850, -8713, -8087, -7331, -6599, -5862, -5126, -4387, -3650, -2916, -2179, -1441, -713, 56, 579, 355, 57, -223, -507, -792, -1078, -1363, -1649, -1934, -2218, -2507, -2782, -3159, -3703, -4243, -4783, -5325, -5864, -6405, -6946, -7485, -8026, -8566, -9097, -9677, -9515, -8675, -7900, -7113, -6327, -5538, -4752, -3965, -3178, -2391, -1602, -817, -24, 1188, 2615, 4008, 5408, 6809, 8206, 9606, 11007, 12403, 13802, 15190, 16625, 17816, 17372, 16508, 15723, 14921, 14120, 13316, 12514, 11714, 10911, 10109, 9297, 8536, 7454, 5422, 3300, 1202, -901, -3008, -5110, -7212, -9319, -11420, -13522, -15606, -17801, -19030, -18737, -18472, -18208, -17938, -17669, -17398, -17128, -16859, -16589, -16317, -16040, -15801, -14925, -13485, -12098, -10701, -9307, -7908, -6512, -5118, -3723, -2331, -911};