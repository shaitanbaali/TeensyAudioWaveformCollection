/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0008 256 samples */
 
const int16_t AKWF_linear_0008_256_DATA [256] = 
{372, 915, 1448, 1986, 2503, 3123, 4189, 5329, 6456, 7588, 8715, 9845, 10976, 12104, 13235, 14366, 15494, 16625, 17755, 18884, 20014, 21143, 22273, 23402, 24085, 24555, 25058, 25555, 26051, 26548, 27044, 27541, 28037, 28533, 29029, 29527, 30023, 30519, 31016, 31512, 32000, 32537, 32678, 32365, 32093, 31815, 31536, 31257, 30978, 30699, 30421, 30142, 29862, 29582, 29305, 29026, 28747, 28467, 28192, 27899, 27702, 27791, 27894, 27993, 28092, 28192, 28292, 28392, 28492, 28592, 28692, 28791, 28891, 28992, 29091, 29191, 29289, 29393, 29471, 29240, 28912, 28601, 28288, 27974, 27661, 27347, 27035, 26720, 26407, 26094, 25779, 25467, 25153, 24839, 24525, 24212, 23903, 23444, 22868, 22302, 21736, 21169, 20601, 20036, 19469, 18901, 18335, 17768, 17200, 16635, 16067, 15500, 14934, 14362, 13818, 13051, 11883, 10712, 9545, 8373, 7204, 6036, 4864, 3696, 2527, 1355, 187, -982, -2154, -3321, -4490, -5662, -6832, -7992, -9106, -10209, -11315, -12421, -13525, -14630, -15737, -16839, -17946, -19051, -20156, -21261, -22367, -23470, -24577, -25680, -26785, -27891, -28236, -28195, -28209, -28213, -28216, -28219, -28224, -28227, -28231, -28235, -28238, -28242, -28246, -28250, -28253, -28256, -28261, -28261, -28301, -28390, -28474, -28559, -28644, -28729, -28815, -28899, -28985, -29070, -29155, -29241, -29326, -29411, -29496, -29581, -29665, -29755, -29815, -29778, -29736, -29697, -29657, -29616, -29576, -29535, -29495, -29455, -29415, -29374, -29333, -29292, -29253, -29213, -29170, -29133, -29078, -28790, -28425, -28074, -27720, -27366, -27012, -26658, -26305, -25950, -25595, -25242, -24888, -24534, -24180, -23826, -23471, -23116, -22774, -22135, -21244, -20381, -19512, -18645, -17776, -16908, -16039, -15169, -14304, -13435, -12565, -11699, -10829, -9961, -9095, -8227, -7345, -6586, -6049, -5514, -4980, -4446, -3912, -3378, -2844, -2309, -1776, -1242, -710, -167};