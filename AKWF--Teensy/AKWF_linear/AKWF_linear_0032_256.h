/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0032 256 samples */
 
const int16_t AKWF_linear_0032_256_DATA [256] = 
{802, 2388, 3942, 5497, 7063, 8560, 9877, 11184, 12495, 13807, 15114, 16423, 17732, 19037, 20346, 21655, 22960, 24267, 25575, 26879, 28185, 29484, 30808, 32000, 31986, 31634, 31347, 31047, 30747, 30447, 30147, 29846, 29545, 29244, 28944, 28643, 28342, 28041, 27739, 27437, 27131, 26849, 25893, 24447, 23061, 21666, 20267, 18871, 17477, 16080, 14683, 13289, 11893, 10498, 9105, 7709, 6313, 4921, 3550, 2055, 1559, 2672, 3768, 4861, 5960, 7058, 8156, 9256, 10354, 11452, 12551, 13649, 14747, 15846, 16942, 18041, 19125, 20277, 21067, 20365, 19422, 18526, 17619, 16712, 15804, 14897, 13991, 13083, 12176, 11271, 10363, 9455, 8549, 7643, 6736, 5832, 4915, 3465, 1767, 103, -1564, -3232, -4902, -6568, -8236, -9906, -11570, -13237, -14905, -16570, -18237, -19903, -21566, -23188, -25046, -24808, -22294, -19976, -17629, -15273, -12921, -10571, -8216, -5863, -3514, -1160, 1189, 3539, 5894, 8243, 10592, 12926, 15352, 17253, 17663, 18021, 18396, 18766, 19134, 19502, 19871, 20238, 20605, 20973, 21340, 21706, 22074, 22439, 22806, 23159, 23559, 23757, 21859, 19346, 16948, 14529, 12112, 9690, 7272, 4854, 2433, 17, -2400, -4820, -7233, -9650, -12070, -14478, -16884, -19354, -20298, -20084, -20006, -19903, -19799, -19695, -19591, -19487, -19382, -19278, -19173, -19067, -18962, -18856, -18751, -18644, -18539, -18430, -18356, -18341, -18326, -18311, -18296, -18281, -18266, -18252, -18235, -18221, -18206, -18190, -18175, -18160, -18144, -18130, -18120, -18083, -18186, -18903, -19727, -20532, -21342, -22150, -22959, -23769, -24576, -25386, -26194, -27002, -27810, -28619, -29426, -30234, -31038, -31848, -32643, -32404, -31654, -30976, -30286, -29594, -28902, -28212, -27520, -26828, -26139, -25448, -24755, -24065, -23374, -22683, -21993, -21292, -20642, -19554, -17959, -16402, -14844, -13279, -11716, -10158, -8594, -7033, -5474, -3915, -2359, -772};