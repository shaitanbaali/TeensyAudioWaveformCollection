/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0060 256 samples */
 
const int16_t AKWF_linear_0060_256_DATA [256] = 
{353, 954, 1539, 2128, 2718, 3305, 3895, 4484, 5071, 5659, 6248, 6836, 7423, 8012, 8599, 9186, 9773, 10361, 10948, 11534, 12122, 12708, 13294, 13880, 14466, 15052, 15638, 16224, 16809, 17394, 17979, 18564, 19150, 19733, 20319, 20903, 21486, 22064, 22678, 22987, 22969, 22984, 22993, 23002, 23011, 23020, 23030, 23038, 23046, 23055, 23064, 23071, 23081, 23090, 23097, 23106, 23114, 23122, 23130, 23138, 23146, 23155, 23162, 23171, 23179, 23187, 23194, 23203, 23211, 23220, 23227, 23236, 23243, 23252, 23260, 23267, 23276, 23283, 23291, 23300, 23306, 23316, 23323, 23331, 23339, 23346, 23355, 23362, 23358, 23419, 23082, 21964, 20865, 19763, 18662, 17560, 16457, 15356, 14255, 13153, 12054, 10952, 9848, 8750, 7649, 6548, 5450, 4349, 3248, 2150, 1050, -49, -1146, -2244, -3343, -4439, -5539, -6635, -7730, -8828, -9925, -11021, -12118, -13213, -14308, -15404, -16498, -17592, -18688, -19781, -20873, -21968, -23060, -24153, -25246, -26337, -27430, -28523, -29612, -30691, -31831, -32653, -32237, -31700, -31192, -30677, -30160, -29646, -29129, -28614, -28098, -27582, -27066, -26551, -26035, -25519, -25004, -24487, -23971, -23457, -22940, -22425, -21910, -21394, -20879, -20364, -19848, -19334, -18819, -18304, -17789, -17275, -16760, -16246, -15732, -15217, -14704, -14190, -13676, -13163, -12649, -12135, -11623, -11109, -10596, -10084, -9571, -9058, -8547, -8034, -7524, -7006, -6525, -6443, -6473, -6482, -6493, -6506, -6520, -6530, -6542, -6556, -6569, -6582, -6595, -6608, -6621, -6633, -6646, -6659, -6672, -6685, -6697, -6711, -6724, -6737, -6750, -6763, -6776, -6790, -6803, -6817, -6831, -6844, -6857, -6869, -6883, -6896, -6910, -6922, -6936, -6949, -6962, -6975, -6989, -7002, -7015, -7028, -7040, -7053, -7067, -7078, -7090, -7111, -6715, -6095, -5514, -4922, -4332, -3743, -3152, -2562, -1974, -1384, -796, -197};