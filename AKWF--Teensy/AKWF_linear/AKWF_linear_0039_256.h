/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0039 256 samples */
 
const int16_t AKWF_linear_0039_256_DATA [256] = 
{677, 1671, 2602, 3105, 3466, 3851, 4232, 4612, 4993, 5374, 5754, 6134, 6514, 6893, 7272, 7653, 8032, 8411, 8791, 9171, 9539, 10204, 11103, 11980, 12860, 13737, 14619, 15498, 16376, 17256, 18135, 19012, 19892, 20769, 21647, 22526, 23402, 24268, 25193, 25700, 25470, 25235, 25004, 24770, 24536, 24302, 24068, 23833, 23600, 23365, 23130, 22897, 22663, 22427, 22193, 21948, 21752, 21320, 19700, 17868, 16079, 14276, 12477, 10678, 8875, 7078, 5279, 3478, 1682, -115, -1915, -3710, -5508, -7304, -9096, -10901, -11917, -12530, -13205, -13871, -14532, -15196, -15860, -16520, -17184, -17845, -18506, -19168, -19829, -20489, -21151, -21810, -22462, -23161, -23487, -23349, -23251, -23146, -23043, -22937, -22832, -22727, -22621, -22516, -22411, -22305, -22199, -22093, -21988, -21882, -21771, -21688, -21441, -20681, -19883, -19097, -18305, -17516, -16725, -15935, -15144, -14356, -13565, -12775, -11987, -11196, -10408, -9620, -8826, -8045, -7220, -5845, -4284, -2757, -1220, 312, 1846, 3381, 4913, 6447, 7982, 9511, 11045, 12579, 14108, 15640, 17170, 18692, 20258, 21031, 21140, 21316, 21481, 21644, 21806, 21970, 22132, 22295, 22457, 22619, 22781, 22943, 23104, 23265, 23427, 23583, 23771, 23715, 23196, 22668, 22146, 21619, 21095, 20570, 20045, 19520, 18996, 18470, 17945, 17420, 16895, 16371, 15846, 15318, 14808, 14207, 13108, 11910, 10733, 9549, 8367, 7187, 6004, 4824, 3643, 2460, 1280, 101, -1080, -2259, -3438, -4620, -5797, -6974, -8300, -9702, -11093, -12489, -13879, -15274, -16668, -18058, -19450, -20843, -22232, -23625, -25015, -26404, -27796, -29185, -30544, -32060, -32452, -31384, -30433, -29465, -28494, -27522, -26553, -25581, -24609, -23639, -22668, -21695, -20726, -19754, -18782, -17814, -16843, -15871, -14902, -13927, -12953, -11981, -11006, -10033, -9061, -8088, -7115, -6144, -5169, -4198, -3228, -2256, -1289, -300};