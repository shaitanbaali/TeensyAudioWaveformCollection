/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0033 256 samples */
 
const int16_t AKWF_linear_0033_256_DATA [256] = 
{578, 2136, 3662, 5189, 6715, 8255, 9552, 10659, 11789, 12915, 14037, 15161, 16286, 17407, 18532, 19655, 20776, 21899, 23020, 24141, 25264, 26385, 27491, 28664, 29411, 29408, 29414, 29419, 29422, 29426, 29428, 29431, 29434, 29436, 29437, 29440, 29442, 29444, 29446, 29447, 29449, 29453, 29447, 29396, 29338, 29280, 29223, 29166, 29109, 29052, 28995, 28937, 28879, 28822, 28764, 28708, 28650, 28592, 28535, 28479, 28419, 28507, 28669, 28819, 28971, 29123, 29275, 29427, 29579, 29731, 29884, 30035, 30187, 30339, 30491, 30643, 30794, 30932, 31149, 30599, 29112, 27687, 26253, 24822, 23386, 21952, 20521, 19086, 17653, 16222, 14787, 13355, 11924, 10490, 9059, 7624, 6213, 4642, 2600, 514, -1556, -3630, -5708, -7779, -9853, -11929, -13999, -16073, -18146, -20215, -22287, -24360, -26426, -28486, -30588, -32490, -32323, -31444, -30685, -29900, -29115, -28331, -27545, -26761, -25976, -25190, -24406, -23621, -22834, -22050, -21265, -20477, -19692, -18915, -17960, -16865, -15783, -14698, -13615, -12531, -11446, -10363, -9279, -8195, -7114, -6030, -4946, -3866, -2782, -1701, -647, 547, 815, -623, -2072, -3511, -4954, -6403, -7847, -9292, -10739, -12184, -13629, -15076, -16518, -17964, -19410, -20852, -22283, -23776, -24991, -24626, -23983, -23396, -22796, -22195, -21596, -20995, -20394, -19795, -19194, -18593, -17994, -17392, -16792, -16194, -15592, -14991, -14399, -13544, -12555, -11589, -10616, -9647, -8676, -7704, -6735, -5766, -4794, -3825, -2856, -1885, -918, 51, 1020, 1961, 3046, 2891, 1129, -523, -2194, -3861, -5535, -7206, -8875, -10547, -12217, -13885, -15558, -17228, -18895, -20566, -22235, -23886, -25623, -26862, -26553, -26095, -25674, -25243, -24811, -24381, -23950, -23518, -23087, -22654, -22222, -21791, -21359, -20928, -20496, -20059, -19638, -19153, -17871, -16298, -14776, -13243, -11710, -10179, -8644, -7112, -5582, -4051, -2524, -967};