/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0007 256 samples */
 
const int16_t AKWF_linear_0007_256_DATA [256] = 
{626, 1601, 2557, 3517, 4476, 5433, 6394, 7355, 8304, 9339, 10585, 11846, 13106, 14363, 15622, 16884, 18140, 19400, 20660, 21918, 23178, 24437, 25694, 26956, 28214, 29466, 30744, 31919, 32122, 32060, 32045, 32021, 31995, 31971, 31946, 31922, 31898, 31873, 31848, 31824, 31799, 31775, 31751, 31726, 31700, 31680, 31574, 31407, 31248, 31089, 30930, 30770, 30610, 30449, 30290, 30130, 29970, 29810, 29651, 29490, 29330, 29171, 29013, 28842, 28760, 28832, 28898, 28965, 29031, 29098, 29165, 29232, 29298, 29366, 29432, 29498, 29566, 29632, 29699, 29766, 29830, 29909, 29898, 29465, 28963, 28476, 27986, 27496, 27006, 26516, 26025, 25535, 25046, 24555, 24065, 23576, 23085, 22595, 22105, 21614, 21122, 20478, 19756, 19049, 18339, 17628, 16919, 16208, 15497, 14787, 14077, 13366, 12656, 11946, 11235, 10526, 9814, 9103, 8397, 7648, 6854, 6065, 5273, 4482, 3692, 2900, 2109, 1319, 526, -263, -1054, -1845, -2635, -3427, -4218, -5012, -5788, -6682, -7882, -9107, -10328, -11547, -12770, -13992, -15209, -16432, -17654, -18873, -20095, -21316, -22535, -23757, -24978, -26193, -27430, -28590, -29000, -29189, -29414, -29632, -29851, -30069, -30287, -30506, -30724, -30943, -31160, -31377, -31597, -31816, -32035, -32252, -32466, -32700, -32666, -32432, -32222, -32009, -31795, -31582, -31369, -31154, -30941, -30727, -30514, -30301, -30086, -29873, -29659, -29446, -29235, -29010, -28878, -28920, -28955, -28992, -29029, -29066, -29103, -29141, -29177, -29214, -29251, -29288, -29325, -29362, -29399, -29436, -29471, -29515, -29510, -29248, -28942, -28646, -28347, -28049, -27750, -27452, -27153, -26855, -26558, -26259, -25961, -25662, -25363, -25065, -24765, -24467, -24164, -23484, -22605, -21756, -20901, -20045, -19192, -18336, -17479, -16626, -15770, -14914, -14060, -13206, -12349, -11495, -10639, -9784, -8933, -8031, -7068, -6111, -5151, -4191, -3233, -2274, -1318, -342};