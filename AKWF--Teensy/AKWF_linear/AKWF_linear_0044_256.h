/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0044 256 samples */
 
const int16_t AKWF_linear_0044_256_DATA [256] = 
{755, 2236, 3687, 5140, 6596, 8034, 9306, 10524, 11752, 12981, 14207, 15433, 16660, 17884, 19109, 20336, 21558, 22783, 24008, 25229, 26453, 27673, 28888, 30146, 30075, 29059, 28146, 27216, 26287, 25354, 24424, 23494, 22561, 21631, 20700, 19768, 18838, 17907, 16975, 16046, 15127, 14144, 13642, 13903, 14155, 14405, 14658, 14910, 15163, 15416, 15669, 15922, 16175, 16428, 16682, 16935, 17187, 17440, 17690, 17956, 18136, 17936, 17680, 17435, 17187, 16940, 16693, 16445, 16198, 15951, 15703, 15456, 15209, 14961, 14714, 14467, 14216, 13971, 13725, 12335, 10437, 8620, 6789, 4963, 3132, 1301, -524, -2356, -4185, -6010, -7841, -9668, -11493, -13323, -15147, -16943, -18904, -19397, -18253, -17262, -16248, -15230, -14211, -13194, -12177, -11157, -10141, -9122, -8103, -7088, -6069, -5051, -4035, -3025, -1971, -1193, -1152, -1155, -1145, -1140, -1134, -1129, -1124, -1120, -1114, -1109, -1104, -1099, -1094, -1089, -1085, -1079, -1075, -1070, -1062, -1055, -1048, -1040, -1032, -1024, -1017, -1009, -1001, -994, -986, -977, -971, -962, -955, -945, -931, -954, -60, 1521, 3030, 4550, 6070, 7592, 9112, 10631, 12153, 13672, 15190, 16712, 18230, 19748, 21269, 22786, 24271, 25929, 26315, 24567, 22825, 21092, 19349, 17606, 15867, 14123, 12380, 10642, 8898, 7156, 5417, 3674, 1933, 195, -1545, -3291, -4998, -6546, -8064, -9587, -11112, -12633, -14153, -15678, -17198, -18718, -20240, -21758, -23277, -24798, -26315, -27834, -29351, -30866, -32389, -32803, -32687, -32655, -32606, -32557, -32508, -32459, -32410, -32360, -32310, -32261, -32212, -32161, -32110, -32059, -32010, -31952, -31935, -31576, -30811, -30082, -29350, -28616, -27881, -27148, -26414, -25680, -24947, -24214, -23480, -22746, -22013, -21280, -20548, -19808, -19100, -18209, -16777, -15311, -13857, -12395, -10935, -9480, -8021, -6563, -5108, -3649, -2197, -715};