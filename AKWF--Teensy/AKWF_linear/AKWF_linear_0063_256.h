/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0063 256 samples */
 
const int16_t AKWF_linear_0063_256_DATA [256] = 
{535, 1661, 2765, 3871, 4978, 6087, 7194, 8298, 9404, 10510, 11613, 12718, 13826, 14931, 16035, 17139, 18240, 19344, 20447, 21548, 22651, 23753, 24856, 25960, 27060, 28159, 29261, 30357, 31455, 32564, 32579, 31935, 31374, 30801, 30227, 29652, 29078, 28503, 27928, 27354, 26779, 26201, 25625, 25050, 24475, 23901, 23326, 22751, 22177, 21603, 21028, 20453, 19875, 19301, 18729, 18154, 17579, 17007, 16433, 15860, 15288, 14711, 14137, 13564, 12991, 12419, 11847, 11274, 10703, 10130, 9558, 8985, 8411, 7840, 7269, 6697, 6127, 5557, 4986, 4418, 3837, 3406, 3138, 2857, 2578, 2299, 2021, 1744, 1464, 1187, 909, 632, 354, 76, -200, -477, -756, -1032, -1309, -1587, -1863, -2140, -2416, -2693, -2970, -3246, -3524, -3801, -4076, -4352, -4628, -4905, -5180, -5455, -5732, -6008, -6283, -6560, -6834, -7110, -7385, -7659, -7936, -8211, -8485, -8761, -9036, -9310, -9586, -9860, -10130, -10423, -10552, -10388, -10219, -10056, -9889, -9722, -9557, -9389, -9225, -9056, -8891, -8726, -8558, -8392, -8223, -8060, -7893, -7726, -7560, -7393, -7229, -7061, -6895, -6730, -6563, -6397, -6230, -6066, -5899, -5733, -5569, -5401, -5237, -5069, -4905, -4739, -4572, -4408, -4240, -4077, -3910, -3746, -3580, -3413, -3250, -3083, -2919, -2754, -2587, -2429, -2244, -2190, -2572, -3004, -3426, -3847, -4271, -4697, -5122, -5544, -5966, -6391, -6815, -7240, -7660, -8085, -8509, -8933, -9355, -9777, -10201, -10624, -11049, -11469, -11891, -12315, -12739, -13160, -13581, -14003, -14427, -14850, -15268, -15690, -16113, -16535, -16957, -17376, -17797, -18220, -18642, -19060, -19481, -19903, -20324, -20745, -21162, -21583, -22005, -22426, -22836, -23279, -23581, -22742, -21587, -20490, -19379, -18268, -17159, -16048, -14937, -13825, -12713, -11604, -10495, -9385, -8276, -7168, -6058, -4949, -3838, -2730, -1626, -499};