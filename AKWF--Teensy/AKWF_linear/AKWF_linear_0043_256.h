/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0043 256 samples */
 
const int16_t AKWF_linear_0043_256_DATA [256] = 
{873, 2674, 4439, 6209, 7977, 9746, 11518, 13283, 15052, 16822, 18587, 20354, 22100, 23960, 24961, 24401, 23858, 23317, 22772, 22229, 21683, 21139, 20593, 20047, 19501, 18957, 18410, 17864, 17319, 16773, 16228, 15682, 15144, 14657, 14179, 13698, 13218, 12739, 12259, 11780, 11301, 10822, 10343, 9863, 9383, 8906, 8426, 7948, 7472, 6991, 6522, 6673, 7148, 7577, 8014, 8453, 8891, 9328, 9767, 10205, 10642, 11081, 11519, 11956, 12394, 12832, 13268, 13691, 14201, 13837, 12447, 11118, 9781, 8439, 7101, 5760, 4419, 3081, 1741, 399, -935, -2276, -3615, -4952, -6292, -7626, -8977, -10223, -11155, -12061, -12976, -13888, -14797, -15710, -16620, -17530, -18441, -19351, -20260, -21171, -22079, -22987, -23897, -24796, -25726, -26544, -25710, -24370, -23124, -21862, -20596, -19330, -18069, -16803, -15538, -14276, -13011, -11746, -10484, -9219, -7955, -6694, -5435, -4145, -3275, -2740, -2163, -1593, -1023, -455, 113, 683, 1252, 1819, 2387, 2955, 3523, 4092, 4658, 5226, 5789, 6375, 6790, 6874, 6959, 7045, 7131, 7216, 7302, 7387, 7471, 7556, 7642, 7726, 7810, 7896, 7979, 8064, 8152, 8224, 8375, 8927, 9560, 10177, 10796, 11416, 12036, 12654, 13275, 13895, 14512, 15131, 15751, 16369, 16988, 17607, 18223, 18842, 19453, 19190, 18443, 17763, 17071, 16377, 15684, 14992, 14298, 13605, 12912, 12219, 11527, 10835, 10141, 9449, 8757, 8055, 7401, 6315, 4696, 3106, 1510, -88, -1680, -3277, -4874, -6467, -8062, -9657, -11249, -12845, -14439, -16029, -17624, -19209, -20834, -22215, -22854, -23425, -24012, -24593, -25174, -25757, -26336, -26917, -27497, -28077, -28657, -29237, -29816, -30395, -30974, -31545, -32141, -32646, -31670, -30203, -28820, -27425, -26024, -24625, -23230, -21831, -20431, -19036, -17637, -16239, -14845, -13445, -12049, -10654, -9252, -7873, -6271, -4480, -2718, -916};