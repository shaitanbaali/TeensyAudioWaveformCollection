/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0070 256 samples */
 
const int16_t AKWF_linear_0070_256_DATA [256] = 
{1990, 5675, 9305, 12879, 14851, 16207, 17668, 19102, 20539, 21978, 23411, 24847, 26283, 27715, 29128, 30643, 31677, 30160, 28205, 26341, 24451, 22564, 20680, 18790, 16904, 15020, 13130, 11270, 9276, 8052, 8689, 9385, 10065, 10751, 11437, 12125, 12811, 13497, 14185, 14870, 15545, 16286, 16501, 16043, 15624, 15200, 14776, 14350, 13925, 13500, 13075, 12650, 12225, 11805, 11358, 11367, 11696, 11985, 12283, 12579, 12876, 13173, 13470, 13767, 14064, 14360, 14658, 14951, 15094, 15182, 15280, 15375, 15471, 15568, 15663, 15759, 15855, 15950, 16042, 16152, 16177, 15761, 15275, 14804, 14329, 13853, 13379, 12903, 12429, 11954, 11480, 11013, 10506, 10226, 10480, 10746, 11009, 11272, 11535, 11800, 12064, 12328, 12593, 12855, 13082, 13512, 12322, 9109, 6031, 2938, -163, -3265, -6359, -9461, -12561, -15653, -18748, -21812, -25076, -24706, -21848, -19314, -16716, -14121, -11528, -8927, -6332, -3738, -1139, 1448, 4055, 6603, 7803, 8525, 9331, 10118, 10906, 11694, 12480, 13267, 14055, 14839, 15601, 16480, 16800, 14312, 11402, 8587, 5744, 2902, 67, -2775, -5615, -8451, -11293, -14092, -17088, -18944, -18181, -17375, -16587, -15791, -14994, -14194, -13397, -12600, -11801, -11004, -10224, -9341, -9293, -10258, -11149, -12050, -12954, -13858, -14761, -15664, -16567, -17469, -18370, -19264, -20214, -20125, -19347, -18663, -17960, -17257, -16556, -15852, -15150, -14449, -13745, -13046, -12337, -11665, -11751, -12097, -12397, -12705, -13014, -13323, -13630, -13939, -14249, -14556, -14862, -15184, -15426, -15280, -15080, -14892, -14700, -14509, -14319, -14127, -13936, -13745, -13554, -13365, -13166, -13027, -13026, -13026, -13025, -13023, -13022, -13022, -13021, -13021, -13019, -13018, -13035, -12957, -13650, -15259, -16795, -18340, -19889, -21438, -22983, -24531, -26079, -27623, -29165, -30683, -32379, -30680, -26800, -23229, -19594, -15965, -12339, -8710, -5091, -1399};