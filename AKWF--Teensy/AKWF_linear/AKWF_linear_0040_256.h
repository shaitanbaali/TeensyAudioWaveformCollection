/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0040 256 samples */
 
const int16_t AKWF_linear_0040_256_DATA [256] = 
{444, 1610, 2754, 3900, 5044, 6189, 7335, 8479, 9624, 10769, 11911, 13045, 14234, 14601, 14278, 14034, 13776, 13517, 13257, 12998, 12739, 12478, 12219, 11960, 11700, 11440, 11181, 10921, 10662, 10411, 10110, 10180, 10972, 11771, 12565, 13363, 14159, 14957, 15755, 16550, 17347, 18145, 18939, 19735, 20534, 21327, 22124, 22907, 23750, 24278, 23164, 21703, 20305, 18895, 17488, 16075, 14665, 13258, 11846, 10437, 9028, 7617, 6209, 4801, 3391, 1984, 576, -833, -2299, -3801, -5301, -6797, -8295, -9794, -11289, -12785, -14283, -15777, -17274, -18771, -20264, -21759, -23254, -24745, -26218, -27812, -28345, -27541, -26806, -26061, -25312, -24563, -23815, -23066, -22318, -21569, -20820, -20072, -19323, -18574, -17826, -17077, -16332, -15568, -14908, -14591, -14302, -14005, -13710, -13417, -13121, -12827, -12535, -12241, -11946, -11653, -11359, -11065, -10773, -10480, -10184, -9895, -9586, -8758, -7758, -6790, -5816, -4844, -3870, -2897, -1924, -951, 20, 993, 1965, 2936, 3908, 4880, 5850, 6823, 7791, 8812, 9885, 10951, 12016, 13082, 14149, 15213, 16280, 17345, 18408, 19475, 20539, 21602, 22667, 23730, 24792, 25842, 26968, 27552, 27020, 26470, 25930, 25382, 24836, 24291, 23744, 23199, 22652, 22105, 21559, 21013, 20466, 19920, 19374, 18824, 18287, 17697, 16800, 15835, 14883, 13927, 12974, 12019, 11065, 10111, 9156, 8202, 7250, 6296, 5343, 4390, 3437, 2486, 1534, 579, -106, -632, -1180, -1724, -2268, -2812, -3355, -3897, -4440, -4983, -5525, -6068, -6609, -7151, -7694, -8235, -8784, -9292, -10135, -11422, -12691, -13958, -15232, -16502, -17770, -19043, -20313, -21581, -22852, -24121, -25388, -26659, -27925, -29193, -30439, -31797, -32561, -31275, -29788, -28344, -26887, -25434, -23978, -22522, -21068, -19612, -18155, -16703, -15247, -13791, -12339, -10883, -9429, -7976, -6526, -5309, -4174, -3024, -1880, -713};