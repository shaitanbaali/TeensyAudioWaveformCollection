/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0050 256 samples */
 
const int16_t AKWF_linear_0050_256_DATA [256] = 
{594, 1977, 3335, 4694, 5975, 7226, 8483, 9735, 10989, 12244, 13494, 14747, 16001, 17250, 18503, 19755, 21004, 22255, 23507, 24753, 25995, 27291, 28065, 28295, 28570, 28838, 29105, 29372, 29639, 29905, 30170, 30436, 30702, 30967, 31234, 31499, 31765, 32028, 32286, 32587, 32641, 32014, 31370, 30733, 30091, 29452, 28812, 28172, 27532, 26892, 26251, 25612, 24972, 24331, 23693, 23053, 22411, 21777, 21116, 20204, 19221, 18250, 17279, 16307, 15334, 14363, 13392, 12419, 11450, 10480, 9506, 8537, 7567, 6595, 5629, 4663, 3673, 3323, 3446, 3512, 3588, 3665, 3742, 3818, 3896, 3974, 4050, 4128, 4206, 4283, 4361, 4438, 4516, 4607, 4628, 5197, 6676, 8146, 9615, 11089, 12559, 14029, 15502, 16971, 18442, 19915, 21382, 22853, 24324, 25790, 27260, 28704, 30268, 31200, 29448, 27240, 25120, 22979, 20844, 18702, 16562, 14426, 12284, 10145, 8010, 5868, 3731, 1595, -544, -2677, -4815, -6944, -8464, -9696, -10973, -12238, -13503, -14770, -16034, -17299, -18564, -19826, -21090, -22355, -23615, -24879, -26142, -27401, -28649, -29978, -30547, -30276, -30070, -29855, -29636, -29417, -29198, -28979, -28761, -28542, -28323, -28104, -27885, -27665, -27445, -27226, -27009, -26782, -26607, -26588, -26576, -26561, -26547, -26533, -26518, -26504, -26491, -26477, -26463, -26448, -26434, -26420, -26406, -26392, -26371, -26374, -26275, -24949, -23261, -21640, -20009, -18378, -16744, -15113, -13482, -11849, -10219, -8587, -6954, -5326, -3696, -2065, -442, 1173, 2872, 2848, 1484, 277, -955, -2191, -3428, -4661, -5898, -7134, -8367, -9604, -10840, -12073, -13310, -14544, -15778, -17003, -18283, -19117, -19161, -19204, -19251, -19295, -19340, -19383, -19427, -19471, -19515, -19557, -19601, -19645, -19688, -19731, -19775, -19808, -19886, -19734, -18536, -17143, -15788, -14424, -13063, -11697, -10334, -8973, -7609, -6246, -4885, -3523, -2165, -780};