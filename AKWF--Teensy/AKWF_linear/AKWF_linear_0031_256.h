/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0031 256 samples */
 
const int16_t AKWF_linear_0031_256_DATA [256] = 
{484, 1259, 2018, 2781, 3525, 4422, 5593, 6760, 7928, 9097, 10262, 11431, 12599, 13764, 14931, 16099, 17264, 18430, 19596, 20759, 21927, 23087, 24267, 25329, 25825, 26212, 26622, 27027, 27431, 27836, 28240, 28644, 29048, 29452, 29855, 30258, 30661, 31064, 31467, 31868, 32271, 32669, 32755, 32681, 32628, 32571, 32514, 32457, 32400, 32343, 32286, 32228, 32171, 32113, 32056, 31998, 31941, 31883, 31826, 31765, 31751, 31795, 31835, 31877, 31917, 31957, 31999, 32039, 32080, 32121, 32161, 32202, 32244, 32283, 32324, 32365, 32397, 32470, 32330, 31563, 30760, 29963, 29164, 28367, 27567, 26768, 25971, 25171, 24373, 23577, 22777, 21980, 21183, 20385, 19586, 18795, 17974, 16634, 15137, 13670, 12201, 10729, 9257, 7789, 6317, 4846, 3378, 1908, 437, -1027, -2498, -3967, -5431, -6894, -8393, -9324, -9796, -10323, -10840, -11356, -11872, -12387, -12904, -13418, -13933, -14448, -14963, -15477, -15992, -16506, -17019, -17527, -18065, -18385, -18291, -18196, -18103, -18009, -17915, -17820, -17725, -17631, -17537, -17441, -17347, -17253, -17157, -17062, -16968, -16877, -16765, -16760, -17285, -17918, -18531, -19148, -19762, -20380, -20996, -21611, -22228, -22844, -23459, -24075, -24690, -25306, -25921, -26535, -27150, -27763, -28046, -28148, -28275, -28397, -28519, -28641, -28763, -28884, -29006, -29127, -29248, -29370, -29490, -29611, -29733, -29853, -29966, -30125, -29859, -29069, -28307, -27541, -26774, -26007, -25241, -24472, -23708, -22941, -22174, -21409, -20641, -19875, -19111, -18345, -17585, -16793, -16184, -16145, -16153, -16150, -16150, -16152, -16152, -16151, -16152, -16154, -16154, -16154, -16155, -16156, -16157, -16159, -16158, -16161, -16151, -15880, -15522, -15180, -14835, -14491, -14146, -13802, -13458, -13113, -12769, -12425, -12081, -11736, -11393, -11048, -10704, -10357, -10029, -9456, -8672, -7913, -7152, -6388, -5626, -4864, -4102, -3339, -2579, -1817, -1058, -283};