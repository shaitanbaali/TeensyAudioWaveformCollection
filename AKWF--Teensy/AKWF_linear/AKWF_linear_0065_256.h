/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0065 256 samples */
 
const int16_t AKWF_linear_0065_256_DATA [256] = 
{1074, 3812, 6495, 9185, 11874, 14559, 17255, 19926, 21422, 22314, 23294, 24259, 25225, 26186, 27148, 28113, 29073, 30036, 30986, 31987, 32716, 31520, 29828, 28228, 26610, 24995, 23375, 21758, 20143, 18523, 16906, 15289, 13676, 12014, 10183, 8335, 6495, 4652, 2807, 967, -874, -2718, -4557, -6398, -8225, -10131, -11364, -11516, -11690, -11866, -12040, -12210, -12382, -12552, -12722, -12895, -13064, -13228, -13423, -13128, -12393, -11700, -11001, -10300, -9597, -8898, -8199, -7497, -6796, -6097, -5395, -4703, -4389, -4266, -4113, -3966, -3819, -3672, -3525, -3379, -3232, -3084, -2939, -2792, -2645, -2491, -2339, -2184, -2031, -1878, -1724, -1571, -1418, -1264, -1111, -959, -802, -670, -612, -561, -509, -457, -405, -353, -301, -249, -198, -146, -95, -41, 1, 25, 50, 76, 101, 125, 150, 175, 200, 225, 250, 275, 299, 317, 327, 336, 347, 357, 368, 377, 389, 398, 409, 418, 430, 438, 403, 351, 302, 250, 198, 147, 95, 44, -7, -58, -109, -162, -205, -173, -125, -83, -36, 7, 52, 97, 140, 186, 230, 274, 325, 326, 192, 45, -97, -241, -385, -529, -674, -817, -962, -1105, -1246, -1402, -1423, -1239, -1061, -882, -703, -524, -344, -164, 15, 193, 372, 550, 734, 811, 796, 791, 784, 777, 771, 764, 757, 750, 743, 738, 729, 736, 1293, 2106, 2878, 3659, 4439, 5219, 5999, 6780, 7558, 8337, 9105, 9924, 10484, 9521, 8209, 6961, 5700, 4442, 3178, 1919, 660, -602, -1860, -3123, -4373, -5707, -7278, -8868, -10449, -12035, -13620, -15202, -16786, -18371, -19953, -21534, -23095, -24778, -25379, -24409, -23489, -22562, -21631, -20701, -19772, -18841, -17911, -16980, -16048, -15110, -14221, -12304, -9541, -6865, -4181, -1441};