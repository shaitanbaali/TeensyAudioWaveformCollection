/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0052 256 samples */
 
const int16_t AKWF_linear_0052_256_DATA [256] = 
{110, 348, 584, 820, 1049, 1359, 1745, 2122, 2501, 2881, 3258, 3637, 4016, 4395, 4773, 5153, 5530, 5909, 6287, 6664, 7043, 7422, 7795, 8196, 8661, 9126, 9591, 10056, 10520, 10985, 11449, 11914, 12378, 12843, 13307, 13771, 14235, 14698, 15162, 15625, 16089, 16551, 16997, 17441, 17887, 18330, 18774, 19219, 19662, 20105, 20549, 20992, 21436, 21879, 22321, 22765, 23208, 23650, 24093, 24537, 24904, 25221, 25545, 25867, 26190, 26511, 26834, 27156, 27477, 27800, 28121, 28442, 28764, 29085, 29406, 29727, 30047, 30375, 30621, 30740, 30862, 30984, 31106, 31227, 31349, 31470, 31591, 31713, 31834, 31955, 32078, 32198, 32319, 32440, 32555, 32700, 32679, 32060, 31354, 30665, 29973, 29281, 28588, 27896, 27204, 26511, 25821, 25128, 24436, 23745, 23053, 22361, 21668, 20982, 20263, 18816, 17052, 15336, 13615, 11890, 10166, 8446, 6720, 4999, 3278, 1555, -165, -1884, -3607, -5325, -7045, -8760, -10505, -11882, -12896, -13936, -14973, -16010, -17044, -18079, -19115, -20147, -21182, -22218, -23249, -24283, -25317, -26347, -27380, -28402, -29472, -30271, -30399, -30511, -30629, -30744, -30858, -30973, -31088, -31202, -31316, -31430, -31543, -31657, -31771, -31884, -31998, -32109, -32227, -32316, -32122, -31858, -31609, -31357, -31103, -30850, -30599, -30346, -30092, -29840, -29587, -29335, -29083, -28830, -28578, -28326, -28071, -27825, -27413, -26887, -26377, -25864, -25349, -24837, -24324, -23810, -23297, -22785, -22271, -21760, -21247, -20733, -20222, -19711, -19199, -18683, -18208, -17800, -17391, -16981, -16572, -16163, -15754, -15345, -14936, -14527, -14119, -13710, -13301, -12895, -12486, -12078, -11671, -11263, -10852, -10430, -10007, -9583, -9160, -8737, -8313, -7891, -7468, -7045, -6623, -6200, -5777, -5355, -4933, -4511, -4090, -3667, -3249, -2961, -2732, -2493, -2256, -2019, -1783, -1547, -1311, -1074, -838, -603, -368, -128};