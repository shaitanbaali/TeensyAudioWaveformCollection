/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0073 256 samples */
 
const int16_t AKWF_linear_0073_256_DATA [256] = 
{611, 1803, 2963, 4461, 6119, 7751, 9389, 11023, 12660, 14298, 15931, 17567, 19204, 20830, 22480, 24053, 24863, 25505, 26182, 26850, 27519, 28187, 28854, 29522, 30189, 30856, 31516, 32212, 32720, 32582, 32405, 32240, 32070, 31901, 31732, 31561, 31391, 31221, 31052, 30879, 30719, 30477, 30097, 29721, 29346, 28970, 28595, 28218, 27843, 27467, 27091, 26717, 26349, 25934, 26017, 26551, 27031, 27519, 28010, 28498, 28987, 29477, 29966, 30455, 30942, 31428, 31933, 31258, 30023, 28883, 27724, 26567, 25410, 24250, 23095, 21937, 20778, 19618, 18474, 17250, 15305, 13195, 11120, 9042, 6959, 4878, 2800, 719, -1360, -3436, -5486, -7686, -9092, -7893, -6545, -5240, -3919, -2601, -1283, 37, 1355, 2674, 3996, 5312, 6635, 7927, 9164, 10405, 11647, 12885, 14126, 15367, 16605, 17846, 19085, 20320, 21526, 22923, 22217, 19655, 17320, 14947, 12570, 10195, 7823, 5444, 3071, 698, -1678, -4049, -6423, -8518, -10476, -12459, -14439, -16414, -18390, -20370, -22344, -24320, -26298, -28258, -30268, -32076, -32220, -32009, -31871, -31718, -31566, -31412, -31258, -31105, -30950, -30796, -30644, -30481, -30376, -30461, -30555, -30645, -30737, -30829, -30920, -31013, -31104, -31194, -31287, -31377, -31470, -31545, -31586, -31629, -31673, -31716, -31759, -31802, -31845, -31887, -31930, -31973, -32013, -32070, -31908, -31558, -31229, -30898, -30566, -30233, -29903, -29571, -29238, -28907, -28572, -28242, -27911, -26642, -24952, -23334, -21700, -20071, -18440, -16806, -15178, -13547, -11914, -10292, -8647, -7088, -6185, -5417, -4621, -3832, -3041, -2252, -1464, -675, 113, 900, 1672, 2529, 2914, 1882, 778, -302, -1393, -2482, -3570, -4662, -5750, -6838, -7929, -9006, -10144, -10850, -10891, -10969, -11041, -11112, -11184, -11254, -11324, -11395, -11466, -11535, -11596, -11713, -11096, -9860, -8702, -7532, -6357, -5185, -4015, -2843, -1675, -484};