/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0024 256 samples */
 
const int16_t AKWF_linear_0024_256_DATA [256] = 
{749, 2248, 3718, 5189, 6661, 8133, 9609, 11079, 12550, 14024, 15494, 16966, 18438, 19906, 21378, 22834, 24364, 25417, 25482, 25553, 25625, 25695, 25764, 25835, 25903, 25972, 26040, 26110, 26179, 26247, 26316, 26384, 26452, 26502, 26633, 26341, 23547, 20216, 16990, 13751, 10507, 7259, 4021, 777, -2469, -5705, -8949, -12193, -15428, -18671, -21912, -25132, -28373, -31615, -31022, -28169, -25623, -23022, -20414, -17810, -15208, -12601, -9999, -7396, -4788, -2187, 415, 3022, 5622, 8223, 10810, 13494, 15215, 15670, 16172, 16670, 17166, 17659, 18154, 18646, 19140, 19634, 20126, 20618, 21110, 21604, 22094, 22587, 23048, 23660, 23436, 20558, 17393, 14284, 11163, 8044, 4918, 1800, -1318, -4442, -7558, -10677, -13800, -16915, -20032, -23153, -26250, -29402, -32369, -32141, -30753, -29554, -28321, -27084, -25847, -24612, -23375, -22138, -20903, -19664, -18427, -17192, -15954, -14718, -13483, -12251, -10988, -10070, -9452, -8801, -8158, -7512, -6870, -6226, -5581, -4939, -4296, -3651, -3009, -2367, -1723, -1082, -440, 195, 863, 1336, 1373, 1412, 1453, 1492, 1532, 1570, 1609, 1647, 1686, 1723, 1762, 1801, 1840, 1877, 1914, 1953, 1993, 2021, 1984, 1930, 1881, 1831, 1780, 1729, 1678, 1629, 1579, 1528, 1477, 1427, 1376, 1325, 1274, 1224, 1173, 1124, 888, 534, 196, -144, -485, -825, -1165, -1506, -1846, -2186, -2527, -2868, -3208, -3548, -3888, -4228, -4566, -4914, -5171, -5300, -5433, -5567, -5698, -5830, -5964, -6097, -6228, -6360, -6494, -6625, -6756, -6889, -7021, -7153, -7282, -7422, -7507, -7400, -7271, -7146, -7020, -6894, -6768, -6643, -6517, -6391, -6265, -6140, -6013, -5887, -5761, -5635, -5509, -5384, -5257, -5072, -4865, -4663, -4461, -4256, -4053, -3850, -3647, -3444, -3242, -3037, -2835, -2633, -2430, -2227, -2024, -1811, -1669, -780};