/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0027 256 samples */
 
const int16_t AKWF_linear_0027_256_DATA [256] = 
{566, 1484, 2385, 3287, 4190, 5097, 5979, 7054, 8492, 9934, 11368, 12808, 14249, 15686, 17126, 18566, 20001, 21440, 22879, 24313, 25752, 27189, 28623, 30034, 31564, 32518, 30493, 27902, 25423, 22912, 20407, 17903, 15392, 12888, 10383, 7875, 5372, 2866, 358, -2142, -4645, -7147, -9644, -12172, -12787, -12400, -12160, -11893, -11626, -11358, -11090, -10822, -10554, -10284, -10016, -9748, -9478, -9210, -8940, -8671, -8402, -8134, -7839, -7503, -7168, -6835, -6502, -6167, -5834, -5501, -5166, -4833, -4500, -4165, -3833, -3498, -3165, -2832, -2506, -2146, -1974, -2410, -2894, -3367, -3843, -4319, -4795, -5271, -5745, -6221, -6698, -7172, -7646, -8125, -8600, -9074, -9542, -10034, -10426, -9495, -8092, -6771, -5433, -4099, -2761, -1424, -91, 1246, 2583, 3917, 5254, 6592, 7923, 9259, 10593, 11914, 13306, 13488, 12625, 11865, 11088, 10309, 9530, 8751, 7973, 7194, 6414, 5637, 4856, 4078, 3300, 2519, 1743, 977, 143, -210, 360, 951, 1533, 2121, 2709, 3294, 3882, 4469, 5055, 5643, 6231, 6816, 7403, 7990, 8576, 9154, 9772, 10202, 9599, 8779, 7999, 7210, 6423, 5634, 4845, 4058, 3269, 2480, 1693, 905, 116, -669, -1457, -2245, -3029, -3824, -4244, -4455, -4697, -4931, -5167, -5402, -5637, -5871, -6107, -6341, -6577, -6811, -7046, -7280, -7514, -7748, -7976, -8240, -8237, -7883, -7552, -7219, -6884, -6548, -6215, -5881, -5546, -5211, -4877, -4543, -4208, -3874, -3540, -3206, -2875, -2525, -2285, -2433, -2615, -2788, -2964, -3140, -3316, -3490, -3665, -3841, -4018, -4193, -4369, -4544, -4720, -4895, -5072, -5247, -5424, -5651, -5896, -6137, -6381, -6623, -6866, -7108, -7350, -7592, -7835, -8077, -8320, -8562, -8804, -9045, -9287, -9521, -9797, -9432, -8483, -7587, -6684, -5780, -4876, -3972, -3069, -2166, -1265, -346};