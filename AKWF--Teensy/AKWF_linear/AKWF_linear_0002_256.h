/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0002 256 samples */
 
const int16_t AKWF_linear_0002_256_DATA [256] = 
{882, 2660, 4399, 6144, 7888, 9633, 11380, 13125, 14871, 16618, 18362, 20107, 21855, 23598, 25345, 27091, 28817, 30640, 31909, 31380, 30647, 29958, 29261, 28561, 27862, 27165, 26464, 25765, 25068, 24367, 23669, 22971, 22270, 21573, 20871, 20176, 19458, 18389, 17184, 16005, 14819, 13631, 12446, 11260, 10075, 8889, 7702, 6514, 5332, 4145, 2958, 1774, 588, -591, -1810, -2451, -2578, -2746, -2909, -3073, -3234, -3396, -3559, -3720, -3883, -4045, -4207, -4369, -4532, -4693, -4856, -5016, -5186, -5304, -5315, -5325, -5335, -5346, -5355, -5365, -5374, -5384, -5394, -5403, -5414, -5424, -5434, -5444, -5454, -5459, -5484, -5420, -4670, -3778, -2918, -2052, -1183, -316, 550, 1420, 2285, 3152, 4021, 4888, 5755, 6623, 7488, 8357, 9228, 10086, 11189, 12439, 13665, 14897, 16129, 17358, 18589, 19821, 21052, 22284, 23516, 24745, 25977, 27208, 28437, 29670, 30875, 32215, 32433, 31035, 29712, 28378, 27044, 25709, 24369, 23036, 21701, 20364, 19030, 17694, 16357, 15024, 13688, 12351, 11014, 9693, 8246, 6344, 4380, 2430, 482, -1473, -3423, -5374, -7327, -9279, -11230, -13184, -15135, -17086, -19039, -20989, -22933, -24904, -26772, -26973, -26488, -26112, -25715, -25316, -24919, -24521, -24123, -23725, -23326, -22929, -22530, -22133, -21735, -21337, -20939, -20539, -20156, -19559, -18766, -17993, -17213, -16435, -15658, -14878, -14099, -13322, -12542, -11765, -10986, -10206, -9430, -8650, -7871, -7102, -6291, -5714, -5654, -5606, -5556, -5509, -5458, -5410, -5362, -5311, -5264, -5213, -5165, -5117, -5066, -5019, -4971, -4923, -4867, -4854, -5208, -5642, -6059, -6482, -6904, -7326, -7747, -8170, -8591, -9012, -9436, -9856, -10279, -10700, -11122, -11543, -11958, -12411, -12125, -11370, -10687, -9990, -9293, -8597, -7899, -7202, -6505, -5808, -5111, -4415, -3717, -3021, -2324, -1630, -934, -226};