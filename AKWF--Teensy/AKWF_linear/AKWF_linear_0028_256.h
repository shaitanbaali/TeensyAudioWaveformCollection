/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0028 256 samples */
 
const int16_t AKWF_linear_0028_256_DATA [256] = 
{139, 557, 969, 1379, 1792, 2204, 2576, 2922, 3271, 3618, 3965, 4313, 4660, 5007, 5355, 5703, 6049, 6396, 6743, 7089, 7435, 7782, 8140, 8439, 9140, 10478, 11794, 13111, 14428, 15747, 17063, 18380, 19698, 21014, 22330, 23648, 24963, 26279, 27595, 28909, 30204, 31596, 32522, 31246, 29715, 28248, 26761, 25276, 23794, 22309, 20823, 19342, 17857, 16371, 14890, 13404, 11920, 10439, 8954, 7471, 5991, 4543, 3113, 1681, 248, -1183, -2613, -4047, -5476, -6906, -8338, -9766, -11196, -12626, -14054, -15481, -16909, -18314, -19843, -19935, -18473, -17131, -15769, -14408, -13044, -11680, -10320, -8955, -7593, -6232, -4868, -3505, -2144, -781, 580, 1936, 3314, 4578, 5565, 6537, 7510, 8483, 9457, 10428, 11401, 12373, 13344, 14315, 15288, 16257, 17228, 18200, 19168, 20137, 21114, 22050, 22683, 23225, 23782, 24336, 24889, 25441, 25995, 26548, 27100, 27653, 28205, 28757, 29309, 29860, 30412, 30961, 31502, 32108, 31180, 29168, 27276, 25361, 23450, 21537, 19621, 17711, 15796, 13882, 11972, 10058, 8145, 6236, 4322, 2411, 510, -1432, -3117, -4377, -5651, -6923, -8191, -9462, -10731, -11998, -13269, -14534, -15801, -17070, -18336, -19602, -20871, -22134, -23390, -24696, -25766, -25647, -25374, -25136, -24889, -24642, -24395, -24149, -23901, -23654, -23405, -23158, -22912, -22663, -22416, -22169, -21921, -21673, -21425, -21290, -21209, -21120, -21031, -20943, -20854, -20766, -20677, -20589, -20500, -20412, -20323, -20235, -20147, -20059, -19970, -19879, -19802, -19582, -19202, -18833, -18462, -18092, -17721, -17350, -16978, -16608, -16237, -15868, -15497, -15127, -14757, -14386, -14015, -13646, -13277, -12895, -12472, -12044, -11618, -11193, -10767, -10341, -9915, -9488, -9064, -8638, -8212, -7789, -7363, -6937, -6513, -6088, -5663, -5241, -4824, -4410, -3998, -3584, -3170, -2759, -2344, -1932, -1520, -1107, -697, -277};