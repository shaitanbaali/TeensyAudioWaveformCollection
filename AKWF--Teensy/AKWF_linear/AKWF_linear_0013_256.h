/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0013 256 samples */
 
const int16_t AKWF_linear_0013_256_DATA [256] = 
{669, 1972, 3249, 4530, 5810, 7091, 8374, 9652, 10934, 12216, 13495, 14775, 16057, 17333, 18612, 19905, 20583, 20843, 21157, 21459, 21761, 22064, 22366, 22667, 22970, 23271, 23573, 23874, 24175, 24477, 24778, 25078, 25375, 25695, 25811, 25618, 25429, 25242, 25053, 24863, 24674, 24484, 24296, 24106, 23916, 23727, 23538, 23348, 23159, 22970, 22782, 22587, 22425, 22389, 22370, 22347, 22325, 22303, 22282, 22261, 22238, 22217, 22195, 22174, 22152, 22130, 22109, 22087, 22066, 22043, 22025, 22148, 22331, 22504, 22680, 22856, 23031, 23208, 23383, 23559, 23734, 23910, 24086, 24261, 24436, 24611, 24787, 24940, 25217, 24304, 22166, 20139, 18096, 16047, 14002, 11958, 9909, 7865, 5822, 3775, 1732, -311, -2356, -4396, -6439, -8475, -10552, -12377, -13518, -14644, -15778, -16909, -18035, -19166, -20295, -21422, -22551, -23679, -24804, -25932, -27059, -28184, -29311, -30427, -31578, -32571, -32076, -31177, -30357, -29522, -28686, -27849, -27014, -26178, -25341, -24505, -23669, -22832, -21997, -21160, -20324, -19492, -18662, -17795, -17943, -18822, -19611, -20414, -21220, -22025, -22829, -23634, -24439, -25243, -26049, -26853, -27656, -28462, -29266, -30069, -30866, -31701, -32227, -32253, -32284, -32317, -32348, -32379, -32410, -32442, -32472, -32502, -32533, -32562, -32594, -32624, -32654, -32685, -32710, -32756, -32695, -32199, -31631, -31077, -30519, -29962, -29404, -28847, -28291, -27732, -27176, -26619, -26061, -25505, -24948, -24391, -23831, -23281, -22700, -21052, -18903, -16825, -14741, -12651, -10560, -8475, -6386, -4296, -2214, -125, 1963, 4045, 6132, 8218, 10299, 12368, 14532, 15783, 16056, 16405, 16742, 17078, 17411, 17745, 18080, 18414, 18747, 19080, 19413, 19746, 20079, 20411, 20743, 21059, 21460, 21407, 20085, 18725, 17376, 16020, 14669, 13314, 11960, 10609, 9253, 7900, 6548, 5195, 3841, 2490, 1136, -203, -1583, -2791, -1995, -601};