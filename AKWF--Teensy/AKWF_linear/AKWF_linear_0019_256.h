/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0019 256 samples */
 
const int16_t AKWF_linear_0019_256_DATA [256] = 
{621, 1589, 2507, 3606, 5070, 6534, 7998, 9460, 10924, 12389, 13849, 15312, 16776, 18236, 19698, 21161, 22619, 24080, 25542, 26988, 28485, 29770, 29521, 28978, 28497, 28004, 27510, 27016, 26522, 26027, 25533, 25038, 24544, 24049, 23554, 23059, 22565, 22068, 21568, 21094, 19489, 17208, 15033, 12835, 10635, 8443, 6245, 4047, 1855, -341, -2537, -4727, -6924, -9119, -11309, -13503, -15668, -17975, -18991, -18220, -17529, -16828, -16124, -15419, -14714, -14009, -13303, -12597, -11894, -11188, -10481, -9776, -9071, -8365, -7655, -6968, -6145, -4875, -3548, -2232, -917, 400, 1718, 3032, 4350, 5666, 6980, 8297, 9612, 10926, 12242, 13557, 14865, 16189, 17460, 17942, 18118, 18342, 18555, 18770, 18982, 19195, 19408, 19621, 19834, 20047, 20259, 20471, 20683, 20895, 21106, 21303, 21585, 20765, 18947, 17221, 15476, 13733, 11992, 10247, 8502, 6762, 5016, 3274, 1533, -210, -1950, -3690, -5433, -7159, -8959, -10317, -10707, -11084, -11467, -11846, -12224, -12603, -12981, -13360, -13737, -14115, -14493, -14870, -15247, -15624, -16000, -16370, -16769, -17047, -16320, -15389, -14503, -13608, -12709, -11814, -10920, -10022, -9126, -8230, -7334, -6438, -5544, -4646, -3752, -2857, -1961, -1067, -174, 717, 1607, 2499, 3391, 4280, 5172, 6062, 6952, 7843, 8734, 9621, 10511, 11401, 12289, 13178, 14046, 15024, 15059, 13717, 12431, 11137, 9843, 8549, 7250, 5956, 4662, 3365, 2071, 777, -519, -1812, -3107, -4402, -5695, -6988, -8295, -9648, -11011, -12371, -13728, -15090, -16449, -17807, -19167, -20525, -21881, -23241, -24599, -25953, -27312, -28669, -30015, -31389, -32664, -32249, -31128, -30117, -29083, -28049, -27015, -25983, -24947, -23914, -22880, -21845, -20813, -19779, -18744, -17711, -16678, -15645, -14610, -13619, -12671, -11723, -10774, -9823, -8876, -7926, -6978, -6032, -5083, -4135, -3189, -2242, -1299, -335};