/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0072 256 samples */
 
const int16_t AKWF_linear_0072_256_DATA [256] = 
{418, 1211, 1986, 2763, 3540, 4318, 5097, 5872, 6650, 7428, 8205, 8977, 9773, 10905, 12150, 13375, 14600, 15829, 17057, 18281, 19509, 20735, 21959, 23181, 24426, 25551, 26174, 26729, 27298, 27864, 28429, 28994, 29560, 30123, 30688, 31253, 31800, 32437, 32527, 31501, 30470, 29441, 28412, 27380, 26350, 25320, 24289, 23257, 22228, 21188, 20197, 18784, 16894, 15045, 13192, 11335, 9480, 7627, 5771, 3918, 2065, 212, -1633, -3517, -4420, -4726, -5114, -5489, -5862, -6234, -6608, -6979, -7351, -7724, -8087, -8479, -8764, -7595, -5975, -4436, -2885, -1328, 226, 1777, 3333, 4887, 6440, 7995, 9549, 11097, 12634, 14167, 15696, 17231, 18763, 20293, 21827, 23356, 24886, 26419, 27930, 29531, 30595, 30578, 30567, 30557, 30545, 30532, 30519, 30507, 30493, 30480, 30465, 30438, 30488, 29831, 28406, 27048, 25683, 24311, 22942, 21575, 20205, 18837, 17470, 16100, 14732, 13366, 11949, 10508, 9070, 7628, 6191, 4752, 3311, 1876, 438, -1001, -2434, -3877, -5288, -6257, -7100, -7966, -8825, -9685, -10545, -11403, -12263, -13122, -13979, -14834, -15708, -16484, -16874, -17220, -17575, -17929, -18281, -18634, -18987, -19339, -19691, -20044, -20393, -20756, -21035, -21148, -21264, -21380, -21495, -21610, -21726, -21841, -21956, -22071, -22186, -22300, -22420, -22485, -22496, -22511, -22526, -22541, -22555, -22570, -22584, -22599, -22613, -22627, -22641, -22656, -22631, -22581, -22535, -22488, -22441, -22394, -22348, -22302, -22255, -22208, -22161, -22114, -22065, -21968, -21856, -21748, -21639, -21530, -21422, -21313, -21204, -21095, -20987, -20876, -20773, -20638, -20376, -20102, -19832, -19561, -19289, -19019, -18747, -18476, -18204, -17933, -17661, -17397, -17077, -16649, -16222, -15796, -15370, -14944, -14517, -14092, -13665, -13239, -12814, -12383, -11980, -11317, -10381, -9472, -8563, -7649, -6737, -5826, -4914, -4002, -3092, -2182, -1274, -347};