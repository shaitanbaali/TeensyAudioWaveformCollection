/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0071 256 samples */
 
const int16_t AKWF_linear_0071_256_DATA [256] = 
{1972, 5299, 8595, 11722, 13380, 14682, 16058, 17415, 18773, 20132, 21486, 22844, 24202, 25556, 26889, 28334, 29152, 27949, 26591, 25274, 23942, 22612, 21285, 19954, 18623, 17295, 15964, 14665, 13206, 12918, 14571, 16156, 17749, 19343, 20938, 22536, 24129, 25724, 27321, 28911, 30486, 32178, 32363, 31177, 30140, 29079, 28016, 26952, 25891, 24827, 23763, 22702, 21641, 20577, 19520, 19333, 19576, 19750, 19938, 20125, 20312, 20500, 20688, 20875, 21063, 21249, 21442, 21600, 21499, 21337, 21188, 21036, 20883, 20731, 20579, 20426, 20274, 20122, 19963, 19840, 19503, 18496, 17441, 16400, 15353, 14308, 13264, 12218, 11173, 10129, 9083, 8061, 6922, 6671, 7845, 8967, 10095, 11223, 12353, 13486, 14614, 15744, 16875, 18000, 19099, 20372, 19255, 16018, 13013, 9975, 6929, 3883, 846, -2199, -5243, -8280, -11313, -14363, -17364, -16932, -14849, -13036, -11169, -9303, -7439, -5570, -3705, -1842, 27, 1882, 3776, 5486, 5884, 5978, 6135, 6278, 6421, 6564, 6706, 6849, 6992, 7134, 7255, 7484, 7077, 4781, 2353, -35, -2439, -4842, -7239, -9643, -12044, -14441, -16843, -19206, -21768, -22742, -21248, -19850, -18440, -17027, -15612, -14196, -12783, -11369, -9953, -8543, -7150, -5636, -5916, -7742, -9395, -11076, -12760, -14445, -16125, -17810, -19494, -21173, -22851, -24540, -26191, -26139, -25289, -24570, -23824, -23081, -22337, -21590, -20846, -20102, -19356, -18620, -17849, -17247, -17762, -18526, -19241, -19965, -20688, -21414, -22138, -22862, -23587, -24310, -25029, -25775, -26355, -26467, -26548, -26636, -26723, -26809, -26895, -26981, -27067, -27153, -27239, -27313, -27448, -27091, -25997, -24933, -23865, -22797, -21728, -20658, -19590, -18522, -17453, -16388, -15335, -14198, -14421, -15787, -17024, -18282, -19541, -20802, -22059, -23321, -24580, -25838, -27084, -28359, -29542, -27523, -24048, -20817, -17532, -14251, -10975, -7696, -4427, -1090};