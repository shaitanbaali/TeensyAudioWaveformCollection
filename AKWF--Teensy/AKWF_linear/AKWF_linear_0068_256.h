/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0068 256 samples */
 
const int16_t AKWF_linear_0068_256_DATA [256] = 
{1074, 3673, 6246, 8454, 10297, 12171, 14042, 15908, 17775, 19644, 21508, 23375, 25242, 27100, 28968, 30823, 31441, 31380, 31412, 31425, 31438, 31450, 31462, 31474, 31486, 31497, 31504, 31530, 31463, 30681, 29695, 28746, 27788, 26831, 25874, 24917, 23960, 23004, 22046, 21094, 20122, 19258, 18741, 18260, 17772, 17287, 16801, 16315, 15830, 15344, 14859, 14375, 13898, 13376, 13203, 13616, 14027, 14435, 14847, 15258, 15668, 16080, 16490, 16901, 17313, 17725, 18130, 18622, 19194, 19760, 20327, 20893, 21460, 22028, 22593, 23161, 23728, 24290, 24859, 25418, 25361, 24977, 24637, 24290, 23941, 23593, 23246, 22897, 22549, 22202, 21849, 21513, 21100, 20120, 18984, 17877, 16763, 15651, 14539, 13425, 12313, 11202, 10088, 8977, 7867, 6744, 5591, 4431, 3272, 2116, 957, -201, -1355, -2512, -3670, -4824, -5964, -7197, -7679, -6938, -6204, -5476, -4740, -4006, -3272, -2537, -1803, -1069, -334, 396, 1145, 1627, 1860, 2115, 2367, 2618, 2869, 3120, 3371, 3622, 3873, 4119, 4375, 4607, 3744, 2312, 959, -405, -1772, -3140, -4505, -5873, -7240, -8604, -9969, -11344, -12664, -13635, -14509, -15400, -16289, -17177, -18063, -18953, -19839, -20725, -21613, -22491, -23405, -24123, -24260, -24342, -24436, -24526, -24616, -24706, -24796, -24886, -24976, -25065, -25146, -25269, -25067, -24350, -23639, -22930, -22218, -21507, -20796, -20084, -19372, -18662, -17951, -17244, -16516, -16096, -15949, -15778, -15612, -15446, -15281, -15114, -14948, -14782, -14616, -14454, -14286, -14131, -14525, -15193, -15822, -16458, -17096, -17734, -18369, -19006, -19643, -20279, -20917, -21551, -22204, -23010, -23851, -24684, -25521, -26356, -27190, -28027, -28861, -29696, -30532, -31352, -32237, -32757, -32242, -31630, -31040, -30446, -29849, -29252, -28657, -28061, -27463, -26869, -26253, -25739, -24413, -21830, -19270, -16716, -14150, -11590, -9032, -6473, -3920, -1315};