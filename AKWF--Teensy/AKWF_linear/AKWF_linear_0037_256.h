/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0037 256 samples */
 
const int16_t AKWF_linear_0037_256_DATA [256] = 
{217, 552, 881, 1210, 1539, 1867, 2196, 2525, 2851, 3187, 3468, 3576, 3667, 3763, 3858, 3952, 4046, 4140, 4235, 4328, 4422, 4516, 4609, 4703, 4797, 4890, 4987, 5073, 5204, 5931, 6875, 7782, 8698, 9612, 10527, 11442, 12356, 13269, 14185, 15098, 16011, 16925, 17837, 18751, 19663, 20572, 21504, 22042, 22237, 22464, 22685, 22908, 23127, 23350, 23570, 23790, 24010, 24231, 24452, 24671, 24891, 25111, 25330, 25532, 25832, 25451, 23732, 21979, 20242, 18498, 16752, 15009, 13265, 11519, 9778, 8034, 6289, 4548, 2805, 1060, -677, -2414, -4178, -5805, -6652, -7332, -8042, -8746, -9449, -10151, -10855, -11557, -12258, -12961, -13662, -14362, -15064, -15765, -16464, -17164, -17861, -18576, -18649, -18363, -18127, -17880, -17635, -17388, -17142, -16896, -16650, -16403, -16157, -15910, -15664, -15418, -15171, -14925, -14675, -14449, -14039, -13378, -12736, -12089, -11445, -10798, -10152, -9508, -8861, -8216, -7571, -6925, -6281, -5637, -4991, -4348, -3698, -3075, -2306, -1011, 334, 1662, 2997, 4331, 5662, 6997, 8331, 9662, 10995, 12328, 13658, 14992, 16323, 17652, 18981, 20319, 21609, 22122, 22331, 22591, 22842, 23091, 23341, 23591, 23839, 24088, 24337, 24586, 24835, 25083, 25331, 25580, 25826, 26064, 26362, 25707, 24175, 22720, 21251, 19784, 18314, 16845, 15378, 13908, 12440, 10975, 9506, 8038, 6573, 5103, 3637, 2170, 714, -841, -2611, -4392, -6167, -7943, -9722, -11496, -13271, -15050, -16821, -18596, -20372, -22142, -23917, -25691, -27461, -29222, -31035, -32597, -32615, -32272, -31996, -31705, -31413, -31122, -30829, -30537, -30246, -29952, -29660, -29368, -29074, -28782, -28489, -28194, -27899, -27624, -26637, -25226, -23870, -22502, -21139, -19773, -18407, -17044, -15678, -14312, -12950, -11584, -10219, -8858, -7493, -6130, -4780, -3362, -2406, -2110, -1771, -1439, -1110, -779, -450, -114};