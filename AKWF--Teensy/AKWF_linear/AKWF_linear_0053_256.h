/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0053 256 samples */
 
const int16_t AKWF_linear_0053_256_DATA [256] = 
{732, 2206, 3647, 5104, 6461, 7702, 8954, 10200, 11449, 12698, 13944, 15192, 16440, 17684, 18930, 20178, 21421, 22667, 23913, 25155, 26392, 27673, 28691, 28915, 29089, 29276, 29458, 29640, 29822, 30004, 30186, 30367, 30548, 30730, 30910, 31092, 31272, 31452, 31633, 31815, 31988, 32058, 32096, 32139, 32181, 32222, 32263, 32305, 32347, 32388, 32431, 32472, 32513, 32555, 32596, 32638, 32676, 32707, 32797, 31691, 29609, 27625, 25628, 23630, 21629, 19632, 17635, 15633, 13638, 11641, 9641, 7647, 5650, 3652, 1659, -333, -2346, -4202, -5783, -7360, -8935, -10512, -12088, -13660, -15237, -16812, -18382, -19957, -21530, -23101, -24675, -26245, -27815, -29369, -31004, -32228, -31380, -30129, -28954, -27760, -26569, -25377, -24183, -22992, -21799, -20605, -19415, -18222, -17028, -15837, -14644, -13454, -12264, -11066, -10700, -10773, -10782, -10804, -10825, -10847, -10869, -10891, -10913, -10935, -10957, -10980, -11002, -11024, -11047, -11069, -11078, -11163, -10653, -9399, -8200, -6996, -5789, -4581, -3377, -2169, -961, 242, 1448, 2655, 3859, 5066, 6271, 7474, 8679, 9887, 11067, 12162, 13250, 14335, 15426, 16513, 17600, 18688, 19774, 20859, 21947, 23033, 24118, 25205, 26289, 27373, 28447, 29558, 30502, 29118, 26915, 24858, 22770, 20688, 18601, 16514, 14432, 12345, 10259, 8177, 6090, 4005, 1925, -160, -2242, -4316, -6431, -7896, -8800, -9763, -10715, -11665, -12616, -13566, -14515, -15467, -16414, -17363, -18314, -19260, -20209, -21157, -22103, -23045, -24018, -24766, -25086, -25398, -25710, -26022, -26333, -26644, -26956, -27267, -27577, -27888, -28198, -28508, -28818, -29128, -29438, -29743, -30071, -30282, -29863, -29309, -28781, -28246, -27713, -27179, -26645, -26111, -25577, -25042, -24509, -23975, -23441, -22908, -22374, -21839, -21305, -20777, -19632, -18144, -16699, -15248, -13800, -12347, -10895, -9447, -7995, -6545, -5097, -3647, -2204, -730};