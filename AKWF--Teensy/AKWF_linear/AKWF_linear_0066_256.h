/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0066 256 samples */
 
const int16_t AKWF_linear_0066_256_DATA [256] = 
{555, 1624, 2589, 3473, 4362, 5251, 6141, 7028, 7916, 8805, 9691, 10579, 11466, 12351, 13244, 13759, 14054, 14379, 14699, 15017, 15337, 15657, 15975, 16294, 16612, 16925, 17258, 17507, 16909, 16060, 15254, 14441, 13625, 12812, 11998, 11182, 10369, 9555, 8741, 7922, 7141, 6499, 5876, 5248, 4620, 3994, 3368, 2741, 2115, 1489, 862, 253, -441, -583, 279, 1142, 2001, 2862, 3726, 4587, 5449, 6312, 7174, 8035, 8902, 9745, 10803, 12080, 13334, 14593, 15853, 17110, 18369, 19628, 20885, 22143, 23401, 24655, 25919, 26680, 27156, 27673, 28184, 28692, 29201, 29710, 30218, 30726, 31235, 31735, 32264, 32676, 31969, 30943, 29975, 28997, 28015, 27036, 26056, 25075, 24096, 23116, 22130, 21177, 20060, 18372, 16629, 14895, 13157, 11424, 9687, 7950, 6218, 4482, 2745, 1023, -748, -2227, -3187, -4156, -5124, -6087, -7054, -8019, -8982, -9948, -10912, -11873, -12831, -13827, -14407, -14585, -14797, -15003, -15209, -15413, -15619, -15824, -16028, -16233, -16437, -16640, -16848, -16724, -16420, -16142, -15858, -15575, -15291, -15008, -14724, -14442, -14158, -13876, -13588, -13324, -13279, -13293, -13296, -13301, -13306, -13311, -13317, -13322, -13328, -13333, -13335, -13351, -13300, -13022, -12721, -12425, -12128, -11831, -11534, -11236, -10940, -10643, -10345, -10046, -9760, -9390, -8879, -8370, -7862, -7354, -6844, -6336, -5827, -5318, -4810, -4302, -3801, -3259, -3167, -3505, -3802, -4106, -4411, -4716, -5021, -5327, -5631, -5936, -6242, -6547, -6850, -7396, -8067, -8722, -9379, -10035, -10693, -11350, -12007, -12664, -13320, -13976, -14633, -15287, -15919, -16548, -17176, -17803, -18432, -19058, -19686, -20314, -20940, -21567, -22182, -22863, -23188, -22325, -21360, -20417, -19466, -18519, -17569, -16619, -15670, -14721, -13771, -12822, -11877, -10893, -9847, -8799, -7753, -6708, -5660, -4614, -3570, -2524, -1483, -419};