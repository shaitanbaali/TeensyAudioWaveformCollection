/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0036 256 samples */
 
const int16_t AKWF_linear_0036_256_DATA [256] = 
{86, 213, 336, 460, 584, 707, 832, 953, 1090, 1260, 1430, 1600, 1770, 1940, 2110, 2280, 2450, 2620, 2790, 2959, 3129, 3299, 3468, 3638, 3811, 3970, 4192, 4806, 5511, 6200, 6892, 7583, 8275, 8966, 9657, 10350, 11040, 11730, 12422, 13112, 13803, 14494, 15181, 15871, 16566, 16641, 16329, 16067, 15797, 15526, 15254, 14983, 14711, 14440, 14169, 13897, 13625, 13354, 13082, 12811, 12539, 12255, 12038, 11251, 9673, 8123, 6571, 5014, 3461, 1907, 351, -1200, -2755, -4310, -5861, -7415, -8969, -10518, -12071, -13611, -15211, -16472, -16541, -16468, -16425, -16374, -16322, -16271, -16219, -16167, -16115, -16063, -16011, -15959, -15906, -15854, -15801, -15747, -15697, -15633, -15188, -14596, -14028, -13457, -12885, -12312, -11741, -11169, -10596, -10025, -9453, -8881, -8311, -7738, -7167, -6597, -6028, -5441, -5037, -4802, -4549, -4299, -4050, -3800, -3551, -3301, -3052, -2803, -2554, -2305, -2056, -1807, -1559, -1310, -1061, -812, -567, -333, -99, 135, 369, 603, 837, 1072, 1306, 1539, 1773, 2006, 2240, 2474, 2706, 2940, 3172, 3409, 3619, 3637, 3606, 3584, 3560, 3536, 3512, 3489, 3465, 3441, 3417, 3392, 3368, 3344, 3320, 3296, 3272, 3247, 3224, 3164, 3081, 3000, 2920, 2839, 2758, 2677, 2596, 2516, 2435, 2354, 2273, 2193, 2112, 2031, 1950, 1869, 1791, 1683, 1531, 1380, 1229, 1078, 927, 776, 624, 474, 323, 171, 21, -130, -281, -432, -583, -733, -886, -1022, -1093, -1154, -1218, -1281, -1344, -1407, -1470, -1533, -1596, -1659, -1722, -1785, -1848, -1911, -1974, -2036, -2099, -2160, -2138, -2081, -2029, -1977, -1925, -1872, -1820, -1768, -1715, -1663, -1610, -1558, -1506, -1454, -1401, -1349, -1295, -1247, -1158, -1031, -907, -784, -660, -536, -412, -288, -165, -39};