/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0026 256 samples */
 
const int16_t AKWF_linear_0026_256_DATA [256] = 
{1030, 2998, 4400, 5231, 6105, 6972, 7841, 8705, 9571, 10438, 11301, 12167, 13033, 13896, 14762, 15625, 16488, 17352, 18195, 19141, 19509, 18320, 17065, 15826, 14578, 13332, 12087, 10841, 9594, 8348, 7104, 5859, 4612, 3365, 2123, 874, -358, -1633, -2742, -1634, 68, 1651, 3254, 4863, 6471, 8077, 9682, 11289, 12895, 14500, 16109, 17711, 19316, 20923, 22522, 24119, 25774, 26322, 26041, 25865, 25670, 25475, 25279, 25084, 24888, 24691, 24497, 24299, 24103, 23907, 23709, 23514, 23318, 23092, 23015, 21844, 18776, 15735, 12691, 9641, 6600, 3551, 506, -2535, -5584, -8628, -11668, -14716, -17757, -20794, -23839, -26857, -29984, -32506, -32306, -31612, -31017, -30401, -29786, -29169, -28552, -27935, -27316, -26700, -26082, -25463, -24846, -24229, -23609, -22990, -22375, -21746, -20635, -19278, -17955, -16631, -15299, -13972, -12647, -11317, -9990, -8664, -7336, -6008, -4685, -3357, -2031, -708, 610, 1971, 2885, 3290, 3723, 4151, 4582, 5009, 5437, 5865, 6292, 6719, 7146, 7573, 8001, 8427, 8853, 9280, 9695, 10168, 10314, 9544, 8711, 7893, 7074, 6255, 5432, 4612, 3794, 2971, 2151, 1332, 511, -309, -1129, -1947, -2759, -3597, -4352, -3909, -3123, -2399, -1666, -930, -195, 538, 1272, 2007, 2740, 3476, 4210, 4944, 5678, 6413, 7145, 7878, 8625, 9120, 9414, 9735, 10049, 10366, 10680, 10996, 11311, 11625, 11939, 12255, 12569, 12883, 13198, 13511, 13825, 14120, 14520, 14166, 12427, 10698, 8970, 7239, 5512, 3781, 2049, 324, -1407, -3137, -4862, -6594, -8323, -10048, -11777, -13498, -15246, -16847, -17719, -18451, -19211, -19964, -20715, -21469, -22220, -22973, -23725, -24475, -25226, -25978, -26727, -27476, -28228, -28970, -29725, -30454, -29403, -27400, -25529, -23637, -21741, -19842, -17948, -16052, -14157, -12265, -10365, -8470, -6579, -4687, -2797, -871};