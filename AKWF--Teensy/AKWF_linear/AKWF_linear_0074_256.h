/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0074 256 samples */
 
const int16_t AKWF_linear_0074_256_DATA [256] = 
{845, 2680, 4421, 5875, 7272, 8681, 10088, 11493, 12899, 14305, 15707, 17113, 18518, 19914, 21345, 22566, 23296, 24004, 24717, 25426, 26136, 26845, 27554, 28264, 28972, 29679, 30382, 31120, 31523, 31501, 31496, 31491, 31484, 31476, 31468, 31460, 31453, 31445, 31437, 31429, 31418, 31479, 31591, 31696, 31803, 31910, 32017, 32123, 32229, 32337, 32443, 32547, 32661, 32739, 32262, 31567, 30906, 30240, 29572, 28904, 28239, 27570, 26904, 26239, 25553, 24951, 23951, 21080, 17878, 14738, 11578, 8428, 5274, 2116, -1031, -4184, -7340, -10469, -13697, -16343, -17665, -18934, -20218, -21492, -22769, -24045, -25317, -26593, -27867, -29139, -30391, -31759, -32061, -31040, -30086, -29122, -28155, -27188, -26221, -25252, -24286, -23319, -22351, -21386, -20408, -19757, -19337, -18890, -18447, -18006, -17564, -17121, -16679, -16239, -15796, -15356, -14913, -14475, -14097, -13742, -13383, -13025, -12666, -12309, -11952, -11593, -11235, -10878, -10518, -10171, -9761, -9071, -8333, -7604, -6873, -6143, -5412, -4681, -3952, -3221, -2490, -1754, -1059, -83, 1514, 3136, 4751, 6366, 7984, 9601, 11215, 12833, 14449, 16061, 17672, 19314, 20649, 21620, 22608, 23594, 24580, 25564, 26548, 27533, 28516, 29499, 30480, 31452, 32488, 31801, 29953, 28239, 26501, 24765, 23025, 21285, 19550, 17810, 16071, 14335, 12598, 10845, 8817, 6683, 4568, 2453, 333, -1782, -3896, -6015, -8130, -10243, -12349, -14506, -16386, -17049, -17514, -18018, -18513, -19006, -19500, -19993, -20485, -20978, -21471, -21962, -22461, -22908, -23247, -23584, -23921, -24257, -24593, -24930, -25265, -25601, -25937, -26272, -26609, -26941, -27303, -27701, -28096, -28490, -28886, -29280, -29675, -30070, -30464, -30859, -31251, -31640, -32062, -31548, -30422, -29370, -28303, -27239, -26173, -25107, -24043, -22977, -21911, -20845, -19785, -18688, -17054, -15228, -13435, -11638, -9838, -8040, -6246, -4448, -2657, -830};