/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0029 256 samples */
 
const int16_t AKWF_linear_0029_256_DATA [256] = 
{287, 782, 1267, 1753, 2241, 2719, 3308, 4009, 4702, 5397, 6090, 6786, 7480, 8173, 8867, 9561, 10255, 10947, 11642, 12334, 13027, 13719, 14410, 15106, 15779, 16397, 17014, 17631, 18246, 18864, 19479, 20093, 20710, 21324, 21939, 22555, 23169, 23784, 24400, 25012, 25626, 26245, 26832, 27178, 27458, 27749, 28037, 28325, 28613, 28901, 29189, 29475, 29763, 30051, 30337, 30625, 30912, 31198, 31486, 31771, 32066, 32146, 32079, 32031, 31980, 31928, 31876, 31825, 31773, 31721, 31669, 31617, 31565, 31513, 31461, 31409, 31358, 31300, 31269, 31074, 30613, 30162, 29710, 29258, 28805, 28352, 27901, 27449, 26996, 26545, 26092, 25640, 25189, 24736, 24286, 23833, 23388, 22900, 22210, 21493, 20782, 20070, 19356, 18645, 17933, 17221, 16511, 15798, 15086, 14376, 13664, 12953, 12244, 11533, 10822, 10111, 9313, 8475, 7645, 6812, 5979, 5149, 4317, 3485, 2655, 1823, 993, 163, -669, -1498, -2328, -3159, -3986, -4818, -5619, -6382, -7150, -7917, -8682, -9449, -10216, -10980, -11745, -12511, -13275, -14041, -14806, -15568, -16333, -17098, -17858, -18631, -19343, -19904, -20456, -21009, -21562, -22114, -22666, -23218, -23771, -24322, -24874, -25426, -25977, -26528, -27080, -27630, -28179, -28736, -29260, -29518, -29696, -29888, -30077, -30265, -30454, -30643, -30832, -31020, -31208, -31396, -31584, -31772, -31961, -32148, -32335, -32521, -32719, -32678, -32465, -32270, -32071, -31875, -31677, -31478, -31281, -31083, -30884, -30687, -30489, -30290, -30093, -29896, -29698, -29496, -29314, -29014, -28513, -28018, -27522, -27027, -26530, -26035, -25540, -25044, -24548, -24054, -23557, -23063, -22567, -22072, -21578, -21082, -20593, -20064, -19314, -18532, -17758, -16982, -16205, -15431, -14655, -13878, -13105, -12330, -11554, -10780, -10006, -9230, -8458, -7684, -6909, -6138, -5563, -5087, -4597, -4108, -3620, -3133, -2645, -2158, -1671, -1184, -699, -203};