/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0023 256 samples */
 
const int16_t AKWF_linear_0023_256_DATA [256] = 
{159, 428, 690, 954, 1266, 1599, 1930, 2260, 2591, 2922, 3252, 3583, 3914, 4244, 4574, 4905, 5234, 5565, 5895, 6225, 6557, 6879, 7285, 7784, 8274, 8765, 9256, 9749, 10239, 10730, 11222, 11711, 12203, 12694, 13184, 13676, 14165, 14654, 15146, 15635, 16134, 16668, 17202, 17737, 18272, 18804, 19339, 19873, 20406, 20940, 21474, 22006, 22540, 23073, 23605, 24138, 24671, 25204, 25728, 26138, 26515, 26900, 27281, 27662, 28045, 28426, 28808, 29190, 29571, 29952, 30333, 30714, 31096, 31477, 31856, 32235, 32624, 32780, 32761, 32763, 32761, 32758, 32756, 32754, 32751, 32749, 32748, 32744, 32741, 32740, 32737, 32733, 32731, 32717, 32764, 32332, 31087, 29849, 28612, 27371, 26134, 24894, 23653, 22416, 21177, 19937, 18701, 17462, 16223, 14986, 13748, 12508, 11282, 9992, 8429, 6822, 5220, 3618, 2019, 416, -1184, -2782, -4383, -5983, -7580, -9181, -10779, -12375, -13975, -15568, -17168, -18754, -19535, -19925, -20372, -20806, -21241, -21675, -22109, -22543, -22977, -23409, -23843, -24276, -24709, -25141, -25574, -26006, -26433, -26887, -27093, -27020, -26968, -26912, -26856, -26798, -26741, -26684, -26628, -26571, -26514, -26458, -26401, -26343, -26287, -26229, -26171, -26121, -26026, -25799, -25569, -25339, -25109, -24880, -24649, -24419, -24190, -23961, -23729, -23500, -23270, -23040, -22812, -22580, -22351, -22123, -21890, -21599, -21292, -20988, -20684, -20380, -20075, -19772, -19467, -19163, -18859, -18556, -18252, -17948, -17644, -17340, -17037, -16734, -16429, -16139, -15857, -15573, -15292, -15009, -14727, -14446, -14163, -13880, -13600, -13317, -13036, -12755, -12472, -12190, -11910, -11627, -11351, -11029, -10626, -10225, -9824, -9421, -9020, -8618, -8215, -7815, -7414, -7012, -6612, -6211, -5809, -5409, -5008, -4607, -4204, -3822, -3540, -3279, -3013, -2749, -2485, -2220, -1956, -1693, -1429, -1164, -901, -637, -373, -106};