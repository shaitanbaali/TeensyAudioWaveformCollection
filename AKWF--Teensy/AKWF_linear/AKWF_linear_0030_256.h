/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0030 256 samples */
 
const int16_t AKWF_linear_0030_256_DATA [256] = 
{250, 646, 1033, 1421, 1809, 2198, 2586, 2973, 3360, 3748, 4135, 4523, 4910, 5297, 5690, 6055, 6650, 7486, 8298, 9111, 9927, 10742, 11554, 12371, 13185, 13997, 14812, 15626, 16439, 17253, 18065, 18878, 19688, 20514, 21242, 21719, 22187, 22658, 23128, 23596, 24066, 24535, 25004, 25472, 25941, 26410, 26878, 27346, 27814, 28282, 28749, 29219, 29666, 29888, 30047, 30219, 30388, 30555, 30724, 30893, 31062, 31230, 31398, 31566, 31734, 31902, 32070, 32238, 32405, 32572, 32745, 32675, 32431, 32206, 31978, 31750, 31521, 31293, 31064, 30836, 30608, 30379, 30151, 29923, 29695, 29467, 29239, 29007, 28791, 28452, 27910, 27370, 26833, 26295, 25756, 25216, 24677, 24140, 23601, 23062, 22524, 21985, 21447, 20910, 20373, 19831, 19302, 18726, 17964, 17174, 16389, 15600, 14817, 14029, 13243, 12458, 11672, 10887, 10103, 9317, 8533, 7748, 6963, 6178, 5395, 4609, 3780, 2931, 2083, 1236, 390, -458, -1303, -2149, -2996, -3841, -4687, -5534, -6377, -7224, -8069, -8911, -9755, -10607, -11372, -12048, -12731, -13411, -14093, -14772, -15452, -16133, -16812, -17491, -18172, -18851, -19528, -20207, -20886, -21564, -22240, -22926, -23556, -24030, -24497, -24965, -25434, -25901, -26368, -26837, -27304, -27771, -28239, -28705, -29173, -29639, -30105, -30572, -31036, -31508, -31946, -32052, -32058, -32084, -32106, -32127, -32148, -32171, -32193, -32214, -32235, -32257, -32278, -32299, -32321, -32341, -32363, -32382, -32407, -32300, -32090, -31893, -31693, -31495, -31294, -31096, -30896, -30696, -30498, -30298, -30098, -29899, -29700, -29500, -29302, -29096, -28922, -28500, -27647, -26797, -25951, -25100, -24251, -23403, -22553, -21705, -20856, -20008, -19159, -18310, -17461, -16615, -15768, -14920, -14070, -13246, -12545, -11870, -11188, -10507, -9828, -9146, -8465, -7788, -7108, -6427, -5750, -5070, -4391, -3714, -3034, -2356, -1679, -1002, -529, -144};