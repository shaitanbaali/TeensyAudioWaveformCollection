/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0069 256 samples */
 
const int16_t AKWF_linear_0069_256_DATA [256] = 
{1157, 4909, 8560, 12362, 14994, 16288, 17713, 19111, 20510, 21910, 23306, 24702, 26101, 27495, 28888, 30268, 31744, 31263, 29573, 28073, 26534, 24995, 23459, 21919, 20381, 18844, 17305, 15775, 14218, 12763, 13081, 13943, 14699, 15476, 16252, 17030, 17807, 18583, 19362, 20137, 20900, 21731, 22226, 21189, 19978, 18810, 17631, 16451, 15275, 14095, 12916, 11740, 10560, 9404, 8134, 7552, 8422, 9272, 10120, 10972, 11823, 12676, 13528, 14379, 15233, 16084, 16930, 17804, 18460, 18877, 19316, 19751, 20186, 20622, 21057, 21492, 21928, 22361, 22794, 23220, 23696, 23035, 21693, 20459, 19201, 17943, 16689, 15432, 14175, 12921, 11664, 10415, 9144, 7959, 8070, 8570, 8995, 9432, 9871, 10311, 10750, 11188, 11628, 12067, 12481, 13017, 12939, 10211, 7191, 4247, 1282, -1683, -4642, -7608, -10573, -13530, -16494, -19400, -22604, -23928, -21423, -18977, -16533, -14082, -11631, -9173, -6722, -4271, -1815, 635, 3068, 5607, 7202, 7777, 8453, 9111, 9768, 10426, 11082, 11738, 12395, 13050, 13700, 14345, 15063, 13609, 10880, 8353, 5782, 3212, 649, -1921, -4489, -7052, -9623, -12176, -14773, -17183, -17098, -16284, -15611, -14912, -14212, -13510, -12810, -12109, -11407, -10708, -10024, -9254, -8925, -10389, -12042, -13644, -15263, -16882, -18497, -20115, -21732, -23345, -24962, -26548, -28298, -28971, -27529, -26124, -24719, -23308, -21899, -20487, -19078, -17667, -16256, -14848, -13453, -11971, -11330, -11573, -11729, -11900, -12071, -12242, -12415, -12586, -12758, -12930, -13103, -13275, -13442, -13844, -14383, -14898, -15419, -15941, -16460, -16981, -17502, -18021, -18543, -19059, -19588, -20061, -19876, -19502, -19165, -18820, -18477, -18131, -17787, -17444, -17100, -16755, -16424, -16030, -15968, -17205, -18574, -19908, -21253, -22598, -23939, -25283, -26627, -27967, -29311, -30603, -32168, -31898, -28149, -24470, -20784, -17094, -13408, -9720, -6041, -2288};