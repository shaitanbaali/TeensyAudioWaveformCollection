/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0062 256 samples */
 
const int16_t AKWF_linear_0062_256_DATA [256] = 
{29, 125, 223, 318, 413, 509, 605, 700, 795, 892, 988, 1082, 1182, 1633, 2274, 2894, 3516, 4138, 4759, 5379, 6003, 6625, 7244, 7866, 8487, 9106, 9730, 10351, 10970, 11591, 12210, 12829, 13452, 14071, 14689, 15310, 15928, 16548, 17169, 17786, 18405, 19024, 19642, 20262, 20880, 21496, 22114, 22733, 23351, 23969, 24585, 25201, 25817, 26435, 27053, 27669, 28285, 28899, 29515, 30133, 30749, 31363, 31969, 32623, 32575, 31869, 31218, 30556, 29894, 29231, 28568, 27907, 27243, 26580, 25919, 25256, 24595, 23935, 23272, 22610, 21949, 21287, 20624, 19964, 19301, 18640, 17979, 17318, 16660, 16000, 15339, 14678, 14019, 13357, 12698, 12038, 11377, 10719, 10059, 9402, 8744, 8085, 7426, 6768, 6110, 5450, 4793, 4135, 3476, 2820, 2164, 1508, 852, 196, -465, -1086, -1648, -2210, -2771, -3332, -3893, -4453, -5014, -5574, -6135, -6695, -7254, -7813, -8374, -8933, -9493, -10052, -10611, -11168, -11729, -12287, -12845, -13404, -13961, -14518, -15079, -15634, -16192, -16749, -17306, -17863, -18420, -18976, -19534, -20090, -20646, -21203, -21758, -22314, -22870, -23426, -23980, -24536, -25091, -25646, -26201, -26755, -27308, -27865, -28409, -28998, -29325, -28883, -28368, -27868, -27364, -26860, -26356, -25851, -25347, -24843, -24340, -23835, -23332, -22828, -22323, -21819, -21317, -20812, -20308, -19806, -19302, -18799, -18296, -17792, -17288, -16787, -16283, -15781, -15278, -14776, -14274, -13772, -13269, -12768, -12265, -11764, -11263, -10761, -10257, -9759, -9256, -8756, -8255, -7754, -7252, -6755, -6253, -5752, -5252, -4756, -4247, -3788, -3625, -3539, -3439, -3342, -3243, -3146, -3049, -2952, -2855, -2758, -2661, -2564, -2468, -2371, -2274, -2177, -2081, -1984, -1888, -1791, -1694, -1598, -1503, -1405, -1309, -1214, -1117, -1020, -925, -829, -732, -637, -541, -445, -349, -254, -158, -59};