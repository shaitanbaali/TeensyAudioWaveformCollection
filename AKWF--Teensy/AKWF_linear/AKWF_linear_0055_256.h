/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0055 256 samples */
 
const int16_t AKWF_linear_0055_256_DATA [256] = 
{1476, 3680, 5900, 7647, 8688, 9766, 10840, 11910, 12980, 14054, 15122, 16191, 17263, 18330, 19401, 20470, 21536, 22604, 23673, 24731, 25828, 26719, 26852, 26888, 26947, 26997, 27051, 27103, 27154, 27206, 27257, 27308, 27360, 27410, 27462, 27514, 27563, 27612, 27666, 27700, 27385, 26920, 26478, 26032, 25586, 25140, 24694, 24247, 23801, 23356, 22910, 22464, 22017, 21571, 21126, 20678, 20214, 19854, 18173, 15216, 12361, 9483, 6611, 3738, 860, -2010, -4883, -7758, -10627, -13498, -16373, -19238, -22109, -24982, -27812, -30824, -32748, -32212, -31581, -30977, -30362, -29747, -29132, -28516, -27898, -27282, -26667, -26048, -25432, -24816, -24198, -23581, -22954, -22370, -21597, -19289, -16611, -14006, -11388, -8762, -6145, -3526, -902, 1712, 4331, 6954, 9566, 12184, 14805, 17417, 20031, 22621, 25369, 25396, 23672, 22213, 20701, 19192, 17684, 16171, 14662, 13154, 11642, 10132, 8623, 7111, 5602, 4092, 2582, 1080, -460, -1719, -2534, -3371, -4206, -5037, -5869, -6702, -7533, -8366, -9197, -10026, -10860, -11691, -12519, -13351, -14181, -14988, -15902, -16229, -14202, -11841, -9557, -7257, -4953, -2652, -352, 1953, 4251, 6551, 8856, 11153, 13452, 15755, 18052, 20335, 22660, 24845, 23973, 21718, 19681, 17599, 15515, 13437, 11355, 9272, 7194, 5111, 3030, 952, -1129, -3210, -5287, -7369, -9434, -11572, -12777, -13018, -13326, -13624, -13920, -14217, -14513, -14808, -15103, -15399, -15695, -15989, -16284, -16579, -16872, -17166, -17446, -17798, -17719, -16622, -15470, -14331, -13190, -12046, -10903, -9762, -8618, -7477, -6337, -5192, -4050, -2911, -1766, -625, 499, 1686, 2606, 1189, -843, -2762, -4704, -6650, -8590, -10532, -12476, -14416, -16358, -18303, -20241, -22183, -24126, -26064, -28002, -29915, -31991, -31411, -29027, -26897, -24715, -22533, -20358, -18176, -15997, -13820, -11640, -9461, -7285, -5108, -2937, -722};