/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0041 256 samples */
 
const int16_t AKWF_linear_0041_256_DATA [256] = 
{852, 3201, 5502, 7808, 10114, 12421, 14731, 17028, 19348, 21596, 22365, 22576, 22878, 23159, 23442, 23723, 24005, 24286, 24566, 24847, 25128, 25408, 25687, 25967, 26247, 26525, 26795, 27115, 26931, 26280, 25681, 25071, 24461, 23853, 23245, 22635, 22026, 21417, 20807, 20199, 19590, 18981, 18373, 17764, 17166, 16511, 16196, 16667, 17141, 17612, 18085, 18557, 19031, 19504, 19977, 20451, 20924, 21397, 21869, 22343, 22816, 23289, 23750, 24260, 24529, 23071, 21200, 19410, 17606, 15802, 13994, 12191, 10387, 8580, 6779, 4974, 3169, 1368, -435, -2239, -4037, -5838, -7651, -8750, -9394, -10096, -10787, -11478, -12168, -12857, -13545, -14235, -14923, -15613, -16301, -16988, -17678, -18365, -19051, -19726, -20469, -20614, -19894, -19200, -18503, -17803, -17106, -16406, -15705, -15008, -14308, -13607, -12910, -12211, -11510, -10813, -10113, -9419, -8702, -8113, -7984, -7916, -7835, -7757, -7679, -7602, -7525, -7447, -7369, -7292, -7215, -7137, -7060, -6983, -6906, -6827, -6754, -6660, -6069, -5276, -4514, -3747, -2979, -2211, -1446, -677, 90, 854, 1623, 2390, 3154, 3922, 4688, 5454, 6225, 6965, 8011, 9355, 10670, 11988, 13307, 14625, 15943, 17263, 18578, 19896, 21214, 22529, 23846, 25165, 26478, 27793, 29078, 30528, 31039, 29218, 27376, 25545, 23707, 21874, 20035, 18197, 16364, 14525, 12688, 10855, 9017, 7181, 5349, 3511, 1677, -157, -1981, -3685, -5359, -7043, -8720, -10399, -12078, -13754, -15433, -17111, -18786, -20463, -22140, -23814, -25490, -27166, -28834, -30504, -32204, -32754, -32524, -32392, -32242, -32092, -31941, -31790, -31638, -31487, -31336, -31185, -31033, -30881, -30729, -30577, -30424, -30268, -30133, -29834, -29289, -28751, -28210, -27669, -27129, -26591, -26049, -25510, -24969, -24429, -23890, -23349, -22808, -22270, -21730, -21176, -20689, -19854, -17707, -15367, -13062, -10751, -8443, -6133, -3830, -1480};