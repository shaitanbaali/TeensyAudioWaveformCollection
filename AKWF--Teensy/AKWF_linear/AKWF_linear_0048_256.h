/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0048 256 samples */
 
const int16_t AKWF_linear_0048_256_DATA [256] = 
{45, 141, 234, 328, 421, 515, 609, 701, 795, 889, 991, 1048, 1395, 2323, 3257, 4190, 5121, 6055, 6988, 7919, 8852, 9786, 10716, 11649, 12582, 13512, 14444, 15375, 16304, 17241, 18153, 18919, 19660, 20405, 21148, 21893, 22635, 23378, 24122, 24864, 25607, 26350, 27090, 27834, 28576, 29317, 30056, 30795, 31550, 31707, 31519, 31383, 31238, 31092, 30945, 30800, 30654, 30508, 30362, 30215, 30069, 29923, 29777, 29631, 29484, 29341, 29183, 29150, 29288, 29416, 29547, 29678, 29810, 29940, 30070, 30201, 30332, 30462, 30593, 30723, 30854, 30986, 31116, 31243, 31385, 31441, 31210, 30946, 30689, 30429, 30170, 29912, 29653, 29394, 29136, 28877, 28618, 28360, 28101, 27843, 27584, 27318, 27076, 26734, 24939, 22573, 20305, 18014, 15722, 13437, 11145, 8855, 6570, 4280, 1991, -291, -2580, -4867, -7149, -9436, -11712, -14036, -15627, -16553, -17534, -18508, -19480, -20451, -21423, -22392, -23361, -24332, -25300, -26268, -27239, -28205, -29174, -30142, -31097, -32111, -32765, -32665, -32548, -32438, -32324, -32209, -32096, -31981, -31866, -31751, -31636, -31522, -31407, -31292, -31176, -31061, -30948, -30827, -30731, -30802, -30906, -31004, -31104, -31203, -31303, -31401, -31500, -31600, -31699, -31798, -31897, -31996, -32096, -32194, -32292, -32389, -32499, -32318, -31964, -31637, -31304, -30971, -30638, -30305, -29973, -29641, -29308, -28975, -28644, -28310, -27978, -27646, -27313, -26973, -26679, -26014, -24819, -23650, -22476, -21304, -20131, -18956, -17785, -16612, -15438, -14267, -13095, -11922, -10752, -9579, -8407, -7243, -6053, -4997, -4418, -3897, -3364, -2835, -2305, -1776, -1247, -719, -190, 337, 866, 1394, 1920, 2449, 2976, 3500, 4034, 4531, 4455, 4139, 3861, 3576, 3290, 3004, 2717, 2432, 2146, 1860, 1574, 1289, 1002, 716, 430, 144, -138, -437, -528, -421, -330, -236, -143, -49};