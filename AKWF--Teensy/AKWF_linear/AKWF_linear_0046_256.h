/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0046 256 samples */
 
const int16_t AKWF_linear_0046_256_DATA [256] = 
{121, 460, 793, 1127, 1456, 1814, 2315, 2841, 3363, 3886, 4408, 4931, 5453, 5975, 6497, 7019, 7541, 8063, 8585, 9105, 9628, 10149, 10668, 11191, 11773, 12386, 12997, 13607, 14218, 14828, 15437, 16047, 16657, 17266, 17876, 18484, 19094, 19702, 20312, 20920, 21526, 22144, 22662, 23062, 23472, 23878, 24285, 24692, 25098, 25504, 25910, 26316, 26722, 27128, 27534, 27939, 28344, 28749, 29153, 29566, 29921, 30088, 30244, 30402, 30560, 30718, 30876, 31033, 31191, 31348, 31505, 31663, 31820, 31977, 32134, 32292, 32447, 32606, 32746, 32617, 32396, 32193, 31986, 31778, 31571, 31365, 31158, 30949, 30743, 30536, 30328, 30122, 29914, 29707, 29500, 29290, 29096, 28611, 27881, 27176, 26470, 25761, 25053, 24347, 23639, 22929, 22223, 21516, 20807, 20102, 19395, 18688, 17981, 17270, 16584, 15707, 14463, 13215, 11972, 10724, 9477, 8234, 6987, 5741, 4497, 3251, 2007, 764, -481, -1723, -2966, -4209, -5455, -6667, -7692, -8675, -9666, -10657, -11645, -12634, -13624, -14609, -15598, -16586, -17573, -18561, -19548, -20534, -21520, -22505, -23490, -24479, -25073, -25455, -25867, -26273, -26678, -27083, -27488, -27893, -28298, -28703, -29106, -29510, -29914, -30318, -30722, -31125, -31524, -31947, -32177, -32165, -32166, -32165, -32165, -32166, -32165, -32163, -32163, -32163, -32162, -32160, -32158, -32158, -32157, -32155, -32151, -32162, -32100, -31788, -31460, -31137, -30813, -30489, -30164, -29839, -29516, -29191, -28867, -28542, -28218, -27894, -27570, -27246, -26921, -26599, -26269, -25804, -25295, -24791, -24288, -23786, -23282, -22778, -22276, -21772, -21268, -20766, -20263, -19761, -19258, -18756, -18253, -17749, -17253, -16647, -15943, -15248, -14553, -13858, -13161, -12467, -11773, -11076, -10383, -9687, -8993, -8301, -7605, -6910, -6218, -5527, -4819, -4236, -3896, -3562, -3227, -2892, -2557, -2222, -1887, -1554, -1220, -887, -554, -214};