/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0056 256 samples */
 
const int16_t AKWF_linear_0056_256_DATA [256] = 
{807, 3383, 5907, 8437, 10964, 13494, 16029, 18555, 21085, 23616, 26095, 28825, 29984, 28259, 26583, 24906, 23226, 21541, 19856, 18176, 16489, 14806, 13125, 11439, 9755, 8074, 6389, 4706, 3025, 1342, -347, -2092, -3850, -5602, -7355, -9112, -10863, -12615, -14370, -16119, -17872, -19625, -21372, -23123, -24876, -26622, -28368, -30118, -31869, -32441, -32386, -32428, -32452, -32476, -32499, -32521, -32544, -32566, -32589, -32611, -32633, -32655, -32676, -32697, -32719, -32736, -32779, -32538, -31942, -31365, -30785, -30207, -29627, -29047, -28469, -27888, -27309, -26730, -26150, -25570, -24992, -24412, -23833, -23246, -22705, -21869, -20170, -18384, -16619, -14852, -13080, -11312, -9547, -7776, -6008, -4242, -2473, -708, 1057, 2825, 4589, 6352, 8127, 9854, 11118, 12221, 13347, 14469, 15593, 16713, 17835, 18956, 20074, 21195, 22316, 23433, 24554, 25673, 26791, 27907, 29011, 30195, 30105, 28975, 27950, 26906, 25860, 24816, 23769, 22724, 21680, 20633, 19589, 18544, 17497, 16454, 15409, 14363, 13325, 12258, 11360, 10789, 10215, 9640, 9067, 8493, 7920, 7348, 6775, 6202, 5631, 5058, 4485, 3915, 3343, 2771, 2204, 1622, 1094, 917, 799, 667, 540, 412, 284, 156, 29, -97, -223, -351, -478, -605, -733, -860, -986, -1111, -1244, -998, -542, -120, 309, 739, 1169, 1597, 2027, 2455, 2885, 3315, 3743, 4172, 4601, 5029, 5459, 5894, 6294, 7013, 8148, 9261, 10378, 11493, 12610, 13727, 14841, 15957, 17074, 18187, 19303, 20418, 21531, 22646, 23762, 24848, 26065, 26514, 24563, 22355, 20207, 18047, 15880, 13717, 11557, 9392, 7230, 5069, 2905, 745, -1415, -3579, -5737, -7889, -10070, -12134, -12775, -12888, -13084, -13262, -13442, -13621, -13799, -13978, -14155, -14333, -14511, -14688, -14866, -15043, -15220, -15395, -15552, -15817, -14522, -11888, -9380, -6849, -4326, -1750};