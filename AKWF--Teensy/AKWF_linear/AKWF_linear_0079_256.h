/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0079 256 samples */
 
const int16_t AKWF_linear_0079_256_DATA [256] = 
{1160, 3003, 4808, 6618, 8426, 10226, 12079, 13603, 14331, 15013, 15705, 16394, 17084, 17770, 18459, 19147, 19833, 20521, 21208, 21893, 22580, 23267, 23951, 24638, 25323, 26007, 26693, 27377, 28060, 28746, 29427, 30105, 30816, 30713, 29990, 29335, 28668, 28000, 27333, 26667, 25999, 25331, 24663, 23995, 23328, 22662, 21994, 21326, 20661, 19993, 19325, 18660, 17993, 17326, 16660, 15993, 15334, 14643, 14123, 14456, 14959, 15428, 15904, 16380, 16856, 17332, 17808, 18285, 18761, 19237, 19714, 20189, 20665, 21142, 21617, 22093, 22569, 23044, 23520, 23996, 24471, 24946, 25410, 25936, 25860, 24995, 24167, 23333, 22498, 21664, 20828, 19994, 19161, 18324, 17491, 16656, 15821, 14988, 14154, 13319, 12487, 11653, 10820, 9986, 9154, 8320, 7489, 6658, 5821, 5012, 4637, 4439, 4213, 3991, 3770, 3550, 3329, 3107, 2888, 2668, 2447, 2227, 2007, 1787, 1567, 1348, 1128, 908, 689, 469, 250, 31, -188, -408, -620, -895, -1319, -1749, -2177, -2607, -3036, -3464, -3894, -4323, -4751, -5179, -5607, -6036, -6464, -6893, -7319, -7748, -8176, -8603, -9032, -9459, -9886, -10313, -10741, -11168, -11592, -12132, -12757, -13372, -13986, -14603, -15219, -15834, -16450, -17067, -17680, -18297, -18912, -19526, -20141, -20756, -21370, -21984, -22599, -23212, -23825, -24440, -25053, -25666, -26273, -26911, -27378, -27072, -26625, -26206, -25782, -25357, -24932, -24507, -24083, -23657, -23232, -22807, -22382, -21958, -21532, -21108, -20683, -20259, -19834, -19409, -18984, -18559, -18135, -17711, -17296, -16831, -16873, -17536, -18168, -18804, -19442, -20078, -20716, -21353, -21989, -22628, -23264, -23900, -24538, -25175, -25811, -26448, -27083, -27720, -28357, -28992, -29628, -30265, -30900, -31526, -32184, -32706, -31469, -29565, -27773, -25956, -24139, -22326, -20510, -18693, -16880, -15064, -13249, -11436, -9621, -7807, -5995, -4183, -2377, -533};