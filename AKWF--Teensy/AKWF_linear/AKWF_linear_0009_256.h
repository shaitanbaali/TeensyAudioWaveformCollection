/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0009 256 samples */
 
const int16_t AKWF_linear_0009_256_DATA [256] = 
{532, 1760, 2963, 4169, 5376, 6582, 7790, 8994, 10206, 11391, 12162, 12814, 13487, 14156, 14825, 15494, 16163, 16832, 17501, 18170, 18840, 19509, 20177, 20847, 21516, 22183, 22851, 23531, 24025, 24372, 24737, 25099, 25462, 25825, 26187, 26551, 26913, 27274, 27637, 27999, 28362, 28725, 29086, 29448, 29809, 30181, 30468, 30589, 30713, 30837, 30961, 31085, 31209, 31332, 31456, 31580, 31705, 31828, 31951, 32075, 32199, 32323, 32445, 32573, 32669, 32598, 32495, 32398, 32299, 32202, 32103, 32005, 31906, 31809, 31710, 31612, 31513, 31415, 31317, 31219, 31120, 31022, 30923, 30723, 30468, 30222, 29973, 29724, 29477, 29229, 28980, 28733, 28485, 28236, 27989, 27740, 27492, 27243, 26995, 26743, 26511, 26092, 25447, 24816, 24181, 23546, 22911, 22276, 21642, 21008, 20373, 19737, 19104, 18469, 17833, 17200, 16565, 15925, 15312, 14556, 13393, 12198, 11006, 9815, 8625, 7431, 6239, 5048, 3854, 2663, 1472, 279, -911, -2103, -3296, -4487, -5678, -6879, -8215, -9599, -10976, -12351, -13728, -15107, -16481, -17859, -19237, -20612, -21991, -23368, -24744, -26122, -27499, -28873, -30240, -31674, -32302, -32262, -32306, -32335, -32365, -32397, -32427, -32457, -32486, -32516, -32544, -32574, -32606, -32636, -32665, -32695, -32724, -32760, -32738, -32599, -32461, -32321, -32182, -32044, -31905, -31766, -31628, -31489, -31350, -31211, -31071, -30933, -30793, -30654, -30516, -30375, -30250, -30211, -30190, -30166, -30141, -30118, -30095, -30071, -30047, -30023, -30000, -29977, -29954, -29929, -29905, -29882, -29859, -29835, -29810, -29680, -29489, -29306, -29121, -28937, -28752, -28568, -28383, -28198, -28014, -27829, -27645, -27460, -27275, -27091, -26906, -26715, -26559, -26082, -25196, -24329, -23460, -22588, -21719, -20846, -19975, -19106, -18235, -17364, -16495, -15622, -14751, -13882, -13010, -12136, -11279, -10338, -9152, -7942, -6735, -5529, -4323, -3117, -1914, -687};