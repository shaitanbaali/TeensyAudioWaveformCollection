/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0058 256 samples */
 
const int16_t AKWF_linear_0058_256_DATA [256] = 
{227, 812, 1386, 1957, 2550, 3213, 3882, 4548, 5216, 5883, 6550, 7217, 7884, 8550, 9217, 9883, 10547, 11213, 11880, 12543, 13208, 13880, 14508, 14662, 14647, 14660, 14668, 14676, 14683, 14691, 14697, 14705, 14712, 14719, 14725, 14732, 14740, 14746, 14753, 14759, 14766, 14761, 14745, 14731, 14717, 14701, 14686, 14672, 14657, 14642, 14627, 14612, 14598, 14583, 14568, 14552, 14538, 14524, 14506, 14508, 14548, 14589, 14629, 14669, 14709, 14749, 14790, 14830, 14870, 14910, 14951, 14991, 15031, 15072, 15112, 15148, 15202, 15176, 14696, 14130, 13582, 13029, 12475, 11923, 11371, 10818, 10267, 9713, 9161, 8610, 8057, 7505, 6955, 6402, 5851, 5300, 4761, 4231, 3700, 3168, 2639, 2108, 1578, 1048, 518, -13, -542, -1072, -1602, -2130, -2660, -3189, -3716, -4253, -4721, -5098, -5484, -5867, -6250, -6633, -7017, -7398, -7782, -8165, -8547, -8930, -9312, -9694, -10076, -10457, -10835, -11233, -11523, -11467, -11378, -11297, -11214, -11130, -11047, -10963, -10880, -10796, -10712, -10629, -10545, -10461, -10378, -10294, -10211, -10127, -10044, -9976, -9914, -9852, -9788, -9725, -9663, -9600, -9538, -9474, -9411, -9350, -9287, -9224, -9161, -9099, -9035, -8966, -8934, -8293, -7117, -5989, -4853, -3718, -2581, -1444, -311, 825, 1961, 3095, 4231, 5366, 6498, 7634, 8768, 9882, 11098, 11646, 10872, 10066, 9271, 8472, 7670, 6869, 6069, 5267, 4468, 3668, 2866, 2067, 1266, 465, -334, -1138, -1922, -2807, -4337, -6005, -7643, -9290, -10937, -12579, -14225, -15871, -17513, -19159, -20803, -22443, -24089, -25731, -27371, -29011, -30641, -32343, -32008, -30515, -29195, -27840, -26488, -25134, -23779, -22429, -21074, -19719, -18368, -17013, -15659, -14308, -12954, -11601, -10258, -8868, -7827, -7279, -6695, -6117, -5541, -4963, -4388, -3813, -3235, -2659, -2085, -1510, -936, -351};