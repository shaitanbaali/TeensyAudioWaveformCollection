/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0076 256 samples */
 
const int16_t AKWF_linear_0076_256_DATA [256] = 
{916, 3370, 5774, 8185, 10593, 13003, 15417, 17822, 20233, 22643, 25046, 27447, 29867, 32216, 32554, 31952, 31497, 31013, 30529, 30043, 29555, 29071, 28587, 28101, 27616, 27131, 26645, 26159, 25674, 25187, 24699, 24214, 23727, 23242, 22757, 22271, 21786, 21289, 20846, 20065, 18352, 16571, 14814, 13046, 11279, 9516, 7749, 5982, 4220, 2455, 689, -1070, -2836, -4600, -6360, -8126, -9887, -11645, -13409, -15169, -16926, -18690, -20444, -22189, -24016, -24270, -23228, -22324, -21396, -20468, -19537, -18606, -17677, -16746, -15818, -14887, -13957, -13028, -12097, -11168, -10239, -9308, -8378, -7451, -6519, -5590, -4663, -3733, -2810, -1864, -1048, -1005, -1131, -1223, -1323, -1424, -1522, -1623, -1722, -1823, -1923, -2023, -2124, -2224, -2325, -2424, -2525, -2625, -2726, -2825, -2928, -3027, -3127, -3228, -3326, -3437, -3419, -3214, -3015, -2815, -2615, -2417, -2217, -2017, -1818, -1618, -1418, -1218, -1019, -820, -621, -421, -222, -22, 177, 376, 573, 770, 969, 1167, 1368, 1557, 1471, 1263, 1075, 883, 690, 499, 306, 114, -77, -269, -462, -654, -846, -1037, -1230, -1422, -1614, -1805, -1997, -2190, -2381, -2573, -2766, -2954, -3160, -3262, -3107, -2936, -2769, -2601, -2433, -2266, -2098, -1930, -1763, -1595, -1427, -1260, -1092, -923, -756, -588, -421, -253, -86, 81, 248, 416, 583, 751, 919, 1091, 1268, 1446, 1622, 1799, 1976, 2153, 2329, 2504, 2682, 2859, 3035, 3210, 3388, 3565, 3740, 3915, 4093, 4269, 4445, 4620, 4795, 4973, 5139, 5348, 5333, 4185, 2803, 1466, 122, -1222, -2568, -3913, -5256, -6603, -7946, -9290, -10636, -11977, -13321, -14666, -16006, -17351, -18694, -20034, -21377, -22720, -24059, -25399, -26707, -28197, -27977, -25481, -23085, -20674, -18259, -15849, -13431, -11018, -8608, -6196, -3791, -1337};