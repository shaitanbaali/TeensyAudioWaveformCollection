/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0017 256 samples */
 
const int16_t AKWF_linear_0017_256_DATA [256] = 
{510, 1663, 2791, 3924, 5054, 6186, 7318, 8457, 9624, 10794, 11961, 13130, 14300, 15466, 16635, 17802, 18968, 20136, 21302, 22467, 23635, 24801, 25964, 27126, 28302, 29406, 29692, 29689, 29734, 29771, 29806, 29842, 29878, 29913, 29949, 29984, 30018, 30053, 30087, 30123, 30157, 30189, 30214, 30302, 29171, 27031, 24984, 22921, 20862, 18798, 16734, 14676, 12612, 10550, 8492, 6430, 4369, 2312, 250, -1809, -3848, -5984, -7476, -7765, -8041, -8324, -8600, -8877, -9154, -9430, -9707, -9982, -10257, -10534, -10808, -11083, -11358, -11632, -11898, -12202, -12331, -11475, -10430, -9424, -8408, -7392, -6377, -5360, -4345, -3331, -2314, -1298, -284, 730, 1745, 2759, 3774, 4786, 5809, 6441, 6862, 7316, 7765, 8212, 8660, 9107, 9553, 10000, 10448, 10893, 11341, 11788, 12233, 12679, 13125, 13552, 14080, 13811, 12493, 11249, 9996, 8743, 7485, 6231, 4977, 3721, 2466, 1213, -43, -1295, -2548, -3805, -5056, -6310, -7563, -8827, -10147, -11472, -12791, -14114, -15437, -16756, -18079, -19400, -20719, -22039, -23360, -24678, -25999, -27319, -28635, -29948, -31281, -32525, -32633, -32313, -32067, -31805, -31543, -31282, -31020, -30757, -30497, -30234, -29971, -29709, -29446, -29184, -28921, -28657, -28385, -28169, -27008, -25024, -23111, -21185, -19265, -17338, -15412, -13491, -11566, -9640, -7721, -5796, -3873, -1954, -30, 1890, 3793, 5784, 7205, 7510, 7788, 8073, 8354, 8636, 8916, 9197, 9477, 9757, 10037, 10317, 10596, 10875, 11155, 11433, 11704, 12010, 12154, 11323, 10285, 9288, 8281, 7275, 6270, 5263, 4257, 3252, 2245, 1239, 234, -772, -1776, -2781, -3787, -4789, -5805, -6376, -6691, -7045, -7391, -7737, -8083, -8429, -8774, -9119, -9464, -9808, -10153, -10498, -10842, -11187, -11532, -11859, -12279, -12025, -10836, -9713, -8581, -7450, -6313, -5180, -4048, -2915, -1786, -633};