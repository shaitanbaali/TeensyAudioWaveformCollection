/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0018 256 samples */
 
const int16_t AKWF_linear_0018_256_DATA [256] = 
{406, 1287, 2153, 3003, 4083, 5389, 6673, 7958, 9244, 10532, 11816, 13101, 14388, 15671, 16957, 18242, 19523, 20808, 22092, 23374, 24648, 25970, 26967, 27244, 27496, 27756, 28012, 28269, 28525, 28781, 29035, 29291, 29547, 29801, 30056, 30311, 30565, 30820, 31062, 31356, 31397, 29794, 27771, 25825, 23861, 21903, 19940, 17976, 16019, 14056, 12093, 10137, 8174, 6213, 4256, 2294, 337, -1616, -3583, -5188, -6563, -7969, -9368, -10763, -12162, -13558, -14954, -16353, -17746, -19142, -20539, -21932, -23326, -24721, -26112, -27480, -28992, -29364, -28095, -26875, -25654, -24425, -23196, -21970, -20740, -19511, -18285, -17055, -15827, -14602, -13372, -12145, -10919, -9685, -8480, -7142, -5284, -3373, -1473, 434, 2335, 4239, 6144, 8045, 9948, 11851, 13751, 15653, 17555, 19452, 21353, 23251, 25151, 27041, 27739, 27964, 28276, 28570, 28865, 29159, 29453, 29747, 30040, 30333, 30626, 30919, 31211, 31504, 31797, 32088, 32368, 32710, 32404, 31438, 30537, 29627, 28715, 27802, 26892, 25980, 25067, 24158, 23247, 22335, 21425, 20513, 19601, 18692, 17779, 16877, 15906, 14763, 13614, 12470, 11323, 10175, 9031, 7883, 6738, 5594, 4446, 3302, 2159, 1013, -130, -1273, -2417, -3562, -4687, -5647, -6559, -7482, -8402, -9321, -10242, -11163, -12080, -13000, -13919, -14835, -15754, -16674, -17590, -18507, -19423, -20338, -21263, -21874, -22273, -22699, -23119, -23538, -23958, -24377, -24796, -25215, -25633, -26052, -26471, -26888, -27305, -27725, -28142, -28555, -28993, -29248, -29227, -29214, -29200, -29185, -29169, -29153, -29138, -29123, -29108, -29092, -29076, -29060, -29045, -29030, -29014, -28990, -29001, -28848, -28017, -27099, -26198, -25291, -24388, -23483, -22577, -21674, -20769, -19863, -18961, -18057, -17151, -16249, -15344, -14440, -13538, -12635, -11756, -10890, -10020, -9151, -8284, -7416, -6547, -5681, -4813, -3945, -3079, -2213, -1350, -468};