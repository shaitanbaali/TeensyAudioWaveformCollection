/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0078 256 samples */
 
const int16_t AKWF_linear_0078_256_DATA [256] = 
{504, 1601, 2678, 3756, 4834, 5914, 6993, 8070, 9148, 10226, 11303, 12381, 13459, 14533, 15610, 16688, 17760, 18834, 19916, 20961, 21557, 21981, 22430, 22876, 23323, 23767, 24211, 24656, 25101, 25546, 25989, 26433, 26878, 27321, 27763, 28206, 28650, 29094, 29536, 29977, 30421, 30865, 31306, 31732, 32242, 32181, 30885, 29544, 28220, 26887, 25554, 24225, 22892, 21560, 20232, 18900, 17568, 16239, 14907, 13577, 12248, 10918, 9588, 8260, 6930, 5602, 4274, 2944, 1620, 296, -1044, -1733, -1981, -2282, -2574, -2863, -3153, -3442, -3732, -4023, -4312, -4602, -4891, -5179, -5468, -5757, -6045, -6334, -6623, -6911, -7198, -7486, -7774, -8063, -8347, -8645, -8876, -8835, -8751, -8676, -8598, -8521, -8443, -8366, -8288, -8208, -8130, -8053, -7975, -7897, -7820, -7740, -7663, -7585, -7507, -7429, -7351, -7273, -7195, -7117, -7038, -6960, -6885, -6811, -6738, -6664, -6591, -6517, -6444, -6370, -6297, -6223, -6150, -6077, -6003, -5930, -5857, -5784, -5710, -5637, -5563, -5491, -5417, -5344, -5271, -5194, -5129, -5017, -4379, -3554, -2761, -1961, -1163, -365, 435, 1232, 2030, 2831, 3629, 4425, 5225, 6023, 6819, 7618, 8415, 9212, 10009, 10806, 11603, 12400, 13194, 13976, 14838, 15129, 14268, 13376, 12496, 11610, 10722, 9837, 8950, 8063, 7178, 6290, 5405, 4520, 3633, 2746, 1863, 975, 91, -793, -1679, -2562, -3447, -4332, -5216, -6100, -6984, -7945, -8957, -9962, -10968, -11975, -12981, -13985, -14991, -15997, -16999, -18006, -19010, -20012, -21018, -22021, -23022, -24028, -25031, -26031, -27035, -28037, -29037, -30041, -31027, -32084, -32747, -31901, -30827, -29800, -28762, -27725, -26684, -25648, -24610, -23571, -22534, -21495, -20457, -19420, -18383, -17344, -16308, -15269, -14232, -13196, -12160, -11123, -10088, -9050, -8014, -6982, -5923, -4841, -3761, -2681, -1604, -504};