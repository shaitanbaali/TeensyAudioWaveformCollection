/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0003 256 samples */
 
const int16_t AKWF_linear_0003_256_DATA [256] = 
{304, 830, 1344, 1863, 2379, 2895, 3415, 3929, 4453, 4945, 5633, 6924, 8262, 9584, 10912, 12243, 13567, 14897, 16225, 17552, 18880, 20208, 21535, 22864, 24192, 25518, 26843, 28183, 29444, 29865, 29994, 30175, 30345, 30515, 30685, 30857, 31026, 31196, 31367, 31537, 31708, 31878, 32049, 32219, 32387, 32546, 32775, 31583, 29237, 27001, 24748, 22496, 20242, 17985, 15734, 13476, 11221, 8970, 6713, 4458, 2205, -50, -2304, -4534, -6883, -8431, -8512, -8579, -8654, -8724, -8795, -8863, -8933, -9002, -9072, -9142, -9213, -9280, -9352, -9421, -9490, -9561, -9632, -9692, -9683, -9666, -9647, -9631, -9612, -9595, -9578, -9560, -9543, -9524, -9507, -9489, -9471, -9454, -9437, -9420, -9401, -9386, -9250, -9051, -8861, -8670, -8479, -8288, -8097, -7905, -7715, -7523, -7332, -7140, -6949, -6758, -6567, -6376, -6170, -6046, -5246, -3569, -1959, -338, 1282, 2905, 4526, 6147, 7770, 9391, 11012, 12635, 14255, 15878, 17500, 19120, 20720, 22433, 23490, 22433, 21194, 20003, 18798, 17593, 16391, 15185, 13980, 12778, 11570, 10365, 9164, 7958, 6753, 5551, 4348, 3135, 1980, 1575, 1445, 1267, 1098, 931, 762, 593, 425, 256, 88, -80, -248, -417, -586, -754, -922, -1091, -1262, -1366, -1412, -1465, -1513, -1566, -1615, -1667, -1717, -1766, -1816, -1868, -1918, -1968, -2018, -2069, -2119, -2178, -2193, -2508, -3401, -4308, -5207, -6110, -7014, -7917, -8821, -9726, -10628, -11531, -12435, -13336, -14240, -15145, -16048, -16942, -17878, -18617, -18229, -17605, -17029, -16442, -15854, -15267, -14679, -14093, -13505, -12917, -12329, -11743, -11156, -10569, -9981, -9394, -8809, -8215, -7872, -7673, -7452, -7232, -7014, -6796, -6578, -6361, -6142, -5923, -5706, -5488, -5271, -5053, -4834, -4618, -4396, -4194, -3852, -3323, -2809, -2292, -1776, -1259, -743, -217};