/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0004 256 samples */
 
const int16_t AKWF_linear_0004_256_DATA [256] = 
{260, 790, 1310, 1830, 2350, 2870, 3392, 3912, 4439, 4938, 5565, 6835, 8183, 9509, 10843, 12177, 13507, 14842, 16175, 17504, 18838, 20172, 21503, 22837, 24170, 25501, 26833, 28167, 29491, 29987, 30098, 30273, 30438, 30602, 30764, 30929, 31093, 31257, 31420, 31584, 31749, 31912, 32075, 32240, 32402, 32546, 32801, 31821, 29476, 27234, 24975, 22719, 20455, 18195, 15938, 13675, 11415, 9158, 6894, 4636, 2379, 117, -2141, -4382, -6722, -8444, -8596, -8643, -8716, -8780, -8844, -8909, -8974, -9038, -9102, -9166, -9232, -9296, -9360, -9424, -9490, -9554, -9619, -9678, -9678, -9663, -9649, -9635, -9620, -9606, -9592, -9578, -9564, -9549, -9535, -9521, -9507, -9492, -9478, -9464, -9449, -9439, -9316, -9112, -8918, -8722, -8525, -8327, -8132, -7935, -7739, -7542, -7345, -7149, -6952, -6757, -6561, -6363, -6151, -6021, -5330, -3693, -2071, -452, 1167, 2793, 4416, 6037, 7663, 9285, 10908, 12531, 14152, 15775, 17401, 19023, 20626, 22324, 23592, 22636, 21371, 20178, 18966, 17753, 16543, 15332, 14119, 12910, 11697, 10485, 9276, 8064, 6852, 5642, 4431, 3220, 2008, 1534, 1418, 1243, 1079, 915, 751, 587, 423, 259, 95, -67, -231, -395, -560, -724, -887, -1050, -1219, -1334, -1384, -1441, -1496, -1551, -1605, -1660, -1714, -1770, -1824, -1879, -1933, -1989, -2044, -2099, -2154, -2215, -2241, -2491, -3355, -4267, -5166, -6069, -6974, -7875, -8778, -9683, -10585, -11488, -12392, -13293, -14197, -15101, -16002, -16899, -17823, -18628, -18345, -17706, -17128, -16537, -15948, -15359, -14767, -14177, -13587, -12997, -12407, -11818, -11226, -10637, -10047, -9457, -8869, -8269, -7894, -7693, -7473, -7257, -7039, -6822, -6606, -6390, -6173, -5957, -5740, -5524, -5307, -5091, -4874, -4658, -4439, -4235, -3916, -3395, -2875, -2355, -1834, -1313, -793, -266};