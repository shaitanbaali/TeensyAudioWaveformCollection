/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0082 256 samples */
 
const int16_t AKWF_linear_0082_256_DATA [256] = 
{759, 2681, 4566, 6455, 8341, 10230, 12110, 14039, 15684, 16391, 17018, 17664, 18304, 18943, 19583, 20222, 20860, 21499, 22137, 22774, 23412, 24050, 24686, 25324, 25960, 26596, 27233, 27869, 28504, 29140, 29775, 30409, 31038, 31706, 31932, 31758, 31624, 31485, 31343, 31203, 31062, 30920, 30780, 30638, 30497, 30356, 30214, 30074, 29932, 29791, 29650, 29507, 29367, 29225, 29084, 28942, 28801, 28660, 28517, 28376, 28224, 28069, 27917, 27763, 27610, 27456, 27302, 27149, 26996, 26843, 26689, 26536, 26383, 26229, 26076, 25922, 25770, 25617, 25463, 25310, 25157, 25005, 24852, 24692, 24569, 24200, 23436, 22685, 21934, 21182, 20429, 19675, 18924, 18172, 17420, 16669, 15916, 15164, 14414, 13662, 12911, 12161, 11409, 10659, 9909, 9158, 8409, 7658, 6909, 6160, 5409, 4999, 4752, 4479, 4211, 3943, 3674, 3405, 3137, 2870, 2603, 2335, 2067, 1801, 1534, 1266, 999, 732, 466, 199, -67, -334, -600, -865, -1133, -1395, -1686, -2066, -2452, -2838, -3222, -3606, -3992, -4376, -4760, -5145, -5530, -5913, -6298, -6683, -7066, -7450, -7835, -8217, -8601, -8985, -9368, -9751, -10135, -10518, -10903, -11274, -11811, -12489, -13151, -13816, -14481, -15146, -15810, -16475, -17139, -17802, -18467, -19130, -19794, -20459, -21121, -21785, -22448, -23110, -23773, -24436, -25097, -25761, -26422, -27081, -27753, -28369, -28560, -28662, -28781, -28896, -29012, -29127, -29242, -29357, -29472, -29587, -29701, -29817, -29931, -30046, -30160, -30274, -30389, -30503, -30617, -30732, -30846, -30960, -31074, -31187, -31304, -31395, -31449, -31504, -31559, -31613, -31668, -31722, -31777, -31831, -31886, -31940, -31995, -32050, -32104, -32158, -32212, -32267, -32322, -32376, -32430, -32484, -32539, -32592, -32643, -32699, -32754, -31394, -29416, -27538, -25642, -23751, -21853, -19959, -18068, -16171, -14277, -12387, -10490, -8598, -6708, -4816, -2931, -1007};