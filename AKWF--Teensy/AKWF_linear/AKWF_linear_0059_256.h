/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0059 256 samples */
 
const int16_t AKWF_linear_0059_256_DATA [256] = 
{135, 546, 950, 1355, 1761, 2164, 2570, 2975, 3380, 3785, 4189, 4594, 4998, 5403, 5806, 6212, 6615, 7019, 7423, 7826, 8230, 8634, 9038, 9441, 9844, 10247, 10651, 11053, 11457, 11859, 12262, 12664, 13067, 13470, 13871, 14274, 14676, 15078, 15479, 15880, 16282, 16681, 17095, 17376, 17452, 17532, 17611, 17689, 17768, 17847, 17925, 18003, 18082, 18161, 18239, 18317, 18395, 18474, 18552, 18630, 18708, 18786, 18864, 18942, 19020, 19097, 19175, 19254, 19332, 19409, 19487, 19565, 19642, 19719, 19797, 19875, 19953, 20031, 20108, 20185, 20263, 20340, 20417, 20495, 20572, 20650, 20728, 20805, 20882, 20959, 21037, 21114, 21181, 21297, 21116, 20108, 19033, 17975, 16911, 15847, 14784, 13721, 12657, 11595, 10532, 9469, 8407, 7345, 6282, 5222, 4159, 3097, 2037, 976, -86, -1144, -2205, -3265, -4323, -5385, -6444, -7500, -8561, -9619, -10676, -11735, -12792, -13848, -14907, -15963, -17018, -18077, -19131, -20187, -21244, -22297, -23352, -24409, -25461, -26515, -27571, -28622, -29675, -30720, -31803, -32679, -32328, -31690, -31106, -30512, -29917, -29321, -28726, -28132, -27536, -26940, -26347, -25749, -25155, -24560, -23965, -23370, -22775, -22180, -21585, -20991, -20395, -19801, -19207, -18611, -18019, -17424, -16830, -16236, -15643, -15048, -14456, -13862, -13267, -12677, -12083, -11490, -10898, -10305, -9712, -9121, -8529, -7936, -7346, -6752, -6162, -5571, -4978, -4389, -3799, -3206, -2630, -2477, -2517, -2526, -2542, -2557, -2573, -2590, -2605, -2621, -2638, -2653, -2670, -2687, -2703, -2720, -2736, -2752, -2769, -2785, -2802, -2818, -2834, -2852, -2868, -2884, -2902, -2918, -2934, -2951, -2968, -2985, -3001, -3018, -3035, -3051, -3068, -3085, -3101, -3118, -3134, -3151, -3169, -3184, -3201, -3218, -3234, -3251, -3267, -3283, -3299, -3324, -3102, -2678, -2277, -1871, -1466, -1061, -657, -244};