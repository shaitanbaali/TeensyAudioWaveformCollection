/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0067 256 samples */
 
const int16_t AKWF_linear_0067_256_DATA [256] = 
{409, 1112, 1801, 2488, 3200, 3951, 4704, 5454, 6204, 6957, 7705, 8457, 9208, 9956, 10708, 11464, 12182, 13385, 15013, 16597, 18193, 19787, 21378, 22973, 24565, 26156, 27750, 29335, 30931, 32506, 32252, 31110, 30095, 29057, 28021, 26980, 25943, 24904, 23865, 22828, 21791, 20745, 19741, 19010, 18344, 17670, 16995, 16321, 15648, 14974, 14300, 13628, 12955, 12279, 11620, 10880, 9912, 8930, 7947, 6966, 5986, 5004, 4022, 3044, 2061, 1082, 111, -904, -1601, -1812, -2035, -2257, -2477, -2697, -2917, -3138, -3357, -3577, -3796, -4016, -4237, -4417, -4563, -4709, -4857, -5004, -5150, -5298, -5445, -5591, -5738, -5885, -6031, -6177, -6289, -6383, -6482, -6579, -6676, -6773, -6870, -6967, -7064, -7161, -7256, -7359, -7426, -7248, -7016, -6794, -6569, -6345, -6120, -5896, -5671, -5447, -5222, -5000, -4768, -4587, -4552, -4525, -4497, -4470, -4442, -4415, -4388, -4360, -4333, -4306, -4277, -4253, -4201, -4107, -4013, -3920, -3827, -3734, -3640, -3547, -3454, -3361, -3268, -3172, -3090, -2825, -2410, -2010, -1608, -1206, -804, -401, 1, 402, 804, 1207, 1608, 2013, 2553, 3155, 3749, 4342, 4938, 5534, 6126, 6720, 7315, 7908, 8500, 9101, 9662, 9967, 10218, 10479, 10738, 10996, 11253, 11511, 11770, 12027, 12285, 12526, 12853, 12701, 11226, 9669, 8129, 6585, 5041, 3496, 1952, 410, -1135, -2678, -4217, -5777, -7204, -8447, -9699, -10947, -12197, -13446, -14692, -15941, -17189, -18434, -19681, -20920, -22212, -22691, -22515, -22407, -22287, -22168, -22047, -21926, -21807, -21685, -21564, -21443, -21322, -21198, -20873, -20463, -20065, -19666, -19266, -18865, -18467, -18067, -17666, -17267, -16865, -16474, -16034, -15292, -14486, -13696, -12901, -12106, -11313, -10519, -9724, -8931, -8138, -7345, -6548, -5777, -5081, -4392, -3698, -3007, -2316, -1626, -938, -235};