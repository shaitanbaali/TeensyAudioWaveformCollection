/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0021 256 samples */
 
const int16_t AKWF_linear_0021_256_DATA [256] = 
{99, 305, 506, 705, 948, 1231, 1510, 1790, 2069, 2349, 2628, 2907, 3186, 3465, 3745, 4024, 4302, 4582, 4860, 5138, 5419, 5694, 5998, 6365, 6734, 7100, 7468, 7836, 8203, 8570, 8938, 9305, 9672, 10039, 10406, 10772, 11139, 11506, 11871, 12238, 12608, 13003, 13402, 13802, 14201, 14600, 14999, 15397, 15796, 16195, 16594, 16992, 17391, 17789, 18186, 18585, 18983, 19380, 19778, 20172, 20566, 20961, 21356, 21749, 22144, 22538, 22931, 23326, 23718, 24112, 24505, 24899, 25291, 25685, 26077, 26468, 26871, 27170, 27334, 27503, 27670, 27839, 28006, 28175, 28342, 28510, 28677, 28845, 29012, 29179, 29346, 29514, 29681, 29845, 30027, 30111, 29844, 29544, 29254, 28959, 28667, 28374, 28080, 27787, 27493, 27200, 26907, 26614, 26321, 26028, 25735, 25437, 25151, 24833, 23641, 22132, 20680, 19219, 17760, 16296, 14835, 13376, 11912, 10453, 8995, 7532, 6073, 4615, 3155, 1696, 239, -1220, -2679, -4141, -5606, -7066, -8527, -9990, -11450, -12910, -14371, -15829, -17290, -18750, -20207, -21667, -23125, -24579, -26027, -27531, -28636, -28889, -29117, -29353, -29585, -29816, -30046, -30278, -30509, -30739, -30971, -31200, -31431, -31661, -31891, -32121, -32347, -32587, -32761, -32537, -32214, -31909, -31600, -31292, -30983, -30674, -30367, -30058, -29749, -29440, -29132, -28823, -28515, -28206, -27897, -27589, -27281, -26847, -26335, -25831, -25327, -24823, -24318, -23814, -23310, -22805, -22301, -21797, -21293, -20789, -20286, -19782, -19279, -18776, -18270, -17793, -17354, -16914, -16476, -16037, -15598, -15159, -14721, -14282, -13844, -13406, -12967, -12529, -12091, -11654, -11217, -10779, -10340, -9912, -9522, -9136, -8750, -8365, -7979, -7594, -7208, -6824, -6438, -6052, -5667, -5283, -4897, -4513, -4129, -3745, -3361, -2978, -2730, -2536, -2331, -2128, -1926, -1724, -1522, -1319, -1116, -914, -713, -511, -310, -105};