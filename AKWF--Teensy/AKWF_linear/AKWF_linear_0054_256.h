/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0054 256 samples */
 
const int16_t AKWF_linear_0054_256_DATA [256] = 
{653, 1661, 2659, 3401, 3960, 4540, 5117, 5692, 6268, 6844, 7419, 7994, 8570, 9144, 9719, 10294, 10867, 11441, 12015, 12581, 13185, 13546, 13500, 13466, 13433, 13397, 13360, 13325, 13289, 13253, 13217, 13181, 13144, 13109, 13073, 13036, 13000, 12964, 12927, 12888, 12835, 12780, 12724, 12668, 12613, 12558, 12503, 12447, 12392, 12337, 12282, 12226, 12171, 12116, 12060, 12005, 11951, 11896, 11975, 12119, 12252, 12387, 12522, 12657, 12792, 12926, 13061, 13196, 13331, 13466, 13601, 13736, 13871, 14006, 14137, 14287, 14228, 13931, 13650, 13368, 13084, 12800, 12517, 12235, 11951, 11667, 11385, 11100, 10817, 10534, 10251, 9967, 9683, 9409, 9058, 8497, 7919, 7347, 6773, 6198, 5625, 5051, 4477, 3904, 3331, 2757, 2184, 1611, 1038, 466, -106, -679, -1252, -1834, -2421, -3006, -3592, -4177, -4761, -5347, -5932, -6515, -7100, -7684, -8267, -8852, -9436, -10019, -10602, -11183, -11781, -12028, -12012, -12024, -12031, -12038, -12046, -12052, -12059, -12065, -12071, -12078, -12084, -12091, -12097, -12103, -12109, -12112, -12134, -12021, -11670, -11321, -10973, -10626, -10277, -9929, -9580, -9232, -8884, -8536, -8186, -7840, -7491, -7142, -6795, -6444, -6111, -5687, -4745, -3725, -2725, -1719, -713, 290, 1295, 2299, 3303, 4307, 5313, 6315, 7318, 8323, 9324, 10325, 11327, 12336, 12229, 11564, 10990, 10396, 9804, 9213, 8621, 8029, 7437, 6844, 6253, 5660, 5067, 4477, 3883, 3291, 2689, 2149, 972, -969, -2860, -4761, -6656, -8558, -10457, -12352, -14254, -16152, -18047, -19946, -21843, -23737, -25636, -27531, -29400, -31393, -32648, -31821, -30818, -29859, -28888, -27913, -26941, -25968, -24993, -24021, -23048, -22073, -21102, -20128, -19154, -18182, -17209, -16236, -15263, -14272, -13276, -12283, -11288, -10292, -9300, -8305, -7310, -6319, -5323, -4330, -3339, -2346, -1357, -347};