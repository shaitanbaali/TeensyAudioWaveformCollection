/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0010 256 samples */
 
const int16_t AKWF_linear_0010_256_DATA [256] = 
{803, 2793, 4744, 6700, 8647, 10624, 12472, 13551, 14472, 15428, 16375, 17323, 18272, 19217, 20165, 21113, 22059, 23007, 23956, 24902, 25850, 26798, 27743, 28690, 29638, 29869, 29685, 29558, 29421, 29284, 29146, 29009, 28872, 28734, 28596, 28459, 28321, 28184, 28047, 27909, 27772, 27635, 27491, 27412, 27416, 27417, 27417, 27419, 27419, 27420, 27421, 27421, 27423, 27424, 27424, 27425, 27426, 27426, 27428, 27430, 27429, 27440, 27491, 27548, 27602, 27657, 27712, 27768, 27822, 27878, 27932, 27988, 28043, 28097, 28152, 28207, 28262, 28316, 28374, 28420, 28309, 28140, 27979, 27818, 27656, 27495, 27333, 27171, 27010, 26848, 26686, 26525, 26363, 26202, 26040, 25879, 25721, 25542, 25588, 25827, 26046, 26268, 26491, 26713, 26935, 27157, 27378, 27601, 27824, 28046, 28268, 28491, 28712, 28935, 29142, 29431, 29236, 27990, 26752, 25516, 24277, 23041, 21801, 20562, 19324, 18085, 16847, 15610, 14370, 13132, 11894, 10653, 9412, 8190, 6867, 4906, 2803, 726, -1350, -3432, -5515, -7592, -9674, -11756, -13832, -15914, -17996, -20073, -22155, -24237, -26310, -28391, -30483, -31222, -31134, -31158, -31162, -31165, -31169, -31171, -31175, -31178, -31181, -31185, -31188, -31191, -31194, -31198, -31201, -31205, -31207, -31227, -31272, -31315, -31360, -31404, -31447, -31491, -31535, -31579, -31624, -31668, -31712, -31756, -31801, -31845, -31888, -31931, -31980, -31996, -31902, -31793, -31688, -31582, -31476, -31370, -31265, -31158, -31052, -30946, -30841, -30734, -30628, -30523, -30417, -30311, -30203, -30106, -30191, -30348, -30494, -30640, -30789, -30936, -31083, -31231, -31379, -31526, -31674, -31821, -31969, -32117, -32264, -32412, -32553, -32729, -32525, -31971, -31452, -30928, -30403, -29879, -29354, -28829, -28304, -27779, -27253, -26731, -26205, -25679, -25155, -24630, -24090, -23632, -22721, -20759, -18804, -16848, -14893, -12938, -10979, -9023, -7069, -5113, -3162, -1172};