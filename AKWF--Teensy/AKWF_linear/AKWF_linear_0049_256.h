/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0049 256 samples */
 
const int16_t AKWF_linear_0049_256_DATA [256] = 
{768, 2982, 5150, 7325, 9485, 11707, 13571, 14650, 15714, 16785, 17849, 18915, 19981, 21044, 22109, 23173, 24236, 25299, 26364, 27424, 28487, 29550, 30594, 31710, 32523, 30863, 28673, 26594, 24495, 22391, 20290, 18189, 16084, 13985, 11885, 9779, 7681, 5582, 3479, 1383, -713, -2805, -4948, -5717, -5623, -5653, -5662, -5670, -5677, -5684, -5691, -5697, -5704, -5710, -5717, -5722, -5729, -5734, -5739, -5729, -5810, -5141, -3366, -1638, 98, 1832, 3568, 5307, 7039, 8775, 10513, 12246, 13980, 15718, 17449, 19184, 20919, 22626, 24456, 25594, 24202, 22469, 20811, 19139, 17463, 15787, 14115, 12437, 10763, 9090, 7413, 5738, 4066, 2390, 717, -948, -2636, -4254, -4710, -4672, -4709, -4732, -4753, -4774, -4796, -4817, -4838, -4859, -4880, -4901, -4923, -4942, -4962, -4984, -5002, -5031, -4928, -4696, -4473, -4249, -4026, -3801, -3577, -3354, -3129, -2905, -2682, -2458, -2233, -2010, -1786, -1561, -1338, -1117, -874, -584, -292, 0, 290, 582, 873, 1165, 1457, 1748, 2039, 2331, 2622, 2912, 3204, 3496, 3777, 4094, 4269, 3204, 1846, 547, -762, -2076, -3386, -4696, -6008, -7318, -8628, -9940, -11249, -12559, -13869, -15178, -16485, -17784, -19143, -19361, -18827, -18404, -17959, -17515, -17071, -16625, -16181, -15738, -15292, -14847, -14403, -13958, -13513, -13069, -12623, -12165, -11780, -10831, -8999, -7200, -5394, -3591, -1787, 20, 1820, 3624, 5431, 7232, 9035, 10839, 12639, 14440, 16244, 18015, 19922, 21079, 19254, 16993, 14827, 12644, 10454, 8265, 6082, 3892, 1704, -479, -2669, -4854, -7037, -9226, -11410, -13588, -15785, -17923, -18846, -19220, -19676, -20115, -20557, -20995, -21434, -21872, -22311, -22750, -23188, -23625, -24064, -24501, -24937, -25373, -25790, -26321, -25473, -23211, -21053, -18875, -16697, -14522, -12340, -10164, -7990, -5813, -3643, -1430};