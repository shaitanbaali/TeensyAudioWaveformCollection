/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0012 256 samples */
 
const int16_t AKWF_linear_0012_256_DATA [256] = 
{1043, 2855, 4630, 6408, 8179, 9992, 11553, 12647, 13757, 14866, 15972, 17077, 18185, 19289, 20395, 21501, 22604, 23709, 24813, 25915, 27020, 28122, 29216, 30349, 31292, 31200, 30939, 30714, 30481, 30247, 30014, 29781, 29547, 29313, 29079, 28844, 28611, 28377, 28142, 27908, 27674, 27440, 27207, 27133, 27143, 27142, 27141, 27142, 27142, 27142, 27142, 27142, 27142, 27142, 27143, 27143, 27144, 27144, 27144, 27145, 27141, 27195, 27321, 27442, 27564, 27686, 27809, 27932, 28053, 28176, 28298, 28420, 28543, 28665, 28787, 28909, 29031, 29151, 29283, 29344, 29206, 29050, 28900, 28747, 28594, 28442, 28289, 28136, 27984, 27832, 27679, 27527, 27375, 27222, 27069, 26919, 26763, 26626, 26699, 26841, 26970, 27103, 27235, 27368, 27500, 27633, 27764, 27897, 28030, 28163, 28295, 28427, 28560, 28690, 28806, 29019, 27813, 25483, 23276, 21044, 18814, 16587, 14353, 12123, 9896, 7664, 5436, 3209, 979, -1245, -3472, -5702, -7913, -10191, -12083, -13223, -14378, -15534, -16684, -17836, -18989, -20138, -21289, -22441, -23589, -24739, -25890, -27036, -28185, -29334, -30470, -31652, -32629, -32346, -31844, -31390, -30926, -30460, -29997, -29531, -29065, -28600, -28135, -27669, -27204, -26740, -26273, -25808, -25344, -24879, -24411, -24512, -24931, -25299, -25678, -26057, -26435, -26813, -27193, -27571, -27950, -28329, -28706, -29085, -29463, -29841, -30220, -30593, -30991, -31153, -31015, -30893, -30769, -30644, -30520, -30395, -30270, -30145, -30020, -29896, -29770, -29646, -29521, -29396, -29271, -29148, -29014, -28946, -29077, -29227, -29373, -29519, -29666, -29813, -29960, -30107, -30254, -30400, -30547, -30694, -30841, -30988, -31134, -31278, -31432, -31544, -31145, -30561, -30008, -29450, -28890, -28331, -27773, -27213, -26655, -26096, -25537, -24979, -24420, -23861, -23303, -22745, -22177, -21662, -20429, -18595, -16824, -15040, -13255, -11473, -9688, -7906, -6126, -4344, -2568, -756};