/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0001 256 samples */
 
const int16_t AKWF_linear_0001_256_DATA [256] = 
{194, 735, 1263, 1794, 2324, 2854, 3386, 3918, 4438, 5271, 6321, 7349, 8382, 9412, 10445, 11477, 12507, 13540, 14572, 15602, 16635, 17668, 18698, 19731, 20762, 21787, 22845, 23690, 24189, 24697, 25205, 25710, 26217, 26723, 27229, 27735, 28241, 28748, 29254, 29760, 30267, 30773, 31278, 31777, 32316, 32664, 32075, 31363, 30679, 29988, 29296, 28607, 27914, 27223, 26533, 25842, 25151, 24461, 23769, 23078, 22388, 21695, 21004, 20314, 19298, 18134, 16994, 15849, 14705, 13560, 12415, 11271, 10127, 8981, 7839, 6694, 5547, 4406, 3260, 2114, 971, -174, -1319, -2464, -3612, -4758, -5903, -7051, -8197, -9342, -10491, -11637, -12782, -13930, -15076, -16221, -17369, -18515, -19647, -20851, -21615, -21215, -20733, -20272, -19805, -19337, -18871, -18404, -17936, -17469, -17001, -16534, -16068, -15600, -15132, -14667, -14195, -13737, -13223, -12194, -11005, -9845, -8676, -7511, -6346, -5177, -4012, -2846, -1677, -512, 654, 1822, 2986, 4154, 5320, 6477, 7681, 7918, 7428, 7014, 6587, 6160, 5733, 5305, 4878, 4451, 4023, 3596, 3168, 2741, 2314, 1886, 1459, 1031, 613, 109, -546, -1203, -1857, -2511, -3168, -3822, -4477, -5133, -5787, -6443, -7098, -7752, -8407, -9063, -9717, -10371, -11034, -11651, -12043, -12401, -12763, -13127, -13489, -13850, -14214, -14576, -14936, -15300, -15663, -16024, -16387, -16749, -17111, -17472, -17834, -18202, -18057, -17661, -17307, -16946, -16583, -16223, -15861, -15500, -15138, -14775, -14415, -14054, -13692, -13331, -12968, -12607, -12247, -11884, -11526, -11173, -10818, -10464, -10111, -9755, -9401, -9048, -8694, -8340, -7986, -7631, -7277, -6923, -6569, -6215, -5864, -5498, -5221, -5197, -5191, -5182, -5173, -5164, -5156, -5147, -5140, -5131, -5122, -5114, -5105, -5097, -5088, -5080, -5069, -5067, -5026, -4606, -4058, -3531, -3001, -2470, -1940, -1409, -881, -341};