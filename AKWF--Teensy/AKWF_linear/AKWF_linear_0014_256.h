/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0014 256 samples */
 
const int16_t AKWF_linear_0014_256_DATA [256] = 
{816, 3036, 5210, 7390, 9570, 11751, 13934, 16110, 18290, 20471, 22648, 24827, 27007, 29147, 31475, 32627, 31377, 30079, 28798, 27511, 26219, 24929, 23641, 22349, 21058, 19770, 18479, 17190, 15901, 14610, 13321, 12032, 10740, 9460, 8251, 7054, 5858, 4662, 3463, 2267, 1072, -124, -1317, -2514, -3711, -4903, -6100, -7295, -8486, -9678, -10864, -12099, -12122, -11434, -10857, -10259, -9661, -9063, -8464, -7865, -7268, -6669, -6071, -5472, -4873, -4276, -3678, -3079, -2490, -1849, -1635, -2028, -2387, -2751, -3115, -3479, -3844, -4209, -4574, -4939, -5302, -5667, -6034, -6396, -6760, -7126, -7485, -7866, -8120, -7921, -7668, -7428, -7186, -6941, -6697, -6455, -6210, -5967, -5724, -5481, -5236, -4995, -4750, -4507, -4266, -4019, -3790, -3828, -3978, -4111, -4245, -4379, -4514, -4650, -4787, -4920, -5054, -5190, -5326, -5462, -5595, -5730, -5864, -5991, -6173, -5539, -4146, -2816, -1476, -136, 1202, 2544, 3883, 5225, 6565, 7904, 9244, 10585, 11922, 13262, 14601, 15916, 17344, 18095, 17398, 16657, 15928, 15195, 14461, 13724, 12991, 12256, 11521, 10786, 10051, 9318, 8582, 7846, 7113, 6378, 5647, 4897, 3996, 3061, 2134, 1204, 274, -652, -1579, -2509, -3435, -4363, -5293, -6219, -7146, -8075, -8999, -9926, -10844, -11813, -11830, -11262, -10785, -10290, -9795, -9300, -8805, -8311, -7818, -7322, -6827, -6333, -5837, -5343, -4848, -4352, -3866, -3342, -3098, -3279, -3440, -3601, -3762, -3926, -4089, -4251, -4414, -4578, -4740, -4901, -5065, -5228, -5391, -5553, -5716, -5883, -6011, -5995, -5958, -5925, -5891, -5858, -5824, -5789, -5756, -5723, -5689, -5655, -5621, -5588, -5554, -5521, -5487, -5453, -5421, -5473, -5557, -5637, -5717, -5797, -5877, -5957, -6038, -6118, -6198, -6278, -6358, -6438, -6519, -6598, -6678, -6740, -6898, -5841, -3590, -1386};