/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0038 256 samples */
 
const int16_t AKWF_linear_0038_256_DATA [256] = 
{273, 732, 1174, 1560, 1931, 2304, 2677, 3050, 3422, 3795, 4166, 4539, 4911, 5283, 5655, 6027, 6399, 6770, 7143, 7514, 7881, 8448, 9145, 9828, 10512, 11196, 11881, 12565, 13248, 13933, 14616, 15298, 15983, 16666, 17348, 18032, 18714, 19397, 20080, 20757, 21431, 22104, 22776, 23449, 24122, 24792, 25465, 26137, 26807, 27479, 28151, 28821, 29492, 30163, 30833, 31496, 32192, 32732, 32628, 32449, 32285, 32118, 31951, 31784, 31616, 31448, 31280, 31112, 30945, 30778, 30610, 30442, 30274, 30104, 29939, 29767, 29016, 28027, 27080, 26124, 25172, 24217, 23262, 22310, 21355, 20400, 19449, 18494, 17541, 16589, 15634, 14682, 13730, 12782, 11749, 10625, 9506, 8388, 7271, 6153, 5037, 3920, 2802, 1687, 571, -546, -1660, -2776, -3892, -5006, -6117, -7250, -8239, -8890, -9523, -10159, -10795, -11431, -12064, -12700, -13335, -13968, -14602, -15235, -15868, -16503, -17135, -17768, -18399, -19040, -19623, -19770, -19792, -19835, -19875, -19914, -19953, -19993, -20032, -20071, -20109, -20147, -20186, -20225, -20264, -20302, -20340, -20378, -20420, -20283, -20022, -19776, -19526, -19276, -19027, -18778, -18529, -18279, -18029, -17780, -17530, -17282, -17032, -16783, -16534, -16285, -16033, -15804, -15613, -15420, -15229, -15037, -14845, -14653, -14461, -14270, -14079, -13887, -13695, -13503, -13312, -13120, -12930, -12739, -12544, -12372, -12297, -12235, -12169, -12106, -12042, -11979, -11914, -11851, -11787, -11723, -11660, -11596, -11532, -11468, -11405, -11342, -11277, -11214, -11144, -11070, -10997, -10923, -10850, -10776, -10704, -10631, -10557, -10484, -10411, -10338, -10266, -10192, -10119, -10045, -9972, -9902, -9791, -9635, -9480, -9326, -9172, -9018, -8864, -8710, -8556, -8403, -8248, -8094, -7941, -7787, -7633, -7480, -7323, -7180, -6956, -6513, -6058, -5607, -5155, -4703, -4251, -3799, -3347, -2896, -2444, -1992, -1542, -1091, -641, -182};