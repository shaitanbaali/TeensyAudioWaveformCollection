/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0025 256 samples */
 
const int16_t AKWF_linear_0025_256_DATA [256] = 
{541, 1471, 2384, 3297, 4211, 5124, 6039, 6951, 7863, 8777, 9688, 10601, 11513, 12422, 13334, 14246, 15138, 16117, 16616, 15131, 13350, 11634, 9907, 8175, 6445, 4718, 2986, 1257, -469, -2201, -3929, -5656, -7387, -9113, -10830, -12575, -14227, -13662, -12069, -10635, -9170, -7702, -6239, -4772, -3303, -1840, -374, 1091, 2555, 4022, 5487, 6950, 8416, 9874, 11367, 12429, 13033, 13667, 14298, 14927, 15555, 16186, 16815, 17443, 18072, 18699, 19327, 19956, 20582, 21210, 21837, 22443, 23158, 23215, 21668, 20028, 18410, 16789, 15163, 13539, 11917, 10292, 8666, 7047, 5421, 3797, 2178, 553, -1069, -2674, -4340, -5765, -4975, -3588, -2311, -1012, 289, 1588, 2887, 4190, 5489, 6789, 8091, 9388, 10689, 11991, 13289, 14586, 15873, 17239, 17378, 16662, 16065, 15445, 14826, 14208, 13589, 12969, 12351, 11730, 11111, 10492, 9872, 9253, 8635, 8014, 7395, 6782, 6123, 5390, 4661, 3929, 3200, 2470, 1738, 1009, 280, -450, -1178, -1907, -2637, -3365, -4094, -4824, -5543, -6301, -6860, -6520, -6039, -5586, -5127, -4669, -4211, -3752, -3293, -2835, -2376, -1918, -1460, -1002, -542, -85, 372, 833, 1282, 1370, 1280, 1217, 1149, 1082, 1013, 945, 878, 809, 742, 673, 605, 536, 469, 401, 333, 270, 181, 365, 851, 1316, 1786, 2254, 2723, 3193, 3661, 4130, 4600, 5068, 5536, 6006, 6473, 6942, 7411, 7858, 8416, 8305, 6470, 4512, 2582, 649, -1288, -3226, -5160, -7097, -9034, -10967, -12904, -14839, -16771, -18708, -20643, -22565, -24523, -26357, -26994, -27283, -27631, -27967, -28303, -28638, -28973, -29308, -29642, -29977, -30312, -30645, -30978, -31313, -31646, -31978, -32295, -32706, -31778, -29867, -28086, -26279, -24472, -22667, -20859, -19052, -17249, -15441, -13635, -11834, -10026, -8221, -6419, -4616, -2818, -984};