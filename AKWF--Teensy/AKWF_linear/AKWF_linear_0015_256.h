/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0015 256 samples */
 
const int16_t AKWF_linear_0015_256_DATA [256] = 
{1004, 3467, 5876, 8290, 10732, 12106, 12811, 13612, 14394, 15177, 15957, 16738, 17521, 18300, 19080, 19861, 20639, 21420, 22198, 22977, 23754, 24502, 25414, 24900, 22332, 19845, 17343, 14843, 12344, 9839, 7339, 4839, 2334, -163, -2663, -5166, -7663, -10162, -12664, -15128, -17743, -19538, -18462, -17011, -15640, -14252, -12861, -11469, -10081, -8690, -7298, -5910, -4519, -3126, -1738, -348, 1043, 2429, 3823, 5201, 6347, 7399, 8463, 9524, 10589, 11650, 12710, 13773, 14832, 15893, 16956, 18014, 19074, 20135, 21192, 22251, 23292, 24436, 24317, 23003, 21792, 20561, 19328, 18100, 16866, 15633, 14403, 13171, 11940, 10710, 9478, 8247, 7018, 5785, 4563, 3300, 2282, 1832, 1396, 954, 516, 78, -362, -799, -1237, -1676, -2113, -2551, -2988, -3425, -3863, -4300, -4732, -5184, -5555, -5180, -4642, -4138, -3629, -3117, -2605, -2094, -1582, -1072, -560, -50, 460, 972, 1485, 1995, 2504, 3016, 3526, 4069, 4635, 5197, 5759, 6323, 6884, 7446, 8010, 8571, 9133, 9697, 10257, 10819, 11381, 11941, 12503, 13053, 13668, 13732, 12956, 12210, 11460, 10708, 9958, 9205, 8454, 7702, 6949, 6199, 5448, 4695, 3946, 3194, 2442, 1693, 936, 225, -309, -819, -1334, -1847, -2362, -2875, -3388, -3902, -4415, -4927, -5440, -5953, -6466, -6978, -7490, -7997, -8517, -8991, -8500, -7582, -6731, -5867, -5001, -4137, -3272, -2407, -1542, -678, 186, 1049, 1914, 2779, 3641, 4504, 5347, 6314, 5825, 3879, 2049, 198, -1656, -3504, -5358, -7212, -9061, -10915, -12767, -14615, -16469, -18319, -20167, -22019, -23853, -25764, -27217, -27559, -27859, -28170, -28478, -28783, -29091, -29396, -29702, -30008, -30312, -30618, -30923, -31228, -31533, -31837, -32129, -32474, -32602, -30612, -28106, -25700, -23281, -20854, -18429, -16009, -13583, -11160, -8740, -6320, -3904, -1440};