/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0011 256 samples */
 
const int16_t AKWF_linear_0011_256_DATA [256] = 
{782, 2902, 4979, 7063, 9140, 11218, 13326, 14430, 14835, 15322, 15793, 16265, 16736, 17206, 17676, 18147, 18616, 19086, 19555, 20024, 20492, 20961, 21428, 21892, 22380, 22674, 22664, 22658, 22653, 22647, 22641, 22634, 22627, 22621, 22614, 22607, 22600, 22593, 22587, 22580, 22572, 22552, 22595, 22313, 20727, 18944, 17197, 15443, 13691, 11937, 10183, 8432, 6678, 4924, 3174, 1420, -331, -2080, -3833, -5581, -7332, -9077, -10344, -11400, -12490, -13572, -14654, -15737, -16817, -17898, -18980, -20059, -21139, -22221, -23298, -24378, -25458, -26534, -27584, -28795, -28597, -26894, -25336, -23757, -22172, -20587, -19006, -17421, -15837, -14256, -12670, -11087, -9508, -7922, -6340, -4760, -3177, -1589, -54, 1339, 2726, 4116, 5506, 6892, 8280, 9668, 11053, 12441, 13829, 15213, 16598, 17985, 19368, 20754, 22128, 23542, 24757, 24070, 22830, 21694, 20537, 19382, 18224, 17067, 15912, 14754, 13598, 12442, 11284, 10129, 8973, 7814, 6661, 5509, 4335, 3755, 3613, 3421, 3239, 3056, 2873, 2692, 2510, 2328, 2147, 1966, 1784, 1603, 1422, 1240, 1060, 894, 648, 1020, 2417, 3809, 5194, 6587, 7977, 9367, 10758, 12147, 13537, 14928, 16316, 17706, 19097, 20484, 21874, 23245, 24699, 25712, 24817, 23600, 22446, 21276, 20108, 18939, 17769, 16602, 15433, 14263, 13097, 11926, 10758, 9590, 8421, 7252, 6087, 4914, 3483, 1926, 385, -1154, -2695, -4239, -5779, -7319, -8862, -10400, -11940, -13481, -15018, -16557, -18097, -19633, -21160, -22749, -23806, -24273, -24790, -25295, -25802, -26309, -26812, -27318, -27824, -28328, -28833, -29337, -29840, -30347, -30849, -31352, -31847, -32387, -32675, -32222, -31739, -31266, -30788, -30312, -29835, -29357, -28880, -28402, -27926, -27449, -26971, -26494, -26017, -25541, -25056, -24599, -24031, -22256, -20114, -18039, -15951, -13867, -11777, -9690, -7608, -5523, -3444, -1323};