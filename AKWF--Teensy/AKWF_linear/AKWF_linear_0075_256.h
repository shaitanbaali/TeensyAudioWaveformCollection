/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0075 256 samples */
 
const int16_t AKWF_linear_0075_256_DATA [256] = 
{466, 1400, 2313, 3230, 4146, 5061, 5979, 6893, 7809, 8726, 9633, 10576, 11251, 11551, 11874, 12195, 12513, 12832, 13152, 13469, 13789, 14108, 14425, 14743, 15062, 15379, 15697, 16015, 16332, 16649, 16967, 17285, 17601, 17918, 18236, 18545, 18872, 19142, 17699, 15563, 13548, 11505, 9470, 7430, 5390, 3355, 1316, -723, -2757, -4796, -6834, -8867, -10905, -12941, -14973, -17010, -19045, -21076, -23112, -25145, -27175, -29176, -31345, -32486, -31004, -29431, -27888, -26330, -24775, -23220, -21663, -20109, -18553, -16995, -15443, -13886, -12329, -10778, -9221, -7665, -6113, -4558, -3002, -1451, 104, 1657, 3206, 4754, 6337, 7231, 7614, 8061, 8496, 8931, 9366, 9800, 10235, 10668, 11102, 11536, 11968, 12402, 12835, 13267, 13700, 14133, 14565, 14997, 15429, 15860, 16293, 16724, 17146, 17611, 17855, 16909, 15750, 14638, 13518, 12393, 11270, 10151, 9026, 7905, 6786, 5663, 4542, 3421, 2299, 1180, 59, -1062, -2181, -3300, -4421, -5540, -6659, -7779, -8883, -10061, -10607, -10318, -10086, -9843, -9602, -9357, -9114, -8871, -8628, -8383, -8141, -7897, -7653, -7409, -7165, -6921, -6678, -6434, -6191, -5947, -5703, -5459, -5215, -4973, -4727, -4494, -4511, -4624, -4721, -4821, -4920, -5020, -5119, -5219, -5319, -5418, -5518, -5618, -5718, -5817, -5917, -6017, -6116, -6216, -6316, -6415, -6515, -6614, -6713, -6805, -6937, -6814, -6083, -5336, -4595, -3850, -3107, -2365, -1620, -876, -134, 609, 1352, 2095, 2838, 3580, 4323, 5066, 5807, 6550, 7293, 8033, 8775, 9517, 10255, 10989, 11767, 11486, 10451, 9517, 8564, 7610, 6658, 5705, 4751, 3799, 2847, 1893, 942, -10, -964, -1915, -2867, -3820, -4770, -5722, -6676, -7625, -8577, -9529, -10466, -11460, -12160, -11437, -10480, -9573, -8657, -7739, -6821, -5905, -4986, -4069, -3152, -2235, -1321, -388};