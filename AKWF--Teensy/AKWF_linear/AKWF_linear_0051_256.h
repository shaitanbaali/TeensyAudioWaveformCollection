/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0051 256 samples */
 
const int16_t AKWF_linear_0051_256_DATA [256] = 
{767, 2059, 3324, 4593, 5859, 7128, 8397, 9662, 10930, 12198, 13462, 14729, 15997, 17251, 18559, 19541, 19704, 19815, 19938, 20056, 20174, 20292, 20408, 20527, 20645, 20761, 20878, 20996, 21113, 21229, 21346, 21461, 21582, 21681, 21598, 21462, 21336, 21207, 21079, 20950, 20821, 20693, 20564, 20436, 20307, 20178, 20049, 19921, 19792, 19663, 19537, 19398, 19458, 19661, 19846, 20034, 20223, 20411, 20599, 20787, 20976, 21164, 21352, 21540, 21729, 21916, 22106, 22294, 22468, 22714, 22515, 21538, 20592, 19643, 18694, 17744, 16793, 15845, 14894, 13943, 12997, 12045, 11096, 10148, 9198, 8249, 7302, 6353, 5400, 4427, 3446, 2469, 1493, 514, -461, -1438, -2416, -3391, -4367, -5344, -6319, -7293, -8270, -9245, -10218, -11196, -12161, -12701, -13028, -13385, -13739, -14091, -14443, -14795, -15147, -15498, -15850, -16201, -16552, -16903, -17253, -17603, -17954, -18299, -18671, -18749, -18486, -18245, -18001, -17757, -17512, -17267, -17022, -16777, -16531, -16287, -16043, -15797, -15552, -15307, -15063, -14803, -14622, -13962, -12039, -10013, -8009, -6005, -3995, -1987, 17, 2027, 4034, 6038, 8047, 10052, 12056, 14063, 16067, 18050, 20111, 21854, 20458, 18085, 15879, 13639, 11396, 9158, 6917, 4674, 2437, 196, -2047, -4281, -6523, -8765, -10999, -13238, -15462, -17775, -18632, -18387, -18268, -18127, -17985, -17842, -17700, -17557, -17415, -17271, -17127, -16985, -16841, -16698, -16554, -16410, -16255, -16164, -15677, -14465, -13274, -12081, -10888, -9693, -8499, -7307, -6113, -4918, -3727, -2533, -1340, -149, 1044, 2236, 3406, 4673, 5471, 3703, 1510, -588, -2703, -4826, -6943, -9060, -11183, -13300, -15417, -17538, -19653, -21770, -23889, -26003, -28111, -30232, -32332, -31902, -30134, -28572, -26967, -25362, -23761, -22158, -20553, -18953, -17347, -15744, -14143, -12537, -10935, -9334, -7731, -6132, -4520, -3065, -1809, -514};