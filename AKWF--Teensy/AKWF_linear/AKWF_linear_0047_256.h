/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_linear_0047 256 samples */
 
const int16_t AKWF_linear_0047_256_DATA [256] = 
{127, 712, 1490, 2248, 3010, 3771, 4534, 5294, 6055, 6817, 7577, 8338, 9099, 9859, 10619, 11380, 12139, 12900, 13657, 14440, 15271, 16102, 16931, 17762, 18591, 19419, 20251, 21080, 21907, 22737, 23566, 24393, 25223, 26049, 26877, 27700, 28547, 29262, 29372, 29377, 29403, 29424, 29445, 29465, 29486, 29506, 29526, 29546, 29566, 29587, 29607, 29627, 29646, 29665, 29686, 29704, 29401, 28944, 28509, 28069, 27630, 27190, 26751, 26312, 25872, 25434, 24994, 24553, 24115, 23676, 23237, 22799, 22362, 21916, 21536, 21229, 20915, 20604, 20292, 19981, 19670, 19358, 19047, 18736, 18424, 18113, 17803, 17491, 17180, 16870, 16560, 16247, 15950, 15699, 15451, 15202, 14952, 14705, 14457, 14207, 13959, 13710, 13462, 13215, 12965, 12718, 12471, 12222, 11970, 11732, 11441, 10576, 9528, 8512, 7489, 6470, 5447, 4425, 3406, 2384, 1363, 344, -678, -1698, -2715, -3736, -4756, -5776, -6791, -7940, -9200, -10450, -11699, -12949, -14200, -15447, -16697, -17947, -19193, -20443, -21691, -22937, -24186, -25434, -26678, -27915, -29207, -30088, -30244, -30395, -30548, -30699, -30849, -30999, -31150, -31300, -31450, -31599, -31748, -31898, -32048, -32196, -32346, -32491, -32657, -32711, -32229, -31645, -31080, -30510, -29942, -29373, -28803, -28234, -27665, -27095, -26528, -25957, -25388, -24821, -24251, -23682, -23115, -22545, -22038, -21563, -21084, -20603, -20125, -19645, -19167, -18690, -18210, -17732, -17254, -16775, -16298, -15821, -15341, -14864, -14390, -13896, -13563, -13422, -13266, -13113, -12960, -12806, -12654, -12502, -12348, -12197, -12044, -11892, -11741, -11587, -11435, -11284, -11131, -10984, -10806, -10524, -10240, -9955, -9670, -9385, -9101, -8817, -8533, -8249, -7964, -7680, -7396, -7111, -6827, -6544, -6261, -5976, -5691, -5375, -5050, -4726, -4402, -4078, -3754, -3431, -3106, -2783, -2459, -2137, -1813, -1490, -1167, -843, -521, -192};