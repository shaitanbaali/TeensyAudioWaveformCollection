/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1357 256 samples */
 
const int16_t AKWF_1357_256_DATA [256] = 
{4612, 13405, 17169, 20417, 22972, 25064, 26790, 28209, 29374, 30322, 31078, 31671, 32120, 32439, 32646, 32751, 32762, 32690, 32542, 32322, 32038, 31693, 31294, 30842, 30343, 29800, 29216, 28595, 27942, 27256, 26544, 25809, 25050, 24275, 23483, 22677, 21862, 21037, 20204, 19368, 18529, 17686, 16847, 16006, 15167, 14334, 13501, 12674, 11854, 11037, 10227, 9424, 8625, 7834, 7051, 6272, 5501, 4737, 3978, 3226, 2481, 1741, 1008, 282, -440, -1156, -1867, -2573, -3272, -3967, -4658, -5342, -6022, -6698, -7367, -8032, -8693, -9347, -9997, -10642, -11281, -11914, -12543, -13165, -13782, -14392, -14994, -15592, -16182, -16765, -17341, -17909, -18468, -19021, -19564, -20098, -20624, -21140, -21647, -22145, -22631, -23108, -23575, -24029, -24474, -24908, -25330, -25741, -26141, -26528, -26904, -27269, -27620, -27961, -28289, -28604, -28909, -29201, -29480, -29749, -30004, -30247, -30480, -30700, -30908, -31105, -31290, -31464, -31626, -31777, -31917, -32046, -32164, -32270, -32366, -32452, -32527, -32592, -32646, -32691, -32725, -32749, -32764, -32768, -32763, -32749, -32724, -32691, -32649, -32597, -32536, -32467, -32388, -32301, -32204, -32100, -31987, -31865, -31735, -31597, -31451, -31297, -31134, -30964, -30786, -30600, -30407, -30207, -29999, -29784, -29563, -29333, -29097, -28855, -28606, -28351, -28090, -27822, -27548, -27269, -26984, -26694, -26398, -26097, -25792, -25481, -25165, -24846, -24522, -24193, -23862, -23526, -23186, -22844, -22497, -22147, -21796, -21440, -21083, -20723, -20360, -19996, -19630, -19261, -18890, -18520, -18146, -17771, -17396, -17019, -16641, -16263, -15884, -15504, -15124, -14743, -14362, -13981, -13599, -13218, -12836, -12454, -12073, -11692, -11311, -10931, -10550, -10170, -9791, -9412, -9033, -8656, -8279, -7901, -7526, -7150, -6775, -6402, -6028, -5654, -5283, -4911, -4540, -4171, -3802, -3433, -3066, -2699, -2332, -1967, -1602, -1238, -876, -513, -153, 214};