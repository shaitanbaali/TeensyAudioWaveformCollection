/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1319 256 samples */
 
const int16_t AKWF_1319_256_DATA [256] = 
{122, 309, 501, 701, 902, 1109, 1323, 1543, 1764, 1992, 2222, 2457, 2698, 2940, 3188, 3440, 3693, 3949, 4210, 4471, 4737, 5007, 5276, 5550, 5822, 6099, 6376, 6653, 6932, 7216, 7497, 7778, 8060, 8342, 8625, 8908, 9187, 9469, 9750, 10030, 10310, 10585, 10861, 11138, 11409, 11681, 11948, 12213, 12476, 12738, 12995, 13250, 13502, 13751, 13996, 14237, 14475, 14708, 14938, 15167, 15389, 15606, 15819, 16026, 16231, 16429, 16623, 16814, 16996, 17174, 17349, 17518, 17680, 17828, 18047, 18351, 18675, 18849, 18831, 19013, 19178, 19336, 19479, 19605, 19709, 19784, 19861, 19921, 19836, 19750, 19660, 19560, 19452, 19332, 19206, 19071, 18934, 18791, 18101, 20917, -7735, -32692, -32511, -32185, -31217, -30035, -28800, -27565, -26345, -25162, -24010, -22899, -21833, -20808, -19831, -18906, -18063, -16943, -21093, -21753, -20054, -18980, -17900, -16887, -15934, -15031, -13988, -13023, -12167, -11384, -10668, -10013, -9457, -8758, -7747, -6890, -6145, -5532, -5453, -5545, -5039, -7349, -11356, -9884, -9167, -8527, -7995, -7572, -7252, -7040, -6898, -7016, -7708, -8249, -8673, -9039, -9351, -9618, -9838, -10016, -10151, -10254, -10329, -10388, -10452, -10519, -10592, -10665, -10745, -10831, -10915, -11003, -11095, -11188, -11283, -11382, -11481, -11584, -11684, -11786, -11895, -12000, -12105, -12210, -12320, -12428, -12534, -12641, -12757, -12850, -12519, -12262, -12143, -12073, -12052, -12052, -12162, -11880, -10851, -10051, -9408, -8895, -8502, -8392, -7331, -11778, -19493, -16564, -15136, -13867, -12822, -12001, -11368, -11008, -10492, -10063, -10969, -11647, -12152, -12591, -12962, -13281, -13545, -13760, -13924, -14038, -14106, -14149, -14277, -13908, -12997, -11335, -8582, -6603, -5075, -3643, -2352, -1185, -121, 848, 1724, 2511, 3214, 3812, 4170, 5710, -13053, -17878, -13514, -11548, -9526, -7713, -6073, -4546, -2500, -685};