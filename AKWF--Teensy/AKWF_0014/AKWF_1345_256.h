/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1345 256 samples */
 
const int16_t AKWF_1345_256_DATA [256] = 
{-7058, -19648, -7181, -3063, 717, 3694, 6136, 8183, 9942, 11476, 12825, 14030, 15114, 16091, 16983, 17800, 18549, 19243, 19885, 20481, 21038, 21559, 22046, 22504, 22935, 23342, 23726, 24090, 24433, 24760, 25071, 25365, 25647, 25915, 26170, 26415, 26648, 26871, 27085, 27290, 27486, 27675, 27855, 28029, 28196, 28357, 28511, 28660, 28803, 28941, 29074, 29202, 29326, 29445, 29560, 29672, 29779, 29882, 29983, 30079, 30173, 30264, 30351, 30436, 30518, 30597, 30674, 30748, 30820, 30890, 30957, 31022, 31086, 31147, 31206, 31264, 31320, 31374, 31426, 31477, 31526, 31574, 31620, 31664, 31707, 31749, 31790, 31829, 31867, 31904, 31941, 31975, 32009, 32041, 32072, 32103, 32133, 32161, 32188, 32215, 32241, 32266, 32290, 32313, 32336, 32357, 32378, 32399, 32418, 32437, 32455, 32472, 32489, 32505, 32521, 32536, 32551, 32564, 32577, 32590, 32602, 32614, 32625, 32636, 32646, 32655, 32664, 32673, 32682, 32690, 32697, 32704, 32710, 32717, 32722, 32728, 32732, 32737, 32742, 32746, 32749, 32752, 32756, 32758, 32761, 32762, 32764, 32765, 32766, 32767, 32768, 32767, 32767, 32768, 32767, 32766, 32765, 32764, 32762, 32761, 32759, 32756, 32754, 32751, 32748, 32745, 32742, 32738, 32734, 32731, 32726, 32722, 32718, 32713, 32709, 32703, 32698, 32693, 32687, 32681, 32676, 32669, 32664, 32657, 32651, 32644, 32638, 32631, 32624, 32617, 32609, 32602, 32594, 32586, 32579, 32571, 32563, 32554, 32546, 32538, 32529, 32521, 32512, 32503, 32494, 32485, 32475, 32467, 32458, 32448, 32438, 32429, 32419, 32409, 32399, 32389, 32380, 32369, 32359, 32349, 32338, 32328, 32317, 32307, 32296, 32285, 32275, 32264, 32252, 32241, 32230, 32219, 32208, 32197, 32185, 32174, 32163, 32151, 32139, 32127, 32116, 32104, 32092, 32080, 32068, 32056, 32044, 32032, 32020, 32008, 31995, 31983, 31971, 31958, 31946, 31933};