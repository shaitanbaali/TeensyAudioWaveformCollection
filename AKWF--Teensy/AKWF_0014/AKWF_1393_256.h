/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1393 256 samples */
 
const int16_t AKWF_1393_256_DATA [256] = 
{191, 553, 1308, 1932, 2419, 2794, 3314, 4084, 4630, 5070, 5421, 5718, 5979, 6228, 6431, 6843, 7503, 7958, 8319, 8610, 8864, 9064, 9525, 10122, 10533, 10877, 11170, 11431, 11663, 12181, 12728, 13120, 13452, 13734, 13979, 14219, 14730, 15189, 15529, 15813, 16056, 16258, 16493, 16956, 17323, 17601, 17832, 18027, 18179, 18404, 18791, 19068, 19281, 19450, 19586, 19701, 19804, 19895, 19981, 20230, 20460, 20615, 20733, 20821, 20890, 20946, 20995, 21037, 21066, 21135, 21321, 21443, 21522, 21568, 21586, 21584, 21578, 21662, 21718, 21736, 21798, 21821, 21797, 21745, 21671, 21579, 21475, 21359, 21232, 21089, 20957, 20851, 20712, 20554, 20380, 20193, 19994, 19805, 19625, 19425, 19215, 19006, 18793, 18571, 18343, 18109, 17872, 17630, 17386, 17139, 16890, 16643, 16400, 16157, 15915, 15654, 15494, 14923, 10553, 6626, 3815, 1651, 120, -877, -1438, -1607, -1377, -815, 18, 1030, 2138, 3294, 4483, 5688, 6892, 8060, 9150, 10110, 10915, 11552, 11996, 12232, 12243, 12029, 11607, 11030, 10296, 9401, 8364, 7207, 5947, 4596, 3237, 1816, 321, -1218, -2795, -4412, -6035, -7573, -9176, -10835, -12530, -14237, -15935, -17549, -18999, -20470, -21930, -23359, -24739, -26066, -27333, -28462, -29334, -29956, -30513, -30992, -31396, -31732, -32011, -32240, -32425, -32576, -32688, -32716, -32740, -32760, -32768, -32764, -32744, -32708, -32652, -32500, -32345, -32143, -31848, -31586, -31333, -31079, -30817, -30545, -30256, -29944, -29606, -29259, -28629, -27871, -27202, -26578, -26010, -25468, -24971, -24250, -23299, -22589, -21728, -20711, -19946, -19292, -18721, -18207, -17731, -17273, -16824, -16388, -15969, -15188, -14389, -13777, -13244, -12772, -12345, -11907, -11086, -10338, -9741, -9216, -8747, -8337, -7862, -6971, -6146, -5511, -4982, -4536, -4148, -3795, -3461, -3149, -2833, -2106, -1419, -912, -483, -114};