/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1362 256 samples */
 
const int16_t AKWF_1362_256_DATA [256] = 
{459, 1485, 2543, 3634, 4769, 5932, 7132, 8353, 9600, 10866, 12141, 13430, 14718, 16007, 17284, 18556, 19796, 21021, 22209, 23362, 24471, 25533, 26537, 27488, 28366, 29179, 29917, 30579, 31156, 31650, 32057, 32373, 32598, 32730, 32767, 32711, 32561, 32321, 31985, 31563, 31051, 30457, 29780, 29027, 28197, 27301, 26338, 25319, 24244, 23124, 21957, 20760, 19526, 18270, 16997, 15706, 14411, 13115, 11824, 10537, 9273, 8017, 6794, 5592, 4425, 3289, 2196, 1137, 124, -846, -1774, -2655, -3486, -4277, -5018, -5715, -6369, -6977, -7547, -8077, -8570, -9027, -9455, -9849, -10220, -10564, -10888, -11193, -11482, -11756, -12021, -12276, -12523, -12766, -13004, -13242, -13476, -13711, -13945, -14180, -14413, -14647, -14878, -15108, -15331, -15550, -15759, -15962, -16148, -16322, -16477, -16611, -16723, -16808, -16863, -16886, -16874, -16823, -16732, -16596, -16416, -16189, -15911, -15584, -15205, -14774, -14287, -13752, -13158, -12519, -11824, -11084, -10295, -9464, -8588, -7679, -6732, -5754, -4756, -3731, -2693, -1643, -586, 470, 1517, 2556, 3575, 4573, 5539, 6477, 7364, 8217, 9012, 9754, 10434, 11053, 11600, 12079, 12481, 12807, 13054, 13219, 13304, 13306, 13226, 13064, 12821, 12498, 12098, 11626, 11079, 10467, 9785, 9050, 8252, 7409, 6517, 5587, 4618, 3626, 2604, 1568, 521, -535, -1587, -2638, -3675, -4700, -5700, -6678, -7623, -8536, -9410, -10244, -11028, -11774, -12463, -13107, -13696, -14234, -14718, -15150, -15527, -15854, -16129, -16354, -16531, -16663, -16747, -16813, -16684, -16284, -15869, -15426, -14965, -14485, -13994, -13495, -12990, -12485, -11980, -11478, -10982, -10493, -10011, -9539, -9077, -8624, -8183, -7752, -7330, -6919, -6517, -6122, -5738, -5361, -4991, -4629, -4273, -3923, -3582, -3246, -2919, -2600, -2291, -1992, -1707, -1434, -1178, -940, -722, -528, -360, -220, -111, -38};