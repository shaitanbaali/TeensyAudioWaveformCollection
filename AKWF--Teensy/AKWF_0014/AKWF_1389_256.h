/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1389 256 samples */
 
const int16_t AKWF_1389_256_DATA [256] = 
{1173, 5026, 8617, 11957, 15034, 17891, 20606, 23270, 25936, 28120, 29609, 30635, 31334, 31805, 32123, 32337, 32479, 32575, 32639, 32682, 32710, 32729, 32741, 32749, 32755, 32759, 32762, 32763, 32764, 32766, 32766, 32767, 32766, 32767, 32766, 32767, 32768, 32767, 32768, 32768, 32767, 32768, 32767, 32766, 32767, 32767, 32766, 32767, 32766, 32766, 32765, 32765, 32764, 32763, 32761, 32759, 32755, 32750, 32745, 32741, 32735, 32731, 32727, 32724, 32719, 32715, 32711, 32705, 32696, 32685, 32668, 32644, 32616, 32585, 32553, 32521, 32488, 32451, 32408, 32356, 32292, 32215, 32123, 32014, 31883, 31727, 31545, 31331, 31082, 30795, 30463, 30085, 29655, 29166, 28619, 28008, 27300, 26690, 26058, 25373, 24619, 23929, 23275, 22514, 21887, 21369, 20898, 20522, 20339, 20388, 20555, 20649, 20522, 20099, 19397, 18528, 17578, 16602, 15908, 15264, 14665, 14104, 13522, 12909, 12275, 11635, 11002, 10347, 9630, 8840, 7962, 6983, 5924, 4814, 3677, 2527, 1350, 140, -1105, -2397, -3729, -5093, -6484, -7879, -9264, -10642, -12004, -13348, -14678, -15986, -17267, -18525, -19752, -20950, -22093, -23325, -24593, -25945, -26982, -27938, -28713, -29341, -29867, -30305, -30664, -30966, -31234, -31482, -31710, -31907, -32069, -32217, -32324, -32401, -32451, -32496, -32528, -32554, -32579, -32600, -32619, -32638, -32656, -32676, -32694, -32709, -32724, -32733, -32740, -32744, -32747, -32749, -32752, -32753, -32755, -32757, -32758, -32759, -32759, -32761, -32762, -32762, -32762, -32763, -32764, -32763, -32764, -32765, -32766, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32766, -32765, -32763, -32764, -32763, -32762, -32761, -32760, -32757, -32754, -32750, -32745, -32737, -32728, -32714, -32696, -32670, -32633, -32576, -32466, -32269, -31899, -31262, -30216, -28648, -26677, -24187, -21834, -19590, -17359, -15005, -12382, -9434, -6179, -2524};