/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1367 256 samples */
 
const int16_t AKWF_1367_256_DATA [256] = 
{24274, 33739, 31659, 31668, 31346, 31034, 30709, 30437, 30131, 29814, 29500, 29186, 28874, 28560, 28249, 27937, 27627, 27316, 27006, 26698, 26389, 26082, 25775, 25468, 25162, 24857, 24552, 24248, 23945, 23642, 23339, 23038, 22736, 22435, 22135, 21836, 21537, 21240, 20940, 20644, 20348, 20052, 19757, 19462, 19167, 18875, 18581, 18288, 17997, 17705, 17414, 17125, 16834, 16546, 16257, 15969, 15681, 15396, 15108, 14823, 14539, 14254, 13969, 13686, 13402, 13121, 12839, 12557, 12277, 11998, 11717, 11438, 11160, 10882, 10605, 10328, 10051, 9775, 9501, 9225, 8951, 8678, 8405, 8132, 7860, 7589, 7319, 7047, 6777, 6509, 6239, 5971, 5704, 5436, 5169, 4903, 4636, 4372, 4107, 3842, 3579, 3316, 3054, 2791, 2530, 2269, 2009, 1749, 1488, 1230, 972, 713, 457, 199, -57, -312, -567, -824, -1078, -1331, -1585, -1838, -2091, -2343, -2594, -2844, -3095, -3345, -3594, -3844, -4092, -4341, -4587, -4836, -5083, -5328, -5574, -5819, -6064, -6308, -6552, -6795, -7037, -7280, -7522, -7763, -8005, -8245, -8485, -8724, -8963, -9202, -9441, -9677, -9914, -10152, -10388, -10624, -10859, -11094, -11328, -11562, -11796, -12029, -12261, -12494, -12726, -12956, -13188, -13418, -13648, -13876, -14106, -14335, -14563, -14790, -15017, -15245, -15471, -15697, -15923, -16147, -16371, -16595, -16820, -17043, -17265, -17487, -17710, -17931, -18152, -18373, -18593, -18812, -19031, -19251, -19469, -19687, -19905, -20121, -20339, -20555, -20771, -20987, -21201, -21416, -21631, -21844, -22057, -22270, -22483, -22695, -22908, -23119, -23328, -23539, -23750, -23959, -24169, -24376, -24586, -24795, -25002, -25209, -25416, -25622, -25828, -26034, -26239, -26444, -26650, -26846, -27053, -27261, -27460, -27667, -27392, -30173, -12476, 6285, 3530, 3720, 3456, 3198, 2927, 2695, 2461, 2194, 1933, 1681, 1416, 1155, 899, 614, 500, -337};