/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1320 256 samples */
 
const int16_t AKWF_1320_256_DATA [256] = 
{874, 3129, 5267, 7340, 9341, 11275, 13146, 14944, 16685, 18363, 19971, 21526, 23020, 24455, 25835, 27163, 28432, 29652, 30805, 32000, 32622, 31994, 31382, 30789, 30204, 29624, 29105, 28375, 26092, 23607, 21272, 19006, 16814, 14702, 12668, 10704, 8816, 7000, 5247, 3567, 1949, 398, -1094, -2526, -3898, -5210, -6470, -7677, -8828, -9928, -11004, -11907, -12286, -12599, -12903, -13185, -13452, -13699, -13932, -14148, -14351, -14539, -14714, -14877, -15028, -15167, -15297, -15417, -15530, -15633, -15728, -15817, -15896, -15965, -16036, -15784, -14016, -11920, -9941, -7997, -6112, -4278, -2508, -802, 839, 2407, 3896, 5313, 6645, 7888, 9046, 10109, 11076, 11949, 12723, 13398, 13974, 14450, 14837, 15083, 14554, 13775, 12988, 12151, 11275, 10364, 9424, 8457, 7474, 6485, 5485, 4489, 3507, 2534, 1584, 714, -406, -2130, -3745, -5262, -6669, -7957, -9134, -10189, -11121, -11933, -12617, -13184, -13623, -13944, -14151, -14239, -14219, -14096, -13873, -13563, -13164, -12687, -12136, -11565, -10200, -8245, -6400, -4610, -2891, -1242, 326, 1802, 3176, 4453, 5628, 6690, 7633, 8462, 9164, 9740, 10194, 10530, 10729, 10813, 10777, 10629, 10366, 9986, 9278, 8430, 7560, 6640, 5759, 4890, 3982, 3062, 2134, 1204, 287, -611, -1479, -2307, -3086, -3803, -4462, -5043, -5546, -5976, -6255, -6381, -6424, -6373, -6232, -5994, -5671, -5260, -4776, -4223, -3594, -2918, -2193, -1431, -631, 178, 999, 1814, 2608, 3372, 4101, 4777, 5391, 5932, 6387, 6762, 7034, 7182, 7219, 7159, 6976, 6667, 6233, 5688, 5028, 4248, 3363, 2381, 1308, 163, -1058, -2342, -3658, -5013, -6383, -7753, -9109, -10411, -11688, -12884, -14014, -15040, -15963, -16759, -17397, -17910, -18242, -18407, -18394, -18199, -17791, -17209, -16429, -15449, -14279, -12910, -11369, -9670, -7792, -5764, -3608, -1285};