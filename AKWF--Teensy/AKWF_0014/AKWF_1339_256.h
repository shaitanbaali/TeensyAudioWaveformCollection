/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1339 256 samples */
 
const int16_t AKWF_1339_256_DATA [256] = 
{3534, 10227, 17089, 20052, 19036, 18323, 17563, 16799, 16028, 15248, 14554, 11532, 7072, 2839, -1445, -5731, -9992, -14259, -18633, -18541, -15449, -12743, -9972, -7192, -4410, -1686, 1427, 3401, 4647, 6033, 7393, 8752, 10101, 11480, 12746, 11056, 8162, 5476, 2745, 22, -2686, -5471, -8224, -8098, -7456, -6932, -6384, -5835, -5285, -4741, -4206, -2805, -1163, 427, 2024, 3628, 5191, 6944, 8013, 6758, 5495, 4242, 2987, 1729, 479, -814, -1656, -2007, -2392, -2771, -3151, -3530, -3886, -4361, -4121, -2985, -1938, -879, 183, 1244, 2295, 3401, 3713, 3277, 2908, 2528, 2147, 1764, 1389, 975, 444, -81, -603, -1129, -1653, -2174, -2699, -3231, -3036, -2407, -1840, -1261, -682, -105, 468, 1105, 1304, 1334, 1398, 1455, 1513, 1564, 1643, 1591, 1184, 774, 366, -43, -451, -855, -1287, -1518, -1344, -1166, -989, -810, -632, -457, -271, -57, 129, 317, 504, 691, 878, 1063, 1267, 1272, 1022, 789, 554, 317, 81, -149, -413, -544, -541, -558, -572, -587, -600, -612, -633, -553, -387, -232, -77, 80, 236, 392, 561, 545, 454, 377, 297, 217, 138, 58, -12, -85, -169, -253, -336, -420, -502, -589, -663, -601, -522, -447, -370, -294, -219, -140, -82, -70, -62, -53, -43, -34, -27, -12, -36, -140, -241, -341, -443, -545, -645, -753, -794, -715, -638, -558, -480, -403, -323, -245, -110, 59, 226, 392, 558, 723, 888, 1062, 1108, 1049, 1002, 951, 901, 853, 806, 730, 1443, 2566, 3620, 4687, 5750, 6813, 7893, 8899, 9348, 9649, 9975, 10296, 10617, 10911, 11312, 11303, 6592, 771, -4819, -10442, -16081, -21666, -27457, -32191, -29995, -26122, -22572, -18957, -15344, -11724, -8159, -3707};