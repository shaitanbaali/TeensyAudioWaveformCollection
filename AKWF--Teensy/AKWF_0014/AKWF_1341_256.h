/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1341 256 samples */
 
const int16_t AKWF_1341_256_DATA [256] = 
{241, 1141, 2022, 2904, 3783, 4660, 5535, 6403, 7269, 8130, 8983, 9830, 10671, 11503, 12328, 13143, 13947, 14743, 15529, 16301, 17063, 17812, 18547, 19271, 19979, 20672, 21352, 22014, 22661, 23292, 23906, 24502, 25081, 25641, 26182, 26705, 27207, 27690, 28154, 28596, 29017, 29418, 29797, 30154, 30489, 30802, 31093, 31361, 31605, 31827, 32027, 32202, 32354, 32482, 32587, 32668, 32725, 32758, 32768, 32754, 32715, 32653, 32567, 32458, 32324, 32167, 31987, 31783, 31556, 31306, 31033, 30739, 30421, 30081, 29719, 29336, 28930, 28505, 28058, 27591, 27105, 26597, 26070, 25526, 24961, 24379, 23779, 23161, 22527, 21877, 21210, 20528, 19832, 19119, 18394, 17656, 16904, 16140, 15365, 14577, 13780, 12973, 12154, 11330, 10495, 9652, 8805, 7949, 7087, 6223, 5351, 4476, 3599, 2718, 1835, 952, 68, -817, -1700, -2583, -3464, -4342, -5218, -6089, -6955, -7818, -8674, -9523, -10367, -11202, -12029, -12848, -13656, -14455, -15245, -16022, -16787, -17542, -18281, -19009, -19724, -20421, -21107, -21776, -22428, -23065, -23685, -24287, -24873, -25440, -25987, -26517, -27027, -27517, -27988, -28438, -28866, -29275, -29661, -30026, -30370, -30691, -30990, -31266, -31519, -31749, -31957, -32141, -32301, -32438, -32551, -32641, -32707, -32749, -32767, -32762, -32732, -32679, -32601, -32500, -32375, -32227, -32055, -31860, -31641, -31400, -31135, -30848, -30539, -30207, -29853, -29478, -29080, -28663, -28223, -27763, -27284, -26784, -26264, -25726, -25169, -24592, -24000, -23388, -22759, -22116, -21455, -20778, -20087, -19380, -18659, -17927, -17179, -16419, -15649, -14865, -14072, -13268, -12453, -11631, -10801, -9961, -9115, -8262, -7402, -6539, -5669, -4795, -3919, -3040, -2157, -1275, -390, 495, 1377, 2261, 3144, 4022, 4899, 5773, 6640, 7504, 8363, 9214, 10060, 10899, 11728, 12551, 13364, 14165, 14958, 15740, 16509, 17267, 18011, 18755};