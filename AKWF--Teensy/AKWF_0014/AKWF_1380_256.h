/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1380 256 samples */
 
const int16_t AKWF_1380_256_DATA [256] = 
{2461, 6955, 10835, 14125, 16739, 18637, 19800, 20230, 19964, 19051, 17566, 15591, 13221, 10568, 7726, 4806, 1917, -860, -3433, -5726, -7690, -9274, -10448, -11205, -11542, -11476, -11032, -10252, -9181, -7871, -6385, -4780, -3114, -1455, 149, 1650, 3000, 4164, 5120, 5843, 6328, 6574, 6585, 6378, 5971, 5394, 4672, 3841, 2937, 1990, 1037, 111, -761, -1554, -2243, -2817, -3261, -3567, -3739, -3774, -3681, -3474, -3163, -2767, -2304, -1795, -1258, -712, -179, 328, 792, 1200, 1544, 1814, 2006, 2120, 2158, 2121, 2016, 1850, 1634, 1377, 1090, 787, 475, 167, -126, -397, -638, -842, -1006, -1126, -1202, -1233, -1221, -1169, -1081, -964, -822, -661, -489, -311, -134, 35, 193, 335, 457, 556, 630, 679, 702, 700, 676, 629, 566, 487, 398, 300, 199, 98, 0, -92, -176, -247, -307, -352, -383, -400, -402, -391, -368, -333, -290, -239, -184, -127, -69, -12, 40, 89, 132, 167, 195, 215, 227, 229, 224, 213, 195, 170, 143, 112, 79, 46, 14, -17, -46, -71, -92, -109, -121, -129, -132, -130, -124, -114, -101, -86, -69, -50, -31, -12, 5, 22, 37, 49, 59, 67, 72, 74, 73, 71, 65, 59, 50, 41, 30, 19, 8, -2, -11, -20, -27, -33, -38, -41, -42, -42, -41, -39, -35, -31, -25, -18, -13, -7, -1, 4, 9, 14, 17, 20, 22, 23, 24, 23, 21, 20, 16, 14, 11, 7, 4, 0, -3, -5, -8, -10, -12, -13, -14, -13, -14, -13, -12, -11, -9, -7, -6, -3, -1, 0, 2, 3, 5, 6, -466, 2167, -22182, -32218, -25936, -22152, -17422, -12408, -7310, -2201};