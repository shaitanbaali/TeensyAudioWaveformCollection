/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1333 256 samples */
 
const int16_t AKWF_1333_256_DATA [256] = 
{-9605, -9278, -9339, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9327, -9335, -9514, -8442, -23049, -30683, -29346, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29587, -29236, -31226, -23401, 9801, 8455, 8647, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8667, 8664, 8678, 8604};