/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1344 256 samples */
 
const int16_t AKWF_1344_256_DATA [256] = 
{-3823, -37415, -30074, -29110, -27196, -25419, -23788, -22295, -20918, -19641, -18458, -17351, -16312, -15337, -14415, -13543, -12718, -11930, -11180, -10466, -9780, -9124, -8495, -7889, -7306, -6745, -6204, -5681, -5176, -4686, -4212, -3754, -3308, -2876, -2455, -2046, -1650, -1263, -885, -519, -161, 188, 528, 861, 1187, 1504, 1815, 2119, 2416, 2707, 2992, 3271, 3545, 3813, 4075, 4334, 4587, 4835, 5079, 5318, 5552, 5784, 6010, 6232, 6452, 6667, 6879, 7088, 7293, 7494, 7693, 7888, 8081, 8270, 8457, 8641, 8822, 9000, 9176, 9350, 9521, 9689, 9856, 10020, 10181, 10341, 10498, 10653, 10807, 10958, 11107, 11255, 11400, 11544, 11687, 11827, 11966, 12102, 12237, 12371, 12503, 12634, 12763, 12890, 13016, 13141, 13264, 13386, 13507, 13626, 13744, 13860, 13975, 14090, 14203, 14314, 14425, 14535, 14643, 14750, 14856, 14961, 15065, 15168, 15270, 15371, 15471, 15570, 15668, 15765, 15861, 15956, 16051, 16144, 16237, 16328, 16419, 16509, 16598, 16687, 16775, 16861, 16948, 17033, 17117, 17201, 17284, 17366, 17448, 17529, 17609, 17689, 17768, 17846, 17924, 18001, 18077, 18153, 18228, 18302, 18377, 18450, 18522, 18595, 18666, 18737, 18808, 18877, 18947, 19016, 19084, 19152, 19219, 19286, 19352, 19417, 19483, 19548, 19612, 19676, 19739, 19802, 19864, 19926, 19988, 20049, 20109, 20170, 20229, 20289, 20348, 20406, 20464, 20522, 20579, 20636, 20692, 20749, 20804, 20860, 20914, 20969, 21024, 21077, 21131, 21184, 21237, 21289, 21341, 21392, 21444, 21495, 21546, 21597, 21646, 21696, 21746, 21795, 21844, 21892, 21940, 21989, 22036, 22083, 22131, 22177, 22223, 22270, 22315, 22361, 22406, 22451, 22496, 22541, 22585, 22629, 22673, 22716, 22759, 22802, 22844, 22886, 22929, 22971, 23013, 23054, 23095, 23136, 23177, 23218, 23258, 23297, 23337, 23377, 23416, 23456};