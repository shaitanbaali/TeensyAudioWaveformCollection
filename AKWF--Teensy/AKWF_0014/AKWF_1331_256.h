/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1331 256 samples */
 
const int16_t AKWF_1331_256_DATA [256] = 
{5805, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5807, 5804, 6213, 4036, 17900, 28902, 26855, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27235, 27330, 26820, 29567, 32934, 32380, 32485, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32483, 32428, 32689, 31745, 19434, 18177, 18497, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18432, 18433, 17981, 20400, 8303, -8578, -6110, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6569, -6652, -6251, -7677, -26414, -28016, -27583, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27670, -27671, -27753, -27307, -30361, -32685, -32252, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32332, -32080, -33438, -26158, -16644, -18047, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785, -17785};