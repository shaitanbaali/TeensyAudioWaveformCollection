/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1387 256 samples */
 
const int16_t AKWF_1387_256_DATA [256] = 
{308, 1129, 1937, 2741, 3529, 4298, 5051, 5782, 6494, 7184, 7852, 8497, 9118, 9715, 10288, 10836, 11357, 11854, 12325, 12772, 13196, 13598, 13978, 14339, 14680, 15004, 15312, 15606, 15886, 16156, 16416, 16666, 16913, 17155, 17394, 17631, 17868, 18105, 18346, 18590, 18838, 19090, 19349, 19615, 19886, 20166, 20454, 20749, 21060, 21423, 21845, 22337, 22907, 23552, 24266, 25036, 25831, 26637, 27445, 28238, 29005, 29734, 30415, 31032, 31580, 32047, 32422, 32668, 32768, 32712, 32480, 32078, 31503, 30759, 29860, 28822, 27660, 26390, 25028, 23596, 22122, 20623, 19123, 17648, 16224, 14902, 13705, 12655, 11768, 11046, 10484, 10077, 9802, 9645, 9588, 9616, 9704, 9835, 9986, 10136, 10267, 10364, 10401, 10331, 10130, 9777, 9253, 8556, 7674, 6617, 5388, 4003, 2480, 826, -913, -2692, -4486, -6261, -7997, -9669, -11230, -12668, -13966, -15110, -16100, -16933, -17615, -18156, -18564, -18844, -19004, -19057, -19017, -18899, -18719, -18494, -18237, -17964, -17690, -17426, -17184, -16974, -16805, -16680, -16607, -16583, -16611, -16691, -16820, -16995, -17210, -17466, -17753, -18069, -18410, -18770, -19143, -19529, -19917, -20306, -20692, -21067, -21426, -21770, -22087, -22379, -22639, -22867, -23089, -23323, -23568, -23841, -24133, -24440, -24760, -25078, -25378, -25655, -25900, -26105, -26258, -26348, -26370, -26314, -26174, -25946, -25625, -25212, -24708, -24113, -23433, -22674, -21837, -20936, -19977, -18969, -17924, -16852, -15763, -14670, -13582, -12509, -11474, -10487, -9556, -8696, -7899, -7176, -6527, -5950, -5449, -5024, -4673, -4395, -4188, -4048, -3969, -3951, -3986, -4071, -4201, -4366, -4567, -4793, -5044, -5309, -5586, -5867, -6148, -6424, -6688, -6935, -7162, -7363, -7533, -7670, -7768, -7823, -7834, -7798, -7711, -7574, -7384, -7140, -6845, -6492, -6091, -5635, -5131, -4581, -3988, -3354, -2682, -1974, -1239, -460};