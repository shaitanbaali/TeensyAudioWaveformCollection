/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1325 256 samples */
 
const int16_t AKWF_1325_256_DATA [256] = 
{31195, 31299, 31280, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31283, 31281, 31056, 32350, 15529, 8687, 10103, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9850, 9325, 12209, -1395, -34542, -32389, -32735, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32682, -32935, -32132, -8710, -2856, -4153, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3908, -3912, -3894, -3990};