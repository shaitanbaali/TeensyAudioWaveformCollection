/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1307 256 samples */
 
const int16_t AKWF_1307_256_DATA [256] = 
{501, 1374, 2329, 3396, 4590, 5937, 7416, 9784, 11325, 12478, 13954, 15419, 16849, 18222, 19541, 20803, 22006, 23159, 24257, 25300, 26296, 27221, 28081, 28889, 29634, 30312, 30921, 31456, 31911, 32278, 32551, 32718, 32769, 32688, 32456, 32062, 31481, 30675, 29688, 28064, 26296, 25009, 23122, 21463, 19597, 17343, 13997, 11084, 9445, 7245, 5035, 2884, 811, -1170, -3055, -4859, -6606, -8183, -9669, -11084, -12408, -13648, -14798, -15861, -16840, -17733, -18541, -19265, -19899, -20461, -20779, -21180, -21700, -22094, -22452, -22786, -23104, -23404, -23693, -23968, -24230, -24482, -24721, -24949, -25166, -25370, -25561, -25740, -25903, -26051, -26183, -26293, -26382, -26445, -26480, -26482, -26445, -26365, -26234, -26045, -25791, -25460, -25041, -24523, -23888, -23117, -22262, -20849, -19550, -18801, -17725, -16572, -15368, -14110, -12823, -11329, -9602, -8533, -7354, -6121, -4912, -3731, -2578, -1449, -337, 770, 1879, 2998, 4144, 5321, 6551, 7796, 9433, 10865, 11841, 12999, 14143, 15251, 16305, 17311, 18267, 19172, 20033, 20849, 21618, 22347, 23032, 23673, 24272, 24827, 25335, 25796, 26206, 26559, 26857, 27092, 27258, 27350, 27357, 27289, 27028, 26687, 26468, 26094, 25564, 24928, 24368, 23506, 22676, 22100, 21018, 19869, 18587, 17123, 15568, 13105, 10771, 9665, 8068, 6443, 4856, 3338, 1900, 536, -753, -1971, -3125, -4217, -5248, -6226, -7150, -8026, -8857, -9643, -10389, -11098, -11768, -12405, -13012, -13586, -14133, -14653, -15147, -15617, -16066, -16489, -16894, -17277, -17640, -17983, -18307, -18609, -18892, -19154, -19392, -19608, -19799, -19961, -20095, -20195, -20258, -20279, -20255, -20178, -20041, -19838, -19559, -19196, -18735, -18165, -17465, -16675, -15202, -14260, -13719, -12897, -12076, -11281, -10519, -9795, -9110, -8457, -7833, -7238, -6664, -6108, -5565, -5030, -4497, -3963, -3417, -2855, -2268, -1649, -989, -258};