/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1308 256 samples */
 
const int16_t AKWF_1308_256_DATA [256] = 
{4197, 5503, 5953, 7437, 8988, 10549, 12079, 13543, 14939, 16277, 17549, 18756, 19902, 20982, 22006, 22975, 23888, 24759, 25587, 26388, 27138, 27784, 28393, 28966, 29483, 29945, 30357, 30722, 31040, 31323, 31571, 31786, 31972, 32129, 32264, 32382, 32481, 32568, 32646, 32704, 32745, 32763, 32768, 32762, 32736, 32694, 32632, 32554, 32459, 32343, 32202, 32041, 31863, 31663, 31433, 31166, 30859, 30509, 30126, 29715, 29262, 28749, 28185, 27564, 26777, 25824, 25180, 24492, 23767, 23030, 22303, 21595, 20895, 20217, 19556, 18896, 18246, 17609, 16970, 16319, 15658, 14994, 14336, 13681, 13016, 12338, 11651, 10959, 10277, 9609, 8959, 8314, 7681, 7073, 6475, 5889, 5308, 4731, 4173, 3636, 3115, 2595, 2070, 1546, 1023, 496, -36, -574, -1107, -1633, -2155, -2662, -3144, -3605, -4046, -4463, -4863, -5244, -5617, -5983, -6350, -6722, -7093, -7462, -7845, -8242, -8645, -9059, -9494, -9935, -10383, -10837, -11282, -11710, -12130, -12548, -12950, -13333, -13710, -14092, -14472, -14848, -15227, -15610, -15989, -16343, -16669, -16993, -17319, -17622, -17915, -18186, -18430, -18661, -18886, -19095, -19281, -19442, -19586, -19713, -19829, -19947, -20057, -20158, -20243, -20314, -20376, -20434, -20493, -20561, -20636, -20715, -20800, -20887, -20954, -21004, -21055, -21102, -21142, -21177, -21202, -21215, -21219, -21217, -21196, -21143, -21058, -20950, -20813, -20642, -20443, -20202, -19811, -19253, -19016, -18729, -18390, -18050, -17718, -17399, -17085, -16774, -16468, -16172, -15897, -15637, -15371, -15102, -14837, -14571, -14310, -14063, -13819, -13574, -13324, -13066, -12807, -12548, -12291, -12037, -11779, -11510, -11232, -10937, -10632, -10334, -10045, -9760, -9476, -9179, -8866, -8553, -8252, -7953, -7646, -7332, -7013, -6685, -6344, -6004, -5670, -5331, -4999, -4660, -4303, -3921, -3516, -3091, -2719, -2436, -2142, -1861, -1599, -1367, -1167, -990};