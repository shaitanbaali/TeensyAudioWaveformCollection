/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1399 256 samples */
 
const int16_t AKWF_1399_256_DATA [256] = 
{758, 2250, 3744, 5275, 6836, 8432, 10061, 11718, 13393, 15113, 16212, 18976, 21141, 20632, 20567, 20426, 20282, 20133, 19983, 19830, 19671, 19510, 19344, 19176, 19005, 18829, 18650, 18466, 18280, 18089, 17893, 17694, 17491, 17283, 17071, 16855, 16634, 16410, 16179, 15943, 15704, 15458, 15209, 14952, 14693, 14428, 14155, 13878, 13596, 13306, 13012, 12710, 12403, 12090, 11769, 11441, 11109, 10768, 10420, 10064, 9702, 9332, 8954, 8569, 8173, 7772, 7361, 6941, 6514, 6077, 5630, 5175, 4709, 4233, 3749, 3254, 2748, 2232, 1704, 1165, 617, 56, -517, -1100, -1699, -2309, -2931, -3567, -4217, -4880, -5558, -6248, -6954, -7677, -8412, -9164, -9933, -10715, -11515, -12334, -13167, -14016, -14878, -16002, -15333, -26692, -33870, -32187, -31888, -31140, -30344, -29535, -28709, -27861, -26998, -26116, -25215, -24295, -23357, -22396, -21416, -20417, -19395, -18352, -17288, -16198, -15087, -13953, -12793, -11612, -10405, -9170, -7912, -6627, -5311, -3973, -2604, -1204, 220, 1679, 3168, 4685, 6238, 7824, 9440, 11092, 12780, 14496, 16241, 17954, 19759, 20255, 17021, 16768, 16571, 16339, 16107, 15873, 15632, 15386, 15134, 14879, 14616, 14348, 14076, 13796, 13512, 13220, 12924, 12620, 12310, 11994, 11671, 11341, 11005, 10660, 10310, 9951, 9586, 9212, 8830, 8443, 8044, 7637, 7223, 6801, 6367, 5927, 5477, 5017, 4546, 4068, 3578, 3078, 2568, 2046, 1515, 972, 417, -147, -725, -1317, -1918, -2533, -3162, -3801, -4456, -5126, -5806, -6502, -7213, -7937, -8676, -9431, -10199, -10984, -11784, -12597, -13428, -14272, -15132, -16007, -16895, -17796, -18712, -19638, -20573, -21514, -22465, -23418, -24374, -25322, -26263, -27187, -28085, -28951, -29771, -30527, -31205, -31683, -32673, -30788, -16921, -15707, -14676, -13505, -12340, -11146, -9929, -8688, -7417, -6122, -4801, -3450, -2075, -642};