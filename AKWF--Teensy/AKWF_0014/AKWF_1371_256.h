/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1371 256 samples */
 
const int16_t AKWF_1371_256_DATA [256] = 
{26576, 30482, 29105, 28789, 28316, 27848, 27374, 26976, 26505, 26035, 25565, 25097, 24628, 24163, 23697, 23231, 22769, 22304, 21842, 21384, 20922, 20461, 20004, 19546, 19089, 18633, 18178, 17725, 17272, 16819, 16368, 15918, 15467, 15018, 14572, 14124, 13679, 13233, 12787, 12346, 11901, 11460, 11020, 10580, 10141, 9702, 9265, 8828, 8393, 7956, 7523, 7090, 6657, 6226, 5795, 5366, 4937, 4509, 4082, 3655, 3229, 2804, 2381, 1958, 1535, 1113, 694, 273, -144, -562, -982, -1397, -1812, -2228, -2640, -3055, -3468, -3879, -4289, -4701, -5109, -5518, -5926, -6331, -6739, -7143, -7547, -7952, -8355, -8756, -9159, -9558, -9957, -10357, -10756, -11153, -11549, -11945, -12339, -12734, -13128, -13522, -13914, -14303, -14695, -15086, -15474, -15861, -16250, -16634, -17021, -17408, -17791, -18174, -18559, -18940, -19322, -19704, -20081, -20462, -20840, -21216, -21594, -21971, -22345, -22721, -23095, -23467, -23841, -24212, -24584, -24954, -25323, -25681, -26065, -26430, -26795, -27082, -27321, -29080, 11578, 27391, 23757, 23881, 23410, 22955, 22480, 22089, 21641, 21177, 20719, 20259, 19801, 19344, 18888, 18432, 17979, 17524, 17072, 16619, 16169, 15719, 15270, 14821, 14374, 13927, 13481, 13036, 12593, 12149, 11708, 11267, 10825, 10386, 9947, 9509, 9073, 8636, 8200, 7767, 7331, 6900, 6468, 6037, 5607, 5178, 4750, 4321, 3894, 3468, 3043, 2618, 2194, 1772, 1351, 929, 508, 89, -329, -746, -1163, -1579, -1994, -2409, -2823, -3235, -3648, -4059, -4469, -4879, -5289, -5696, -6104, -6510, -6914, -7321, -7726, -8129, -8530, -8932, -9333, -9734, -10133, -10530, -10930, -11326, -11722, -12119, -12513, -12907, -13302, -13692, -14084, -14475, -14864, -15254, -15643, -16031, -16418, -16805, -17190, -17575, -17960, -18342, -18724, -19107, -19487, -19869, -20247, -20614, -21011, -21381, -21754, -21996, -23134, -19934};