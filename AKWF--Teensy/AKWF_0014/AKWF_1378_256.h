/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1378 256 samples */
 
const int16_t AKWF_1378_256_DATA [256] = 
{169, 655, 1161, 1711, 2316, 2971, 3660, 4366, 5085, 6097, 5672, 15758, 14459, 26989, 30207, 30152, 28978, 27320, 25510, 23695, 21937, 20278, 18727, 17272, 15915, 14654, 13478, 12400, 11412, 10500, 9654, 8857, 8092, 7355, 6649, 5979, 5354, 5058, 4575, 4059, 3598, 3173, 2790, 2441, 2124, 1828, 1547, 1275, 1010, 748, 490, 237, -11, -251, -486, -715, -939, -1161, -1380, -1604, -1834, -2081, -2353, -2655, -2991, -3362, -3765, -4193, -4626, -5029, -5382, -5679, -5924, -6120, -6273, -6392, -6479, -6535, -6570, -6593, -6612, -6631, -6650, -6663, -6667, -6659, -6636, -6599, -6523, -6439, -6353, -6254, -6152, -6055, -5975, -5919, -5892, -5897, -5930, -5982, -6045, -6107, -6159, -6191, -6197, -6177, -6132, -6064, -5983, -5899, -5819, -5748, -5690, -5641, -5594, -5541, -5473, -5379, -5256, -5097, -4903, -4676, -4418, -4141, -3854, -3569, -3301, -3056, -2835, -2640, -2460, -2285, -2106, -1914, -1698, -1459, -1191, -895, -582, -513, -230, 76, 330, 540, 701, 814, 881, 914, 915, 946, 669, 1931, 5012, 4886, 4900, 4902, 4887, 4848, 4780, 4676, 4527, 4340, 4116, 3860, 3584, 3297, 3008, 2728, 2461, 2209, 1968, 1730, 1490, 1237, 970, 674, 324, 2609, 3146, 2602, 2275, 1928, 1606, 1308, 1044, 801, 573, 349, 140, -163, -705, -942, -1190, -1441, -1698, -1951, -2186, -2399, -2585, -2748, -2885, -2996, -3083, -3157, -3232, -3322, -3437, -3582, -3752, -3940, -4143, -4354, -4551, -4710, -4828, -4895, -4911, -4882, -4819, -4742, -4664, -4595, -4536, -4486, -4450, -4425, -4413, -4405, -4393, -4361, -4298, -4201, -4073, -3916, -3740, -3542, -3323, -3090, -2870, -2694, -2594, -2635, -2671, -2712, -2738, -2727, -2673, -2575, -2442, -2282, -2085, -1835, -1519, -1143, -726, -275};