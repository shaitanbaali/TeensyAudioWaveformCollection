/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1340 256 samples */
 
const int16_t AKWF_1340_256_DATA [256] = 
{227, 1060, 2167, 3551, 5216, 7147, 9318, 11680, 14187, 16782, 19390, 21943, 24360, 26563, 28491, 30099, 31341, 32199, 32669, 32761, 32505, 31940, 31114, 30080, 28893, 27614, 26285, 24966, 23693, 22498, 21411, 20448, 19610, 18901, 18312, 17828, 17435, 17103, 16804, 16518, 16215, 15868, 15452, 14934, 14294, 13509, 12558, 11435, 10136, 8671, 7059, 5338, 3542, 1721, -69, -1788, -3384, -4816, -6058, -7085, -7888, -8475, -8856, -9053, -9092, -9008, -8833, -8603, -8347, -8095, -7866, -7678, -7539, -7455, -7426, -7450, -7520, -7634, -7790, -7982, -8218, -8508, -8863, -9295, -9816, -10428, -11138, -11942, -12826, -13766, -14731, -15680, -16571, -17353, -17975, -18392, -18559, -18464, -18087, -17423, -16494, -15318, -13933, -12390, -10725, -8986, -7230, -5487, -3796, -2197, -710, 639, 1836, 2877, 3748, 4445, 4976, 5336, 5546, 5610, 5546, 5371, 5106, 4774, 4402, 4010, 3623, 3263, 2946, 2689, 2498, 2382, 2329, 2331, 2366, 2407, 2425, 2378, 2232, 1957, 1514, 886, 60, -964, -2168, -3538, -5039, -6624, -8253, -9872, -11425, -12878, -14178, -15287, -16185, -16845, -17255, -17423, -17356, -17072, -16597, -15964, -15204, -14352, -13444, -12508, -11571, -10660, -9792, -8982, -8247, -7601, -7056, -6632, -6344, -6211, -6258, -6501, -6948, -7596, -8428, -9402, -10474, -11583, -12666, -13657, -14503, -15157, -15586, -15762, -15683, -15355, -14800, -14053, -13142, -12112, -11010, -9879, -8758, -7687, -6683, -5778, -4986, -4312, -3767, -3344, -3034, -2834, -2733, -2722, -2785, -2915, -3096, -3318, -3562, -3813, -4052, -4254, -4402, -4471, -4440, -4292, -4016, -3607, -3065, -2396, -1626, -771, 135, 1064, 1983, 2866, 3676, 4398, 5010, 5497, 5854, 6073, 6155, 6101, 5923, 5621, 5213, 4711, 4130, 3488, 2816, 2131, 1467, 853, 320, -99, -356, -486, -624, -324};