/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1338 256 samples */
 
const int16_t AKWF_1338_256_DATA [256] = 
{69, 223, 374, 524, 675, 826, 974, 1070, 1148, 1230, 1308, 1390, 1470, 1550, 1631, 1710, 1801, 1833, 2304, 3399, 4454, 5514, 6573, 7635, 8696, 9755, 10818, 11857, 12972, 13776, 10629, 6330, 2250, -1864, -5982, -10107, -14222, -18340, -22463, -26476, -31229, -29278, -23561, -18494, -13304, -8128, -2939, 2249, 7424, 12612, 17717, 23262, 25338, 21691, 18193, 14682, 11160, 7643, 4116, 596, -2921, -6428, -9990, -13303, -12771, -10775, -9033, -7238, -5448, -3656, -1861, -72, 1725, 3464, 5526, 6227, 5505, 4983, 4425, 3866, 3308, 2750, 2192, 1635, 1078, 507, 77, -189, -467, -743, -1018, -1295, -1569, -1846, -2122, -2392, -2685, -2909, -2315, -1572, -862, -146, 570, 1286, 2003, 2721, 3435, 4141, 4910, 4744, 3787, 2919, 2038, 1154, 270, -609, -1494, -2377, -3247, -4175, -4802, -4163, -3344, -2567, -1779, -991, -204, 582, 1370, 2156, 2937, 3806, 3541, 2848, 2238, 1614, 990, 365, -258, -884, -1507, -2122, -2789, -2930, -2460, -2037, -1604, -1172, -741, -309, 123, 555, 978, 1447, 1787, 1566, 1340, 1118, 894, 670, 444, 221, -2, -225, -452, -659, -649, -564, -491, -418, -345, -272, -196, -123, -50, 23, 100, 147, 161, 177, 193, 210, 226, 241, 258, 274, 289, 309, 311, 236, 154, 74, -5, -84, -163, -243, -324, -403, -482, -563, -531, -430, -339, -248, -157, -64, 29, 120, 211, 302, 410, 424, 319, 226, 131, 36, -57, -152, -248, -342, -435, -536, -602, -553, -491, -431, -373, -312, -253, -192, -133, -74, -14, 48, 43, -20, -78, -136, -195, -253, -312, -371, -429, -486, -554, -580, -518, -460, -404, -347, -289, -230, -174, -116, -59, -1};