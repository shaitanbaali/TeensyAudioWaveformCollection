/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1318 256 samples */
 
const int16_t AKWF_1318_256_DATA [256] = 
{590, 2349, 4049, 5735, 7397, 9044, 10678, 12291, 13889, 15475, 17040, 18594, 20137, 21658, 23159, 24624, 26032, 27367, 28601, 29708, 30671, 31469, 32083, 32507, 32732, 32760, 32599, 32257, 31747, 31084, 30286, 29371, 28352, 27250, 26075, 24838, 23556, 22236, 20888, 19523, 18143, 16760, 15381, 14003, 12634, 11281, 9938, 8612, 7306, 6016, 4744, 3497, 2266, 1057, -127, -1295, -2442, -3569, -4682, -5773, -6849, -7911, -8954, -9984, -10999, -11998, -12981, -13952, -14904, -15836, -16737, -17595, -18399, -19135, -19777, -20308, -20727, -21022, -21191, -21233, -21150, -20948, -20633, -20213, -19699, -19101, -18434, -17706, -16930, -16119, -15276, -14413, -13539, -12659, -11802, -10983, -10217, -9516, -8877, -8298, -7773, -7292, -6847, -6431, -6038, -5665, -5306, -4953, -4502, -4630, -921, 5267, 7879, 9219, 9213, 8321, 6944, 5348, 3689, 2052, 500, -939, -2247, -3405, -4405, -5261, -5989, -6629, -7206, -7722, -8173, -8551, -8846, -9047, -9142, -9109, -8932, -8607, -8126, -7485, -6694, -5777, -4768, -3719, -2659, -1606, -571, 439, 1417, 2346, 3216, 4020, 4750, 5402, 5979, 6481, 6910, 7241, 7427, 7418, 7184, 6729, 6081, 5270, 4346, 3351, 2310, 1257, 203, -840, -1855, -2833, -3751, -4602, -5416, -6218, -7019, -7821, -8606, -9365, -10099, -10802, -11471, -12114, -12596, -12912, -13162, -13308, -13333, -13255, -13123, -12997, -12912, -12871, -12844, -12806, -12720, -12562, -12327, -12016, -11635, -11216, -10765, -10280, -9754, -9192, -8627, -8097, -7609, -7157, -6718, -6278, -5831, -5379, -4931, -4493, -4068, -3662, -3269, -2883, -2511, -2199, -2031, -2097, -2450, -3089, -3966, -5026, -6194, -7402, -8603, -9753, -10828, -11817, -12692, -13435, -14007, -14401, -14657, -14817, -14899, -14899, -14799, -14586, -14260, -13819, -13272, -12612, -11820, -10881, -9757, -8414, -6832, -5028, -3096, -1090};