/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1350 256 samples */
 
const int16_t AKWF_1350_256_DATA [256] = 
{-1, 5, 20, 43, 74, 113, 160, 216, 279, 350, 429, 515, 609, 710, 819, 935, 1058, 1188, 1325, 1468, 1617, 1774, 1935, 2104, 2277, 2455, 2640, 2829, 3022, 3221, 3423, 3629, 3840, 4053, 4270, 4490, 4712, 4936, 5163, 5391, 5621, 5852, 6083, 6315, 6548, 6780, 7012, 7243, 7472, 7702, 7929, 8153, 8375, 8595, 8811, 9025, 9234, 9439, 9641, 9837, 10028, 10215, 10395, 10570, 10738, 10900, 11055, 11203, 11344, 11476, 11601, 11717, 11826, 11925, 12015, 12096, 12168, 12230, 12281, 12323, 12354, 12374, 12384, 12382, 12370, 12346, 12310, 12263, 12204, 12133, 12050, 11955, 11847, 11727, 11595, 11450, 11293, 11123, 10940, 10744, 10536, 10315, 10081, 9835, 9576, 9303, 9020, 8723, 8414, 8093, 7759, 7413, 7055, 6685, 6304, 5912, 5507, 5091, 4666, 4228, 3780, 3323, 2854, 2376, 1889, 1391, 886, 372, -151, -682, -1221, -1767, -2320, -2881, -3448, -4020, -4598, -5182, -5770, -6363, -6961, -7560, -8164, -8772, -9380, -9991, -10604, -11216, -11831, -12445, -13057, -13671, -14282, -14891, -15499, -16103, -16704, -17302, -17895, -18482, -19066, -19643, -20214, -20780, -21336, -21885, -22428, -22960, -23484, -23998, -24501, -24995, -25477, -25947, -26406, -26852, -27285, -27706, -28112, -28503, -28880, -29243, -29589, -29921, -30235, -30532, -30814, -31077, -31322, -31550, -31759, -31949, -32120, -32272, -32404, -32516, -32608, -32679, -32730, -32759, -32768, -32755, -32720, -32664, -32585, -32486, -32363, -32218, -32051, -31861, -31649, -31414, -31156, -30876, -30574, -30248, -29899, -29529, -29135, -28719, -28281, -27820, -27337, -26833, -26306, -25757, -25188, -24596, -23985, -23352, -22697, -22024, -21331, -20616, -19884, -19132, -18361, -17573, -16765, -15940, -15100, -14241, -13366, -12478, -11570, -10650, -9716, -8767, -7805, -6831, -5843, -4845, -3837, -2817, -1790, -733};