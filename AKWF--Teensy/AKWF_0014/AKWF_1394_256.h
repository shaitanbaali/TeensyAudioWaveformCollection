/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1394 256 samples */
 
const int16_t AKWF_1394_256_DATA [256] = 
{426, 1741, 3026, 4307, 5582, 6852, 8123, 9389, 10654, 11918, 13171, 14419, 15655, 16876, 18087, 19285, 20466, 21634, 22787, 23920, 25046, 26137, 27090, 27898, 28586, 29168, 29667, 30090, 30454, 30767, 31034, 31263, 31460, 31629, 31773, 31897, 32003, 32094, 32172, 32239, 32297, 32347, 32389, 32427, 32459, 32487, 32510, 32532, 32550, 32565, 32579, 32591, 32601, 32609, 32617, 32623, 32628, 32633, 32636, 32639, 32641, 32641, 32643, 32642, 32641, 32639, 32637, 32634, 32629, 32624, 32618, 32611, 32602, 32592, 32581, 32568, 32554, 32537, 32519, 32498, 32475, 32448, 32420, 32386, 32348, 32306, 32259, 32204, 32143, 32072, 31991, 31897, 31793, 31671, 31531, 31371, 31185, 30968, 30718, 30428, 30090, 29697, 29239, 28705, 28079, 27345, 26487, 25482, 24412, 23339, 22253, 21158, 20060, 18954, 17846, 16738, 15625, 14515, 13408, 12299, 11193, 10092, 8990, 7893, 6801, 5711, 4627, 3548, 2471, 1402, 336, -728, -1787, -2848, -3918, -4993, -6077, -7171, -8272, -9383, -10501, -11624, -12757, -13900, -15048, -16207, -17372, -18541, -19715, -20889, -22061, -23232, -24395, -25556, -26642, -27561, -28332, -28988, -29542, -30012, -30412, -30752, -31042, -31290, -31501, -31682, -31836, -31969, -32083, -32180, -32264, -32336, -32399, -32452, -32498, -32537, -32571, -32601, -32628, -32650, -32669, -32685, -32699, -32712, -32722, -32731, -32739, -32746, -32752, -32757, -32760, -32763, -32766, -32767, -32767, -32767, -32766, -32766, -32763, -32761, -32756, -32751, -32746, -32739, -32732, -32722, -32712, -32700, -32686, -32670, -32651, -32629, -32605, -32575, -32541, -32500, -32453, -32399, -32335, -32260, -32172, -32067, -31943, -31798, -31625, -31422, -31184, -30904, -30576, -30189, -29732, -29197, -28564, -27815, -26935, -25884, -24713, -23531, -22338, -21136, -19927, -18706, -17477, -16242, -14994, -13737, -12476, -11202, -9922, -8638, -7345, -6050, -4754, -3453, -2157, -836};