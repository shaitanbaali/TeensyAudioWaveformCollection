/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1397 256 samples */
 
const int16_t AKWF_1397_256_DATA [256] = 
{2582, 2633, 2684, 2736, 2791, 2844, 2897, 2955, 3012, 3071, 3130, 3190, 3252, 3315, 3380, 3446, 3511, 3581, 3650, 3719, 3792, 3866, 3940, 4018, 4096, 4174, 4256, 4338, 4422, 4507, 4595, 4683, 4775, 4869, 4961, 5059, 5156, 5256, 5358, 5462, 5568, 5677, 5787, 5897, 6014, 6130, 6248, 6370, 6492, 6618, 6747, 6877, 7011, 7147, 7284, 7427, 7572, 7717, 7867, 8020, 8174, 8333, 8494, 8660, 8827, 8998, 9173, 9351, 9533, 9717, 9906, 10098, 10294, 10492, 10696, 10903, 11115, 11330, 11550, 11774, 12002, 12235, 12473, 12713, 12960, 13212, 13467, 13729, 13996, 14266, 14543, 14825, 15111, 15404, 15704, 16007, 16319, 16634, 16956, 17285, 17621, 17963, 18311, 18665, 19027, 19396, 19772, 20156, 20546, 20943, 21350, 21764, 22185, 22616, 23055, 23500, 23956, 24421, 24894, 25377, 25869, 26370, 26881, 27402, 27934, 28327, 29598, 27519, -4277, -7076, -6461, -6724, -6843, -6962, -7084, -7209, -7335, -7464, -7593, -7727, -7863, -8002, -8140, -8282, -8428, -8574, -8725, -8877, -9033, -9192, -9351, -9514, -9682, -9850, -10022, -10198, -10374, -10556, -10741, -10927, -11118, -11312, -11509, -11710, -11914, -12122, -12333, -12547, -12767, -12989, -13214, -13444, -13679, -13916, -14158, -14404, -14654, -14908, -15168, -15431, -15699, -15971, -16248, -16531, -16818, -17110, -17393, -17708, -18026, -18346, -18674, -19006, -19345, -19687, -20038, -20394, -20757, -21126, -21503, -21884, -22272, -22668, -23072, -23481, -23899, -24322, -24755, -25195, -25641, -26097, -26561, -27031, -27510, -27999, -28494, -29001, -29516, -29669, -32220, -13302, -4086, -4740, -3471, -3723, -3760, -3833, -3907, -3982, -4060, -4138, -4219, -4300, -4383, -4469, -4556, -4645, -4734, -4825, -4920, -5014, -5112, -4959, -6444, 480, 10176, 6474, 4585, 2484, 114, -1678, 10541, 13735, 15597, 16364, 16746, -2990};