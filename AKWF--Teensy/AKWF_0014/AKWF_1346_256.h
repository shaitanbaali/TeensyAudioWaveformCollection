/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1346 256 samples */
 
const int16_t AKWF_1346_256_DATA [256] = 
{-9191, -33866, -26268, -17732, -9971, -3267, 2408, 7181, 11222, 14654, 17565, 20053, 22181, 23996, 25551, 26881, 28012, 28976, 29791, 30473, 31044, 31513, 31891, 32191, 32420, 32585, 32695, 32754, 32767, 32740, 32676, 32579, 32452, 32299, 32122, 31922, 31703, 31466, 31213, 30946, 30665, 30372, 30070, 29758, 29436, 29108, 28772, 28429, 28083, 27731, 27374, 27015, 26651, 26285, 25918, 25547, 25175, 24802, 24427, 24052, 23677, 23300, 22925, 22549, 22173, 21799, 21424, 21050, 20678, 20306, 19935, 19566, 19198, 18831, 18466, 18102, 17740, 17380, 17021, 16665, 16310, 15957, 15605, 15257, 14909, 14564, 14221, 13880, 13541, 13204, 12869, 12536, 12206, 11877, 11551, 11227, 10904, 10585, 10267, 9951, 9639, 9327, 9018, 8711, 8407, 8104, 7803, 7505, 7208, 6915, 6623, 6332, 6045, 5759, 5475, 5193, 4913, 4636, 4361, 4087, 3815, 3546, 3278, 3013, 2749, 2487, 2227, 1970, 1713, 1459, 1207, 956, 708, 462, 216, -26, -267, -507, -745, -981, -1215, -1447, -1678, -1908, -2135, -2361, -2585, -2807, -3028, -3248, -3465, -3681, -3896, -4108, -4320, -4530, -4737, -4944, -5149, -5353, -5556, -5756, -5955, -6153, -6350, -6545, -6738, -6930, -7121, -7311, -7498, -7685, -7870, -8054, -8237, -8418, -8598, -8777, -8955, -9131, -9306, -9479, -9651, -9823, -9993, -10162, -10329, -10495, -10660, -10824, -10987, -11149, -11309, -11469, -11627, -11784, -11940, -12095, -12249, -12402, -12553, -12704, -12853, -13002, -13150, -13296, -13441, -13586, -13729, -13871, -14012, -14153, -14292, -14431, -14568, -14705, -14840, -14975, -15108, -15241, -15373, -15504, -15634, -15763, -15891, -16018, -16145, -16271, -16395, -16519, -16642, -16765, -16885, -17006, -17126, -17245, -17362, -17479, -17596, -17712, -17827, -17941, -18054, -18166, -18278, -18389, -18499, -18609, -18718, -18826, -18933, -19039, -19145, -19250, -19354, -19459};