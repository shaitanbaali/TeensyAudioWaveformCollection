/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1311 256 samples */
 
const int16_t AKWF_1311_256_DATA [256] = 
{529, 1317, 2073, 2815, 3541, 4253, 4950, 5632, 6300, 6954, 7594, 8221, 8835, 9435, 10024, 10601, 11164, 11716, 12258, 12787, 13305, 13813, 14310, 14796, 15273, 15739, 16196, 16643, 17080, 17509, 17929, 18340, 18742, 19136, 19522, 19899, 20268, 20630, 20986, 21332, 21672, 22005, 22330, 22649, 22962, 23267, 23566, 23859, 24146, 24427, 24703, 24971, 25235, 25494, 25746, 25993, 26236, 26473, 26705, 26933, 27155, 27373, 27587, 27796, 28000, 28200, 28396, 28589, 28777, 28961, 29141, 29318, 29491, 29660, 29826, 29988, 30146, 30302, 30454, 30603, 30749, 30892, 31032, 31168, 31303, 31434, 31563, 31689, 31812, 31933, 32050, 32166, 32280, 32391, 32500, 32600, 32717, 32725, 31979, 30696, 29323, 27939, 26571, 25233, 23920, 22633, 21376, 20144, 18935, 17755, 16598, 15464, 14357, 13270, 12206, 11167, 10147, 9148, 8174, 7215, 6279, 5363, 4465, 3585, 2725, 1882, 1057, 250, -541, -1314, -2072, -2816, -3542, -4254, -4951, -5633, -6301, -6954, -7595, -8222, -8836, -9436, -10025, -10601, -11165, -11717, -12259, -12787, -13306, -13814, -14310, -14797, -15273, -15739, -16196, -16644, -17081, -17510, -17930, -18340, -18743, -19136, -19522, -19900, -20268, -20631, -20986, -21332, -21672, -22005, -22330, -22649, -22962, -23267, -23566, -23860, -24146, -24428, -24703, -24971, -25235, -25494, -25746, -25993, -26236, -26473, -26706, -26933, -27155, -27374, -27587, -27796, -28000, -28200, -28396, -28589, -28777, -28961, -29141, -29318, -29491, -29660, -29826, -29988, -30146, -30302, -30454, -30603, -30749, -30892, -31032, -31168, -31303, -31434, -31563, -31689, -31812, -31933, -32050, -32166, -32280, -32391, -32500, -32600, -32717, -32725, -31979, -30696, -29323, -27940, -26571, -25234, -23921, -22633, -21377, -20144, -18935, -17756, -16598, -15465, -14358, -13271, -12207, -11168, -10148, -9149, -8175, -7216, -6279, -5364, -4465, -3586, -2726, -1884, -1061, -241};