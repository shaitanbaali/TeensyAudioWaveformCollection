/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1347 256 samples */
 
const int16_t AKWF_1347_256_DATA [256] = 
{5328, 19666, 33114, 32275, 29869, 26434, 22701, 18986, 15403, 12012, 8842, 5879, 3121, 567, -1811, -4021, -6068, -7977, -9753, -11401, -12940, -14374, -15708, -16956, -18120, -19205, -20221, -21170, -22055, -22885, -23659, -24382, -25060, -25691, -26282, -26834, -27349, -27829, -28278, -28695, -29083, -29445, -29780, -30092, -30381, -30647, -30893, -31120, -31327, -31518, -31692, -31849, -31992, -32121, -32235, -32338, -32427, -32505, -32572, -32628, -32674, -32711, -32738, -32756, -32766, -32768, -32762, -32749, -32729, -32703, -32669, -32630, -32585, -32534, -32478, -32417, -32351, -32281, -32206, -32126, -32043, -31956, -31864, -31770, -31672, -31570, -31466, -31358, -31248, -31136, -31019, -30901, -30780, -30658, -30532, -30405, -30276, -30145, -30012, -29877, -29741, -29603, -29463, -29323, -29181, -29037, -28892, -28746, -28598, -28450, -28301, -28151, -28000, -27848, -27695, -27541, -27387, -27232, -27076, -26920, -26763, -26606, -26448, -26289, -26130, -25971, -25811, -25651, -25491, -25330, -25170, -25008, -24847, -24686, -24524, -24361, -24199, -24037, -23875, -23713, -23550, -23388, -23226, -23063, -22901, -22738, -22575, -22414, -22251, -22089, -21927, -21764, -21603, -21441, -21279, -21118, -20957, -20796, -20635, -20474, -20314, -20153, -19993, -19834, -19674, -19515, -19355, -19197, -19038, -18879, -18722, -18564, -18406, -18249, -18092, -17935, -17779, -17623, -17467, -17312, -17157, -17003, -16848, -16694, -16540, -16387, -16234, -16081, -15929, -15777, -15626, -15475, -15324, -15173, -15024, -14873, -14724, -14576, -14427, -14279, -14131, -13983, -13836, -13690, -13543, -13398, -13253, -13107, -12962, -12818, -12674, -12531, -12387, -12245, -12103, -11961, -11819, -11678, -11537, -11397, -11257, -11118, -10978, -10840, -10702, -10564, -10426, -10289, -10152, -10016, -9880, -9745, -9610, -9475, -9341, -9207, -9073, -8941, -8808, -8675, -8544, -8413, -8281, -8151, -8020, -7890, -7761, -7632, -7503, -7375, -7247, -7120, -6993, -6866, -6740, -6612};