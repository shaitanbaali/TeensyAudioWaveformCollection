/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1359 256 samples */
 
const int16_t AKWF_1359_256_DATA [256] = 
{227, 896, 1553, 2206, 2863, 3516, 4173, 4824, 5480, 6133, 6788, 7443, 8100, 8756, 9418, 10081, 10744, 11413, 12082, 12754, 13428, 14107, 14787, 15469, 16152, 16837, 17521, 18207, 18888, 19575, 20252, 20930, 21600, 22268, 22925, 23577, 24216, 24844, 25461, 26062, 26648, 27215, 27764, 28291, 28798, 29277, 29734, 30163, 30563, 30933, 31273, 31579, 31854, 32092, 32297, 32465, 32597, 32692, 32748, 32768, 32749, 32693, 32600, 32469, 32302, 32099, 31860, 31585, 31279, 30939, 30567, 30166, 29735, 29276, 28794, 28283, 27753, 27199, 26628, 26035, 25429, 24807, 24171, 23525, 22866, 22201, 21525, 20846, 20159, 19474, 18779, 18088, 17393, 16699, 16004, 15313, 14620, 13935, 13247, 12566, 11884, 11209, 10533, 9864, 9194, 8528, 7865, 7202, 6543, 5884, 5228, 4569, 3916, 3258, 2603, 1945, 1290, 630, -26, -686, -1346, -2008, -2669, -3332, -3992, -4655, -5315, -5973, -6632, -7285, -7936, -8583, -9225, -9858, -10490, -11107, -11720, -12320, -12911, -13487, -14053, -14602, -15136, -15655, -16156, -16638, -17102, -17545, -17969, -18370, -18750, -19110, -19445, -19760, -20050, -20320, -20565, -20790, -20992, -21173, -21332, -21472, -21593, -21694, -21778, -21846, -21897, -21935, -21959, -21970, -21971, -21963, -21946, -21923, -21893, -21859, -21822, -21783, -21741, -21701, -21663, -21625, -21591, -21559, -21532, -21509, -21492, -21479, -21471, -21470, -21473, -21480, -21494, -21511, -21532, -21558, -21584, -21613, -21642, -21670, -21698, -21723, -21743, -21759, -21770, -21771, -21765, -21749, -21720, -21681, -21627, -21558, -21473, -21372, -21252, -21112, -20954, -20776, -20575, -20354, -20112, -19847, -19558, -19250, -18916, -18562, -18185, -17787, -17367, -16929, -16467, -15989, -15492, -14976, -14445, -13896, -13334, -12758, -12169, -11567, -10958, -10336, -9708, -9071, -8430, -7780, -7131, -6470, -5812, -5166, -4041, -2809, -1838, -1061, -492, -131};