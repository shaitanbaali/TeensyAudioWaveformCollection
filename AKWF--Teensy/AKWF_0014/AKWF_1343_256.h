/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1343 256 samples */
 
const int16_t AKWF_1343_256_DATA [256] = 
{0, 7, 23, 50, 85, 130, 185, 249, 322, 405, 496, 598, 708, 829, 958, 1097, 1245, 1403, 1570, 1746, 1932, 2127, 2331, 2545, 2768, 3000, 3241, 3492, 3751, 4020, 4298, 4584, 4881, 5185, 5498, 5820, 6150, 6490, 6838, 7194, 7559, 7932, 8311, 8700, 9097, 9499, 9911, 10329, 10754, 11187, 11626, 12070, 12522, 12979, 13441, 13909, 14383, 14860, 15342, 15828, 16317, 16811, 17307, 17805, 18306, 18807, 19310, 19815, 20317, 20821, 21324, 21824, 22322, 22819, 23311, 23800, 24284, 24762, 25235, 25702, 26159, 26610, 27051, 27482, 27904, 28314, 28710, 29095, 29465, 29821, 30161, 30484, 30790, 31077, 31346, 31593, 31821, 32026, 32208, 32366, 32499, 32607, 32688, 32741, 32766, 32762, 32729, 32663, 32566, 32437, 32275, 32078, 31848, 31582, 31279, 30942, 30566, 30153, 29703, 29214, 28686, 28122, 27516, 26872, 26190, 25468, 24708, 23910, 23071, 22197, 21285, 20333, 19349, 18328, 17271, 16183, 15061, 13906, 12725, 11512, 10272, 9009, 7720, 6408, 5080, 3730, 2365, 989, -401, -1799, -3200, -4609, -6017, -7421, -8823, -10215, -11594, -12962, -14310, -15636, -16941, -18215, -19458, -20670, -21840, -22969, -24056, -25091, -26077, -27007, -27877, -28688, -29434, -30110, -30717, -31251, -31707, -32086, -32384, -32597, -32726, -32768, -32722, -32584, -32357, -32038, -31625, -31120, -30523, -29832, -29051, -28179, -27215, -26166, -25030, -23808, -22508, -21129, -19673, -18149, -16556, -14899, -13188, -11421, -9605, -7753, -5859, -3936, -1994, -31, 1940, 3910, 5880, 7836, 9769, 11679, 13550, 15376, 17155, 18872, 20521, 22099, 23592, 24994, 26304, 27508, 28602, 29583, 30439, 31169, 31768, 32230, 32551, 32730, 32763, 32647, 32381, 31967, 31401, 30686, 29825, 28816, 27664, 26378, 24953, 23401, 21729, 19937, 18040, 16046, 13957, 11790, 9555, 7260, 4924, 2504};