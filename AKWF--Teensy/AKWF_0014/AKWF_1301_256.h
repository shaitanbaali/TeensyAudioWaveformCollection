/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1301 256 samples */
 
const int16_t AKWF_1301_256_DATA [256] = 
{13828, 24783, 21318, 20542, 19348, 18152, 16949, 15787, 14654, 13450, 12259, 11064, 9868, 8677, 7481, 6285, 5093, 3897, 2715, 1467, 592, 595, 596, 595, 596, 596, 596, 596, 596, 596, 597, 596, 598, 599, 598, 589, 632, 30, -1061, -2080, -3116, -4151, -5184, -6219, -7254, -8286, -9322, -10357, -11390, -12424, -13460, -14492, -15528, -16564, -17595, -18608, -19743, -19667, -18522, -17513, -16478, -15443, -14407, -13373, -12335, -11301, -10268, -9232, -8198, -7163, -6126, -5093, -4058, -3022, -1988, -964, 125, 656, 594, 654, 1284, 2049, 2787, 3527, 4270, 5014, 5755, 6499, 7240, 7982, 8726, 9467, 10209, 10951, 11695, 12438, 13181, 13910, 14682, 15303, 13482, 10964, 8581, 6178, 3771, 1361, -1039, -3283, -6631, 4503, 8259, 6519, 5953, 5210, 4467, 3727, 2986, 1638, 4158, -17052, -34098, -29114, -28070, -26404, -24742, -23075, -21410, -19746, -18078, -16411, -14747, -13079, -11415, -9750, -8083, -6420, -4752, -3081, -1451, 756, 2134, 2929, 3831, 4716, 5598, 6482, 7367, 8249, 9135, 10019, 10900, 11785, 12669, 13550, 14435, 15319, 16201, 17068, 18032, 17926, 16978, 15869, 16336, 13698, 11245, 11918, 11625, 10717, 9839, 8957, 8075, 7191, 6307, 5426, 4542, 3658, 2588, 2784, -2973, -16660, -14629, -13781, -12822, -12098, -11392, -10683, -9973, -9263, -8555, -7844, -7258, -5638, -9093, -7865, -2023, -3602, -3697, -4003, -4311, -4618, -4916, -5270, -5349, -4749, -4360, -3952, -3546, -3141, -2735, -2328, -1923, -1517, -1111, -705, -299, 105, 495, 982, 1045, -298, 35, 231, 1755, 2279, 2048, 1972, 1873, 1772, 1671, 1570, 1470, 1369, 1267, 1017, 2167, -3561, -7283, 4304, -206, -11752, -10176, -8186, -6099, -3885, -1682, 519, 2708, 4833, 7591, -3733, -6274, -4451, -3588, -2581, -1577, -554};