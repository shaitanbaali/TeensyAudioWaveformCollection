/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1314 256 samples */
 
const int16_t AKWF_1314_256_DATA [256] = 
{248, 683, 1117, 1559, 2007, 2463, 2926, 3393, 3867, 4348, 4832, 5323, 5819, 6316, 6820, 7329, 7838, 8353, 8872, 9390, 9914, 10440, 10967, 11496, 12028, 12561, 13096, 13631, 14166, 14704, 15240, 15778, 16316, 16854, 17392, 17931, 18468, 19004, 19541, 20076, 20610, 21146, 21678, 22209, 22742, 23271, 23799, 24328, 24853, 25378, 25902, 26423, 26947, 27467, 27985, 28505, 29022, 29536, 30053, 30568, 31081, 31326, 33156, 28830, -28830, -33156, -31326, -31081, -30569, -30054, -29538, -29023, -28506, -27988, -27470, -26950, -26428, -25908, -25384, -24859, -24335, -23807, -23278, -22750, -22219, -21688, -21157, -20623, -20089, -19555, -19018, -18482, -17946, -17408, -16871, -16333, -15794, -15258, -14721, -14184, -13649, -13114, -12579, -12047, -11516, -10986, -10460, -9933, -9409, -8890, -8371, -7857, -7346, -6837, -6332, -5833, -5339, -4847, -4361, -3880, -3404, -2936, -2472, -2015, -1565, -1121, -689, -243, 8, -3, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};