/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1306 256 samples */
 
const int16_t AKWF_1306_256_DATA [256] = 
{1040, 4258, 7107, 9718, 12105, 14293, 16312, 18166, 19883, 21476, 22953, 24332, 25622, 26829, 27963, 28806, 29526, 30263, 30897, 31419, 31841, 32172, 32421, 32598, 32711, 32762, 32762, 32713, 32619, 32486, 32313, 32106, 31868, 31599, 31301, 30976, 30623, 30246, 29843, 29417, 28968, 28490, 27992, 27469, 26919, 26347, 25749, 25120, 24468, 23783, 23065, 22319, 21532, 20703, 19831, 18897, 17897, 16803, 15590, 13641, 12611, 12104, 10948, 9837, 8827, 7921, 7110, 6382, 5731, 5147, 4620, 4149, 3726, 3344, 3001, 2691, 2411, 2157, 1929, 1723, 1537, 1366, 1214, 1074, 947, 832, 727, 631, 542, 463, 389, 320, 257, 198, 143, 91, 42, -4, -49, -95, -138, -182, -226, -271, -316, -363, -413, -466, -520, -579, -642, -709, -779, -856, -939, -1026, -1121, -1223, -1332, -1449, -1574, -1707, -1851, -2003, -2165, -2339, -2522, -2718, -2924, -3143, -3374, -3618, -3875, -4146, -4430, -4729, -5043, -5372, -5716, -6074, -6449, -6839, -7247, -7626, -8002, -8403, -8807, -9206, -9605, -9999, -10390, -10780, -11168, -11552, -11934, -12312, -12685, -13058, -13424, -13786, -14144, -14493, -14836, -15173, -15501, -15820, -16129, -16426, -16711, -16982, -17236, -17473, -17692, -17888, -18062, -18209, -18327, -18411, -18461, -18469, -18431, -18338, -18185, -17955, -17632, -17180, -16583, -15158, -14632, -14639, -13944, -13257, -12638, -12094, -11619, -11205, -10848, -10540, -10275, -10051, -9863, -9707, -9581, -9482, -9407, -9355, -9323, -9312, -9318, -9343, -9383, -9440, -9511, -9598, -9699, -9815, -9945, -10091, -10249, -10423, -10612, -10814, -11034, -11267, -11517, -11784, -12066, -12367, -12684, -13017, -13372, -13744, -14136, -14549, -14979, -15431, -15906, -16399, -16918, -17459, -18021, -18609, -19219, -19852, -20513, -21197, -21907, -22643, -23098, -25650, -16395, -4693, -12401, -10010, -6117, -2313};