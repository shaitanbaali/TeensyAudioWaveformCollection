/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1327 256 samples */
 
const int16_t AKWF_1327_256_DATA [256] = 
{8667, 8609, 8620, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8618, 8930, 7181, 15443, 32882, 30837, 31222, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31208, 31025, 31921, 28674, -11867, -15222, -14306, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14492, -14690, -13584, -18812, -29589, -28239, -28495, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28484, -28489, -28464, -28597};