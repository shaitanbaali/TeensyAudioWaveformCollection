/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1304 256 samples */
 
const int16_t AKWF_1304_256_DATA [256] = 
{-1946, 18060, 18019, 18024, 18053, 18078, 18101, 18123, 18249, 17751, 10353, 19654, 18913, 18701, 18353, 17880, 17514, 17290, 17053, 16849, 16809, 16726, 17174, 17422, 17618, 17819, 18000, 18134, 18230, 18232, 18202, 18178, 18153, 18128, 18103, 18078, 18053, 18027, 18003, 17977, 17952, 17927, 17901, 17876, 17852, 17826, 17801, 17774, 17749, 17724, 17698, 17674, 17648, 17623, 17598, 17573, 17547, 17521, 17495, 17470, 17445, 17419, 17393, 17367, 17341, 17315, 17290, 17264, 17237, 17212, 17186, 17160, 17134, 17107, 17081, 17055, 17028, 16999, 16968, 16932, 16884, 16809, 16648, 16475, 16065, 15755, 15335, 15048, 14801, 14503, 14120, 13521, 12436, 9647, 6306, 953, -5222, -4460, -4780, -4925, -5071, -5218, -5366, -5512, -5659, -5806, -5953, -6100, -6247, -6392, -6534, -6673, -6798, -6895, -6921, -6793, -6304, -5102, -1378, 2256, 9750, 15924, 14807, 15049, 15072, 15098, 15124, 15149, 15174, 15200, 15226, 15252, 15278, 15303, 15330, 15355, 15381, 15407, 15433, 15458, 15485, 15512, 15540, 15570, 15608, 15657, 15759, 15809, 15896, 15931, 15632, 15575, 15556, 15528, 15501, 15474, 15446, 15419, 15392, 15366, 15339, 15312, 15285, 15258, 15231, 15204, 15177, 15151, 15122, 15095, 15067, 15039, 15011, 14982, 14952, 14922, 14890, 14857, 14822, 14786, 14746, 14704, 14660, 14612, 14559, 14501, 14438, 14364, 14282, 14187, 14089, 13857, 14219, 14015, 11664, 12471, 12790, 12519, 12101, 11629, 11067, 10405, 9635, 8742, 7731, 6592, 5269, 3911, 1702, -11300, -15129, -17502, -21004, -23982, -26337, -26779, -25996, -25448, -24856, -24265, -23685, -22896, -23253, -25650, -19625, -20501, -20515, -20668, -20822, -20975, -21129, -21283, -21437, -21591, -21745, -21900, -22052, -22208, -22362, -22517, -22671, -22824, -22979, -23133, -23287, -23439, -23588, -23729, -23855, -23945, -23948, -23755, -23116, -21483, -17583, -8137};