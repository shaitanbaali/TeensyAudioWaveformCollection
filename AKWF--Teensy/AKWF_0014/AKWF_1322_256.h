/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1322 256 samples */
 
const int16_t AKWF_1322_256_DATA [256] = 
{25709, 25997, 25943, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25953, 25904, 26181, 23938, 21854, 22143, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 22091, 21965, 22441, 21032, -25709, -32005, -30342, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30651, -30577, -30929, -29485, -18033, -16457, -16821, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16744, -16793, -16533, -17925};