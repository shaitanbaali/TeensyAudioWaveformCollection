/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1372 256 samples */
 
const int16_t AKWF_1372_256_DATA [256] = 
{27491, 29989, 28855, 28452, 27947, 27442, 26936, 26510, 26001, 25497, 24994, 24492, 23989, 23489, 22989, 22491, 21994, 21498, 21001, 20507, 20013, 19520, 19030, 18537, 18047, 17558, 17071, 16584, 16098, 15613, 15129, 14645, 14164, 13681, 13203, 12721, 12243, 11765, 11288, 10814, 10337, 9864, 9393, 8921, 8448, 7979, 7509, 7041, 6575, 6107, 5640, 5177, 4713, 4250, 3790, 3326, 2867, 2408, 1949, 1492, 1037, 579, 126, -328, -781, -1233, -1685, -2135, -2583, -3032, -3480, -3927, -4373, -4818, -5262, -5706, -6148, -6590, -7031, -7470, -7909, -8347, -8785, -9221, -9656, -10091, -10525, -10959, -11391, -11821, -12251, -12681, -13110, -13538, -13966, -14392, -14818, -15242, -15666, -16088, -16511, -16933, -17354, -17771, -18191, -18611, -19026, -19444, -19860, -20273, -20688, -21103, -21513, -21925, -22336, -22746, -23154, -23563, -23971, -24378, -24781, -25176, -25601, -25994, -26393, -26499, -28261, -23155, 24688, 30708, 28658, 28471, 27964, 27462, 26953, 26528, 26021, 25516, 25013, 24511, 24008, 23508, 23008, 22510, 22014, 21516, 21019, 20527, 20031, 19539, 19047, 18555, 18066, 17577, 17089, 16601, 16115, 15629, 15146, 14663, 14180, 13700, 13219, 12738, 12261, 11783, 11306, 10831, 10356, 9881, 9410, 8937, 8465, 7995, 7527, 7058, 6591, 6124, 5657, 5193, 4729, 4266, 3805, 3343, 2883, 2424, 1965, 1508, 1051, 595, 142, -312, -766, -1218, -1668, -2119, -2567, -3017, -3466, -3912, -4358, -4804, -5247, -5689, -6133, -6575, -7016, -7455, -7894, -8332, -8771, -9206, -9644, -10077, -10510, -10944, -11376, -11808, -12238, -12667, -13096, -13525, -13952, -14378, -14804, -15229, -15652, -16075, -16498, -16919, -17340, -17759, -18178, -18598, -19014, -19430, -19846, -20260, -20675, -21089, -21500, -21912, -22324, -22733, -23142, -23551, -23958, -24364, -24770, -25162, -25587, -25983, -26382, -26740, -27418, -26531};