/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1374 256 samples */
 
const int16_t AKWF_1374_256_DATA [256] = 
{24686, 30949, 29154, 28950, 28504, 28064, 27613, 27239, 26799, 26355, 25913, 25472, 25032, 24593, 24155, 23717, 23281, 22846, 22412, 21979, 21543, 21111, 20680, 20249, 19819, 19391, 18963, 18533, 18108, 17682, 17258, 16834, 16411, 15989, 15567, 15145, 14726, 14307, 13888, 13472, 13055, 12639, 12224, 11810, 11396, 10984, 10573, 10161, 9753, 9342, 8933, 8526, 8119, 7712, 7307, 6903, 6498, 6096, 5694, 5292, 4892, 4492, 4092, 3694, 3297, 2901, 2505, 2109, 1716, 1321, 927, 536, 144, -246, -634, -1025, -1412, -1798, -2186, -2572, -2957, -3342, -3726, -4108, -4491, -4873, -5253, -5633, -6011, -6390, -6769, -7145, -7521, -7897, -8272, -8645, -9020, -9392, -9764, -10134, -10505, -10875, -11243, -11611, -11979, -12348, -12712, -13078, -13442, -13806, -14170, -14534, -14894, -15255, -15616, -15976, -16335, -16694, -17050, -17406, -17763, -18119, -18474, -18828, -19181, -19534, -19886, -20237, -20588, -20936, -21287, -21635, -21984, -22332, -22678, -23022, -23368, -23713, -24057, -24400, -24743, -25085, -25427, -25758, -26100, -26449, -26779, -27130, -26766, -30860, -9126, 24010, 20408, 20517, 20108, 19683, 19245, 18851, 18473, 18038, 17615, 17190, 16766, 16341, 15921, 15499, 15079, 14659, 14239, 13821, 13405, 12988, 12572, 12156, 11741, 11330, 10917, 10505, 10093, 9685, 9275, 8866, 8460, 8051, 7646, 7243, 6836, 6433, 6032, 5627, 5227, 4827, 4427, 4028, 3630, 3231, 2835, 2440, 2044, 1651, 1256, 862, 472, 82, -308, -698, -1088, -1477, -1862, -2249, -2636, -3020, -3405, -3789, -4171, -4553, -4935, -5316, -5695, -6074, -6452, -6831, -7208, -7583, -7959, -8333, -8707, -9082, -9453, -9824, -10197, -10567, -10935, -11306, -11674, -12041, -12407, -12774, -13139, -13504, -13867, -14231, -14593, -14955, -15316, -15676, -16035, -16395, -16754, -17100, -17471, -17825, -18176, -18563, -18771, -19708};