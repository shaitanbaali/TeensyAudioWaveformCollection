/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1369 256 samples */
 
const int16_t AKWF_1369_256_DATA [256] = 
{28926, 31014, 30100, 29789, 29392, 28997, 28600, 28262, 27865, 27470, 27076, 26682, 26288, 25895, 25504, 25113, 24725, 24335, 23945, 23559, 23171, 22785, 22400, 22014, 21631, 21247, 20865, 20483, 20103, 19723, 19343, 18964, 18586, 18208, 17832, 17456, 17082, 16707, 16333, 15961, 15589, 15216, 14847, 14477, 14107, 13740, 13371, 13003, 12638, 12272, 11906, 11543, 11179, 10817, 10455, 10094, 9733, 9373, 9014, 8656, 8297, 7939, 7584, 7229, 6873, 6519, 6165, 5812, 5460, 5109, 4757, 4407, 4057, 3707, 3361, 3013, 2666, 2321, 1975, 1629, 1286, 943, 600, 258, -84, -423, -763, -1104, -1442, -1780, -2117, -2453, -2789, -3127, -3461, -3795, -4129, -4461, -4793, -5124, -5456, -5785, -6115, -6443, -6771, -7101, -7427, -7753, -8080, -8404, -8729, -9053, -9376, -9699, -10021, -10342, -10662, -10984, -11302, -11620, -11939, -12256, -12574, -12890, -13204, -13520, -13835, -14148, -14461, -14773, -15086, -15398, -15709, -16019, -16328, -16636, -16946, -17254, -17560, -17866, -18174, -18479, -18782, -19088, -19391, -19693, -19997, -20298, -20599, -20900, -21200, -21499, -21798, -22096, -22394, -22692, -22988, -23284, -23579, -23874, -24168, -24463, -24755, -25048, -25339, -25630, -25921, -26213, -26497, -26783, -27083, -27361, -27655, -27493, -30202, -18575, 15227, 14350, 13970, 13672, 13307, 12936, 12586, 12272, 11902, 11538, 11175, 10811, 10450, 10087, 9728, 9368, 9009, 8651, 8294, 7936, 7579, 7223, 6867, 6513, 6160, 5807, 5455, 5103, 4753, 4402, 4052, 3704, 3356, 3008, 2661, 2315, 1969, 1624, 1280, 938, 594, 252, -88, -428, -769, -1108, -1446, -1785, -2123, -2459, -2796, -3132, -3466, -3800, -4135, -4467, -4799, -5131, -5460, -5792, -6121, -6450, -6779, -7107, -7432, -7760, -8086, -8409, -8735, -9059, -9382, -9704, -10026, -10338, -10674, -10989, -11304, -11598, -12086, -11602};