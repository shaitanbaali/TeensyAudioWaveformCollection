/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1360 256 samples */
 
const int16_t AKWF_1360_256_DATA [256] = 
{273, 857, 1431, 2014, 2595, 3189, 3785, 4392, 5004, 5628, 6258, 6901, 7556, 8219, 8896, 9584, 10285, 10996, 11722, 12454, 13203, 13958, 14724, 15498, 16280, 17063, 17857, 18647, 19442, 20232, 21022, 21803, 22579, 23342, 24094, 24831, 25548, 26246, 26920, 27570, 28190, 28783, 29338, 29861, 30346, 30793, 31196, 31558, 31873, 32145, 32367, 32542, 32667, 32743, 32768, 32744, 32670, 32545, 32371, 32150, 31879, 31564, 31201, 30798, 30350, 29865, 29340, 28780, 28185, 27563, 26908, 26230, 25526, 24801, 24058, 23302, 22527, 21746, 20955, 20157, 19357, 18552, 17751, 16951, 16155, 15362, 14580, 13801, 13038, 12278, 11534, 10798, 10079, 9367, 8671, 7986, 7311, 6651, 6000, 5360, 4733, 4113, 3501, 2901, 2305, 1716, 1133, 555, -21, -590, -1161, -1728, -2295, -2861, -3428, -3992, -4559, -5126, -5691, -6260, -6826, -7391, -7956, -8517, -9076, -9632, -10181, -10725, -11261, -11789, -12304, -12811, -13303, -13782, -14243, -14688, -15113, -15519, -15902, -16263, -16599, -16909, -17195, -17453, -17683, -17883, -18056, -18200, -18314, -18398, -18455, -18482, -18483, -18456, -18403, -18326, -18225, -18102, -17959, -17798, -17619, -17426, -17220, -17004, -16781, -16550, -16315, -16079, -15846, -15613, -15387, -15167, -14957, -14758, -14574, -14403, -14250, -14114, -13997, -13901, -13826, -13771, -13740, -13730, -13743, -13779, -13837, -13915, -14014, -14133, -14270, -14424, -14595, -14779, -14976, -15182, -15397, -15618, -15844, -16070, -16298, -16521, -16741, -16952, -17154, -17344, -17520, -17682, -17825, -17950, -18051, -18131, -18187, -18217, -18221, -18197, -18146, -18066, -17957, -17818, -17652, -17455, -17231, -16978, -16699, -16392, -16061, -15702, -15324, -14920, -14496, -14055, -13593, -13117, -12624, -12120, -11600, -11075, -10535, -9991, -9439, -8881, -8317, -7755, -7187, -6621, -6050, -5482, -4912, -4343, -3769, -3226, -2357, -1377, -686, -227};