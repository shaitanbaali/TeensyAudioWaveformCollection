/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1328 256 samples */
 
const int16_t AKWF_1328_256_DATA [256] = 
{3030, 3245, 3205, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3213, 3248, 3343, 2557, 23852, 31481, 29843, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30142, 30020, 30588, 28927, -6088, -9630, -8711, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -8888, -9043, -8177, -11633, -28687, -28450, -28448, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28470, -28517, -28265, -29620};