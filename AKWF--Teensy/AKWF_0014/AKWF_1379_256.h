/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1379 256 samples */
 
const int16_t AKWF_1379_256_DATA [256] = 
{8022, 7979, 6515, 5525, 5514, 6001, 6756, 7635, 8559, 9485, 10382, 11245, 12068, 12848, 13588, 14291, 14955, 15588, 16190, 16762, 17311, 17836, 18337, 18821, 19285, 19734, 20168, 20587, 20994, 21391, 21776, 22152, 22520, 22878, 23230, 23576, 23914, 24247, 24575, 24896, 25214, 25528, 25837, 26142, 26445, 26742, 27038, 27329, 27617, 27903, 28186, 28465, 28742, 29017, 29288, 29556, 29823, 30087, 30348, 30606, 30596, 32314, 26293, 12075, 13815, 16553, 18023, 18308, 17939, 17226, 16354, 15432, 14515, 13632, 12803, 12027, 11307, 10644, 10030, 9463, 8941, 8458, 8011, 7597, 7212, 6852, 6518, 6204, 5908, 5630, 5367, 5117, 4879, 4650, 4432, 4222, 4017, 3819, 3626, 3438, 3253, 3071, 2893, 2717, 2542, 2369, 2196, 2026, 1855, 1686, 1515, 1346, 1177, 1008, 838, 669, 499, 330, 160, -10, -178, -349, -520, -690, -859, -1209, -436, -5337, -11550, -10553, -9511, -9196, -9403, -9908, -10566, -11290, -12033, -12769, -13481, -14166, -14820, -15443, -16038, -16604, -17144, -17661, -18155, -18628, -19083, -19521, -19943, -20350, -20744, -21125, -21497, -21857, -22207, -22550, -22884, -23211, -23531, -23844, -24152, -24454, -24751, -25043, -25331, -25614, -25893, -26169, -26440, -26709, -26975, -27236, -27495, -27751, -28003, -28253, -28500, -28745, -28987, -29226, -29462, -29696, -29928, -30156, -30382, -30606, -30611, -32021, -27260, -15616, -17024, -19263, -20476, -20724, -20437, -19870, -19172, -18433, -17697, -16989, -16323, -15701, -15125, -14594, -14102, -13649, -13232, -12846, -12489, -12159, -11851, -11566, -11299, -11048, -10813, -10592, -10382, -10183, -9995, -9813, -9639, -9472, -9309, -9152, -8998, -8848, -8701, -8556, -8414, -8274, -8133, -7995, -7858, -7721, -7584, -7448, -7312, -7176, -7040, -6904, -6768, -6632, -6495, -6358, -6222, -6085, -5947, -5810, -5673, -5535, -5398, -5222, -5293, -4035};