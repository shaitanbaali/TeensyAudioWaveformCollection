/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1324 256 samples */
 
const int16_t AKWF_1324_256_DATA [256] = 
{24132, 23792, 23855, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23843, 23793, 24072, 22669, 20060, 20348, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20295, 20175, 20673, 19107, -24655, -29270, -27906, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28159, -28148, -28080, -28548, -18307, -14747, -15524, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15383, -15381, -15396, -15314};