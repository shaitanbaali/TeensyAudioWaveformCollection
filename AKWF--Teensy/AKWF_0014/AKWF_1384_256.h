/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1384 256 samples */
 
const int16_t AKWF_1384_256_DATA [256] = 
{156, 386, 596, 793, 974, 1140, 1291, 1427, 1550, 1657, 1748, 1829, 1898, 1954, 2000, 2034, 2059, 2073, 2079, 2077, 2067, 2049, 2026, 1996, 1960, 1921, 1875, 1826, 1775, 1720, 1703, 1433, 2859, 5320, 6455, 7309, 7878, 8256, 8499, 8638, 8686, 8644, 8515, 8294, 7984, 7596, 7133, 6620, 6071, 5505, 4952, 4438, 3979, 3592, 3284, 3061, 2927, 2879, 2920, 3047, 3254, 3537, 3890, 4307, 4786, 5315, 5889, 6502, 7142, 7808, 8494, 9192, 9900, 10618, 11336, 12052, 12802, 13270, 13354, 13436, 13527, 13645, 13791, 13960, 14153, 14363, 14593, 14853, 15141, 15464, 15826, 16226, 16665, 17139, 17640, 17809, 20288, 233, -10714, -9376, -8288, -5729, -2417, 1351, 5441, 9423, 12846, 15825, 18493, 20971, 23356, 25666, 27874, 29850, 31358, 32324, 32749, 32632, 31933, 30643, 28813, 26492, 23726, 20710, 17624, 14517, 11439, 8412, 5448, 2574, -200, -2853, -5365, -7745, -10005, -12142, -14172, -16098, -17905, -19544, -20985, -22230, -23299, -24201, -24947, -25553, -26015, -26325, -26489, -26519, -26420, -26203, -25875, -25445, -24918, -24303, -23606, -22833, -22026, -20965, -21169, -22104, -21951, -21563, -20943, -20161, -19261, -18270, -17193, -16041, -14821, -13533, -12191, -10814, -9412, -8010, -6632, -5297, -4027, -2845, -1772, -852, -108, 467, 876, 1130, 1243, 1233, 1115, 902, 608, 249, -168, -627, -1122, -1641, -2176, -2720, -3269, -3812, -4348, -4873, -5380, -5873, -6351, -6755, -7077, -7388, -7686, -7977, -8253, -8518, -8766, -9000, -9216, -9410, -9586, -9739, -9869, -9976, -10057, -10109, -10130, -10115, -10064, -9974, -9849, -9688, -9493, -9268, -9011, -8727, -8417, -8084, -7732, -7363, -6978, -6582, -6178, -5767, -5354, -4939, -4526, -4118, -3715, -3321, -2936, -2561, -2199, -1851, -1516, -1198, -895, -607, -336, -77};