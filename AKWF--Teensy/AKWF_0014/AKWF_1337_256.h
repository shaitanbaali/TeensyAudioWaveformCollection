/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1337 256 samples */
 
const int16_t AKWF_1337_256_DATA [256] = 
{8393, 16976, 15383, 15686, 15689, 15691, 15689, 15688, 15722, 14016, 12521, 10942, 6144, 840, -647, 702, 1811, 2756, 3581, 4321, 5021, 5561, 6061, 6788, 7309, 7808, 8281, 8730, 9158, 9567, 9955, 10325, 10677, 11013, 11330, 11637, 11840, 12158, 12454, 12688, 12916, 13128, 13326, 13510, 13679, 13833, 13978, 14105, 14222, 14298, 14386, 14481, 14538, 14585, 14618, 14634, 14654, 14672, 14649, 14684, 14736, 14774, 14800, 14828, 14865, 14888, 14913, 14935, 14955, 14976, 14994, 15012, 15029, 15045, 15061, 15076, 15087, 15104, 15116, 15130, 15144, 15155, 15165, 15177, 15188, 15198, 15207, 15216, 15225, 15232, 15241, 15249, 15041, 15850, 12500, -21294, -34436, -32275, -32720, -32728, -32737, -32743, -32748, -32755, -32759, -32761, -32763, -32767, -32768, -32767, -32767, -32767, -32768, -32767, -32765, -32762, -32760, -32756, -32752, -32748, -32744, -32739, -32733, -32727, -32723, -32716, -32709, -32703, -32695, -32689, -32680, -32672, -32663, -32655, -32637, -32617, -32549, -29127, -22966, -16210, -10827, -8167, -6577, -5563, -3804, -2036, -689, 596, 1772, 2857, 3854, 4770, 5608, 6375, 7082, 7753, 8223, 8759, 9417, 9878, 10325, 10737, 11120, 11476, 11809, 12120, 12411, 12679, 12935, 13141, 13316, 13573, 13756, 13920, 14070, 14204, 14323, 14430, 14519, 14595, 14658, 14707, 14741, 14754, 14751, 14689, 14733, 14824, 14866, 14905, 14938, 14969, 14995, 15021, 15044, 15068, 15084, 15105, 15126, 15145, 15161, 15179, 15194, 15209, 15224, 15236, 15250, 15264, 15277, 15284, 15296, 15310, 15319, 15330, 15339, 15348, 15357, 15366, 15375, 15383, 15390, 15397, 15403, 15409, 15417, 15422, 15428, 15433, 15292, 15693, 14497, -17495, -34593, -32230, -32689, -32695, -32698, -32704, -32708, -32710, -32713, -32715, -32716, -32717, -32716, -32714, -32711, -32709, -32706, -32703, -32700, -32696, -32691, -32684, -32678, -32672};