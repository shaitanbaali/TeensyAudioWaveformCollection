/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1386 256 samples */
 
const int16_t AKWF_1386_256_DATA [256] = 
{859, 2507, 4044, 5520, 6945, 8334, 9699, 11037, 12359, 13663, 14942, 16204, 17438, 18633, 19791, 20895, 21932, 22902, 23792, 24599, 25327, 25967, 26520, 26985, 27363, 27655, 27862, 27985, 28031, 28004, 27910, 27753, 27537, 27271, 26959, 26608, 26222, 25806, 25318, 24782, 24239, 23687, 23138, 22591, 22052, 21522, 21007, 20508, 20028, 19567, 19128, 18717, 18328, 17964, 17627, 17316, 17028, 16763, 16520, 16298, 16095, 15910, 15744, 15594, 15459, 15338, 15231, 15133, 15048, 14970, 14902, 14841, 14788, 14739, 14697, 14661, 14626, 14597, 14571, 14549, 14528, 14511, 14499, 14487, 14479, 14473, 14381, 14853, 10880, 8379, 8873, 9157, 9625, 10115, 10588, 11043, 11495, 11957, 12444, 12960, 13494, 14038, 14574, 15077, 15533, 15926, 16241, 16476, 16624, 16689, 16674, 16493, 16807, 13874, 10439, 10527, 10226, 11144, -7074, -14025, -13193, -12532, -11113, -9452, -7705, -5905, -4050, -2122, -170, 1751, 3638, 5466, 7185, 8747, 10090, 11145, 11845, 12140, 12041, 11597, 10845, 9813, 8520, 7004, 5311, 3466, 1506, -518, -2586, -4666, -6720, -8732, -10678, -12548, -14345, -16056, -17682, -19227, -20689, -22068, -23373, -24597, -25734, -26785, -27742, -28611, -29394, -30093, -30712, -31251, -31710, -32093, -32395, -32638, -32730, -32507, -32202, -31851, -31465, -31052, -30610, -30149, -29671, -29179, -28681, -28184, -27693, -27214, -26756, -26317, -25907, -25523, -25167, -24835, -24529, -24246, -23987, -23741, -23508, -23290, -23079, -22873, -22673, -22479, -22286, -22089, -21890, -21687, -21485, -21281, -21067, -20849, -20631, -20407, -20176, -19939, -19700, -19459, -19210, -18959, -18704, -18449, -17735, -19849, -4937, 9345, 8006, 7704, 6310, 4610, 2813, 988, -882, -2834, -4888, -7038, -9200, -11310, -13340, -15229, -16913, -18333, -19396, -19745, -21929, -12809, -7517, -14203, -12226, -11424, -9989, -8264, -6400, -4496, -2629, -803};