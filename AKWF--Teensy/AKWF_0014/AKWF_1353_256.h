/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1353 256 samples */
 
const int16_t AKWF_1353_256_DATA [256] = 
{0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 481, -2119, 11424, 30961, 28253, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28754, 28778, 28645, 29235, 31158, 31055, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 31072, 30617, 33067, 19930, 2762, 5293, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4822, 4333, 6996, -15308, -27949, -25394, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25861, -25985, -25324, -28982, -33316, -32641, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767};