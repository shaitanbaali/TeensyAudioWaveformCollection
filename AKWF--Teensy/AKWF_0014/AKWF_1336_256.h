/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1336 256 samples */
 
const int16_t AKWF_1336_256_DATA [256] = 
{486, 2052, 4483, 6764, 9553, 12977, 16484, 18727, 19615, 20725, 21073, 20647, 20326, 19786, 19045, 18185, 18644, 20384, 22139, 22322, 21007, 19883, 18652, 17345, 15898, 16039, 17677, 18958, 15325, 10429, 6526, 7057, 8363, 9198, 8249, 7027, 5887, 4750, 3500, 2748, 4540, 6693, 8590, 9800, 10901, 12168, 14178, 16495, 17749, 14633, 10894, 8242, 9368, 10866, 12039, 12385, 12669, 12967, 13270, 13601, 13790, 13507, 13124, 13114, 14291, 15543, 16686, 17589, 18575, 19086, 18224, 17260, 16611, 16761, 16921, 17134, 17532, 17921, 18362, 18935, 19606, 19739, 18597, 17342, 16736, 17610, 18355, 19756, 22643, 25641, 27848, 28481, 29119, 29895, 30952, 32067, 32775, 32715, 32744, 32371, 31257, 30104, 29376, 29338, 29461, 28359, 25349, 21614, 17193, 13359, 9480, 8806, 9393, 9738, 9503, 9031, 8602, 7959, 7234, 6534, 5978, 5475, 4944, 3748, 2329, 942, -987, -3115, -5154, -6626, -7930, -9313, -11684, -14389, -16903, -17996, -18736, -19510, -19869, -20152, -20380, -19785, -19019, -18205, -16388, -14333, -12348, -10292, -8205, -6133, -3906, -1553, 460, 217, -486, -880, 192, 1626, 2554, 675, -1680, -3831, -5602, -7360, -8965, -9820, -10513, -11517, -14131, -17019, -19559, -20869, -22044, -23245, -24487, -25880, -26600, -24465, -21985, -19927, -19132, -18443, -17738, -17032, -16292, -15710, -15665, -15644, -15676, -15763, -15907, -15324, -14160, -12995, -12850, -13498, -14011, -14811, -15817, -16850, -17001, -16532, -16129, -16104, -16335, -16595, -15787, -14273, -12851, -11870, -11166, -10369, -10641, -11549, -12337, -13420, -14675, -15932, -16159, -15825, -15526, -16889, -19145, -21225, -23624, -26202, -28768, -29452, -29245, -29199, -28731, -28079, -27462, -27064, -26768, -26456, -25314, -23802, -22375, -22083, -22244, -22318, -22110, -21809, -21495, -19541, -16961, -14557, -13465, -12845, -12073, -9378, -5995, -2853, -1488, -644};