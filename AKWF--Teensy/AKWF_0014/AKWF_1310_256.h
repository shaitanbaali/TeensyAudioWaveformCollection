/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1310 256 samples */
 
const int16_t AKWF_1310_256_DATA [256] = 
{1523, 3876, 6002, 7979, 9807, 11504, 13077, 14530, 15877, 17128, 18282, 19352, 20345, 21261, 22112, 22900, 23629, 24304, 24930, 25508, 26047, 26544, 27002, 27429, 27824, 28190, 28529, 28842, 29132, 29400, 29650, 29880, 30094, 30293, 30476, 30647, 30803, 30948, 31084, 31208, 31325, 31430, 31530, 31621, 31707, 31785, 31858, 31926, 31988, 32046, 32101, 32151, 32197, 32239, 32277, 32315, 32349, 32380, 32409, 32437, 32461, 32484, 32505, 32525, 32544, 32561, 32577, 32591, 32604, 32617, 32629, 32639, 32650, 32658, 32667, 32675, 32681, 32689, 32696, 32701, 32706, 32711, 32716, 32720, 32724, 32727, 32731, 32734, 32737, 32739, 32742, 32745, 32747, 32748, 32750, 32753, 32753, 32755, 32758, 32757, 32758, 32761, 32761, 32760, 32762, 32765, 32764, 32765, 32764, 32766, 32768, 32767, 32768, 32768, 32768, 32768, 32754, 32770, 32689, 29612, 24856, 20637, 16691, 13037, 9656, 6519, 3618, 932, -1560, -3865, -5998, -7979, -9808, -11505, -13078, -14531, -15878, -17128, -18283, -19353, -20345, -21262, -22113, -22900, -23629, -24304, -24930, -25508, -26047, -26544, -27003, -27429, -27824, -28190, -28529, -28842, -29132, -29400, -29650, -29880, -30094, -30293, -30476, -30647, -30803, -30948, -31084, -31208, -31325, -31430, -31530, -31621, -31707, -31785, -31858, -31926, -31988, -32046, -32101, -32151, -32197, -32239, -32277, -32315, -32350, -32380, -32409, -32437, -32461, -32484, -32505, -32525, -32544, -32561, -32577, -32591, -32604, -32617, -32629, -32639, -32650, -32658, -32667, -32675, -32681, -32689, -32696, -32701, -32706, -32711, -32716, -32720, -32724, -32727, -32731, -32734, -32737, -32739, -32742, -32745, -32746, -32748, -32750, -32753, -32753, -32755, -32758, -32757, -32758, -32761, -32761, -32760, -32762, -32765, -32764, -32765, -32764, -32766, -32768, -32767, -32767, -32767, -32767, -32767, -32754, -32770, -32689, -29612, -24856, -20638, -16692, -13037, -9657, -6524, -3629, -901};