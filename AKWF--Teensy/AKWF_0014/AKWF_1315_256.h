/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1315 256 samples */
 
const int16_t AKWF_1315_256_DATA [256] = 
{1400, 3384, 5262, 7082, 8836, 10530, 12166, 13727, 15233, 16676, 18051, 19368, 20617, 21802, 22928, 23989, 24983, 25920, 26791, 27597, 28340, 29021, 29636, 30191, 30681, 31106, 31471, 31772, 32008, 32180, 32290, 32337, 32319, 32240, 32096, 31890, 31619, 31285, 30887, 30428, 29903, 29316, 28664, 27952, 27173, 26333, 25427, 24463, 23432, 22336, 21179, 19959, 18674, 17324, 15915, 14439, 12903, 11302, 9635, 7907, 6118, 4270, 2338, 427, -61, 18, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -15, 40, -249, -2046, -4024, -5889, -7705, -9455, -11143, -12769, -14326, -15825, -17260, -18628, -19936, -21181, -22359, -23477, -24533, -25520, -26448, -27311, -28110, -28850, -29523, -30131, -30680, -31164, -31583, -31940, -32233, -32462, -32629, -32731, -32769, -32749, -32661, -32508, -32295, -32019, -31679, -31274, -30806, -30277, -29682, -29026, -28305, -27520, -26675, -25762, -24787, -23753, -22650, -21483, -20258, -18967, -17613, -16195, -14711, -13167, -11563, -9888, -8154, -6358, -4498, -2577, -553};