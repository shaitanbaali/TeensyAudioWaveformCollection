/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1391 256 samples */
 
const int16_t AKWF_1391_256_DATA [256] = 
{1378, 5048, 8582, 12013, 15283, 18360, 21207, 23782, 26073, 28065, 29743, 31043, 31913, 32446, 32717, 32757, 32579, 32166, 31481, 30447, 29043, 27382, 25492, 23385, 21089, 18627, 16015, 13290, 10482, 7610, 4717, 1826, -1041, -3848, -6578, -9214, -11725, -14098, -16317, -18358, -20218, -21886, -23344, -24585, -25608, -26405, -26984, -27335, -27459, -27362, -27049, -26531, -25813, -24910, -23829, -22572, -21159, -19602, -17919, -16135, -14258, -12304, -10295, -8242, -6171, -4104, -2051, -35, 1927, 3833, 5659, 7389, 9031, 10562, 11969, 13265, 14431, 15451, 16339, 17083, 17677, 18133, 18458, 18642, 18680, 18579, 18347, 17974, 17475, 16864, 16146, 15319, 14395, 13390, 12316, 11175, 9976, 8751, 7503, 6228, 4940, 3648, 2368, 1110, -130, -1341, -2507, -3629, -4702, -5716, -6663, -7534, -8328, -9052, -9697, -10254, -10722, -11100, -11390, -11596, -11715, -11754, -11718, -11611, -11438, -11198, -10888, -10517, -10095, -9632, -9127, -8583, -8004, -7396, -6768, -6125, -5465, -4791, -4107, -3415, -2725, -2038, -1357, -690, -43, 583, 1180, 1746, 2282, 2784, 3245, 3662, 4030, 4347, 4620, 4847, 5030, 5168, 5261, 5310, 5316, 5281, 5210, 5105, 4967, 4803, 4613, 4405, 4181, 3941, 3685, 3413, 3125, 2825, 2516, 2202, 1892, 1585, 1283, 985, 695, 414, 148, -104, -336, -547, -739, -911, -1064, -1197, -1307, -1396, -1463, -1509, -1534, -1540, -1530, -1503, -1464, -1413, -1350, -1276, -1194, -1105, -1012, -915, -816, -715, -617, -523, -433, -348, -270, -199, -136, -81, -37, -3, 19, 26, 17, -7, -46, -99, -163, -237, -320, -410, -503, -600, -699, -798, -896, -991, -1079, -1160, -1230, -1326, -1288, -1772, -10372, -19240, -21302, -24210, -26845, -27280, -26403, -25203, -23552, -21275, -18611, -15730, -12611, -9263, -5783, -2143};