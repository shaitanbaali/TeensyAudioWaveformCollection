/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1302 256 samples */
 
const int16_t AKWF_1302_256_DATA [256] = 
{392, 1726, 3043, 4368, 5700, 7049, 8435, 9882, 11420, 13078, 14862, 16776, 18774, 20780, 22685, 24401, 25765, 26841, 27540, 28212, 29045, 30339, 29418, 28287, 27195, 26087, 24988, 23907, 22849, 21797, 20744, 19631, 18453, 17097, 15633, 13906, 12118, 10275, 8345, 7349, 4362, 3586, 1626, -2136, -3263, -4908, -6589, -8436, -10386, -12442, -14697, -16989, -19200, -21219, -22821, -24064, -24735, -25767, -26379, -28021, -27648, -26189, -24910, -23576, -22203, -20773, -19277, -17689, -16030, -14309, -12570, -10886, -9311, -7927, -6724, -5764, -4803, -3848, -2434, -2298, -2462, -2565, -2677, -2780, -2869, -2949, -3013, -3078, -3159, -3273, -3442, -3681, -3990, -4353, -4726, -5049, -5231, -5212, -4921, -4358, -3668, -2859, -2609, -1786, 253, 2242, 4322, 6539, 8922, 11480, 14214, 17049, 19875, 22524, 24874, 26690, 28077, 28936, 29761, 30913, 32631, 31133, 29394, 27670, 25862, 23959, 21964, 19875, 17726, 15575, 13506, 11580, 9915, 8472, 7287, 6125, 4798, 3202, 3207, 3345, 3452, 3572, 3694, 3817, 3937, 4058, 4174, 4294, 4422, 4565, 4728, 4919, 5138, 5385, 5668, 5680, 7143, 5753, 4140, 5635, 6100, 5991, 5960, 6050, 5303, 4781, 4234, 3675, 3095, 2502, 1728, 2049, -2797, -16491, -15426, -15269, -15016, -14777, -14562, -14371, -14208, -14066, -13947, -13847, -13869, -12963, -16658, -16547, -11272, -13502, -14309, -15403, -16593, -17881, -19264, -20702, -22145, -23500, -24717, -25677, -26426, -26958, -27430, -28235, -29042, -28295, -27584, -26862, -26119, -25359, -24581, -23788, -22975, -22150, -21315, -20469, -19620, -18760, -17890, -17003, -16090, -15128, -14115, -13039, -11897, -10706, -9500, -8441, -6232, -10204, -13497, -1706, -3422, -2748, -2015, -2124, -2337, -2378, -2444, -2515, -2604, -2729, -2897, -3110, -3366, -3637, -3894, -4071, -4139, -4031, -3755, -3352, -2864, -2632, -2207, -863};