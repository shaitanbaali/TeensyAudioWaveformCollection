/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1351 256 samples */
 
const int16_t AKWF_1351_256_DATA [256] = 
{0, 4, 17, 36, 61, 94, 134, 179, 231, 291, 356, 428, 506, 590, 681, 778, 880, 989, 1103, 1222, 1347, 1477, 1612, 1753, 1898, 2047, 2201, 2360, 2521, 2688, 2857, 3030, 3207, 3386, 3567, 3751, 3938, 4126, 4316, 4508, 4701, 4894, 5089, 5283, 5478, 5672, 5866, 6060, 6251, 6442, 6631, 6818, 7002, 7184, 7363, 7538, 7710, 7877, 8041, 8200, 8353, 8502, 8645, 8782, 8913, 9037, 9154, 9264, 9367, 9461, 9548, 9625, 9694, 9754, 9805, 9846, 9876, 9897, 9906, 9905, 9893, 9870, 9834, 9787, 9728, 9657, 9573, 9477, 9367, 9244, 9108, 8959, 8796, 8619, 8429, 8225, 8006, 7775, 7529, 7268, 6994, 6706, 6403, 6087, 5756, 5411, 5054, 4682, 4297, 3898, 3487, 3062, 2626, 2176, 1714, 1242, 756, 261, -244, -761, -1288, -1822, -2367, -2920, -3480, -4048, -4622, -5201, -5787, -6376, -6969, -7566, -8164, -8765, -9367, -9966, -10566, -11165, -11758, -12350, -12937, -13516, -14090, -14657, -15212, -15761, -16297, -16821, -17332, -17829, -18310, -18776, -19223, -19651, -20060, -20447, -20812, -21155, -21473, -21764, -22030, -22268, -22477, -22656, -22804, -22921, -23004, -23054, -23068, -23048, -22991, -22897, -22765, -22594, -22384, -22134, -21845, -21514, -21142, -20730, -20274, -19777, -19240, -18659, -18037, -17375, -16669, -15924, -15139, -14313, -13449, -12548, -11607, -10632, -9622, -8576, -7501, -6394, -5256, -4094, -2904, -1690, -458, 795, 2066, 3348, 4645, 5951, 7260, 8575, 9890, 11199, 12506, 13803, 15083, 16351, 17599, 18820, 20018, 21184, 22313, 23408, 24459, 25463, 26421, 27323, 28169, 28956, 29677, 30331, 30916, 31425, 31857, 32209, 32478, 32660, 32755, 32758, 32669, 32484, 32205, 31826, 31349, 30773, 30095, 29318, 28443, 27465, 26390, 25219, 23950, 22589, 21139, 19600, 17982, 16243};