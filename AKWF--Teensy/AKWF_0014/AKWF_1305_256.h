/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1305 256 samples */
 
const int16_t AKWF_1305_256_DATA [256] = 
{889, 3661, 6054, 8190, 10085, 11758, 13224, 14501, 15581, 16529, 17353, 18049, 18658, 19226, 19684, 20334, 20720, 21087, 21475, 21842, 22178, 22489, 22747, 22994, 23229, 23436, 23617, 23773, 23906, 24022, 24120, 24203, 24274, 24332, 24377, 24416, 24447, 24469, 24485, 24495, 24498, 24499, 24495, 24488, 24477, 24463, 24446, 24428, 24408, 24385, 24362, 24336, 24311, 24282, 24254, 24225, 24193, 24163, 24131, 24099, 24066, 24032, 23999, 23965, 23931, 23896, 23861, 23825, 23790, 23753, 23716, 23678, 23636, 23588, 23527, 23421, 23320, 23088, 22946, 22706, 22526, 22309, 22022, 21684, 21219, 20502, 18852, 17364, 14411, 11830, 12306, 10408, 8451, 6637, 4996, 3514, 2172, 960, -139, -1139, -2049, -2882, -3643, -4340, -4980, -5565, -6090, -6541, -6877, -6998, -6724, -5105, -4076, -433, 1418, 617, 2611, 4575, 6373, 7988, 9426, 10704, 11847, 12864, 13769, 14579, 15300, 15944, 16522, 17038, 17499, 17914, 18286, 18619, 18921, 19192, 19439, 19667, 19879, 20099, 20263, 20454, 20579, 20551, 20709, 20820, 20878, 20924, 20961, 20988, 21008, 21022, 21029, 21031, 21030, 21024, 21014, 21000, 20984, 20967, 20946, 20923, 20898, 20872, 20844, 20815, 20784, 20752, 20718, 20683, 20647, 20608, 20569, 20527, 20483, 20437, 20389, 20336, 20281, 20221, 20153, 20082, 20001, 19911, 19809, 19695, 19562, 19409, 19233, 19026, 18785, 18504, 18171, 17782, 17325, 16791, 16173, 15465, 14647, 13712, 12625, 11284, 9671, 7677, 5386, 2687, 161, -2386, -4265, -6175, -8528, -10686, -12646, -14412, -16001, -17440, -18740, -19918, -20989, -21964, -22852, -23667, -24414, -25100, -25736, -26324, -26870, -27380, -27856, -28303, -28727, -29125, -29504, -29865, -30209, -30540, -30858, -31164, -31459, -31744, -32018, -32276, -32509, -32692, -32768, -32608, -31934, -29976, -25881, -23176, -13798, -15995, -13426, -9317, -5535, -2068};