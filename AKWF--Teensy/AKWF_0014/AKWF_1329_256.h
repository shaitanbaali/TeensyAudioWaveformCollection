/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1329 256 samples */
 
const int16_t AKWF_1329_256_DATA [256] = 
{28903, 28626, 28678, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28668, 28383, 29976, 22484, 5849, 7544, 7233, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7238, 7078, 7875, 4867, -28182, -30574, -29891, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30033, -30057, -29526, -32312, -10442, 268, -1991, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1588, -1587, -1596, -1548};