/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1356 256 samples */
 
const int16_t AKWF_1356_256_DATA [256] = 
{5995, 16810, 20626, 23706, 25902, 27566, 28853, 29856, 30644, 31262, 31741, 32108, 32381, 32573, 32696, 32757, 32765, 32722, 32634, 32503, 32331, 32122, 31875, 31593, 31275, 30924, 30538, 30121, 29671, 29188, 28675, 28131, 27556, 26952, 26320, 25659, 24972, 24258, 23518, 22755, 21968, 21158, 20329, 19479, 18609, 17725, 16823, 15906, 14978, 14036, 13083, 12124, 11154, 10179, 9201, 8216, 7231, 6246, 5258, 4273, 3292, 2313, 1340, 374, -586, -1537, -2479, -3413, -4334, -5244, -6142, -7027, -7898, -8756, -9597, -10424, -11237, -12031, -12810, -13574, -14318, -15047, -15759, -16451, -17129, -17787, -18428, -19052, -19659, -20247, -20819, -21374, -21910, -22431, -22935, -23422, -23894, -24349, -24788, -25212, -25620, -26014, -26394, -26758, -27109, -27447, -27770, -28080, -28378, -28662, -28936, -29197, -29446, -29684, -29911, -30127, -30333, -30529, -30714, -30890, -31057, -31214, -31363, -31503, -31634, -31758, -31873, -31981, -32080, -32173, -32258, -32336, -32407, -32472, -32529, -32580, -32625, -32664, -32696, -32722, -32742, -32757, -32765, -32768, -32765, -32757, -32743, -32722, -32698, -32667, -32631, -32589, -32542, -32490, -32432, -32369, -32301, -32227, -32147, -32063, -31972, -31877, -31776, -31669, -31558, -31440, -31316, -31188, -31054, -30913, -30768, -30617, -30459, -30297, -30128, -29953, -29774, -29587, -29395, -29197, -28993, -28783, -28568, -28345, -28118, -27884, -27644, -27398, -27146, -26888, -26625, -26355, -26079, -25797, -25509, -25215, -24915, -24610, -24298, -23981, -23658, -23329, -22995, -22655, -22309, -21959, -21602, -21240, -20874, -20501, -20123, -19741, -19353, -18961, -18564, -18162, -17756, -17345, -16930, -16510, -16087, -15659, -15228, -14793, -14353, -13911, -13466, -13016, -12564, -12110, -11651, -11191, -10728, -10263, -9795, -9326, -8853, -8380, -7905, -7428, -6951, -6471, -5990, -5509, -5027, -4545, -4062, -3578, -3095, -2612, -2129, -1646, -1164, -682, -203, 285};