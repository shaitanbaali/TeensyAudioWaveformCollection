/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1375 256 samples */
 
const int16_t AKWF_1375_256_DATA [256] = 
{6192, 9279, 11179, 13052, 14643, 15937, 16937, 17731, 18385, 18961, 19457, 19830, 20061, 20152, 20121, 20031, 19963, 19946, 19980, 20033, 20033, 19948, 19774, 19583, 19435, 19353, 19344, 19405, 19527, 19698, 19906, 20135, 20367, 20577, 20745, 20855, 20895, 20855, 20735, 20534, 20255, 19911, 19509, 19050, 18550, 18009, 17424, 16796, 16115, 15364, 14534, 13614, 12588, 11463, 10243, 8937, 7580, 6239, 4986, 3841, 2811, 1888, 1066, 329, -328, -868, -1287, -1606, -1853, -2059, -2243, -2410, -2562, -2697, -2815, -2913, -2991, -3047, -3084, -3113, -3138, -3176, -3245, -3361, -3538, -3778, -4074, -4408, -4753, -5078, -5358, -5572, -5701, -5739, -5687, -5549, -5345, -5097, -4828, -4557, -4295, -4046, -3800, -3543, -3254, -2915, -2510, -2033, -1480, -857, -174, 548, 1287, 2014, 2695, 3304, 3834, 4279, 4657, 4988, 5298, 5611, 5949, 6328, 6757, 7237, 7761, 8321, 8892, 9408, 9830, 10146, 10348, 10439, 10418, 10311, 10133, 9916, 9687, 9323, 13010, 14388, 13964, 13921, 13827, 13709, 13548, 13334, 13038, 12665, 12225, 11722, 11176, 10609, 10042, 9500, 9001, 8545, 8128, 7735, 7350, 6952, 6515, 6084, 5249, 6283, 8585, 7681, 7020, 6336, 5682, 5075, 4522, 4019, 3543, 3076, 2594, 2070, 1497, 888, 223, -485, -1240, -2033, -2835, -3621, -4376, -5085, -5743, -6345, -6897, -7417, -7932, -8477, -9075, -9746, -10492, -11314, -12200, -13146, -14118, -15042, -15888, -16641, -17291, -17848, -18322, -18739, -19129, -19514, -19906, -20312, -20732, -21171, -21621, -22074, -22514, -22916, -23263, -23538, -23742, -23885, -23974, -24013, -24009, -23965, -23967, -24173, -24708, -25632, -26860, -28238, -29581, -30734, -31627, -32238, -32593, -32752, -32740, -32513, -32010, -31214, -30168, -28972, -27694, -26349, -24893, -23270, -21425, -19326, -17010, -14582, -12125, -9647, -7351, -4268};