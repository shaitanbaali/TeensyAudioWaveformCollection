/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1321 256 samples */
 
const int16_t AKWF_1321_256_DATA [256] = 
{-130, -13, 1242, 2379, 3480, 4539, 5556, 6524, 7449, 8328, 9160, 9946, 10688, 11381, 12032, 12637, 13196, 13712, 14186, 14615, 15005, 15352, 15663, 15946, 16202, 16435, 16645, 16836, 17003, 17153, 17283, 17399, 17500, 17589, 17664, 17730, 17789, 17842, 17890, 17934, 17978, 18021, 18064, 18110, 18158, 18212, 18271, 18337, 18407, 18485, 18573, 18669, 18772, 18886, 19008, 19139, 19281, 19432, 19594, 19765, 19944, 20134, 20332, 20540, 20756, 20982, 21215, 21455, 21702, 21957, 22217, 22484, 22746, 22968, 23090, 23150, 23263, 23313, 23340, 23367, 23386, 23377, 23328, 23239, 23118, 22974, 22801, 22587, 22328, 22022, 21672, 21287, 20869, 20412, 19917, 19386, 18819, 18222, 17598, 16947, 16274, 15574, 14854, 14117, 13364, 12599, 11824, 11038, 10245, 9450, 8652, 7851, 7056, 6264, 5475, 4693, 3921, 3159, 2409, 1670, 946, 239, -454, -1127, -1784, -2424, -3041, -3638, -4218, -4770, -5304, -5817, -6306, -6770, -7213, -7630, -8026, -8396, -8741, -9066, -9367, -9649, -9910, -10158, -10386, -10599, -10798, -10981, -11149, -11305, -11450, -11583, -11705, -11818, -11923, -12020, -12112, -12197, -12279, -12358, -12434, -12508, -12583, -12659, -12734, -12814, -12897, -12983, -13073, -13169, -13272, -13381, -13497, -13620, -13753, -13894, -14044, -14204, -14374, -14553, -14745, -14947, -15159, -15383, -15615, -15900, -16302, -16724, -17162, -17619, -18093, -18584, -19097, -19627, -20175, -20745, -21334, -21943, -22574, -23222, -23894, -24586, -25298, -26033, -26790, -27567, -28361, -29139, -29844, -30426, -30866, -31205, -31493, -31775, -32050, -32295, -32489, -32624, -32711, -32759, -32766, -32718, -32605, -32418, -32163, -31847, -31471, -31035, -30537, -29973, -29344, -28659, -27918, -27126, -26283, -25389, -24445, -23461, -22435, -21373, -20282, -19154, -17999, -16823, -15621, -14402, -13172, -11927, -10673, -9417, -8151, -6889, -5629, -4374, -3130, -1869};