/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1364 256 samples */
 
const int16_t AKWF_1364_256_DATA [256] = 
{481, 1963, 3445, 4972, 6514, 8086, 9664, 11250, 12830, 14407, 15958, 17488, 18988, 20440, 21849, 23203, 24485, 25701, 26841, 27892, 28856, 29722, 30489, 31150, 31703, 32141, 32467, 32674, 32764, 32734, 32586, 32321, 31939, 31444, 30838, 30122, 29307, 28390, 27377, 26282, 25102, 23847, 22529, 21144, 19710, 18229, 16714, 15160, 13599, 12010, 10423, 8833, 7254, 5686, 4148, 2631, 1152, -284, -1682, -3024, -4317, -5555, -6729, -7841, -8893, -9875, -10796, -11648, -12437, -13159, -13823, -14421, -14964, -15449, -15881, -16262, -16598, -16890, -17142, -17359, -17544, -17701, -17832, -17944, -18037, -18117, -18185, -18244, -18297, -18346, -18391, -18436, -18480, -18524, -18567, -18610, -18652, -18691, -18725, -18755, -18775, -18783, -18779, -18756, -18714, -18645, -18550, -18423, -18259, -18056, -17811, -17518, -17175, -16780, -16324, -15815, -15239, -14604, -13900, -13134, -12296, -11398, -10428, -9396, -8303, -7144, -5930, -4658, -3337, -1965, -559, 896, 2369, 3877, 5402, 6936, 8469, 10011, 11526, 13036, 14511, 15956, 17354, 18710, 19999, 21230, 22387, 23464, 24460, 25363, 26172, 26879, 27483, 27976, 28361, 28630, 28785, 28823, 28745, 28551, 28241, 27821, 27287, 26649, 25904, 25065, 24126, 23103, 21995, 20809, 19558, 18241, 16870, 15451, 13995, 12498, 10991, 9453, 7917, 6376, 4843, 3319, 1821, 341, -1095, -2500, -3854, -5167, -6418, -7622, -8760, -9836, -10851, -11797, -12679, -13491, -14239, -14917, -15535, -16085, -16578, -17009, -17385, -17708, -17981, -18209, -18393, -18540, -18652, -18732, -18784, -18813, -18823, -18815, -18794, -18763, -18724, -18678, -18630, -18579, -18526, -18473, -18421, -18369, -18315, -18259, -18201, -18138, -18069, -17990, -17899, -17793, -17670, -17522, -17353, -17152, -16920, -16650, -16340, -15988, -15588, -15138, -14631, -14073, -13450, -12770, -12025, -11218, -10342, -9408, -8402, -7335, -6198, -5048, -3614, -1332};