/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1330 256 samples */
 
const int16_t AKWF_1330_256_DATA [256] = 
{32675, 32784, 32764, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32234, 35206, 21105, -10089, -6997, -7561, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7554, -7621, -7319, -8064, -29604, -31815, -31240, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -31348, -30916, -33327, -21970, 3439, 930, 1388, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1336, 1588, 237};