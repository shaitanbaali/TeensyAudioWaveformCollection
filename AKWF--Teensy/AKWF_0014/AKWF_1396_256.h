/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1396 256 samples */
 
const int16_t AKWF_1396_256_DATA [256] = 
{224, 765, 1368, 2039, 2839, 3824, 4956, 6155, 7368, 8618, 9924, 11295, 12726, 14214, 15752, 17311, 18859, 20373, 21819, 23169, 24425, 25593, 26678, 27692, 28631, 29489, 30263, 30945, 31526, 32004, 32368, 32615, 32745, 32763, 32684, 32527, 32309, 32047, 31739, 31376, 30945, 30442, 29867, 29215, 28498, 27755, 27010, 26272, 25524, 24742, 23924, 23072, 22192, 21294, 20384, 19465, 18546, 17646, 16780, 15965, 15206, 14508, 13873, 13298, 12788, 12333, 11757, 11077, 10384, 9667, 8925, 8153, 7352, 6542, 5745, 4965, 4210, 3489, 2807, 2169, 1582, 1050, 579, 174, -160, -420, -600, -700, -718, -660, -522, -307, -22, 332, 751, 1229, 1759, 2332, 2943, 3580, 4237, 4903, 5574, 6237, 6887, 7519, 8118, 8680, 9197, 9662, 10074, 10430, 10720, 10940, 11082, 11143, 11118, 11009, 10810, 10519, 10123, 9621, 9009, 8283, 7422, 6264, 4884, 3576, 2422, 1419, 526, -292, -967, -1469, -1852, -2156, -2419, -2655, -2862, -3028, -3138, -3174, -3127, -3011, -2848, -2663, -2474, -2295, -2123, -1955, -1781, -1598, -1404, -1202, -998, -799, -616, -461, -346, -278, -265, -308, -407, -569, -792, -1078, -1450, -1977, -2667, -3486, -4407, -5399, -6414, -7414, -8382, -9315, -10219, -11108, -11989, -12865, -13743, -14620, -15483, -16327, -17140, -17909, -18625, -19275, -19849, -20344, -20753, -21072, -21303, -21452, -21724, -22210, -22844, -23598, -24442, -25344, -26278, -27207, -28095, -28915, -29640, -30243, -30693, -30976, -31084, -31014, -30774, -30374, -29826, -29148, -28358, -27475, -26518, -25503, -24439, -23345, -22230, -21105, -19987, -18881, -17780, -16695, -15633, -14599, -13612, -12688, -11812, -10966, -10153, -9397, -8714, -8099, -7543, -7050, -6606, -6206, -5851, -5533, -5242, -4972, -4713, -4465, -4219, -3970, -3711, -3428, -3084, -2516, -1842, -1250, -736, -250};