/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1398 256 samples */
 
const int16_t AKWF_1398_256_DATA [256] = 
{363, 899, 1420, 1945, 2468, 2990, 3511, 4042, 4595, 5169, 5750, 6334, 6930, 7532, 8161, 8805, 9451, 10116, 10795, 11484, 12175, 12854, 13522, 14179, 14837, 15497, 16162, 16815, 17456, 18093, 18739, 19397, 20060, 20731, 21426, 22134, 22853, 23592, 24320, 25029, 25644, 26543, 27402, 28043, 28620, 29145, 29613, 30032, 30420, 30780, 31098, 31374, 31613, 31819, 32002, 32166, 32313, 32434, 32534, 32617, 32683, 32729, 32760, 32768, 32766, 32753, 32716, 32663, 32092, 34659, 15860, -2185, -836, -1273, -1536, -1792, -2070, -2362, -2644, -2985, -3410, -3819, -4209, -4570, -4915, -5246, -5583, -5920, -6258, -6598, -6931, -7252, -7567, -7877, -8177, -8476, -8786, -9101, -9401, -9689, -9972, -10259, -10556, -10860, -11159, -11442, -11712, -11972, -12227, -12482, -12742, -13001, -13259, -13513, -13757, -14000, -14247, -14505, -14770, -15035, -15303, -15569, -15831, -16101, -16391, -16698, -17006, -17319, -17637, -17965, -18305, -18645, -18959, -19168, -19664, -20131, -20387, -20449, -21125, -19778, 10132, 33310, 31680, 31789, 31625, 31422, 31194, 30934, 30643, 30315, 29942, 29526, 29061, 28546, 27980, 27391, 26746, 26003, 25235, 24438, 23581, 22671, 21711, 20695, 19628, 18502, 17315, 16070, 14765, 13402, 11979, 10506, 8850, 8260, 3614, -20525, -21300, -21120, -21216, -21221, -21217, -21207, -21186, -21151, -21113, -21069, -21017, -20968, -20905, -20822, -20736, -20655, -20580, -20510, -20448, -20391, -20330, -20262, -20180, -20083, -19975, -19858, -19741, -19619, -19478, -19322, -19142, -18938, -18717, -18486, -18248, -17985, -17694, -17394, -17073, -16746, -16423, -16078, -15701, -15319, -14939, -14563, -14184, -13803, -13422, -13043, -12647, -12230, -11812, -11387, -10944, -10493, -10042, -9599, -9163, -8743, -8338, -7940, -7553, -7180, -6811, -6437, -6070, -5707, -5334, -4956, -4562, -4147, -3712, -3257, -2779, -2278, -1759, -1233, -704, -158};