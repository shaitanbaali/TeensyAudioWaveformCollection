/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1383 256 samples */
 
const int16_t AKWF_1383_256_DATA [256] = 
{691, 2199, 3639, 5043, 6402, 7715, 8979, 10186, 11337, 12431, 13459, 14426, 15328, 16160, 16926, 17622, 18244, 18798, 19280, 19688, 20026, 20294, 20489, 20613, 20670, 20658, 20580, 20437, 20230, 19963, 19636, 19252, 18813, 18322, 17782, 17195, 16564, 15892, 15180, 14437, 13659, 12851, 12022, 11166, 10293, 9405, 8502, 7590, 6672, 5750, 4827, 3909, 2994, 2087, 1195, 313, -551, -1396, -2221, -3021, -3795, -4544, -5262, -5948, -6604, -7224, -7808, -8356, -8866, -9336, -9769, -10159, -10510, -10821, -11089, -11317, -11504, -11650, -11755, -11820, -11846, -11833, -11781, -11694, -11569, -11410, -11218, -10992, -10735, -10449, -10135, -9794, -9429, -9040, -8630, -8200, -7750, -7287, -6808, -6316, -5815, -5303, -4785, -4262, -3735, -3207, -2679, -2152, -1629, -1112, -600, -97, 395, 879, 1350, 1806, 2247, 2672, 3081, 3472, 3843, 4196, 4528, 4838, 5125, 5392, 5635, 5856, 6053, 6227, 6376, 6504, 6607, 6686, 6743, 6777, 6787, 6776, 6743, 6689, 6615, 6520, 6406, 6275, 6124, 5957, 5775, 5577, 5366, 5140, 4904, 4655, 4397, 4129, 3854, 3571, 3282, 2989, 2691, 2391, 2089, 1785, 1484, 1182, 883, 586, 294, 8, -274, -550, -818, -1078, -1330, -1572, -1804, -2027, -2237, -2437, -2625, -2801, -2964, -3114, -3252, -3375, -3486, -3583, -3667, -3738, -3794, -3838, -3868, -3884, -3890, -3881, -3860, -3827, -3782, -3726, -3659, -3581, -3495, -3397, -3292, -3177, -3054, -2924, -2787, -2643, -2496, -2340, -2182, -2019, -1853, -1685, -1514, -1342, -1169, -996, -822, -650, -478, -309, -142, 22, 183, 339, 493, 641, 784, 922, 442, 3858, -14577, -34868, -30564, -30186, -29096, -27936, -26706, -25415, -24070, -22669, -21224, -19741, -18222, -16673, -15104, -13513, -11911, -10306, -8694, -7088, -5493, -3910, -2350, -783};