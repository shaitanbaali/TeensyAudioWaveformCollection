/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1382 256 samples */
 
const int16_t AKWF_1382_256_DATA [256] = 
{1410, 3699, 5837, 7866, 9766, 11527, 13142, 14592, 15880, 16999, 17939, 18704, 19292, 19702, 19939, 20003, 19901, 19638, 19223, 18664, 17968, 17145, 16210, 15168, 14036, 12826, 11545, 10211, 8838, 7431, 6009, 4583, 3161, 1762, 392, -940, -2221, -3444, -4602, -5682, -6685, -7601, -8423, -9152, -9785, -10314, -10743, -11071, -11297, -11424, -11452, -11386, -11227, -10982, -10656, -10250, -9773, -9233, -8631, -7979, -7282, -6546, -5780, -4991, -4184, -3371, -2554, -1741, -941, -158, 603, 1333, 2030, 2690, 3305, 3874, 4394, 4862, 5274, 5631, 5929, 6170, 6352, 6477, 6543, 6556, 6513, 6418, 6273, 6082, 5846, 5570, 5257, 4910, 4534, 4133, 3710, 3269, 2817, 2354, 1888, 1420, 955, 498, 51, -383, -799, -1197, -1572, -1922, -2246, -2541, -2806, -3040, -3241, -3408, -3543, -3645, -3714, -3750, -3754, -3726, -3669, -3585, -3472, -3335, -3176, -2994, -2794, -2578, -2347, -2103, -1851, -1591, -1325, -1059, -790, -524, -263, -8, 239, 477, 703, 917, 1116, 1300, 1468, 1617, 1750, 1864, 1958, 2035, 2091, 2128, 2147, 2148, 2130, 2096, 2047, 1981, 1901, 1809, 1704, 1588, 1464, 1331, 1191, 1046, 897, 744, 592, 439, 286, 137, -9, -149, -286, -414, -536, -649, -754, -849, -934, -1009, -1073, -1127, -1168, -1199, -1221, -1230, -1229, -1219, -1199, -1169, -1132, -1085, -1031, -971, -904, -832, -756, -676, -592, -506, -420, -332, -244, -157, -72, 12, 91, 169, 242, 312, 376, 436, 490, 538, 580, 616, 647, 670, 688, 699, 704, 703, 697, 684, 667, 644, 618, 587, 551, 513, 472, 428, 382, 324, 16, 1564, -25407, -33135, -29719, -28460, -26657, -24692, -22590, -20362, -18040, -15646, -13193, -10711, -8223, -5743, -3300, -860};