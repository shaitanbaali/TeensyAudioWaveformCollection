/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1354 256 samples */
 
const int16_t AKWF_1354_256_DATA [256] = 
{4079, 11740, 14895, 17625, 19795, 21615, 23176, 24526, 25707, 26747, 27659, 28466, 29178, 29802, 30351, 30829, 31242, 31598, 31899, 32148, 32352, 32512, 32631, 32711, 32756, 32767, 32747, 32697, 32618, 32513, 32383, 32228, 32051, 31852, 31634, 31395, 31139, 30865, 30574, 30268, 29947, 29612, 29263, 28902, 28528, 28143, 27747, 27340, 26924, 26498, 26063, 25621, 25170, 24712, 24247, 23774, 23296, 22812, 22322, 21828, 21329, 20824, 20316, 19804, 19287, 18768, 18246, 17721, 17193, 16664, 16131, 15597, 15062, 14525, 13987, 13448, 12908, 12368, 11826, 11285, 10745, 10203, 9661, 9122, 8581, 8041, 7504, 6966, 6429, 5896, 5360, 4828, 4299, 3769, 3242, 2717, 2193, 1673, 1154, 637, 125, -386, -895, -1401, -1904, -2405, -2901, -3397, -3889, -4376, -4861, -5344, -5821, -6297, -6769, -7236, -7701, -8162, -8619, -9072, -9522, -9968, -10410, -10849, -11282, -11713, -12139, -12561, -12981, -13394, -13804, -14210, -14611, -15009, -15403, -15790, -16175, -16556, -16932, -17303, -17671, -18033, -18391, -18746, -19095, -19440, -19781, -20116, -20449, -20776, -21098, -21417, -21730, -22039, -22344, -22644, -22939, -23231, -23517, -23798, -24076, -24349, -24617, -24881, -25139, -25394, -25645, -25890, -26131, -26368, -26599, -26827, -27050, -27268, -27483, -27692, -27897, -28098, -28294, -28485, -28673, -28856, -29034, -29208, -29378, -29543, -29704, -29861, -30013, -30162, -30305, -30444, -30580, -30711, -30837, -30960, -31078, -31192, -31302, -31408, -31509, -31607, -31700, -31789, -31875, -31956, -32033, -32107, -32176, -32241, -32303, -32360, -32414, -32464, -32509, -32552, -32590, -32624, -32655, -32682, -32705, -32725, -32741, -32753, -32761, -32766, -32768, -32766, -32760, -32751, -32738, -32723, -32703, -32680, -32654, -32624, -32591, -32554, -32515, -32472, -32426, -32377, -32324, -32269, -32210, -32148, -32083, -32015, -31944, -31870, -31792, -31712, -31630, -31544, -31455, -31362};