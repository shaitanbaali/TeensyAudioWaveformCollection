/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1385 256 samples */
 
const int16_t AKWF_1385_256_DATA [256] = 
{133, 535, 991, 1417, 1771, 2015, 2368, 2812, 2685, 2341, 2375, 2220, 2175, 2304, 2272, 1534, 1013, 390, -519, -632, 294, 1095, 2612, 5020, 6631, 8023, 8622, 9661, 10348, 9435, 9348, 8741, 8111, 7006, 6084, 4459, 3022, 1382, 392, -939, -213, 211, 889, 1305, 3082, 4406, 6833, 9391, 10567, 11552, 12485, 13304, 13418, 13408, 11029, 10157, 8041, 7686, 6790, 6081, 5970, 5850, 5783, 5554, 5494, 4539, 5601, 7246, 8167, 11624, 13137, 14971, 17258, 17762, 19513, 20600, 19870, 18349, 18647, 18058, 17420, 16321, 16112, 14595, 12474, 10358, 8752, 8464, 8480, 8398, 7151, 7761, 8522, 8379, 8414, 9093, 9901, 10862, 11232, 11865, 11858, 14279, -212, -12260, -11411, -10589, -8983, -7198, -5820, -3114, -2017, 1445, 5334, 8701, 12141, 15708, 18045, 19487, 22035, 23758, 25760, 27531, 28419, 28918, 28808, 27323, 25176, 22948, 19524, 16103, 12706, 9288, 6062, 3150, -32, -3256, -5018, -6141, -7959, -9231, -10625, -12248, -13467, -13189, -13300, -13174, -12485, -13266, -15927, -18225, -21288, -25138, -27538, -29456, -30314, -31577, -32387, -31448, -31248, -30418, -29411, -27850, -26334, -23986, -21671, -19078, -17086, -14745, -14502, -13880, -13484, -12857, -13228, -13265, -14046, -14943, -15037, -15086, -15146, -15202, -14839, -14389, -12636, -11681, -9976, -9251, -8203, -7287, -6741, -6182, -5717, -5166, -4759, -3996, -4147, -4541, -4675, -5730, -6092, -6546, -7154, -7124, -7516, -7662, -7267, -6701, -6609, -6286, -5949, -5516, -5209, -4671, -4038, -3422, -2902, -2604, -2362, -2131, -1799, -1704, -1637, -1525, -1470, -1478, -1527, -1592, -1657, -1735, -1825, -1911, -2004, -2083, -2145, -2208, -2243, -2235, -2154, -2113, -1915, -1849, -1796, -1709, -1661, -1696, -1567, -1308, -1290, -1119, -1149, -1243, -1248, -1290, -1300, -1009, -635, -545};