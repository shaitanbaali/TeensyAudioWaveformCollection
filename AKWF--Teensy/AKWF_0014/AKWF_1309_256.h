/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1309 256 samples */
 
const int16_t AKWF_1309_256_DATA [256] = 
{517, 1802, 2992, 4125, 5196, 6210, 7167, 8067, 8914, 9707, 10443, 11127, 11755, 12328, 12845, 13307, 13714, 14064, 14359, 14598, 14783, 14915, 14992, 15018, 14995, 14924, 14808, 14648, 14448, 14210, 13938, 13636, 13306, 12955, 12584, 12198, 11803, 11402, 10998, 10600, 10209, 9830, 9471, 9131, 8820, 8541, 8296, 8092, 7929, 7815, 7754, 7745, 7795, 7906, 8082, 8280, 8781, 8904, 7434, 7759, 7701, 7494, 7221, 6901, 6534, 6136, 5727, 5221, 4669, 4066, 3405, 2684, 1903, 1057, 151, -816, -1843, -2926, -4063, -5254, -6491, -7772, -9091, -10440, -11820, -13219, -14609, -16113, -17276, -11893, -15041, -15871, -15845, -15993, -16138, -16304, -16484, -16671, -16860, -17041, -17207, -17352, -17467, -17547, -17586, -17576, -17509, -17384, -17192, -16929, -16591, -16171, -15669, -15077, -14395, -13623, -12752, -11782, -10724, -9536, -8265, -11213, -10302, -9348, -9165, -8963, -8777, -8578, -8361, -8124, -7868, -7592, -7299, -6986, -6654, -6306, -5937, -5550, -5144, -4716, -4266, -3797, -3303, -2787, -2251, -1692, -1111, -511, 109, 749, 1402, 2072, 2754, 3443, 4142, 4843, 5544, 6244, 6935, 7615, 8284, 8932, 9558, 10159, 10729, 11265, 11764, 12222, 12634, 13000, 13312, 13572, 13772, 13914, 13994, 14010, 13958, 13839, 13650, 13389, 13058, 12652, 12173, 11621, 10995, 10295, 9524, 8680, 7765, 6780, 5731, 4617, 3437, 2202, 909, -437, -1828, -3268, -4751, -6263, -7811, -9386, -10976, -12585, -14204, -15819, -17437, -19043, -20630, -22197, -23735, -25233, -26692, -28101, -29430, -30830, -31714, -24801, -28118, -28596, -28016, -27623, -27211, -26807, -26410, -26014, -25614, -25205, -24786, -24349, -23891, -23414, -22913, -22388, -21841, -21270, -20677, -20065, -19433, -18789, -18135, -17472, -16808, -16150, -15500, -14866, -14247, -13664, -13203, -8560, -7088, -6579, -5116, -3646, -2195, -776};