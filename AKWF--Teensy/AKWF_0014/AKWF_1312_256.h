/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1312 256 samples */
 
const int16_t AKWF_1312_256_DATA [256] = 
{223, 572, 915, 1260, 1607, 1955, 2305, 2655, 3006, 3360, 3713, 4068, 4425, 4781, 5139, 5499, 5858, 6219, 6581, 6942, 7307, 7671, 8035, 8402, 8770, 9137, 9505, 9874, 10244, 10615, 10986, 11358, 11732, 12104, 12478, 12853, 13229, 13604, 13982, 14358, 14736, 15115, 15493, 15873, 16253, 16633, 17014, 17396, 17777, 18160, 18544, 18926, 19310, 19695, 20079, 20464, 20850, 21235, 21622, 22009, 22395, 22783, 23172, 23558, 23948, 24336, 24726, 25116, 25504, 25895, 26286, 26676, 27066, 27459, 27850, 28242, 28634, 29026, 29419, 29813, 30205, 30599, 30993, 31386, 31781, 32165, 32592, 32677, 31647, 30087, 28445, 26809, 25206, 23638, 22114, 20630, 19182, 17776, 16407, 15074, 13779, 12519, 11292, 10102, 8944, 7817, 6726, 5664, 4631, 3632, 2659, 1714, 801, -86, -946, -1779, -2588, -3371, -4128, -4863, -5572, -6257, -6922, -7562, -8182, -8781, -9358, -9914, -10451, -10967, -11464, -11944, -12403, -12845, -13270, -13677, -14067, -14441, -14797, -15139, -15465, -15774, -16070, -16351, -16617, -16870, -17109, -17333, -17546, -17745, -17931, -18106, -18268, -18418, -18557, -18685, -18800, -18905, -19000, -19084, -19158, -19223, -19276, -19320, -19355, -19382, -19399, -19407, -19407, -19397, -19380, -19355, -19322, -19282, -19232, -19176, -19113, -19042, -18964, -18881, -18789, -18692, -18588, -18477, -18361, -18238, -18110, -17976, -17836, -17691, -17540, -17384, -17222, -17056, -16884, -16708, -16528, -16343, -16151, -15957, -15758, -15555, -15347, -15135, -14919, -14700, -14476, -14248, -14017, -13782, -13543, -13303, -13057, -12808, -12557, -12302, -12043, -11782, -11518, -11250, -10981, -10708, -10433, -10154, -9872, -9590, -9304, -9015, -8724, -8430, -8135, -7837, -7536, -7235, -6931, -6623, -6315, -6004, -5691, -5376, -5061, -4743, -4422, -4100, -3776, -3451, -3124, -2795, -2465, -2134, -1800, -1465, -1129, -792, -454, -108};