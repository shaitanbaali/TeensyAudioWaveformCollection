/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1368 256 samples */
 
const int16_t AKWF_1368_256_DATA [256] = 
{25707, 32353, 30670, 30584, 30250, 29924, 29585, 29302, 28977, 28645, 28316, 27987, 27658, 27331, 27003, 26677, 26352, 26026, 25702, 25379, 25055, 24733, 24410, 24089, 23768, 23449, 23128, 22810, 22493, 22174, 21858, 21542, 21225, 20911, 20597, 20282, 19969, 19657, 19344, 19033, 18722, 18412, 18103, 17794, 17486, 17178, 16872, 16563, 16259, 15953, 15647, 15344, 15040, 14737, 14435, 14133, 13831, 13531, 13231, 12932, 12633, 12335, 12038, 11740, 11443, 11148, 10853, 10558, 10264, 9970, 9676, 9385, 9093, 8800, 8510, 8220, 7930, 7641, 7353, 7064, 6777, 6490, 6204, 5920, 5633, 5349, 5065, 4782, 4499, 4217, 3935, 3654, 3374, 3093, 2813, 2535, 2255, 1978, 1701, 1423, 1147, 871, 596, 322, 48, -225, -499, -771, -1044, -1314, -1585, -1857, -2126, -2395, -2664, -2932, -3200, -3468, -3735, -4001, -4266, -4531, -4796, -5060, -5324, -5586, -5849, -6111, -6373, -6633, -6895, -7155, -7414, -7673, -7932, -8189, -8447, -8704, -8960, -9217, -9472, -9728, -9982, -10237, -10490, -10743, -10995, -11246, -11499, -11750, -12000, -12250, -12500, -12749, -12998, -13245, -13493, -13741, -13988, -14233, -14480, -14724, -14969, -15213, -15457, -15701, -15944, -16185, -16428, -16669, -16909, -17149, -17390, -17630, -17869, -18108, -18345, -18583, -18821, -19057, -19294, -19530, -19764, -20000, -20234, -20467, -20701, -20934, -21166, -21399, -21630, -21861, -22093, -22324, -22553, -22783, -23012, -23240, -23469, -23695, -23923, -24150, -24376, -24602, -24827, -25053, -25277, -25502, -25725, -25948, -26172, -26392, -26609, -26841, -27054, -27276, -27215, -28897, -22492, 5867, 6775, 6136, 5956, 5673, 5387, 5110, 4872, 4585, 4304, 4022, 3739, 3458, 3179, 2898, 2620, 2341, 2062, 1786, 1508, 1231, 956, 680, 405, 131, -143, -416, -688, -960, -1233, -1495, -1775, -2046, -2312, -2613, -2721, -3649};