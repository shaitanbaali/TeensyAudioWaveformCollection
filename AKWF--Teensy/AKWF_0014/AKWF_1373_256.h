/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1373 256 samples */
 
const int16_t AKWF_1373_256_DATA [256] = 
{29983, 31076, 30260, 29822, 29334, 28846, 28362, 27949, 27456, 26971, 26485, 25999, 25515, 25031, 24550, 24068, 23589, 23109, 22630, 22154, 21677, 21201, 20727, 20253, 19780, 19308, 18837, 18367, 17900, 17431, 16963, 16497, 16030, 15568, 15104, 14641, 14180, 13718, 13257, 12800, 12341, 11883, 11429, 10973, 10518, 10065, 9611, 9159, 8709, 8258, 7809, 7360, 6912, 6466, 6022, 5575, 5132, 4688, 4246, 3804, 3365, 2923, 2485, 2048, 1610, 1174, 738, 304, -128, -561, -994, -1425, -1855, -2285, -2713, -3142, -3568, -3995, -4419, -4844, -5267, -5692, -6113, -6534, -6955, -7373, -7792, -8211, -8627, -9043, -9460, -9872, -10287, -10700, -11112, -11524, -11934, -12344, -12753, -13161, -13567, -13976, -14382, -14785, -15190, -15595, -15996, -16398, -16799, -17198, -17598, -17999, -18396, -18793, -19189, -19584, -19979, -20374, -20767, -21159, -21551, -21941, -22333, -22722, -23109, -23498, -23886, -24270, -24657, -25041, -25425, -25810, -26193, -26563, -26954, -27337, -27714, -28077, -27816, -31883, 4528, 29096, 24476, 24762, 24266, 23796, 23304, 22886, 22438, 21956, 21482, 21005, 20531, 20058, 19585, 19113, 18643, 18174, 17705, 17239, 16771, 16304, 15840, 15374, 14911, 14449, 13988, 13527, 13068, 12608, 12151, 11696, 11238, 10784, 10329, 9876, 9424, 8971, 8520, 8071, 7621, 7174, 6728, 6281, 5836, 5390, 4947, 4505, 4063, 3620, 3180, 2740, 2302, 1865, 1429, 992, 556, 122, -309, -741, -1174, -1604, -2034, -2464, -2892, -3319, -3747, -4173, -4595, -5020, -5445, -5867, -6289, -6711, -7128, -7549, -7967, -8385, -8801, -9217, -9633, -10048, -10461, -10871, -11285, -11695, -12106, -12517, -12925, -13332, -13741, -14145, -14549, -14955, -15359, -15762, -16166, -16567, -16968, -17367, -17767, -18166, -18563, -18959, -19355, -19751, -20145, -20539, -20931, -21311, -21722, -22105, -22493, -22791, -23710, -21633};