/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1326 256 samples */
 
const int16_t AKWF_1326_256_DATA [256] = 
{32539, 32733, 32697, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32703, 32582, 33172, 31010, 4680, 2408, 3018, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2894, 2770, 3371, 1551, -30651, -33353, -32624, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32236, -35153, -20888, 5745, 2741, 3289, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3290, 3488, 2410, 6877, 31613, 31853, 31710, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31763, 31118, 34650, 3755, -12944, -9541, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10161, -10162, -10482, -8744, -17736, -31274, -29458, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793, -29793};