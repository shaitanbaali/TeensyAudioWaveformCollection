/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1370 256 samples */
 
const int16_t AKWF_1370_256_DATA [256] = 
{27472, 30805, 29617, 29338, 28923, 28513, 28099, 27750, 27337, 26925, 26515, 26103, 25694, 25287, 24878, 24471, 24067, 23662, 23257, 22854, 22450, 22048, 21648, 21247, 20847, 20449, 20050, 19652, 19257, 18861, 18466, 18072, 17679, 17286, 16896, 16504, 16114, 15724, 15334, 14948, 14559, 14173, 13788, 13403, 13019, 12636, 12253, 11869, 11490, 11109, 10726, 10349, 9971, 9593, 9217, 8840, 8465, 8091, 7716, 7343, 6972, 6599, 6228, 5858, 5488, 5120, 4752, 4384, 4018, 3653, 3288, 2923, 2559, 2195, 1834, 1471, 1110, 751, 391, 32, -325, -683, -1040, -1395, -1751, -2105, -2459, -2813, -3166, -3516, -3868, -4218, -4567, -4917, -5266, -5613, -5962, -6307, -6653, -6998, -7342, -7685, -8029, -8370, -8712, -9054, -9394, -9734, -10073, -10410, -10749, -11086, -11423, -11757, -12092, -12428, -12761, -13096, -13426, -13759, -14090, -14420, -14750, -15079, -15406, -15735, -16063, -16388, -16715, -17040, -17365, -17689, -18012, -18336, -18657, -18978, -19299, -19620, -19940, -20260, -20578, -20895, -21212, -21529, -21844, -22161, -22474, -22789, -23103, -23416, -23727, -24040, -24351, -24661, -24970, -25279, -25588, -25898, -26198, -26504, -26820, -27118, -27429, -27126, -30692, -13044, 19112, 16296, 16300, 15941, 15556, 15161, 14800, 14461, 14067, 13683, 13299, 12914, 12530, 12148, 11766, 11386, 11007, 10626, 10247, 9870, 9491, 9115, 8740, 8364, 7990, 7616, 7243, 6870, 6500, 6128, 5759, 5390, 5021, 4653, 4286, 3919, 3554, 3189, 2825, 2461, 2097, 1736, 1374, 1014, 654, 295, -64, -422, -777, -1135, -1491, -1846, -2199, -2553, -2907, -3260, -3611, -3962, -4312, -4661, -5010, -5360, -5706, -6053, -6400, -6745, -7089, -7434, -7776, -8120, -8462, -8803, -9144, -9486, -9824, -10164, -10502, -10839, -11176, -11512, -11847, -12182, -12515, -12839, -13189, -13513, -13843, -14059, -15042, -12313};