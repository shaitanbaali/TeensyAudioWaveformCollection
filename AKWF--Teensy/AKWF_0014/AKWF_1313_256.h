/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1313 256 samples */
 
const int16_t AKWF_1313_256_DATA [256] = 
{300, 1055, 1785, 2508, 3219, 3920, 4611, 5288, 5954, 6609, 7250, 7879, 8498, 9102, 9695, 10277, 10847, 11405, 11951, 12486, 13012, 13526, 14028, 14522, 15004, 15476, 15940, 16393, 16836, 17271, 17696, 18112, 18521, 18920, 19311, 19695, 20069, 20436, 20796, 21147, 21492, 21830, 22160, 22483, 22800, 23110, 23413, 23711, 24001, 24286, 24566, 24838, 25106, 25368, 25624, 25875, 26121, 26361, 26597, 26828, 27053, 27274, 27491, 27702, 27910, 28114, 28312, 28507, 28698, 28884, 29068, 29247, 29420, 29588, 29766, 29421, 28327, 27031, 25703, 24384, 23092, 21822, 20578, 19363, 18171, 17004, 15864, 14744, 13649, 12578, 11528, 10500, 9495, 8508, 7544, 6600, 5675, 4774, 3881, 3058, 2941, 3455, 4109, 4791, 5473, 6145, 6802, 7447, 8078, 8694, 9300, 9893, 10471, 11040, 11597, 12139, 12673, 13195, 13705, 14205, 14695, 15174, 15645, 16104, 16553, 16995, 17426, 17848, 18262, 18667, 19063, 19451, 19831, 20202, 20568, 20924, 21274, 21616, 21950, 22278, 22599, 22913, 23221, 23523, 23818, 24106, 24389, 24665, 24937, 25202, 25461, 25716, 25966, 26209, 26448, 26682, 26910, 27135, 27354, 27569, 27780, 27985, 28186, 28384, 28577, 28767, 28953, 29134, 29311, 29485, 29655, 29822, 29986, 30145, 30301, 30455, 30605, 30752, 30896, 31036, 31174, 31309, 31441, 31571, 31698, 31821, 31943, 32061, 32178, 32292, 32403, 32513, 32613, 32738, 32672, 31807, 30498, 29119, 27734, 26373, 25035, 23724, 22443, 21187, 19956, 18754, 17575, 16419, 15291, 14184, 13100, 12041, 11002, 9985, 8990, 8014, 7061, 6127, 5212, 4316, 3440, 2580, 1740, 918, 111, -677, -1449, -2206, -2946, -3671, -4381, -5076, -5756, -6424, -7075, -7713, -8340, -8932, -9378, -9603, -9623, -9469, -9172, -8764, -8262, -7690, -7063, -6391, -5688, -4963, -4220, -3467, -2709, -1950, -1193, -426};