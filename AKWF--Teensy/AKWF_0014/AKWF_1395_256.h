/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1395 256 samples */
 
const int16_t AKWF_1395_256_DATA [256] = 
{329, 1041, 1715, 2147, 2426, 2649, 2905, 3284, 3865, 4659, 5620, 6690, 7805, 8902, 9918, 10783, 11447, 11923, 12221, 12326, 12308, 12203, 11988, 11711, 11430, 11182, 11007, 10926, 10939, 11068, 11568, 12245, 12798, 13326, 13937, 14798, 15892, 17083, 18403, 19757, 21059, 22261, 23316, 24219, 24999, 25653, 26170, 26539, 26755, 26828, 26813, 26785, 26745, 26640, 26442, 26211, 26045, 25887, 25681, 25450, 25220, 25037, 24976, 25076, 25340, 25756, 26282, 26848, 27365, 27806, 28188, 28505, 28751, 28919, 29014, 29050, 29037, 28981, 28884, 28737, 28536, 28271, 27934, 27520, 27021, 26430, 25727, 24875, 23867, 22662, 21209, 19441, 17172, 14508, 11651, 8375, 4921, 1752, -1242, -3929, -6281, -8423, -10402, -12256, -14001, -15640, -17174, -18592, -19871, -20998, -21996, -22885, -23694, -24454, -25176, -25876, -26707, -27743, -28845, -29834, -30616, -31238, -31760, -32202, -32541, -32738, -32745, -32528, -32069, -31377, -30705, -30281, -30032, -29896, -29830, -29721, -29462, -29009, -28372, -27582, -26708, -25823, -24987, -24262, -23692, -23264, -22984, -22873, -22862, -22914, -23047, -23213, -23359, -23454, -23463, -23359, -23142, -22783, -22027, -21068, -20207, -19403, -18645, -17753, -16717, -15637, -14448, -13220, -12030, -10905, -9874, -8918, -7992, -7079, -6180, -5306, -4471, -3674, -2877, -2024, -1133, -281, 481, 1204, 1968, 2704, 3347, 3912, 4417, 4901, 5439, 6081, 6831, 7674, 8570, 9439, 10192, 10825, 11382, 11849, 12205, 12446, 12590, 12659, 12673, 12650, 12601, 12527, 12434, 12330, 12218, 12101, 11977, 11846, 11698, 11526, 11325, 11131, 11037, 10819, 10327, 9510, 8359, 6654, 4692, 2984, 1447, 207, -681, -1340, -1850, -2262, -2547, -2693, -2720, -2631, -2422, -2106, -1704, -1248, -779, -329, 75, 412, 537, 371, 58, -224, -387, -475, -547, -619, -665, -637, -490, -161};