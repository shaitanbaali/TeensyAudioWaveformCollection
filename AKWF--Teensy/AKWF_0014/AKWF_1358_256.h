/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1358 256 samples */
 
const int16_t AKWF_1358_256_DATA [256] = 
{4210, 12262, 15782, 18896, 21434, 23595, 25456, 27051, 28415, 29568, 30519, 31288, 31883, 32316, 32599, 32743, 32760, 32660, 32456, 32157, 31773, 31317, 30796, 30218, 29593, 28927, 28226, 27497, 26745, 25972, 25186, 24388, 23581, 22769, 21954, 21135, 20318, 19503, 18687, 17879, 17073, 16271, 15477, 14687, 13902, 13126, 12355, 11591, 10835, 10085, 9341, 8606, 7875, 7151, 6436, 5724, 5020, 4323, 3630, 2944, 2264, 1589, 920, 256, -402, -1055, -1703, -2348, -2986, -3620, -4251, -4875, -5496, -6113, -6725, -7332, -7937, -8535, -9131, -9722, -10308, -10892, -11471, -12044, -12614, -13181, -13742, -14299, -14852, -15399, -15944, -16482, -17015, -17544, -18067, -18585, -19098, -19604, -20105, -20601, -21089, -21571, -22047, -22515, -22977, -23431, -23877, -24315, -24747, -25168, -25581, -25986, -26381, -26766, -27142, -27508, -27863, -28209, -28542, -28865, -29176, -29476, -29764, -30039, -30303, -30554, -30792, -31016, -31228, -31427, -31612, -31784, -31942, -32086, -32217, -32333, -32436, -32525, -32599, -32660, -32708, -32741, -32762, -32768, -32761, -32741, -32708, -32662, -32603, -32532, -32449, -32353, -32246, -32127, -31997, -31857, -31706, -31544, -31372, -31191, -31000, -30799, -30591, -30373, -30148, -29914, -29673, -29425, -29170, -28908, -28640, -28366, -28086, -27801, -27510, -27214, -26914, -26609, -26299, -25987, -25670, -25349, -25026, -24699, -24370, -24038, -23702, -23365, -23027, -22685, -22342, -21997, -21651, -21303, -20954, -20604, -20253, -19901, -19548, -19195, -18840, -18485, -18130, -17775, -17419, -17063, -16707, -16351, -15996, -15639, -15283, -14928, -14572, -14216, -13862, -13507, -13153, -12800, -12446, -12093, -11741, -11389, -11038, -10687, -10336, -9987, -9638, -9290, -8942, -8595, -8248, -7903, -7558, -7213, -6869, -6526, -6184, -5842, -5501, -5160, -4821, -4482, -4143, -3807, -3469, -3133, -2798, -2463, -2128, -1795, -1462, -1130, -799, -468, -139, 196};