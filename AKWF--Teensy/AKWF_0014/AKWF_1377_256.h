/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1377 256 samples */
 
const int16_t AKWF_1377_256_DATA [256] = 
{47, 110, 171, 233, 295, 361, 432, 403, 3031, 4112, 3965, 4056, 4109, 4163, 4215, 4271, 4325, 4377, 4426, 4490, 4488, 4230, 4277, 4330, 4380, 4430, 4480, 4530, 4579, 4628, 4677, 4727, 4775, 4823, 4871, 4920, 4967, 5014, 5062, 5109, 5155, 5203, 5249, 5294, 5341, 5386, 5432, 5477, 5522, 5567, 5611, 5656, 5700, 5744, 5787, 5830, 5874, 5917, 5959, 6002, 6044, 6086, 6128, 6169, 6211, 6252, 6293, 6334, 6374, 6415, 6455, 6494, 6465, 6491, 6534, 6571, 6610, 6649, 6688, 6725, 6763, 6801, 6838, 6875, 6912, 6949, 6986, 7022, 7058, 7095, 7130, 7167, 7202, 7235, 7271, 7304, 7640, 6306, 15642, 13687, 25264, 28375, 27842, 26267, 24262, 22149, 20064, 18052, 16149, 14370, 12706, 11155, 9718, 8377, 7131, 5976, 4897, 3894, 2962, 2090, 1277, 521, -185, -853, -1188, -1693, -2248, -2750, -3222, -3662, -4075, -4462, -4822, -5159, -5475, -5770, -6046, -6304, -6543, -6768, -6976, -7171, -7351, -7519, -7674, -7818, -7952, -8075, -8188, -8292, -8387, -8474, -8553, -8624, -8688, -8745, -8795, -8840, -8880, -8913, -8940, -8963, -8982, -8996, -9005, -9010, -9011, -9008, -9002, -8992, -8979, -8964, -8944, -8922, -8900, -8854, -8813, -8783, -8748, -8712, -8673, -8632, -8591, -8547, -8501, -8454, -8405, -8355, -8304, -8250, -8196, -8141, -8084, -8026, -7968, -7909, -7848, -7787, -7724, -7661, -7597, -7533, -7467, -7402, -7335, -7269, -7201, -7132, -7064, -6995, -6925, -6856, -6786, -6716, -6645, -6574, -6502, -6431, -6359, -6287, -6215, -6142, -6070, -5998, -5924, -5848, -6035, -6019, -5933, -5863, -5789, -5715, -5642, -5570, -5495, -5422, -5306, -5464, -4257, -991, -982, -917, -845, -780, -717, -651, -583, -518, -455, -391, -328, -266, -202, -139, -76, -14};