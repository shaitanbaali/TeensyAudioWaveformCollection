/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1376 256 samples */
 
const int16_t AKWF_1376_256_DATA [256] = 
{6026, 3297, 5050, 7874, 10213, 12223, 13852, 15167, 16272, 17236, 18100, 18830, 19384, 19761, 19976, 20075, 20153, 20274, 20446, 20658, 20837, 20922, 20894, 20800, 20728, 20718, 20786, 20932, 21149, 21424, 21747, 22096, 22458, 22802, 23106, 23347, 23511, 23586, 23567, 23453, 23246, 22956, 22595, 22165, 21683, 21151, 20566, 19934, 19245, 18483, 17633, 16686, 15621, 14438, 13143, 11742, 10263, 8760, 7328, 6015, 4831, 3772, 2833, 1997, 1248, 614, 121, -245, -514, -724, -902, -1060, -1202, -1324, -1430, -1514, -1576, -1613, -1627, -1626, -1621, -1619, -1644, -1720, -1857, -2068, -2349, -2684, -3043, -3398, -3711, -3962, -4124, -4180, -4135, -3988, -3755, -3462, -3133, -2794, -2461, -2143, -1835, -1523, -1184, -797, -343, 193, 812, 1515, 2295, 3130, 3994, 4860, 5691, 6446, 7115, 7687, 8171, 8593, 8975, 9351, 9744, 10177, 10663, 11209, 11808, 12454, 13129, 13775, 14326, 14760, 15067, 15245, 15293, 15228, 15076, 14856, 14680, 14005, 16135, 20001, 19533, 19484, 19398, 19295, 19151, 18952, 18672, 18299, 17844, 17314, 16722, 16099, 15464, 14845, 14268, 13741, 13262, 12819, 12391, 11963, 11499, 10998, 10370, 9905, 13099, 13221, 12251, 11509, 10756, 10053, 9406, 8825, 8282, 7760, 7235, 6673, 6052, 5388, 4668, 3891, 3064, 2184, 1280, 384, -485, -1306, -2071, -2775, -3417, -4012, -4587, -5179, -5823, -6540, -7345, -8238, -9210, -10249, -11350, -12426, -13421, -14320, -15103, -15771, -16341, -16829, -17274, -17704, -18137, -18584, -19047, -19529, -20029, -20537, -21040, -21510, -21927, -22266, -22523, -22706, -22823, -22881, -22888, -22844, -22792, -22901, -23326, -24188, -25452, -26969, -28540, -29958, -31100, -31929, -32443, -32704, -32766, -32613, -32169, -31390, -30295, -28981, -27541, -26033, -24422, -22645, -20644, -18359, -15794, -13050, -10240, -7429, -4589, -1931};