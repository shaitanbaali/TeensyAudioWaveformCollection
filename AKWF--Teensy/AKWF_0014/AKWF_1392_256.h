/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1392 256 samples */
 
const int16_t AKWF_1392_256_DATA [256] = 
{2113, 6039, 9768, 13349, 16715, 19832, 22663, 25193, 27313, 28753, 29688, 30258, 31389, 32379, 32650, 32763, 32748, 32637, 32414, 32041, 31419, 30090, 27456, 23638, 19941, 16673, 13791, 11318, 9201, 7379, 5817, 4477, 3315, 2310, 1426, 649, -20, -587, -1025, -1334, -1537, -1636, -1610, -1440, -1108, -640, -104, 432, 925, 1354, 1664, 2029, 3186, 4313, 3136, 457, -2138, -4295, -5862, -6851, -7344, -7435, -7194, -6701, -6045, -5299, -4517, -3751, -3033, -2375, -1769, -1259, -876, -647, -588, -723, -1043, -1528, -2157, -2924, -3848, -4939, -6177, -7503, -9063, -11751, -10284, -7854, -6319, -5138, -4361, -3929, -3798, -3929, -4317, -4932, -5714, -6619, -7603, -8632, -9671, -10701, -11727, -12731, -13725, -14733, -15770, -16849, -17984, -19164, -20365, -21527, -22567, -23420, -24043, -24408, -24229, -26074, -28375, -27758, -25938, -22887, -19255, -15327, -11310, -7313, -3432, 284, 3847, 7264, 10556, 13724, 16743, 19595, 22223, 24598, 26673, 28171, 29116, 29708, 30038, 30151, 30070, 29780, 29261, 28482, 27394, 25939, 24289, 20943, 15190, 11465, 9254, 8086, 7680, 7808, 8246, 8851, 9534, 10235, 10918, 11568, 12179, 12757, 13292, 13756, 14130, 14394, 14541, 14565, 14467, 14251, 13935, 13519, 12989, 12330, 11541, 10633, 9598, 8595, 8261, 7908, 5482, 1589, -2124, -5241, -7635, -9324, -10416, -11037, -11283, -11248, -11021, -10663, -10227, -9746, -9246, -8742, -8234, -7767, -7385, -7114, -6973, -6997, -7188, -7538, -8043, -8703, -9517, -10476, -11557, -12711, -13874, -17243, -15262, -10946, -8411, -6522, -5358, -4790, -4716, -5041, -5698, -6634, -7772, -9043, -10363, -11665, -12905, -14083, -15220, -16298, -17334, -18349, -19351, -20338, -21315, -22267, -23171, -23978, -24617, -25069, -25035, -26531, -28591, -29348, -29745, -29038, -27427, -24622, -21202, -17509, -13643, -9696, -5734, -1706};