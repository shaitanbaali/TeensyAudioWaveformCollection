/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1355 256 samples */
 
const int16_t AKWF_1355_256_DATA [256] = 
{5103, 14577, 18305, 21448, 23846, 25772, 27344, 28628, 29681, 30539, 31225, 31764, 32174, 32467, 32656, 32752, 32763, 32696, 32560, 32359, 32099, 31784, 31421, 31010, 30557, 30066, 29538, 28978, 28387, 27766, 27121, 26452, 25760, 25049, 24320, 23572, 22811, 22036, 21247, 20450, 19640, 18821, 17997, 17165, 16326, 15485, 14638, 13787, 12937, 12083, 11227, 10374, 9519, 8666, 7816, 6966, 6120, 5278, 4438, 3603, 2773, 1947, 1128, 315, -493, -1294, -2087, -2875, -3654, -4426, -5190, -5945, -6692, -7431, -8159, -8880, -9592, -10292, -10985, -11667, -12338, -13000, -13652, -14292, -14924, -15544, -16153, -16752, -17340, -17916, -18483, -19038, -19582, -20115, -20636, -21147, -21646, -22134, -22610, -23076, -23529, -23972, -24404, -24823, -25232, -25630, -26015, -26390, -26754, -27106, -27447, -27777, -28095, -28403, -28700, -28986, -29261, -29525, -29777, -30020, -30251, -30472, -30682, -30882, -31071, -31249, -31417, -31575, -31723, -31861, -31988, -32106, -32213, -32311, -32399, -32478, -32547, -32606, -32656, -32697, -32728, -32750, -32764, -32768, -32763, -32750, -32728, -32698, -32658, -32611, -32555, -32491, -32419, -32339, -32251, -32156, -32052, -31941, -31822, -31697, -31564, -31423, -31275, -31120, -30959, -30791, -30616, -30434, -30247, -30052, -29851, -29644, -29431, -29212, -28988, -28756, -28520, -28278, -28031, -27778, -27520, -27256, -26988, -26714, -26436, -26153, -25865, -25573, -25276, -24974, -24668, -24359, -24045, -23727, -23405, -23079, -22750, -22417, -22079, -21740, -21396, -21049, -20700, -20346, -19989, -19631, -19269, -18904, -18538, -18167, -17794, -17420, -17043, -16664, -16283, -15899, -15514, -15127, -14737, -14347, -13955, -13560, -13165, -12769, -12370, -11971, -11570, -11168, -10766, -10362, -9957, -9552, -9146, -8739, -8332, -7924, -7515, -7107, -6698, -6289, -5880, -5470, -5061, -4652, -4242, -3833, -3425, -3016, -2607, -2200, -1792, -1385, -979, -574, -170, 240};