/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1352 256 samples */
 
const int16_t AKWF_1352_256_DATA [256] = 
{0, 5, 17, 37, 63, 97, 137, 184, 238, 299, 366, 440, 520, 607, 700, 800, 905, 1017, 1133, 1256, 1385, 1519, 1658, 1802, 1952, 2105, 2264, 2426, 2594, 2764, 2938, 3117, 3298, 3483, 3669, 3859, 4051, 4245, 4441, 4638, 4836, 5036, 5236, 5436, 5637, 5836, 6036, 6235, 6432, 6629, 6822, 7014, 7204, 7390, 7574, 7754, 7930, 8102, 8269, 8431, 8588, 8740, 8886, 9025, 9158, 9283, 9402, 9513, 9616, 9710, 9796, 9872, 9939, 9997, 10044, 10081, 10108, 10123, 10127, 10120, 10101, 10070, 10026, 9969, 9899, 9817, 9722, 9612, 9489, 9352, 9200, 9034, 8854, 8659, 8450, 8225, 7986, 7732, 7463, 7178, 6879, 6564, 6235, 5891, 5532, 5157, 4769, 4367, 3949, 3519, 3073, 2614, 2143, 1658, 1160, 652, 130, -402, -945, -1499, -2063, -2635, -3217, -3807, -4404, -5008, -5617, -6232, -6853, -7475, -8100, -8729, -9357, -9986, -10614, -11239, -11862, -12482, -13095, -13702, -14303, -14893, -15476, -16047, -16605, -17151, -17682, -18195, -18693, -19173, -19632, -20070, -20486, -20878, -21246, -21587, -21900, -22185, -22440, -22663, -22854, -23010, -23133, -23219, -23268, -23279, -23250, -23182, -23072, -22921, -22727, -22489, -22208, -21882, -21511, -21094, -20632, -20123, -19569, -18969, -18321, -17629, -16891, -16107, -15279, -14408, -13492, -12536, -11539, -10499, -9424, -8312, -7162, -5982, -4769, -3525, -2257, -963, 355, 1688, 3041, 4408, 5783, 7167, 8556, 9941, 11326, 12704, 14067, 15419, 16751, 18057, 19339, 20588, 21799, 22972, 24099, 25176, 26201, 27166, 28068, 28905, 29670, 30360, 30971, 31499, 31939, 32291, 32548, 32707, 32767, 32726, 32578, 32324, 31962, 31490, 30905, 30211, 29403, 28483, 27454, 26312, 25062, 23708, 22246, 20684, 19028, 17274, 15433, 13512, 11507, 9433, 7297, 5102, 2863, 535};