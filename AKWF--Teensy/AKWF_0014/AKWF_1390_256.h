/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1390 256 samples */
 
const int16_t AKWF_1390_256_DATA [256] = 
{873, 3281, 5560, 7860, 10157, 12476, 14807, 17125, 19453, 21792, 24144, 26428, 28211, 29470, 30375, 31017, 31469, 31792, 32026, 32193, 32321, 32419, 32498, 32559, 32607, 32644, 32673, 32695, 32712, 32725, 32735, 32742, 32748, 32753, 32756, 32759, 32760, 32762, 32763, 32763, 32764, 32765, 32766, 32765, 32766, 32767, 32766, 32767, 32767, 32767, 32766, 32767, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32767, 32766, 32767, 32766, 32765, 32765, 32766, 32765, 32763, 32764, 32763, 32762, 32762, 32760, 32758, 32757, 32755, 32752, 32749, 32746, 32741, 32736, 32730, 32721, 32712, 32700, 32683, 32661, 32631, 32589, 32533, 32462, 32365, 32237, 32065, 31842, 31548, 31154, 30630, 29952, 29069, 27923, 26428, 24576, 22634, 20617, 18417, 15977, 13264, 10324, 7185, 4042, 962, -1912, -4670, -7241, -9664, -11968, -14221, -16471, -18730, -20999, -23266, -25545, -27507, -28920, -29955, -30717, -31279, -31696, -32001, -32220, -32375, -32483, -32557, -32610, -32647, -32675, -32696, -32712, -32724, -32734, -32741, -32747, -32751, -32754, -32758, -32759, -32761, -32762, -32763, -32764, -32765, -32765, -32766, -32767, -32766, -32766, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32767, -32766, -32767, -32766, -32766, -32767, -32766, -32765, -32765, -32766, -32764, -32763, -32763, -32762, -32759, -32758, -32755, -32752, -32747, -32742, -32734, -32726, -32714, -32698, -32679, -32654, -32624, -32587, -32543, -32488, -32417, -32319, -32186, -32003, -31749, -31398, -30921, -30264, -29366, -28150, -26463, -24311, -22075, -19834, -17580, -15317, -13034, -10733, -8413, -6050, -3742, -1338};