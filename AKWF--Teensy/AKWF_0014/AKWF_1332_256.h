/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1332 256 samples */
 
const int16_t AKWF_1332_256_DATA [256] = 
{30358, 28263, 28654, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28581, 28431, 29243, 25483, 13782, 13905, 13921, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13892, 13823, 14185, 12785, -823, -1384, -1178, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1222, -1376, -549, -4381, -16306, -16180, -16164, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16193, -16184, -16236, -15959};