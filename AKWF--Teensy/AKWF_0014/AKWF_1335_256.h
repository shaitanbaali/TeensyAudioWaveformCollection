/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1335 256 samples */
 
const int16_t AKWF_1335_256_DATA [256] = 
{32382, 32047, 32109, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32097, 32061, 31774, 33793, -14362, -28266, -25119, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25679, -25590, -26081, -22706, -18893, -19335, -19257, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19255, -19339, -18889, -21306};