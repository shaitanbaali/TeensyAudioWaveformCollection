/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1381 256 samples */
 
const int16_t AKWF_1381_256_DATA [256] = 
{2492, 5946, 9043, 11823, 14238, 16261, 17872, 19054, 19809, 20143, 20068, 19605, 18782, 17636, 16198, 14514, 12633, 10593, 8445, 6241, 4016, 1822, -297, -2313, -4186, -5884, -7390, -8676, -9731, -10547, -11118, -11443, -11532, -11390, -11035, -10480, -9750, -8865, -7848, -6730, -5534, -4286, -3018, -1751, -510, 678, 1798, 2829, 3753, 4561, 5240, 5784, 6191, 6457, 6583, 6576, 6441, 6187, 5824, 5366, 4826, 4217, 3556, 2858, 2137, 1410, 690, -9, -672, -1291, -1856, -2356, -2787, -3143, -3420, -3618, -3735, -3773, -3737, -3629, -3457, -3225, -2941, -2614, -2252, -1863, -1457, -1042, -627, -220, 171, 541, 882, 1190, 1459, 1687, 1871, 2011, 2103, 2151, 2154, 2115, 2036, 1922, 1776, 1603, 1406, 1192, 965, 731, 492, 256, 26, -192, -397, -584, -751, -895, -1014, -1109, -1177, -1218, -1234, -1226, -1194, -1140, -1067, -975, -870, -753, -627, -494, -359, -224, -89, 39, 161, 274, 377, 465, 542, 604, 651, 684, 702, 705, 694, 669, 634, 588, 532, 469, 399, 325, 248, 170, 93, 18, -54, -121, -183, -239, -287, -327, -359, -382, -398, -404, -401, -393, -376, -353, -323, -290, -252, -211, -167, -123, -79, -34, 7, 46, 84, 118, 148, 174, 195, 211, 221, 228, 230, 226, 220, 208, 194, 176, 155, 133, 109, 84, 59, 34, 9, -14, -37, -57, -75, -92, -106, -116, -125, -129, -132, -132, -129, -124, -116, -107, -96, -84, -70, -57, -42, -27, -12, 0, 13, 25, 37, 46, 55, 62, 68, 72, 73, 74, 73, 72, 68, 63, 58, 51, 44, -344, 1804, -8017, -33436, -29107, -26697, -23555, -20093, -16413, -12594, -8712, -4856, -1025};