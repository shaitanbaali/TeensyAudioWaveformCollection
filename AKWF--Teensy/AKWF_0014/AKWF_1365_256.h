/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1365 256 samples */
 
const int16_t AKWF_1365_256_DATA [256] = 
{45, 366, 862, 1460, 2138, 2881, 3674, 4505, 5371, 6263, 7173, 8101, 9040, 9983, 10933, 11883, 12829, 13772, 14708, 15633, 16549, 17451, 18335, 19207, 20059, 20891, 21705, 22496, 23264, 24010, 24730, 25423, 26093, 26733, 27347, 27934, 28490, 29018, 29517, 29983, 30421, 30827, 31201, 31545, 31857, 32136, 32378, 32614, 32694, 32220, 31682, 31147, 30600, 30041, 29476, 28902, 28321, 27733, 27137, 26536, 25929, 25315, 24698, 24075, 23447, 22817, 22182, 21542, 20902, 20258, 19610, 18961, 18311, 17658, 17004, 16348, 15691, 15035, 14377, 13719, 13062, 12403, 11745, 11089, 10431, 9776, 9122, 8468, 7816, 7167, 6517, 5869, 5226, 4582, 3941, 3303, 2666, 2033, 1403, 775, 152, -467, -1077, -1674, -2260, -2837, -3400, -3953, -4496, -5025, -5544, -6053, -6548, -7033, -7508, -7969, -8421, -8862, -9290, -9708, -10115, -10511, -10896, -11270, -11632, -11984, -12325, -12656, -12976, -13285, -13583, -13872, -14149, -14416, -14674, -14920, -15157, -15384, -15601, -15808, -16005, -16193, -16370, -16538, -16697, -16847, -16988, -17119, -17241, -17354, -17458, -17554, -17641, -17720, -17790, -17851, -17905, -17950, -17987, -18016, -18038, -18051, -18058, -18056, -18047, -18032, -18009, -17979, -17941, -17897, -17846, -17789, -17725, -17655, -17578, -17496, -17407, -17312, -17212, -17105, -16993, -16875, -16753, -16625, -16491, -16353, -16209, -16061, -15908, -15751, -15588, -15422, -15251, -15076, -14896, -14713, -14526, -14335, -14141, -13943, -13741, -13536, -13328, -13117, -12903, -12685, -12465, -12242, -12017, -11789, -11558, -11326, -11091, -10854, -10615, -10374, -10131, -9887, -9640, -9392, -9143, -8892, -8640, -8387, -8133, -7878, -7621, -7364, -7106, -6849, -6589, -6330, -6071, -5810, -5550, -5289, -5029, -4769, -4509, -4248, -3989, -3729, -3470, -3211, -2953, -2696, -2439, -2183, -1928, -1675, -1422, -1170, -920, -670, -423, -172};