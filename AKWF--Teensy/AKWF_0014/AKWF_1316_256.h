/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1316 256 samples */
 
const int16_t AKWF_1316_256_DATA [256] = 
{23290, 22923, 22564, 22202, 21839, 21475, 21110, 20746, 20381, 20013, 19646, 19278, 18910, 18543, 18173, 17806, 17437, 17068, 16699, 16330, 15961, 15592, 15224, 14855, 14486, 14117, 13747, 13380, 13012, 12643, 12274, 11907, 11538, 11171, 10804, 10435, 10068, 9701, 9334, 8633, 10088, -3916, -12574, -10275, -10092, -9578, -9063, -8547, -8034, -7518, -7002, -6487, -5973, -5457, -4943, -4427, -3827, -3775, -278, 2078, 1222, 950, 589, 209, -8, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -4, 10, -300, -843, -1359, -1880, -2399, -2919, -3440, -3960, -4478, -4998, -5518, -6036, -6554, -7071, -7590, -8108, -8624, -9143, -9659, -10174, -10691, -11207, -11722, -12238, -12753, -13267, -13783, -14296, -14810, -15325, -15837, -16350, -16864, -17376, -17887, -18400, -18912, -19423, -19935, -20445, -20956, -21466, -21975, -22486, -22995, -23504, -24013, -24523, -25029, -25539, -26046, -26554, -27060, -27568, -28074, -28581, -29089, -29593, -30100, -30605, -31110, -31614, -32117, -32630};