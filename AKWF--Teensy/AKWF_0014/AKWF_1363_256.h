/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1363 256 samples */
 
const int16_t AKWF_1363_256_DATA [256] = 
{803, 2308, 3822, 5369, 6935, 8525, 10127, 11721, 13317, 14899, 16456, 17990, 19481, 20932, 22326, 23668, 24931, 26131, 27242, 28268, 29199, 30035, 30762, 31385, 31895, 32289, 32569, 32729, 32767, 32686, 32487, 32170, 31733, 31186, 30526, 29761, 28892, 27929, 26866, 25728, 24501, 23208, 21847, 20430, 18957, 17451, 15902, 14328, 12742, 11137, 9535, 7935, 6349, 4775, 3239, 1721, 246, -1185, -2566, -3903, -5174, -6396, -7548, -8642, -9667, -10630, -11522, -12352, -13113, -13810, -14447, -15019, -15534, -15993, -16400, -16757, -17070, -17338, -17569, -17765, -17931, -18070, -18185, -18280, -18359, -18424, -18480, -18527, -18570, -18608, -18645, -18680, -18715, -18750, -18784, -18817, -18849, -18877, -18902, -18918, -18925, -18919, -18898, -18858, -18794, -18705, -18587, -18433, -18243, -18011, -17735, -17409, -17032, -16598, -16106, -15555, -14939, -14260, -13513, -12701, -11817, -10875, -9856, -8781, -7638, -6436, -5175, -3862, -2490, -1086, 368, 1850, 3366, 4898, 6454, 8009, 9569, 11124, 12659, 14177, 15661, 17108, 18505, 19857, 21136, 22357, 23494, 24553, 25523, 26400, 27176, 27851, 28414, 28869, 29210, 29433, 29540, 29529, 29400, 29154, 28792, 28317, 27730, 27037, 26240, 25348, 24356, 23285, 22125, 20896, 19596, 18239, 16824, 15370, 13874, 12349, 10803, 9247, 7678, 6121, 4565, 3029, 1518, 32, -1412, -2819, -4178, -5490, -6739, -7939, -9069, -10141, -11143, -12082, -12950, -13753, -14488, -15156, -15761, -16303, -16780, -17203, -17568, -17881, -18147, -18366, -18545, -18686, -18795, -18871, -18924, -18954, -18965, -18961, -18944, -18918, -18885, -18848, -18807, -18763, -18720, -18676, -18632, -18588, -18542, -18495, -18444, -18387, -18321, -18246, -18158, -18053, -17927, -17777, -17602, -17394, -17154, -16873, -16551, -16182, -15765, -15293, -14767, -14183, -13537, -12829, -12057, -11216, -10313, -9344, -8306, -7208, -6031, -4884, -3019, -959};