/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1400 256 samples */
 
const int16_t AKWF_1400_256_DATA [256] = 
{1765, 4343, 6721, 8980, 11121, 13154, 15083, 16904, 18627, 20253, 21774, 23199, 24529, 25755, 26888, 27921, 28854, 29689, 30425, 31060, 31596, 32032, 32366, 32588, 32779, 32516, 31379, 30542, 29803, 29120, 28479, 27870, 27285, 26722, 26177, 25646, 25130, 24625, 24131, 23647, 23172, 22704, 22247, 21794, 21349, 20911, 20478, 20051, 19629, 19212, 18800, 18393, 17991, 17593, 17199, 16809, 16423, 16042, 15662, 15287, 14917, 14548, 14183, 13822, 13463, 13108, 12755, 12405, 12059, 11716, 11374, 11035, 10700, 10366, 10036, 9708, 9382, 9060, 8738, 8421, 8105, 7791, 7480, 7172, 6866, 6560, 6259, 5959, 5661, 5366, 5072, 4782, 4492, 4206, 3921, 3638, 3357, 3079, 2803, 2527, 2255, 1985, 1716, 1449, 1185, 922, 662, 403, 146, -108, -361, -612, -860, -1108, -1353, -1597, -1838, -2077, -2315, -2551, -2785, -3017, -3247, -3475, -3702, -3927, -4150, -4370, -4590, -4807, -5022, -5236, -5447, -5657, -5866, -6072, -6276, -6478, -6679, -6878, -7076, -7271, -7464, -7656, -7845, -8034, -8221, -8405, -8587, -8768, -8946, -9124, -9299, -9473, -9645, -9814, -9982, -10149, -10314, -10476, -10637, -10796, -10952, -11108, -11262, -11413, -11563, -11712, -11859, -12003, -12146, -12287, -12426, -12563, -12699, -12833, -12965, -13094, -13223, -13349, -13474, -13597, -13718, -13836, -13954, -14070, -14184, -14296, -14406, -14514, -14621, -14725, -14828, -14930, -15029, -15126, -15222, -15315, -15408, -15498, -15586, -15673, -15758, -15840, -15921, -16001, -16078, -16154, -16227, -16300, -16370, -16438, -16504, -16569, -16633, -16693, -16753, -16810, -16866, -16919, -16971, -17022, -17070, -17116, -17161, -17204, -17245, -17284, -17321, -17357, -17390, -17422, -17452, -17480, -17507, -17532, -17555, -17576, -17595, -17612, -17628, -17641, -17653, -17663, -17670, -17677, -17681, -17685, -17686, -17616, -17949, -15207, -10321, -6916, -3772, -843};