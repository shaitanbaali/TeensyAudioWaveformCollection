/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1388 256 samples */
 
const int16_t AKWF_1388_256_DATA [256] = 
{724, 2285, 3902, 5589, 7316, 9137, 10528, 14497, 23314, 28579, 31027, 32123, 32333, 31970, 31208, 30129, 28787, 27215, 25451, 23531, 21499, 19441, 17422, 15471, 13638, 11980, 10575, 9469, 8654, 8115, 7834, 7781, 7942, 8304, 8837, 9515, 10304, 11177, 12105, 13053, 14004, 14933, 15818, 16647, 17410, 18102, 18722, 19271, 19745, 20150, 20488, 20763, 20980, 21144, 21090, 21929, 17243, 5107, -637, -2764, -3106, -2316, -810, 1150, 3418, 5785, 7953, 9859, 11537, 13040, 14404, 15629, 16700, 17569, 18164, 18368, 18101, 17341, 16112, 14545, 12722, 10681, 8471, 6133, 3689, 1182, -1349, -3888, -6389, -8813, -11135, -13331, -15395, -17333, -19138, -20820, -22386, -23833, -25156, -26344, -27396, -28326, -29142, -29851, -30467, -30995, -31440, -31804, -32093, -32307, -32451, -32526, -32496, -32600, -31840, -24473, -18500, -16348, -15793, -16185, -17097, -18192, -19298, -20349, -21340, -22298, -23244, -24195, -25155, -26100, -27001, -27814, -28470, -28911, -29114, -29068, -28784, -28275, -27371, -29660, -32456, -32752, -31958, -30485, -28575, -26369, -23964, -21426, -18786, -16086, -13367, -10659, -8076, -5699, -3536, -1625, 15, 1391, 2503, 3367, 3996, 4404, 4603, 4600, 4410, 4053, 3555, 2945, 2248, 1486, 687, -132, -955, -1764, -2553, -3315, -4042, -4737, -5397, -6019, -6606, -7157, -7671, -8149, -8592, -8998, -9364, -9693, -9981, -10229, -10434, -10592, -10708, -10777, -10801, -10779, -10713, -10602, -10448, -10253, -10018, -9751, -9452, -9127, -8777, -8408, -8023, -7624, -7217, -6804, -6387, -5972, -5559, -5153, -4753, -4363, -3980, -3617, -3151, -2360, -1368, -314, 733, 1731, 2657, 3488, 4223, 4864, 5409, 5860, 6219, 6488, 6669, 6770, 6795, 6754, 6657, 6515, 6342, 6150, 5953, 5764, 5594, 5451, 5345, 5271, 5245, 5370, 1794, -2549, -4106, -4411, -3995, -3139, -2012, -675};