/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1349 256 samples */
 
const int16_t AKWF_1349_256_DATA [256] = 
{-24753, -24139, -23553, -22979, -22419, -21872, -21338, -20818, -20309, -19812, -19329, -18856, -18395, -17945, -17506, -17077, -16658, -16250, -15851, -15463, -15083, -14711, -14350, -13997, -13652, -13316, -12987, -12666, -12353, -12047, -11749, -11458, -11173, -10896, -10626, -10360, -10102, -9850, -9603, -9363, -9128, -8898, -8674, -8455, -8241, -8033, -7829, -7629, -7435, -7244, -7058, -6877, -6699, -6526, -6357, -6191, -6029, -5871, -5716, -5565, -5417, -5272, -5131, -4993, -4857, -4725, -4595, -4468, -4344, -4223, -4103, -3987, -3872, -3760, -3651, -3544, -3439, -3336, -3235, -3135, -3038, -2942, -2849, -2757, -2667, -2578, -2491, -2405, -2320, -2238, -2156, -2076, -1997, -1919, -1843, -1768, -1693, -1620, -1547, -1476, -1405, -1336, -1267, -1199, -1131, -1064, -998, -933, -868, -804, -740, -676, -613, -551, -488, -426, -364, -303, -241, -180, -118, -58, 3, 63, 124, 186, 247, 308, 370, 432, 494, 557, 619, 682, 746, 810, 874, 939, 1004, 1071, 1138, 1205, 1274, 1343, 1413, 1483, 1555, 1627, 1700, 1775, 1850, 1928, 2005, 2084, 2164, 2246, 2329, 2414, 2499, 2586, 2675, 2766, 2858, 2952, 3048, 3145, 3244, 3346, 3449, 3555, 3663, 3772, 3884, 3999, 4115, 4235, 4357, 4481, 4609, 4738, 4871, 5007, 5145, 5287, 5433, 5581, 5732, 5887, 6046, 6209, 6375, 6544, 6718, 6896, 7078, 7265, 7456, 7650, 7851, 8055, 8264, 8479, 8698, 8923, 9153, 9388, 9630, 9877, 10130, 10389, 10654, 10926, 11204, 11490, 11781, 12081, 12388, 12701, 13023, 13352, 13689, 14035, 14389, 14752, 15124, 15504, 15894, 16295, 16704, 17123, 17554, 17994, 18445, 18908, 19381, 19867, 20365, 20874, 21396, 21932, 22479, 23042, 23619, 24208, 24813, 25433, 26067, 26719, 27385, 28067, 28768, 29486, 30220, 30973, 31742, 32548};