/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1361 256 samples */
 
const int16_t AKWF_1361_256_DATA [256] = 
{410, 1036, 1679, 2346, 3042, 3762, 4514, 5288, 6091, 6923, 7776, 8657, 9559, 10486, 11428, 12394, 13366, 14360, 15357, 16364, 17372, 18383, 19384, 20382, 21367, 22336, 23284, 24210, 25104, 25970, 26797, 27583, 28329, 29024, 29671, 30262, 30798, 31271, 31686, 32033, 32316, 32531, 32678, 32755, 32762, 32699, 32567, 32366, 32097, 31760, 31359, 30897, 30371, 29789, 29153, 28462, 27726, 26943, 26119, 25256, 24365, 23435, 22489, 21515, 20528, 19524, 18517, 17498, 16481, 15466, 14453, 13454, 12462, 11488, 10529, 9587, 8668, 7776, 6905, 6061, 5242, 4453, 3686, 2955, 2243, 1562, 906, 278, -328, -908, -1470, -2010, -2530, -3035, -3522, -3996, -4458, -4909, -5353, -5789, -6218, -6643, -7064, -7484, -7899, -8318, -8732, -9151, -9567, -9982, -10397, -10813, -11224, -11634, -12041, -12440, -12835, -13220, -13595, -13957, -14307, -14637, -14951, -15244, -15513, -15759, -15977, -16165, -16324, -16449, -16540, -16595, -16614, -16593, -16534, -16435, -16297, -16119, -15901, -15644, -15349, -15016, -14649, -14246, -13813, -13348, -12855, -12338, -11801, -11242, -10673, -10086, -9496, -8898, -8301, -7706, -7121, -6544, -5983, -5441, -4920, -4426, -3959, -3528, -3129, -2771, -2450, -2175, -1943, -1758, -1620, -1531, -1492, -1502, -1560, -1668, -1825, -2027, -2278, -2569, -2904, -3278, -3689, -4133, -4608, -5111, -5638, -6188, -6749, -7329, -7913, -8504, -9098, -9689, -10271, -10848, -11405, -11950, -12472, -12972, -13446, -13892, -14305, -14686, -15032, -15339, -15612, -15843, -16037, -16190, -16303, -16377, -16411, -16406, -16365, -16286, -16172, -16025, -15846, -15636, -15398, -15135, -14848, -14540, -14210, -13865, -13503, -13127, -12742, -12348, -11945, -11535, -11123, -10705, -10288, -9867, -9447, -9026, -8605, -8184, -7765, -7342, -6922, -6498, -6073, -5642, -5209, -4769, -4319, -3862, -3393, -2912, -2416, -1904, -1390, -586};