/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1303 256 samples */
 
const int16_t AKWF_1303_256_DATA [256] = 
{256, 727, 1254, 1798, 2390, 3016, 3664, 4316, 4978, 5648, 6294, 6921, 7544, 8143, 8711, 9255, 9764, 10211, 10619, 10999, 11338, 11638, 11912, 12159, 12345, 12532, 12764, 13053, 13288, 13353, 13392, 13379, 13319, 13214, 13046, 12865, 12761, 12709, 12577, 12419, 12287, 12190, 12149, 12174, 12232, 12318, 12442, 12586, 12734, 12908, 13127, 13355, 13599, 13867, 14134, 14415, 14708, 14986, 15283, 15638, 15846, 16010, 16247, 16532, 16833, 17136, 17450, 17756, 18027, 18278, 18521, 18730, 18919, 19111, 19296, 19476, 19682, 19891, 20089, 20283, 20445, 20535, 20654, 20828, 21008, 21162, 21294, 21385, 21417, 21408, 21369, 21287, 21181, 21063, 20916, 20746, 20564, 20363, 20133, 19869, 19580, 19247, 18873, 18467, 18014, 17446, 17760, 15165, 14582, 14612, 14008, 13090, 12136, 11088, 9966, 8768, 7493, 6155, 4777, 3401, 1911, 1900, -5564, -11739, -11333, -12272, -13029, -13734, -14360, -14905, -15365, -15733, -16020, -16248, -16503, -15969, -19866, -16306, -15482, -16294, -16723, -17120, -17478, -17788, -17970, -18158, -18426, -18668, -18872, -19051, -19225, -19374, -19516, -19628, -19676, -19596, -19523, -19594, -19605, -19574, -19512, -19401, -19239, -19055, -18870, -18680, -18541, -18410, -18216, -17984, -17760, -17551, -17347, -17165, -17012, -16858, -16699, -16767, -15349, -21861, -17849, -14277, -15076, -14948, -14872, -14678, -14343, -13822, -13475, -12751, -12307, -12164, -11918, -11674, -11448, -11223, -11015, -10846, -10714, -10602, -10534, -10530, -10569, -10672, -10848, -11062, -11257, -11383, -11490, -11666, -11861, -12031, -12136, -12184, -12199, -12168, -12106, -12031, -11957, -11859, -11743, -11621, -11477, -11332, -11193, -11032, -10850, -10670, -10470, -10166, -9815, -9564, -9299, -8998, -8673, -8318, -7937, -7535, -7111, -6669, -6222, -5772, -5325, -4892, -4470, -4059, -3660, -3225, -2755, -2226, -1639, -1195, -900, -622, -389, -117};