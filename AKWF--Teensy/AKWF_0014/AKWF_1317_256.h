/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1317 256 samples */
 
const int16_t AKWF_1317_256_DATA [256] = 
{32628, 32110, 31601, 31091, 30578, 30065, 29552, 29038, 28522, 28007, 27492, 26976, 26459, 25943, 25427, 24909, 24394, 23876, 23358, 22842, 22325, 21808, 21293, 20776, 20260, 19744, 19227, 18713, 18197, 17681, 17166, 16652, 16136, 15622, 15108, 14593, 14080, 13567, 13053, 12541, 12028, 11514, 11003, 10491, 9979, 9468, 8956, 8445, 7935, 7424, 6913, 6405, 5894, 5385, 4876, 4367, 3858, 3350, 2842, 2334, 1827, 1320, 817, 290, -11, 3, 0, 0, 0, 0, 0, 0, 1, -4, 37, 132, 221, 311, 400, 491, 580, 671, 762, 837, 1009, 386, 24, 106, 100, 107, 114, 120, 133, 114, -2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -29, 134, -2274, -3183, -3083, -3199, -3282, -3365, -3449, -3532, -3615, -3698, -3781, -3865, -3947, -4031, -4114, -4197, -4281, -4363, -4447, -4531, -4613, -4697, -4780, -4863, -4946, -5029, -5112, -5195, -5279, -5362, -5445, -5529, -5611, -5695, -5778, -5866, -5918, -6145, -6647, -6710, -6805, -6895, -7096, -6586, -9800, -14455, -14006, -14294, -14468, -14642, -14815, -14988, -15162, -15336, -15520, -15631, -16145, -16725, -16843, -17035, -17216, -17396, -17577, -17756, -17936, -18118, -18298, -18478, -18658, -18839, -19019, -19199, -19379, -19561, -19741, -19920, -20101, -20282, -20447, -20706, -20369, -20127, -20377, -20537, -20709, -20883, -21057, -21230, -21403, -21576, -21750, -21923, -22096, -22270, -22444, -22616, -22789, -22963, -23137, -23310, -23484, -23657, -23831, -24003, -24176, -24350, -24524, -24697, -24870, -25045, -25217, -25389, -25564, -25738, -25910, -26084, -26258, -26431, -26604, -26777, -26950, -27125, -27298, -27470, -27400, -28881, -21544, -13581, -14986, -14830, -14920, -14991, -15184, -14418, -14017, -14198, -14263, -14336, -14355, -14915, -2692, 628, -136, 0, 0, 0, 0};