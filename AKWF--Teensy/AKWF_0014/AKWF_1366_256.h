/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1366 256 samples */
 
const int16_t AKWF_1366_256_DATA [256] = 
{0, 10, 91, 297, 641, 1103, 1661, 2299, 3024, 3842, 4757, 5773, 6889, 8095, 9392, 10775, 12238, 13777, 15450, 16695, 17476, 18294, 19086, 19863, 20623, 21362, 22086, 22789, 23472, 24136, 24778, 25398, 25998, 26573, 27126, 27656, 28161, 28642, 29099, 29530, 29935, 30316, 30668, 30995, 31295, 31567, 31812, 32030, 32220, 32382, 32515, 32621, 32698, 32747, 32767, 32760, 32723, 32659, 32566, 32445, 32295, 32117, 31912, 31679, 31418, 31130, 30816, 30474, 30107, 29713, 29292, 28848, 28378, 27882, 27364, 26821, 26254, 25667, 25055, 24422, 23769, 23094, 22399, 21686, 20952, 20201, 19433, 18647, 17845, 17029, 16196, 15351, 14492, 13619, 12736, 11842, 10936, 10022, 9100, 8167, 7230, 6286, 5335, 4382, 3423, 2461, 1499, 534, -431, -1393, -2358, -3320, -4277, -5233, -6184, -7127, -8067, -8999, -9922, -10838, -11744, -12638, -13525, -14398, -15257, -16106, -16939, -17757, -18561, -19348, -20118, -20872, -21606, -22322, -23020, -23696, -24352, -24988, -25601, -26192, -26761, -27305, -27827, -28325, -28797, -29246, -29669, -30065, -30435, -30772, -31102, -30921, -29228, -25993, -22002, -17336, -9613, -1866, 2191, 2248, -460, -3451, -5353, -6012, -5847, -5346, -4796, -4275, -3726, -3112, -2152, -2364, -7704, -14745, -19510, -21488, -21683, -21336, -21205, -21499, -22091, -22763, -23355, -23811, -24141, -24359, -24301, -23849, -23119, -22279, -21446, -20658, -19899, -19147, -18378, -17581, -16762, -15923, -15065, -14209, -13193, -12080, -11007, -9953, -8921, -7916, -6935, -5981, -5059, -4163, -3298, -2465, -1662, -893, -159, 539, 1187, 1771, 2289, 2739, 3127, 3458, 3735, 3960, 4138, 4269, 4357, 4403, 4412, 4384, 4324, 4234, 4118, 3976, 3814, 3633, 3436, 3227, 3007, 2780, 2548, 2313, 2078, 1846, 1619, 1398, 1187, 988, 802, 631, 477, 342, 227, 133, 63, 16};