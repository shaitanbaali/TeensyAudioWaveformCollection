/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1342 256 samples */
 
const int16_t AKWF_1342_256_DATA [256] = 
{263, 1245, 2205, 3167, 4125, 5080, 6033, 6977, 7917, 8852, 9775, 10692, 11601, 12497, 13384, 14260, 15121, 15972, 16808, 17627, 18434, 19224, 19996, 20753, 21491, 22209, 22910, 23590, 24248, 24888, 25505, 26099, 26671, 27220, 27745, 28248, 28724, 29176, 29603, 30003, 30378, 30727, 31049, 31344, 31612, 31852, 32065, 32250, 32407, 32535, 32636, 32708, 32752, 32768, 32755, 32714, 32644, 32546, 32420, 32266, 32083, 31873, 31635, 31370, 31077, 30758, 30412, 30039, 29641, 29217, 28767, 28293, 27794, 27270, 26724, 26154, 25560, 24947, 24310, 23651, 22974, 22276, 21558, 20823, 20068, 19296, 18509, 17703, 16884, 16051, 15201, 14340, 13467, 12580, 11684, 10778, 9861, 8938, 8006, 7065, 6121, 5170, 4214, 3256, 2294, 1330, 367, -598, -1564, -2525, -3487, -4446, -5398, -6349, -7293, -8229, -9161, -10083, -10996, -11901, -12795, -13677, -14549, -15408, -16251, -17083, -17899, -18699, -19484, -20251, -21001, -21733, -22445, -23138, -23812, -24464, -25096, -25706, -26292, -26857, -27399, -27915, -28409, -28878, -29321, -29739, -30132, -30497, -30837, -31151, -31436, -31695, -31926, -32129, -32305, -32453, -32572, -32663, -32726, -32761, -32767, -32744, -32694, -32614, -32507, -32372, -32208, -32017, -31797, -31549, -31276, -30974, -30645, -30291, -29910, -29502, -29070, -28612, -28129, -27622, -27091, -26536, -25959, -25358, -24736, -24093, -23428, -22743, -22040, -21315, -20573, -19814, -19035, -18242, -17433, -16607, -15770, -14917, -14050, -13174, -12284, -11383, -10474, -9555, -8628, -7694, -6752, -5804, -4854, -3896, -2936, -1975, -1010, -45, 918, 1884, 2846, 3805, 4763, 5716, 6663, 7605, 8541, 9468, 10388, 11298, 12199, 13091, 13968, 14835, 15691, 16529, 17356, 18168, 18962, 19741, 20504, 21246, 21972, 22679, 23364, 24031, 24678, 25301, 25904, 26483, 27039, 27573, 28083, 28567, 29028, 29463, 29873, 30256, 30613, 30948};