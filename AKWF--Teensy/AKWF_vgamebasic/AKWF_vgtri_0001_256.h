/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0001 256 samples */
 
const int16_t AKWF_vgtri_0001_256_DATA [256] = 
{1896, 2493, 2250, 2311, 2305, 2306, 2306, 2306, 2306, 2306, 2297, 2406, 1882, 4293, 7342, 6835, 6926, 6921, 6922, 6915, 7002, 6644, 7709, 12110, 12068, 11893, 12014, 16508, 17299, 17007, 17081, 17075, 17075, 17075, 17075, 17075, 17076, 17067, 17177, 16654, 18896, 22113, 21610, 21693, 21691, 21691, 21686, 21763, 21453, 22329, 26773, 26864, 26685, 26705, 31111, 32104, 31771, 31851, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31845, 31847, 31811, 31919, 31825, 27362, 26541, 26817, 26782, 26911, 22936, 21883, 22228, 22145, 22152, 22151, 22151, 22151, 22151, 22151, 22161, 22044, 22578, 20517, 16667, 17139, 17078, 17075, 17077, 17046, 17123, 17161, 12725, 11737, 12055, 11993, 12194, 8319, 7094, 7462, 7375, 7382, 7382, 7382, 7382, 7381, 7387, 7314, 7559, 6952, 1015, -2185, -1777, -1840, -1844, -1844, -1844, -1844, -1844, -1845, -1844, -1858, -1863, -1554, -5737, -7277, -6827, -6957, -6883, -6809, -11198, -12269, -11921, -12005, -11990, -12089, -11658, -13163, -16908, -16583, -16605, -16613, -16613, -16613, -16613, -16613, -16614, -16614, -16622, -16654, -16287, -20331, -22070, -21590, -21700, -21691, -21691, -21691, -21691, -21692, -21687, -21748, -21574, -21862, -27704, -31717, -31333, -31373, -31384, -31383, -31383, -31383, -31383, -31383, -31384, -31385, -31398, -31284, -32324, -32834, -32747, -32768, -32767, -32767, -32767, -32767, -32767, -32769, -32740, -32773, -32620, -27390, -22760, -23105, -23094, -23075, -23076, -23075, -23075, -23075, -23075, -23075, -23073, -23008, -23482, -19700, -17576, -18106, -17990, -18000, -17999, -17999, -17999, -17999, -18003, -17961, -18043, -18061, -12847, -8036, -8325, -8328, -8306, -8307, -8306, -8306, -8306, -8306, -8306, -8309, -8224, -8755, -5132, -2774, -3342, -3221, -3231, -3230, -3230, -3230, -3230, -3233, -3197, -3330, -3141};