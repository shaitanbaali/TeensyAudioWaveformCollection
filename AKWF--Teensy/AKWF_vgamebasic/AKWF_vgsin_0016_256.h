/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0016 256 samples */
 
const int16_t AKWF_vgsin_0016_256_DATA [256] = 
{843, 1416, 1575, 2001, 2972, 3519, 5232, 5782, 6312, 6859, 7768, 8478, 9197, 10129, 11695, 11949, 12113, 12880, 13571, 14548, 16086, 16319, 16486, 17277, 17968, 18623, 20005, 20255, 20466, 20995, 21460, 22435, 22855, 23821, 24500, 24694, 24936, 25587, 25933, 26793, 27092, 27325, 27562, 28245, 28544, 28764, 29212, 30060, 30177, 30110, 30249, 30569, 30764, 31344, 31495, 31419, 31560, 31919, 31893, 31878, 32249, 32359, 32324, 32332, 32331, 32332, 32323, 32367, 32207, 31861, 31903, 31904, 31516, 31470, 31323, 31024, 30769, 30540, 30230, 30074, 29545, 29270, 29014, 28777, 28515, 28176, 27516, 27370, 26483, 26121, 25898, 25523, 24929, 24499, 23365, 23058, 22864, 22324, 21401, 20914, 20517, 19731, 18401, 18174, 18004, 17147, 16529, 15410, 14452, 14116, 13589, 12760, 12093, 11129, 10787, 9556, 8695, 8257, 6735, 6544, 6386, 4665, 3877, 3402, 2921, 1942, 1475, -164, -932, -1421, -1905, -2859, -3502, -4333, -5041, -6720, -7148, -7695, -8316, -9149, -9920, -11222, -11493, -12080, -12713, -13538, -14365, -14922, -15749, -17028, -17228, -17409, -18321, -18888, -20072, -20988, -21144, -21387, -21962, -22422, -23438, -23798, -24878, -25394, -25604, -25881, -26537, -26894, -27773, -27975, -28258, -28484, -28740, -29135, -29736, -29952, -30499, -30656, -30968, -31188, -31455, -31742, -31912, -31937, -32332, -32344, -32297, -32613, -32789, -32762, -32768, -32767, -32768, -32763, -32780, -32685, -32328, -32328, -32329, -32347, -32294, -31940, -31790, -31229, -30979, -31048, -30976, -30617, -30508, -29692, -29213, -28973, -28743, -28490, -28062, -27489, -27281, -26377, -26093, -25869, -25416, -24901, -24335, -23286, -22977, -22365, -21891, -21400, -20843, -19339, -18726, -18915, -18197, -17394, -16880, -16519, -15093, -13935, -13779, -13565, -12588, -12091, -10729, -9363, -9148, -9224, -8224, -7542, -6237, -5717, -4019, -3384, -3236, -2819, -1879, -1142};