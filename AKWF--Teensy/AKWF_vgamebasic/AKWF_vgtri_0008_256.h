/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0008 256 samples */
 
const int16_t AKWF_vgtri_0008_256_DATA [256] = 
{371, 464, 439, 413, 411, 2316, 2734, 2626, 2413, 4353, 5465, 5241, 5051, 6189, 7635, 7390, 7484, 7242, 8232, 9806, 9629, 9479, 10029, 12305, 12281, 12200, 12254, 14191, 14533, 14431, 14276, 15953, 16801, 16575, 16662, 16429, 17993, 19003, 18821, 18575, 19845, 21672, 21424, 21305, 21831, 23702, 23626, 23643, 23520, 23897, 25812, 25854, 25771, 25778, 28056, 28571, 28430, 28256, 29865, 30809, 30576, 30652, 30505, 31397, 32061, 31850, 32165, 30994, 29094, 29318, 29425, 28976, 27081, 27106, 27107, 27211, 26907, 24963, 24882, 24963, 25015, 22756, 22158, 22319, 22496, 20943, 19931, 20123, 20315, 19259, 17741, 17977, 17889, 18119, 17230, 15574, 15737, 15873, 15427, 13112, 13076, 13160, 13158, 11249, 10823, 10959, 10934, 11028, 9190, 8614, 8736, 8984, 7222, 5887, 6133, 6307, 5352, 3747, 3972, 3892, 4105, 3302, 1596, 1742, 1840, 1530, -398, -487, -409, -375, -2245, -2749, -2594, -2632, -2534, -4184, -5259, -7378, -7480, -7417, -7432, -7482, -7253, -8145, -9793, -9622, -9562, -9733, -12370, -14165, -13969, -13995, -13998, -13998, -14008, -14000, -13876, -16083, -16792, -16619, -16441, -17742, -20617, -21113, -20959, -21002, -20999, -20994, -21051, -20798, -21742, -23805, -23623, -23571, -23683, -26259, -28152, -27976, -27994, -28000, -27999, -28007, -28008, -27853, -30011, -30800, -30617, -30401, -31989, -31485, -30400, -30673, -30619, -30623, -30628, -30572, -30817, -29960, -27833, -27996, -28042, -27976, -25479, -23483, -23637, -23629, -23621, -23622, -23618, -23604, -23767, -22031, -21271, -21423, -21653, -20292, -17107, -16496, -16665, -16619, -16623, -16626, -16583, -16768, -16141, -14332, -14417, -14479, -14432, -11620, -9487, -9638, -9631, -9622, -9622, -9620, -9598, -9791, -8093, -7265, -7427, -7641, -6387, -3194, -2481, -2668, -2620, -2624, -2627, -2587, -2757, -2214, -350, -425, -461, -421};