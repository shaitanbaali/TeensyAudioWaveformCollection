/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0004 256 samples */
 
const int16_t AKWF_vgsaw_0004_256_DATA [256] = 
{693, 1490, 2912, 2797, 2804, 2808, 2808, 2808, 2808, 2808, 2804, 2845, 2661, 3375, 4640, 5734, 6721, 6511, 6555, 6551, 6552, 6552, 6552, 6552, 6550, 6585, 6389, 7631, 8573, 9979, 10398, 10266, 10298, 10296, 10296, 10296, 10296, 10300, 10309, 10178, 11715, 12195, 12472, 14113, 14048, 14033, 14042, 14042, 14042, 14042, 14040, 14064, 13971, 14191, 15905, 15777, 16790, 17968, 17748, 17790, 17787, 17787, 17787, 17787, 17784, 17828, 17624, 18439, 19823, 19528, 21102, 21663, 21498, 21536, 21533, 21533, 21533, 21530, 21573, 21352, 22471, 23602, 23304, 23556, 24798, 24833, 24798, 24810, 24809, 24809, 24809, 24817, 24806, 24728, 26301, 26841, 26485, 27384, 28714, 28525, 28554, 28553, 28553, 28553, 28551, 28581, 28462, 28787, 30438, 30470, 30307, 31384, 31948, 31802, 31834, 31831, 31831, 31831, 31832, 31820, 31886, 31388, 31521, 30799, -18794, -34828, -32048, -32798, -32763, -32767, -32767, -32767, -32754, -32811, -32232, -31749, -31824, -31939, -31433, -30329, -30439, -30430, -30427, -30427, -30428, -30417, -30443, -30467, -28838, -28452, -28550, -28725, -27459, -26507, -26724, -26678, -26682, -26681, -26684, -26651, -26792, -26360, -24753, -24787, -24838, -24834, -23201, -22840, -22967, -22935, -22938, -22937, -22941, -22896, -23114, -22070, -20887, -21070, -21177, -20708, -19117, -19188, -19199, -19191, -19191, -19192, -19161, -19360, -18028, -17150, -17364, -17276, -17498, -16415, -15270, -15484, -15444, -15447, -15448, -15432, -15479, -15430, -13772, -13493, -13592, -13570, -13665, -12112, -11578, -11736, -11700, -11702, -11706, -11666, -11833, -11276, -9733, -9836, -9807, -9915, -9612, -7964, -7929, -7970, -7956, -7956, -7959, -7919, -8133, -6971, -5909, -6128, -6041, -6255, -5354, -4047, -4243, -4212, -4213, -4211, -4197, -4321, -3255, -2692, -2837, -2804, -2788, -2954, -1514, -781, -976, -933, -938, -922, -980, -865};