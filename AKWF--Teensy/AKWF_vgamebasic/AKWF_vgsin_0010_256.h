/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0010 256 samples */
 
const int16_t AKWF_vgsin_0010_256_DATA [256] = 
{253, 518, 262, 945, 3166, 3064, 2918, 5166, 5631, 6399, 8932, 8703, 8676, 10574, 11089, 10684, 11945, 13338, 12967, 13336, 15273, 15358, 15068, 17096, 18170, 17684, 18551, 20263, 20049, 20093, 21635, 21969, 21616, 22962, 24260, 23892, 24282, 25808, 25804, 25682, 26732, 27213, 26949, 27526, 28519, 28354, 28434, 29595, 29776, 29613, 30196, 30680, 30513, 30746, 31490, 31463, 31432, 31794, 31935, 31848, 32062, 32372, 32325, 32331, 32331, 32331, 32332, 32326, 32351, 32290, 31900, 31881, 31933, 31599, 31405, 31516, 31296, 30145, 29636, 29727, 29711, 29682, 29833, 29057, 28258, 28491, 28230, 27075, 27045, 27232, 25855, 23707, 23537, 23615, 23572, 23634, 23549, 21617, 21285, 21600, 20454, 19455, 19801, 19392, 16299, 14671, 14895, 14808, 15029, 14259, 12089, 12244, 12303, 10737, 10581, 9763, 7657, 8047, 5918, 5047, 5291, 5203, 5451, 3503, 2342, 2902, 1799, -650, -385, -434, -2523, -3704, -5740, -5684, -5706, -5556, -5993, -8310, -8361, -8098, -10154, -11181, -10651, -11783, -13556, -14885, -15921, -15676, -15784, -15476, -17132, -18636, -18171, -18704, -20593, -20555, -20443, -21758, -22604, -24391, -24519, -24446, -24413, -25522, -25896, -25594, -26527, -27698, -27445, -27625, -28822, -28745, -29472, -30272, -30136, -30087, -30370, -31081, -31009, -31002, -31763, -31952, -31841, -32107, -32364, -32333, -32706, -32778, -32764, -32768, -32767, -32767, -32767, -32768, -32766, -32771, -32745, -32374, -32351, -32175, -31858, -31888, -31942, -31762, -30989, -31096, -30513, -30042, -30250, -29876, -28775, -28839, -28901, -27789, -27411, -27666, -26977, -26076, -26296, -26092, -24531, -24387, -24673, -23072, -22056, -22455, -21851, -20416, -20558, -20592, -18699, -18173, -18629, -17142, -15455, -15872, -15497, -13561, -13473, -13759, -11756, -10655, -11181, -10172, -8096, -8360, -8305, -6007, -5503, -5962, -4353, -2763, -3270, -2617, 44, 10};