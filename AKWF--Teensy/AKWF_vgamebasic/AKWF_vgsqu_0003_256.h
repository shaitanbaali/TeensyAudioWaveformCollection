/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0003 256 samples */
 
const int16_t AKWF_vgsqu_0003_256_DATA [256] = 
{26313, 30801, 28993, 29493, 29459, 29410, 29554, 30281, 30292, 30273, 30280, 30279, 30288, 30246, 30408, 30728, 30690, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30700, 30683, 30714, 31095, 31084, 31267, 31562, 31516, 31524, 31523, 31523, 31523, 31523, 31516, 31593, 30501, 34977, 12000, -33709, -31015, -30415, -30734, -30692, -30696, -30695, -30695, -30695, -30696, -30695, -30704, -30656, -30879, -31147, -31101, -31110, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31110, -31109, -31112, -31106, -31100, -31457, -31548, -31517, -31524, -31523, -31524, -31523, -31533, -31488, -31662, -32002, -31539, -32924, -26287};