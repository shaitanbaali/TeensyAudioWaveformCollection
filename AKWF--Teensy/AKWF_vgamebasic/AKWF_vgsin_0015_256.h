/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0015 256 samples */
 
const int16_t AKWF_vgsin_0015_256_DATA [256] = 
{330, 775, 1269, 2127, 2692, 3925, 5254, 5429, 5581, 6834, 7646, 8528, 9087, 10415, 11515, 11808, 11898, 12968, 13482, 14925, 15323, 15907, 16344, 16894, 17560, 18350, 19194, 20453, 20638, 20884, 21361, 21824, 22763, 23971, 24147, 24391, 24878, 25379, 25959, 26328, 27162, 27523, 27740, 27997, 28270, 28512, 29395, 29710, 29940, 30185, 30481, 30692, 30985, 31224, 31490, 31450, 31842, 31924, 31847, 32113, 32374, 32323, 32332, 32331, 32332, 32327, 32345, 32309, 31918, 31882, 31898, 31895, 31913, 31477, 31012, 31011, 31058, 30750, 30530, 30208, 30100, 29351, 28790, 28564, 28325, 28057, 27738, 26838, 26633, 26371, 26097, 25432, 25113, 23982, 23525, 23331, 22964, 21944, 21476, 20974, 20427, 18975, 18635, 18483, 17770, 16994, 16437, 14999, 14694, 14539, 13795, 13041, 12153, 11659, 10222, 9117, 8964, 8720, 7744, 7200, 5325, 4291, 4150, 3891, 2908, 2282, 1437, 603, -1396, -1854, -2016, -2517, -3447, -4066, -5773, -6250, -6793, -7393, -8257, -9029, -9657, -10766, -12205, -12403, -12577, -13461, -14043, -15228, -16596, -16782, -16961, -17865, -18510, -19044, -19508, -20955, -21461, -21656, -21965, -23018, -23372, -24472, -24959, -25175, -25462, -26106, -26544, -27116, -27318, -28228, -28510, -28783, -29026, -29240, -29854, -30579, -30600, -30539, -30776, -31035, -31324, -31499, -31955, -32360, -32329, -32336, -32313, -32382, -32749, -32771, -32766, -32768, -32767, -32768, -32761, -32790, -32515, -32285, -32367, -32254, -31874, -31928, -31634, -31406, -31107, -30896, -30602, -30389, -29825, -29657, -29347, -29124, -28893, -28341, -27919, -27544, -26702, -26485, -26262, -25683, -25292, -24496, -23606, -23415, -23221, -22314, -21695, -21108, -20832, -19521, -18691, -18546, -18218, -17208, -16683, -15246, -14822, -14268, -13775, -12828, -12165, -11335, -10851, -9412, -8970, -8438, -7752, -6989, -6114, -4534, -4154, -3618, -2901, -2138, -1283, -683};