/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0007 256 samples */
 
const int16_t AKWF_vgsqu_0007_256_DATA [256] = 
{27463, 33294, 32505, 32778, 32766, 32768, 32748, 32827, 32046, 31395, 31536, 31488, 31589, 31094, 30589, 30694, 30635, 30780, 31116, 31084, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31088, 31079, 31118, 30980, 30642, 30669, 30681, 30642, 30730, 31967, 32818, 32748, 32767, 32766, 32770, 32504, 33046, 29622, -20518, -31677, -28216, -28880, -30385, -31946, -31933, -31918, -31928, -31927, -31928, -31918, -31965, -31770, -31470, -31515, -31507, -31508, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31503, -31540, -31220, -31054, -31096, -31087, -31088, -31076, -31125, -30997, -30250, -30277, -29776, -31724, -25955};