/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0015 256 samples */
 
const int16_t AKWF_vgsqu_0015_256_DATA [256] = 
{16446, 28392, 29110, 30125, 29245, 29103, 28897, 28905, 28213, 28113, 28155, 28140, 28134, 28464, 28550, 28522, 28528, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28529, 28529, 28498, 28868, 28852, 28138, 28130, 28148, 28178, 27738, 27987, 29289, 29292, 30656, 29769, -21256, -33144, -25667, -27158, -27876, -28016, -28212, -28534, -28461, -28937, -29365, -29302, -29244, -28909, -28910, -28916, -28913, -28914, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28914, -28908, -28945, -28825, -28703, -29329, -29301, -29297, -29299, -29308, -29261, -29442, -29843, -28398, -26985, -28906, -18042, 762};