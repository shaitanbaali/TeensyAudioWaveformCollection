/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0012 256 samples */
 
const int16_t AKWF_vgsaw_0012_256_DATA [256] = 
{496, 927, 806, 1372, 2151, 2130, 2125, 2114, 2146, 2544, 2486, 2905, 3477, 3364, 4124, 4289, 4280, 5072, 5604, 5520, 5507, 5598, 5981, 5883, 6447, 6892, 6764, 6877, 7261, 7165, 7672, 8784, 8981, 8929, 8898, 9129, 9390, 9342, 10102, 10221, 10331, 10677, 10582, 11256, 11584, 11883, 11928, 11915, 11863, 12567, 12775, 12910, 13659, 13580, 13886, 14049, 14110, 14833, 15053, 15352, 15301, 15320, 16066, 16218, 16116, 16380, 16624, 16587, 17369, 17413, 17732, 18331, 18555, 18777, 18657, 18908, 19621, 19536, 19845, 20054, 19933, 20187, 20904, 20783, 21392, 21781, 22067, 22165, 22040, 22567, 23051, 22970, 23387, 23345, 23713, 24330, 24221, 24612, 24649, 24876, 25583, 25527, 25496, 26227, 26406, 26473, 26846, 26737, 27392, 27713, 27697, 28108, 28014, 28542, 29019, 28921, 28939, 28972, 28776, 29873, 30752, 30708, 31406, 35092, 11795, -20174, -15004, -29221, -33482, -31709, -29619, -29744, -30367, -30802, -30368, -28907, -28923, -28950, -28926, -28986, -28805, -28054, -28160, -27602, -27169, -27233, -26810, -26875, -26447, -25881, -25984, -25581, -25567, -25330, -24434, -24224, -24267, -24238, -24323, -24001, -23335, -23470, -22776, -22513, -22496, -22098, -22198, -21647, -20887, -20839, -20840, -20933, -20459, -19914, -20033, -19968, -19572, -19644, -19176, -18650, -18761, -17944, -17419, -17448, -17446, -17499, -16795, -16562, -16528, -16136, -16243, -15641, -15237, -15347, -15302, -14585, -13974, -14044, -14077, -13962, -13195, -13216, -12982, -12741, -12764, -11995, -11916, -11762, -11523, -10946, -10565, -10647, -10674, -10482, -10177, -10258, -9524, -9367, -9178, -8457, -8541, -8248, -8029, -7321, -7191, -7286, -7003, -6786, -6796, -6033, -5915, -6009, -5721, -5512, -5501, -4811, -4433, -3787, -3834, -3848, -3469, -3440, -3194, -2496, -2591, -2249, -2136, -2016, -1258, -1307, -1050, -797, -904, -730, 19, -34};