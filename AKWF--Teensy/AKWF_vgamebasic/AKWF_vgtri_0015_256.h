/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0015 256 samples */
 
const int16_t AKWF_vgtri_0015_256_DATA [256] = 
{495, 953, 1168, 1494, 2127, 2505, 3651, 4005, 4234, 4584, 5191, 5678, 6137, 6807, 7806, 8007, 8236, 8775, 9202, 9925, 10886, 11075, 11305, 11854, 12314, 12931, 13249, 14294, 14892, 15097, 15357, 16025, 16328, 17406, 17962, 18171, 18440, 19084, 19510, 20069, 20542, 21668, 21940, 22175, 22588, 23145, 23650, 24757, 25010, 25244, 25682, 26224, 26778, 27144, 28012, 28841, 29024, 29253, 29877, 30222, 31129, 31901, 32088, 32410, 31693, 31297, 30672, 30335, 29198, 28772, 28549, 28239, 27591, 27239, 26092, 25708, 25479, 25152, 24530, 24053, 23576, 22949, 21920, 21712, 21478, 20961, 20511, 19835, 18837, 18642, 18412, 17870, 17445, 16716, 15760, 15573, 15340, 14782, 14330, 13711, 13398, 12344, 11747, 11547, 11287, 10621, 10318, 9230, 8686, 8478, 8208, 7562, 7131, 6573, 6102, 4979, 4706, 4470, 4050, 3500, 2994, 1888, 1637, 1403, 964, 428, -141, -479, -959, -1736, -1939, -2167, -2793, -3134, -4046, -4821, -5006, -5245, -5866, -6284, -6902, -7242, -8382, -8804, -9024, -9340, -9986, -10338, -11484, -11867, -12093, -12432, -13046, -13524, -13993, -14635, -15659, -15862, -16095, -16614, -17061, -17753, -18757, -18834, -19598, -20166, -20074, -20801, -21094, -22121, -22756, -22956, -23207, -23874, -24173, -25238, -25822, -26026, -26287, -26931, -27354, -27932, -28376, -29511, -29800, -30033, -30436, -31007, -31475, -32618, -32723, -32409, -32011, -31466, -30947, -29843, -29602, -29369, -28923, -28387, -27820, -27461, -26587, -25771, -25583, -25351, -24723, -24389, -23469, -22698, -22513, -22279, -21655, -21239, -20620, -20270, -19135, -18722, -18497, -18179, -17534, -17177, -16035, -15654, -15425, -15087, -14475, -13996, -13530, -12881, -11860, -11660, -11427, -10906, -10460, -9763, -8783, -8588, -8358, -7819, -7350, -6740, -6425, -5389, -4764, -4566, -4315, -3650, -3342, -2277, -1702, -1497, -1242, -552, -280, -25};