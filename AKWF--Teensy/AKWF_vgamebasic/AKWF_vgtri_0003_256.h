/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0003 256 samples */
 
const int16_t AKWF_vgtri_0003_256_DATA [256] = 
{1798, 3821, 3428, 3504, 3499, 3500, 3500, 3500, 3500, 3505, 3531, 3289, 5861, 7507, 10278, 10602, 10471, 10506, 10504, 10504, 10504, 10504, 10504, 10497, 10586, 10222, 11688, 16721, 18204, 17872, 17953, 17946, 17947, 17947, 17947, 17947, 17947, 17944, 17993, 17798, 18300, 21412, 21509, 21416, 21517, 21205, 22194, 25537, 25393, 25372, 25388, 25384, 25451, 25068, 27493, 29214, 28814, 28899, 28889, 28930, 28779, 29119, 32252, 32485, 32365, 32338, 32595, 31820, 28402, 28417, 28475, 28451, 28457, 28383, 28788, 26531, 24618, 25026, 24944, 24900, 25244, 22641, 21152, 21523, 21441, 21447, 21453, 21373, 21721, 20530, 17280, 17530, 17462, 17714, 16864, 13880, 13995, 14022, 14006, 14007, 14008, 13982, 14060, 13982, 10904, 10345, 10513, 10783, 7723, 6258, 6643, 6557, 6564, 6563, 6570, 6487, 6896, 5015, 2739, 3067, 3301, 2248, -639, -422, -427, -437, -436, -437, -432, -488, -258, -947, -3992, -3988, -3708, -6594, -7691, -7375, -7446, -7440, -7440, -7441, -7440, -7454, -7438, -7282, -10339, -10859, -11996, -15159, -14845, -14879, -14883, -14883, -14883, -14884, -14877, -14957, -14592, -16066, -18661, -18201, -21197, -22102, -21826, -21892, -21886, -21886, -21886, -21887, -21883, -21931, -21748, -22225, -25376, -27088, -29581, -29283, -29329, -29329, -29329, -29329, -29329, -29329, -29330, -29333, -29345, -29097, -31893, -29776, -28607, -28961, -28887, -28893, -28892, -28892, -28892, -28892, -28898, -28834, -29060, -28392, -23838, -21591, -21954, -21885, -21887, -21887, -21886, -21894, -21805, -22192, -20775, -17675, -17985, -17953, -17948, -17947, -17947, -17953, -17888, -18160, -17281, -14301, -14437, -14458, -14449, -14369, -14773, -12912, -10618, -11009, -10941, -10945, -10922, -10978, -11013, -7591, -6799, -7064, -6968, -7088, -6873, -3763, -3383, -3539, -3498, -3500, -3505, -3433, -3824, -1580, 325, -84, 43, -160};