/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0013 256 samples */
 
const int16_t AKWF_vgsin_0013_256_DATA [256] = 
{1657, 1694, 2301, 3157, 3032, 4785, 5720, 7468, 7337, 8166, 8825, 10219, 10476, 10854, 11904, 11690, 13016, 13791, 15210, 15221, 15885, 16599, 17854, 19614, 19690, 19664, 19557, 20434, 21075, 22477, 22736, 22975, 23667, 23521, 24544, 25050, 26324, 27157, 27081, 27032, 27758, 28000, 28032, 28439, 28292, 29214, 29826, 30076, 30151, 30206, 31048, 31541, 31422, 31501, 31886, 31905, 31892, 31873, 32235, 32362, 32323, 32332, 32331, 32331, 32332, 32322, 32370, 32172, 31859, 31896, 31914, 31847, 31452, 31488, 31236, 31013, 30356, 30039, 29725, 29690, 29777, 29144, 28740, 28038, 28007, 27624, 27079, 26501, 26186, 26090, 25454, 24815, 23924, 24098, 22937, 22736, 22398, 21312, 21500, 20549, 19922, 18474, 18406, 17820, 17050, 15834, 15194, 15199, 14360, 14604, 13207, 12076, 10803, 10483, 10146, 9070, 9285, 7996, 7176, 5376, 5289, 4686, 3961, 2374, 1649, 1578, 363, 616, -812, -1940, -3105, -3809, -4813, -4831, -4671, -6319, -7303, -9059, -9118, -9752, -10496, -11761, -12286, -12434, -13617, -13400, -14561, -15437, -16788, -17022, -17459, -18300, -19404, -20221, -20127, -20974, -20870, -21586, -22296, -23566, -24922, -24910, -24914, -24797, -25697, -26336, -27347, -27549, -27664, -27926, -28514, -28894, -28844, -29871, -30643, -30579, -30558, -30930, -31022, -31104, -31486, -31423, -31730, -31937, -32286, -32313, -32479, -32789, -32762, -32767, -32767, -32768, -32767, -32766, -32772, -32424, -32303, -32339, -32323, -32369, -32064, -31511, -31430, -31505, -31280, -31054, -30437, -30094, -30113, -29690, -29783, -29258, -28799, -27814, -27387, -27082, -27205, -26377, -25675, -25777, -24937, -24992, -24379, -23608, -22394, -21752, -21719, -21118, -20246, -19082, -19307, -17758, -17442, -17239, -16706, -15616, -14730, -14841, -13575, -13701, -12635, -11281, -10134, -9544, -9449, -8229, -8486, -7071, -5956, -4669, -4371, -3982, -3164, -1776, -742, -806};