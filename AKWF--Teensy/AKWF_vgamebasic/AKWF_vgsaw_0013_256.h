/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0013 256 samples */
 
const int16_t AKWF_vgsaw_0013_256_DATA [256] = 
{144, 934, 1220, 1112, 1251, 1567, 1515, 1782, 1981, 2635, 2692, 2840, 3122, 3043, 3424, 4207, 4268, 4196, 4449, 4646, 4940, 5006, 5105, 5428, 5340, 5922, 6253, 6482, 6669, 6962, 6930, 6923, 7560, 7810, 8094, 8068, 8306, 8495, 9125, 9264, 9355, 9628, 9861, 10034, 10056, 10760, 10779, 10954, 11210, 11175, 11463, 11714, 12355, 12307, 12555, 12750, 13048, 13095, 13219, 13525, 13440, 14047, 14347, 14625, 14622, 14826, 15060, 15026, 15680, 15913, 16199, 16162, 16415, 16607, 17245, 17352, 17463, 17765, 17715, 17996, 18211, 18868, 18870, 19067, 19289, 19566, 19662, 19732, 20075, 19982, 20525, 20887, 21149, 21187, 21332, 21620, 21548, 22170, 22448, 22732, 22718, 22934, 23128, 23729, 23927, 23973, 24311, 24259, 24527, 24703, 25400, 25860, 25826, 25825, 25851, 25759, 26008, 27371, 27356, 27562, 27836, 26921, 25312, 31616, 4091, -35054, -31979, -32311, -27499, -26761, -27060, -26981, -26933, -27686, -27601, -26194, -26192, -26255, -25954, -25791, -25867, -25728, -25411, -25502, -24923, -24593, -24321, -24306, -24127, -23918, -23381, -23051, -22787, -22722, -22782, -22533, -22342, -21717, -21572, -21494, -21170, -21225, -20951, -20740, -20127, -19912, -19639, -19690, -19379, -19266, -19222, -18865, -18955, -18444, -18055, -17800, -17743, -17611, -17387, -16893, -16520, -16570, -16196, -16214, -16014, -15820, -15237, -14999, -14980, -14627, -14678, -14430, -14227, -13626, -13381, -13102, -13102, -13123, -12847, -12631, -11971, -11968, -11776, -11550, -11274, -11176, -11113, -10764, -10859, -10322, -9952, -9690, -9651, -9501, -9287, -8764, -8428, -8463, -8093, -8121, -7909, -7713, -7112, -6911, -6871, -6528, -6580, -6320, -6127, -5477, -5396, -5262, -5009, -4783, -4291, -4223, -4230, -4313, -3846, -3414, -3173, -3083, -3000, -2666, -2760, -2195, -1871, -1547, -1139, -1145, -1222, -636, -337, -355, 6, -8};