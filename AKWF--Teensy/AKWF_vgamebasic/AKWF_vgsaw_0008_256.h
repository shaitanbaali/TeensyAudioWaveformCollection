/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0008 256 samples */
 
const int16_t AKWF_vgsaw_0008_256_DATA [256] = 
{217, 463, 415, 424, 446, 311, 1194, 1840, 1583, 2005, 3051, 2981, 2946, 3034, 3796, 3850, 3818, 3848, 3761, 4017, 5129, 5124, 5078, 5113, 6244, 6455, 6286, 6850, 7312, 7215, 7235, 7251, 7126, 8067, 8617, 8510, 8391, 9066, 9916, 9725, 9879, 10630, 10651, 10630, 10660, 10560, 10882, 11961, 11928, 11879, 11963, 13095, 13248, 13099, 13703, 14119, 14023, 14045, 14055, 13947, 14947, 15418, 15319, 15201, 15957, 16730, 16525, 16721, 17460, 17456, 17440, 17471, 17357, 17749, 18796, 18732, 18679, 18809, 19953, 20045, 19920, 20564, 20923, 20833, 20856, 20859, 20778, 21817, 22216, 22127, 22011, 22827, 23538, 23325, 23569, 24290, 24257, 24250, 24281, 24157, 24626, 25621, 25538, 25476, 25673, 26799, 26837, 26737, 27412, 27728, 27645, 27681, 27558, 28506, 29047, 28912, 28949, 28900, 29200, 29387, 29414, 29163, 28461, 28590, 27579, 31902, 16381, -32165, -32555, -32582, -32847, -32222, -29764, -29754, -29854, -29140, -28879, -28954, -28930, -29001, -28338, -28022, -28104, -28068, -28192, -27245, -26674, -26936, -26444, -25440, -25547, -25519, -25591, -25330, -24634, -24687, -24663, -24761, -24440, -23348, -23403, -23460, -22378, -22050, -22148, -22123, -22175, -21479, -21218, -21268, -21396, -20566, -19884, -20010, -20072, -19710, -19080, -19164, -19123, -19250, -18787, -17781, -17870, -17928, -17741, -16608, -16569, -16612, -16613, -15875, -15698, -15753, -15744, -15793, -14718, -14389, -14468, -14578, -13695, -13078, -13200, -13264, -12859, -12266, -12357, -12313, -12450, -11904, -10960, -11062, -11131, -10874, -9763, -9771, -9808, -9778, -9027, -8900, -8941, -8945, -8960, -7845, -7592, -7660, -7764, -6814, -6275, -6392, -6461, -6004, -5450, -5550, -5503, -5644, -5032, -4145, -4253, -4333, -4012, -2931, -2968, -3004, -2947, -2190, -2099, -2127, -2147, -2114, -988, -795, -860, -909, -246, 65, -13, -18};