/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0006 256 samples */
 
const int16_t AKWF_vgsqu_0006_256_DATA [256] = 
{16606, 31103, 27969, 28660, 28363, 29624, 30865, 30624, 30670, 30667, 30667, 30673, 30649, 30714, 31087, 31094, 31085, 31088, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31088, 31087, 31096, 31048, 31302, 31545, 31524, 31412, 31877, 32800, 32755, 32756, 32769, 31842, 35426, -2945, -35046, -29086, -30335, -30159, -30675, -31152, -31412, -31534, -31501, -31508, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31508, -31507, -31516, -31469, -31744, -31967, -31918, -31928, -31927, -31927, -31927, -31924, -31917, -31494, -33812, -12149, 2836, -745, 352, -1429};