/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0001 256 samples */
 
const int16_t AKWF_vgsaw_0001_256_DATA [256] = 
{1275, 1819, 2174, 4594, 4575, 4534, 4550, 4550, 4550, 4550, 4550, 4550, 4550, 4549, 4584, 4358, 6019, 7025, 6776, 6830, 6825, 6826, 6826, 6826, 6828, 6850, 6655, 8459, 9119, 9559, 11927, 11838, 11821, 11832, 11832, 11832, 11832, 11832, 11832, 11832, 11834, 11857, 11659, 13431, 14288, 14058, 14110, 14106, 14106, 14106, 14105, 14146, 13904, 15460, 16631, 16176, 16911, 18787, 18652, 18653, 18659, 18659, 18659, 18659, 18659, 18659, 18659, 18666, 18674, 18495, 20706, 21583, 21337, 21394, 21389, 21389, 21389, 21389, 21425, 21198, 22855, 23910, 23443, 24308, 26099, 25921, 25935, 25939, 25939, 25937, 25969, 25852, 26111, 28555, 28743, 28645, 28673, 28671, 28671, 28671, 28671, 28671, 28671, 28672, 28673, 28691, 28532, 29952, 30638, 30455, 30497, 30493, 30493, 30493, 30493, 30493, 30493, 30493, 30493, 30493, 30511, 30174, 31027, 29888, -20510, -34588, -32122, -32793, -32764, -32767, -32767, -32763, -32744, -32813, -30723, -29785, -30338, -28979, -27059, -27353, -27304, -27306, -27305, -27305, -27305, -27305, -27305, -27306, -27290, -27338, -27301, -25301, -24926, -25061, -25027, -25030, -25029, -25030, -25021, -25032, -25134, -23218, -22551, -23046, -21557, -19774, -20076, -20021, -20024, -20024, -20023, -20023, -20023, -20023, -20025, -20004, -20077, -19955, -17922, -17668, -17776, -17747, -17750, -17749, -17750, -17738, -17766, -17795, -15833, -15291, -15770, -14127, -12480, -12799, -12739, -12743, -12742, -12742, -12742, -12742, -12742, -12744, -12719, -12813, -12593, -10569, -10407, -10488, -10465, -10467, -10466, -10467, -10451, -10499, -10463, -8464, -8033, -8477, -6690, -5208, -5520, -5456, -5461, -5460, -5460, -5460, -5460, -5460, -5463, -5431, -5556, -5238, -3212, -3144, -3202, -3184, -3185, -3184, -3186, -3165, -3238, -3116, -1084, -813, -1017, -365, 81, -21, 1, -1, 0, 0, 0, -3, 15, -89};