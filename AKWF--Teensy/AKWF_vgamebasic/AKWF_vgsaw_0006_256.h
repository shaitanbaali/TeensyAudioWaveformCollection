/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0006 256 samples */
 
const int16_t AKWF_vgsaw_0006_256_DATA [256] = 
{403, 1919, 2331, 2217, 2246, 2243, 2244, 2244, 2243, 2268, 2118, 3044, 3738, 3466, 3901, 5010, 4931, 4932, 4933, 4965, 4807, 5595, 6412, 6254, 6283, 6309, 6174, 6976, 9101, 9525, 9392, 9427, 9424, 9424, 9422, 9452, 9299, 10079, 10896, 10770, 10671, 11144, 12208, 12107, 12116, 12116, 12145, 11992, 12849, 13590, 13433, 13495, 13356, 14010, 15811, 16247, 16131, 16160, 16158, 16158, 16158, 16156, 16194, 15987, 17134, 18123, 17944, 17844, 18394, 19411, 19284, 19300, 19300, 19325, 19176, 20104, 20771, 20616, 20676, 20529, 21369, 22086, 23100, 23416, 23320, 23343, 23341, 23341, 23340, 23364, 23221, 24145, 24805, 24697, 24531, 25372, 26639, 26454, 26482, 26511, 26357, 27138, 27955, 27802, 27830, 27853, 27710, 28620, 29305, 29944, 30116, 30064, 30076, 30076, 30074, 30095, 29989, 30516, 31052, 30998, 30095, 34391, 9889, -21455, -16154, -17084, -17353, -15629, -25292, -33572, -32508, -32748, -32856, -31853, -30843, -30964, -29732, -29580, -29643, -29626, -29627, -29630, -29592, -29795, -28652, -27661, -27871, -27797, -27958, -27170, -26353, -26511, -26482, -26460, -26602, -25679, -25014, -25166, -25107, -25266, -24390, -23705, -23734, -22496, -22408, -22456, -22443, -22443, -22444, -22419, -22567, -21640, -20973, -21129, -21059, -21265, -20124, -19134, -19343, -19269, -19430, -18642, -17825, -17983, -17954, -17932, -18076, -17134, -16543, -16497, -15277, -15238, -15271, -15260, -15262, -15232, -15390, -14606, -13787, -13941, -13914, -13890, -14039, -13110, -12443, -12599, -12528, -12736, -11594, -10605, -10813, -10741, -10898, -10110, -9277, -9519, -9235, -8059, -8057, -8170, -7065, -6634, -6758, -6730, -6733, -6732, -6734, -6703, -6840, -6190, -4380, -3952, -4066, -4036, -4039, -4038, -4038, -4041, -4003, -4208, -3067, -2055, -2364, -1990, -845, -894, -902, -896, -897, -881, -977, -362, 81, -21, 9, -35};