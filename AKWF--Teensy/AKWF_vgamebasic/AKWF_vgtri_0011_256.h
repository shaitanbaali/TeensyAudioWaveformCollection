/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0011 256 samples */
 
const int16_t AKWF_vgtri_0011_256_DATA [256] = 
{1229, 1381, 1172, 2074, 2690, 2688, 4270, 4443, 4224, 5146, 5749, 5749, 7335, 7501, 7300, 8180, 8831, 10193, 10579, 10479, 10367, 11276, 11855, 11888, 13469, 13611, 13405, 14338, 14937, 14870, 16776, 18004, 17900, 17929, 17850, 18046, 19605, 19724, 19527, 20482, 21024, 21086, 22697, 22633, 23317, 24177, 23936, 24179, 25726, 25838, 25643, 26621, 27137, 27209, 28798, 28900, 28715, 29571, 31614, 31989, 31865, 31891, 31933, 31619, 31386, 31586, 31077, 29596, 29867, 28578, 27864, 27867, 26660, 26600, 26809, 25512, 24727, 25032, 24601, 23495, 23739, 22451, 21674, 21938, 21686, 19813, 18643, 18819, 18761, 18881, 18466, 17379, 17623, 16301, 15555, 15860, 15402, 14321, 14559, 13239, 12498, 12802, 12335, 11256, 11503, 10163, 9439, 9746, 9262, 8201, 8426, 7123, 6356, 5369, 5192, 5239, 5367, 4025, 3328, 3631, 3133, 2078, 2322, 965, 278, 539, 184, -511, -301, -1672, -2350, -2047, -2562, -3601, -3364, -4741, -5404, -5101, -5659, -6487, -7555, -8460, -8288, -8199, -8697, -9721, -9480, -10882, -11520, -11218, -11761, -12785, -12532, -13936, -15678, -15760, -15713, -15739, -15616, -17019, -17636, -17332, -17896, -18901, -18661, -20120, -20582, -20744, -21901, -21857, -21740, -23163, -23745, -23448, -24028, -25018, -24787, -26224, -26799, -26540, -26931, -28914, -29860, -29670, -29740, -29598, -30168, -31132, -30915, -32342, -32820, -32817, -32289, -31347, -31564, -30101, -29564, -29859, -29228, -28285, -28508, -27029, -26504, -26797, -26159, -25230, -25422, -24010, -23329, -22321, -22252, -22294, -22354, -20892, -20395, -20684, -20032, -19110, -19318, -17819, -17336, -17626, -16959, -16057, -16230, -14809, -14139, -13129, -13089, -13099, -13149, -13054, -11451, -11454, -10671, -9550, -8731, -8196, -8289, -8458, -7588, -6383, -6618, -6499, -5295, -5357, -4540, -3322, -3562, -3437, -2225, -2305, -1467, -257, -513, -359};