/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0003 256 samples */
 
const int16_t AKWF_vgsin_0003_256_DATA [256] = 
{1601, 1258, 1318, 1309, 1310, 1310, 1310, 1310, 1309, 1320, 1376, 905, 5243, 11908, 12389, 12164, 12237, 12232, 12232, 12232, 12232, 12232, 12224, 12319, 11969, 13126, 19247, 21771, 21315, 21411, 21407, 21407, 21407, 21407, 21407, 21407, 21405, 21445, 21305, 21547, 25437, 25934, 25727, 25777, 25826, 25597, 26360, 28540, 28391, 28393, 28396, 28446, 28192, 29452, 30794, 30538, 30587, 30583, 30592, 30565, 30588, 31740, 31956, 31877, 31902, 31882, 31922, 32311, 32343, 32327, 32332, 32331, 32332, 32316, 32410, 31814, 31379, 31479, 31421, 31625, 30510, 29545, 29748, 29706, 29710, 29712, 29672, 29839, 29341, 27055, 27061, 27065, 27212, 26787, 24068, 23972, 24052, 24028, 24029, 24030, 24014, 24029, 24217, 20562, 19386, 19648, 20086, 16813, 14420, 14958, 14846, 14855, 14854, 14853, 14862, 14750, 15309, 12546, 9498, 10450, 9180, 3856, 3864, 3966, 3927, 3930, 3929, 3934, 3869, 4106, 3573, -1478, -1980, -1238, -5143, -7446, -6877, -7000, -6990, -6990, -6990, -6991, -6996, -7057, -6546, -11031, -12847, -13412, -17659, -17489, -17455, -17476, -17475, -17475, -17475, -17476, -17468, -17571, -17089, -19162, -21916, -24829, -26558, -26125, -26221, -26213, -26213, -26213, -26214, -26212, -26231, -26173, -26254, -28377, -29460, -31109, -31016, -31016, -31022, -31021, -31021, -31021, -31021, -31022, -31020, -31046, -30904, -31775, -32769, -32763, -32764, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32756, -32807, -32499, -31842, -31902, -31896, -31898, -31859, -32062, -30948, -29983, -30185, -30145, -30139, -30146, -30267, -28053, -27355, -27571, -27519, -27528, -27468, -27728, -26831, -24305, -24474, -24482, -24373, -24834, -23033, -19740, -20153, -20100, -20098, -20086, -20070, -20393, -16485, -14949, -15382, -15258, -15322, -15398, -11255, -10226, -10560, -10478, -10484, -10495, -10350, -11048, -7843, -3794, -4497, -4248, -4834, -2333};