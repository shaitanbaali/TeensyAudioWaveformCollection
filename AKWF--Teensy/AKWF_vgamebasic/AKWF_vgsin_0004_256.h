/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0004 256 samples */
 
const int16_t AKWF_vgsin_0004_256_DATA [256] = 
{4094, 4534, 4394, 3894, 7987, 10549, 9924, 10059, 10047, 10048, 10043, 10106, 9874, 10406, 14662, 14987, 14866, 14468, 18017, 20076, 19555, 19668, 19658, 19659, 19655, 19709, 19506, 20005, 23480, 23688, 23595, 23323, 25960, 27379, 27013, 27094, 27087, 27086, 27111, 27031, 27130, 29451, 29824, 29675, 29725, 29612, 30623, 31127, 30994, 31024, 31021, 31020, 31034, 30988, 31060, 32228, 32382, 32315, 32333, 32331, 32331, 32331, 32331, 32331, 32331, 32332, 32322, 32357, 32297, 31516, 31427, 31464, 31447, 31569, 30176, 29576, 29745, 29706, 29710, 29712, 29681, 29795, 29558, 27218, 27007, 27105, 27075, 27268, 24765, 23805, 24088, 24024, 24031, 24004, 24080, 24036, 20988, 20360, 20585, 20469, 20902, 17660, 15784, 16259, 16156, 16164, 16167, 16121, 16257, 16119, 11518, 10677, 11000, 10894, 10930, 11155, 6738, 5329, 5776, 5669, 5682, 5632, 5788, 5577, 958, 213, 506, 405, 457, 632, -3824, -5138, -4710, -4813, -4800, -4857, -4668, -4971, -9999, -10704, -10412, -10517, -10451, -10339, -14464, -15579, -15209, -15297, -15312, -15258, -15191, -18590, -19452, -19157, -19228, -19250, -19177, -19143, -22935, -23828, -23523, -23596, -23615, -23548, -23553, -26587, -27276, -27031, -27091, -27105, -27053, -27058, -29353, -29846, -29669, -29712, -29722, -29683, -29705, -31234, -31544, -31432, -31459, -31467, -31434, -31471, -32558, -32800, -32755, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32754, -32798, -32062, -30664, -30542, -30600, -30582, -30584, -30583, -30583, -30583, -30583, -30584, -30573, -30567, -30754, -28378, -25016, -24827, -24939, -24900, -24904, -24903, -24903, -24903, -24903, -24904, -24886, -24884, -25136, -21495, -16704, -16510, -16649, -16597, -16602, -16601, -16601, -16601, -16601, -16603, -16574, -16595, -16871, -11943, -6155, -6028, -6170, -6112, -6117, -6116, -6116, -6116, -6117, -6103, -6110, -6313, -2996, -1118};