/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0011 256 samples */
 
const int16_t AKWF_vgsqu_0011_256_DATA [256] = 
{20007, 34217, 32182, 31559, 31464, 31589, 30962, 30596, 30685, 30666, 30673, 30636, 30958, 31121, 31079, 31088, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31088, 31079, 31127, 30884, 30639, 30639, 30760, 31504, 31521, 31513, 31474, 31563, 32619, 32295, 34189, 12633, -2363, -1806, -29150, -30825, -30771, -32108, -31893, -31929, -31926, -31918, -31994, -31371, -30997, -31165, -31510, -31512, -31505, -31508, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31508, -31507, -31515, -31470, -31766, -31967, -31918, -31928, -31927, -31929, -31909, -31990, -31761, -30626, -30836, -29429, -29729, -27391, -1474, 1161, -1997};