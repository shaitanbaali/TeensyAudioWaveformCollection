/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0001 256 samples */
 
const int16_t AKWF_vgsqu_0001_256_DATA [256] = 
{27252, 30516, 29077, 29395, 30301, 30799, 30669, 30698, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30696, 30693, 30698, 30706, 30347, 30256, 30287, 30279, 30279, 30279, 30279, 30279, 30279, 30278, 30306, 29889, 31027, 29240, -21182, -34469, -32102, -32800, -32763, -32768, -32746, -32831, -32396, -30671, -30672, -30711, -30688, -30693, -31056, -31129, -31103, -31110, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31110, -31109, -31115, -31093, -31143, -31510, -31535, -31520, -31524, -31523, -31523, -31523, -31523, -31523, -31520, -31564, -31022, -32894, -24947};