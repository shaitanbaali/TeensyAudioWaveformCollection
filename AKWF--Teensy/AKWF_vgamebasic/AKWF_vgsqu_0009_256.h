/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0009 256 samples */
 
const int16_t AKWF_vgsqu_0009_256_DATA [256] = 
{26729, 33084, 32213, 31184, 30086, 30325, 30276, 30280, 30279, 30284, 30269, 30297, 30667, 30709, 30690, 30696, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30696, 30690, 30710, 30662, 30293, 30272, 30289, 30227, 30897, 31110, 31331, 30231, 28032, 27608, 30022, 24722, -25477, -30256, -28063, -28454, -30690, -31740, -31528, -31309, -30601, -30931, -31150, -31100, -31110, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31110, -31104, -31124, -31077, -30709, -30686, -30699, -30695, -30696, -30692, -30740, -30505, -31606, -32553, -33343, -26891};