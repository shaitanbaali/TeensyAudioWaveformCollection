/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0014 256 samples */
 
const int16_t AKWF_vgsaw_0014_256_DATA [256] = 
{253, 480, 844, 1406, 1370, 1588, 1885, 2176, 2409, 2731, 2953, 3306, 3245, 3595, 3818, 4141, 4376, 4672, 4952, 5195, 5515, 5741, 6052, 6313, 6576, 6883, 7111, 7432, 7671, 7957, 8244, 8483, 8807, 9036, 9338, 9614, 9856, 9855, 10194, 10571, 11247, 11490, 11718, 12109, 12649, 12602, 12842, 13123, 13421, 13653, 13976, 14209, 14504, 14786, 15026, 15359, 15524, 16091, 16424, 16351, 16759, 16850, 16959, 17304, 17562, 17819, 18130, 18356, 18674, 18921, 19202, 19496, 19729, 20052, 20282, 20582, 20858, 21108, 21425, 21651, 21963, 22217, 22488, 22794, 23009, 23392, 23374, 23627, 23877, 24567, 24933, 25212, 25460, 25747, 26038, 26272, 26608, 26775, 27354, 27657, 27600, 27973, 28191, 28511, 28758, 29034, 29330, 29562, 29887, 30114, 30461, 30399, 30752, 30965, 31338, 31384, 31322, 31646, 31874, 32233, 32323, 32288, 32340, 31783, 33329, 24351, -15958, -23825, -32559, -32256, -32806, -32753, -32762, -32790, -32503, -32270, -32289, -31850, -31860, -31634, -31326, -31371, -30993, -30780, -30465, -30212, -29942, -29635, -29407, -29084, -28845, -28560, -28289, -27674, -27627, -27515, -27168, -26911, -26660, -26311, -26217, -26087, -25800, -25282, -24392, -24347, -24273, -23908, -23669, -23393, -23096, -22865, -22542, -22308, -22010, -21732, -21487, -21169, -20943, -20631, -20372, -20106, -19802, -19571, -19251, -19019, -18689, -18746, -18379, -18163, -17842, -17596, -17321, -17032, -16426, -16399, -16261, -15927, -15665, -15409, -15093, -14866, -14551, -14301, -14029, -13721, -13534, -13053, -12603, -12683, -12351, -12147, -12120, -11792, -11371, -10732, -10491, -10243, -9920, -9695, -9386, -9122, -8865, -8553, -8328, -8008, -7763, -7480, -7189, -6955, -6632, -6402, -6101, -5826, -5583, -5222, -5158, -5010, -4684, -4412, -4166, -3848, -3623, -3310, -3053, -2786, -2471, -2293, -1793, -1365, -1444, -1116, -879, -556, -332, -2};