/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0016 256 samples */
 
const int16_t AKWF_vgsqu_0016_256_DATA [256] = 
{15818, 31317, 29858, 29875, 29305, 29106, 28882, 28907, 28972, 28709, 28094, 28144, 28138, 28473, 28548, 28522, 28528, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28534, 28508, 28576, 28995, 28566, 28068, 28159, 28134, 28171, 28069, 27310, 29197, 30221, 29307, 35682, 3385, -35050, -29397, -28109, -27704, -28161, -28334, -28575, -28481, -28634, -29299, -29343, -29072, -28879, -28922, -28913, -28914, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28914, -28910, -28926, -28891, -28564, -28446, -28882, -29372, -29284, -29307, -29282, -29350, -30175, -30233, -28684, -22331, 650, -1099};