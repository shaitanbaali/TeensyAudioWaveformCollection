/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0007 256 samples */
 
const int16_t AKWF_vgsin_0007_256_DATA [256] = 
{2585, 4210, 6762, 6525, 6546, 6552, 6549, 6624, 6191, 8794, 10848, 10393, 10555, 10265, 11414, 15760, 17315, 16963, 17045, 17039, 17037, 17066, 16969, 17129, 19849, 20213, 20107, 19845, 22041, 25163, 25413, 25306, 25342, 25339, 25336, 25381, 25191, 25821, 27631, 27518, 27539, 27451, 27699, 29243, 29311, 29262, 29203, 30275, 30675, 30558, 30600, 30506, 31126, 31534, 31457, 31387, 31737, 32399, 32322, 32331, 32331, 32331, 32332, 32329, 32336, 32341, 31960, 31872, 31894, 31934, 31642, 31417, 31469, 31427, 31581, 30909, 30023, 30174, 30112, 30277, 29685, 28277, 28418, 28466, 26965, 26543, 26680, 26636, 26656, 26747, 24536, 23865, 24075, 23990, 24249, 22241, 21319, 21134, 18365, 18297, 18372, 18353, 18292, 18556, 17695, 15138, 15266, 15358, 15285, 12123, 11900, 10813, 8479, 8778, 8736, 8743, 8641, 9157, 6694, 3947, 4460, 4299, 4618, 3338, 1479, -1248, -3454, -2963, -3066, -3057, -3076, -3029, -3005, -5648, -6278, -6145, -5735, -8588, -10813, -12938, -13727, -13490, -13547, -13538, -13595, -13365, -14020, -17081, -17079, -17041, -17011, -16981, -20244, -23279, -23159, -23138, -23157, -23156, -23152, -23200, -22946, -24279, -25547, -25331, -25232, -25671, -28269, -29416, -29241, -29274, -29273, -29273, -29279, -29278, -29178, -30609, -31142, -30989, -31038, -30943, -31563, -31972, -31894, -31825, -32173, -32792, -32758, -32767, -32767, -32767, -32768, -32766, -32769, -32752, -32397, -32308, -32338, -32328, -32349, -32057, -31794, -30665, -30542, -30598, -30584, -30564, -30653, -30395, -29253, -29261, -29265, -29315, -29212, -27656, -27461, -27535, -27528, -27605, -25769, -25137, -25656, -24169, -22006, -22332, -22285, -22234, -22475, -21477, -19913, -20084, -20247, -19725, -16645, -16492, -16897, -14648, -13271, -13610, -13537, -13531, -13529, -13774, -10543, -9337, -9600, -9985, -7750, -5348, -5785, -2653, -2009, -2235, -2185, -2136, -2335, -1892};