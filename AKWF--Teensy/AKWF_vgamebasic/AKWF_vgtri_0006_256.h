/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0006 256 samples */
 
const int16_t AKWF_vgtri_0006_256_DATA [256] = 
{2467, 2856, 2700, 2736, 2597, 4860, 5705, 5173, 6437, 8424, 8151, 8188, 8190, 8189, 8242, 7911, 10175, 11666, 11302, 11439, 11166, 12407, 16043, 17032, 16782, 16844, 16846, 16859, 16631, 19201, 20260, 19960, 20028, 20039, 19995, 19979, 22355, 22899, 22713, 22759, 22751, 22806, 22583, 23239, 25993, 25967, 25945, 25907, 25916, 28870, 31533, 31401, 31389, 31404, 31403, 31403, 31403, 31409, 31398, 31359, 32454, 32771, 32883, 31703, 29814, 30077, 30038, 30037, 30037, 30000, 30264, 28269, 27069, 27369, 27234, 27571, 25976, 22087, 21211, 21444, 21385, 21390, 21389, 21389, 21394, 21330, 21621, 20510, 18418, 18733, 18689, 15908, 15314, 15519, 15470, 15442, 15561, 15295, 12871, 12666, 12771, 12715, 12773, 12773, 9645, 6677, 6830, 6841, 6825, 6826, 6826, 6822, 6799, 7029, 4923, 3881, 4091, 4338, 3014, 1123, 1409, 1363, 1367, 1310, 1621, -75, -1622, -1302, -1429, -1121, -2404, -4116, -5845, -7058, -6768, -6832, -6826, -6827, -6821, -6884, -6616, -7493, -10164, -10031, -9957, -10012, -12422, -12869, -12704, -12743, -12775, -12642, -12956, -15390, -15535, -15468, -15435, -15476, -18051, -19309, -21435, -21407, -21376, -21390, -21390, -21389, -21395, -21414, -21192, -23343, -24330, -24135, -23826, -25442, -27603, -27249, -27302, -27365, -27054, -28414, -30283, -29991, -30033, -30096, -29800, -31066, -32886, -32419, -32273, -32322, -32313, -32313, -32317, -32276, -32437, -32013, -29539, -29799, -28236, -26587, -26909, -26848, -26852, -26853, -26828, -26905, -26836, -24016, -23522, -23703, -23647, -23832, -21550, -20903, -20466, -18099, -18196, -18215, -18203, -18203, -18205, -18146, -18498, -16306, -14721, -15093, -14952, -15272, -13822, -12037, -12337, -12289, -12226, -12545, -11129, -9300, -9612, -9491, -9799, -8684, -6136, -6593, -4475, -3422, -3697, -3635, -3641, -3644, -3600, -3772, -3291, -903, -874, -906, -980, -834};