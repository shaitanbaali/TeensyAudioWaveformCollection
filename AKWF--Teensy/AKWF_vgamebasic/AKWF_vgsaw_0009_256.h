/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0009 256 samples */
 
const int16_t AKWF_vgsaw_0009_256_DATA [256] = 
{406, 1705, 1992, 1905, 1927, 1934, 1900, 1978, 2664, 2720, 2690, 2664, 3338, 3426, 3778, 4707, 4612, 4636, 4571, 4798, 5436, 5401, 5368, 5446, 6136, 6191, 6158, 6116, 7093, 7413, 7231, 7663, 8163, 8094, 8042, 8275, 8906, 8874, 8824, 8960, 9906, 10305, 10843, 10783, 10790, 10809, 10720, 11126, 11634, 11570, 11484, 11834, 12792, 12711, 12702, 13372, 13533, 13490, 13429, 13995, 14326, 14272, 14157, 14768, 15536, 15363, 15514, 16112, 16497, 17025, 16949, 16961, 16961, 16979, 16863, 17713, 18234, 18034, 18338, 18948, 18870, 18889, 19571, 19694, 19655, 19652, 19637, 20636, 20895, 20725, 21194, 21660, 21585, 21553, 21699, 22921, 23614, 23492, 23515, 23530, 23442, 23934, 24357, 24268, 24303, 24213, 24679, 25103, 25081, 26132, 26254, 26205, 26210, 26216, 26557, 26618, 26596, 26602, 26593, 26682, 25387, 32013, -1375, -35632, -31973, -31717, -26933, -26923, -27024, -26982, -26644, -26583, -26603, -26616, -26365, -26107, -25117, -25028, -25071, -25047, -25099, -24950, -24273, -24273, -24302, -24284, -23605, -23459, -23633, -22877, -22251, -22368, -22421, -22100, -21527, -21587, -21628, -21476, -20804, -20805, -20878, -19980, -19499, -18919, -18874, -18895, -18891, -18873, -18955, -18634, -18045, -18157, -18080, -17047, -16908, -17044, -16500, -16120, -16208, -16174, -16261, -15767, -15328, -15503, -15204, -14222, -14254, -14274, -14278, -13440, -12683, -12723, -12724, -12722, -12696, -12826, -12269, -11463, -11570, -11611, -11418, -10752, -10857, -10286, -9955, -10040, -10000, -10126, -9326, -8761, -8876, -8932, -8571, -8027, -8096, -8140, -7952, -7292, -7323, -7378, -6395, -6094, -6174, -6234, -5700, -5328, -5396, -5462, -5084, -4640, -3821, -3379, -3493, -3463, -3470, -3501, -2852, -2651, -2697, -2767, -2237, -1835, -2025, -1655, -703, -767, -798, -719, -31, 20, -8, 0, 0, -2, 6, -31};