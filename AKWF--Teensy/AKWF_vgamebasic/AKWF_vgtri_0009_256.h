/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0009 256 samples */
 
const int16_t AKWF_vgtri_0009_256_DATA [256] = 
{258, 518, 293, 872, 2746, 2678, 2596, 2719, 4695, 4954, 4854, 4758, 6187, 6766, 6654, 6461, 7610, 10555, 11206, 11024, 11071, 11080, 11043, 11074, 12630, 12919, 12842, 12668, 14390, 15112, 15376, 17328, 17280, 17281, 17191, 17462, 19030, 19080, 19011, 18986, 20902, 21424, 21037, 22163, 24812, 25349, 25204, 25242, 25237, 25264, 25163, 25403, 27369, 27539, 27245, 28940, 29770, 29858, 31464, 31459, 31428, 31448, 31411, 31533, 31896, 31887, 31964, 30088, 29536, 29676, 29825, 28606, 27737, 27887, 28086, 27083, 25466, 25780, 25574, 23593, 23396, 23486, 23539, 22209, 21325, 19534, 19444, 19502, 19445, 19611, 19090, 17203, 17245, 17313, 17233, 15669, 15384, 15727, 14235, 13080, 13283, 13470, 12533, 10888, 11074, 11157, 10830, 9277, 9267, 9308, 9397, 7195, 4823, 4851, 4886, 4872, 4834, 5004, 4370, 2974, 3085, 3187, 2893, 892, 1004, -27, -1051, -844, -925, -718, -1699, -2819, -2663, -2500, -3185, -5004, -4865, -4757, -6827, -8892, -8868, -8840, -8856, -8850, -8903, -8652, -9743, -11296, -10953, -11222, -13240, -13168, -14137, -15226, -15017, -15055, -15094, -14854, -16338, -17513, -17082, -17718, -19577, -19501, -19433, -19546, -21121, -21321, -21246, -21117, -22893, -23678, -23231, -24291, -25869, -25676, -25579, -26017, -27289, -28470, -29866, -29622, -29720, -29468, -30526, -32081, -31844, -31903, -31809, -32160, -32792, -32774, -32660, -30776, -30462, -30560, -30714, -28975, -28169, -28350, -28503, -27472, -26403, -26567, -26680, -26185, -23287, -21947, -22186, -22138, -22139, -22116, -22287, -20975, -20223, -20357, -20575, -19392, -17976, -18202, -16219, -15837, -15963, -15945, -15999, -14483, -14068, -14159, -14368, -12821, -11718, -12118, -11601, -8940, -7823, -8006, -7970, -7971, -7965, -7962, -8091, -6266, -5554, -5997, -4859, -3355, -3619, -2038, -1675, -1799, -1753, -1809, -1724, -156, 71, -44};