/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0008 256 samples */
 
const int16_t AKWF_vgsqu_0008_256_DATA [256] = 
{27110, 32454, 31134, 31654, 30672, 30501, 30749, 30685, 30696, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30703, 30668, 30784, 31129, 31108, 31108, 31110, 31109, 31113, 31049, 31389, 29623, 27920, 28374, 26990, 32868, 10776, -33825, -30914, -31434, -31522, -31523, -31524, -31509, -31601, -31045, -30617, -30722, -30664, -30789, -31130, -31109, -31108, -31110, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31110, -31105, -31119, -31097, -30730, -30679, -30701, -30695, -30694, -30708, -30651, -30812, -31533, -31535, -31541, -31105, -33187, -26201};