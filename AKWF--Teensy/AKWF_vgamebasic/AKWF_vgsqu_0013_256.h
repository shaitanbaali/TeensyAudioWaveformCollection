/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0013 256 samples */
 
const int16_t AKWF_vgsqu_0013_256_DATA [256] = 
{17398, 34023, 27758, 27065, 27563, 27785, 27670, 28631, 28941, 28148, 28126, 28154, 28135, 28149, 28489, 28544, 28523, 28528, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28530, 28525, 28522, 28840, 28997, 28676, 28017, 28632, 28968, 28938, 29242, 29371, 27863, 27854, -18887, -35002, -31415, -30553, -29175, -27920, -28216, -28523, -28465, -28875, -29415, -28709, -28448, -28625, -28930, -28914, -28912, -28914, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28914, -28913, -28920, -28893, -28977, -29309, -29302, -29288, -29326, -29259, -28450, -28904, -29785, -29679, -29739, -32601, -22515, 249};