/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0002 256 samples */
 
const int16_t AKWF_vgsaw_0002_256_DATA [256] = 
{786, 1447, 3289, 3760, 3605, 3642, 3639, 3640, 3640, 3640, 3640, 3640, 3635, 3687, 3450, 4352, 6094, 5888, 5914, 5916, 5915, 5926, 5906, 5840, 7795, 8324, 8157, 8204, 8081, 9553, 10140, 9975, 10013, 10010, 10010, 10010, 10010, 10013, 10028, 9859, 11713, 12317, 12695, 14661, 14564, 14553, 14562, 14562, 14562, 14562, 14562, 14562, 14562, 14562, 14590, 14400, 15707, 16547, 16344, 16386, 16381, 16407, 16318, 16504, 18528, 18727, 18633, 18691, 18564, 18879, 20903, 20977, 20915, 20934, 20933, 20933, 20932, 20948, 20904, 20923, 22917, 23358, 23007, 24122, 25200, 24992, 25032, 25029, 25029, 25029, 25029, 25029, 25029, 25035, 25053, 24867, 26852, 29521, 29632, 29558, 29586, 29583, 29583, 29583, 29583, 29583, 29584, 29579, 29643, 29338, 30599, 32557, 32269, 32314, 32313, 32312, 32334, 31883, 33432, 26313, -15709, -18515, -16823, -16788, -29221, -33298, -32587, -32775, -32766, -32767, -32767, -32767, -32768, -32753, -32795, -32532, -30462, -29359, -27660, -27771, -27766, -27761, -27762, -27761, -27761, -27761, -27761, -27761, -27759, -27735, -27933, -26188, -25301, -25533, -25481, -25486, -25485, -25489, -25445, -25647, -24826, -23509, -23660, -23782, -23340, -21352, -21368, -21403, -21389, -21390, -21389, -21389, -21389, -21393, -21346, -21556, -20766, -19184, -17838, -16628, -16889, -16836, -16840, -16839, -16839, -16839, -16839, -16839, -16841, -16821, -16891, -16742, -15121, -14962, -15036, -15015, -15016, -15019, -14971, -15234, -13836, -12528, -12794, -12689, -12953, -11749, -10258, -10509, -10465, -10467, -10467, -10466, -10466, -10470, -10427, -10633, -9693, -8504, -8715, -6692, -6256, -6404, -6368, -6371, -6370, -6370, -6370, -6370, -6370, -6375, -6324, -6555, -5682, -3920, -4120, -4097, -4095, -4093, -4068, -4268, -2541, -1634, -1868, -1813, -1809, -1932, -467, 134, -36, 2, -1, 0, 0, -3, 13, -70};