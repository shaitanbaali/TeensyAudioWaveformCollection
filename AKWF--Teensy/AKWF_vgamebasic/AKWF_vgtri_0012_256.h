/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0012 256 samples */
 
const int16_t AKWF_vgtri_0012_256_DATA [256] = 
{851, 788, 1440, 3534, 4077, 3981, 3891, 4312, 5405, 5201, 6216, 6691, 6763, 7996, 7867, 8642, 9366, 10317, 10714, 10637, 10460, 11522, 12542, 12367, 13615, 13667, 14169, 15170, 14972, 16013, 16596, 17656, 17764, 17581, 18524, 19181, 18927, 19294, 20451, 20207, 21443, 22255, 22219, 23310, 23913, 24893, 24771, 24773, 25952, 26091, 26496, 27558, 27348, 28402, 28913, 28652, 29185, 30032, 31098, 32056, 31820, 31952, 32306, 32456, 31579, 30906, 30984, 29736, 29743, 29161, 28221, 28418, 27277, 26887, 27192, 26333, 25085, 25331, 24158, 23915, 23632, 22487, 22701, 21712, 21191, 21152, 19912, 20026, 19286, 18455, 18679, 18473, 17254, 17413, 16428, 15344, 15539, 14299, 14218, 13756, 12729, 12938, 11825, 11496, 11291, 10112, 10301, 9393, 8711, 8962, 8627, 7460, 7680, 6486, 5634, 5720, 4464, 4512, 3865, 2985, 3162, 1962, 1796, 1429, 332, 525, -128, -1608, -1831, -1752, -1793, -1628, -3000, -3626, -3672, -4908, -4760, -5566, -6316, -6140, -7571, -8904, -8863, -8847, -8796, -9901, -10300, -10043, -10660, -11631, -11398, -12910, -13348, -13413, -15132, -16050, -15933, -15888, -16060, -17268, -17168, -17900, -18707, -18562, -19755, -20019, -19813, -20379, -22456, -23158, -23016, -22918, -23438, -24463, -24245, -25342, -25705, -25904, -26924, -27608, -28448, -28285, -29460, -29743, -29673, -29543, -30433, -31071, -31056, -32573, -32827, -32564, -32295, -32357, -31309, -30736, -29676, -29635, -29782, -28748, -28295, -28199, -27005, -26974, -27130, -26106, -25648, -25480, -24038, -23402, -22469, -22627, -22563, -21357, -21315, -20799, -19807, -20022, -18880, -18591, -18353, -17184, -17385, -16450, -15791, -16084, -15589, -14072, -14290, -13350, -12765, -12774, -11525, -11606, -10917, -10075, -10227, -9017, -8894, -8474, -7421, -7553, -7559, -6364, -6267, -5713, -4291, -4536, -3467, -3066, -2923, -1722, -1884, -1024, -350, -423};