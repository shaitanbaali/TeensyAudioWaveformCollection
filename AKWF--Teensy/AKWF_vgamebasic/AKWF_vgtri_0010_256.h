/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0010 256 samples */
 
const int16_t AKWF_vgtri_0010_256_DATA [256] = 
{1016, 1929, 1598, 2109, 3578, 3486, 3456, 4821, 5619, 7003, 7013, 6957, 7004, 8167, 8386, 8123, 9291, 10240, 9900, 10399, 11896, 11657, 12958, 13685, 13543, 13383, 14338, 15479, 15175, 15494, 17041, 17079, 16906, 18333, 18805, 19112, 20611, 20549, 20480, 20615, 22172, 22365, 22108, 23357, 24218, 23862, 24475, 25903, 25639, 27031, 27658, 27524, 27358, 28441, 29397, 29310, 30910, 31099, 30889, 31843, 32416, 32427, 31900, 30469, 30611, 30612, 29082, 28712, 29027, 27940, 26896, 27221, 26811, 25292, 25324, 25439, 23989, 23436, 23783, 22885, 21664, 21940, 21707, 20145, 20033, 20250, 18929, 18169, 18527, 17823, 16454, 16651, 16576, 15031, 14748, 15041, 13859, 12910, 13256, 12743, 11274, 11364, 11428, 9898, 9646, 9114, 7723, 7905, 7849, 6685, 6465, 6729, 5560, 4617, 4914, 4602, 2363, 1163, 1342, 1312, 1272, 1471, 513, -619, -341, -590, -1749, -1791, -1602, -2997, -5139, -5295, -5219, -5262, -5194, -5323, -6881, -7073, -6815, -8075, -8924, -8609, -9021, -11300, -12380, -12197, -12231, -12269, -12065, -13131, -14175, -13848, -14262, -15791, -15598, -16785, -17651, -18617, -18843, -18781, -18768, -18773, -20296, -20657, -20344, -21430, -22473, -22145, -22597, -23905, -24849, -25932, -25739, -25818, -25617, -26481, -27705, -27429, -27671, -29224, -29334, -29135, -30402, -31250, -32541, -32800, -32746, -32779, -32661, -31207, -30914, -31208, -30027, -29078, -29426, -28873, -27612, -26629, -25623, -25778, -25913, -25252, -23892, -24073, -24007, -22843, -22633, -22896, -21704, -20873, -20863, -19269, -19178, -19243, -19277, -17793, -17335, -17668, -16677, -15537, -15843, -15511, -13946, -14119, -12996, -12070, -12233, -12382, -11619, -10319, -10558, -10400, -8846, -8654, -8914, -7625, -6912, -6824, -5245, -5207, -5272, -5263, -3737, -3372, -3688, -2594, -1552, -1879, -1465, 36, 12, -9, 0, -4, 16, -88};