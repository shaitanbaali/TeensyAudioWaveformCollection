/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0002 256 samples */
 
const int16_t AKWF_vgtri_0002_256_DATA [256] = 
{2036, 2344, 2213, 2246, 2243, 2244, 2244, 2244, 2238, 2312, 1998, 3049, 5973, 8452, 11183, 10679, 10778, 10771, 10772, 10772, 10772, 10772, 10772, 10769, 10813, 10651, 11009, 14614, 14925, 14772, 14815, 14812, 14810, 14884, 14447, 17184, 19221, 18759, 18949, 18426, 21269, 23758, 23244, 23348, 23341, 23341, 23341, 23342, 23337, 23417, 22963, 25789, 27572, 27724, 31817, 31956, 31837, 31874, 31871, 31871, 31871, 31871, 31871, 31871, 31872, 31847, 31992, 31080, 30401, 30553, 30521, 30527, 30475, 30668, 30244, 26238, 25915, 26081, 25971, 26232, 25477, 21956, 21952, 22017, 21992, 21993, 21993, 21996, 21948, 22127, 21729, 17725, 17318, 17899, 14901, 13110, 13552, 13456, 13464, 13464, 13464, 13464, 13464, 13467, 13427, 13517, 13480, 8810, 4671, 4961, 4952, 4935, 4936, 4936, 4936, 4936, 4936, 4935, 4933, 4890, 5234, 2131, 573, 979, 888, 896, 895, 902, 808, 1269, -856, -3511, -3140, -2866, -4066, -7392, -7168, -7170, -7181, -7180, -7180, -7180, -7181, -7172, -7280, -6769, -9137, -11830, -14586, -16013, -15628, -15715, -15708, -15708, -15708, -15708, -15708, -15709, -15701, -15796, -15374, -16934, -20499, -20164, -20192, -20200, -20198, -20219, -20174, -20102, -23575, -24459, -24192, -24246, -24052, -27455, -28533, -28207, -28284, -28277, -28277, -28278, -28277, -28299, -28247, -28185, -31857, -33053, -31945, -30353, -30550, -30525, -30524, -30523, -30523, -30523, -30523, -30523, -30525, -30501, -30555, -30636, -26770, -25789, -26102, -26028, -26033, -26041, -25944, -26411, -24299, -21614, -22080, -21892, -22389, -20296, -17115, -17580, -17504, -17506, -17505, -17505, -17505, -17512, -17418, -17881, -15722, -13158, -13552, -9509, -8770, -9038, -8972, -8977, -8976, -8976, -8976, -8976, -8983, -8902, -9200, -8239, -2919, -555, -981, -892, -897, -896, -896, -896, -896, -896, -898, -877, -957, -824};