/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0001 256 samples */
 
const int16_t AKWF_vgsin_0001_256_DATA [256] = 
{3850, 4081, 3874, 3938, 3931, 3933, 3919, 4071, 3386, 5892, 10962, 10475, 10416, 10346, 15960, 17433, 16934, 17059, 17047, 17048, 17048, 17048, 17048, 17048, 17048, 17049, 17131, 16552, 20639, 23248, 22603, 22740, 22728, 22729, 22727, 22756, 22692, 22623, 26385, 27355, 27105, 26778, 28520, 30925, 30543, 30600, 30600, 30600, 30600, 30600, 30600, 30600, 30601, 30598, 30624, 30515, 30855, 31965, 31919, 31907, 31914, 31913, 31914, 31913, 31923, 31872, 32093, 32392, 32325, 32396, 32286, 30742, 30535, 30623, 30598, 30601, 30600, 30600, 30600, 30600, 30600, 30601, 30591, 30588, 30790, 28344, 27305, 27601, 27533, 27539, 27540, 27511, 27584, 27633, 23860, 22914, 23246, 23056, 23678, 20422, 17408, 18034, 17915, 17923, 17922, 17922, 17922, 17922, 17922, 17921, 17935, 17772, 18504, 15826, 10405, 10993, 10940, 10928, 10927, 10939, 10773, 11574, 8082, 3301, 4058, 3826, 4260, 3168, -2978, -3198, -2998, -3064, -3059, -3059, -3059, -3059, -3059, -3060, -3056, -3106, -2991, -2897, -9275, -10932, -10361, -10502, -10490, -10485, -10559, -10313, -10708, -16539, -17307, -16962, -17134, -16591, -20363, -22772, -22178, -22303, -22293, -22293, -22293, -22293, -22293, -22294, -22284, -22399, -21931, -23584, -29159, -30839, -30541, -30601, -30600, -30600, -30600, -30600, -30600, -30600, -30601, -30598, -30632, -30485, -30953, -32418, -32357, -32341, -32350, -32349, -32349, -32349, -32349, -32350, -32349, -32354, -32333, -32374, -32667, -31607, -31419, -31493, -31474, -31476, -31475, -31475, -31475, -31475, -31475, -31476, -31466, -31464, -31669, -29219, -28181, -28484, -28323, -28780, -26814, -24123, -24544, -24478, -24479, -24478, -24483, -24366, -25031, -21504, -18242, -18919, -18789, -18798, -18797, -18797, -18797, -18797, -18797, -18797, -18810, -18656, -19343, -16833, -11750, -12300, -12251, -12239, -12240, -12239, -12239, -12239, -12239, -12245, -12186, -12293, -12416, -5248};