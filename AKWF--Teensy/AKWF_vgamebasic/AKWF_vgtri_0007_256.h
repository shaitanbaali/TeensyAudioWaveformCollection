/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0007 256 samples */
 
const int16_t AKWF_vgtri_0007_256_DATA [256] = 
{745, 1445, 1296, 1379, 1123, 2260, 3740, 3544, 3390, 3992, 6267, 6212, 6211, 6119, 6364, 8340, 8473, 8397, 8272, 10453, 11255, 11019, 11104, 10881, 12517, 13470, 13293, 13046, 14292, 16176, 15929, 15827, 16240, 18180, 18178, 18168, 18080, 18291, 20654, 20895, 20795, 20791, 20785, 22702, 23197, 22736, 24260, 25938, 25628, 25681, 25728, 25472, 26775, 28103, 27898, 27716, 28510, 30706, 30544, 30470, 32242, 32846, 32742, 32761, 32761, 32722, 30580, 29952, 30153, 30089, 30269, 28486, 27873, 27488, 25166, 25223, 25252, 25243, 25192, 25424, 24512, 22853, 23018, 23135, 22765, 20374, 20526, 19271, 17944, 18202, 18152, 18153, 18125, 18359, 16344, 15278, 15553, 15450, 15693, 14276, 13131, 11103, 10471, 10670, 10622, 10630, 10582, 10781, 10148, 7885, 7958, 7958, 8009, 7943, 5269, 2930, 3115, 3106, 3097, 3098, 3096, 3069, 3282, 1625, 697, 886, 1037, 211, -2724, -3714, -3495, -3546, -3542, -3540, -3572, -3456, -3702, -6079, -6273, -6186, -6174, -6185, -8116, -8523, -8421, -8186, -10068, -11307, -11009, -11120, -10860, -12188, -13487, -13286, -13099, -13924, -16088, -15928, -15966, -15828, -16240, -18179, -18194, -18121, -18097, -20384, -20962, -20807, -20616, -22115, -23227, -22973, -23087, -22769, -24257, -25938, -25624, -25731, -25495, -26433, -28098, -27818, -27925, -30287, -30670, -30518, -30578, -30501, -30635, -32488, -32807, -32731, -32811, -31541, -30812, -31206, -30378, -28626, -28800, -28792, -28729, -28998, -27967, -25927, -26157, -26091, -26264, -25695, -23778, -24139, -22263, -21016, -21311, -21249, -21246, -21253, -21353, -19508, -18896, -19026, -19286, -17614, -16187, -16358, -14329, -14090, -14195, -14170, -14127, -14316, -13739, -11455, -11494, -11500, -11594, -11291, -9597, -8397, -6459, -6669, -6644, -6640, -6640, -6609, -6833, -5217, -4237, -4417, -4659, -3426, -1676, -625, 147, -40, 16, -67};