/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0002 256 samples */
 
const int16_t AKWF_vgsin_0002_256_DATA [256] = 
{1474, 1888, 1702, 1749, 1745, 1746, 1746, 1746, 1737, 1852, 1365, 3043, 7471, 11094, 15004, 14282, 14425, 14415, 14416, 14416, 14416, 14416, 14416, 14412, 14472, 14246, 14781, 19439, 19793, 19610, 19663, 19659, 19657, 19742, 19230, 22555, 24895, 24358, 24544, 24130, 26375, 28294, 27887, 27969, 27963, 27963, 27963, 27964, 27961, 28010, 27720, 29547, 30772, 30659, 31885, 31918, 31886, 31896, 31895, 31895, 31895, 31895, 31895, 31896, 31895, 31903, 31856, 32158, 32370, 32324, 32306, 32458, 31616, 30897, 31050, 31019, 31022, 31024, 30988, 31135, 30703, 28798, 28818, 28850, 28837, 28837, 28837, 28840, 28800, 28951, 28594, 25485, 25190, 25738, 22496, 20594, 21064, 20963, 20972, 20971, 20971, 20971, 20971, 20976, 20916, 21066, 20917, 14522, 9712, 10090, 10065, 10047, 10048, 10048, 10048, 10048, 10048, 10047, 10042, 9971, 10569, 5111, 2497, 3202, 3045, 3058, 3057, 3068, 2923, 3635, 353, -3629, -3054, -2632, -4490, -9525, -9148, -9160, -9175, -9174, -9174, -9174, -9175, -9164, -9307, -8621, -11911, -15543, -19125, -20913, -20431, -20542, -20533, -20533, -20533, -20533, -20533, -20534, -20525, -20629, -20162, -21914, -25674, -25296, -25333, -25340, -25340, -25337, -25378, -25225, -25568, -28697, -28937, -28803, -28722, -30939, -31622, -31412, -31461, -31457, -31457, -31457, -31458, -31456, -31472, -31414, -31554, -32656, -32784, -32760, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32768, -32763, -32769, -32730, -31657, -31390, -31477, -31456, -31457, -31462, -31400, -31700, -30297, -28595, -28895, -28756, -29154, -27477, -25021, -25401, -25338, -25340, -25339, -25339, -25339, -25347, -25244, -25756, -23367, -20647, -21031, -15940, -15038, -15366, -15285, -15291, -15290, -15289, -15209, -15754, -11553, -9134, -9733, -9600, -9611, -9610, -9610, -9610, -9612, -9576, -9663, -9740, -4027, -2707, -3163, -3018, -3160, -2912};