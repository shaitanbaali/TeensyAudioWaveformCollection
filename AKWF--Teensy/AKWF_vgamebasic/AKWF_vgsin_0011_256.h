/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0011 256 samples */
 
const int16_t AKWF_vgsin_0011_256_DATA [256] = 
{384, 509, 191, 2066, 3335, 2848, 3575, 5387, 5033, 7045, 8113, 7685, 8301, 11182, 12413, 12183, 12281, 12037, 13020, 14601, 14296, 16187, 16774, 16398, 17367, 18486, 18295, 20247, 20669, 20378, 21202, 21922, 21867, 23842, 24137, 23879, 24784, 25407, 25443, 26938, 27410, 28015, 27970, 27906, 28105, 29264, 29305, 29198, 29897, 30169, 30270, 31048, 31029, 30991, 31359, 31460, 31547, 31919, 31893, 31877, 32249, 32359, 32324, 32332, 32332, 32324, 32361, 32242, 31876, 31891, 31906, 31882, 31484, 31483, 31282, 30971, 31057, 30961, 30164, 30194, 29809, 28630, 28341, 28419, 28372, 28525, 27685, 26943, 27191, 26862, 25706, 25931, 24694, 23924, 23937, 22729, 22667, 22886, 21272, 20272, 18947, 18728, 18792, 18813, 18801, 16826, 16643, 16062, 13118, 12059, 12282, 12181, 12431, 11308, 9820, 10162, 9888, 7887, 8054, 6587, 5040, 5244, 3255, 2922, 3331, 1610, 154, 621, 39, -1858, -1521, -3368, -4631, -4256, -4508, -7361, -9440, -9117, -9211, -9033, -9692, -11059, -10750, -12884, -13767, -13338, -14179, -15436, -15177, -17061, -17648, -17273, -18241, -19359, -19170, -21120, -21550, -21212, -22289, -23279, -23192, -24660, -25304, -26274, -26221, -26170, -26299, -27468, -27580, -27395, -28372, -28895, -28957, -30147, -30173, -30105, -30466, -30570, -30723, -31484, -31465, -31427, -31797, -31897, -31984, -32356, -32329, -32317, -32672, -32783, -32763, -32768, -32767, -32768, -32762, -32789, -32606, -32294, -32347, -32320, -31912, -31952, -31577, -30691, -30559, -30595, -30555, -30707, -29952, -29138, -29340, -29173, -28375, -28513, -27669, -27002, -27041, -25844, -25711, -25946, -24691, -23840, -24186, -23625, -22170, -22421, -21092, -20359, -20659, -20233, -17692, -16416, -16650, -16562, -16757, -15972, -14705, -14992, -12756, -12027, -12440, -11473, -10352, -10554, -8230, -7682, -8109, -6771, -5526, -5662, -3296, -2915, -3299, -1821, -701, -856};