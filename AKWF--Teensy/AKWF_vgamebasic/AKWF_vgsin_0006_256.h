/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0006 256 samples */
 
const int16_t AKWF_vgsin_0006_256_DATA [256] = 
{1300, 1941, 1688, 1751, 1745, 1746, 1745, 1761, 1754, 1510, 5573, 6579, 7473, 10731, 10459, 10476, 10484, 10483, 10499, 10483, 10319, 13621, 14663, 14354, 14470, 14119, 17295, 21289, 21478, 21370, 21410, 21407, 21407, 21407, 21413, 21427, 21213, 23677, 24749, 24177, 25439, 27311, 27045, 27087, 27087, 27122, 26896, 28437, 29469, 29226, 29279, 29293, 29170, 30154, 31786, 31942, 31877, 31897, 31895, 31896, 31895, 31904, 31853, 32140, 32373, 32322, 32332, 32331, 32331, 32331, 32331, 32332, 32315, 32413, 31827, 31376, 31479, 31430, 31574, 30794, 30091, 28768, 28291, 28430, 28397, 28400, 28399, 28402, 28356, 28605, 27246, 26010, 26207, 26420, 25426, 23401, 23619, 23594, 23594, 23531, 23881, 21922, 20245, 20606, 20443, 20900, 18676, 16418, 13972, 12862, 13170, 13100, 13106, 13105, 13112, 13021, 13479, 11195, 8804, 9163, 9518, 7923, 4052, 4399, 4385, 4283, 4707, 3005, 98, 491, 444, 350, 789, -1308, -3565, -6991, -8650, -8208, -8309, -8300, -8294, -8380, -7991, -9462, -12513, -12187, -12295, -11985, -13048, -15921, -15712, -15710, -15819, -15373, -17093, -20428, -20040, -20154, -19876, -20852, -23372, -22943, -24998, -25988, -25723, -25782, -25777, -25773, -25828, -25582, -26460, -28575, -28380, -28424, -28292, -28746, -30222, -30148, -30085, -31201, -31540, -31435, -31459, -31456, -31473, -31401, -31646, -32377, -32298, -32615, -32789, -32761, -32768, -32767, -32768, -32762, -32787, -32659, -32312, -32334, -32319, -32382, -32185, -31431, -31455, -31445, -31515, -31312, -30154, -30126, -30159, -30118, -30251, -29830, -28297, -28620, -26742, -25546, -25833, -25773, -25780, -25747, -25872, -25572, -23242, -23095, -23182, -23108, -23308, -22726, -20066, -20070, -20061, -20266, -19710, -15823, -15641, -15730, -15814, -15589, -12467, -12046, -12629, -9855, -7941, -8387, -8293, -8304, -8253, -8433, -8058, -3770, -3350, -3518, -3570, -3444};