/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0004 256 samples */
 
const int16_t AKWF_vgtri_0004_256_DATA [256] = 
{1944, 2335, 2175, 2215, 2211, 2212, 2212, 2212, 2212, 2206, 2279, 2001, 2966, 7666, 9593, 9223, 9302, 9297, 9298, 9298, 9298, 9298, 9299, 9340, 9053, 11620, 13287, 15674, 16041, 15907, 15942, 15940, 15940, 15940, 15940, 15935, 16003, 15704, 16744, 19314, 21331, 23344, 22949, 23030, 23025, 23025, 23025, 23025, 23025, 23031, 23052, 22823, 25468, 27116, 29942, 30198, 30081, 30114, 30111, 30111, 30111, 30112, 30109, 30145, 29986, 30502, 32314, 29849, 28010, 28418, 28335, 28342, 28341, 28341, 28341, 28342, 28291, 28613, 26346, 25134, 24875, 21682, 21652, 21720, 21696, 21697, 21697, 21697, 21702, 21642, 21892, 21126, 18001, 18445, 15946, 14291, 14687, 14603, 14610, 14610, 14610, 14610, 14607, 14566, 14901, 12143, 10970, 10565, 7437, 7505, 7543, 7525, 7526, 7526, 7525, 7531, 7463, 7756, 6716, 4161, 2157, 114, 518, 436, 442, 442, 442, 441, 443, 392, 683, -1068, -2521, -1924, -2948, -5922, -5754, -5745, -5757, -5756, -5757, -5752, -5806, -5592, -6200, -9313, -9374, -9031, -11883, -13110, -12769, -12847, -12840, -12841, -12841, -12839, -12898, -12527, -15060, -16769, -16050, -17303, -20143, -19904, -19918, -19926, -19926, -19923, -19961, -19822, -20111, -23272, -23584, -23437, -23312, -25894, -26771, -26512, -26572, -26567, -26568, -26562, -26641, -26233, -28398, -30447, -30089, -29909, -30898, -32839, -32738, -32765, -32767, -32767, -32768, -32739, -32834, -32311, -29347, -29130, -29271, -29331, -26311, -25479, -25739, -25677, -25682, -25681, -25685, -25614, -26014, -23640, -21819, -22140, -22445, -20874, -18290, -18653, -18597, -18598, -18599, -18570, -18669, -18521, -15386, -14917, -15080, -15086, -15084, -12362, -11803, -11999, -11951, -11954, -11960, -11878, -12295, -10311, -8074, -8491, -8330, -8738, -6957, -4552, -4935, -4867, -4871, -4873, -4836, -4966, -4698, -1535, -1220, -1346, -1384, -1273};