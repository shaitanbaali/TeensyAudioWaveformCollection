/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0005 256 samples */
 
const int16_t AKWF_vgsaw_0005_256_DATA [256] = 
{1425, 1626, 1412, 2094, 2808, 2674, 2699, 2697, 2697, 2701, 2710, 2588, 3787, 4363, 4205, 4267, 4129, 4756, 5503, 5374, 5396, 5396, 5394, 5425, 5247, 6250, 7085, 6904, 6938, 6971, 6793, 7582, 8620, 8453, 8478, 8503, 8389, 8803, 9718, 9628, 9631, 9662, 9543, 9915, 11109, 11642, 12427, 12317, 12334, 12334, 12334, 12334, 12333, 12344, 12317, 12312, 13653, 13984, 13750, 14297, 15130, 15017, 15034, 15034, 15034, 15034, 15059, 14892, 15952, 16721, 16541, 16605, 16476, 16966, 17837, 17609, 18821, 19398, 19242, 19278, 19275, 19275, 19275, 19273, 19293, 19232, 19374, 20953, 22095, 21951, 21971, 21973, 21973, 21973, 21973, 21973, 21972, 21992, 21912, 22119, 23372, 23878, 24740, 24666, 24671, 24673, 24673, 24673, 24673, 24678, 24676, 24587, 25840, 26334, 26156, 26318, 26626, 26599, 26600, 26601, 26592, 26684, 25372, 32168, -1909, -35631, -31790, -32707, -32976, -31253, -26700, -26989, -27006, -26985, -26971, -27040, -26814, -26176, -26216, -26220, -26195, -26264, -26123, -24442, -23432, -23526, -23520, -23515, -23516, -23515, -23515, -23516, -23508, -23520, -23579, -22264, -21947, -21782, -20775, -20812, -20823, -20817, -20818, -20817, -20819, -20787, -20965, -19994, -19129, -19288, -19341, -19086, -18091, -18109, -18124, -18117, -18117, -18120, -18084, -18257, -17538, -16440, -16603, -16553, -16659, -16356, -15018, -15015, -15045, -15035, -15017, -15092, -14880, -13874, -13860, -13886, -13863, -13901, -13880, -12314, -11125, -11179, -11186, -11178, -11179, -11178, -11178, -11179, -11176, -11164, -11295, -10094, -9557, -9556, -8499, -8456, -8490, -8480, -8481, -8480, -8483, -8446, -8623, -7833, -6797, -6951, -6981, -6846, -5820, -5752, -5794, -5781, -5785, -5756, -5872, -5524, -4205, -4228, -4250, -4226, -4279, -4171, -3142, -3047, -3096, -3073, -3089, -3142, -1703, -369, -372, -395, -385, -368, -434, -318};