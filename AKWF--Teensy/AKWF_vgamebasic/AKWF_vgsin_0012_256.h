/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0012 256 samples */
 
const int16_t AKWF_vgsin_0012_256_DATA [256] = 
{1191, 1281, 1810, 4479, 5353, 5296, 7300, 7500, 7420, 7292, 8668, 9229, 9369, 10939, 10969, 10741, 12440, 13214, 13208, 15726, 17172, 17032, 16999, 17071, 18665, 18703, 19408, 20691, 20441, 21595, 21812, 22237, 23556, 24238, 25017, 24908, 24788, 25266, 26747, 26573, 27202, 27567, 27581, 28407, 28295, 29013, 29808, 30010, 30198, 30065, 30421, 31092, 31006, 31016, 31406, 31445, 31585, 31930, 31862, 32213, 32364, 32323, 32332, 32331, 32331, 32331, 32332, 32322, 32371, 32151, 31851, 31917, 31860, 31552, 31210, 30531, 30590, 30602, 30212, 30182, 29936, 29208, 29347, 28669, 28388, 28257, 27068, 27152, 26644, 26112, 26291, 26071, 24875, 25046, 24017, 23022, 23168, 21557, 21450, 20966, 19980, 20213, 18712, 18345, 18032, 16492, 16757, 15522, 14664, 15003, 14511, 12994, 13340, 11483, 10311, 10422, 8746, 8901, 7753, 6366, 6630, 4653, 4390, 3878, 2475, 2785, 1052, 223, 651, -194, -1929, -1539, -3615, -4487, -4572, -6189, -5930, -7337, -8446, -8343, -10372, -10433, -10986, -13333, -14117, -13940, -14022, -13825, -14659, -15876, -15591, -17861, -18393, -18710, -20226, -19982, -20873, -22901, -23242, -23153, -23032, -23807, -24610, -24384, -24593, -25794, -25634, -26629, -27688, -27454, -28377, -29290, -29282, -29270, -29219, -29944, -30155, -30296, -31061, -30984, -31280, -31504, -31431, -31501, -32044, -32366, -32330, -32317, -32361, -32727, -32773, -32765, -32768, -32768, -32762, -32786, -32635, -32304, -32335, -32333, -32323, -32365, -32215, -31858, -31963, -31279, -30993, -30926, -30121, -30215, -29686, -29221, -28588, -28324, -28495, -28066, -27447, -27596, -26487, -26100, -26356, -25726, -24788, -24991, -23613, -22854, -21458, -21354, -21536, -20552, -20052, -19962, -18347, -18484, -17510, -16462, -16640, -15013, -14960, -14177, -12477, -12723, -12686, -10731, -10559, -9827, -8119, -8467, -6660, -6057, -5864, -4272, -4565, -3069, -2074, -2076};