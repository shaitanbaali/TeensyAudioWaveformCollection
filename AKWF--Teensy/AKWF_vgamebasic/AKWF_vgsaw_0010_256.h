/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0010 256 samples */
 
const int16_t AKWF_vgsaw_0010_256_DATA [256] = 
{512, 1003, 847, 1024, 1820, 1844, 1745, 2406, 2830, 3536, 3677, 3631, 3641, 3594, 4354, 4630, 4454, 4871, 5543, 5429, 5483, 6214, 6603, 7309, 7288, 7263, 7283, 8080, 8252, 8090, 8616, 9198, 9050, 9173, 10000, 9945, 10421, 11007, 10919, 10868, 11081, 11862, 11842, 11765, 12493, 12830, 12650, 13012, 13722, 13579, 14305, 14632, 14562, 14479, 14943, 15565, 15431, 15511, 16319, 16433, 16285, 16889, 17358, 17305, 18138, 18238, 18203, 18131, 18816, 19208, 19030, 19333, 20077, 20021, 19977, 20765, 20931, 21120, 21895, 21844, 21819, 22200, 22350, 22213, 22614, 23293, 23182, 23217, 24016, 24180, 24020, 24554, 25129, 24975, 25126, 25839, 26255, 26913, 26839, 26867, 26794, 27018, 27795, 27770, 27696, 28424, 28758, 28578, 28947, 29656, 29566, 29564, 30349, 30552, 30436, 30685, 30995, 30927, 30971, 31375, 31400, 31480, 30964, 29580, 33223, 20677, -29599, -31431, -31093, -31979, -31767, -32070, -32432, -31339, -31403, -31409, -31386, -31466, -31193, -30440, -30495, -30536, -29775, -29504, -29661, -29344, -28137, -27688, -27780, -27762, -27742, -27848, -27321, -26752, -26906, -26770, -25961, -25903, -26023, -25436, -24262, -24074, -24136, -24116, -24115, -24177, -23449, -23123, -23303, -22935, -22227, -22309, -22345, -21468, -20472, -20468, -20483, -20486, -20501, -19713, -19498, -19668, -19186, -18567, -18702, -18603, -17881, -17476, -16789, -16846, -16828, -16884, -16719, -15922, -15905, -16004, -15309, -14923, -15101, -14779, -14143, -13633, -13111, -13218, -13176, -13277, -12868, -12200, -12319, -12276, -11470, -11319, -11472, -10925, -10430, -9785, -9490, -9575, -9540, -9634, -8990, -8549, -8723, -8472, -7685, -7818, -7180, -6758, -6813, -6387, -6357, -6369, -6432, -5702, -5374, -5553, -5185, -4478, -4568, -4570, -3765, -3661, -3394, -2667, -2728, -2757, -2685, -1878, -1774, -1914, -1310, -810, -976, -784, 18, -35};