/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0014 256 samples */
 
const int16_t AKWF_vgsin_0014_256_DATA [256] = 
{696, 1394, 2268, 2906, 3801, 4492, 5270, 6098, 6718, 7781, 7789, 8422, 9191, 10361, 11170, 12035, 12701, 13522, 14319, 14931, 16041, 17109, 16916, 17667, 18421, 19297, 19859, 20421, 20881, 21373, 22239, 22870, 23445, 23763, 24842, 25428, 25289, 25402, 26524, 26828, 27019, 27577, 28051, 28263, 28580, 29247, 29474, 29723, 30008, 30221, 30524, 30744, 31016, 31280, 31497, 31832, 31925, 31848, 32114, 32373, 32323, 32332, 32331, 32331, 32332, 32325, 32353, 32274, 31890, 31885, 31929, 31591, 31415, 31492, 31373, 30800, 30553, 30592, 30238, 30029, 29787, 29305, 28784, 28511, 28424, 28215, 27564, 27094, 26602, 26031, 25607, 25009, 24556, 24021, 23495, 23026, 22040, 21561, 21012, 20511, 20048, 19086, 18548, 18040, 17344, 16571, 15721, 15137, 14457, 14506, 13836, 13114, 11550, 10660, 10199, 9724, 8013, 7344, 7425, 5962, 5297, 4448, 3710, 2982, 2117, 1483, 587, -101, -875, -1687, -3383, -3454, -3837, -4762, -5544, -6184, -6204, -7618, -8439, -9607, -10348, -11042, -11931, -12562, -13438, -14156, -14940, -15434, -15934, -16876, -17521, -18380, -18859, -19327, -20318, -20809, -21357, -21854, -22303, -23321, -23615, -23810, -24400, -25159, -25882, -26420, -26844, -27483, -27727, -27932, -28565, -29292, -29209, -29539, -30177, -30393, -30625, -30924, -31136, -31427, -31666, -31941, -31868, -31937, -32324, -32343, -32328, -32315, -32659, -32785, -32763, -32768, -32767, -32768, -32762, -32785, -32643, -32305, -32337, -32336, -31992, -31792, -31496, -31264, -31007, -30726, -30512, -30210, -29996, -29672, -29777, -29058, -28002, -27974, -27815, -27557, -26989, -26548, -25947, -25521, -24950, -24458, -23970, -23400, -22998, -21639, -20891, -21036, -20408, -19946, -18999, -18365, -17481, -16970, -16567, -16510, -15492, -14701, -13537, -12796, -12105, -11215, -10577, -9698, -8977, -8235, -7380, -6744, -5845, -5169, -4367, -3565, -2882, -2023, -1266, 22};