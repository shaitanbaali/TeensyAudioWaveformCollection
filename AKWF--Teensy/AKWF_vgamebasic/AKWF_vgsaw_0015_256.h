/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0015 256 samples */
 
const int16_t AKWF_vgsaw_0015_256_DATA [256] = 
{226, 475, 408, 456, 977, 1333, 1252, 1597, 2096, 2251, 2551, 2791, 3024, 3335, 3859, 3900, 3835, 4097, 4338, 4632, 4791, 5283, 5599, 5832, 6068, 6372, 6527, 7029, 7366, 7315, 7336, 7677, 7878, 8168, 8372, 8932, 9098, 9403, 9615, 9898, 10116, 10685, 10811, 10734, 10910, 11203, 11461, 11658, 12045, 12473, 12658, 12932, 13201, 13390, 13791, 14243, 14232, 14195, 14509, 14717, 15026, 15185, 15733, 15963, 16241, 16457, 16764, 16925, 17482, 17718, 17648, 17733, 18064, 18282, 18536, 18813, 19334, 19488, 19792, 20026, 20267, 20558, 21094, 21149, 21080, 21333, 21566, 21886, 22374, 22535, 22828, 23071, 23308, 23606, 23767, 24252, 24610, 24565, 24570, 24924, 25069, 25580, 25869, 26118, 26348, 26640, 26851, 27140, 27343, 27917, 28062, 27986, 28142, 28442, 28702, 28900, 28942, 29638, 30038, 30635, 30863, 31046, 31802, 32929, 30704, 32170, 62, -20551, -27331, -30592, -30843, -32597, -31718, -31366, -31144, -30820, -29937, -29739, -29458, -29244, -28939, -28775, -28218, -27985, -28055, -27969, -27638, -27418, -27162, -26882, -26368, -26211, -25908, -25674, -25434, -25140, -24605, -24552, -24619, -24369, -24122, -23833, -23668, -23188, -22860, -22632, -22392, -22093, -21932, -21443, -21088, -21163, -20811, -20688, -20617, -20285, -20096, -19534, -19362, -19060, -18848, -18559, -18352, -17784, -17641, -17719, -17554, -17253, -17035, -16486, -16324, -16015, -15800, -15529, -15264, -15068, -14681, -14216, -14218, -14264, -13949, -13770, -13349, -12954, -12760, -12494, -12220, -12004, -11699, -11541, -10992, -10736, -10804, -10733, -10386, -10232, -9672, -9465, -9176, -8964, -8668, -8442, -8189, -7915, -7368, -7304, -7375, -7136, -6893, -6587, -6088, -5931, -5633, -5396, -5151, -4857, -4693, -4223, -3846, -3887, -3889, -3541, -3394, -2894, -2588, -2348, -2115, -1822, -1614, -1320, -1125, -555, -394, -471, -331, 3};