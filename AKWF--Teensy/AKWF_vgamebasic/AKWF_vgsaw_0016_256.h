/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0016 256 samples */
 
const int16_t AKWF_vgsaw_0016_256_DATA [256] = 
{254, 446, 746, 900, 1376, 1692, 1919, 2138, 2469, 2936, 3082, 3422, 3403, 3385, 3716, 3907, 4211, 4371, 4920, 5122, 5415, 5572, 6033, 6370, 6582, 6852, 6782, 6852, 7184, 7387, 7652, 7892, 8423, 8569, 8886, 9040, 9583, 9793, 10087, 10254, 10169, 10346, 10630, 10880, 11077, 11446, 11881, 12051, 12329, 12551, 13093, 13235, 13582, 13639, 13574, 13855, 14056, 14408, 14857, 15018, 15302, 15547, 15756, 16102, 16558, 16707, 17044, 17019, 17008, 17352, 17494, 17970, 18291, 18513, 18747, 19039, 19194, 19665, 19991, 20207, 20471, 20398, 20476, 20818, 20966, 21518, 21719, 22001, 22205, 22507, 22664, 23215, 23414, 23714, 23871, 23786, 23976, 24253, 24484, 25018, 25169, 25474, 25682, 25950, 26179, 26719, 26859, 27207, 27257, 27194, 27482, 27679, 28041, 28479, 28645, 28928, 29175, 29366, 30092, 30600, 30828, 31735, 30382, 28549, 30714, 23551, -19797, -29933, -30565, -32933, -32053, -31790, -30964, -30679, -30204, -29747, -29135, -28873, -28984, -28823, -28262, -28050, -28116, -28035, -27694, -27544, -26995, -26791, -26507, -26304, -26012, -25798, -25539, -25298, -24747, -24652, -24725, -24537, -24259, -24023, -23491, -23344, -23039, -22828, -22562, -22304, -22110, -21747, -21272, -21264, -21318, -21028, -20836, -20469, -20035, -19866, -19585, -19338, -19116, -18817, -18670, -18183, -17838, -17881, -17881, -17539, -17395, -16905, -16602, -16375, -16141, -15855, -15652, -15354, -15191, -14635, -14428, -14497, -14408, -14072, -13919, -13365, -13171, -12885, -12684, -12391, -12173, -11916, -11669, -11120, -11034, -11107, -10909, -10639, -10393, -9865, -9719, -9416, -9205, -8940, -8677, -8489, -8115, -7652, -7648, -7698, -7401, -7215, -6838, -6412, -6241, -5966, -5716, -5494, -5194, -5045, -4551, -4219, -4266, -4259, -3911, -3773, -3274, -2981, -2747, -2519, -2233, -2030, -1733, -1565, -1008, -812, -882, -784, -452, -285};