/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0013 256 samples */
 
const int16_t AKWF_vgtri_0013_256_DATA [256] = 
{754, 1401, 2407, 2670, 2872, 3611, 3453, 4434, 5037, 6102, 6165, 6565, 7070, 8014, 8469, 8519, 9340, 9186, 10045, 10696, 11757, 12868, 12869, 12710, 13612, 14263, 14190, 15039, 14955, 15630, 16421, 17330, 17791, 17731, 19013, 20038, 19895, 19906, 21081, 21249, 21525, 22091, 22930, 23557, 23502, 24351, 24273, 24832, 26606, 27123, 26930, 27176, 27951, 27787, 28690, 29342, 30377, 30546, 30845, 31397, 32237, 32812, 31978, 31813, 32020, 31238, 30506, 29552, 29189, 29070, 28278, 28451, 27534, 26868, 25917, 25434, 24754, 24913, 23940, 23389, 23409, 22565, 22691, 21932, 21194, 20225, 19900, 19723, 19119, 18363, 17607, 17726, 16880, 16908, 16338, 15492, 14627, 14097, 14094, 13254, 13392, 12604, 11882, 10902, 10606, 10412, 9814, 9033, 8310, 8415, 7567, 7613, 7013, 6182, 5302, 4802, 4787, 3950, 4094, 3277, 2579, 1585, 1310, 1105, 464, -48, -501, -455, -1297, -1237, -1871, -2676, -3571, -4048, -4084, -4912, -4761, -5594, -6284, -7294, -7536, -7777, -8360, -9093, -10490, -10666, -10640, -10505, -11197, -11983, -12897, -13336, -13429, -14070, -14752, -15624, -15413, -16333, -17695, -17760, -17575, -18503, -19135, -19062, -19916, -19829, -20516, -21292, -22222, -22663, -22603, -23910, -24907, -24767, -24782, -25588, -25617, -26107, -26996, -27818, -28431, -28377, -29228, -29143, -29722, -31501, -31991, -31799, -32052, -32799, -32542, -32295, -32339, -31517, -31513, -30986, -30113, -29313, -28660, -28027, -27826, -28031, -27246, -26519, -25552, -25207, -25047, -24437, -23694, -22918, -23019, -22322, -21804, -20734, -20929, -19942, -19407, -19389, -18725, -18099, -17160, -17333, -16543, -16420, -16065, -15112, -14364, -13621, -13738, -12893, -12921, -12336, -11507, -10629, -10115, -10075, -9418, -8773, -7859, -8028, -7232, -7126, -6740, -5804, -5037, -4323, -4428, -3581, -3628, -3011, -2197, -1314, -820, -792, 25, -55};