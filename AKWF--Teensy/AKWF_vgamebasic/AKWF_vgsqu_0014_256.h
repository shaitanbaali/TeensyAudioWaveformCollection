/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0014 256 samples */
 
const int16_t AKWF_vgsqu_0014_256_DATA [256] = 
{18003, 33989, 27687, 27173, 27807, 27919, 28177, 28136, 28144, 28143, 28149, 28108, 28378, 28564, 28519, 28528, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28528, 28521, 28554, 28447, 28125, 28143, 28145, 28144, 28135, 28176, 27992, 27755, 27479, 27501, 25941, 31537, 2803, -35354, -30272, -30213, -29798, -29546, -29280, -29302, -29300, -29300, -29291, -29334, -29121, -28878, -28921, -28913, -28914, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28914, -28913, -28921, -28889, -28996, -29316, -29299, -29298, -29300, -29299, -29298, -29282, -29409, -28327, -27055, -28761, -19181, 174};