/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0005 256 samples */
 
const int16_t AKWF_vgsqu_0005_256_DATA [256] = 
{25024, 33420, 31914, 32369, 32340, 32346, 32315, 32459, 31818, 30948, 31088, 31064, 31075, 31027, 31251, 31531, 31484, 31492, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31491, 31492, 31491, 31499, 31468, 31565, 31928, 31919, 31915, 31918, 31917, 31917, 31917, 31917, 31920, 31878, 32063, 30516, 34589, -549, -35094, -29522, -30696, -30632, -30641, -30642, -30639, -30674, -30516, -31089, -32450, -32336, -32348, -31985, -31893, -31924, -31917, -31918, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31917, -31918, -31915, -31922, -31920, -31549, -31471, -31517, -31387, -32258, -32831, -32748, -32767, -32775, -32564, -33097, -28558};