/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0003 256 samples */
 
const int16_t AKWF_vgsaw_0003_256_DATA [256] = 
{509, 408, 426, 423, 424, 422, 446, 351, 600, 2110, 2164, 2103, 2080, 3550, 3924, 3801, 3830, 3828, 3828, 3828, 3830, 3844, 3710, 5044, 5698, 5352, 6093, 7374, 7210, 7233, 7234, 7234, 7234, 7234, 7231, 7270, 7089, 7828, 9075, 8829, 10646, 11193, 11025, 11065, 11062, 11062, 11062, 11061, 11069, 11055, 11005, 12496, 12727, 13248, 14593, 14449, 14466, 14468, 14468, 14468, 14468, 14468, 14465, 14505, 14310, 15270, 16238, 17452, 17992, 17841, 17876, 17873, 17873, 17873, 17873, 17873, 17871, 17893, 17832, 17936, 20140, 21861, 21678, 21699, 21703, 21703, 21703, 21703, 21703, 21703, 21702, 21737, 21555, 22609, 24826, 25192, 25078, 25110, 25107, 25107, 25107, 25107, 25107, 25107, 25105, 25140, 24988, 25501, 26904, 26802, 26805, 26806, 26846, 26646, 27608, 28676, 28478, 28516, 28514, 28521, 28450, 29112, 29432, 29346, 29362, 29420, 28578, 32023, 20218, -29859, -32985, -32513, -32736, -32868, -32074, -29691, -29782, -29801, -29789, -29790, -29786, -29779, -29900, -28534, -27964, -28119, -28057, -28262, -26649, -25783, -26004, -25954, -25958, -25960, -25926, -26073, -25570, -24167, -24263, -24234, -24352, -23972, -22503, -22545, -22562, -22553, -22553, -22554, -22545, -22566, -22591, -21123, -20758, -20854, -20997, -19773, -19001, -19186, -19146, -19150, -19149, -19149, -19152, -19113, -19313, -18296, -17254, -17590, -17149, -15298, -15297, -15331, -15318, -15319, -15318, -15320, -15303, -15361, -15253, -13733, -13529, -13791, -12591, -11759, -11952, -11911, -11915, -11914, -11914, -11914, -11915, -11887, -12070, -10839, -10133, -10063, -8515, -8483, -8522, -8510, -8511, -8510, -8510, -8510, -8513, -8477, -8635, -8033, -6904, -5621, -4487, -4726, -4677, -4681, -4680, -4680, -4680, -4680, -4678, -4668, -4774, -3488, -2704, -1356, -1237, -1291, -1275, -1277, -1276, -1276, -1276, -1276, -1280, -1242, -1413, -691};