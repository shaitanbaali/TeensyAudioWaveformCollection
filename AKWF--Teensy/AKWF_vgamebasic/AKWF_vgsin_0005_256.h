/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0005 256 samples */
 
const int16_t AKWF_vgsin_0005_256_DATA [256] = 
{3598, 6135, 5569, 5687, 5677, 5678, 5669, 5777, 5290, 7175, 10839, 10490, 10275, 11031, 14863, 14908, 14826, 14856, 14849, 14935, 14477, 16924, 19164, 18702, 18793, 18846, 18454, 21279, 23059, 22633, 22730, 22739, 22522, 24961, 26003, 25718, 25795, 25761, 25725, 27853, 28853, 30160, 30157, 30139, 30148, 30147, 30147, 30146, 30163, 30097, 30266, 31428, 31496, 31380, 32055, 32405, 32313, 32333, 32331, 32331, 32331, 32331, 32331, 32331, 32333, 32316, 32390, 32142, 31417, 31459, 31460, 31457, 31458, 31430, 31613, 30352, 29555, 29748, 29702, 29693, 29856, 28095, 27361, 27568, 27508, 27537, 27596, 25352, 24753, 24948, 24871, 24978, 24758, 21989, 20346, 17721, 17934, 17920, 17913, 17913, 17913, 17919, 17840, 18168, 17152, 13393, 13519, 13772, 10118, 8889, 9252, 9167, 9173, 9183, 9068, 9591, 7428, 3958, 4452, 4268, 4756, 2844, -813, -380, -432, -434, -517, -27, -2971, -5212, -4709, -4816, -4880, -4411, -7979, -13625, -14130, -13920, -13986, -13980, -13980, -13980, -13981, -13977, -14033, -13808, -14464, -17907, -19872, -22591, -22220, -22282, -22281, -22281, -22282, -22276, -22349, -22020, -23206, -26028, -25717, -25762, -28067, -28523, -28363, -28402, -28400, -28396, -28447, -28195, -29440, -30788, -30537, -30615, -30461, -31139, -32016, -31885, -31839, -32083, -32775, -32762, -32766, -32767, -32767, -32768, -32763, -32775, -32709, -31979, -31860, -31906, -31895, -31896, -31895, -31895, -31897, -31882, -31933, -31825, -30619, -30710, -29766, -28674, -28873, -28835, -28838, -28837, -28842, -28790, -29012, -28269, -26080, -26189, -26312, -26052, -23312, -23066, -23187, -23153, -23155, -23158, -23085, -23512, -20846, -18861, -19314, -19126, -19643, -16905, -14437, -14949, -14848, -14840, -14849, -15069, -11431, -10202, -10564, -10452, -10487, -10705, -5859, -751, -845, -906, -870, -873, -872, -872, -874, -854, -935, -710, 494, 184};