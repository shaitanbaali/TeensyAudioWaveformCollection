/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0002 256 samples */
 
const int16_t AKWF_vgsqu_0002_256_DATA [256] = 
{25060, 29744, 27724, 28248, 28200, 28250, 28022, 28974, 30458, 30248, 30279, 30289, 30241, 30461, 30733, 30688, 30696, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30695, 30697, 30676, 30801, 29851, 30861, 27291, -23643, -34140, -32224, -32785, -32765, -32767, -32767, -32767, -32767, -32767, -32768, -32749, -32829, -32276, -31424, -31542, -31523, -31524, -31524, -31521, -31529, -31525, -31162, -31090, -31115, -31109, -31110, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31109, -31114, -31101, -31096, -31815, -31983, -31926, -31941, -31939, -31939, -31939, -31938, -31961, -31617, -32752, -27301};