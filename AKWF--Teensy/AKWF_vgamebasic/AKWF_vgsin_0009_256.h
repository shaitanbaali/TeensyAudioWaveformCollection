/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0009 256 samples */
 
const int16_t AKWF_vgsin_0009_256_DATA [256] = 
{761, 1420, 1333, 1159, 1894, 5908, 7717, 7352, 7430, 7434, 7439, 7259, 9767, 10690, 10479, 10242, 11981, 13242, 13283, 16062, 16233, 16161, 16098, 16270, 18617, 18877, 18767, 18664, 20462, 21121, 20980, 20724, 22461, 23762, 23696, 25711, 25828, 25770, 25744, 25832, 26996, 27134, 27078, 27010, 28367, 29101, 30110, 30170, 30137, 30163, 30092, 30321, 31059, 31029, 30994, 31056, 31838, 31930, 31848, 32164, 32371, 32322, 32332, 32331, 32332, 32324, 32359, 32245, 31875, 31897, 31900, 31588, 31294, 30572, 30578, 30588, 30585, 30564, 30665, 30233, 29611, 29785, 29575, 28023, 27904, 28087, 27092, 26536, 26679, 26611, 26840, 25315, 24223, 24700, 23818, 21685, 21842, 21859, 21906, 19544, 16874, 17051, 17048, 17043, 16982, 17282, 15846, 14178, 14417, 14600, 13765, 11613, 12018, 9594, 8500, 8798, 8683, 9022, 6388, 4948, 5259, 5484, 4049, 2374, 2607, 2868, 1764, -1107, -820, -820, -3867, -4545, -4351, -4164, -6122, -7200, -7011, -6679, -8590, -10636, -12756, -13756, -13485, -13560, -13523, -13504, -15411, -15841, -15737, -15481, -17779, -19100, -18517, -19572, -21595, -21411, -21307, -21661, -23580, -23637, -23556, -23568, -25461, -25924, -25582, -26665, -27646, -28562, -28918, -28816, -28837, -28861, -28759, -29031, -30580, -30618, -30512, -31214, -31544, -31365, -31760, -32406, -32318, -32340, -32298, -32459, -32779, -32764, -32767, -32767, -32767, -32765, -32770, -32736, -32023, -31851, -31908, -31896, -31882, -31944, -31758, -31002, -31009, -31041, -31010, -30207, -30232, -29629, -28717, -28864, -28798, -28987, -28235, -26941, -27086, -27180, -26822, -25306, -25309, -25388, -25312, -23372, -23015, -23425, -21669, -20298, -20544, -20718, -19769, -18174, -18332, -18523, -17803, -15507, -13879, -11965, -12291, -12232, -12181, -12479, -10758, -9370, -9593, -9905, -8410, -5791, -6248, -5975, -3252, -2952, -3082, -3215, -703, 205, -44, -61};