/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0007 256 samples */
 
const int16_t AKWF_vgsaw_0007_256_DATA [256] = 
{30, 287, 486, 437, 448, 448, 446, 464, 383, 666, 1396, 1354, 1320, 1362, 2902, 4125, 4027, 4034, 4038, 4038, 4041, 4044, 3961, 5073, 5479, 5361, 5397, 5321, 6025, 6352, 6292, 6157, 6955, 7757, 7599, 7661, 7503, 8237, 9099, 8975, 8883, 9307, 10399, 10314, 10335, 10266, 10495, 11257, 11233, 11182, 11276, 12480, 12613, 12558, 12490, 13601, 14007, 13890, 13930, 13818, 14874, 15367, 15233, 15274, 15189, 15855, 16259, 16033, 16548, 17601, 17494, 17501, 17535, 17382, 18036, 18972, 18852, 18766, 19122, 20262, 20197, 20161, 20926, 21150, 21082, 21108, 21075, 21108, 22302, 22500, 22433, 22432, 22422, 23622, 23745, 24238, 25251, 25116, 25135, 25135, 25159, 25014, 25960, 26605, 26453, 26503, 26407, 26970, 27440, 28516, 28800, 28709, 28731, 28727, 28757, 28623, 29127, 30171, 30084, 29998, 30260, 31940, 31543, 30880, 30990, 30972, 30983, 30743, 31123, 31454, -17878, -33701, -29610, -30587, -30429, -32211, -31314, -30858, -31000, -30972, -30973, -30976, -30945, -31100, -30289, -29503, -29629, -29711, -29313, -27779, -27311, -27401, -27380, -27382, -27383, -27366, -27428, -27281, -26077, -26003, -26033, -26067, -25980, -24781, -24638, -24697, -24759, -23662, -23248, -23364, -23331, -23404, -22694, -22377, -22433, -22568, -21761, -20950, -21197, -20892, -19721, -19740, -19759, -19724, -19846, -19420, -18320, -18400, -18437, -18336, -17535, -17485, -17501, -17539, -17452, -16252, -16113, -16163, -16180, -16140, -14953, -14731, -14956, -14061, -13341, -13494, -13462, -13452, -13541, -12868, -12493, -12557, -12694, -11954, -11075, -11306, -11065, -9882, -9853, -9886, -9851, -9957, -9610, -8472, -8527, -8520, -8576, -8387, -7590, -7742, -6801, -6162, -6311, -6281, -6275, -6296, -6306, -5130, -4867, -4938, -5046, -4016, -3524, -3483, -2671, -2686, -2697, -2692, -2694, -2667, -2817, -1934, -1222, -1349, -1449, -909};