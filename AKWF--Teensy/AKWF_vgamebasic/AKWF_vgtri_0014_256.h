/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0014 256 samples */
 
const int16_t AKWF_vgtri_0014_256_DATA [256] = 
{487, 941, 1530, 1950, 2541, 3005, 3518, 4082, 4487, 5212, 5158, 5747, 7214, 7445, 7499, 8201, 8620, 9165, 9692, 10144, 10767, 11077, 12140, 12744, 12627, 13315, 13723, 14324, 14779, 15303, 15850, 16266, 16974, 16993, 17398, 17908, 18790, 19392, 19955, 20400, 20952, 21468, 21927, 22519, 22945, 23529, 24004, 24507, 25075, 25500, 26102, 26543, 27082, 27620, 28071, 28671, 29077, 29753, 29652, 30263, 30699, 31748, 32024, 31526, 30951, 31045, 30344, 29944, 29352, 28889, 28376, 27813, 27385, 26778, 26338, 25794, 25314, 24155, 24040, 23856, 23197, 22729, 22250, 21612, 21407, 21203, 20609, 19873, 19129, 18604, 18168, 17568, 17112, 16589, 16042, 15605, 15004, 14570, 14007, 13497, 13031, 12442, 12022, 11433, 10959, 10455, 9891, 9479, 8768, 8791, 8328, 7841, 6922, 6361, 5799, 5344, 4815, 4297, 3157, 3078, 2852, 2216, 1736, 1251, 666, 252, -389, -632, -849, -1461, -1812, -2685, -3541, -3499, -3445, -4082, -4543, -5534, -5999, -6532, -7057, -7516, -8114, -8532, -9117, -9599, -10093, -10664, -11089, -11687, -12137, -12675, -13213, -13655, -14257, -14681, -15249, -15754, -16215, -16888, -16993, -17391, -18364, -18827, -19297, -19887, -20308, -20895, -21370, -21874, -22453, -22797, -23703, -24536, -24389, -24983, -25434, -26033, -26459, -27034, -27522, -27998, -28642, -28836, -29050, -29637, -30384, -31119, -31655, -32058, -32757, -32397, -31874, -31330, -30892, -30286, -29851, -29296, -28784, -28321, -27729, -27304, -26716, -26246, -25739, -25173, -24768, -24054, -24086, -23613, -23131, -22187, -21722, -20811, -20025, -20169, -19543, -19111, -18510, -18086, -17517, -17014, -16535, -15949, -15529, -14922, -14565, -13401, -13068, -13061, -12346, -11945, -11301, -11405, -10763, -10303, -9312, -8847, -8317, -7782, -7333, -6733, -6308, -5731, -5246, -4757, -4183, -3756, -3156, -2703, -2176, -1633, -1202, -560, -280, -25};