/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0010 256 samples */
 
const int16_t AKWF_vgsqu_0010_256_DATA [256] = 
{22581, 28010, 25518, 27106, 27888, 28039, 28170, 28137, 28144, 28143, 28143, 28150, 28114, 28247, 28553, 28525, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28527, 28528, 28520, 28556, 28435, 28119, 28145, 28143, 28158, 28087, 28336, 28964, 28907, 28859, 29920, 28990, 34697, 4726, -34604, -28602, -29708, -29674, -29678, -29721, -29472, -29262, -29308, -29299, -29299, -29295, -29328, -29030, -28883, -28922, -28913, -28914, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28913, -28914, -28913, -28921, -28886, -29010, -29321, -29297, -29297, -29321, -29216, -29589, -30558, -30094, -31478, -27650};