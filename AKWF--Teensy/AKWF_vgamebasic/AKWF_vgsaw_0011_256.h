/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsaw_0011 256 samples */
 
const int16_t AKWF_vgsaw_0011_256_DATA [256] = 
{431, 926, 848, 796, 1025, 1753, 1628, 2228, 2635, 2507, 2637, 3011, 2905, 3443, 4543, 4722, 4664, 4696, 4601, 5190, 5616, 5486, 5604, 5985, 5880, 6461, 6858, 6842, 7617, 7698, 7569, 8145, 8596, 8467, 8577, 8960, 8859, 9412, 9877, 9741, 9843, 10872, 11552, 11476, 11493, 11467, 11542, 11935, 11838, 12365, 12860, 12705, 12871, 13633, 13548, 14055, 14555, 14430, 14515, 14907, 14820, 15317, 15834, 15704, 15774, 16767, 17506, 17442, 17421, 17776, 17903, 17864, 17887, 17797, 18409, 18770, 18774, 19551, 19609, 19489, 20104, 20473, 20471, 21250, 21305, 21230, 21540, 21714, 21747, 22516, 22593, 22465, 23058, 23458, 23442, 24176, 24402, 24703, 24687, 24658, 24720, 25479, 25577, 25444, 26014, 26439, 26400, 27178, 27274, 27185, 27473, 27682, 27680, 28442, 28562, 28420, 28972, 29418, 29374, 30532, 30673, 30586, 29969, 31011, -6377, -19216, -15671, -14740, -24113, -33633, -32462, -31264, -30951, -31254, -30234, -29201, -29415, -28948, -28505, -28510, -28511, -28524, -28518, -27772, -27602, -27756, -27266, -26736, -26835, -26068, -25949, -25841, -25495, -25545, -25550, -24812, -24618, -24774, -24308, -23761, -23866, -23114, -22926, -23016, -22883, -22037, -21632, -21723, -21683, -21783, -21358, -20778, -20897, -20155, -19940, -20054, -19829, -19541, -19613, -18889, -18653, -18814, -18401, -17800, -17923, -17199, -16958, -17076, -16863, -16559, -16634, -15970, -15599, -14919, -14873, -14897, -14940, -14239, -13973, -14094, -13896, -13579, -13670, -12975, -12687, -12855, -12485, -11840, -11980, -11283, -10990, -11115, -10927, -10599, -10699, -10013, -9705, -9873, -9517, -8954, -8450, -8007, -8095, -8117, -7963, -7621, -7726, -7056, -6723, -6892, -6571, -5890, -6030, -5375, -4686, -4673, -4686, -4676, -4684, -4710, -3968, -3840, -3634, -2921, -2984, -3002, -2336, -1973, -1295, -1260, -1282, -1297, -927, -881, -662, 6};