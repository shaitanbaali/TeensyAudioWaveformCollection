/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0005 256 samples */
 
const int16_t AKWF_vgtri_0005_256_DATA [256] = 
{2531, 2791, 2705, 2431, 4695, 6111, 5765, 5840, 5833, 5832, 5860, 5780, 5823, 8979, 9601, 9375, 9468, 9170, 11493, 12839, 12498, 12572, 12568, 12605, 12318, 14661, 15976, 15641, 15711, 15773, 15442, 17196, 21282, 22188, 21932, 21998, 21993, 21993, 21993, 21994, 21987, 22061, 21732, 22988, 25416, 24867, 27320, 28532, 28212, 28283, 28277, 28278, 28273, 28324, 28131, 28644, 31404, 31478, 31400, 31393, 31744, 31908, 31862, 31872, 31873, 31852, 31904, 31884, 29389, 28139, 25625, 25535, 25608, 25584, 25585, 25585, 25585, 25586, 25536, 25864, 23616, 22157, 22513, 22437, 22443, 22386, 22703, 20645, 16298, 15514, 15772, 15702, 15708, 15708, 15708, 15708, 15713, 15639, 16002, 14430, 12271, 12788, 10130, 9205, 9484, 9418, 9424, 9424, 9429, 9370, 9618, 8863, 6186, 6250, 6304, 6421, 3776, 2931, 3198, 3134, 3142, 3112, 3206, 3079, 312, -134, 42, -17, 12, 101, -2189, -2864, -2644, -2702, -2720, -2470, -4914, -6086, -5769, -5839, -5889, -5559, -7678, -9176, -11509, -12313, -12065, -12123, -12118, -12118, -12119, -12113, -12187, -11843, -13231, -15542, -15183, -15203, -17930, -18573, -18354, -18408, -18403, -18404, -18397, -18475, -18132, -19316, -22220, -21999, -21944, -21960, -24709, -25298, -25087, -25140, -25132, -25174, -25024, -25349, -28152, -28366, -28243, -28304, -28226, -28289, -31045, -31575, -31374, -31431, -31421, -31362, -32445, -32822, -32749, -32765, -32732, -32839, -30699, -29320, -26883, -26339, -26528, -26480, -26484, -26483, -26483, -26489, -26414, -26780, -25113, -23015, -23473, -23257, -20485, -20073, -20240, -20196, -20199, -20205, -20142, -20409, -19526, -16908, -17056, -17040, -17137, -16941, -14159, -13798, -13952, -13914, -13882, -14001, -13778, -10996, -10662, -10810, -10772, -10739, -10864, -10619, -7834, -7524, -7668, -7605, -7667, -7694, -4572, -3844, -4096, -4023, -4034, -4188, -1771, -486};