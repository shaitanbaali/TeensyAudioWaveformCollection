/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsin_0008 256 samples */
 
const int16_t AKWF_vgsin_0008_256_DATA [256] = 
{2140, 3945, 6798, 6517, 6547, 6546, 6628, 6233, 7977, 10358, 10030, 9904, 10425, 13166, 12864, 14659, 16454, 16099, 16169, 16163, 16219, 15861, 18341, 19970, 19629, 19489, 20339, 22029, 21638, 23741, 24667, 24412, 24469, 24477, 24453, 24377, 26611, 27242, 27070, 26965, 27784, 28488, 28402, 29975, 30222, 30124, 30148, 30163, 30098, 30246, 31416, 31492, 31448, 31429, 31783, 31905, 31954, 32343, 32336, 32329, 32332, 32331, 32331, 32331, 32332, 32328, 32341, 32327, 31918, 31955, 31593, 30946, 31033, 31021, 31024, 30992, 31147, 30431, 29588, 29706, 29809, 29425, 27886, 28116, 26995, 26047, 26252, 26210, 26212, 26186, 26394, 24758, 23845, 24009, 24294, 22951, 20699, 21167, 18985, 18159, 18400, 18346, 18331, 18377, 18406, 15746, 15127, 15272, 15619, 13306, 11541, 11756, 8944, 8630, 8771, 8737, 8687, 8894, 8355, 5262, 5169, 5258, 5467, 2158, 1253, 714, -2318, -2195, -2164, -2243, -1983, -2755, -5772, -5702, -5695, -5585, -5810, -9002, -8984, -10492, -12987, -12611, -12663, -12735, -12397, -13768, -15995, -15676, -15780, -15534, -16321, -18967, -18521, -20619, -22123, -21779, -21849, -21895, -21597, -23337, -24714, -24404, -24518, -24268, -25335, -26837, -26530, -28404, -28974, -28799, -28845, -28839, -28767, -29854, -30239, -30123, -30171, -30030, -30953, -31548, -31490, -32297, -32356, -32323, -32336, -32319, -32353, -32722, -32776, -32764, -32768, -32768, -32762, -32787, -32657, -32310, -32333, -32334, -32317, -32370, -32232, -31132, -30513, -30599, -30584, -30587, -30546, -30750, -29816, -28675, -28870, -28839, -28799, -28995, -28135, -26933, -27084, -27188, -26825, -24908, -24833, -25135, -23191, -22053, -22338, -22277, -22233, -22549, -20404, -18953, -19234, -19428, -18434, -16385, -16655, -16677, -14022, -13374, -13593, -13520, -13557, -13680, -10348, -9377, -9606, -9934, -7824, -5747, -6317, -5820, -3108, -2996, -3090, -3000, -3242, -2691};