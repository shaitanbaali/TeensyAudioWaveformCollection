/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgtri_0016 256 samples */
 
const int16_t AKWF_vgtri_0016_256_DATA [256] = 
{480, 950, 1167, 1498, 2117, 2594, 3068, 3706, 4735, 4940, 5171, 5698, 6141, 6852, 7820, 8016, 8247, 8796, 9263, 9878, 10193, 11257, 11841, 12047, 12311, 12977, 13289, 14393, 14908, 15120, 15403, 16047, 16493, 17029, 17544, 18649, 18898, 19132, 19589, 20103, 20676, 21750, 21970, 22204, 22690, 23195, 23783, 24125, 25083, 25805, 25994, 26237, 26895, 27211, 28221, 28877, 29074, 29330, 29974, 30393, 30968, 31461, 31991, 31850, 31564, 31198, 30613, 30145, 29021, 28743, 28509, 28088, 27534, 27013, 25914, 25666, 25434, 24979, 24449, 23881, 23525, 22615, 21833, 21647, 21411, 20768, 20440, 19475, 18764, 18572, 18325, 17685, 17269, 16664, 16285, 15133, 14776, 14548, 14193, 13582, 13164, 12018, 11710, 11476, 11091, 10508, 9982, 9570, 8802, 7885, 7696, 7463, 6872, 6500, 5659, 4803, 4619, 4385, 3783, 3354, 2732, 2397, 1274, 810, 590, 301, -401, -538, -1375, -1827, -2042, -2373, -2992, -3468, -3943, -4590, -5611, -5816, -6046, -6578, -7021, -7729, -8693, -8891, -9123, -9678, -10137, -10753, -11068, -12131, -12716, -12921, -13185, -13852, -14164, -15266, -15781, -15994, -16277, -16923, -17368, -17905, -18419, -19523, -19772, -20007, -20464, -20976, -21551, -22625, -22845, -23077, -23571, -24053, -24665, -25789, -26251, -26135, -26674, -27155, -27763, -28087, -29100, -29754, -29950, -30202, -30867, -31164, -32278, -32616, -32300, -32300, -31599, -31178, -30612, -30142, -29022, -28743, -28509, -28081, -27530, -27028, -25884, -25326, -25417, -24990, -24448, -23881, -23526, -22615, -21834, -21647, -21412, -20769, -20431, -19521, -18554, -18330, -18373, -17676, -17270, -16666, -16285, -15133, -14777, -14549, -14193, -13577, -13170, -12026, -11370, -11419, -11107, -10500, -9984, -9572, -8798, -7881, -7695, -7464, -6873, -6492, -5694, -4652, -4331, -4428, -3778, -3352, -2727, -2395, -1275, -817, -572, -356, -2, -37};