/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_vgsqu_0004 256 samples */
 
const int16_t AKWF_vgsqu_0004_256_DATA [256] = 
{25341, 33687, 32390, 32785, 32765, 32767, 32767, 32750, 32819, 32003, 31398, 31526, 31542, 31365, 31053, 31093, 31088, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31087, 31088, 31087, 31097, 31055, 31208, 31539, 31504, 31507, 31509, 31481, 31630, 30898, 30126, 30274, 30245, 30171, 29685, 33606, -9661, -33667, -27803, -29087, -28993, -28968, -28957, -30778, -31199, -31056, -31090, -31093, -31070, -31131, -31502, -31516, -31504, -31508, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31507, -31504, -31533, -31223, -31029, -30695, -30655, -30672, -30667, -30668, -30667, -30666, -30699, -30324, -31640, -27912};