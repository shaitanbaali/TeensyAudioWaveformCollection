/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0019 256 samples */
 
const int16_t AKWF_theremin_0019_256_DATA [256] = 
{10, 275, 2759, 7186, 12505, 18256, 23515, 27087, 28867, 29796, 30601, 31277, 31711, 31967, 32145, 32296, 32436, 32562, 32666, 32745, 32770, 32763, 32743, 32731, 32709, 32639, 32503, 32335, 32170, 32006, 31820, 31599, 31351, 31093, 30827, 30526, 30172, 29800, 29483, 29264, 29108, 28988, 28885, 28766, 28606, 28409, 28197, 27976, 27736, 27463, 27183, 26940, 26757, 26617, 26504, 26409, 26326, 26247, 26168, 26077, 25976, 25869, 25766, 25665, 25548, 25408, 25257, 25109, 24968, 24841, 24739, 24635, 24466, 24211, 23957, 23798, 23728, 23607, 23308, 23004, 23062, 23329, 22951, 21236, 18136, 13771, 8301, 2785, -1441, -4151, -6082, -7685, -9036, -10193, -11266, -12256, -13146, -13959, -14738, -15491, -16202, -16840, -17400, -17917, -18419, -18886, -19270, -19570, -19831, -20107, -20387, -20612, -20746, -20817, -20867, -20900, -20876, -20762, -20606, -20500, -20486, -20513, -20525, -20512, -20486, -20452, -20398, -20314, -20201, -20080, -19971, -19872, -19767, -19651, -19529, -19405, -19281, -19148, -19000, -18843, -18682, -18526, -18382, -18259, -18150, -18031, -17887, -17729, -17573, -17425, -17280, -17136, -16995, -16860, -16729, -16596, -16454, -16304, -16148, -15991, -15848, -15752, -15699, -15631, -15492, -15305, -15124, -14973, -14847, -14748, -14664, -14579, -14473, -14355, -14236, -14120, -14011, -13909, -13812, -13722, -13636, -13542, -13425, -13290, -13171, -13097, -13047, -12988, -12903, -12804, -12696, -12587, -12484, -12391, -12313, -12246, -12191, -12149, -12126, -12098, -12021, -11878, -11720, -11599, -11517, -11453, -11392, -11331, -11266, -11193, -11113, -11028, -10943, -10861, -10790, -10734, -10711, -10702, -10666, -10570, -10433, -10281, -10139, -10030, -9986, -9996, -10016, -10021, -10020, -10019, -10017, -10017, -10022, -10006, -9915, -9734, -9525, -9368, -9239, -9045, -8732, -8361, -8031, -7748, -7414, -6950, -6393, -5847, -5352, -4791, -4051, -3159, -2223, -1317, -546, -90};