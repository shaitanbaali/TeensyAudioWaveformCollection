/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0018 256 samples */
 
const int16_t AKWF_theremin_0018_256_DATA [256] = 
{1069, 3235, 5296, 7197, 8949, 10583, 12164, 13749, 15394, 17111, 18849, 20532, 22076, 23392, 24473, 25324, 25979, 26484, 26881, 27204, 27444, 27613, 27746, 27872, 28011, 28181, 28378, 28592, 28809, 29013, 29201, 29381, 29557, 29724, 29886, 30041, 30190, 30330, 30466, 30594, 30717, 30837, 30950, 31053, 31139, 31205, 31247, 31269, 31277, 31279, 31283, 31294, 31309, 31332, 31372, 31435, 31526, 31644, 31786, 31943, 32102, 32254, 32389, 32500, 32594, 32673, 32741, 32769, 32766, 32771, 32727, 32557, 32279, 31897, 31397, 30736, 29877, 28788, 27460, 25896, 24151, 22268, 20308, 18320, 16290, 14243, 12249, 10345, 8575, 6973, 5510, 4181, 2959, 1815, 749, -230, -1139, -1974, -2745, -3461, -4119, -4730, -5297, -5817, -6296, -6736, -7138, -7521, -7893, -8263, -8639, -9018, -9399, -9779, -10152, -10513, -10868, -11215, -11549, -11870, -12174, -12456, -12725, -12980, -13226, -13468, -13703, -13933, -14162, -14392, -14625, -14861, -15103, -15347, -15592, -15831, -16063, -16289, -16504, -16710, -16899, -17070, -17219, -17348, -17460, -17558, -17647, -17728, -17802, -17869, -17933, -17996, -18063, -18133, -18206, -18280, -18354, -18424, -18491, -18558, -18619, -18676, -18725, -18768, -18805, -18833, -18858, -18880, -18901, -18922, -18940, -18960, -18982, -19006, -19034, -19067, -19101, -19138, -19175, -19211, -19247, -19283, -19316, -19347, -19376, -19400, -19420, -19437, -19450, -19460, -19468, -19471, -19471, -19467, -19463, -19458, -19449, -19439, -19423, -19399, -19367, -19328, -19278, -19217, -19140, -19044, -18928, -18795, -18647, -18489, -18324, -18156, -17983, -17808, -17641, -17482, -17335, -17205, -17086, -16974, -16865, -16749, -16630, -16505, -16369, -16214, -16037, -15831, -15598, -15341, -15064, -14773, -14472, -14158, -13834, -13511, -13198, -12906, -12637, -12386, -12141, -11888, -11605, -11283, -10911, -10483, -10009, -9478, -8892, -8272, -7587, -6769, -5750, -4457, -2862, -932};