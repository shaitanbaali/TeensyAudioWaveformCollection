/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0006 256 samples */
 
const int16_t AKWF_theremin_0006_256_DATA [256] = 
{1558, 3013, 3740, 4804, 5947, 7107, 8279, 9434, 10579, 11706, 12794, 13849, 14859, 15815, 16719, 17575, 18395, 19184, 19941, 20664, 21355, 22026, 22679, 23318, 23941, 24547, 25141, 25727, 26305, 26881, 27449, 27993, 28501, 28949, 29324, 29623, 29853, 30024, 30149, 30243, 30311, 30350, 30362, 30350, 30316, 30261, 30188, 30098, 30000, 29898, 29799, 29706, 29619, 29537, 29451, 29354, 29245, 29122, 28983, 28823, 28626, 28384, 28087, 27735, 27331, 26894, 26439, 25978, 25525, 25074, 24603, 24099, 23535, 22899, 22199, 21439, 20634, 19806, 18964, 18120, 17283, 16451, 15658, 14928, 14270, 13699, 13208, 12792, 12446, 12159, 11922, 11731, 11590, 11507, 11490, 11544, 11669, 11843, 12016, 12128, 12122, 11963, 11646, 11174, 10546, 9762, 8830, 7757, 6538, 5185, 3710, 2135, 473, -1260, -3060, -4867, -6643, -8326, -9907, -11381, -12737, -13971, -15091, -16085, -16959, -17704, -18314, -18793, -19141, -19361, -19456, -19429, -19287, -19042, -18701, -18271, -17755, -17162, -16499, -15775, -14997, -14170, -13304, -12409, -11498, -10581, -9658, -8749, -7853, -6982, -6151, -5356, -4603, -3910, -3292, -2774, -2374, -2096, -1941, -1903, -1972, -2130, -2373, -2700, -3107, -3584, -4109, -4678, -5277, -5902, -6555, -7249, -7997, -8810, -9691, -10624, -11583, -12530, -13449, -14309, -15113, -15876, -16622, -17385, -18193, -19048, -19942, -20851, -21742, -22604, -23410, -24160, -24867, -25539, -26188, -26835, -27475, -28104, -28717, -29307, -29875, -30419, -30940, -31431, -31871, -32238, -32517, -32691, -32763, -32755, -32701, -32631, -32569, -32523, -32481, -32422, -32321, -32155, -31914, -31599, -31222, -30782, -30287, -29745, -29150, -28510, -27827, -27099, -26336, -25542, -24719, -23875, -22996, -22084, -21140, -20159, -19145, -18121, -17086, -16064, -15071, -14111, -13178, -12245, -11278, -10256, -9173, -8037, -6887, -5747, -4662, -3656, -2736, -1859, -1317, -489};