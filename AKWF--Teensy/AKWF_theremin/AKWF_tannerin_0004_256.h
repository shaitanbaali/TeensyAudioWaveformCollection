/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tannerin_0004 256 samples */
 
const int16_t AKWF_tannerin_0004_256_DATA [256] = 
{1178, 3449, 4752, 5333, 5827, 6551, 7384, 8213, 9027, 9841, 10641, 11440, 12223, 12985, 13730, 14455, 15161, 15855, 16534, 17198, 17852, 18494, 19132, 19762, 20386, 20996, 21600, 22193, 22771, 23339, 23891, 24428, 24954, 25465, 25959, 26438, 26898, 27343, 27773, 28185, 28581, 28960, 29319, 29665, 29994, 30305, 30599, 30875, 31133, 31375, 31597, 31801, 31986, 32152, 32298, 32425, 32532, 32620, 32686, 32733, 32760, 32767, 32755, 32720, 32667, 32592, 32497, 32380, 32243, 32085, 31906, 31707, 31488, 31250, 30995, 30721, 30432, 30128, 29809, 29480, 29137, 28779, 28410, 28028, 27630, 27216, 26786, 26335, 25866, 25378, 24869, 24339, 23788, 23215, 22625, 22019, 21401, 20767, 20122, 19466, 18802, 18134, 17459, 16777, 16088, 15391, 14690, 13985, 13270, 12547, 11816, 11076, 10332, 9580, 8818, 8051, 7277, 6498, 5720, 4931, 4138, 3342, 2542, 1741, 940, 129, -678, -1489, -2297, -3108, -3918, -4727, -5533, -6332, -7129, -7920, -8707, -9488, -10263, -11028, -11790, -12545, -13294, -14036, -14767, -15491, -16210, -16920, -17623, -18317, -18996, -19667, -20328, -20973, -21608, -22224, -22824, -23412, -23981, -24533, -25071, -25585, -26087, -26571, -27037, -27486, -27921, -28335, -28734, -29118, -29482, -29829, -30157, -30467, -30759, -31031, -31284, -31517, -31731, -31925, -32099, -32252, -32384, -32497, -32591, -32663, -32715, -32746, -32758, -32750, -32722, -32674, -32603, -32516, -32407, -32279, -32133, -31966, -31782, -31581, -31360, -31121, -30866, -30592, -30302, -29996, -29670, -29329, -28972, -28599, -28212, -27807, -27387, -26954, -26505, -26044, -25571, -25081, -24574, -24054, -23517, -22964, -22392, -21803, -21196, -20577, -19946, -19302, -18644, -17971, -17282, -16583, -15861, -15125, -14373, -13600, -12811, -12007, -11187, -10361, -9542, -8735, -7955, -7204, -6495, -5834, -5227, -4674, -4178, -3727, -3278, -2900, -2752, -2833, -2533, -1082};