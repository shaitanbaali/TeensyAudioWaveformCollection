/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tannerin_0003 256 samples */
 
const int16_t AKWF_tannerin_0003_256_DATA [256] = 
{766, 2344, 3275, 3813, 4366, 5102, 5937, 6788, 7636, 8494, 9350, 10199, 11034, 11851, 12643, 13423, 14185, 14931, 15664, 16376, 17074, 17763, 18438, 19104, 19752, 20390, 21016, 21625, 22215, 22789, 23347, 23892, 24425, 24943, 25449, 25942, 26423, 26894, 27353, 27799, 28230, 28646, 29045, 29428, 29793, 30138, 30459, 30761, 31040, 31299, 31536, 31751, 31943, 32116, 32267, 32398, 32508, 32599, 32670, 32722, 32754, 32767, 32762, 32736, 32689, 32623, 32536, 32428, 32301, 32152, 31981, 31788, 31576, 31342, 31089, 30816, 30522, 30211, 29883, 29535, 29173, 28792, 28396, 27988, 27563, 27123, 26668, 26198, 25712, 25217, 24701, 24171, 23627, 23066, 22493, 21907, 21303, 20687, 20057, 19414, 18763, 18096, 17415, 16725, 16023, 15309, 14591, 13857, 13113, 12363, 11602, 10837, 10064, 9280, 8491, 7697, 6895, 6095, 5286, 4471, 3653, 2834, 2014, 1194, 372, -449, -1267, -2080, -2895, -3704, -4509, -5310, -6099, -6887, -7671, -8444, -9212, -9970, -10713, -11455, -12184, -12901, -13609, -14304, -14986, -15659, -16322, -16968, -17608, -18231, -18844, -19448, -20041, -20620, -21186, -21739, -22281, -22811, -23326, -23831, -24318, -24795, -25259, -25710, -26147, -26570, -26980, -27376, -27757, -28124, -28475, -28807, -29124, -29422, -29703, -29967, -30209, -30431, -30636, -30822, -30989, -31135, -31263, -31374, -31467, -31542, -31599, -31637, -31659, -31663, -31649, -31618, -31568, -31500, -31415, -31309, -31187, -31045, -30885, -30707, -30510, -30296, -30062, -29813, -29544, -29259, -28956, -28635, -28298, -27947, -27575, -27189, -26786, -26365, -25934, -25484, -25020, -24542, -24048, -23543, -23027, -22495, -21952, -21400, -20837, -20270, -19691, -19101, -18500, -17888, -17261, -16620, -15963, -15290, -14602, -13903, -13187, -12465, -11733, -10999, -10273, -9554, -8843, -8156, -7487, -6841, -6224, -5624, -5052, -4487, -3927, -3465, -3196, -2973, -2346, -956};