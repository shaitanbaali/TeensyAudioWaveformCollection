/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0012 256 samples */
 
const int16_t AKWF_theremin_0012_256_DATA [256] = 
{1170, 4933, 10339, 16586, 22204, 26074, 28471, 30033, 31086, 31810, 32298, 32602, 32743, 32770, 32656, 32376, 32041, 31694, 31369, 31013, 30672, 30364, 30042, 29680, 29281, 28876, 28489, 28111, 27722, 27362, 27028, 26659, 26271, 25941, 25601, 25249, 24908, 24601, 24311, 23993, 23676, 23415, 23135, 22837, 22608, 22366, 22075, 21809, 21563, 21350, 21120, 20900, 20697, 20485, 20263, 20043, 19825, 19624, 19434, 19277, 19103, 18914, 18738, 18582, 18457, 18311, 18141, 18009, 17906, 17772, 17627, 17498, 17367, 17240, 17106, 17005, 16906, 16799, 16696, 16573, 16461, 16387, 16266, 16151, 16044, 15949, 15875, 15786, 15690, 15606, 15526, 15453, 15359, 15304, 15246, 15145, 15109, 15067, 15011, 14944, 14838, 14736, 14673, 14616, 14552, 14478, 14412, 14356, 14324, 14295, 14246, 14175, 14096, 14045, 13972, 13906, 13795, 13662, 13589, 13640, 13810, 13976, 14095, 14160, 14242, 14316, 14346, 14339, 14316, 14331, 14209, 13670, 10389, 2609, -6010, -11441, -14536, -16946, -19019, -20833, -22401, -23771, -24974, -25998, -26871, -27579, -28112, -28501, -28879, -29290, -29677, -30027, -30346, -30587, -30756, -30939, -31059, -31130, -31186, -31198, -31178, -31091, -31029, -30973, -30867, -30726, -30573, -30398, -30201, -30020, -29831, -29604, -29377, -29174, -28964, -28745, -28509, -28238, -27971, -27715, -27482, -27243, -26984, -26762, -26581, -26386, -26135, -25856, -25635, -25432, -25216, -25004, -24779, -24578, -24360, -24169, -23984, -23790, -23586, -23385, -23203, -22991, -22781, -22606, -22452, -22303, -22116, -21908, -21745, -21562, -21365, -21197, -21045, -20869, -20670, -20472, -20296, -20130, -19931, -19732, -19541, -19323, -19084, -18853, -18628, -18386, -18151, -17890, -17601, -17276, -16907, -16527, -16158, -15761, -15294, -14833, -14353, -13851, -13299, -12671, -12028, -11359, -10665, -10035, -9404, -8798, -8195, -7527, -6866, -6148, -5343, -4520, -3615, -2723, -1618, -486};