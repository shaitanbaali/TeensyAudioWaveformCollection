/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0008 256 samples */
 
const int16_t AKWF_theremin_0008_256_DATA [256] = 
{1083, 4322, 8967, 14828, 20818, 25388, 27974, 29405, 30355, 30976, 31389, 31777, 32102, 32303, 32415, 32514, 32627, 32733, 32770, 32767, 32765, 32719, 32633, 32503, 32335, 32171, 32046, 31931, 31772, 31549, 31296, 31044, 30782, 30487, 30151, 29819, 29539, 29313, 29126, 28969, 28824, 28669, 28500, 28320, 28139, 27941, 27709, 27445, 27168, 26893, 26648, 26480, 26401, 26354, 26283, 26184, 26074, 25962, 25839, 25699, 25553, 25424, 25328, 25238, 25113, 24954, 24805, 24698, 24607, 24487, 24327, 24159, 24006, 23858, 23672, 23444, 23243, 23076, 22912, 22859, 22859, 22056, 19436, 15120, 10002, 4757, -26, -3545, -5690, -7163, -8581, -9918, -11041, -11990, -12865, -13718, -14548, -15320, -16016, -16658, -17245, -17784, -18280, -18737, -19144, -19491, -19777, -20023, -20238, -20419, -20563, -20667, -20729, -20748, -20730, -20673, -20590, -20511, -20464, -20447, -20453, -20472, -20478, -20437, -20352, -20256, -20173, -20086, -19975, -19841, -19704, -19580, -19461, -19328, -19180, -19035, -18909, -18792, -18676, -18552, -18422, -18288, -18147, -18004, -17858, -17705, -17540, -17368, -17214, -17096, -16993, -16879, -16748, -16607, -16460, -16311, -16172, -16041, -15902, -15734, -15555, -15409, -15315, -15229, -15103, -14945, -14788, -14652, -14535, -14433, -14340, -14249, -14150, -14050, -13958, -13876, -13798, -13722, -13637, -13524, -13378, -13240, -13150, -13094, -13031, -12939, -12831, -12722, -12617, -12514, -12419, -12326, -12232, -12136, -12052, -11989, -11932, -11847, -11729, -11620, -11556, -11517, -11457, -11360, -11265, -11218, -11201, -11153, -11048, -10930, -10864, -10842, -10803, -10712, -10604, -10533, -10502, -10462, -10378, -10266, -10160, -10069, -9980, -9875, -9781, -9756, -9821, -9906, -9931, -9897, -9860, -9847, -9813, -9706, -9529, -9339, -9176, -9006, -8771, -8468, -8163, -7906, -7651, -7301, -6826, -6293, -5773, -5241, -4651, -3989, -3250, -2407, -1543, -801, -337, -193};