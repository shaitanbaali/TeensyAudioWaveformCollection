/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0021 256 samples */
 
const int16_t AKWF_theremin_0021_256_DATA [256] = 
{1847, 8892, 16009, 19367, 20176, 20743, 21400, 22006, 22688, 23415, 24067, 24659, 25180, 25628, 26029, 26403, 26749, 27067, 27367, 27661, 27957, 28273, 28625, 28995, 29364, 29716, 30025, 30279, 30497, 30697, 30889, 31097, 31320, 31541, 31743, 31916, 32039, 32117, 32177, 32229, 32290, 32377, 32479, 32579, 32669, 32731, 32760, 32767, 32767, 32767, 32767, 32767, 32767, 32759, 32724, 32647, 32535, 32412, 32289, 32177, 32087, 32019, 31970, 31943, 31948, 31980, 32023, 32071, 32081, 31989, 31808, 31621, 31458, 31453, 31743, 32151, 32358, 32174, 31275, 29443, 26916, 23949, 20696, 17338, 14014, 10845, 7918, 5365, 3451, 2147, 1202, 478, -229, -1143, -2217, -3300, -4342, -5257, -6001, -6627, -7206, -7772, -8384, -9053, -9738, -10408, -11032, -11576, -12047, -12471, -12872, -13270, -13683, -14107, -14517, -14902, -15243, -15530, -15775, -16001, -16215, -16437, -16672, -16901, -17116, -17305, -17452, -17559, -17651, -17734, -17829, -17953, -18091, -18221, -18333, -18400, -18415, -18394, -18355, -18309, -18276, -18260, -18253, -18248, -18241, -18221, -18196, -18176, -18167, -18185, -18239, -18316, -18393, -18457, -18478, -18447, -18386, -18318, -18257, -18230, -18245, -18274, -18301, -18314, -18291, -18236, -18171, -18106, -18056, -18036, -18033, -18034, -18032, -18009, -17958, -17896, -17835, -17786, -17766, -17775, -17791, -17799, -17784, -17726, -17629, -17519, -17403, -17298, -17214, -17148, -17095, -17054, -17021, -16998, -16985, -16982, -16992, -17015, -17051, -17087, -17121, -17137, -17126, -17094, -17057, -17023, -17012, -17034, -17073, -17114, -17142, -17140, -17100, -17038, -16969, -16905, -16862, -16840, -16823, -16799, -16757, -16682, -16583, -16476, -16371, -16286, -16234, -16195, -16147, -16073, -15939, -15741, -15511, -15271, -15054, -14904, -14806, -14706, -14570, -14319, -13883, -13325, -12742, -12201, -11893, -11905, -11979, -11871, -11379, -10086, -7964, -5502, -2911, -806, -486, -795};