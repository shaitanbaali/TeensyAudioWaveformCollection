/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0003 256 samples */
 
const int16_t AKWF_theremin_0003_256_DATA [256] = 
{3191, 8363, 12539, 15070, 16355, 17180, 18298, 19764, 21369, 22962, 24436, 25848, 27173, 28392, 29505, 30478, 31280, 31896, 32324, 32614, 32762, 32768, 32766, 32771, 32684, 32488, 32271, 32054, 31854, 31679, 31542, 31453, 31415, 31420, 31453, 31508, 31583, 31676, 31785, 31905, 32029, 32150, 32262, 32363, 32453, 32532, 32598, 32654, 32698, 32732, 32752, 32754, 32729, 32675, 32588, 32459, 32284, 32063, 31793, 31479, 31122, 30719, 30274, 29783, 29241, 28643, 27980, 27242, 26424, 25523, 24532, 23454, 22284, 20999, 19609, 18112, 16518, 14849, 13107, 11301, 9472, 7631, 5797, 4011, 2268, 599, -984, -2482, -3878, -5163, -6363, -7473, -8500, -9447, -10311, -11102, -11824, -12480, -13081, -13634, -14134, -14587, -14987, -15335, -15634, -15878, -16069, -16212, -16318, -16395, -16449, -16485, -16513, -16538, -16567, -16601, -16648, -16710, -16784, -16870, -16962, -17064, -17169, -17272, -17371, -17462, -17541, -17602, -17644, -17667, -17666, -17641, -17594, -17529, -17449, -17357, -17256, -17152, -17049, -16948, -16856, -16778, -16715, -16670, -16644, -16641, -16660, -16700, -16755, -16825, -16908, -17000, -17099, -17200, -17301, -17397, -17485, -17564, -17633, -17691, -17738, -17776, -17804, -17825, -17838, -17844, -17843, -17833, -17818, -17796, -17768, -17736, -17697, -17653, -17605, -17550, -17491, -17425, -17356, -17282, -17205, -17126, -17045, -16962, -16880, -16799, -16719, -16639, -16558, -16478, -16398, -16318, -16241, -16167, -16098, -16037, -15982, -15938, -15902, -15878, -15867, -15869, -15887, -15918, -15963, -16018, -16084, -16157, -16232, -16309, -16385, -16455, -16519, -16572, -16613, -16637, -16640, -16623, -16587, -16533, -16464, -16381, -16292, -16203, -16118, -16039, -15971, -15915, -15873, -15861, -15885, -15942, -16029, -16138, -16262, -16392, -16504, -16576, -16594, -16545, -16410, -16174, -15831, -15362, -14751, -13999, -13118, -12115, -10980, -9686, -8398, -7313, -6624, -5969, -4479, -1303};