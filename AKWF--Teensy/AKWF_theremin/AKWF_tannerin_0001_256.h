/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tannerin_0001 256 samples */
 
const int16_t AKWF_tannerin_0001_256_DATA [256] = 
{414, 1015, 1781, 2660, 3581, 4504, 5401, 6259, 7086, 7895, 8684, 9462, 10234, 10992, 11739, 12472, 13189, 13899, 14601, 15302, 16003, 16701, 17392, 18074, 18744, 19404, 20050, 20680, 21295, 21894, 22485, 23062, 23631, 24190, 24735, 25269, 25788, 26292, 26777, 27242, 27683, 28108, 28512, 28898, 29265, 29614, 29943, 30257, 30549, 30825, 31084, 31321, 31541, 31742, 31924, 32087, 32234, 32360, 32472, 32568, 32647, 32709, 32750, 32768, 32759, 32721, 32652, 32554, 32431, 32288, 32130, 31966, 31798, 31626, 31446, 31252, 31039, 30801, 30532, 30229, 29895, 29534, 29152, 28758, 28350, 27936, 27518, 27090, 26653, 26203, 25731, 25238, 24723, 24184, 23629, 23056, 22467, 21866, 21255, 20633, 20007, 19366, 18712, 18046, 17365, 16672, 15966, 15246, 14515, 13777, 13028, 12278, 11519, 10752, 9983, 9209, 8439, 7671, 6904, 6140, 5380, 4622, 3856, 3084, 2304, 1512, 716, -86, -897, -1710, -2523, -3336, -4142, -4954, -5762, -6565, -7366, -8159, -8945, -9729, -10506, -11271, -12027, -12764, -13488, -14198, -14891, -15573, -16242, -16906, -17570, -18235, -18898, -19557, -20205, -20840, -21454, -22048, -22614, -23158, -23681, -24188, -24681, -25164, -25635, -26094, -26543, -26981, -27409, -27825, -28231, -28632, -29022, -29398, -29756, -30093, -30402, -30680, -30932, -31155, -31352, -31526, -31681, -31817, -31935, -32035, -32116, -32182, -32237, -32282, -32319, -32350, -32372, -32380, -32371, -32337, -32274, -32182, -32060, -31913, -31738, -31542, -31330, -31102, -30858, -30597, -30318, -30022, -29710, -29376, -29025, -28656, -28268, -27865, -27443, -26995, -26528, -26037, -25524, -24996, -24457, -23907, -23356, -22807, -22261, -21712, -21157, -20586, -19997, -19387, -18746, -18081, -17397, -16695, -15987, -15275, -14557, -13842, -13124, -12401, -11678, -10939, -10188, -9433, -8674, -7915, -7155, -6382, -5605, -4814, -4004, -3191, -2413, -1740, -1025, -208};