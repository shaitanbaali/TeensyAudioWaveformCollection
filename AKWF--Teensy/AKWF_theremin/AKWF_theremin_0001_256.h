/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0001 256 samples */
 
const int16_t AKWF_theremin_0001_256_DATA [256] = 
{363, 932, 1483, 2031, 2577, 3120, 3659, 4193, 4713, 5227, 5728, 6218, 6694, 7160, 7618, 8066, 8504, 8937, 9362, 9784, 10203, 10615, 11019, 11415, 11809, 12203, 12601, 13004, 13406, 13799, 14179, 14543, 14896, 15244, 15593, 15947, 16303, 16660, 17015, 17368, 17717, 18061, 18395, 18716, 19025, 19324, 19620, 19921, 20221, 20525, 20832, 21138, 21452, 21766, 22068, 22352, 22611, 22851, 23084, 23318, 23558, 23801, 24045, 24287, 24524, 24756, 24981, 25196, 25398, 25586, 25762, 25928, 26083, 26231, 26367, 26494, 26610, 26718, 26813, 26891, 26948, 26980, 26988, 26975, 26948, 26910, 26858, 26794, 26719, 26635, 26542, 26434, 26307, 26152, 25971, 25765, 25544, 25318, 25090, 24851, 24589, 24285, 23934, 23542, 23121, 22691, 22260, 21822, 21374, 20909, 20421, 19917, 19385, 18826, 18239, 17631, 16988, 16317, 15620, 14893, 14142, 13383, 12614, 11851, 11090, 10310, 9508, 8663, 7779, 6878, 5972, 5075, 4194, 3309, 2418, 1519, 605, -312, -1231, -2150, -3063, -3972, -4890, -5818, -6770, -7738, -8710, -9674, -10623, -11558, -12481, -13387, -14269, -15130, -15971, -16810, -17649, -18495, -19333, -20155, -20953, -21729, -22478, -23200, -23886, -24545, -25173, -25776, -26366, -26945, -27512, -28060, -28581, -29066, -29516, -29932, -30321, -30689, -31031, -31345, -31630, -31880, -32097, -32280, -32433, -32554, -32643, -32703, -32742, -32764, -32768, -32768, -32758, -32711, -32627, -32509, -32360, -32183, -31978, -31749, -31492, -31210, -30901, -30567, -30209, -29832, -29442, -29043, -28634, -28206, -27758, -27286, -26792, -26282, -25762, -25228, -24684, -24132, -23573, -23002, -22426, -21838, -21232, -20605, -19954, -19282, -18601, -17919, -17243, -16573, -15903, -15241, -14582, -13929, -13284, -12640, -11990, -11342, -10692, -10039, -9390, -8733, -8077, -7430, -6794, -6176, -5572, -4968, -4362, -3750, -3133, -2524, -1923, -1335, -759, -183};