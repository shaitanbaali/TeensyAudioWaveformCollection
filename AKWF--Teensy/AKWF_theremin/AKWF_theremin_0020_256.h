/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0020 256 samples */
 
const int16_t AKWF_theremin_0020_256_DATA [256] = 
{1775, 6885, 13949, 20422, 24436, 26830, 28379, 29505, 30407, 31141, 31695, 32094, 32394, 32608, 32723, 32770, 32737, 32568, 32312, 31999, 31691, 31458, 31278, 31099, 30886, 30648, 30399, 30145, 29888, 29645, 29398, 29110, 28837, 28591, 28341, 28041, 27742, 27500, 27283, 27035, 26766, 26531, 26297, 26059, 25845, 25615, 25392, 25194, 24970, 24737, 24504, 24250, 24017, 23825, 23680, 23625, 23618, 23587, 23524, 23439, 23352, 23270, 23169, 23062, 22970, 22831, 22701, 22583, 22217, 21459, 19569, 15409, 9065, 2428, -2096, -4944, -6916, -8573, -10060, -11372, -12483, -13468, -14346, -15098, -15719, -16243, -16671, -16992, -17222, -17363, -17448, -17539, -17657, -17790, -17905, -17921, -17916, -17956, -17905, -17803, -17705, -17588, -17516, -17452, -17294, -17144, -17022, -16889, -16747, -16601, -16449, -16281, -16099, -15918, -15754, -15610, -15460, -15286, -15106, -14929, -14766, -14622, -14465, -14296, -14143, -14007, -13877, -13727, -13548, -13389, -13252, -13073, -12914, -12797, -12678, -12556, -12425, -12291, -12193, -12088, -11944, -11797, -11659, -11540, -11450, -11371, -11286, -11194, -11115, -11020, -10897, -10792, -10679, -10565, -10498, -10444, -10373, -10287, -10208, -10129, -10042, -9973, -9916, -9854, -9772, -9695, -9617, -9529, -9483, -9448, -9393, -9350, -9302, -9236, -9161, -9107, -9061, -8994, -8937, -8877, -8809, -8768, -8740, -8705, -8658, -8629, -8593, -8510, -8439, -8406, -8387, -8326, -8275, -8265, -8247, -8182, -8094, -8042, -8016, -8004, -7991, -7958, -7926, -7904, -7873, -7812, -7745, -7718, -7672, -7624, -7613, -7609, -7568, -7502, -7472, -7462, -7450, -7419, -7373, -7323, -7281, -7253, -7227, -7193, -7155, -7110, -7063, -7010, -6947, -6879, -6800, -6692, -6612, -6581, -6533, -6423, -6258, -6080, -5887, -5735, -5671, -5651, -5611, -5516, -5385, -5205, -4981, -4737, -4440, -4113, -3751, -3246, -2695, -2164, -1560, -728};