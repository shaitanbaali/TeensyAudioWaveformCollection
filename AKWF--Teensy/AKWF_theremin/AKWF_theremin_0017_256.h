/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0017 256 samples */
 
const int16_t AKWF_theremin_0017_256_DATA [256] = 
{304, 848, 1372, 1934, 2545, 3238, 4411, 6769, 10557, 15424, 20821, 25789, 29448, 31525, 32440, 32758, 32685, 32475, 32105, 31582, 31016, 30425, 29802, 29187, 28616, 28102, 27620, 27084, 26559, 26038, 25527, 25051, 24560, 24070, 23636, 23184, 22747, 22375, 21994, 21599, 21221, 20850, 20500, 20198, 19877, 19560, 19306, 19024, 18755, 18454, 18196, 17985, 17706, 17481, 17357, 17170, 16918, 16694, 16540, 16390, 16203, 16015, 15834, 15652, 15534, 15422, 15266, 15129, 14998, 14881, 14794, 14652, 14505, 14431, 14344, 14239, 14172, 14056, 13943, 13848, 13768, 13654, 13490, 13372, 13412, 13503, 13671, 13781, 13825, 13922, 13891, 13878, 13876, 13659, 12559, 8945, 2044, -5756, -11664, -14969, -16747, -18019, -19026, -19846, -20509, -20997, -21296, -21420, -21439, -21464, -21573, -21651, -21672, -21647, -21571, -21441, -21303, -21132, -20954, -20779, -20528, -20246, -19957, -19703, -19424, -19133, -18841, -18512, -18216, -17914, -17595, -17283, -17017, -16747, -16426, -16139, -15875, -15572, -15341, -15063, -14742, -14526, -14302, -14079, -13817, -13556, -13357, -13177, -13011, -12818, -12649, -12491, -12295, -12126, -11975, -11815, -11651, -11511, -11337, -11196, -11030, -10923, -10829, -10728, -10614, -10507, -10435, -10357, -10249, -10116, -9992, -9934, -9837, -9757, -9721, -9649, -9547, -9451, -9403, -9358, -9276, -9242, -9182, -9117, -9072, -9057, -9024, -8948, -8882, -8839, -8778, -8697, -8652, -8642, -8639, -8603, -8568, -8529, -8468, -8424, -8399, -8339, -8321, -8312, -8242, -8248, -8178, -8152, -8110, -8091, -8085, -8047, -8031, -7995, -7966, -7923, -7890, -7852, -7794, -7781, -7756, -7706, -7635, -7558, -7489, -7450, -7356, -7268, -7200, -7155, -7071, -6988, -6924, -6787, -6613, -6517, -6425, -6294, -6081, -5848, -5634, -5389, -5176, -4914, -4628, -4307, -3948, -3583, -3210, -2789, -2357, -1869, -1390, -988, -557, -160};