/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0014 256 samples */
 
const int16_t AKWF_theremin_0014_256_DATA [256] = 
{3646, 9588, 13565, 15191, 15585, 15972, 16566, 17201, 17832, 18510, 19225, 19911, 20559, 21156, 21685, 22148, 22562, 22952, 23326, 23690, 24067, 24457, 24847, 25228, 25595, 25938, 26257, 26546, 26807, 27049, 27271, 27473, 27657, 27825, 27978, 28123, 28259, 28391, 28519, 28648, 28778, 28910, 29045, 29188, 29344, 29507, 29672, 29831, 29980, 30112, 30214, 30292, 30353, 30404, 30450, 30498, 30559, 30627, 30694, 30754, 30802, 30831, 30834, 30814, 30781, 30741, 30699, 30661, 30635, 30619, 30606, 30597, 30588, 30575, 30554, 30529, 30507, 30491, 30486, 30502, 30545, 30606, 30670, 30729, 30773, 30782, 30749, 30681, 30600, 30517, 30442, 30399, 30400, 30432, 30467, 30499, 30509, 30459, 30334, 30167, 30003, 29862, 29767, 29759, 29852, 30006, 30155, 30252, 30300, 30309, 30247, 30011, 29494, 28644, 27321, 25324, 22627, 19439, 16040, 12559, 9205, 6255, 3825, 1795, 29, -1521, -2879, -4111, -5259, -6332, -7320, -8241, -9140, -10061, -11029, -12011, -12981, -13933, -14837, -15669, -16431, -17137, -17817, -18477, -19127, -19800, -20492, -21182, -21854, -22498, -23093, -23629, -24101, -24528, -24933, -25318, -25707, -26122, -26556, -26996, -27420, -27819, -28183, -28491, -28745, -28962, -29160, -29343, -29524, -29719, -29927, -30136, -30341, -30538, -30719, -30873, -31005, -31130, -31253, -31380, -31528, -31708, -31911, -32117, -32309, -32475, -32590, -32635, -32618, -32569, -32505, -32442, -32402, -32405, -32446, -32506, -32571, -32636, -32687, -32712, -32716, -32712, -32707, -32701, -32707, -32721, -32744, -32766, -32767, -32768, -32763, -32667, -32508, -32331, -32152, -31982, -31849, -31771, -31728, -31689, -31641, -31560, -31415, -31190, -30900, -30589, -30263, -29944, -29678, -29475, -29306, -29127, -28920, -28644, -28230, -27657, -26985, -26282, -25570, -24929, -24487, -24263, -24122, -23878, -23462, -22738, -21500, -19705, -17503, -15108, -12524, -10032, -8093, -6883, -5308, -1736};