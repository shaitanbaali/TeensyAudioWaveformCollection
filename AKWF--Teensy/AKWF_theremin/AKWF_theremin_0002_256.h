/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0002 256 samples */
 
const int16_t AKWF_theremin_0002_256_DATA [256] = 
{1514, 9490, 18580, 24148, 25780, 26005, 26789, 27981, 29079, 29917, 30630, 31261, 31832, 32298, 32598, 32729, 32763, 32767, 32767, 32768, 32767, 32768, 32763, 32692, 32584, 32495, 32440, 32409, 32399, 32405, 32425, 32454, 32485, 32510, 32525, 32526, 32511, 32476, 32424, 32360, 32287, 32207, 32125, 32041, 31960, 31883, 31810, 31748, 31693, 31645, 31595, 31537, 31462, 31358, 31213, 31018, 30757, 30427, 30026, 29557, 29015, 28402, 27723, 26968, 26131, 25215, 24204, 23103, 21915, 20627, 19244, 17769, 16201, 14554, 12854, 11111, 9357, 7595, 5853, 4147, 2487, 879, -675, -2180, -3637, -5036, -6365, -7615, -8795, -9889, -10900, -11819, -12636, -13355, -13979, -14509, -14955, -15329, -15639, -15904, -16132, -16336, -16523, -16693, -16850, -16995, -17121, -17232, -17327, -17412, -17485, -17546, -17595, -17636, -17671, -17702, -17729, -17755, -17779, -17797, -17807, -17808, -17795, -17767, -17725, -17662, -17578, -17478, -17362, -17236, -17106, -16982, -16868, -16771, -16698, -16652, -16640, -16666, -16725, -16814, -16928, -17056, -17191, -17325, -17446, -17546, -17619, -17661, -17668, -17640, -17585, -17505, -17407, -17292, -17168, -17038, -16911, -16791, -16678, -16573, -16478, -16391, -16307, -16230, -16159, -16094, -16035, -15983, -15934, -15891, -15853, -15819, -15790, -15768, -15751, -15743, -15744, -15754, -15773, -15801, -15841, -15895, -15962, -16040, -16127, -16220, -16315, -16407, -16488, -16555, -16605, -16635, -16640, -16619, -16575, -16512, -16431, -16339, -16241, -16145, -16055, -15977, -15913, -15867, -15840, -15830, -15834, -15847, -15866, -15888, -15907, -15919, -15920, -15908, -15872, -15811, -15726, -15621, -15497, -15364, -15234, -15113, -15009, -14921, -14861, -14847, -14884, -14965, -15080, -15218, -15347, -15430, -15442, -15355, -15138, -14777, -14244, -13524, -12625, -11572, -10390, -9112, -7794, -6478, -5212, -4037, -2990, -2092, -1362, -802, -399, 18, 378, 113, -1268, -1722};