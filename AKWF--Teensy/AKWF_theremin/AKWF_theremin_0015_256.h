/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0015 256 samples */
 
const int16_t AKWF_theremin_0015_256_DATA [256] = 
{1340, 3695, 6090, 8553, 11091, 13762, 16540, 19236, 21589, 23402, 24698, 25617, 26304, 26802, 27148, 27441, 27758, 28123, 28506, 28853, 29161, 29442, 29692, 29914, 30109, 30281, 30440, 30592, 30738, 30876, 31005, 31129, 31248, 31365, 31477, 31587, 31694, 31805, 31916, 32026, 32128, 32221, 32304, 32370, 32409, 32419, 32408, 32388, 32366, 32343, 32333, 32355, 32412, 32496, 32588, 32675, 32750, 32769, 32765, 32674, 32502, 32310, 32129, 31964, 31849, 31837, 31958, 32185, 32441, 32661, 32766, 32772, 32702, 32390, 31859, 31099, 30107, 28895, 27420, 25628, 23462, 20960, 18245, 15452, 12651, 9908, 7369, 5158, 3316, 1778, 445, -731, -1755, -2683, -3562, -4412, -5230, -5993, -6688, -7329, -7923, -8474, -8996, -9484, -9947, -10386, -10803, -11201, -11584, -11951, -12304, -12645, -12971, -13288, -13595, -13892, -14181, -14460, -14724, -14978, -15217, -15440, -15642, -15822, -15980, -16125, -16259, -16384, -16504, -16625, -16751, -16879, -17007, -17127, -17241, -17344, -17429, -17496, -17542, -17575, -17601, -17621, -17639, -17660, -17690, -17729, -17771, -17813, -17849, -17880, -17900, -17906, -17896, -17874, -17845, -17812, -17777, -17739, -17705, -17674, -17646, -17621, -17597, -17575, -17556, -17541, -17529, -17519, -17512, -17506, -17501, -17496, -17488, -17477, -17465, -17455, -17447, -17443, -17445, -17456, -17477, -17506, -17539, -17574, -17609, -17643, -17671, -17693, -17707, -17717, -17721, -17721, -17714, -17704, -17687, -17667, -17641, -17613, -17583, -17551, -17517, -17482, -17448, -17414, -17379, -17345, -17311, -17278, -17246, -17215, -17184, -17150, -17112, -17068, -17014, -16953, -16880, -16797, -16705, -16607, -16502, -16388, -16264, -16136, -16000, -15859, -15716, -15567, -15421, -15278, -15140, -15001, -14852, -14689, -14507, -14299, -14060, -13783, -13467, -13118, -12735, -12319, -11878, -11426, -10965, -10485, -9966, -9385, -8721, -7985, -7180, -6320, -5364, -4180, -2662, -747};