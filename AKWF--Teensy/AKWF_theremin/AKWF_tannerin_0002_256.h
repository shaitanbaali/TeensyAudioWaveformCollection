/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tannerin_0002 256 samples */
 
const int16_t AKWF_tannerin_0002_256_DATA [256] = 
{1810, 4674, 6553, 7456, 7871, 8350, 9043, 9835, 10634, 11390, 12136, 12874, 13606, 14333, 15052, 15761, 16459, 17140, 17813, 18471, 19115, 19747, 20362, 20964, 21557, 22134, 22700, 23256, 23794, 24322, 24837, 25337, 25825, 26295, 26748, 27190, 27613, 28022, 28415, 28789, 29148, 29491, 29815, 30123, 30414, 30686, 30941, 31181, 31401, 31603, 31786, 31951, 32100, 32231, 32342, 32437, 32513, 32572, 32611, 32634, 32638, 32623, 32589, 32534, 32460, 32366, 32250, 32113, 31955, 31775, 31572, 31352, 31109, 30845, 30562, 30258, 29938, 29601, 29244, 28872, 28484, 28080, 27664, 27234, 26787, 26327, 25853, 25364, 24866, 24350, 23819, 23275, 22718, 22148, 21566, 20967, 20354, 19730, 19093, 18446, 17786, 17115, 16431, 15745, 15045, 14335, 13620, 12895, 12166, 11436, 10694, 9949, 9200, 8444, 7688, 6928, 6160, 5389, 4617, 3839, 3061, 2278, 1491, 702, -90, -882, -1674, -2468, -3264, -4058, -4849, -5634, -6418, -7199, -7975, -8743, -9502, -10256, -11002, -11743, -12476, -13199, -13910, -14617, -15313, -16001, -16680, -17346, -18004, -18651, -19288, -19914, -20528, -21125, -21716, -22292, -22857, -23409, -23948, -24476, -24992, -25494, -25984, -26460, -26926, -27379, -27819, -28244, -28655, -29049, -29428, -29790, -30132, -30457, -30759, -31041, -31302, -31542, -31757, -31950, -32121, -32272, -32401, -32511, -32600, -32668, -32720, -32752, -32767, -32765, -32747, -32712, -32659, -32590, -32502, -32396, -32273, -32130, -31969, -31787, -31584, -31361, -31119, -30852, -30566, -30258, -29932, -29584, -29216, -28829, -28421, -27998, -27554, -27089, -26607, -26105, -25586, -25056, -24509, -23951, -23379, -22793, -22197, -21587, -20955, -20305, -19635, -18942, -18232, -17499, -16735, -15947, -15130, -14291, -13440, -12567, -11691, -10823, -9969, -9143, -8353, -7607, -6910, -6272, -5694, -5184, -4734, -4346, -3988, -3631, -3378, -3353, -3629, -3766, -3058, -988};