/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0005 256 samples */
 
const int16_t AKWF_theremin_0005_256_DATA [256] = 
{254, 496, 575, 524, 384, 264, 250, 437, 933, 1680, 2542, 3468, 4431, 5387, 6273, 7045, 7680, 8164, 8508, 8729, 8838, 8848, 8767, 8621, 8420, 8168, 7868, 7519, 7116, 6670, 6196, 5703, 5202, 4702, 4203, 3710, 3230, 2768, 2337, 1945, 1604, 1320, 1106, 967, 903, 916, 1001, 1147, 1349, 1594, 1879, 2194, 2539, 2914, 3319, 3759, 4239, 4756, 5315, 5917, 6557, 7245, 7970, 8732, 9529, 10350, 11196, 12069, 12956, 13861, 14771, 15695, 16627, 17565, 18504, 19440, 20374, 21303, 22227, 23143, 24044, 24925, 25785, 26612, 27402, 28143, 28830, 29461, 30037, 30555, 31018, 31424, 31772, 32070, 32315, 32509, 32648, 32734, 32767, 32749, 32688, 32590, 32461, 32305, 32126, 31929, 31714, 31476, 31213, 30921, 30588, 30212, 29788, 29310, 28783, 28206, 27581, 26913, 26206, 25460, 24689, 23885, 23052, 22194, 21318, 20412, 19486, 18544, 17585, 16620, 15651, 14667, 13684, 12696, 11704, 10720, 9730, 8737, 7747, 6759, 5771, 4793, 3812, 2837, 1872, 909, -36, -972, -1904, -2821, -3725, -4621, -5497, -6369, -7233, -8088, -8938, -9781, -10616, -11446, -12267, -13081, -13891, -14694, -15499, -16305, -17114, -17923, -18733, -19539, -20339, -21119, -21875, -22589, -23271, -23907, -24492, -25035, -25531, -25987, -26407, -26794, -27149, -27478, -27779, -28058, -28313, -28539, -28738, -28905, -29043, -29148, -29220, -29257, -29261, -29232, -29178, -29106, -29020, -28930, -28843, -28763, -28692, -28634, -28583, -28537, -28492, -28445, -28390, -28322, -28241, -28143, -28026, -27897, -27754, -27601, -27443, -27280, -27113, -26947, -26780, -26610, -26432, -26243, -26030, -25792, -25517, -25202, -24842, -24437, -23987, -23494, -22956, -22370, -21733, -21045, -20307, -19524, -18706, -17843, -16944, -15997, -14998, -13951, -12853, -11689, -10457, -9154, -7798, -6427, -5068, -3781, -2610, -1595, -765, -146};