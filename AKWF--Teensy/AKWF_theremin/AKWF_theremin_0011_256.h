/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0011 256 samples */
 
const int16_t AKWF_theremin_0011_256_DATA [256] = 
{3025, 10215, 13726, 14329, 14417, 14970, 15669, 16354, 17105, 17877, 18603, 19276, 19868, 20366, 20805, 21214, 21604, 22001, 22422, 22850, 23268, 23670, 24037, 24363, 24651, 24915, 25160, 25391, 25617, 25843, 26058, 26264, 26459, 26642, 26813, 26973, 27119, 27253, 27372, 27472, 27561, 27640, 27711, 27779, 27848, 27914, 27968, 28010, 28030, 28024, 27995, 27948, 27888, 27817, 27740, 27659, 27578, 27498, 27423, 27356, 27300, 27256, 27224, 27206, 27203, 27216, 27242, 27281, 27329, 27390, 27461, 27536, 27608, 27676, 27727, 27755, 27758, 27748, 27729, 27708, 27692, 27687, 27685, 27681, 27676, 27667, 27652, 27633, 27612, 27586, 27558, 27526, 27491, 27456, 27421, 27392, 27373, 27359, 27344, 27324, 27288, 27225, 27138, 27043, 26951, 26874, 26839, 26850, 26883, 26919, 26939, 26869, 26682, 26439, 26219, 26046, 26074, 26414, 26911, 27269, 27331, 26875, 25623, 23589, 21020, 18107, 14904, 11552, 8154, 4841, 1699, -1153, -3485, -5190, -6433, -7407, -8207, -9042, -10061, -11225, -12398, -13536, -14598, -15526, -16322, -17060, -17768, -18465, -19202, -19977, -20756, -21517, -22242, -22897, -23484, -24014, -24510, -24987, -25457, -25938, -26421, -26887, -27332, -27745, -28117, -28451, -28761, -29053, -29332, -29614, -29895, -30165, -30418, -30648, -30852, -31025, -31171, -31297, -31403, -31491, -31564, -31625, -31675, -31717, -31753, -31784, -31813, -31844, -31877, -31917, -31968, -32029, -32093, -32156, -32214, -32258, -32286, -32309, -32334, -32367, -32422, -32504, -32595, -32680, -32745, -32768, -32736, -32662, -32574, -32482, -32408, -32376, -32376, -32380, -32376, -32343, -32256, -32119, -31954, -31783, -31617, -31485, -31396, -31318, -31231, -31121, -30956, -30724, -30445, -30142, -29830, -29540, -29292, -29069, -28838, -28579, -28256, -27833, -27316, -26767, -26203, -25659, -25189, -24788, -24380, -23888, -23293, -22595, -21760, -20708, -19327, -17531, -15421, -13227, -10195, -4572};