/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0013 256 samples */
 
const int16_t AKWF_theremin_0013_256_DATA [256] = 
{2925, 9615, 16472, 21678, 24663, 26423, 27829, 28876, 29719, 30466, 31108, 31627, 32051, 32382, 32586, 32696, 32756, 32764, 32713, 32609, 32442, 32202, 31894, 31549, 31317, 31212, 31096, 30930, 30708, 30476, 30263, 30010, 29723, 29456, 29194, 28927, 28696, 28497, 28275, 28034, 27799, 27538, 27246, 26989, 26779, 26572, 26331, 26037, 25754, 25521, 25337, 25172, 24987, 24785, 24575, 24352, 24123, 23909, 23712, 23532, 23363, 23194, 23023, 22848, 22663, 22491, 22340, 22146, 21926, 21786, 21667, 21481, 21306, 21174, 21028, 20876, 20766, 20641, 20460, 20307, 20195, 20062, 19909, 19756, 19644, 19580, 19472, 19315, 19159, 19041, 18976, 18885, 18749, 18643, 18544, 18407, 18278, 18180, 18079, 17973, 17881, 17815, 17767, 17654, 17462, 17273, 17158, 17173, 17267, 17374, 17450, 17480, 17486, 17481, 17469, 17465, 17472, 17451, 17440, 17502, 17519, 17418, 17336, 17313, 17195, 17115, 16902, 14355, 8712, 1570, -4967, -8881, -11188, -13323, -15210, -16912, -18521, -20029, -21390, -22629, -23770, -24831, -25824, -26715, -27492, -28166, -28758, -29293, -29810, -30235, -30489, -30709, -30993, -31331, -31667, -31914, -32075, -32184, -32275, -32363, -32428, -32470, -32491, -32473, -32418, -32370, -32319, -32208, -32053, -31888, -31739, -31611, -31463, -31292, -31116, -30931, -30734, -30548, -30362, -30145, -29922, -29726, -29535, -29334, -29124, -28922, -28750, -28570, -28356, -28140, -27944, -27779, -27604, -27370, -27128, -26914, -26735, -26563, -26343, -26116, -25918, -25738, -25566, -25404, -25220, -24987, -24786, -24655, -24518, -24347, -24150, -23958, -23796, -23598, -23372, -23193, -23028, -22821, -22625, -22466, -22285, -22077, -21876, -21657, -21392, -21109, -20827, -20549, -20265, -19956, -19641, -19320, -18935, -18493, -18034, -17618, -17277, -16961, -16614, -16179, -15658, -15087, -14496, -13892, -13226, -12481, -11692, -10864, -9997, -9077, -8090, -6996, -5899, -4983, -3393, -889};