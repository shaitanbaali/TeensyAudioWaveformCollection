/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0007 256 samples */
 
const int16_t AKWF_theremin_0007_256_DATA [256] = 
{145, 432, 522, 461, 295, 208, 367, 887, 1716, 2699, 3789, 4930, 6047, 7087, 8029, 8891, 9682, 10418, 11112, 11779, 12427, 13061, 13664, 14232, 14762, 15246, 15688, 16083, 16435, 16743, 17016, 17255, 17470, 17665, 17841, 18003, 18152, 18296, 18439, 18586, 18741, 18905, 19079, 19270, 19488, 19737, 20030, 20365, 20742, 21162, 21614, 22092, 22592, 23100, 23617, 24136, 24651, 25144, 25606, 26018, 26371, 26662, 26884, 27028, 27074, 27004, 26802, 26453, 25958, 25317, 24544, 23659, 22677, 21620, 20507, 19328, 18097, 16829, 15532, 14232, 12940, 11655, 10393, 9166, 7978, 6856, 5798, 4817, 3923, 3121, 2414, 1799, 1274, 840, 495, 241, 77, 5, 23, 131, 328, 611, 979, 1426, 1943, 2521, 3149, 3816, 4519, 5249, 6003, 6770, 7548, 8335, 9123, 9906, 10682, 11433, 12151, 12816, 13409, 13919, 14339, 14672, 14928, 15120, 15260, 15362, 15431, 15471, 15472, 15429, 15339, 15192, 14987, 14721, 14398, 14017, 13577, 13077, 12512, 11884, 11189, 10433, 9624, 8769, 7874, 6954, 6011, 5047, 4077, 3085, 2083, 1078, 67, -943, -1947, -2959, -3960, -4952, -5927, -6892, -7835, -8761, -9671, -10568, -11469, -12380, -13308, -14253, -15211, -16172, -17141, -18099, -19047, -19975, -20876, -21758, -22621, -23454, -24261, -25037, -25775, -26485, -27160, -27794, -28385, -28928, -29416, -29855, -30238, -30573, -30868, -31130, -31369, -31592, -31798, -31988, -32159, -32310, -32441, -32552, -32640, -32705, -32747, -32766, -32759, -32723, -32660, -32567, -32447, -32294, -32101, -31853, -31547, -31167, -30711, -30182, -29590, -28953, -28290, -27609, -26931, -26257, -25584, -24914, -24234, -23542, -22837, -22112, -21372, -20626, -19864, -19093, -18317, -17534, -16751, -15963, -15167, -14366, -13563, -12752, -11942, -11134, -10334, -9536, -8724, -7882, -7001, -6059, -5048, -3990, -2926, -1926, -1044, -331};