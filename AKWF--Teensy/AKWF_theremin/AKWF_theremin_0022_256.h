/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0022 256 samples */
 
const int16_t AKWF_theremin_0022_256_DATA [256] = 
{983, 3395, 6257, 9626, 13394, 17077, 20414, 23209, 25365, 26932, 27949, 28593, 28904, 28970, 28896, 28670, 28430, 28157, 27776, 27327, 26837, 26361, 25833, 25377, 24910, 24425, 23960, 23510, 23076, 22684, 22304, 21953, 21566, 21198, 20847, 20545, 20271, 20002, 19749, 19474, 19216, 18941, 18703, 18500, 18307, 18095, 17889, 17648, 17451, 17301, 17118, 16948, 16782, 16608, 16476, 16415, 16304, 16226, 16108, 15981, 15884, 15816, 15759, 15699, 15636, 15581, 15517, 15487, 15493, 15481, 15503, 15553, 15556, 15575, 15619, 15633, 15639, 15681, 15702, 15711, 15734, 15761, 15771, 15727, 15691, 15660, 15595, 15550, 15464, 15395, 15316, 15208, 15119, 15032, 14921, 14814, 14717, 14618, 14511, 14423, 14341, 14246, 14186, 14092, 13989, 13884, 13820, 13736, 13660, 13574, 13487, 13416, 13321, 13245, 13164, 13096, 13041, 12949, 12867, 12789, 12711, 12631, 12549, 12500, 12422, 12330, 12256, 12176, 12131, 12220, 12467, 12417, 11360, 7859, -1264, -14217, -23656, -28561, -30932, -32077, -32516, -32699, -32766, -32650, -32445, -32184, -31870, -31522, -31155, -30772, -30368, -29977, -29571, -29145, -28726, -28296, -27899, -27457, -27057, -26671, -26281, -25902, -25529, -25170, -24817, -24506, -24167, -23867, -23578, -23275, -23008, -22740, -22501, -22264, -22026, -21803, -21614, -21402, -21219, -21025, -20854, -20668, -20521, -20353, -20204, -20056, -19892, -19780, -19646, -19511, -19374, -19235, -19126, -19015, -18910, -18804, -18694, -18608, -18501, -18366, -18249, -18163, -18065, -17987, -17878, -17764, -17664, -17575, -17474, -17371, -17252, -17160, -17043, -16931, -16818, -16691, -16570, -16470, -16329, -16188, -16026, -15889, -15727, -15556, -15373, -15172, -14965, -14739, -14485, -14212, -13923, -13616, -13300, -12944, -12565, -12170, -11730, -11271, -10829, -10322, -9806, -9238, -8688, -8149, -7597, -7025, -6466, -5897, -5346, -4817, -4277, -3798, -3345, -2783, -1858, -508};