/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0010 256 samples */
 
const int16_t AKWF_theremin_0010_256_DATA [256] = 
{222, 587, 943, 1278, 1599, 1889, 2157, 2444, 2703, 2945, 3162, 3338, 3500, 3635, 3770, 3890, 3973, 4028, 4087, 4115, 4137, 4174, 4199, 4211, 4235, 4238, 4238, 4255, 4283, 4318, 4342, 4357, 4337, 4305, 4267, 4234, 4233, 4231, 4214, 4157, 4090, 3996, 3942, 3877, 3809, 3765, 3697, 3604, 3517, 3441, 3401, 3408, 3409, 3406, 3411, 3397, 3419, 3513, 3607, 3736, 3866, 3999, 4163, 4324, 4577, 4895, 5240, 5619, 6019, 6494, 7057, 7755, 8534, 9433, 10419, 11540, 12714, 14006, 15537, 17258, 19108, 21066, 23093, 25059, 26909, 28666, 30186, 31301, 32058, 32515, 32735, 32751, 32614, 32369, 32030, 31615, 31141, 30639, 30142, 29662, 29148, 28687, 28221, 27786, 27367, 26974, 26594, 26235, 25880, 25572, 25257, 24950, 24651, 24387, 24096, 23641, 22635, 20566, 16479, 9520, 1210, -6009, -11078, -14027, -15618, -16544, -17109, -17502, -17782, -18020, -18182, -18283, -18336, -18356, -18358, -18332, -18297, -18251, -18171, -18087, -17975, -17852, -17721, -17558, -17396, -17215, -17019, -16804, -16579, -16375, -16147, -15893, -15666, -15432, -15174, -14955, -14736, -14494, -14275, -14068, -13871, -13669, -13480, -13293, -13138, -12963, -12810, -12642, -12494, -12351, -12204, -12083, -11970, -11856, -11747, -11631, -11522, -11448, -11347, -11254, -11165, -11095, -11020, -10930, -10859, -10785, -10722, -10657, -10594, -10530, -10487, -10400, -10366, -10309, -10255, -10175, -10139, -10098, -10054, -9979, -9928, -9883, -9837, -9782, -9732, -9684, -9649, -9600, -9554, -9498, -9438, -9399, -9344, -9288, -9246, -9179, -9126, -9072, -9008, -8957, -8886, -8788, -8710, -8629, -8538, -8449, -8339, -8243, -8120, -7980, -7838, -7697, -7542, -7370, -7183, -6975, -6751, -6516, -6272, -6017, -5714, -5416, -5100, -4772, -4413, -4075, -3668, -3315, -2933, -2521, -2118, -1694, -1310, -916, -526, -138};