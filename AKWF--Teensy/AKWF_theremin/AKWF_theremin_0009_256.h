/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0009 256 samples */
 
const int16_t AKWF_theremin_0009_256_DATA [256] = 
{1486, 6027, 12945, 19575, 24170, 26785, 28483, 29657, 30595, 31395, 31929, 32277, 32523, 32693, 32769, 32733, 32618, 32463, 32180, 31839, 31539, 31302, 31116, 30900, 30613, 30320, 30081, 29838, 29526, 29222, 28957, 28690, 28374, 28072, 27811, 27558, 27284, 27021, 26750, 26458, 26172, 25920, 25695, 25458, 25185, 24944, 24741, 24535, 24332, 24107, 23867, 23662, 23473, 23280, 23070, 22854, 22638, 22457, 22315, 22154, 21979, 21809, 21638, 21454, 21277, 21121, 20979, 20818, 20650, 20471, 20262, 20114, 20085, 20146, 20203, 20227, 20200, 20135, 20107, 20087, 20053, 20009, 19895, 19810, 19745, 19469, 18872, 16662, 11591, 4222, -2141, -6086, -8529, -10447, -12136, -13609, -14904, -16054, -17078, -17956, -18651, -19255, -19751, -20125, -20429, -20552, -20617, -20808, -21068, -21259, -21353, -21420, -21462, -21459, -21418, -21372, -21291, -21211, -21136, -21002, -20849, -20706, -20570, -20422, -20247, -20067, -19891, -19674, -19470, -19285, -19077, -18877, -18697, -18513, -18302, -18083, -17891, -17730, -17565, -17369, -17173, -17011, -16848, -16679, -16511, -16346, -16171, -15975, -15778, -15621, -15463, -15328, -15223, -15086, -14946, -14815, -14692, -14591, -14448, -14283, -14166, -14038, -13909, -13792, -13672, -13560, -13452, -13337, -13206, -13098, -13006, -12911, -12831, -12732, -12638, -12589, -12541, -12467, -12372, -12276, -12180, -12080, -11981, -11883, -11775, -11724, -11742, -11700, -11624, -11546, -11466, -11388, -11340, -11308, -11239, -11159, -11105, -11063, -10986, -10930, -10895, -10828, -10703, -10644, -10655, -10632, -10552, -10494, -10450, -10358, -10308, -10260, -10187, -10146, -10100, -10030, -9963, -9939, -9881, -9809, -9778, -9729, -9656, -9562, -9464, -9412, -9361, -9287, -9219, -9137, -9024, -8891, -8762, -8655, -8533, -8367, -8200, -7985, -7713, -7432, -7178, -6982, -6849, -6739, -6596, -6332, -5977, -5653, -5275, -4804, -4264, -3671, -3057, -2411, -1608, -402};