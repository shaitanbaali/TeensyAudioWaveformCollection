/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0004 256 samples */
 
const int16_t AKWF_theremin_0004_256_DATA [256] = 
{389, 958, 1509, 2057, 2603, 3145, 3684, 4216, 4738, 5252, 5750, 6240, 6718, 7185, 7638, 8086, 8524, 8957, 9385, 9804, 10222, 10633, 11037, 11435, 11828, 12220, 12620, 13022, 13424, 13819, 14196, 14560, 14913, 15261, 15611, 15963, 16319, 16676, 17032, 17385, 17733, 18077, 18411, 18731, 19039, 19338, 19634, 19935, 20235, 20539, 20846, 21152, 21466, 21780, 22082, 22364, 22623, 22862, 23096, 23329, 23569, 23813, 24057, 24298, 24535, 24767, 24993, 25207, 25408, 25596, 25770, 25935, 26091, 26238, 26373, 26500, 26616, 26723, 26818, 26895, 26950, 26980, 26987, 26973, 26947, 26908, 26855, 26791, 26717, 26632, 26538, 26430, 26300, 26144, 25962, 25755, 25534, 25306, 25078, 24839, 24575, 24270, 23916, 23522, 23101, 22671, 22240, 21801, 21352, 20887, 20399, 19892, 19359, 18800, 18212, 17598, 16955, 16285, 15587, 14858, 14106, 13342, 12579, 11816, 11054, 10274, 9464, 8620, 7739, 6835, 5930, 5034, 4147, 3268, 2377, 1477, 562, -355, -1274, -2194, -3106, -4014, -4933, -5862, -6814, -7783, -8756, -9718, -10667, -11602, -12524, -13428, -14311, -15170, -16009, -16849, -17689, -18535, -19373, -20193, -20990, -21764, -22513, -23233, -23922, -24576, -25203, -25804, -26394, -26974, -27540, -28086, -28605, -29087, -29536, -29953, -30339, -30706, -31047, -31360, -31643, -31893, -32106, -32289, -32439, -32559, -32647, -32706, -32743, -32765, -32768, -32768, -32758, -32708, -32622, -32503, -32353, -32174, -31968, -31737, -31480, -31195, -30887, -30552, -30191, -29814, -29424, -29023, -28614, -28186, -27736, -27264, -26769, -26258, -25737, -25203, -24659, -24106, -23542, -22974, -22399, -21810, -21203, -20574, -19919, -19251, -18569, -17887, -17212, -16538, -15870, -15209, -14551, -13899, -13253, -12605, -11961, -11312, -10662, -10009, -9355, -8700, -8046, -7400, -6765, -6147, -5544, -4940, -4333, -3721, -3105, -2495, -1895, -1307, -732, -155};