/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_theremin_0016 256 samples */
 
const int16_t AKWF_theremin_0016_256_DATA [256] = 
{3074, 8967, 13580, 18076, 22546, 25671, 27465, 28522, 29205, 29850, 30395, 30793, 31113, 31381, 31621, 31837, 32021, 32188, 32339, 32478, 32603, 32703, 32762, 32768, 32744, 32703, 32681, 32688, 32691, 32663, 32575, 32437, 32272, 32101, 31934, 31774, 31624, 31489, 31371, 31266, 31179, 31108, 31034, 30940, 30794, 30604, 30407, 30236, 30123, 30052, 29996, 29940, 29872, 29799, 29724, 29647, 29565, 29471, 29354, 29215, 29073, 28949, 28874, 28827, 28774, 28671, 28495, 28292, 28107, 27992, 27936, 27888, 27756, 27474, 27160, 26945, 27074, 27394, 27418, 26746, 25023, 22389, 19060, 15068, 10641, 6223, 2351, -445, -2354, -3756, -4988, -6240, -7396, -8431, -9354, -10186, -10979, -11736, -12473, -13185, -13857, -14492, -15082, -15629, -16129, -16581, -16987, -17364, -17717, -18049, -18359, -18646, -18911, -19152, -19363, -19536, -19671, -19781, -19872, -19955, -20026, -20076, -20105, -20106, -20078, -20017, -19918, -19793, -19665, -19559, -19488, -19441, -19412, -19394, -19381, -19371, -19359, -19340, -19308, -19260, -19190, -19100, -18996, -18887, -18778, -18670, -18567, -18473, -18387, -18305, -18221, -18134, -18043, -17951, -17857, -17765, -17673, -17584, -17498, -17414, -17328, -17235, -17134, -17029, -16929, -16839, -16756, -16674, -16585, -16484, -16378, -16272, -16178, -16096, -16016, -15933, -15842, -15747, -15650, -15559, -15473, -15388, -15299, -15203, -15105, -15010, -14928, -14862, -14797, -14726, -14634, -14527, -14423, -14338, -14280, -14233, -14179, -14102, -14005, -13905, -13815, -13746, -13687, -13628, -13562, -13486, -13401, -13301, -13186, -13066, -12949, -12842, -12752, -12689, -12666, -12696, -12760, -12824, -12855, -12836, -12796, -12755, -12740, -12741, -12735, -12702, -12630, -12539, -12449, -12380, -12327, -12265, -12164, -12005, -11816, -11627, -11465, -11331, -11183, -10986, -10710, -10377, -10020, -9674, -9344, -8990, -8579, -8072, -7489, -6864, -6263, -5709, -5021, -4196, -3708, -1797};