/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0004 256 samples */
 
const int16_t AKWF_pluckalgo_0004_256_DATA [256] = 
{2864, 7718, 10550, 11747, 12020, 12124, 12531, 13268, 14065, 14627, 14934, 15309, 16130, 17377, 18522, 18901, 18352, 17287, 16301, 15648, 15162, 14531, 13600, 12520, 11785, 12191, 14379, 18400, 23464, 28138, 31166, 32086, 31372, 30067, 28955, 28244, 27627, 26766, 25678, 24791, 24609, 25345, 26698, 27933, 28341, 27652, 26323, 25130, 24581, 24544, 24378, 23419, 21330, 18394, 15366, 13242, 12731, 13844, 16013, 18415, 20506, 22174, 23440, 24266, 24515, 24048, 22835, 20907, 18415, 15815, 13875, 13282, 14199, 16022, 17902, 19363, 20460, 21424, 22182, 22354, 21789, 20825, 20038, 19737, 19743, 19746, 19663, 19734, 20238, 21213, 22337, 23138, 23217, 22513, 21347, 20218, 19523, 19275, 19155, 18844, 18350, 17975, 18031, 18594, 19525, 20695, 22049, 23527, 24974, 26153, 26854, 27038, 26884, 26751, 26877, 27125, 26960, 25896, 23960, 21696, 19718, 17975, 15599, 11466, 5174, -2639, -10448, -16735, -20805, -22746, -23206, -22865, -22073, -21008, -19818, -18706, -17940, -17748, -18156, -18875, -19350, -19076, -17922, -16317, -15057, -14780, -15651, -17254, -18921, -20092, -20515, -20355, -19984, -19793, -19930, -20193, -20184, -19661, -18833, -18215, -18304, -19198, -20602, -21962, -22746, -22829, -22557, -22544, -23171, -24314, -25463, -26085, -25977, -25322, -24471, -23547, -22294, -20365, -17815, -15146, -13036, -11946, -11954, -12869, -14250, -15596, -16635, -17464, -18449, -19883, -21823, -24143, -26655, -29090, -31088, -32350, -32740, -32259, -30980, -28936, -26241, -23322, -20860, -19472, -19439, -20465, -22009, -23543, -24708, -25265, -24933, -23529, -21292, -18959, -17588, -17835, -19470, -21505, -22860, -23155, -22769, -22358, -22349, -22888, -24051, -25808, -27921, -29851, -30949, -30858, -29696, -28074, -26718, -25956, -25589, -25131, -24262, -22898, -21092, -19076, -17265, -16178, -16082, -16846, -18118, -19588, -21167, -22880, -24580, -25857, -26105, -24656, -21111, -15575, -8636, -1765};