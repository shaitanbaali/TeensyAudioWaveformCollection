/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0007 256 samples */
 
const int16_t AKWF_pluckalgo_0007_256_DATA [256] = 
{1033, 3087, 4964, 6782, 8515, 10147, 11683, 13106, 14410, 15577, 16593, 17434, 18085, 18525, 18750, 18756, 18551, 18149, 17584, 16888, 16102, 15275, 14450, 13667, 12967, 12378, 11915, 11597, 11423, 11394, 11496, 11707, 12015, 12388, 12807, 13247, 13677, 14076, 14435, 14732, 14956, 15109, 15189, 15211, 15178, 15111, 15025, 14932, 14852, 14791, 14760, 14758, 14779, 14814, 14852, 14883, 14900, 14888, 14855, 14796, 14726, 14653, 14593, 14560, 14566, 14625, 14738, 14904, 15122, 15391, 15696, 16033, 16396, 16783, 17188, 17611, 18054, 18515, 18998, 19498, 20011, 20529, 21046, 21537, 21985, 22364, 22648, 22819, 22849, 22733, 22462, 22043, 21486, 20817, 20069, 19280, 18486, 17730, 17037, 16445, 15973, 15634, 15438, 15382, 15463, 15669, 15990, 16410, 16911, 17477, 18090, 18744, 19418, 20096, 20762, 21401, 21987, 22495, 22896, 23158, 23244, 23112, 22724, 22049, 21067, 19747, 18094, 16115, 13829, 11286, 8538, 5652, 2712, -198, -3002, -5601, -7931, -9927, -11540, -12738, -13509, -13866, -13830, -13444, -12769, -11869, -10811, -9676, -8527, -7443, -6480, -5679, -5095, -4749, -4658, -4829, -5258, -5931, -6819, -7891, -9117, -10443, -11823, -13214, -14571, -15853, -17031, -18075, -18981, -19740, -20359, -20851, -21232, -21531, -21772, -21983, -22190, -22413, -22668, -22970, -23317, -23715, -24150, -24609, -25071, -25519, -25928, -26278, -26561, -26758, -26878, -26920, -26904, -26847, -26783, -26736, -26739, -26820, -26997, -27286, -27692, -28209, -28817, -29491, -30199, -30896, -31546, -32093, -32501, -32730, -32743, -32507, -32010, -31241, -30201, -28894, -27350, -25598, -23672, -21634, -19534, -17433, -15399, -13488, -11761, -10269, -9056, -8153, -7587, -7360, -7465, -7883, -8579, -9510, -10623, -11851, -13126, -14381, -15546, -16556, -17357, -17906, -18173, -18131, -17773, -17113, -16165, -14947, -13497, -11855, -10048, -8123, -6127, -4100, -1974, -271};