/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0003 256 samples */
 
const int16_t AKWF_pluckalgo_0003_256_DATA [256] = 
{387, 1065, 2202, 3429, 4638, 5830, 7005, 8184, 9343, 10458, 11571, 12681, 13729, 14752, 15786, 16765, 17685, 18616, 19521, 20342, 21158, 21971, 22703, 23397, 24104, 24755, 25338, 25928, 26499, 26989, 27464, 27944, 28362, 28738, 29125, 29480, 29774, 30072, 30363, 30599, 30822, 31049, 31241, 31403, 31571, 31724, 31845, 31964, 32081, 32173, 32254, 32337, 32406, 32459, 32515, 32564, 32598, 32629, 32660, 32680, 32694, 32708, 32716, 32714, 32712, 32709, 32693, 32672, 32654, 32625, 32586, 32551, 32508, 32447, 32386, 32324, 32239, 32147, 32057, 31948, 31817, 31690, 31549, 31372, 31192, 31011, 30787, 30542, 30303, 30031, 29711, 29397, 29069, 28672, 28267, 27865, 27395, 26884, 26386, 25844, 25228, 24617, 23993, 23283, 22550, 21824, 21034, 20184, 19344, 18475, 17524, 16569, 15613, 14584, 13529, 12484, 11395, 10261, 9134, 7991, 6807, 5621, 4433, 3225, 2008, 790, -426, -1641, -2860, -4073, -5264, -6452, -7639, -8792, -9921, -11054, -12163, -13216, -14266, -15312, -16286, -17234, -18193, -19091, -19929, -20779, -21598, -22332, -23062, -23788, -24433, -25043, -25664, -26231, -26734, -27242, -27733, -28148, -28550, -28956, -29305, -29616, -29937, -30231, -30471, -30715, -30954, -31142, -31320, -31503, -31655, -31782, -31914, -32035, -32128, -32220, -32310, -32379, -32440, -32503, -32553, -32592, -32632, -32669, -32693, -32714, -32737, -32750, -32755, -32764, -32767, -32761, -32757, -32751, -32733, -32714, -32696, -32668, -32631, -32596, -32555, -32499, -32443, -32384, -32306, -32222, -32138, -32036, -31913, -31794, -31663, -31498, -31330, -31160, -30951, -30722, -30499, -30243, -29942, -29647, -29338, -28963, -28577, -28197, -27751, -27266, -26793, -26278, -25689, -25104, -24508, -23826, -23121, -22424, -21662, -20840, -20030, -19188, -18264, -17338, -16409, -15406, -14375, -13353, -12286, -11172, -10065, -8941, -7773, -6601, -5427, -4229, -3027, -1787, -805, -197};