/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0009 256 samples */
 
const int16_t AKWF_pluckalgo_0009_256_DATA [256] = 
{376, 1374, 2545, 3704, 4701, 5522, 6254, 6992, 7759, 8500, 9137, 9648, 10073, 10471, 10866, 11230, 11516, 11706, 11829, 11928, 12028, 12109, 12143, 12114, 12045, 11971, 11913, 11859, 11785, 11678, 11555, 11445, 11365, 11308, 11252, 11184, 11117, 11072, 11064, 11085, 11114, 11138, 11167, 11219, 11306, 11422, 11547, 11667, 11787, 11925, 12090, 12279, 12473, 12661, 12846, 13043, 13261, 13497, 13736, 13966, 14192, 14429, 14685, 14955, 15229, 15494, 15753, 16021, 16306, 16604, 16905, 17197, 17482, 17772, 18074, 18386, 18695, 18990, 19273, 19551, 19830, 20107, 20371, 20609, 20823, 21021, 21208, 21379, 21523, 21627, 21692, 21726, 21735, 21716, 21656, 21549, 21390, 21188, 20951, 20677, 20356, 19981, 19552, 19079, 18569, 18023, 17432, 16790, 16101, 15375, 14620, 13836, 13021, 12162, 11265, 10345, 9406, 8454, 7484, 6486, 5466, 4438, 3404, 2374, 1338, 288, -769, -1826, -2877, -3912, -4944, -5982, -7017, -8045, -9054, -10043, -11019, -11993, -12960, -13916, -14849, -15754, -16645, -17527, -18399, -19256, -20086, -20883, -21660, -22423, -23172, -23903, -24602, -25267, -25905, -26523, -27121, -27695, -28231, -28730, -29199, -29645, -30069, -30463, -30817, -31130, -31412, -31673, -31912, -32125, -32297, -32430, -32535, -32621, -32696, -32747, -32768, -32755, -32721, -32678, -32630, -32570, -32488, -32381, -32262, -32145, -32033, -31919, -31792, -31648, -31500, -31360, -31233, -31113, -30985, -30846, -30706, -30581, -30476, -30381, -30279, -30168, -30056, -29959, -29883, -29815, -29739, -29647, -29551, -29465, -29397, -29333, -29251, -29143, -29019, -28898, -28787, -28670, -28522, -28332, -28110, -27876, -27639, -27381, -27076, -26710, -26294, -25853, -25399, -24914, -24366, -23742, -23054, -22335, -21609, -20849, -20020, -19102, -18115, -17111, -16123, -15124, -14063, -12909, -11687, -10478, -9343, -8253, -7120, -5864, -4502, -3189, -2111, -1353, -830, -293};