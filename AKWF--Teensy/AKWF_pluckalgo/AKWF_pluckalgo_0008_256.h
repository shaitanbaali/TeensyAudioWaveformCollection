/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0008 256 samples */
 
const int16_t AKWF_pluckalgo_0008_256_DATA [256] = 
{675, 2735, 4632, 6495, 8387, 10380, 12532, 14845, 17289, 19778, 22185, 24378, 26211, 27584, 28445, 28786, 28655, 28126, 27282, 26208, 24963, 23580, 22074, 20443, 18693, 16847, 14959, 13143, 11535, 10300, 9603, 9558, 10226, 11576, 13492, 15803, 18295, 20769, 23061, 25055, 26722, 28073, 29155, 30040, 30780, 31414, 31956, 32387, 32670, 32773, 32670, 32358, 31860, 31228, 30538, 29868, 29287, 28833, 28497, 28239, 27983, 27638, 27122, 26389, 25436, 24310, 23085, 21864, 20747, 19805, 19084, 18603, 18354, 18306, 18419, 18644, 18927, 19198, 19390, 19451, 19355, 19112, 18781, 18468, 18295, 18369, 18764, 19488, 20469, 21572, 22633, 23477, 23970, 24045, 23709, 23041, 22171, 21250, 20411, 19751, 19328, 19143, 19159, 19317, 19557, 19816, 20040, 20188, 20220, 20107, 19827, 19370, 18745, 17980, 17117, 16198, 15256, 14312, 13376, 12434, 11478, 10504, 9519, 8538, 7575, 6638, 5718, 4787, 3799, 2719, 1513, 168, -1286, -2808, -4336, -5813, -7206, -8489, -9647, -10671, -11532, -12182, -12555, -12568, -12152, -11264, -9914, -8168, -6128, -3951, -1816, 99, 1625, 2630, 3027, 2786, 1939, 572, -1179, -3167, -5238, -7244, -9088, -10710, -12055, -13103, -13840, -14244, -14305, -14029, -13456, -12655, -11737, -10829, -10060, -9541, -9327, -9423, -9792, -10359, -11034, -11726, -12354, -12860, -13206, -13377, -13376, -13232, -12999, -12750, -12575, -12559, -12767, -13224, -13898, -14707, -15522, -16204, -16621, -16679, -16342, -15627, -14600, -13352, -11983, -10585, -9214, -7912, -6712, -5630, -4685, -3903, -3292, -2856, -2583, -2429, -2325, -2181, -1907, -1432, -716, 243, 1387, 2611, 3784, 4754, 5377, 5540, 5174, 4248, 2783, 859, -1438, -3996, -6684, -9407, -12058, -14543, -16815, -18818, -20504, -21854, -22830, -23383, -23487, -23102, -22206, -20815, -18975, -16751, -14253, -11605, -8899, -6254, -3761, -1347};