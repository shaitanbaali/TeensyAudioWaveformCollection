/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0005 256 samples */
 
const int16_t AKWF_pluckalgo_0005_256_DATA [256] = 
{677, 2639, 4162, 5718, 7242, 8733, 10182, 11575, 12912, 14183, 15377, 16492, 17527, 18472, 19329, 20095, 20771, 21364, 21870, 22296, 22648, 22926, 23140, 23298, 23404, 23467, 23494, 23493, 23474, 23440, 23400, 23360, 23325, 23300, 23287, 23293, 23319, 23366, 23439, 23535, 23652, 23792, 23952, 24133, 24331, 24541, 24761, 24990, 25224, 25460, 25692, 25920, 26144, 26354, 26551, 26734, 26899, 27043, 27164, 27266, 27340, 27388, 27412, 27409, 27381, 27326, 27244, 27138, 27008, 26855, 26684, 26491, 26283, 26064, 25834, 25593, 25348, 25102, 24856, 24615, 24383, 24160, 23951, 23759, 23584, 23426, 23293, 23181, 23090, 23025, 22984, 22964, 22963, 22979, 23016, 23064, 23119, 23183, 23246, 23305, 23353, 23386, 23397, 23381, 23328, 23232, 23087, 22882, 22614, 22281, 21865, 21367, 20785, 20105, 19330, 18461, 17485, 16413, 15242, 13971, 12612, 11162, 9628, 8026, 6353, 4621, 2848, 1040, -794, -2638, -4480, -6313, -8119, -9893, -11625, -13300, -14914, -16461, -17930, -19321, -20630, -21843, -22977, -24027, -24983, -25858, -26653, -27367, -28011, -28587, -29095, -29546, -29943, -30291, -30595, -30861, -31096, -31298, -31475, -31634, -31774, -31899, -32010, -32111, -32204, -32289, -32366, -32436, -32504, -32565, -32618, -32663, -32702, -32734, -32754, -32765, -32765, -32752, -32726, -32686, -32629, -32556, -32467, -32360, -32241, -32105, -31952, -31783, -31600, -31402, -31193, -30974, -30744, -30508, -30261, -30010, -29755, -29500, -29243, -28985, -28728, -28473, -28225, -27981, -27743, -27512, -27286, -27070, -26864, -26666, -26476, -26296, -26123, -25958, -25801, -25651, -25508, -25371, -25237, -25105, -24972, -24839, -24703, -24564, -24417, -24259, -24089, -23907, -23707, -23488, -23241, -22972, -22673, -22336, -21966, -21557, -21099, -20594, -20037, -19426, -18756, -18022, -17227, -16365, -15431, -14433, -13365, -12224, -11023, -9760, -8433, -7054, -5626, -4147, -2679, -756};