/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0002 256 samples */
 
const int16_t AKWF_pluckalgo_0002_256_DATA [256] = 
{370, 1408, 2607, 3775, 4938, 6093, 7238, 8367, 9480, 10577, 11651, 12703, 13736, 14737, 15719, 16670, 17591, 18485, 19347, 20178, 20977, 21747, 22482, 23187, 23860, 24500, 25111, 25688, 26232, 26749, 27235, 27695, 28125, 28530, 28909, 29261, 29589, 29893, 30176, 30438, 30680, 30906, 31111, 31301, 31473, 31630, 31773, 31903, 32021, 32128, 32225, 32313, 32389, 32457, 32516, 32569, 32614, 32654, 32688, 32713, 32735, 32751, 32761, 32766, 32766, 32761, 32752, 32735, 32716, 32691, 32659, 32619, 32574, 32523, 32463, 32396, 32321, 32237, 32142, 32034, 31917, 31787, 31647, 31492, 31319, 31133, 30929, 30709, 30469, 30208, 29929, 29626, 29302, 28950, 28575, 28176, 27748, 27294, 26808, 26295, 25754, 25179, 24575, 23938, 23269, 22568, 21835, 21073, 20274, 19450, 18590, 17699, 16782, 15831, 14858, 13857, 12831, 11782, 10710, 9617, 8505, 7380, 6237, 5082, 3919, 2745, 1570, 391, -791, -1970, -3144, -4314, -5476, -6625, -7765, -8884, -9990, -11078, -12139, -13183, -14200, -15191, -16157, -17097, -18006, -18885, -19734, -20549, -21335, -22088, -22809, -23500, -24157, -24785, -25378, -25941, -26474, -26977, -27453, -27897, -28315, -28707, -29072, -29416, -29732, -30027, -30301, -30552, -30787, -31001, -31199, -31381, -31546, -31697, -31834, -31959, -32072, -32175, -32267, -32348, -32420, -32486, -32542, -32591, -32634, -32673, -32700, -32724, -32743, -32756, -32764, -32767, -32767, -32761, -32747, -32729, -32704, -32675, -32639, -32599, -32552, -32496, -32432, -32361, -32282, -32191, -32091, -31981, -31856, -31721, -31573, -31410, -31233, -31037, -30827, -30596, -30346, -30079, -29787, -29476, -29137, -28775, -28391, -27977, -27538, -27067, -26570, -26043, -25485, -24898, -24276, -23627, -22944, -22227, -21483, -20701, -19892, -19052, -18178, -17275, -16343, -15385, -14394, -13384, -12346, -11286, -10209, -9107, -7989, -6855, -5707, -4551, -3385, -2215, -1013, -147};