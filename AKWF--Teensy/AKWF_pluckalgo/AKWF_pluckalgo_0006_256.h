/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_pluckalgo_0006 256 samples */
 
const int16_t AKWF_pluckalgo_0006_256_DATA [256] = 
{208, 883, 1711, 2579, 3380, 4090, 4764, 5468, 6229, 7015, 7770, 8474, 9148, 9828, 10540, 11265, 11968, 12635, 13276, 13915, 14570, 15229, 15866, 16472, 17052, 17626, 18210, 18792, 19354, 19884, 20386, 20879, 21376, 21871, 22347, 22792, 23208, 23613, 24016, 24412, 24789, 25137, 25456, 25761, 26060, 26351, 26624, 26868, 27085, 27286, 27479, 27661, 27824, 27959, 28067, 28158, 28239, 28309, 28360, 28381, 28377, 28355, 28323, 28279, 28214, 28122, 28002, 27864, 27715, 27554, 27374, 27167, 26934, 26680, 26415, 26135, 25838, 25514, 25165, 24798, 24420, 24028, 23618, 23182, 22720, 22239, 21747, 21242, 20723, 20180, 19613, 19030, 18436, 17829, 17208, 16567, 15904, 15227, 14541, 13846, 13141, 12418, 11675, 10923, 10163, 9394, 8617, 7826, 7021, 6211, 5396, 4579, 3759, 2926, 2084, 1241, 397, -443, -1284, -2134, -2988, -3839, -4686, -5524, -6358, -7195, -8032, -8862, -9683, -10488, -11289, -12088, -12882, -13666, -14436, -15187, -15929, -16665, -17392, -18107, -18803, -19476, -20137, -20788, -21429, -22056, -22662, -23242, -23807, -24361, -24902, -25427, -25929, -26404, -26864, -27310, -27746, -28166, -28560, -28928, -29275, -29610, -29935, -30246, -30533, -30794, -31035, -31262, -31480, -31684, -31866, -32024, -32163, -32291, -32409, -32512, -32594, -32653, -32696, -32730, -32755, -32767, -32759, -32727, -32680, -32625, -32565, -32494, -32402, -32286, -32153, -32012, -31870, -31719, -31548, -31355, -31144, -30927, -30708, -30482, -30236, -29965, -29677, -29383, -29088, -28786, -28465, -28120, -27759, -27391, -27023, -26648, -26252, -25828, -25388, -24943, -24502, -24058, -23592, -23098, -22584, -22064, -21551, -21037, -20503, -19937, -19348, -18755, -18176, -17598, -17000, -16372, -15717, -15061, -14423, -13791, -13138, -12450, -11732, -11018, -10334, -9666, -8980, -8246, -7472, -6707, -5996, -5325, -4636, -3864, -3006, -2154, -1434, -919, -571, -225};