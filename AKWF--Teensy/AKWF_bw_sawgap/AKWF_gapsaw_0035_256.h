/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0035 256 samples */
 
const int16_t AKWF_gapsaw_0035_256_DATA [256] = 
{32538, 31978, 31429, 30878, 30327, 29776, 29225, 28675, 28122, 27570, 27020, 26468, 25917, 25367, 24816, 24264, 23713, 23161, 22609, 22059, 21507, 20956, 20406, 19854, 19303, 18752, 18199, 17648, 17098, 16546, 15995, 15444, 14892, 14343, 13790, 13239, 12688, 12137, 11585, 11034, 10484, 9932, 9381, 8829, 8278, 7727, 7175, 6624, 6074, 5522, 4971, 4420, 3868, 3316, 2766, 2215, 1663, 1116, 553, 53, -10, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -2, 2, -259, -643, -1007, -1374, -1741, -2109, -2477, -2843, -3211, -3579, -3945, -4313, -4682, -5049, -5416, -5784, -6151, -6519, -6886, -7253, -7621, -7988, -8355, -8723, -9090, -9459, -9827, -10194, -10561, -10929, -11295, -11663, -12031, -12398, -12765, -13133, -13500, -13868, -14236, -14604, -14970, -15339, -15705, -16073, -16441, -16807, -17175, -17543, -17910, -18278, -18645, -19013, -19381, -19748, -20115, -20483, -20850, -21218, -21585, -21952, -22319, -22687, -23054, -23422, -23791, -24158, -24525, -24893, -25260, -25627, -25995, -26362, -26729, -27098, -27464, -27832, -28200, -28567, -28935, -29302, -29670, -30038, -30404, -30772, -31140, -31507, -31841, -32157, -33188, -5349};