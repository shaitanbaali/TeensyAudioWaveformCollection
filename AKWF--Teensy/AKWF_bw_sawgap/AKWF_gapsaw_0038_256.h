/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0038 256 samples */
 
const int16_t AKWF_gapsaw_0038_256_DATA [256] = 
{32673, 32372, 32076, 31780, 31483, 31187, 30891, 30595, 30298, 30001, 29706, 29410, 29113, 28816, 28520, 28223, 27927, 27631, 27334, 27037, 26741, 26445, 26149, 25852, 25555, 25260, 24963, 24667, 24370, 24073, 23778, 23481, 23184, 22888, 22591, 22294, 21999, 21703, 21406, 21109, 20813, 20517, 20221, 19923, 19627, 19332, 19035, 18738, 18442, 18144, 17848, 17552, 17256, 16959, 16663, 16367, 16070, 15775, 15477, 15181, 14885, 14589, 14293, 13996, 13698, 13402, 13106, 12809, 12514, 12216, 11920, 11624, 11328, 11031, 10735, 10439, 10142, 9846, 9549, 9252, 8956, 8659, 8363, 8068, 7770, 7474, 7178, 6882, 6585, 6288, 5992, 5696, 5400, 5103, 4806, 4509, 4213, 3917, 3621, 3324, 3027, 2732, 2435, 2139, 1842, 1546, 1250, 954, 657, 360, 65, -11, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, -9, -224, -499, -763, -1028, -1294, -1560, -1826, -2091, -2357, -2623, -2889, -3155, -3419, -3686, -3953, -4218, -4483, -4749, -5015, -5282, -5546, -5812, -6078, -6344, -6610, -6875, -7141, -7407, -7673, -7938, -8204, -8470, -8736, -9001, -9267, -9533, -9799, -10065, -10330, -10596, -10862, -11127, -11393, -11658, -11924, -12190, -12456, -12721, -12987, -13253, -13519, -13784, -14050, -14316, -14582, -14848, -15113, -15379, -15645, -15911, -16176, -16442, -16708, -16974, -17239, -17505, -17771, -18037, -18302, -18568, -18834, -19100, -19366, -19630, -19897, -20163, -20429, -20694, -20960, -21226, -21492, -21758, -22022, -22287, -22554, -22820, -23086, -23351, -23616, -23883, -24149, -24414, -24680, -24946, -25212, -25478, -25742, -26008, -26275, -26541, -26806, -27072, -27337, -27604, -27869, -28134, -28401, -28667, -28932, -29198, -29464, -29730, -29996, -30261, -30527, -30793, -31059, -31323, -31590, -31856, -32089, -32304, -33228, -5345};