/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0007 256 samples */
 
const int16_t AKWF_gapsaw_0007_256_DATA [256] = 
{32680, 32353, 32033, 31711, 31391, 31070, 30748, 30427, 30105, 29784, 29463, 29141, 28820, 28499, 28177, 27855, 27535, 27213, 26892, 26571, 26249, 25928, 25607, 25285, 24964, 24643, 24321, 24000, 23679, 23357, 23036, 22715, 22393, 22072, 21751, 21429, 21107, 20786, 20464, 20143, 19822, 19500, 19179, 18857, 18535, 18215, 17893, 17572, 17251, 16930, 16608, 16287, 15965, 15644, 15323, 15001, 14680, 14359, 14037, 13716, 13395, 13073, 12752, 12431, 12110, 11788, 11467, 11145, 10824, 10503, 10181, 9861, 9539, 9217, 8896, 8575, 8253, 7932, 7611, 7289, 6968, 6647, 6324, 6004, 5682, 5361, 5039, 4718, 4397, 4076, 3753, 3432, 3111, 2790, 2468, 2147, 1825, 1504, 1183, 861, 544, 207, -7, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -4, 11, -160, -498, -816, -1136, -1458, -1779, -2100, -2422, -2744, -3064, -3387, -3707, -4029, -4351, -4672, -4993, -5315, -5636, -5957, -6278, -6600, -6921, -7243, -7564, -7886, -8207, -8528, -8850, -9171, -9492, -9814, -10135, -10456, -10778, -11099, -11420, -11742, -12063, -12384, -12706, -13027, -13348, -13670, -13990, -14312, -14634, -14954, -15276, -15598, -15918, -16240, -16562, -16883, -17204, -17526, -17846, -18168, -18489, -18810, -19132, -19454, -19774, -20096, -20418, -20739, -21061, -21382, -21703, -22025, -22346, -22668, -22989, -23310, -23631, -23954, -24274, -24595, -24917, -25238, -25560, -25882, -26202, -26524, -26845, -27166, -27487, -27809, -28130, -28452, -28773, -29094, -29416, -29737, -30058, -30380, -30702, -31022, -31344, -31665, -31953, -32224, -33206, -5347};