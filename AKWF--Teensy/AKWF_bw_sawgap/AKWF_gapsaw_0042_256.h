/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0042 256 samples */
 
const int16_t AKWF_gapsaw_0042_256_DATA [256] = 
{32692, 32412, 32138, 31863, 31588, 31312, 31037, 30762, 30487, 30211, 29936, 29661, 29386, 29111, 28836, 28560, 28285, 28009, 27734, 27459, 27183, 26908, 26633, 26358, 26082, 25807, 25531, 25256, 24982, 24706, 24431, 24156, 23881, 23605, 23329, 23053, 22779, 22504, 22228, 21953, 21678, 21402, 21128, 20852, 20576, 20302, 20026, 19751, 19476, 19201, 18925, 18649, 18374, 18098, 17824, 17548, 17273, 16998, 16723, 16447, 16172, 15897, 15622, 15347, 15071, 14796, 14521, 14245, 13970, 13694, 13419, 13144, 12869, 12593, 12318, 12043, 11767, 11493, 11217, 10942, 10667, 10392, 10116, 9842, 9566, 9290, 9015, 8739, 8464, 8189, 7914, 7638, 7363, 7087, 6813, 6538, 6262, 5987, 5712, 5437, 5161, 4886, 4610, 4334, 4060, 3784, 3509, 3234, 2958, 2684, 2409, 2133, 1858, 1582, 1307, 1032, 757, 484, 197, -2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -10, 31, -426, -1329, -2175, -3030, -3888, -4745, -5600, -6458, -7313, -8168, -9026, -9882, -10738, -11596, -12451, -13307, -14165, -15021, -15877, -16735, -17589, -18446, -19304, -20159, -21015, -21873, -22727, -23585, -24442, -25297, -26154, -27011, -27866, -28725, -29580, -30403, -31204, -32741, -5329};