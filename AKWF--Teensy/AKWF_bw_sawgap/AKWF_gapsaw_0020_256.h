/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0020 256 samples */
 
const int16_t AKWF_gapsaw_0020_256_DATA [256] = 
{32575, 31859, 31156, 30451, 29748, 29044, 28337, 27635, 26930, 26224, 25520, 24816, 24110, 23406, 22702, 21997, 21292, 20587, 19883, 19179, 18473, 17769, 17066, 16359, 15654, 14951, 14246, 13540, 12837, 12132, 11427, 10723, 10018, 9314, 8609, 7903, 7201, 6496, 5789, 5086, 4382, 3676, 2972, 2268, 1564, 858, 156, -25, 7, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -6, 15, -89, -748, -1464, -2165, -2869, -3574, -4279, -4984, -5688, -6392, -7098, -7802, -8505, -9212, -9916, -10619, -11325, -12030, -12733, -13438, -14143, -14848, -15552, -16256, -16962, -17667, -18369, -19075, -19781, -20484, -21188, -21895, -22598, -23302, -24008, -24712, -25417, -26121, -26826, -27531, -28235, -28939, -29645, -30349, -31020, -31671, -33054, -5363};