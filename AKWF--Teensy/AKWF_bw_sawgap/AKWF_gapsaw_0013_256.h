/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0013 256 samples */
 
const int16_t AKWF_gapsaw_0013_256_DATA [256] = 
{32650, 32214, 31787, 31357, 30929, 30500, 30070, 29642, 29213, 28783, 28355, 27925, 27495, 27067, 26638, 26208, 25780, 25351, 24922, 24493, 24064, 23634, 23205, 22776, 22347, 21919, 21489, 21060, 20631, 20202, 19773, 19345, 18915, 18485, 18056, 17627, 17199, 16770, 16340, 15912, 15483, 15053, 14625, 14196, 13765, 13337, 12908, 12478, 12050, 11621, 11191, 10763, 10333, 9904, 9476, 9045, 8617, 8188, 7759, 7330, 6901, 6472, 6043, 5614, 5185, 4756, 4327, 3896, 3468, 3039, 2609, 2181, 1752, 1323, 896, 461, 57, -10, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, 4, -26, -394, -835, -1261, -1690, -2119, -2548, -2976, -3406, -3835, -4264, -4694, -5123, -5552, -5981, -6410, -6839, -7268, -7697, -8125, -8555, -8983, -9413, -9843, -10271, -10700, -11129, -11558, -11987, -12417, -12845, -13274, -13703, -14133, -14562, -14991, -15420, -15849, -16278, -16707, -17136, -17565, -17993, -18423, -18852, -19282, -19711, -20140, -20568, -20998, -21427, -21855, -22285, -22713, -23142, -23572, -24001, -24430, -24860, -25288, -25717, -26146, -26575, -27004, -27433, -27861, -28292, -28721, -29150, -29579, -30008, -30436, -30866, -31295, -31691, -32069, -33163, -5351};