/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0011 256 samples */
 
const int16_t AKWF_gapsaw_0011_256_DATA [256] = 
{32662, 32269, 31885, 31499, 31113, 30728, 30341, 29955, 29570, 29183, 28798, 28412, 28025, 27641, 27254, 26868, 26483, 26096, 25710, 25325, 24939, 24553, 24167, 23782, 23395, 23009, 22623, 22237, 21850, 21465, 21079, 20693, 20306, 19921, 19535, 19148, 18764, 18377, 17991, 17605, 17219, 16833, 16447, 16061, 15675, 15289, 14904, 14517, 14132, 13746, 13360, 12974, 12589, 12202, 11817, 11430, 11044, 10659, 10272, 9887, 9501, 9114, 8729, 8343, 7957, 7571, 7185, 6799, 6413, 6027, 5641, 5256, 4869, 4482, 4097, 3711, 3324, 2939, 2553, 2167, 1782, 1395, 1009, 629, 221, -12, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -5, 15, -167, -572, -955, -1339, -1726, -2112, -2497, -2883, -3269, -3655, -4042, -4427, -4813, -5200, -5585, -5971, -6358, -6743, -7129, -7515, -7901, -8286, -8674, -9059, -9445, -9832, -10216, -10603, -10989, -11374, -11761, -12146, -12532, -12918, -13304, -13690, -14076, -14462, -14847, -15233, -15620, -16005, -16391, -16778, -17162, -17549, -17935, -18320, -18707, -19093, -19478, -19865, -20250, -20636, -21023, -21409, -21794, -22181, -22566, -22952, -23339, -23725, -24110, -24497, -24882, -25268, -25655, -26040, -26426, -26812, -27197, -27584, -27970, -28355, -28742, -29127, -29513, -29899, -30285, -30671, -31056, -31443, -31796, -32130, -33181, -5350};