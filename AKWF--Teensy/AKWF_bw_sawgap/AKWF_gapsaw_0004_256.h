/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0004 256 samples */
 
const int16_t AKWF_gapsaw_0004_256_DATA [256] = 
{32689, 32399, 32115, 31829, 31545, 31258, 30973, 30688, 30402, 30116, 29831, 29545, 29260, 28974, 28689, 28403, 28118, 27832, 27546, 27261, 26976, 26690, 26405, 26119, 25833, 25549, 25263, 24977, 24691, 24406, 24121, 23835, 23549, 23264, 22979, 22693, 22407, 22122, 21836, 21551, 21265, 20979, 20695, 20409, 20123, 19838, 19552, 19267, 18982, 18696, 18410, 18125, 17839, 17554, 17269, 16983, 16697, 16412, 16126, 15841, 15555, 15270, 14984, 14699, 14413, 14128, 13842, 13556, 13271, 12986, 12700, 12415, 12129, 11843, 11559, 11273, 10987, 10702, 10416, 10131, 9845, 9560, 9273, 8989, 8703, 8417, 8132, 7845, 7561, 7275, 6990, 6704, 6420, 6133, 5848, 5562, 5277, 4992, 4706, 4420, 4134, 3850, 3563, 3278, 2992, 2706, 2422, 2136, 1850, 1565, 1279, 993, 709, 425, 127, -12, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -4, 11, -91, -383, -668, -953, -1238, -1524, -1809, -2095, -2381, -2666, -2951, -3237, -3523, -3808, -4093, -4379, -4665, -4951, -5236, -5521, -5807, -6092, -6378, -6664, -6949, -7234, -7520, -7804, -8091, -8376, -8662, -8947, -9233, -9518, -9804, -10090, -10375, -10660, -10946, -11231, -11517, -11803, -12087, -12373, -12659, -12945, -13230, -13515, -13801, -14087, -14372, -14657, -14943, -15228, -15514, -15799, -16085, -16370, -16656, -16941, -17227, -17513, -17798, -18084, -18369, -18654, -18940, -19226, -19510, -19796, -20082, -20367, -20653, -20938, -21224, -21509, -21795, -22080, -22366, -22651, -22937, -23223, -23508, -23793, -24079, -24364, -24649, -24936, -25221, -25507, -25792, -26077, -26363, -26648, -26934, -27219, -27505, -27790, -28076, -28362, -28647, -28932, -29218, -29503, -29789, -30075, -30360, -30646, -30931, -31216, -31503, -31787, -32040, -32275, -33220, -5346};