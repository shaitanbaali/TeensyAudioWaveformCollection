/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0001 256 samples */
 
const int16_t AKWF_gapsaw_0001_256_DATA [256] = 
{32698, 32437, 32181, 31924, 31667, 31411, 31153, 30897, 30640, 30382, 30127, 29869, 29612, 29356, 29099, 28841, 28586, 28328, 28071, 27814, 27558, 27300, 27044, 26787, 26530, 26274, 26017, 25760, 25503, 25246, 24989, 24733, 24476, 24219, 23962, 23705, 23448, 23191, 22934, 22677, 22420, 22163, 21907, 21649, 21393, 21136, 20879, 20622, 20365, 20108, 19851, 19594, 19337, 19080, 18824, 18566, 18310, 18053, 17796, 17539, 17283, 17025, 16769, 16512, 16255, 15998, 15741, 15484, 15228, 14971, 14713, 14457, 14200, 13943, 13687, 13430, 13173, 12916, 12659, 12402, 12146, 11888, 11631, 11376, 11118, 10861, 10605, 10347, 10090, 9834, 9577, 9319, 9064, 8806, 8549, 8293, 8036, 7779, 7522, 7265, 7008, 6751, 6494, 6237, 5980, 5724, 5467, 5209, 4952, 4696, 4439, 4181, 3925, 3668, 3410, 3155, 2897, 2640, 2384, 2127, 1870, 1614, 1356, 1100, 843, 584, 337, 27, -301, -547, -806, -1063, -1319, -1577, -1833, -2090, -2347, -2604, -2860, -3118, -3374, -3631, -3888, -4145, -4401, -4659, -4916, -5172, -5430, -5687, -5943, -6200, -6458, -6714, -6971, -7228, -7485, -7742, -7999, -8255, -8513, -8769, -9026, -9283, -9540, -9797, -10054, -10310, -10567, -10824, -11081, -11338, -11595, -11851, -12108, -12366, -12621, -12879, -13136, -13392, -13649, -13907, -14163, -14420, -14677, -14933, -15191, -15447, -15703, -15961, -16218, -16474, -16732, -16988, -17245, -17502, -17759, -18015, -18273, -18529, -18786, -19043, -19300, -19557, -19814, -20071, -20328, -20585, -20841, -21099, -21356, -21612, -21869, -22126, -22382, -22640, -22897, -23153, -23411, -23668, -23924, -24181, -24438, -24695, -24952, -25209, -25465, -25723, -25979, -26236, -26493, -26750, -27006, -27263, -27520, -27777, -28034, -28291, -28548, -28804, -29061, -29318, -29575, -29831, -30089, -30345, -30602, -30859, -31116, -31373, -31630, -31886, -32110, -32318, -33232, -5344};