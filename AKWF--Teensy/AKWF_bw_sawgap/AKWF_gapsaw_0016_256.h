/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0016 256 samples */
 
const int16_t AKWF_gapsaw_0016_256_DATA [256] = 
{32627, 32103, 31589, 31073, 30559, 30043, 29527, 29013, 28497, 27981, 27466, 26950, 26435, 25920, 25404, 24889, 24374, 23858, 23342, 22827, 22311, 21795, 21281, 20764, 20249, 19734, 19217, 18702, 18188, 17671, 17156, 16641, 16125, 15610, 15095, 14579, 14064, 13549, 13032, 12518, 12003, 11486, 10972, 10456, 9940, 9426, 8910, 8394, 7879, 7363, 6847, 6333, 5817, 5301, 4786, 4270, 3754, 3239, 2723, 2208, 1693, 1178, 664, 140, -20, 5, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -5, 14, -86, -585, -1104, -1618, -2134, -2648, -3164, -3680, -4195, -4711, -5227, -5742, -6258, -6774, -7288, -7804, -8320, -8834, -9350, -9866, -10380, -10896, -11412, -11927, -12443, -12958, -13473, -13989, -14504, -15019, -15535, -16051, -16565, -17081, -17596, -18112, -18628, -19142, -19658, -20174, -20689, -21205, -21721, -22236, -22752, -23268, -23782, -24299, -24814, -25328, -25844, -26361, -26875, -27390, -27906, -28421, -28937, -29452, -29967, -30483, -30998, -31481, -31944, -33129, -5355};