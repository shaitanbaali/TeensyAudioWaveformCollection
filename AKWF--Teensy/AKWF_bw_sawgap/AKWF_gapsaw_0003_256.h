/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0003 256 samples */
 
const int16_t AKWF_gapsaw_0003_256_DATA [256] = 
{32692, 32412, 32138, 31863, 31588, 31312, 31037, 30762, 30487, 30211, 29936, 29661, 29386, 29111, 28836, 28560, 28285, 28009, 27734, 27459, 27183, 26908, 26633, 26358, 26082, 25807, 25531, 25256, 24982, 24706, 24431, 24156, 23881, 23605, 23329, 23053, 22779, 22504, 22228, 21953, 21678, 21402, 21128, 20852, 20576, 20302, 20026, 19751, 19476, 19201, 18925, 18649, 18374, 18098, 17824, 17548, 17273, 16998, 16723, 16447, 16172, 15897, 15622, 15347, 15071, 14796, 14521, 14245, 13970, 13694, 13419, 13144, 12869, 12593, 12318, 12043, 11767, 11493, 11217, 10942, 10667, 10392, 10116, 9842, 9566, 9290, 9015, 8739, 8464, 8189, 7914, 7638, 7363, 7087, 6813, 6538, 6262, 5987, 5712, 5437, 5161, 4886, 4610, 4334, 4060, 3784, 3509, 3234, 2958, 2684, 2409, 2133, 1858, 1582, 1307, 1032, 757, 484, 197, -2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -3, 8, -155, -446, -717, -993, -1268, -1542, -1818, -2094, -2369, -2644, -2919, -3194, -3470, -3745, -4020, -4295, -4571, -4846, -5122, -5397, -5672, -5948, -6223, -6498, -6773, -7048, -7323, -7599, -7874, -8149, -8425, -8700, -8975, -9251, -9526, -9802, -10077, -10352, -10627, -10903, -11177, -11453, -11728, -12003, -12278, -12553, -12829, -13104, -13380, -13654, -13930, -14206, -14481, -14757, -15031, -15307, -15582, -15857, -16132, -16408, -16683, -16958, -17234, -17508, -17783, -18059, -18334, -18609, -18886, -19160, -19436, -19711, -19986, -20261, -20537, -20812, -21087, -21363, -21638, -21913, -22189, -22463, -22739, -23014, -23288, -23565, -23841, -24115, -24391, -24666, -24941, -25217, -25491, -25767, -26042, -26317, -26593, -26868, -27143, -27418, -27694, -27968, -28245, -28520, -28795, -29071, -29346, -29621, -29896, -30172, -30446, -30722, -30997, -31272, -31547, -31823, -32065, -32290, -33224, -5345};