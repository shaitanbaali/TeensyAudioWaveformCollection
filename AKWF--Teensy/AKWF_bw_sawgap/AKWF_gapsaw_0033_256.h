/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0033 256 samples */
 
const int16_t AKWF_gapsaw_0033_256_DATA [256] = 
{31851, 30280, 28742, 27199, 25657, 24114, 22567, 21025, 19481, 17935, 16394, 14850, 13305, 11764, 10219, 8674, 7132, 5587, 4042, 2519, 892, -46, 13, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -5, 15, -167, -572, -955, -1339, -1726, -2112, -2497, -2883, -3269, -3655, -4042, -4427, -4813, -5200, -5585, -5971, -6358, -6743, -7129, -7515, -7901, -8286, -8674, -9059, -9445, -9832, -10216, -10603, -10989, -11374, -11761, -12146, -12532, -12918, -13304, -13690, -14076, -14462, -14847, -15233, -15620, -16005, -16391, -16778, -17162, -17549, -17935, -18320, -18707, -19093, -19478, -19865, -20250, -20636, -21023, -21409, -21794, -22181, -22566, -22952, -23339, -23725, -24110, -24497, -24882, -25268, -25655, -26040, -26426, -26812, -27197, -27584, -27970, -28355, -28742, -29127, -29513, -29899, -30285, -30671, -31056, -31443, -31796, -32130, -33181, -5350};