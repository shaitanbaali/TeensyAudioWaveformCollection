/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0018 256 samples */
 
const int16_t AKWF_gapsaw_0018_256_DATA [256] = 
{32605, 32000, 31406, 30811, 30216, 29622, 29026, 28430, 27835, 27239, 26644, 26049, 25452, 24859, 24263, 23667, 23072, 22476, 21881, 21286, 20690, 20095, 19500, 18904, 18308, 17713, 17118, 16522, 15928, 15331, 14737, 14142, 13544, 12950, 12355, 11759, 11165, 10569, 9974, 9378, 8782, 8186, 7592, 6997, 6400, 5806, 5210, 4614, 4020, 3424, 2828, 2234, 1637, 1049, 426, -3, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -6, 18, -336, -964, -1551, -2147, -2742, -3337, -3933, -4528, -5123, -5720, -6315, -6910, -7505, -8101, -8695, -9291, -9888, -10482, -11078, -11673, -12268, -12864, -13458, -14054, -14651, -15245, -15840, -16436, -17031, -17626, -18222, -18817, -19413, -20009, -20603, -21198, -21795, -22388, -22985, -23581, -24175, -24771, -25367, -25961, -26557, -27152, -27747, -28343, -28939, -29534, -30129, -30725, -31287, -31829, -33098, -5358};