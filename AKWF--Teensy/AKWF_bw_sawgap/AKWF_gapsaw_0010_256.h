/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0010 256 samples */
 
const int16_t AKWF_gapsaw_0010_256_DATA [256] = 
{32667, 32294, 31928, 31560, 31193, 30826, 30458, 30091, 29724, 29355, 28989, 28621, 28253, 27886, 27518, 27151, 26783, 26416, 26048, 25681, 25314, 24946, 24579, 24212, 23844, 23476, 23108, 22740, 22374, 22006, 21639, 21272, 20903, 20537, 20169, 19801, 19434, 19067, 18698, 18331, 17964, 17596, 17228, 16861, 16493, 16127, 15759, 15391, 15024, 14657, 14289, 13922, 13553, 13186, 12819, 12451, 12084, 11717, 11348, 10981, 10614, 10247, 9880, 9512, 9144, 8776, 8409, 8041, 7674, 7307, 6939, 6572, 6205, 5836, 5469, 5102, 4734, 4367, 3999, 3631, 3264, 2896, 2529, 2162, 1794, 1427, 1060, 695, 316, 13, -3, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -2, 2, -259, -643, -1007, -1374, -1741, -2109, -2477, -2843, -3211, -3579, -3945, -4313, -4682, -5049, -5416, -5784, -6151, -6519, -6886, -7253, -7621, -7988, -8355, -8723, -9090, -9459, -9827, -10194, -10561, -10929, -11295, -11663, -12031, -12398, -12765, -13133, -13500, -13868, -14236, -14604, -14970, -15339, -15705, -16073, -16441, -16807, -17175, -17543, -17910, -18278, -18645, -19013, -19381, -19748, -20115, -20483, -20850, -21218, -21585, -21952, -22319, -22687, -23054, -23422, -23791, -24158, -24525, -24893, -25260, -25627, -25995, -26362, -26729, -27098, -27464, -27832, -28200, -28567, -28935, -29302, -29670, -30038, -30404, -30772, -31140, -31507, -31841, -32157, -33188, -5349};