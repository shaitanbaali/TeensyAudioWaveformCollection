/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0015 256 samples */
 
const int16_t AKWF_gapsaw_0015_256_DATA [256] = 
{32635, 32144, 31663, 31180, 30698, 30214, 29731, 29248, 28766, 28282, 27800, 27316, 26832, 26350, 25867, 25384, 24902, 24418, 23935, 23452, 22969, 22486, 22003, 21519, 21036, 20553, 20070, 19587, 19104, 18621, 18138, 17655, 17171, 16689, 16206, 15723, 15240, 14758, 14273, 13791, 13308, 12825, 12342, 11859, 11375, 10894, 10410, 9927, 9444, 8961, 8477, 7995, 7512, 7028, 6546, 6062, 5579, 5097, 4612, 4130, 3647, 3163, 2681, 2198, 1715, 1231, 755, 245, -18, 5, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -6, 19, -180, -683, -1162, -1645, -2127, -2611, -3093, -3576, -4060, -4542, -5026, -5510, -5992, -6476, -6959, -7441, -7924, -8408, -8890, -9374, -9857, -10339, -10823, -11306, -11789, -12272, -12755, -13237, -13721, -14203, -14687, -15170, -15653, -16135, -16619, -17102, -17584, -18068, -18550, -19033, -19517, -20000, -20482, -20967, -21449, -21932, -22416, -22898, -23381, -23866, -24347, -24831, -25314, -25796, -26279, -26763, -27245, -27729, -28212, -28694, -29177, -29661, -30143, -30627, -31109, -31559, -31990, -33141, -5354};