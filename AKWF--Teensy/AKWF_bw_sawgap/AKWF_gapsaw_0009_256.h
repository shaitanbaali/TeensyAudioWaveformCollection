/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0009 256 samples */
 
const int16_t AKWF_gapsaw_0009_256_DATA [256] = 
{32671, 32315, 31965, 31615, 31264, 30913, 30562, 30213, 29862, 29510, 29160, 28809, 28457, 28107, 27757, 27407, 27056, 26705, 26354, 26003, 25652, 25302, 24952, 24601, 24250, 23899, 23548, 23197, 22848, 22497, 22146, 21796, 21444, 21094, 20743, 20392, 20042, 19692, 19340, 18990, 18639, 18287, 17937, 17587, 17236, 16886, 16535, 16183, 15833, 15482, 15132, 14782, 14431, 14080, 13729, 13378, 13027, 12677, 12327, 11976, 11625, 11274, 10923, 10573, 10222, 9872, 9521, 9170, 8820, 8469, 8118, 7767, 7417, 7066, 6716, 6365, 6013, 5663, 5313, 4962, 4612, 4261, 3909, 3559, 3208, 2857, 2508, 2157, 1806, 1456, 1104, 755, 402, 61, -11, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, 5, -32, -347, -705, -1054, -1404, -1756, -2106, -2457, -2807, -3158, -3509, -3859, -4210, -4561, -4912, -5262, -5613, -5963, -6314, -6665, -7016, -7366, -7717, -8067, -8418, -8769, -9120, -9470, -9821, -10172, -10522, -10873, -11223, -11574, -11925, -12276, -12626, -12977, -13327, -13678, -14029, -14380, -14731, -15082, -15431, -15782, -16133, -16484, -16835, -17186, -17536, -17886, -18237, -18587, -18939, -19290, -19640, -19991, -20341, -20691, -21043, -21394, -21744, -22095, -22446, -22796, -23146, -23497, -23847, -24199, -24550, -24901, -25252, -25601, -25952, -26303, -26654, -27005, -27356, -27706, -28056, -28407, -28757, -29109, -29460, -29810, -30161, -30511, -30861, -31213, -31564, -31881, -32181, -33194, -5348};