/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0017 256 samples */
 
const int16_t AKWF_gapsaw_0017_256_DATA [256] = 
{5356, 33114, 31890, 31391, 30871, 30319, 29765, 29214, 28662, 28108, 27556, 27003, 26450, 25898, 25346, 24793, 24242, 23688, 23135, 22583, 22030, 21478, 20926, 20373, 19820, 19269, 18715, 18162, 17610, 17057, 16505, 15953, 15399, 14847, 14296, 13741, 13190, 12637, 12084, 11532, 10979, 10427, 9875, 9322, 8769, 8217, 7664, 7111, 6560, 6007, 5454, 4903, 4349, 3796, 3244, 2691, 2139, 1587, 1039, 466, 18, -4, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -4, 9, -54, -555, -1120, -1668, -2221, -2773, -3325, -3878, -4431, -4983, -5536, -6089, -6641, -7193, -7746, -8298, -8851, -9405, -9956, -10509, -11061, -11613, -12166, -12719, -13271, -13824, -14377, -14928, -15482, -16034, -16586, -17140, -17691, -18243, -18797, -19349, -19902, -20455, -21007, -21560, -22112, -22664, -23216, -23770, -24322, -24875, -25428, -25979, -26532, -27085, -27636, -28190, -28743, -29294, -29847, -30400, -30952, -31504, -32055, -32616};