/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0014 256 samples */
 
const int16_t AKWF_gapsaw_0014_256_DATA [256] = 
{5352, 33153, 32031, 31628, 31207, 30753, 30298, 29844, 29389, 28934, 28480, 28026, 27571, 27117, 26663, 26207, 25754, 25299, 24844, 24391, 23935, 23481, 23027, 22572, 22118, 21664, 21209, 20754, 20301, 19845, 19391, 18937, 18482, 18028, 17574, 17118, 16664, 16211, 15755, 15302, 14847, 14392, 13938, 13484, 13029, 12575, 12120, 11666, 11212, 10757, 10302, 9848, 9393, 8939, 8485, 8030, 7575, 7122, 6667, 6212, 5758, 5303, 4849, 4396, 3940, 3485, 3031, 2576, 2123, 1668, 1213, 764, 286, -10, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, 0, -7, -358, -830, -1281, -1736, -2190, -2645, -3098, -3552, -4008, -4463, -4916, -5371, -5825, -6280, -6735, -7188, -7643, -8098, -8552, -9006, -9461, -9914, -10369, -10825, -11279, -11733, -12188, -12641, -13096, -13551, -14005, -14460, -14914, -15368, -15823, -16278, -16731, -17186, -17641, -18095, -18550, -19004, -19458, -19913, -20367, -20821, -21277, -21730, -22185, -22640, -23094, -23548, -24003, -24457, -24911, -25366, -25820, -26274, -26730, -27183, -27638, -28093, -28546, -29001, -29456, -29910, -30365, -30819, -31273, -31727, -32181, -32643};