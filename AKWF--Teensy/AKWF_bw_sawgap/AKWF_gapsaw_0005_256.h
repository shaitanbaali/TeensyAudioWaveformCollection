/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0005 256 samples */
 
const int16_t AKWF_gapsaw_0005_256_DATA [256] = 
{32687, 32386, 32090, 31794, 31497, 31201, 30904, 30609, 30311, 30014, 29719, 29422, 29125, 28829, 28533, 28236, 27939, 27643, 27346, 27049, 26753, 26456, 26160, 25863, 25566, 25271, 24974, 24678, 24381, 24084, 23788, 23491, 23194, 22898, 22601, 22304, 22008, 21712, 21415, 21118, 20822, 20525, 20230, 19932, 19635, 19340, 19044, 18746, 18450, 18152, 17856, 17560, 17264, 16967, 16670, 16374, 16077, 15782, 15484, 15187, 14892, 14595, 14299, 14002, 13704, 13408, 13112, 12815, 12519, 12222, 11925, 11629, 11333, 11036, 10739, 10443, 10147, 9851, 9553, 9256, 8960, 8663, 8367, 8071, 7773, 7477, 7181, 6885, 6588, 6291, 5995, 5698, 5403, 5106, 4808, 4511, 4215, 3919, 3623, 3325, 3029, 2733, 2436, 2140, 1843, 1546, 1251, 954, 657, 361, 65, -11, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, 6, -38, -315, -616, -911, -1208, -1504, -1800, -2097, -2394, -2690, -2986, -3283, -3580, -3876, -4172, -4468, -4765, -5063, -5360, -5656, -5952, -6248, -6546, -6842, -7138, -7434, -7730, -8028, -8324, -8620, -8917, -9213, -9510, -9808, -10104, -10400, -10696, -10993, -11290, -11586, -11883, -12179, -12476, -12773, -13068, -13365, -13661, -13959, -14256, -14552, -14848, -15145, -15441, -15738, -16035, -16331, -16627, -16924, -17221, -17517, -17813, -18109, -18406, -18704, -19000, -19297, -19593, -19889, -20186, -20483, -20779, -21075, -21372, -21669, -21965, -22261, -22557, -22855, -23151, -23447, -23745, -24041, -24337, -24635, -24931, -25227, -25523, -25820, -26117, -26413, -26709, -27005, -27303, -27599, -27895, -28193, -28489, -28785, -29082, -29379, -29675, -29972, -30267, -30565, -30861, -31157, -31454, -31751, -32015, -32260, -33216, -5346};