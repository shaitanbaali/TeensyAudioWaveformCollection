/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0012 256 samples */
 
const int16_t AKWF_gapsaw_0012_256_DATA [256] = 
{32657, 32243, 31838, 31431, 31025, 30620, 30213, 29807, 29401, 28993, 28587, 28181, 27775, 27369, 26962, 26555, 26150, 25743, 25336, 24930, 24524, 24118, 23712, 23305, 22898, 22493, 22086, 21679, 21273, 20866, 20460, 20054, 19647, 19241, 18835, 18428, 18023, 17616, 17209, 16803, 16397, 15990, 15585, 15178, 14771, 14365, 13959, 13552, 13146, 12739, 12333, 11927, 11521, 11114, 10708, 10301, 9894, 9489, 9082, 8676, 8270, 7863, 7456, 7050, 6643, 6238, 5832, 5425, 5018, 4612, 4205, 3800, 3393, 2986, 2581, 2174, 1767, 1361, 955, 551, 132, -17, 4, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -5, 13, -87, -490, -897, -1302, -1709, -2115, -2522, -2928, -3334, -3741, -4147, -4553, -4960, -5366, -5773, -6179, -6585, -6991, -7398, -7804, -8210, -8617, -9023, -9429, -9836, -10242, -10648, -11055, -11461, -11868, -12274, -12679, -13086, -13493, -13899, -14306, -14712, -15118, -15525, -15932, -16338, -16744, -17150, -17556, -17964, -18370, -18775, -19182, -19588, -19994, -20402, -20807, -21213, -21621, -22027, -22433, -22839, -23246, -23652, -24059, -24464, -24870, -25277, -25683, -26090, -26497, -26902, -27309, -27716, -28121, -28528, -28935, -29341, -29748, -30154, -30560, -30966, -31372, -31746, -32101, -33172, -5350};