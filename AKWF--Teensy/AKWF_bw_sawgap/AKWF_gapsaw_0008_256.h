/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0008 256 samples */
 
const int16_t AKWF_gapsaw_0008_256_DATA [256] = 
{32676, 32335, 32001, 31665, 31330, 30995, 30659, 30324, 29989, 29653, 29318, 28982, 28647, 28312, 27976, 27640, 27306, 26970, 26635, 26300, 25964, 25628, 25293, 24957, 24622, 24288, 23952, 23616, 23281, 22945, 22610, 22275, 21939, 21604, 21269, 20933, 20598, 20263, 19927, 19592, 19256, 18921, 18586, 18250, 17914, 17580, 17244, 16908, 16574, 16238, 15902, 15568, 15232, 14896, 14561, 14226, 13890, 13556, 13219, 12884, 12549, 12213, 11878, 11543, 11207, 10872, 10536, 10201, 9866, 9530, 9194, 8859, 8524, 8189, 7854, 7518, 7183, 6847, 6511, 6176, 5841, 5506, 5170, 4835, 4499, 4164, 3829, 3493, 3157, 2822, 2487, 2151, 1816, 1480, 1145, 810, 477, 128, -14, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -4, 12, -88, -427, -762, -1097, -1432, -1768, -2103, -2438, -2774, -3109, -3445, -3780, -4116, -4450, -4786, -5122, -5457, -5793, -6128, -6463, -6799, -7135, -7469, -7805, -8141, -8475, -8811, -9146, -9482, -9817, -10153, -10487, -10823, -11159, -11494, -11830, -12165, -12500, -12836, -13171, -13507, -13842, -14177, -14512, -14848, -15183, -15519, -15854, -16189, -16525, -16860, -17195, -17531, -17866, -18201, -18537, -18872, -19207, -19543, -19879, -20214, -20549, -20885, -21219, -21556, -21891, -22226, -22561, -22897, -23232, -23568, -23903, -24238, -24574, -24908, -25244, -25580, -25915, -26250, -26586, -26921, -27256, -27592, -27927, -28263, -28598, -28933, -29268, -29604, -29939, -30275, -30611, -30946, -31281, -31616, -31919, -32204, -33201, -5348};