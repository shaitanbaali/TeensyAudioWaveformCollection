/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0039 256 samples */
 
const int16_t AKWF_gapsaw_0039_256_DATA [256] = 
{32667, 32294, 31928, 31560, 31193, 30826, 30458, 30091, 29724, 29355, 28989, 28621, 28253, 27886, 27518, 27151, 26783, 26416, 26048, 25681, 25314, 24946, 24579, 24212, 23844, 23476, 23108, 22740, 22374, 22006, 21639, 21272, 20903, 20537, 20169, 19801, 19434, 19067, 18698, 18331, 17964, 17596, 17228, 16861, 16493, 16127, 15759, 15391, 15024, 14657, 14289, 13922, 13553, 13186, 12819, 12451, 12084, 11717, 11348, 10981, 10614, 10247, 9880, 9512, 9144, 8776, 8409, 8041, 7674, 7307, 6939, 6572, 6205, 5836, 5469, 5102, 4734, 4367, 3999, 3631, 3264, 2896, 2529, 2162, 1794, 1427, 1060, 695, 316, 13, -3, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, 0, -8, -597, -1400, -2166, -2938, -3707, -4480, -5253, -6023, -6796, -7568, -8339, -9112, -9883, -10654, -11427, -12197, -12969, -13742, -14512, -15284, -16057, -16827, -17599, -18371, -19142, -19914, -20687, -21457, -22229, -23002, -23773, -24545, -25317, -26088, -26860, -27632, -28402, -29175, -29947, -30685, -31402, -32852, -5338};