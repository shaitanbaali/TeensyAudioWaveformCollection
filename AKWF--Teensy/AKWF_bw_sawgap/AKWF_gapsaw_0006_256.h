/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0006 256 samples */
 
const int16_t AKWF_gapsaw_0006_256_DATA [256] = 
{32683, 32370, 32063, 31754, 31446, 31138, 30829, 30521, 30212, 29903, 29595, 29287, 28978, 28670, 28361, 28052, 27745, 27437, 27128, 26819, 26510, 26202, 25894, 25586, 25277, 24968, 24660, 24351, 24043, 23735, 23427, 23118, 22808, 22501, 22193, 21884, 21576, 21267, 20958, 20650, 20341, 20033, 19725, 19416, 19107, 18799, 18491, 18182, 17875, 17566, 17256, 16949, 16640, 16332, 16024, 15715, 15406, 15098, 14790, 14481, 14173, 13865, 13556, 13247, 12939, 12631, 12322, 12013, 11706, 11397, 11088, 10780, 10471, 10163, 9855, 9546, 9237, 8929, 8621, 8312, 8005, 7696, 7386, 7078, 6770, 6462, 6154, 5844, 5535, 5228, 4919, 4611, 4303, 3994, 3685, 3377, 3069, 2761, 2452, 2143, 1835, 1526, 1217, 910, 604, 287, 20, -4, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -4, -239, -560, -865, -1174, -1482, -1790, -2099, -2407, -2716, -3025, -3332, -3641, -3950, -4258, -4567, -4875, -5183, -5492, -5800, -6109, -6418, -6725, -7033, -7342, -7651, -7960, -8268, -8576, -8884, -9193, -9501, -9811, -10119, -10426, -10735, -11044, -11352, -11661, -11969, -12277, -12586, -12894, -13202, -13511, -13820, -14128, -14437, -14745, -15053, -15362, -15670, -15979, -16288, -16595, -16904, -17212, -17521, -17830, -18138, -18446, -18755, -19062, -19371, -19680, -19989, -20296, -20605, -20913, -21222, -21531, -21839, -22148, -22456, -22764, -23072, -23382, -23690, -23998, -24306, -24615, -24923, -25232, -25541, -25849, -26158, -26465, -26774, -27083, -27392, -27699, -28008, -28316, -28624, -28933, -29242, -29550, -29859, -30166, -30475, -30784, -31092, -31401, -31709, -31985, -32242, -33210, -5347};