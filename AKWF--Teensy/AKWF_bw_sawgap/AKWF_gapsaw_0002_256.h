/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0002 256 samples */
 
const int16_t AKWF_gapsaw_0002_256_DATA [256] = 
{32695, 32425, 32161, 31895, 31629, 31363, 31098, 30832, 30566, 30299, 30035, 29769, 29502, 29237, 28971, 28705, 28440, 28174, 27908, 27643, 27376, 27110, 26845, 26580, 26313, 26048, 25781, 25516, 25251, 24984, 24718, 24453, 24188, 23921, 23655, 23389, 23125, 22859, 22592, 22326, 22061, 21796, 21531, 21264, 20998, 20733, 20468, 20201, 19936, 19669, 19404, 19139, 18873, 18606, 18341, 18076, 17810, 17544, 17277, 17013, 16747, 16480, 16214, 15950, 15683, 15417, 15152, 14886, 14621, 14354, 14088, 13823, 13557, 13291, 13025, 12759, 12494, 12228, 11962, 11696, 11431, 11165, 10900, 10635, 10368, 10103, 9838, 9571, 9305, 9040, 8774, 8508, 8243, 7976, 7711, 7446, 7179, 6913, 6648, 6382, 6116, 5850, 5584, 5320, 5054, 4787, 4521, 4256, 3990, 3725, 3458, 3192, 2928, 2661, 2395, 2129, 1864, 1598, 1332, 1066, 801, 537, 265, 25, -5, 1, 0, 0, 0, -1, 1, -9, -224, -499, -763, -1028, -1294, -1560, -1826, -2091, -2357, -2623, -2889, -3155, -3419, -3686, -3953, -4218, -4483, -4749, -5015, -5282, -5546, -5812, -6078, -6344, -6610, -6875, -7141, -7407, -7673, -7938, -8204, -8470, -8736, -9001, -9267, -9533, -9799, -10065, -10330, -10596, -10862, -11127, -11393, -11658, -11924, -12190, -12456, -12721, -12987, -13253, -13519, -13784, -14050, -14316, -14582, -14848, -15113, -15379, -15645, -15911, -16176, -16442, -16708, -16974, -17239, -17505, -17771, -18037, -18302, -18568, -18834, -19100, -19366, -19630, -19897, -20163, -20429, -20694, -20960, -21226, -21492, -21758, -22022, -22287, -22554, -22820, -23086, -23351, -23616, -23883, -24149, -24414, -24680, -24946, -25212, -25478, -25742, -26008, -26275, -26541, -26806, -27072, -27337, -27604, -27869, -28134, -28401, -28667, -28932, -29198, -29464, -29730, -29996, -30261, -30527, -30793, -31059, -31323, -31590, -31856, -32089, -32304, -33228, -5345};