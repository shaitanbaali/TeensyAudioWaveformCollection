/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0019 256 samples */
 
const int16_t AKWF_gapsaw_0019_256_DATA [256] = 
{32591, 31935, 31292, 30647, 30003, 29357, 28712, 28066, 27421, 26775, 26130, 25485, 24839, 24195, 23548, 22902, 22258, 21612, 20965, 20321, 19675, 19029, 18384, 17738, 17093, 16449, 15803, 15158, 14513, 13865, 13221, 12576, 11930, 11285, 10640, 9994, 9349, 8703, 8057, 7413, 6768, 6121, 5476, 4831, 4184, 3539, 2894, 2248, 1604, 965, 288, -26, 7, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -8, 26, -205, -869, -1510, -2155, -2799, -3445, -4092, -4736, -5382, -6028, -6673, -7319, -7964, -8609, -9255, -9901, -10546, -11192, -11836, -12481, -13127, -13772, -14418, -15064, -15708, -16354, -17000, -17644, -18289, -18936, -19581, -20226, -20872, -21517, -22163, -22809, -23453, -24100, -24746, -25390, -26035, -26681, -27325, -27971, -28618, -29262, -29908, -30553, -31165, -31757, -33077, -5360};