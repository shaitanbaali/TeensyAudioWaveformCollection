/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_gapsaw_0037 256 samples */
 
const int16_t AKWF_gapsaw_0037_256_DATA [256] = 
{32500, 31845, 31204, 30561, 29918, 29275, 28631, 27987, 27343, 26699, 26056, 25413, 24769, 24126, 23482, 22838, 22195, 21551, 20906, 20264, 19620, 18975, 18332, 17688, 17045, 16402, 15758, 15115, 14472, 13827, 13183, 12541, 11896, 11253, 10610, 9966, 9322, 8679, 8035, 7392, 6749, 6103, 5461, 4817, 4173, 3529, 2885, 2241, 1599, 962, 287, -26, 7, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, 4, -26, -394, -835, -1261, -1690, -2119, -2548, -2976, -3406, -3835, -4264, -4694, -5123, -5552, -5981, -6410, -6839, -7268, -7697, -8125, -8555, -8983, -9413, -9843, -10271, -10700, -11129, -11558, -11987, -12417, -12845, -13274, -13703, -14133, -14562, -14991, -15420, -15849, -16278, -16707, -17136, -17565, -17993, -18423, -18852, -19282, -19711, -20140, -20568, -20998, -21427, -21855, -22285, -22713, -23142, -23572, -24001, -24430, -24860, -25288, -25717, -26146, -26575, -27004, -27433, -27861, -28292, -28721, -29150, -29579, -30008, -30436, -30866, -31295, -31691, -32069, -33163, -5351};