/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0011 256 samples */
 
const int16_t AKWF_oboe_0011_256_DATA [256] = 
{900, 2934, 5068, 7448, 10072, 12836, 15591, 18257, 20864, 23360, 25581, 27449, 29077, 30447, 31480, 32159, 32593, 32778, 32690, 32341, 31803, 31091, 30146, 28973, 27589, 26020, 24279, 22225, 19941, 17542, 14934, 12207, 9491, 6821, 4232, 1726, -637, -2834, -4797, -6560, -8123, -9331, -10234, -10946, -11405, -11327, -10892, -10250, -9332, -8112, -6775, -5539, -4473, -3546, -2751, -2144, -1757, -1454, -1120, -736, -348, 91, 598, 1101, 1541, 1845, 1986, 2034, 1913, 1600, 1149, 623, -97, -992, -1895, -2913, -4008, -5094, -6197, -7292, -8294, -9177, -10029, -10784, -11416, -11943, -12370, -12625, -12729, -12802, -12776, -12613, -12366, -12128, -11859, -11502, -11069, -10638, -10187, -9646, -8983, -8231, -7424, -6544, -5538, -4577, -3680, -2773, -1880, -1043, -225, 624, 1416, 2270, 3174, 3915, 4669, 5414, 6036, 6562, 6961, 7270, 7542, 7757, 7907, 7979, 7965, 7939, 7834, 7613, 7355, 7005, 6547, 5998, 5358, 4688, 3989, 3228, 2362, 1513, 719, -109, -923, -1590, -2066, -2475, -2746, -2887, -2971, -2902, -2811, -2771, -2712, -2614, -2543, -2513, -2409, -2304, -2161, -1900, -1586, -1255, -890, -485, -147, 174, 506, 757, 945, 1082, 1155, 1139, 1073, 990, 880, 688, 486, 313, 114, -138, -417, -688, -964, -1230, -1477, -1691, -1842, -2039, -2273, -2453, -2701, -3006, -3331, -3703, -4049, -4376, -4712, -5010, -5276, -5518, -5741, -5932, -6059, -6175, -6353, -6384, -6294, -6227, -6213, -6151, -5962, -5652, -5289, -5018, -4823, -4589, -4430, -4341, -4238, -4074, -3964, -3906, -3811, -3653, -3483, -3309, -3116, -2973, -2818, -2628, -2491, -2468, -2500, -2525, -2589, -2642, -2700, -2840, -3083, -3358, -3650, -4012, -4376, -4715, -5028, -5326, -5641, -5874, -5903, -5738, -5518, -5152, -4399, -3334, -2188, -849};