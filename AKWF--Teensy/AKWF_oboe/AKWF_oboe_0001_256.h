/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0001 256 samples */
 
const int16_t AKWF_oboe_0001_256_DATA [256] = 
{780, 2178, 3525, 4851, 6139, 7401, 8625, 9800, 10933, 12017, 13052, 14047, 14996, 15895, 16751, 17556, 18321, 19049, 19740, 20399, 21025, 21620, 22191, 22741, 23271, 23783, 24287, 24777, 25256, 25726, 26183, 26633, 27076, 27511, 27937, 28350, 28743, 29120, 29474, 29806, 30117, 30407, 30676, 30927, 31158, 31369, 31560, 31730, 31882, 32016, 32131, 32229, 32307, 32367, 32404, 32417, 32407, 32372, 32312, 32231, 32130, 32011, 31877, 31728, 31560, 31370, 31154, 30907, 30627, 30313, 29964, 29583, 29166, 28718, 28239, 27725, 27177, 26601, 25993, 25359, 24697, 24004, 23285, 22544, 21785, 21012, 20228, 19435, 18639, 17835, 17017, 16173, 15302, 14398, 13467, 12525, 11583, 10655, 9761, 8908, 8096, 7322, 6569, 5832, 5100, 4368, 3644, 2930, 2228, 1552, 902, 287, -290, -841, -1366, -1864, -2343, -2803, -3244, -3670, -4074, -4451, -4801, -5117, -5397, -5654, -5898, -6145, -6410, -6705, -7034, -7390, -7763, -8136, -8501, -8846, -9167, -9470, -9758, -10038, -10316, -10597, -10882, -11165, -11443, -11714, -11973, -12216, -12442, -12651, -12844, -13021, -13181, -13325, -13453, -13564, -13657, -13731, -13784, -13815, -13822, -13808, -13776, -13727, -13665, -13592, -13512, -13426, -13334, -13239, -13146, -13055, -12973, -12897, -12833, -12778, -12733, -12698, -12673, -12660, -12662, -12690, -12751, -12854, -13006, -13208, -13456, -13745, -14070, -14427, -14811, -15222, -15662, -16126, -16618, -17133, -17669, -18224, -18794, -19388, -20016, -20682, -21390, -22142, -22924, -23733, -24553, -25370, -26169, -26947, -27703, -28429, -29118, -29757, -30340, -30860, -31314, -31705, -32041, -32325, -32570, -32746, -32771, -32766, -32767, -32766, -32771, -32595, -32245, -31812, -31290, -30684, -29995, -29228, -28387, -27470, -26486, -25432, -24311, -23129, -21892, -20607, -19278, -17909, -16506, -15081, -13638, -12185, -10713, -9241, -7767, -6300, -4852, -3418, -1996, -566};