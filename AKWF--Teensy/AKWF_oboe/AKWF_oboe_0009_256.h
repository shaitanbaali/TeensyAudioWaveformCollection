/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0009 256 samples */
 
const int16_t AKWF_oboe_0009_256_DATA [256] = 
{436, 1306, 2126, 2921, 3683, 4417, 5122, 5797, 6444, 7072, 7676, 8259, 8820, 9354, 9873, 10381, 10881, 11378, 11877, 12378, 12888, 13401, 13917, 14432, 14949, 15463, 15973, 16479, 16978, 17476, 17974, 18473, 18977, 19484, 19994, 20515, 21041, 21570, 22099, 22622, 23136, 23643, 24132, 24605, 25065, 25506, 25943, 26378, 26813, 27250, 27695, 28143, 28596, 29041, 29467, 29869, 30233, 30553, 30829, 31059, 31247, 31399, 31519, 31614, 31688, 31746, 31788, 31811, 31816, 31802, 31767, 31713, 31638, 31540, 31422, 31286, 31130, 30959, 30770, 30564, 30345, 30110, 29861, 29599, 29322, 29035, 28740, 28436, 28127, 27812, 27491, 27164, 26829, 26486, 26134, 25768, 25389, 24997, 24592, 24178, 23751, 23311, 22860, 22402, 21933, 21456, 20967, 20466, 19955, 19433, 18901, 18359, 17804, 17238, 16660, 16068, 15464, 14836, 14188, 13515, 12818, 12098, 11354, 10588, 9805, 9002, 8192, 7365, 6526, 5679, 4819, 3949, 3067, 2168, 1252, 324, -621, -1575, -2541, -3511, -4481, -5443, -6392, -7328, -8252, -9164, -10062, -10942, -11803, -12654, -13485, -14300, -15095, -15867, -16624, -17369, -18101, -18826, -19543, -20251, -20958, -21653, -22333, -22994, -23627, -24228, -24801, -25335, -25839, -26315, -26760, -27186, -27595, -27989, -28371, -28741, -29094, -29435, -29760, -30068, -30357, -30631, -30884, -31120, -31340, -31541, -31727, -31896, -32050, -32189, -32312, -32420, -32512, -32589, -32653, -32705, -32744, -32767, -32767, -32767, -32768, -32753, -32711, -32655, -32582, -32491, -32383, -32256, -32112, -31944, -31754, -31539, -31298, -31032, -30738, -30416, -30067, -29691, -29286, -28856, -28395, -27906, -27390, -26846, -26275, -25674, -25040, -24374, -23679, -22956, -22198, -21417, -20609, -19775, -18929, -18061, -17175, -16272, -15351, -14422, -13496, -12566, -11645, -10740, -9849, -8984, -8137, -7297, -6464, -5631, -4788, -3939, -3071, -2191, -1308, -409};