/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0010 256 samples */
 
const int16_t AKWF_oboe_0010_256_DATA [256] = 
{1005, 2698, 4338, 5956, 7541, 9077, 10555, 11950, 13281, 14533, 15707, 16813, 17843, 18810, 19724, 20581, 21386, 22139, 22832, 23470, 24046, 24559, 25001, 25374, 25675, 25904, 26062, 26152, 26174, 26129, 26020, 25847, 25610, 25314, 24962, 24548, 24079, 23562, 23003, 22410, 21796, 21161, 20515, 19863, 19209, 18555, 17898, 17234, 16566, 15889, 15204, 14515, 13813, 13105, 12398, 11695, 11008, 10348, 9713, 9117, 8565, 8059, 7594, 7171, 6788, 6442, 6132, 5854, 5605, 5382, 5189, 5029, 4896, 4784, 4686, 4596, 4511, 4422, 4327, 4221, 4105, 3986, 3868, 3760, 3669, 3600, 3560, 3550, 3574, 3625, 3693, 3772, 3851, 3921, 3971, 3995, 3987, 3951, 3892, 3809, 3710, 3598, 3477, 3354, 3232, 3113, 2991, 2867, 2741, 2619, 2499, 2382, 2270, 2164, 2067, 1982, 1904, 1831, 1758, 1680, 1595, 1499, 1388, 1261, 1120, 971, 825, 690, 574, 489, 441, 437, 473, 551, 663, 806, 976, 1162, 1364, 1575, 1790, 2015, 2249, 2490, 2740, 2998, 3260, 3529, 3803, 4080, 4354, 4627, 4900, 5178, 5461, 5754, 6061, 6380, 6714, 7061, 7413, 7758, 8083, 8377, 8623, 8814, 8936, 8991, 8983, 8911, 8773, 8571, 8306, 7978, 7589, 7144, 6632, 6051, 5411, 4721, 3992, 3234, 2451, 1655, 854, 55, -744, -1560, -2398, -3272, -4190, -5163, -6202, -7312, -8488, -9724, -11000, -12299, -13616, -14925, -16215, -17472, -18678, -19843, -20975, -22061, -23111, -24123, -25090, -26030, -26934, -27803, -28628, -29406, -30133, -30803, -31406, -31937, -32401, -32738, -32772, -32765, -32767, -32767, -32767, -32766, -32767, -32763, -32482, -32014, -31470, -30844, -30141, -29368, -28539, -27655, -26717, -25740, -24721, -23660, -22566, -21417, -20219, -18972, -17667, -16307, -14902, -13434, -11926, -10382, -8799, -7200, -5576, -3934, -2290, -607};