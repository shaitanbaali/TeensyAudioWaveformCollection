/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0004 256 samples */
 
const int16_t AKWF_oboe_0004_256_DATA [256] = 
{338, 1399, 2487, 3605, 4713, 5763, 6756, 7721, 8691, 9669, 10643, 11593, 12514, 13411, 14295, 15185, 16057, 16876, 17611, 18283, 18976, 19756, 20612, 21494, 22347, 23158, 23953, 24734, 25500, 26261, 27039, 27845, 28661, 29456, 30215, 30918, 31535, 32041, 32426, 32683, 32771, 32764, 32656, 32457, 32207, 31890, 31483, 30983, 30397, 29705, 28897, 28012, 27145, 26377, 25710, 25075, 24407, 23706, 22976, 22227, 21461, 20694, 19968, 19299, 18667, 18056, 17450, 16844, 16217, 15542, 14823, 14109, 13443, 12834, 12253, 11656, 11037, 10425, 9847, 9319, 8844, 8426, 8074, 7783, 7504, 7201, 6880, 6577, 6334, 6155, 6008, 5858, 5694, 5539, 5428, 5377, 5371, 5386, 5406, 5432, 5471, 5528, 5592, 5641, 5656, 5629, 5546, 5391, 5155, 4860, 4541, 4222, 3884, 3489, 3027, 2504, 1915, 1264, 556, -141, -759, -1286, -1769, -2270, -2809, -3351, -3859, -4319, -4729, -5085, -5370, -5605, -5840, -6121, -6446, -6789, -7126, -7452, -7760, -8048, -8306, -8547, -8791, -9042, -9304, -9576, -9861, -10149, -10414, -10629, -10802, -10944, -11075, -11196, -11319, -11456, -11614, -11790, -11978, -12183, -12392, -12572, -12696, -12783, -12896, -13093, -13358, -13618, -13793, -13877, -13886, -13835, -13732, -13595, -13459, -13345, -13255, -13192, -13161, -13157, -13167, -13176, -13181, -13185, -13184, -13180, -13173, -13170, -13171, -13180, -13203, -13247, -13305, -13361, -13404, -13443, -13489, -13560, -13651, -13753, -13851, -13945, -14039, -14136, -14238, -14347, -14468, -14600, -14743, -14904, -15086, -15278, -15454, -15589, -15687, -15775, -15879, -16004, -16142, -16291, -16446, -16604, -16760, -16906, -17037, -17143, -17216, -17255, -17257, -17223, -17148, -17035, -16883, -16689, -16448, -16156, -15807, -15404, -14945, -14432, -13864, -13236, -12544, -11793, -10977, -10097, -9169, -8195, -7198, -6185, -5183, -4233, -3349, -2485, -1594, -626};