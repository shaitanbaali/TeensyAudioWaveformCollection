/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0003 256 samples */
 
const int16_t AKWF_oboe_0003_256_DATA [256] = 
{679, 2063, 3417, 4907, 6534, 8259, 10081, 11943, 13619, 14896, 15826, 16751, 17954, 19345, 20535, 21240, 21534, 21704, 21940, 22228, 22554, 22932, 23321, 23521, 23367, 22964, 22638, 22635, 22853, 22989, 22844, 22516, 22241, 22157, 22207, 22274, 22303, 22274, 22110, 21759, 21266, 20757, 20306, 19872, 19363, 18729, 18014, 17286, 16599, 15906, 15124, 14209, 13232, 12332, 11591, 10942, 10271, 9535, 8767, 8039, 7373, 6755, 6181, 5651, 5131, 4577, 3958, 3327, 2781, 2352, 1979, 1566, 1069, 561, 147, -145, -393, -721, -1167, -1656, -2103, -2483, -2812, -3104, -3362, -3593, -3819, -4041, -4256, -4462, -4663, -4798, -4783, -4590, -4340, -4196, -4179, -4103, -3743, -3066, -2237, -1410, -627, 113, 808, 1443, 2002, 2493, 2912, 3264, 3571, 3836, 4052, 4208, 4320, 4427, 4568, 4768, 5080, 5560, 6219, 7056, 8073, 9262, 10547, 11842, 13135, 14537, 16130, 17883, 19632, 21250, 22696, 23932, 24919, 25651, 26189, 26598, 26856, 26905, 26692, 26237, 25582, 24775, 23832, 22761, 21577, 20339, 19183, 18225, 17439, 16716, 15980, 15262, 14637, 14147, 13765, 13440, 13132, 12831, 12547, 12281, 11981, 11521, 10825, 9926, 8910, 7829, 6678, 5461, 4204, 2901, 1484, -57, -1649, -3138, -4423, -5530, -6514, -7389, -8118, -8642, -8939, -9041, -8978, -8775, -8479, -8172, -7908, -7681, -7468, -7270, -7138, -7143, -7321, -7650, -8079, -8591, -9217, -9999, -10948, -12022, -13161, -14335, -15558, -16822, -18118, -19428, -20736, -22041, -23292, -24398, -25342, -26184, -27006, -27848, -28652, -29354, -29943, -30471, -31005, -31561, -32065, -32441, -32667, -32762, -32754, -32643, -32390, -31963, -31370, -30666, -29878, -29027, -28254, -27730, -27455, -27118, -26378, -25204, -23850, -22554, -21322, -20054, -18646, -17113, -15500, -13801, -12044, -10325, -8742, -7301, -5858, -4252, -2514, -785};