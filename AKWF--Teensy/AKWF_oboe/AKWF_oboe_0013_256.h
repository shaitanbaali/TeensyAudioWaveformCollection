/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0013 256 samples */
 
const int16_t AKWF_oboe_0013_256_DATA [256] = 
{1494, 4254, 7045, 9919, 13118, 16298, 19275, 22189, 24894, 27232, 29124, 30660, 31718, 32244, 32650, 32728, 32373, 31886, 31269, 30481, 29501, 28361, 27011, 25391, 23640, 21488, 18869, 16204, 13296, 10052, 6636, 3173, -251, -3549, -6718, -9601, -12041, -13940, -15401, -16375, -16700, -16563, -16059, -15177, -13916, -12385, -10719, -8973, -7204, -5386, -3547, -1791, -94, 1598, 3231, 4726, 6026, 7219, 8274, 9132, 9773, 10212, 10515, 10715, 10663, 10350, 9810, 9026, 7997, 6728, 5256, 3586, 1754, -178, -2186, -4247, -6307, -8358, -10362, -12237, -13882, -15333, -16537, -17393, -17929, -18186, -18193, -17965, -17521, -16907, -16167, -15346, -14418, -13348, -12260, -11176, -10036, -8781, -7544, -6356, -5055, -3798, -2576, -1271, -36, 1119, 2274, 3475, 4472, 5219, 5950, 6569, 6993, 7217, 7277, 7256, 7192, 7026, 6656, 6166, 5794, 5321, 4674, 3993, 3385, 2796, 2151, 1497, 888, 343, -166, -699, -1165, -1444, -1681, -1918, -2127, -2305, -2424, -2503, -2603, -2664, -2613, -2429, -2213, -1980, -1677, -1246, -806, -409, 74, 554, 1000, 1448, 1831, 2135, 2384, 2605, 2724, 2719, 2678, 2575, 2419, 2250, 2002, 1709, 1437, 1149, 823, 461, 94, -272, -660, -1088, -1506, -1920, -2361, -2802, -3220, -3615, -4010, -4323, -4532, -4687, -4796, -4838, -4796, -4723, -4603, -4432, -4290, -4129, -3942, -3796, -3701, -3617, -3500, -3366, -3253, -3197, -3206, -3174, -3082, -3012, -2893, -2725, -2587, -2624, -2653, -2545, -2515, -2397, -2144, -1935, -1759, -1598, -1439, -1225, -1007, -843, -694, -615, -610, -607, -603, -659, -845, -1110, -1374, -1599, -1836, -2152, -2593, -3154, -3785, -4442, -5123, -5840, -6594, -7371, -8150, -8928, -9644, -10192, -10594, -10865, -10973, -10816, -10436, -9874, -9015, -7904, -6553, -4877, -3049, -922};