/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0006 256 samples */
 
const int16_t AKWF_oboe_0006_256_DATA [256] = 
{78, 341, 594, 848, 1098, 1348, 1594, 1839, 2083, 2324, 2564, 2805, 3050, 3300, 3559, 3828, 4111, 4407, 4719, 5056, 5423, 5824, 6266, 6749, 7276, 7846, 8464, 9126, 9832, 10586, 11385, 12226, 13113, 14040, 15004, 16012, 17055, 18128, 19225, 20329, 21432, 22536, 23620, 24688, 25730, 26726, 27682, 28584, 29418, 30186, 30878, 31483, 32005, 32435, 32730, 32772, 32765, 32765, 32773, 32724, 32415, 31971, 31424, 30769, 30009, 29147, 28192, 27133, 25985, 24749, 23435, 22061, 20638, 19164, 17663, 16130, 14573, 13019, 11449, 9880, 8327, 6784, 5266, 3790, 2342, 946, -389, -1667, -2872, -4014, -5093, -6103, -7045, -7922, -8726, -9468, -10144, -10755, -11308, -11803, -12242, -12631, -12973, -13273, -13538, -13773, -13982, -14168, -14338, -14499, -14664, -14839, -15030, -15242, -15474, -15726, -16001, -16296, -16612, -16949, -17305, -17681, -18076, -18483, -18903, -19332, -19764, -20203, -20641, -21074, -21496, -21903, -22292, -22663, -23008, -23323, -23604, -23844, -24042, -24197, -24302, -24359, -24365, -24319, -24220, -24067, -23859, -23593, -23268, -22877, -22422, -21903, -21320, -20683, -19991, -19247, -18460, -17629, -16757, -15854, -14923, -13978, -13028, -12084, -11152, -10226, -9306, -8393, -7476, -6559, -5636, -4711, -3793, -2892, -2015, -1166, -352, 429, 1173, 1875, 2526, 3127, 3673, 4159, 4587, 4957, 5282, 5569, 5824, 6053, 6252, 6420, 6555, 6654, 6714, 6734, 6714, 6657, 6562, 6427, 6249, 6027, 5766, 5462, 5120, 4750, 4357, 3950, 3537, 3113, 2683, 2249, 1810, 1360, 906, 445, -16, -473, -923, -1359, -1776, -2168, -2537, -2877, -3196, -3489, -3760, -4008, -4233, -4430, -4602, -4741, -4846, -4915, -4947, -4944, -4906, -4831, -4721, -4576, -4399, -4187, -3944, -3678, -3394, -3100, -2802, -2502, -2199, -1898, -1598, -1304, -1012, -727, -451, -177};