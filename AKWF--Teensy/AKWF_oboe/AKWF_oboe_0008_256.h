/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0008 256 samples */
 
const int16_t AKWF_oboe_0008_256_DATA [256] = 
{233, 1092, 1949, 2813, 3676, 4542, 5400, 6251, 7099, 7943, 8778, 9615, 10444, 11277, 12114, 12949, 13780, 14609, 15432, 16252, 17069, 17875, 18674, 19461, 20241, 21007, 21762, 22499, 23214, 23909, 24584, 25238, 25872, 26484, 27072, 27644, 28195, 28725, 29231, 29712, 30165, 30588, 30974, 31325, 31638, 31915, 32154, 32358, 32525, 32657, 32750, 32770, 32767, 32767, 32769, 32712, 32597, 32452, 32273, 32063, 31823, 31553, 31251, 30921, 30562, 30174, 29762, 29322, 28859, 28376, 27875, 27363, 26840, 26303, 25760, 25207, 24647, 24085, 23512, 22934, 22352, 21765, 21176, 20590, 19997, 19405, 18815, 18223, 17639, 17055, 16469, 15887, 15311, 14739, 14170, 13605, 13042, 12483, 11928, 11372, 10816, 10260, 9700, 9144, 8585, 8017, 7443, 6855, 6251, 5638, 5002, 4349, 3683, 3002, 2308, 1606, 889, 163, -570, -1316, -2066, -2826, -3599, -4378, -5163, -5955, -6747, -7543, -8339, -9131, -9917, -10693, -11458, -12217, -12962, -13688, -14394, -15072, -15726, -16353, -16953, -17517, -18054, -18561, -19034, -19475, -19884, -20257, -20599, -20907, -21181, -21423, -21631, -21807, -21952, -22066, -22149, -22206, -22234, -22239, -22220, -22178, -22114, -22032, -21934, -21821, -21697, -21563, -21424, -21278, -21128, -20974, -20818, -20661, -20504, -20350, -20198, -20051, -19908, -19773, -19647, -19531, -19424, -19330, -19248, -19177, -19119, -19074, -19040, -19020, -19010, -19012, -19027, -19052, -19088, -19132, -19183, -19242, -19309, -19381, -19456, -19530, -19603, -19672, -19734, -19788, -19834, -19871, -19895, -19910, -19910, -19896, -19866, -19820, -19759, -19680, -19583, -19470, -19339, -19191, -19025, -18838, -18634, -18411, -18170, -17911, -17632, -17336, -17023, -16692, -16335, -15958, -15559, -15135, -14692, -14223, -13729, -13215, -12674, -12112, -11531, -10923, -10293, -9643, -8974, -8284, -7578, -6854, -6115, -5367, -4605, -3826, -3036, -2235, -1421, -584};