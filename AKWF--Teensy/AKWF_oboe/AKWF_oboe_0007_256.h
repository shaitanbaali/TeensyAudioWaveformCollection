/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0007 256 samples */
 
const int16_t AKWF_oboe_0007_256_DATA [256] = 
{500, 1357, 2173, 2967, 3738, 4483, 5209, 5909, 6586, 7238, 7861, 8458, 9032, 9577, 10099, 10603, 11089, 11564, 12032, 12489, 12941, 13383, 13812, 14234, 14641, 15035, 15416, 15783, 16138, 16484, 16817, 17141, 17455, 17757, 18052, 18335, 18606, 18865, 19109, 19338, 19555, 19757, 19944, 20117, 20275, 20417, 20545, 20657, 20753, 20836, 20905, 20964, 21011, 21049, 21078, 21097, 21105, 21102, 21086, 21055, 21011, 20953, 20883, 20803, 20716, 20624, 20526, 20426, 20324, 20221, 20120, 20025, 19936, 19858, 19794, 19742, 19702, 19674, 19656, 19645, 19641, 19642, 19651, 19667, 19694, 19735, 19794, 19872, 19969, 20085, 20216, 20362, 20520, 20688, 20865, 21049, 21240, 21434, 21624, 21808, 21979, 22135, 22271, 22387, 22484, 22559, 22615, 22652, 22667, 22660, 22626, 22569, 22488, 22383, 22256, 22105, 21931, 21733, 21506, 21242, 20932, 20574, 20160, 19690, 19171, 18601, 17980, 17319, 16615, 15876, 15105, 14293, 13448, 12569, 11656, 10720, 9756, 8762, 7749, 6711, 5654, 4591, 3505, 2405, 1296, 178, -938, -2043, -3146, -4229, -5289, -6322, -7338, -8326, -9295, -10241, -11162, -12061, -12939, -13792, -14618, -15414, -16173, -16904, -17599, -18261, -18890, -19487, -20054, -20596, -21113, -21606, -22072, -22513, -22940, -23352, -23754, -24152, -24546, -24936, -25325, -25701, -26059, -26396, -26706, -26987, -27243, -27480, -27707, -27934, -28167, -28416, -28681, -28959, -29247, -29539, -29832, -30119, -30398, -30664, -30922, -31167, -31401, -31624, -31836, -32033, -32218, -32386, -32532, -32648, -32729, -32767, -32761, -32708, -32606, -32457, -32265, -32029, -31748, -31427, -31065, -30658, -30211, -29716, -29174, -28589, -27954, -27279, -26559, -25797, -24996, -24157, -23283, -22381, -21445, -20479, -19489, -18479, -17453, -16415, -15366, -14307, -13244, -12180, -11123, -10067, -9023, -7990, -6970, -5971, -4987, -4018, -3070, -2140, -1238, -338};