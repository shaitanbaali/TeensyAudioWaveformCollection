/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0005 256 samples */
 
const int16_t AKWF_oboe_0005_256_DATA [256] = 
{332, 923, 1528, 2153, 2801, 3479, 4202, 4971, 5778, 6592, 7380, 8128, 8842, 9539, 10251, 10999, 11774, 12580, 13400, 14222, 15047, 15869, 16671, 17450, 18188, 18884, 19559, 20221, 20892, 21577, 22259, 22918, 23542, 24124, 24666, 25185, 25694, 26201, 26706, 27190, 27636, 28030, 28365, 28646, 28880, 29067, 29207, 29299, 29346, 29354, 29328, 29266, 29153, 28969, 28701, 28341, 27905, 27422, 26913, 26395, 25854, 25279, 24658, 23982, 23250, 22477, 21659, 20806, 19922, 18994, 18017, 16978, 15869, 14695, 13460, 12153, 10785, 9342, 7851, 6336, 4838, 3341, 1842, 329, -1226, -2821, -4438, -6089, -7741, -9387, -11032, -12642, -14213, -15731, -17180, -18561, -19884, -21140, -22348, -23495, -24580, -25611, -26587, -27510, -28368, -29139, -29802, -30358, -30817, -31206, -31550, -31857, -32121, -32347, -32532, -32683, -32768, -32765, -32772, -32735, -32544, -32263, -31910, -31498, -31036, -30520, -29947, -29313, -28614, -27857, -27058, -26219, -25360, -24481, -23591, -22691, -21783, -20873, -19963, -19047, -18125, -17188, -16241, -15279, -14292, -13276, -12227, -11155, -10081, -9034, -8020, -7042, -6101, -5213, -4380, -3608, -2877, -2150, -1399, -618, 185, 997, 1798, 2590, 3367, 4137, 4900, 5653, 6396, 7119, 7802, 8431, 8997, 9502, 9958, 10371, 10745, 11078, 11351, 11548, 11656, 11676, 11627, 11534, 11425, 11305, 11166, 11001, 10799, 10553, 10270, 9951, 9602, 9223, 8819, 8389, 7939, 7471, 6993, 6508, 6006, 5479, 4929, 4359, 3795, 3271, 2800, 2387, 2021, 1676, 1332, 990, 645, 296, -61, -430, -808, -1191, -1570, -1939, -2297, -2640, -2958, -3250, -3512, -3744, -3945, -4117, -4260, -4376, -4466, -4535, -4584, -4615, -4630, -4633, -4626, -4612, -4587, -4555, -4511, -4454, -4383, -4296, -4185, -4052, -3896, -3706, -3464, -3154, -2765, -2312, -1812, -1290, -764, -210};