/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0012 256 samples */
 
const int16_t AKWF_oboe_0012_256_DATA [256] = 
{978, 2961, 5133, 7572, 10105, 12712, 15438, 18191, 20768, 23152, 25353, 27363, 29015, 30346, 31433, 32215, 32649, 32772, 32655, 32333, 31720, 30819, 29714, 28431, 26916, 25117, 23040, 20736, 18183, 15421, 12561, 9684, 6851, 4092, 1464, -905, -2994, -4873, -6381, -7502, -8340, -9044, -9564, -9881, -10036, -10096, -10049, -9848, -9483, -9020, -8488, -7855, -7065, -6207, -5279, -4241, -3134, -2006, -905, 115, 1048, 1870, 2540, 3021, 3336, 3487, 3442, 3165, 2761, 2244, 1587, 858, 15, -925, -1872, -2888, -3935, -4953, -5947, -6973, -7933, -8750, -9571, -10363, -11012, -11469, -11926, -12294, -12499, -12618, -12603, -12530, -12434, -12186, -11812, -11372, -10897, -10375, -9763, -9105, -8488, -7790, -7004, -6164, -5297, -4357, -3388, -2440, -1466, -481, 469, 1361, 2222, 3041, 3796, 4459, 5057, 5634, 6193, 6663, 7115, 7580, 8028, 8389, 8658, 8814, 8810, 8683, 8437, 8057, 7545, 6931, 6208, 5399, 4650, 3875, 3030, 2220, 1514, 828, 158, -368, -855, -1308, -1703, -2071, -2380, -2663, -2949, -3109, -3185, -3263, -3330, -3298, -3152, -2973, -2839, -2588, -2233, -1877, -1481, -1083, -671, -218, 131, 421, 720, 991, 1115, 1152, 1214, 1259, 1238, 1162, 1072, 985, 829, 615, 434, 214, -41, -301, -589, -840, -1060, -1297, -1524, -1758, -2016, -2298, -2648, -2985, -3276, -3607, -3977, -4331, -4624, -4899, -5175, -5394, -5532, -5744, -5926, -6014, -6086, -6080, -6010, -5907, -5756, -5588, -5451, -5317, -5026, -4691, -4448, -4286, -4065, -3841, -3690, -3563, -3406, -3213, -3022, -2867, -2712, -2554, -2406, -2218, -1995, -1837, -1844, -1862, -1890, -1965, -2017, -2136, -2356, -2622, -2877, -3144, -3431, -3715, -4027, -4430, -4883, -5225, -5553, -5835, -5956, -5910, -5716, -5299, -4554, -3538, -2298, -762};