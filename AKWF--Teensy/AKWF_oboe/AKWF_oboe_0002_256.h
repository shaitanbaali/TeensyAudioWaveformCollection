/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oboe_0002 256 samples */
 
const int16_t AKWF_oboe_0002_256_DATA [256] = 
{1126, 3594, 6081, 8639, 11485, 14445, 17162, 19580, 22147, 24531, 26428, 27982, 29369, 30609, 31580, 32193, 32533, 32732, 32788, 32595, 31977, 31322, 30426, 29200, 27805, 26124, 24178, 22077, 19706, 17000, 14032, 11059, 8037, 4949, 1959, -771, -3218, -5466, -7395, -8996, -10307, -11379, -12134, -12503, -12497, -12098, -11293, -10110, -8682, -7057, -5254, -3514, -1881, -348, 1034, 2209, 3185, 4039, 4812, 5511, 6129, 6646, 7121, 7608, 7971, 8169, 8218, 8144, 7877, 7351, 6550, 5440, 4049, 2444, 649, -1318, -3404, -5477, -7492, -9413, -11166, -12768, -14172, -15269, -16212, -17011, -17580, -17846, -17916, -17855, -17544, -17044, -16382, -15497, -14496, -13533, -12659, -11533, -10327, -9312, -8347, -7179, -5808, -4587, -3331, -1963, -593, 821, 2134, 3195, 4198, 5225, 6197, 6868, 7426, 7979, 8392, 8608, 8589, 8351, 8082, 7710, 7107, 6383, 5758, 5260, 4647, 4049, 3538, 3045, 2536, 2000, 1457, 884, 364, -55, -506, -919, -1239, -1509, -1709, -1885, -2090, -2182, -2149, -2049, -1906, -1676, -1323, -872, -463, -97, 346, 782, 1162, 1487, 1741, 1983, 2226, 2341, 2391, 2414, 2348, 2243, 2098, 1878, 1625, 1369, 1101, 767, 353, -97, -483, -897, -1394, -1908, -2416, -2907, -3368, -3828, -4244, -4589, -4957, -5219, -5347, -5507, -5608, -5609, -5554, -5515, -5450, -5290, -5108, -4903, -4658, -4404, -4158, -3928, -3718, -3575, -3504, -3450, -3256, -3111, -3202, -3318, -3382, -3390, -3370, -3321, -3244, -3169, -3182, -3228, -3207, -3144, -3049, -2936, -2838, -2760, -2705, -2680, -2648, -2634, -2683, -2751, -2860, -3035, -3242, -3436, -3622, -3864, -4140, -4417, -4681, -5015, -5396, -5760, -6187, -6648, -7088, -7520, -7930, -8299, -8600, -8802, -8828, -8638, -8408, -8014, -7288, -6419, -5456, -4274, -2653, -803};