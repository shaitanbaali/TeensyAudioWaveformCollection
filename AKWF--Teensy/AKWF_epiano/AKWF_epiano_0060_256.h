/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0060 256 samples */
 
const int16_t AKWF_epiano_0060_256_DATA [256] = 
{1073, 3140, 5162, 7168, 9137, 11078, 12954, 14792, 16572, 18273, 19890, 21424, 22875, 24232, 25499, 26674, 27737, 28695, 29556, 30321, 30969, 31523, 31967, 32318, 32565, 32710, 32766, 32730, 32613, 32408, 32127, 31756, 31327, 30819, 30247, 29623, 28938, 28201, 27415, 26591, 25727, 24834, 23900, 22945, 21981, 20985, 19984, 18972, 17969, 16954, 15935, 14934, 13944, 12965, 12013, 11082, 10175, 9289, 8446, 7632, 6862, 6122, 5438, 4802, 4209, 3673, 3189, 2754, 2384, 2088, 1838, 1663, 1554, 1511, 1533, 1618, 1762, 1982, 2256, 2593, 2978, 3417, 3905, 4430, 4997, 5589, 6202, 6846, 7502, 8173, 8848, 9520, 10190, 10857, 11508, 12145, 12772, 13368, 13944, 14514, 15044, 15549, 16029, 16478, 16906, 17300, 17663, 17990, 18292, 18555, 18796, 19003, 19179, 19328, 19435, 19512, 19563, 19567, 19546, 19490, 19406, 19278, 19123, 18940, 18716, 18453, 18153, 17825, 17452, 17053, 16615, 16138, 15623, 15077, 14489, 13881, 13238, 12554, 11832, 11085, 10308, 9489, 8649, 7783, 6875, 5957, 5018, 4042, 3061, 2059, 1045, 23, -998, -2020, -3056, -4074, -5079, -6067, -7043, -7987, -8922, -9822, -10688, -11528, -12333, -13108, -13842, -14546, -15212, -15849, -16446, -17017, -17564, -18082, -18559, -19025, -19466, -19893, -20288, -20678, -21056, -21423, -21775, -22115, -22460, -22791, -23124, -23456, -23791, -24119, -24437, -24768, -25102, -25447, -25778, -26110, -26453, -26793, -27134, -27477, -27810, -28140, -28471, -28810, -29138, -29464, -29774, -30084, -30380, -30663, -30935, -31189, -31430, -31650, -31849, -32036, -32201, -32337, -32453, -32548, -32616, -32659, -32673, -32654, -32608, -32523, -32405, -32253, -32051, -31804, -31519, -31186, -30795, -30340, -29828, -29253, -28601, -27878, -27083, -26196, -25220, -24159, -23014, -21777, -20454, -19028, -17517, -15923, -14253, -12516, -10697, -8828, -6905, -4934, -2958, -902};