/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0024 256 samples */
 
const int16_t AKWF_epiano_0024_256_DATA [256] = 
{969, 3212, 5488, 7809, 10139, 12445, 14702, 16877, 18942, 20885, 22680, 24317, 25805, 27126, 28291, 29301, 30161, 30880, 31472, 31937, 32293, 32551, 32707, 32767, 32761, 32690, 32544, 32343, 32086, 31781, 31431, 31044, 30627, 30178, 29706, 29210, 28694, 28164, 27620, 27065, 26499, 25926, 25348, 24765, 24175, 23584, 22988, 22389, 21786, 21180, 20567, 19950, 19327, 18695, 18059, 17413, 16760, 16100, 15430, 14757, 14085, 13404, 12723, 12046, 11373, 10710, 10055, 9409, 8778, 8160, 7559, 6987, 6435, 5908, 5409, 4951, 4530, 4141, 3789, 3479, 3203, 2951, 2721, 2506, 2300, 2093, 1884, 1670, 1444, 1203, 954, 701, 438, 171, -89, -344, -591, -818, -1025, -1211, -1368, -1495, -1595, -1666, -1704, -1708, -1687, -1639, -1562, -1460, -1338, -1197, -1039, -864, -677, -480, -282, -78, 130, 330, 528, 722, 903, 1073, 1230, 1373, 1496, 1598, 1680, 1741, 1779, 1786, 1767, 1727, 1656, 1552, 1415, 1249, 1051, 815, 540, 230, -111, -496, -921, -1386, -1887, -2429, -3010, -3630, -4290, -4989, -5728, -6509, -7333, -8193, -9087, -10016, -10974, -11947, -12936, -13924, -14900, -15856, -16777, -17647, -18455, -19189, -19831, -20366, -20788, -21089, -21254, -21285, -21190, -20964, -20619, -20171, -19634, -19028, -18365, -17676, -16977, -16275, -15594, -14952, -14348, -13796, -13298, -12864, -12493, -12183, -11936, -11756, -11641, -11583, -11583, -11640, -11748, -11911, -12118, -12364, -12646, -12963, -13312, -13682, -14075, -14489, -14919, -15363, -15811, -16258, -16705, -17140, -17563, -17970, -18352, -18708, -19037, -19335, -19599, -19826, -20010, -20154, -20261, -20325, -20349, -20332, -20272, -20174, -20040, -19869, -19661, -19423, -19152, -18851, -18524, -18176, -17801, -17397, -16968, -16510, -16014, -15481, -14886, -14224, -13484, -12645, -11698, -10629, -9414, -8050, -6533, -4857, -3051, -1051};