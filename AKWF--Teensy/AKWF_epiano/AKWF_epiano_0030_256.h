/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0030 256 samples */
 
const int16_t AKWF_epiano_0030_256_DATA [256] = 
{2050, 5684, 9378, 13075, 16594, 19825, 22688, 25112, 27133, 28764, 30037, 31006, 31717, 32212, 32533, 32713, 32770, 32730, 32603, 32404, 32142, 31819, 31441, 31014, 30540, 30021, 29459, 28860, 28229, 27565, 26875, 26156, 25407, 24638, 23843, 23017, 22176, 21311, 20430, 19550, 18658, 17761, 16866, 15966, 15067, 14168, 13261, 12348, 11435, 10518, 9611, 8707, 7812, 6930, 6063, 5206, 4370, 3540, 2721, 1918, 1127, 356, -393, -1120, -1823, -2494, -3138, -3750, -4339, -4904, -5445, -5958, -6442, -6896, -7315, -7703, -8057, -8382, -8681, -8957, -9195, -9373, -9463, -9429, -9253, -8928, -8470, -7924, -7346, -6775, -6255, -5813, -5458, -5193, -5004, -4878, -4801, -4761, -4746, -4741, -4741, -4737, -4727, -4708, -4672, -4628, -4568, -4493, -4405, -4302, -4187, -4057, -3918, -3768, -3609, -3448, -3282, -3113, -2946, -2782, -2619, -2464, -2318, -2184, -2066, -1970, -1895, -1845, -1824, -1830, -1863, -1928, -2019, -2132, -2276, -2442, -2633, -2847, -3085, -3346, -3628, -3928, -4245, -4576, -4915, -5264, -5618, -5972, -6325, -6679, -7031, -7383, -7740, -8092, -8447, -8806, -9165, -9524, -9881, -10230, -10569, -10887, -11175, -11416, -11591, -11679, -11644, -11443, -11030, -10357, -9411, -8193, -6747, -5167, -3533, -1947, -480, 829, 1953, 2881, 3625, 4198, 4623, 4917, 5092, 5161, 5140, 5032, 4845, 4583, 4255, 3868, 3417, 2919, 2373, 1780, 1156, 490, -215, -950, -1721, -2522, -3337, -4176, -5021, -5841, -6650, -7441, -8209, -8959, -9679, -10369, -11028, -11647, -12230, -12770, -13262, -13704, -14096, -14438, -14733, -14982, -15189, -15355, -15482, -15570, -15629, -15656, -15651, -15623, -15572, -15499, -15410, -15308, -15192, -15070, -14941, -14803, -14662, -14518, -14368, -14216, -14057, -13891, -13714, -13509, -13264, -12951, -12528, -11943, -11123, -9995, -8480, -6522, -4098, -1133};