/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0065 256 samples */
 
const int16_t AKWF_epiano_0065_256_DATA [256] = 
{821, 2446, 4023, 5567, 7062, 8506, 9891, 11221, 12488, 13695, 14839, 15906, 16909, 17848, 18716, 19514, 20244, 20925, 21536, 22078, 22573, 23008, 23382, 23709, 23989, 24213, 24395, 24531, 24617, 24668, 24684, 24656, 24598, 24506, 24383, 24234, 24064, 23872, 23663, 23435, 23189, 22930, 22662, 22387, 22105, 21821, 21535, 21257, 20988, 20722, 20465, 20221, 19979, 19737, 19497, 19249, 18985, 18699, 18382, 18037, 17662, 17243, 16783, 16279, 15731, 15140, 14512, 13848, 13158, 12440, 11700, 10940, 10168, 9386, 8605, 7837, 7076, 6325, 5595, 4894, 4223, 3587, 2982, 2420, 1904, 1437, 1023, 666, 357, 105, -86, -217, -289, -302, -254, -147, 14, 233, 505, 823, 1196, 1624, 2090, 2593, 3145, 3745, 4374, 5030, 5725, 6446, 7197, 7968, 8759, 9570, 10388, 11217, 12056, 12901, 13737, 14565, 15389, 16201, 16995, 17758, 18481, 19172, 19818, 20409, 20940, 21395, 21770, 22067, 22275, 22385, 22389, 22290, 22085, 21768, 21335, 20788, 20129, 19363, 18478, 17488, 16400, 15211, 13942, 12595, 11175, 9702, 8189, 6643, 5091, 3532, 1986, 465, -1020, -2459, -3850, -5190, -6467, -7680, -8829, -9907, -10925, -11872, -12754, -13566, -14316, -15005, -15636, -16214, -16735, -17202, -17629, -18013, -18358, -18672, -18958, -19214, -19450, -19674, -19896, -20114, -20326, -20544, -20771, -21008, -21257, -21525, -21814, -22114, -22429, -22772, -23129, -23493, -23873, -24260, -24656, -25066, -25474, -25877, -26275, -26674, -27063, -27423, -27767, -28103, -28423, -28729, -29019, -29291, -29559, -29825, -30076, -30325, -30577, -30823, -31072, -31324, -31576, -31822, -32051, -32267, -32459, -32612, -32724, -32769, -32749, -32644, -32441, -32142, -31735, -31211, -30576, -29832, -28981, -28026, -26973, -25823, -24593, -23280, -21895, -20453, -18956, -17403, -15811, -14185, -12531, -10864, -9170, -7477, -5786, -4099, -2432, -755};