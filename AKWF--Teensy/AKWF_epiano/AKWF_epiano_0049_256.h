/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0049 256 samples */
 
const int16_t AKWF_epiano_0049_256_DATA [256] = 
{1765, 5129, 8435, 11666, 14744, 17621, 20257, 22608, 24702, 26515, 28054, 29343, 30390, 31217, 31850, 32303, 32598, 32748, 32767, 32677, 32475, 32177, 31794, 31327, 30783, 30172, 29495, 28764, 27987, 27158, 26295, 25403, 24488, 23567, 22641, 21717, 20807, 19918, 19060, 18243, 17460, 16723, 16032, 15387, 14793, 14241, 13727, 13250, 12808, 12391, 11998, 11623, 11266, 10927, 10604, 10296, 10005, 9730, 9469, 9219, 8983, 8758, 8538, 8327, 8126, 7935, 7762, 7612, 7491, 7402, 7349, 7326, 7325, 7337, 7337, 7301, 7204, 7018, 6723, 6296, 5728, 5017, 4173, 3203, 2129, 978, -216, -1425, -2620, -3775, -4857, -5843, -6715, -7458, -8066, -8530, -8850, -9028, -9064, -8968, -8749, -8412, -7971, -7434, -6817, -6120, -5363, -4548, -3687, -2793, -1871, -922, 37, 1005, 1976, 2935, 3891, 4833, 5755, 6656, 7530, 8374, 9195, 9985, 10747, 11475, 12176, 12846, 13490, 14098, 14668, 15200, 15690, 16134, 16528, 16865, 17139, 17348, 17486, 17545, 17520, 17406, 17191, 16864, 16417, 15831, 15097, 14211, 13148, 11910, 10499, 8905, 7151, 5252, 3197, 1034, -1221, -3558, -5922, -8313, -10708, -13069, -15381, -17625, -19760, -21805, -23718, -25477, -27069, -28452, -29604, -30502, -31108, -31406, -31380, -31036, -30383, -29449, -28267, -26901, -25378, -23758, -22090, -20418, -18788, -17238, -15769, -14418, -13196, -12103, -11156, -10340, -9651, -9092, -8657, -8337, -8131, -8032, -8035, -8140, -8346, -8645, -9043, -9537, -10113, -10765, -11491, -12273, -13110, -13990, -14897, -15817, -16735, -17637, -18515, -19351, -20133, -20847, -21485, -22045, -22517, -22898, -23184, -23371, -23464, -23465, -23376, -23206, -22966, -22664, -22318, -21943, -21557, -21178, -20821, -20501, -20225, -20003, -19833, -19708, -19617, -19543, -19462, -19344, -19155, -18852, -18392, -17725, -16806, -15591, -14052, -12158, -9919, -7350, -4502, -1371};