/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0014 256 samples */
 
const int16_t AKWF_epiano_0014_256_DATA [256] = 
{281, 975, 1927, 3079, 4410, 5801, 7183, 8350, 9312, 10064, 10662, 11138, 11585, 12105, 12782, 13714, 14816, 16072, 17286, 18369, 19121, 19631, 19843, 19941, 20017, 20168, 20488, 21011, 21759, 22599, 23535, 24328, 24907, 25171, 25171, 24983, 24814, 24753, 24946, 25384, 26038, 26831, 27668, 28488, 29116, 29505, 29593, 29459, 29245, 29109, 29213, 29574, 30180, 30892, 31613, 32241, 32650, 32523, 32438, 32137, 31648, 31178, 30842, 30799, 30982, 31390, 31774, 32051, 32100, 31895, 31446, 30778, 29986, 29119, 28377, 27811, 27526, 27440, 27512, 27425, 27145, 26524, 25645, 24576, 23333, 22070, 20877, 19874, 19089, 18517, 18115, 17739, 17166, 16317, 15131, 13723, 12160, 10562, 9100, 7814, 6792, 5951, 5304, 4719, 4052, 3140, 1911, 422, -1283, -2996, -4650, -6050, -7230, -8163, -8963, -9679, -10467, -11425, -12610, -14089, -15744, -17489, -19137, -20593, -21700, -22547, -23183, -23714, -24269, -24895, -25694, -26658, -27787, -28926, -30028, -30905, -31509, -31741, -31723, -31542, -31326, -31196, -31136, -31211, -31356, -31545, -31610, -31529, -31172, -30529, -29634, -28590, -27481, -26449, -25508, -24677, -23945, -23246, -22512, -21616, -20612, -19443, -18123, -16717, -15280, -13945, -12729, -11684, -10766, -9945, -9130, -8299, -7432, -6509, -5569, -4620, -3746, -2978, -2359, -1924, -1645, -1495, -1453, -1419, -1385, -1314, -1260, -1239, -1294, -1445, -1721, -2140, -2669, -3259, -3883, -4542, -5185, -5827, -6458, -7116, -7810, -8553, -9371, -10243, -11137, -12022, -12849, -13635, -14373, -15054, -15670, -16245, -16764, -17226, -17712, -18210, -18707, -19238, -19712, -20117, -20450, -20702, -20873, -20939, -20929, -20846, -20763, -20660, -20588, -20547, -20491, -20363, -20123, -19728, -19199, -18529, -17713, -16876, -16032, -15209, -14451, -13781, -13157, -12509, -11798, -10925, -9884, -8663, -7361, -6018, -4757, -3574, -2571, -1720, -980, -312};