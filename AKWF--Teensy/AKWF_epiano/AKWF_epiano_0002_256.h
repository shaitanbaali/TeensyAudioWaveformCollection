/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0002 256 samples */
 
const int16_t AKWF_epiano_0002_256_DATA [256] = 
{294, 756, 1183, 1739, 2305, 2791, 3288, 3789, 4262, 4767, 5277, 5749, 6250, 6791, 7287, 7734, 8225, 8781, 9304, 9756, 10246, 10808, 11322, 11770, 12264, 12798, 13287, 13768, 14292, 14817, 15313, 15785, 16260, 16784, 17319, 17782, 18244, 18770, 19267, 19718, 20155, 20535, 20965, 21556, 22067, 22370, 22754, 23287, 23699, 24013, 24436, 24855, 25140, 25463, 25870, 26166, 26398, 26749, 27081, 27280, 27540, 27842, 27963, 28049, 28284, 28448, 28444, 28504, 28599, 28566, 28511, 28474, 28329, 28156, 28014, 27753, 27440, 27196, 26821, 26286, 25843, 25402, 24760, 24069, 23423, 22699, 21891, 21036, 20131, 19237, 18309, 17247, 16159, 15127, 14022, 12831, 11696, 10615, 9496, 8360, 7255, 6166, 5078, 4020, 3049, 2168, 1310, 460, -305, -976, -1591, -2133, -2583, -2972, -3320, -3623, -3820, -3873, -3881, -3905, -3830, -3636, -3465, -3293, -2997, -2625, -2273, -1927, -1561, -1151, -717, -328, 42, 478, 892, 1216, 1570, 1969, 2266, 2471, 2690, 2881, 2992, 3059, 3071, 3011, 2908, 2717, 2423, 2119, 1774, 1267, 685, 133, -511, -1310, -2132, -2953, -3868, -4891, -5948, -7021, -8161, -9382, -10621, -11842, -13083, -14376, -15669, -16903, -18129, -19401, -20642, -21797, -22952, -24116, -25172, -26118, -27051, -27963, -28770, -29484, -30150, -30737, -31226, -31672, -32071, -32367, -32567, -32692, -32743, -32764, -32760, -32656, -32468, -32285, -32058, -31715, -31356, -31013, -30595, -30128, -29687, -29209, -28673, -28136, -27592, -27050, -26517, -25930, -25309, -24746, -24180, -23542, -22920, -22369, -21786, -21125, -20492, -19936, -19355, -18713, -18100, -17520, -16897, -16279, -15729, -15178, -14580, -13983, -13417, -12867, -12315, -11744, -11163, -10620, -10090, -9523, -8975, -8486, -7958, -7374, -6856, -6384, -5853, -5303, -4806, -4337, -3832, -3271, -2745, -2297, -1803, -1251, -763, -261};