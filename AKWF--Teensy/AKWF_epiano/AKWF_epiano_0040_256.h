/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0040 256 samples */
 
const int16_t AKWF_epiano_0040_256_DATA [256] = 
{1024, 3184, 5341, 7516, 9718, 11906, 14054, 16135, 18125, 20014, 21789, 23435, 24943, 26298, 27524, 28605, 29543, 30350, 31022, 31572, 32011, 32343, 32573, 32714, 32767, 32746, 32656, 32499, 32287, 32024, 31714, 31360, 30968, 30543, 30089, 29614, 29115, 28594, 28055, 27506, 26945, 26376, 25799, 25215, 24623, 24026, 23430, 22826, 22218, 21607, 20992, 20376, 19753, 19120, 18481, 17835, 17184, 16529, 15863, 15193, 14517, 13838, 13160, 12485, 11804, 11129, 10461, 9804, 9157, 8518, 7895, 7295, 6716, 6160, 5631, 5131, 4663, 4226, 3823, 3451, 3111, 2793, 2499, 2229, 1972, 1723, 1483, 1245, 1010, 774, 536, 298, 62, -174, -409, -632, -848, -1052, -1239, -1408, -1556, -1680, -1780, -1854, -1901, -1920, -1911, -1876, -1813, -1728, -1620, -1492, -1344, -1181, -1005, -817, -623, -421, -216, -10, 191, 386, 574, 756, 927, 1083, 1224, 1344, 1447, 1528, 1588, 1624, 1635, 1619, 1577, 1506, 1407, 1274, 1110, 912, 678, 409, 102, -241, -627, -1052, -1519, -2027, -2576, -3163, -3795, -4472, -5188, -5947, -6741, -7569, -8436, -9335, -10257, -11198, -12149, -13108, -14061, -15000, -15913, -16784, -17608, -18373, -19063, -19666, -20168, -20572, -20864, -21040, -21097, -21040, -20867, -20590, -20221, -19768, -19246, -18674, -18058, -17418, -16771, -16128, -15499, -14900, -14338, -13817, -13346, -12929, -12572, -12272, -12038, -11862, -11743, -11687, -11687, -11740, -11849, -12007, -12208, -12449, -12736, -13069, -13431, -13822, -14235, -14665, -15109, -15562, -16021, -16478, -16924, -17364, -17789, -18192, -18572, -18923, -19242, -19531, -19782, -19991, -20161, -20290, -20377, -20423, -20427, -20386, -20303, -20181, -20020, -19821, -19586, -19317, -19010, -18671, -18299, -17891, -17447, -16962, -16429, -15842, -15192, -14467, -13663, -12756, -11740, -10607, -9339, -7938, -6407, -4729, -2924, -951};