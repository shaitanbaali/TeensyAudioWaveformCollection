/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0066 256 samples */
 
const int16_t AKWF_epiano_0066_256_DATA [256] = 
{1038, 2625, 4141, 5631, 7104, 8558, 9986, 11370, 12729, 14051, 15331, 16574, 17772, 18928, 20038, 21102, 22120, 23093, 24012, 24883, 25710, 26491, 27226, 27907, 28535, 29124, 29671, 30171, 30618, 31018, 31380, 31699, 31979, 32213, 32404, 32552, 32660, 32733, 32766, 32762, 32724, 32645, 32537, 32396, 32224, 32020, 31789, 31527, 31238, 30924, 30586, 30229, 29853, 29458, 29042, 28610, 28164, 27702, 27225, 26737, 26230, 25714, 25184, 24642, 24083, 23513, 22927, 22333, 21732, 21115, 20486, 19854, 19216, 18569, 17920, 17268, 16612, 15959, 15311, 14664, 14026, 13394, 12770, 12167, 11576, 10995, 10430, 9884, 9361, 8861, 8379, 7919, 7486, 7076, 6693, 6333, 5997, 5686, 5401, 5139, 4905, 4697, 4515, 4352, 4211, 4091, 3993, 3914, 3857, 3818, 3792, 3779, 3783, 3796, 3819, 3855, 3895, 3938, 3983, 4032, 4078, 4116, 4145, 4164, 4176, 4173, 4147, 4106, 4040, 3944, 3826, 3677, 3492, 3271, 3015, 2725, 2392, 2017, 1601, 1139, 638, 102, -479, -1098, -1751, -2442, -3168, -3919, -4691, -5481, -6292, -7115, -7941, -8766, -9580, -10385, -11176, -11951, -12700, -13419, -14110, -14774, -15401, -15996, -16550, -17076, -17569, -18018, -18437, -18824, -19179, -19506, -19807, -20082, -20333, -20562, -20773, -20966, -21145, -21313, -21473, -21625, -21771, -21915, -22061, -22205, -22351, -22501, -22659, -22827, -23005, -23190, -23381, -23580, -23789, -24010, -24240, -24476, -24721, -24972, -25231, -25494, -25753, -26020, -26285, -26536, -26788, -27039, -27278, -27509, -27729, -27942, -28143, -28330, -28507, -28667, -28809, -28939, -29053, -29151, -29226, -29283, -29321, -29335, -29317, -29269, -29191, -29071, -28900, -28683, -28410, -28076, -27673, -27198, -26653, -26029, -25323, -24542, -23682, -22739, -21727, -20640, -19486, -18262, -16977, -15642, -14264, -12834, -11367, -9864, -8333, -6796, -5235, -3662, -2092, -488};