/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0057 256 samples */
 
const int16_t AKWF_epiano_0057_256_DATA [256] = 
{685, 2067, 3411, 4749, 6089, 7412, 8711, 9998, 11273, 12524, 13743, 14943, 16107, 17241, 18345, 19418, 20455, 21453, 22413, 23336, 24215, 25050, 25848, 26597, 27308, 27976, 28605, 29189, 29724, 30213, 30661, 31060, 31423, 31743, 32008, 32236, 32432, 32574, 32675, 32747, 32768, 32752, 32698, 32604, 32473, 32314, 32112, 31876, 31620, 31322, 30992, 30648, 30276, 29879, 29455, 29014, 28551, 28067, 27575, 27076, 26558, 26026, 25489, 24948, 24393, 23827, 23265, 22700, 22137, 21573, 21005, 20432, 19860, 19287, 18724, 18163, 17598, 17037, 16478, 15928, 15385, 14848, 14315, 13785, 13254, 12735, 12231, 11727, 11226, 10743, 10263, 9790, 9335, 8887, 8446, 8010, 7582, 7170, 6771, 6383, 6000, 5623, 5251, 4887, 4538, 4198, 3863, 3535, 3212, 2899, 2591, 2288, 1981, 1681, 1389, 1108, 817, 522, 237, -45, -329, -621, -916, -1209, -1510, -1818, -2131, -2442, -2763, -3097, -3428, -3765, -4117, -4482, -4859, -5238, -5632, -6038, -6456, -6883, -7315, -7752, -8204, -8662, -9117, -9589, -10068, -10535, -10999, -11467, -11937, -12395, -12840, -13278, -13708, -14122, -14515, -14895, -15259, -15604, -15936, -16253, -16545, -16812, -17060, -17289, -17503, -17705, -17886, -18050, -18203, -18344, -18470, -18583, -18689, -18789, -18884, -18972, -19054, -19128, -19199, -19274, -19354, -19439, -19523, -19604, -19691, -19785, -19886, -19993, -20106, -20225, -20350, -20484, -20631, -20784, -20935, -21097, -21274, -21454, -21634, -21817, -22007, -22204, -22409, -22612, -22814, -23016, -23218, -23422, -23621, -23802, -23981, -24160, -24323, -24473, -24610, -24733, -24843, -24932, -24995, -25037, -25055, -25047, -25010, -24944, -24838, -24688, -24502, -24274, -23996, -23670, -23291, -22861, -22382, -21842, -21246, -20601, -19884, -19108, -18296, -17416, -16476, -15490, -14451, -13370, -12240, -11067, -9862, -8617, -7338, -6044, -4720, -3381, -2036, -645};