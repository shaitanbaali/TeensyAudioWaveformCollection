/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0050 256 samples */
 
const int16_t AKWF_epiano_0050_256_DATA [256] = 
{744, 2750, 4777, 6845, 8920, 11009, 13072, 15086, 17039, 18902, 20668, 22332, 23875, 25289, 26576, 27725, 28748, 29641, 30410, 31054, 31586, 32011, 32334, 32564, 32704, 32764, 32753, 32674, 32535, 32338, 32092, 31798, 31463, 31093, 30686, 30251, 29797, 29313, 28808, 28287, 27748, 27196, 26634, 26059, 25472, 24880, 24278, 23671, 23054, 22430, 21800, 21162, 20517, 19863, 19200, 18530, 17853, 17167, 16475, 15775, 15071, 14362, 13651, 12941, 12231, 11522, 10816, 10115, 9430, 8753, 8093, 7451, 6830, 6239, 5679, 5150, 4657, 4204, 3787, 3413, 3076, 2774, 2505, 2265, 2050, 1855, 1677, 1512, 1354, 1199, 1047, 894, 742, 586, 428, 270, 112, -41, -188, -331, -465, -590, -701, -796, -875, -939, -985, -1016, -1030, -1026, -1008, -975, -929, -870, -801, -725, -640, -551, -460, -368, -278, -192, -112, -39, 23, 73, 111, 134, 140, 129, 101, 51, -19, -112, -231, -374, -539, -735, -955, -1202, -1479, -1783, -2118, -2480, -2868, -3291, -3745, -4228, -4740, -5284, -5856, -6462, -7096, -7761, -8455, -9170, -9910, -10673, -11450, -12235, -13029, -13810, -14583, -15335, -16054, -16731, -17352, -17910, -18398, -18803, -19119, -19343, -19471, -19501, -19435, -19276, -19035, -18715, -18328, -17885, -17397, -16879, -16346, -15800, -15263, -14740, -14240, -13772, -13341, -12956, -12617, -12331, -12096, -11915, -11788, -11716, -11695, -11723, -11801, -11927, -12096, -12303, -12548, -12830, -13140, -13475, -13835, -14215, -14607, -15008, -15417, -15831, -16243, -16650, -17048, -17433, -17805, -18158, -18490, -18800, -19080, -19330, -19551, -19739, -19895, -20012, -20095, -20143, -20151, -20121, -20054, -19950, -19806, -19625, -19406, -19146, -18852, -18518, -18140, -17723, -17260, -16752, -16190, -15569, -14879, -14117, -13279, -12354, -11327, -10199, -8959, -7606, -6146, -4576, -2895, -1079};