/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0047 256 samples */
 
const int16_t AKWF_epiano_0047_256_DATA [256] = 
{738, 3493, 6355, 9332, 12323, 15255, 18056, 20649, 22995, 25091, 26895, 28422, 29683, 30680, 31457, 32034, 32426, 32664, 32764, 32749, 32630, 32421, 32137, 31784, 31373, 30909, 30395, 29840, 29248, 28619, 27963, 27273, 26553, 25807, 25041, 24245, 23429, 22595, 21742, 20880, 20007, 19121, 18226, 17324, 16411, 15500, 14579, 13653, 12725, 11802, 10882, 9977, 9075, 8185, 7314, 6453, 5614, 4791, 3982, 3195, 2425, 1680, 964, 270, -395, -1030, -1638, -2214, -2762, -3285, -3778, -4242, -4675, -5077, -5448, -5785, -6089, -6360, -6600, -6808, -6986, -7126, -7228, -7275, -7263, -7184, -7030, -6804, -6521, -6191, -5832, -5467, -5119, -4801, -4527, -4298, -4121, -3991, -3907, -3857, -3838, -3841, -3860, -3887, -3921, -3957, -3990, -4025, -4054, -4078, -4098, -4115, -4128, -4139, -4147, -4152, -4160, -4164, -4173, -4184, -4198, -4216, -4241, -4273, -4310, -4360, -4424, -4496, -4584, -4688, -4804, -4932, -5076, -5230, -5399, -5577, -5762, -5957, -6162, -6376, -6597, -6824, -7058, -7294, -7533, -7774, -8017, -8256, -8490, -8723, -8955, -9182, -9407, -9628, -9844, -10059, -10265, -10466, -10656, -10827, -10981, -11105, -11190, -11223, -11192, -11080, -10869, -10539, -10075, -9470, -8715, -7813, -6780, -5644, -4441, -3211, -2003, -839, 239, 1207, 2061, 2782, 3376, 3844, 4192, 4422, 4544, 4566, 4496, 4336, 4098, 3789, 3416, 2986, 2504, 1980, 1421, 829, 204, -438, -1107, -1793, -2487, -3192, -3902, -4607, -5312, -6007, -6684, -7352, -7998, -8622, -9228, -9804, -10355, -10878, -11371, -11834, -12263, -12657, -13023, -13355, -13656, -13927, -14171, -14385, -14573, -14734, -14869, -14981, -15066, -15126, -15165, -15181, -15173, -15142, -15092, -15018, -14922, -14798, -14648, -14468, -14254, -14002, -13700, -13344, -12919, -12401, -11771, -11004, -10060, -8917, -7531, -5876, -3946, -1672};