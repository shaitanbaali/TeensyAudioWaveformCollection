/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0028 256 samples */
 
const int16_t AKWF_epiano_0028_256_DATA [256] = 
{1361, 3777, 6181, 8574, 10939, 13265, 15518, 17666, 19710, 21608, 23371, 24989, 26448, 27747, 28884, 29872, 30698, 31384, 31923, 32324, 32593, 32743, 32771, 32694, 32501, 32223, 31842, 31379, 30842, 30220, 29531, 28785, 27979, 27127, 26228, 25297, 24326, 23327, 22299, 21256, 20198, 19136, 18055, 16977, 15896, 14825, 13757, 12701, 11659, 10636, 9631, 8645, 7691, 6760, 5849, 4977, 4128, 3315, 2546, 1809, 1108, 456, -145, -699, -1202, -1652, -2046, -2389, -2663, -2881, -3039, -3131, -3163, -3130, -3027, -2857, -2616, -2307, -1919, -1460, -917, -301, 392, 1158, 1979, 2880, 3821, 4805, 5824, 6844, 7865, 8875, 9855, 10797, 11694, 12531, 13303, 14013, 14652, 15230, 15742, 16188, 16586, 16926, 17217, 17469, 17690, 17874, 18031, 18159, 18266, 18355, 18421, 18477, 18506, 18526, 18519, 18502, 18461, 18389, 18310, 18205, 18071, 17911, 17723, 17510, 17262, 16980, 16670, 16321, 15944, 15518, 15060, 14567, 14033, 13464, 12850, 12199, 11517, 10795, 10040, 9252, 8420, 7563, 6687, 5769, 4817, 3845, 2846, 1827, 778, -294, -1393, -2511, -3643, -4794, -5959, -7132, -8295, -9446, -10577, -11677, -12726, -13730, -14664, -15516, -16288, -16981, -17574, -18079, -18492, -18823, -19080, -19259, -19382, -19461, -19493, -19494, -19480, -19459, -19427, -19396, -19375, -19369, -19380, -19404, -19444, -19510, -19603, -19712, -19839, -19994, -20171, -20364, -20580, -20819, -21067, -21334, -21611, -21907, -22208, -22518, -22842, -23159, -23486, -23817, -24146, -24467, -24785, -25085, -25376, -25653, -25911, -26150, -26371, -26565, -26742, -26888, -27007, -27102, -27174, -27210, -27223, -27209, -27165, -27094, -26996, -26870, -26722, -26547, -26344, -26117, -25864, -25583, -25268, -24924, -24542, -24117, -23644, -23116, -22527, -21862, -21119, -20287, -19347, -18305, -17147, -15863, -14445, -12894, -11203, -9378, -7442, -5377, -3212, -900};