/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0033 256 samples */
 
const int16_t AKWF_epiano_0033_256_DATA [256] = 
{1639, 5478, 9267, 12893, 16273, 19344, 22047, 24367, 26329, 27948, 29272, 30328, 31152, 31773, 32227, 32534, 32710, 32769, 32721, 32577, 32347, 32028, 31628, 31150, 30603, 29990, 29315, 28579, 27794, 26962, 26094, 25207, 24293, 23370, 22448, 21541, 20651, 19782, 18946, 18156, 17412, 16722, 16079, 15490, 14951, 14461, 14017, 13612, 13232, 12875, 12535, 12203, 11880, 11560, 11240, 10922, 10614, 10318, 10036, 9767, 9515, 9275, 9044, 8818, 8589, 8358, 8130, 7913, 7721, 7562, 7448, 7389, 7387, 7434, 7508, 7584, 7626, 7598, 7455, 7162, 6697, 6039, 5193, 4171, 3010, 1739, 416, -929, -2251, -3510, -4675, -5727, -6645, -7419, -8035, -8492, -8797, -8954, -8965, -8842, -8601, -8248, -7791, -7246, -6620, -5925, -5182, -4384, -3543, -2676, -1783, -874, 38, 962, 1886, 2798, 3701, 4583, 5446, 6288, 7103, 7883, 8638, 9359, 10054, 10720, 11358, 11971, 12557, 13121, 13661, 14170, 14645, 15077, 15465, 15805, 16082, 16296, 16440, 16507, 16493, 16395, 16209, 15925, 15536, 15021, 14369, 13569, 12598, 11451, 10109, 8564, 6830, 4923, 2851, 663, -1638, -4014, -6425, -8848, -11240, -13586, -15875, -18080, -20178, -22161, -24008, -25723, -27295, -28707, -29928, -30923, -31661, -32038, -32060, -31818, -31113, -30058, -28685, -27071, -25289, -23420, -21545, -19720, -17977, -16368, -14906, -13614, -12474, -11488, -10650, -9953, -9386, -8937, -8594, -8356, -8212, -8157, -8193, -8319, -8532, -8832, -9215, -9682, -10236, -10873, -11583, -12359, -13191, -14066, -14980, -15908, -16843, -17761, -18646, -19489, -20276, -20988, -21625, -22175, -22628, -22993, -23264, -23438, -23517, -23504, -23398, -23204, -22933, -22595, -22198, -21765, -21306, -20848, -20411, -20016, -19680, -19416, -19226, -19109, -19051, -19034, -19030, -19009, -18935, -18769, -18471, -17989, -17269, -16259, -14898, -13138, -10965, -8342, -5316, -1869};