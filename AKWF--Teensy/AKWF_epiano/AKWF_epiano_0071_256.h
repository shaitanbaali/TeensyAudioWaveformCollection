/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0071 256 samples */
 
const int16_t AKWF_epiano_0071_256_DATA [256] = 
{1292, 4854, 8243, 11497, 14527, 17313, 19846, 22090, 24086, 25835, 27340, 28621, 29693, 30576, 31285, 31839, 32249, 32532, 32702, 32767, 32740, 32627, 32436, 32174, 31841, 31438, 30970, 30436, 29839, 29174, 28442, 27640, 26770, 25841, 24859, 23813, 22728, 21607, 20462, 19315, 18161, 17013, 15893, 14799, 13743, 12736, 11766, 10839, 9961, 9117, 8315, 7539, 6781, 6036, 5296, 4550, 3798, 3024, 2227, 1402, 549, -332, -1246, -2191, -3166, -4160, -5169, -6199, -7232, -8266, -9294, -10295, -11281, -12242, -13169, -14054, -14877, -15602, -16210, -16662, -16945, -17070, -17052, -16922, -16707, -16432, -16121, -15784, -15437, -15077, -14712, -14345, -13975, -13604, -13232, -12863, -12493, -12126, -11761, -11401, -11036, -10672, -10304, -9931, -9553, -9160, -8751, -8325, -7876, -7401, -6901, -6366, -5796, -5184, -4534, -3843, -3102, -2318, -1501, -645, 234, 1136, 2050, 2969, 3878, 4766, 5625, 6452, 7231, 7956, 8620, 9213, 9733, 10176, 10533, 10800, 10977, 11063, 11052, 10946, 10747, 10456, 10075, 9604, 9051, 8412, 7696, 6910, 6054, 5126, 4136, 3085, 1974, 818, -400, -1669, -2984, -4345, -5743, -7169, -8644, -10134, -11616, -13032, -14272, -15247, -15857, -16049, -15817, -15190, -14235, -13029, -11651, -10178, -8676, -7177, -5730, -4360, -3081, -1914, -852, 107, 955, 1708, 2370, 2942, 3440, 3866, 4225, 4527, 4771, 4957, 5088, 5159, 5168, 5109, 4977, 4762, 4454, 4047, 3537, 2915, 2194, 1385, 475, -529, -1631, -2803, -4037, -5324, -6638, -7952, -9257, -10515, -11725, -12864, -13916, -14868, -15711, -16439, -17051, -17542, -17915, -18173, -18321, -18370, -18324, -18196, -17998, -17736, -17429, -17087, -16721, -16349, -15984, -15636, -15319, -15055, -14850, -14722, -14679, -14731, -14883, -15123, -15439, -15791, -16109, -16298, -16231, -15770, -14806, -13267, -11146, -8507, -5465, -2066};