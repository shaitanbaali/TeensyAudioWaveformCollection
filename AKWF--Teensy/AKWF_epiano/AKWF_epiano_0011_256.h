/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0011 256 samples */
 
const int16_t AKWF_epiano_0011_256_DATA [256] = 
{210, 879, 1507, 2023, 2386, 2620, 2793, 2967, 3165, 3367, 3531, 3641, 3707, 3759, 3819, 3882, 3930, 3950, 3945, 3935, 3934, 3943, 3954, 3955, 3949, 3947, 3964, 4000, 4052, 4109, 4174, 4254, 4359, 4492, 4649, 4824, 5016, 5233, 5484, 5770, 6089, 6431, 6794, 7185, 7608, 8064, 8553, 9068, 9604, 10167, 10760, 11384, 12038, 12713, 13402, 14110, 14835, 15579, 16341, 17113, 17889, 18671, 19455, 20241, 21030, 21811, 22583, 23343, 24088, 24821, 25538, 26229, 26895, 27535, 28144, 28727, 29279, 29793, 30268, 30699, 31090, 31444, 31762, 32039, 32272, 32457, 32597, 32695, 32751, 32768, 32745, 32677, 32569, 32420, 32234, 32012, 31754, 31462, 31134, 30772, 30380, 29955, 29502, 29024, 28522, 27996, 27447, 26875, 26280, 25667, 25033, 24384, 23723, 23046, 22354, 21650, 20931, 20202, 19464, 18717, 17963, 17201, 16427, 15646, 14858, 14064, 13270, 12474, 11670, 10864, 10053, 9237, 8423, 7609, 6796, 5984, 5168, 4349, 3533, 2718, 1906, 1100, 294, -509, -1311, -2112, -2907, -3696, -4482, -5263, -6034, -6802, -7561, -8314, -9065, -9810, -10549, -11281, -12001, -12712, -13417, -14116, -14807, -15490, -16161, -16823, -17479, -18129, -18774, -19409, -20030, -20641, -21242, -21833, -22417, -22990, -23549, -24096, -24632, -25154, -25668, -26167, -26648, -27114, -27563, -27999, -28424, -28833, -29222, -29592, -29942, -30273, -30587, -30879, -31148, -31393, -31615, -31817, -31997, -32149, -32273, -32365, -32429, -32467, -32477, -32457, -32399, -32304, -32174, -32012, -31815, -31584, -31309, -30994, -30641, -30254, -29834, -29377, -28876, -28333, -27754, -27143, -26507, -25838, -25131, -24388, -23615, -22819, -22012, -21186, -20334, -19460, -18566, -17668, -16776, -15884, -14983, -14071, -13151, -12241, -11356, -10488, -9627, -8768, -7911, -7082, -6297, -5548, -4819, -4090, -3361, -2667, -2040, -1485, -965, -405};