/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0055 256 samples */
 
const int16_t AKWF_epiano_0055_256_DATA [256] = 
{881, 3997, 7276, 10632, 13941, 17106, 20018, 22625, 24906, 26840, 28433, 29722, 30726, 31491, 32049, 32429, 32658, 32760, 32753, 32655, 32477, 32227, 31915, 31546, 31124, 30654, 30136, 29580, 28986, 28351, 27685, 26989, 26261, 25511, 24732, 23926, 23101, 22252, 21390, 20513, 19619, 18714, 17804, 16887, 15969, 15043, 14112, 13176, 12241, 11306, 10373, 9445, 8520, 7609, 6711, 5830, 4963, 4113, 3278, 2462, 1669, 897, 146, -578, -1280, -1951, -2589, -3205, -3789, -4343, -4869, -5363, -5822, -6251, -6643, -6998, -7317, -7596, -7840, -8045, -8208, -8321, -8373, -8352, -8245, -8046, -7759, -7399, -6991, -6561, -6139, -5749, -5410, -5129, -4907, -4743, -4628, -4556, -4515, -4496, -4492, -4495, -4500, -4500, -4495, -4481, -4457, -4420, -4373, -4314, -4245, -4166, -4076, -3978, -3874, -3764, -3650, -3533, -3417, -3300, -3189, -3082, -2984, -2895, -2819, -2757, -2715, -2692, -2690, -2712, -2757, -2828, -2920, -3040, -3181, -3343, -3527, -3731, -3954, -4196, -4453, -4724, -5008, -5306, -5610, -5925, -6242, -6559, -6882, -7204, -7523, -7844, -8161, -8479, -8797, -9115, -9431, -9750, -10063, -10372, -10676, -10965, -11232, -11461, -11637, -11739, -11737, -11600, -11293, -10786, -10057, -9099, -7934, -6606, -5175, -3711, -2275, -924, 298, 1363, 2266, 3008, 3592, 4037, 4347, 4539, 4625, 4612, 4509, 4326, 4071, 3745, 3355, 2911, 2413, 1869, 1284, 657, -5, -695, -1417, -2159, -2918, -3673, -4433, -5195, -5949, -6696, -7428, -8142, -8833, -9497, -10129, -10733, -11299, -11831, -12324, -12774, -13184, -13553, -13881, -14169, -14418, -14627, -14802, -14944, -15054, -15134, -15183, -15208, -15209, -15187, -15144, -15086, -15013, -14924, -14824, -14711, -14588, -14452, -14304, -14141, -13962, -13763, -13537, -13273, -12954, -12562, -12065, -11428, -10600, -9523, -8152, -6439, -4357, -1857};