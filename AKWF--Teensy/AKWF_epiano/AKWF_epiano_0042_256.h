/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0042 256 samples */
 
const int16_t AKWF_epiano_0042_256_DATA [256] = 
{787, 2543, 4303, 6082, 7871, 9650, 11412, 13155, 14866, 16535, 18133, 19680, 21159, 22552, 23866, 25093, 26224, 27263, 28206, 29052, 29803, 30456, 31023, 31503, 31893, 32206, 32450, 32619, 32723, 32766, 32756, 32686, 32561, 32397, 32188, 31932, 31648, 31331, 30977, 30592, 30177, 29738, 29280, 28801, 28291, 27762, 27215, 26653, 26072, 25474, 24866, 24239, 23591, 22937, 22276, 21602, 20918, 20222, 19516, 18809, 18100, 17382, 16667, 15946, 15226, 14510, 13798, 13093, 12407, 11733, 11071, 10429, 9812, 9221, 8649, 8107, 7596, 7117, 6663, 6235, 5848, 5492, 5158, 4849, 4568, 4312, 4073, 3842, 3623, 3416, 3213, 3008, 2806, 2597, 2377, 2151, 1921, 1687, 1441, 1184, 919, 645, 370, 98, -173, -448, -730, -1009, -1279, -1542, -1809, -2073, -2322, -2570, -2818, -3053, -3285, -3519, -3743, -3970, -4196, -4414, -4632, -4849, -5058, -5272, -5490, -5705, -5927, -6152, -6376, -6604, -6838, -7085, -7334, -7581, -7835, -8095, -8358, -8627, -8903, -9190, -9477, -9769, -10072, -10380, -10691, -11009, -11332, -11657, -11982, -12319, -12659, -12992, -13323, -13656, -13979, -14300, -14611, -14898, -15165, -15411, -15630, -15813, -15958, -16064, -16116, -16121, -16087, -15997, -15854, -15671, -15440, -15159, -14841, -14496, -14127, -13729, -13319, -12901, -12481, -12072, -11682, -11307, -10953, -10627, -10335, -10085, -9877, -9711, -9587, -9512, -9475, -9484, -9538, -9636, -9770, -9940, -10154, -10401, -10670, -10978, -11316, -11673, -12040, -12421, -12824, -13239, -13662, -14096, -14532, -14964, -15399, -15830, -16254, -16675, -17087, -17487, -17874, -18247, -18603, -18937, -19250, -19538, -19803, -20035, -20235, -20407, -20540, -20627, -20672, -20678, -20637, -20540, -20389, -20180, -19915, -19588, -19191, -18719, -18174, -17557, -16865, -16101, -15247, -14308, -13296, -12205, -11030, -9779, -8446, -7053, -5592, -4058, -2488, -830};