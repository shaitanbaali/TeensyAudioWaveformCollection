/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0020 256 samples */
 
const int16_t AKWF_epiano_0020_256_DATA [256] = 
{2512, 4798, 6912, 9063, 11184, 13224, 15244, 17133, 18990, 20709, 22367, 23868, 25302, 26578, 27758, 28793, 29713, 30489, 31159, 31688, 32116, 32428, 32634, 32744, 32754, 32703, 32571, 32387, 32137, 31852, 31517, 31150, 30748, 30333, 29886, 29415, 28913, 28414, 27871, 27318, 26758, 26173, 25583, 24983, 24368, 23759, 23143, 22537, 21939, 21340, 20762, 20189, 19634, 19084, 18561, 18041, 17529, 17028, 16548, 16062, 15589, 15118, 14655, 14193, 13731, 13284, 12829, 12385, 11945, 11522, 11104, 10696, 10300, 9926, 9561, 9206, 8856, 8523, 8205, 7891, 7590, 7293, 7002, 6726, 6438, 6155, 5882, 5608, 5334, 5062, 4795, 4522, 4260, 3992, 3748, 3510, 3274, 3053, 2834, 2624, 2430, 2233, 2044, 1865, 1686, 1506, 1327, 1148, 977, 804, 623, 450, 281, 107, -57, -226, -386, -550, -693, -839, -976, -1108, -1223, -1342, -1456, -1562, -1664, -1765, -1865, -1958, -2060, -2159, -2252, -2356, -2461, -2565, -2670, -2770, -2870, -2975, -3076, -3169, -3279, -3373, -3471, -3567, -3658, -3758, -3857, -3958, -4065, -4176, -4299, -4424, -4555, -4700, -4853, -5012, -5177, -5366, -5554, -5744, -5933, -6145, -6349, -6561, -6772, -6991, -7209, -7430, -7640, -7870, -8103, -8333, -8575, -8833, -9093, -9359, -9641, -9930, -10238, -10548, -10869, -11195, -11539, -11885, -12239, -12591, -12952, -13315, -13683, -14045, -14414, -14783, -15152, -15532, -15916, -16312, -16714, -17122, -17532, -17965, -18409, -18866, -19325, -19803, -20277, -20755, -21241, -21729, -22205, -22687, -23157, -23616, -24068, -24509, -24928, -25331, -25732, -26101, -26474, -26809, -27149, -27453, -27753, -28013, -28252, -28451, -28629, -28759, -28842, -28869, -28837, -28731, -28549, -28287, -27944, -27511, -26962, -26327, -25571, -24727, -23744, -22676, -21472, -20184, -18738, -17211, -15527, -13773, -11876, -9915, -7851, -5678, -3558, -1094};