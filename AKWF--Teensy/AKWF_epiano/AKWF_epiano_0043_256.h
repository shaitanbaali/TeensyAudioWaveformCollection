/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0043 256 samples */
 
const int16_t AKWF_epiano_0043_256_DATA [256] = 
{832, 3370, 5904, 8463, 10985, 13466, 15874, 18159, 20312, 22310, 24123, 25774, 27235, 28513, 29611, 30528, 31275, 31865, 32299, 32589, 32743, 32767, 32676, 32469, 32157, 31743, 31240, 30649, 29972, 29218, 28390, 27493, 26541, 25527, 24463, 23353, 22208, 21035, 19838, 18621, 17397, 16162, 14936, 13720, 12505, 11315, 10138, 8988, 7871, 6785, 5726, 4702, 3712, 2753, 1834, 944, 89, -736, -1523, -2278, -2996, -3674, -4307, -4893, -5418, -5884, -6289, -6623, -6880, -7062, -7166, -7189, -7129, -6985, -6758, -6451, -6055, -5573, -5003, -4341, -3591, -2753, -1822, -813, 270, 1412, 2587, 3792, 4994, 6175, 7322, 8409, 9420, 10365, 11224, 11996, 12693, 13303, 13846, 14328, 14752, 15130, 15471, 15774, 16055, 16320, 16567, 16803, 17035, 17260, 17485, 17704, 17919, 18133, 18339, 18540, 18730, 18904, 19064, 19207, 19329, 19429, 19500, 19543, 19555, 19529, 19470, 19370, 19226, 19039, 18803, 18516, 18180, 17790, 17347, 16857, 16308, 15706, 15050, 14342, 13584, 12779, 11916, 11003, 10044, 9031, 7978, 6869, 5703, 4486, 3219, 1893, 512, -931, -2434, -3988, -5591, -7223, -8886, -10551, -12199, -13789, -15313, -16737, -18032, -19177, -20152, -20942, -21552, -21985, -22243, -22346, -22320, -22180, -21950, -21657, -21317, -20954, -20584, -20214, -19858, -19521, -19212, -18930, -18682, -18462, -18271, -18113, -17988, -17893, -17827, -17789, -17785, -17811, -17866, -17949, -18066, -18213, -18389, -18596, -18823, -19080, -19360, -19657, -19969, -20293, -20623, -20961, -21300, -21635, -21960, -22280, -22580, -22867, -23128, -23364, -23576, -23758, -23909, -24027, -24114, -24166, -24187, -24175, -24134, -24065, -23971, -23853, -23714, -23560, -23391, -23208, -23017, -22817, -22609, -22391, -22159, -21905, -21626, -21311, -20948, -20523, -20022, -19440, -18747, -17933, -16989, -15898, -14657, -13264, -11696, -9968, -8076, -6029, -3860, -1503};