/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0032 256 samples */
 
const int16_t AKWF_epiano_0032_256_DATA [256] = 
{2071, 6019, 9775, 13265, 16368, 19074, 21367, 23251, 24771, 25980, 26913, 27632, 28168, 28554, 28815, 28970, 29034, 29014, 28911, 28724, 28460, 28118, 27696, 27195, 26621, 25975, 25261, 24485, 23652, 22765, 21838, 20879, 19898, 18897, 17892, 16896, 15919, 14973, 14063, 13200, 12394, 11648, 10968, 10343, 9783, 9280, 8821, 8398, 8008, 7637, 7279, 6933, 6601, 6290, 6001, 5745, 5533, 5367, 5249, 5178, 5150, 5157, 5189, 5234, 5284, 5334, 5388, 5452, 5546, 5684, 5891, 6175, 6530, 6939, 7355, 7724, 7990, 8082, 7941, 7526, 6820, 5828, 4579, 3129, 1528, -145, -1815, -3452, -4996, -6402, -7639, -8684, -9532, -10177, -10618, -10863, -10926, -10824, -10567, -10174, -9663, -9052, -8351, -7568, -6719, -5820, -4873, -3888, -2866, -1819, -746, 345, 1439, 2538, 3641, 4732, 5811, 6863, 7879, 8868, 9819, 10729, 11598, 12421, 13202, 13953, 14668, 15354, 16011, 16634, 17230, 17795, 18316, 18791, 19212, 19569, 19862, 20087, 20236, 20309, 20300, 20213, 20037, 19767, 19394, 18895, 18246, 17433, 16423, 15196, 13765, 12103, 10237, 8190, 5989, 3680, 1307, -1141, -3620, -6117, -8635, -11131, -13622, -16082, -18461, -20737, -22880, -24850, -26662, -28290, -29716, -30931, -31891, -32552, -32782, -32696, -32154, -31141, -29752, -28034, -26088, -24020, -21923, -19879, -17945, -16151, -14526, -13079, -11802, -10689, -9722, -8890, -8179, -7585, -7085, -6678, -6366, -6145, -6011, -5970, -6025, -6182, -6441, -6805, -7276, -7859, -8545, -9324, -10184, -11113, -12084, -13091, -14107, -15108, -16071, -16977, -17807, -18554, -19205, -19748, -20179, -20502, -20714, -20812, -20800, -20679, -20454, -20129, -19720, -19244, -18726, -18198, -17694, -17241, -16875, -16621, -16490, -16493, -16624, -16868, -17197, -17583, -17984, -18349, -18639, -18797, -18772, -18508, -17946, -17022, -15667, -13831, -11483, -8649, -5356, -1634};