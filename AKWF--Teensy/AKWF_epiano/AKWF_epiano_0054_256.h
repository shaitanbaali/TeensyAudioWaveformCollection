/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0054 256 samples */
 
const int16_t AKWF_epiano_0054_256_DATA [256] = 
{4582, 12599, 19287, 24296, 27643, 29657, 30738, 31273, 31556, 31766, 31982, 32213, 32436, 32614, 32728, 32768, 32735, 32634, 32477, 32274, 32031, 31754, 31446, 31108, 30739, 30334, 29885, 29388, 28834, 28214, 27522, 26739, 25859, 24879, 23794, 22618, 21352, 20007, 18608, 17181, 15741, 14324, 12939, 11616, 10375, 9235, 8205, 7286, 6469, 5740, 5083, 4474, 3891, 3301, 2686, 2027, 1313, 533, -317, -1236, -2218, -3260, -4349, -5492, -6680, -7900, -9147, -10397, -11636, -12846, -13999, -15068, -16044, -16910, -17676, -18339, -18902, -19382, -19805, -20190, -20497, -20608, -20352, -19620, -18474, -17123, -15845, -14828, -14133, -13707, -13441, -13230, -12993, -12691, -12318, -11899, -11454, -11010, -10577, -10159, -9753, -9359, -8964, -8569, -8167, -7757, -7339, -6905, -6455, -5989, -5498, -4977, -4413, -3797, -3118, -2371, -1553, -657, 304, 1329, 2401, 3502, 4620, 5744, 6852, 7935, 8971, 9936, 10829, 11624, 12310, 12874, 13310, 13615, 13791, 13838, 13759, 13561, 13252, 12833, 12314, 11701, 10995, 10205, 9340, 8387, 7361, 6264, 5097, 3881, 2616, 1310, -17, -1367, -2743, -4140, -5590, -7102, -8691, -10356, -12115, -13919, -15717, -17468, -19143, -20740, -22167, -23085, -22976, -21362, -18208, -13919, -9304, -5139, -1847, 474, 1957, 2859, 3377, 3675, 3867, 4013, 4146, 4280, 4422, 4570, 4723, 4880, 5042, 5207, 5373, 5531, 5676, 5802, 5893, 5938, 5919, 5820, 5620, 5301, 4843, 4232, 3453, 2516, 1411, 143, -1283, -2851, -4527, -6268, -8051, -9806, -11502, -13079, -14516, -15794, -16892, -17799, -18514, -19035, -19373, -19535, -19535, -19391, -19129, -18766, -18323, -17819, -17271, -16692, -16099, -15499, -14911, -14349, -13830, -13371, -12986, -12685, -12487, -12402, -12448, -12638, -12993, -13526, -14256, -15179, -16271, -17494, -18772, -19943, -20733, -20688, -19276, -15977, -10598, -3261};