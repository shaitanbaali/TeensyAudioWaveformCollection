/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0070 256 samples */
 
const int16_t AKWF_epiano_0070_256_DATA [256] = 
{1608, 3826, 5851, 7891, 9896, 11853, 13770, 15621, 17389, 19097, 20713, 22253, 23695, 25029, 26267, 27398, 28423, 29338, 30150, 30847, 31432, 31907, 32280, 32548, 32709, 32769, 32730, 32598, 32379, 32073, 31683, 31217, 30674, 30064, 29387, 28649, 27868, 27028, 26145, 25222, 24258, 23272, 22262, 21226, 20167, 19105, 18034, 16954, 15873, 14800, 13733, 12685, 11650, 10636, 9641, 8679, 7753, 6865, 6006, 5202, 4437, 3720, 3063, 2465, 1915, 1432, 1015, 667, 388, 176, 38, -23, -9, 74, 234, 466, 765, 1122, 1552, 2038, 2575, 3168, 3795, 4455, 5150, 5872, 6611, 7365, 8126, 8893, 9650, 10408, 11148, 11888, 12605, 13303, 13981, 14638, 15269, 15874, 16455, 17010, 17535, 18036, 18502, 18946, 19356, 19738, 20090, 20412, 20699, 20958, 21188, 21388, 21554, 21684, 21782, 21846, 21875, 21872, 21828, 21751, 21637, 21478, 21285, 21048, 20769, 20459, 20097, 19698, 19256, 18766, 18234, 17664, 17048, 16391, 15684, 14934, 14147, 13318, 12442, 11526, 10572, 9574, 8548, 7477, 6372, 5239, 4080, 2896, 1687, 466, -761, -1990, -3210, -4435, -5643, -6831, -7991, -9121, -10217, -11275, -12290, -13265, -14189, -15059, -15890, -16666, -17395, -18083, -18719, -19306, -19860, -20368, -20842, -21285, -21688, -22067, -22422, -22749, -23058, -23352, -23634, -23899, -24153, -24405, -24651, -24888, -25125, -25364, -25602, -25846, -26092, -26331, -26581, -26841, -27096, -27360, -27622, -27888, -28158, -28428, -28697, -28963, -29224, -29486, -29741, -29986, -30222, -30451, -30669, -30867, -31064, -31241, -31394, -31534, -31655, -31760, -31842, -31899, -31941, -31959, -31944, -31909, -31845, -31751, -31636, -31476, -31285, -31056, -30784, -30470, -30105, -29684, -29205, -28664, -28058, -27376, -26608, -25764, -24827, -23802, -22691, -21478, -20170, -18770, -17277, -15700, -14032, -12286, -10466, -8596, -6662, -4680, -2667, -606};