/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0038 256 samples */
 
const int16_t AKWF_epiano_0038_256_DATA [256] = 
{3249, 11179, 18097, 23524, 27289, 29673, 31021, 31711, 32038, 32210, 32340, 32469, 32597, 32702, 32761, 32764, 32714, 32606, 32450, 32249, 32008, 31729, 31414, 31055, 30654, 30205, 29706, 29147, 28530, 27841, 27082, 26252, 25340, 24342, 23262, 22100, 20867, 19585, 18258, 16923, 15598, 14313, 13097, 11961, 10905, 9944, 9071, 8290, 7576, 6928, 6329, 5769, 5228, 4690, 4138, 3555, 2932, 2258, 1522, 720, -147, -1082, -2071, -3103, -4171, -5268, -6386, -7513, -8641, -9759, -10870, -11947, -12987, -13975, -14891, -15736, -16517, -17227, -17890, -18525, -19098, -19507, -19552, -19053, -17995, -16605, -15227, -14104, -13354, -12929, -12718, -12612, -12514, -12369, -12157, -11880, -11566, -11228, -10883, -10538, -10199, -9866, -9534, -9201, -8863, -8513, -8150, -7764, -7347, -6896, -6405, -5875, -5301, -4680, -4009, -3288, -2512, -1680, -794, 157, 1151, 2189, 3253, 4312, 5358, 6366, 7319, 8200, 9006, 9715, 10342, 10877, 11315, 11657, 11902, 12044, 12089, 12027, 11863, 11597, 11230, 10763, 10202, 9550, 8818, 8012, 7137, 6200, 5205, 4156, 3063, 1913, 722, -513, -1796, -3108, -4460, -5857, -7296, -8779, -10312, -11868, -13444, -15007, -16560, -18150, -19790, -21358, -22467, -22528, -21039, -17930, -13726, -9193, -5097, -1860, 441, 1963, 2916, 3498, 3856, 4088, 4253, 4390, 4510, 4628, 4741, 4852, 4959, 5064, 5162, 5250, 5323, 5370, 5382, 5347, 5253, 5084, 4822, 4453, 3959, 3320, 2536, 1617, 556, -655, -2004, -3469, -5022, -6637, -8288, -9946, -11571, -13122, -14558, -15845, -16967, -17899, -18641, -19194, -19565, -19773, -19828, -19746, -19541, -19231, -18833, -18361, -17836, -17274, -16692, -16113, -15542, -14993, -14481, -14017, -13611, -13278, -13029, -12883, -12853, -12957, -13207, -13613, -14186, -14920, -15793, -16772, -17783, -18713, -19356, -19358, -18251, -15519, -10845, -4185};