/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0029 256 samples */
 
const int16_t AKWF_epiano_0029_256_DATA [256] = 
{1539, 3864, 6156, 8448, 10719, 12915, 15074, 17141, 19106, 20956, 22671, 24272, 25737, 27044, 28219, 29254, 30140, 30890, 31506, 31989, 32355, 32598, 32737, 32767, 32690, 32510, 32257, 31909, 31485, 30987, 30418, 29795, 29108, 28368, 27590, 26759, 25898, 25013, 24081, 23141, 22172, 21190, 20200, 19208, 18195, 17177, 16172, 15169, 14183, 13188, 12219, 11262, 10327, 9410, 8527, 7664, 6828, 6025, 5263, 4532, 3850, 3201, 2590, 2038, 1539, 1082, 680, 320, 25, -213, -402, -536, -607, -617, -569, -455, -280, -42, 250, 620, 1049, 1535, 2099, 2710, 3376, 4084, 4838, 5625, 6451, 7287, 8123, 8953, 9767, 10574, 11340, 12065, 12741, 13358, 13926, 14440, 14898, 15291, 15635, 15910, 16152, 16341, 16489, 16609, 16684, 16730, 16750, 16750, 16726, 16679, 16617, 16543, 16443, 16319, 16185, 16037, 15873, 15677, 15468, 15242, 14996, 14726, 14428, 14103, 13761, 13397, 13003, 12571, 12116, 11643, 11133, 10598, 10027, 9421, 8806, 8154, 7475, 6765, 6032, 5280, 4502, 3710, 2889, 2051, 1196, 318, -557, -1447, -2365, -3283, -4203, -5121, -6036, -6939, -7832, -8709, -9574, -10393, -11177, -11928, -12640, -13297, -13891, -14446, -14946, -15392, -15787, -16138, -16431, -16697, -16917, -17118, -17295, -17447, -17586, -17715, -17844, -17971, -18111, -18248, -18392, -18562, -18743, -18947, -19167, -19402, -19661, -19930, -20228, -20542, -20859, -21203, -21545, -21916, -22289, -22664, -23046, -23429, -23809, -24192, -24575, -24937, -25300, -25674, -26028, -26361, -26693, -26993, -27286, -27557, -27803, -28031, -28232, -28406, -28553, -28673, -28766, -28841, -28882, -28890, -28870, -28814, -28731, -28612, -28464, -28290, -28066, -27813, -27522, -27185, -26809, -26381, -25908, -25370, -24771, -24115, -23387, -22569, -21672, -20697, -19614, -18422, -17130, -15726, -14217, -12597, -10845, -8985, -7041, -4987, -2876, -642};