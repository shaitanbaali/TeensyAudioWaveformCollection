/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0034 256 samples */
 
const int16_t AKWF_epiano_0034_256_DATA [256] = 
{393, 1081, 1725, 2334, 2897, 3411, 3873, 4279, 4640, 4961, 5257, 5538, 5818, 6101, 6402, 6719, 7056, 7418, 7803, 8209, 8633, 9073, 9529, 10001, 10479, 10965, 11455, 11952, 12452, 12950, 13446, 13942, 14439, 14930, 15417, 15902, 16386, 16868, 17347, 17831, 18321, 18815, 19318, 19834, 20366, 20908, 21471, 22048, 22643, 23254, 23873, 24506, 25151, 25796, 26443, 27089, 27724, 28345, 28945, 29522, 30070, 30581, 31049, 31476, 31853, 32171, 32428, 32618, 32738, 32771, 32732, 32590, 32341, 31975, 31477, 30830, 30016, 29018, 27822, 26397, 24733, 22814, 20643, 18239, 15608, 12778, 9822, 6784, 3745, 808, -2005, -4609, -6951, -9006, -10768, -12247, -13461, -14443, -15227, -15847, -16351, -16767, -17126, -17449, -17756, -18065, -18385, -18720, -19076, -19451, -19838, -20233, -20626, -21012, -21378, -21709, -22000, -22248, -22440, -22571, -22634, -22628, -22552, -22403, -22180, -21889, -21529, -21104, -20618, -20082, -19497, -18870, -18221, -17547, -16858, -16165, -15480, -14813, -14171, -13554, -12977, -12444, -11960, -11536, -11171, -10863, -10623, -10455, -10365, -10349, -10413, -10558, -10790, -11113, -11533, -12051, -12671, -13395, -14220, -15138, -16154, -17245, -18400, -19596, -20795, -21976, -23096, -24116, -24993, -25692, -26187, -26462, -26502, -26314, -25906, -25303, -24523, -23587, -22522, -21348, -20076, -18732, -17315, -15838, -14316, -12760, -11187, -9615, -8048, -6506, -5014, -3578, -2212, -920, 286, 1404, 2427, 3357, 4191, 4936, 5590, 6154, 6631, 7033, 7357, 7608, 7795, 7918, 7986, 7999, 7959, 7876, 7752, 7591, 7394, 7162, 6904, 6616, 6299, 5952, 5578, 5180, 4761, 4320, 3861, 3376, 2880, 2369, 1842, 1310, 774, 233, -303, -831, -1345, -1838, -2308, -2747, -3151, -3509, -3816, -4068, -4260, -4388, -4444, -4425, -4329, -4155, -3902, -3572, -3168, -2694, -2156, -1566, -935, -260};