/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0064 256 samples */
 
const int16_t AKWF_epiano_0064_256_DATA [256] = 
{1163, 3453, 5774, 8160, 10547, 12915, 15238, 17455, 19573, 21566, 23407, 25090, 26598, 27922, 29083, 30072, 30893, 31553, 32060, 32419, 32653, 32762, 32756, 32644, 32440, 32153, 31785, 31347, 30845, 30293, 29689, 29041, 28356, 27639, 26886, 26109, 25307, 24483, 23636, 22779, 21907, 21021, 20127, 19218, 18310, 17405, 16483, 15563, 14644, 13719, 12807, 11897, 10990, 10094, 9209, 8332, 7479, 6631, 5802, 4993, 4197, 3428, 2679, 1949, 1241, 561, -95, -723, -1324, -1898, -2449, -2968, -3462, -3928, -4366, -4776, -5149, -5494, -5793, -6055, -6270, -6430, -6537, -6587, -6585, -6526, -6418, -6270, -6085, -5876, -5647, -5407, -5165, -4930, -4705, -4497, -4309, -4144, -4004, -3883, -3787, -3711, -3657, -3624, -3603, -3600, -3607, -3624, -3656, -3697, -3740, -3790, -3846, -3906, -3972, -4039, -4109, -4184, -4265, -4347, -4434, -4525, -4626, -4729, -4842, -4954, -5076, -5207, -5343, -5489, -5643, -5804, -5973, -6147, -6331, -6521, -6715, -6914, -7121, -7328, -7541, -7754, -7969, -8188, -8405, -8621, -8841, -9053, -9264, -9473, -9681, -9877, -10070, -10251, -10428, -10592, -10736, -10865, -10972, -11048, -11088, -11089, -11041, -10931, -10759, -10510, -10183, -9774, -9277, -8695, -8041, -7313, -6522, -5694, -4825, -3945, -3071, -2210, -1377, -588, 143, 805, 1399, 1915, 2344, 2688, 2944, 3109, 3191, 3191, 3110, 2947, 2713, 2412, 2052, 1632, 1166, 648, 94, -492, -1116, -1758, -2417, -3091, -3774, -4461, -5151, -5836, -6516, -7184, -7844, -8482, -9104, -9705, -10286, -10843, -11374, -11875, -12353, -12798, -13220, -13613, -13974, -14307, -14610, -14886, -15135, -15354, -15546, -15711, -15849, -15958, -16038, -16091, -16120, -16114, -16082, -16015, -15912, -15774, -15591, -15364, -15077, -14730, -14306, -13796, -13181, -12446, -11580, -10565, -9389, -8047, -6525, -4830, -2975, -914};