/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0009 256 samples */
 
const int16_t AKWF_epiano_0009_256_DATA [256] = 
{1335, 3945, 6416, 8960, 11428, 13872, 16213, 18462, 20569, 22559, 24377, 26031, 27505, 28784, 29871, 30778, 31509, 32059, 32457, 32683, 32765, 32714, 32558, 32293, 31948, 31517, 31013, 30445, 29835, 29193, 28542, 27868, 27175, 26465, 25743, 25039, 24343, 23649, 22965, 22288, 21614, 20945, 20300, 19663, 19037, 18419, 17804, 17189, 16581, 15985, 15395, 14804, 14214, 13618, 13022, 12429, 11839, 11255, 10668, 10074, 9476, 8888, 8297, 7713, 7125, 6543, 5963, 5379, 4802, 4228, 3669, 3111, 2551, 1984, 1423, 856, 308, -242, -799, -1356, -1917, -2475, -3038, -3592, -4149, -4714, -5289, -5866, -6448, -7031, -7622, -8208, -8804, -9417, -10031, -10643, -11267, -11895, -12526, -13160, -13809, -14469, -15123, -15775, -16435, -17102, -17769, -18444, -19114, -19789, -20457, -21127, -21792, -22465, -23138, -23801, -24447, -25083, -25698, -26318, -26922, -27505, -28063, -28581, -29066, -29521, -29933, -30304, -30618, -30857, -31030, -31123, -31134, -31048, -30869, -30571, -30140, -29578, -28882, -28033, -27046, -25889, -24565, -23073, -21414, -19587, -17601, -15474, -13227, -10858, -8392, -5857, -3293, -712, 1852, 4373, 6823, 9157, 11373, 13436, 15337, 17058, 18596, 19930, 21071, 22017, 22779, 23347, 23734, 23947, 23994, 23898, 23679, 23339, 22900, 22361, 21738, 21045, 20291, 19509, 18689, 17838, 16969, 16078, 15175, 14262, 13357, 12457, 11560, 10663, 9760, 8875, 7998, 7136, 6283, 5435, 4589, 3750, 2911, 2087, 1275, 463, -337, -1138, -1938, -2720, -3502, -4266, -5024, -5782, -6535, -7282, -8015, -8745, -9460, -10172, -10879, -11582, -12278, -12956, -13614, -14264, -14910, -15542, -16160, -16757, -17331, -17870, -18392, -18886, -19358, -19779, -20164, -20491, -20775, -20989, -21150, -21232, -21234, -21133, -20926, -20603, -20165, -19591, -18874, -18001, -16963, -15765, -14392, -12858, -11140, -9295, -7267, -5159, -2797, -724};