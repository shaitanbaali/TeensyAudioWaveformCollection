/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0048 256 samples */
 
const int16_t AKWF_epiano_0048_256_DATA [256] = 
{1633, 4158, 6739, 9412, 12093, 14744, 17328, 19760, 22038, 24125, 25983, 27605, 28986, 30119, 31032, 31730, 32228, 32551, 32726, 32767, 32697, 32530, 32278, 31962, 31584, 31156, 30681, 30162, 29612, 29026, 28413, 27773, 27108, 26424, 25725, 25002, 24263, 23511, 22741, 21961, 21167, 20360, 19543, 18716, 17881, 17048, 16199, 15349, 14499, 13641, 12790, 11940, 11090, 10246, 9414, 8588, 7779, 6981, 6195, 5427, 4676, 3947, 3236, 2543, 1870, 1221, 599, 4, -565, -1108, -1626, -2115, -2573, -3012, -3426, -3813, -4180, -4518, -4834, -5119, -5366, -5573, -5732, -5834, -5877, -5847, -5754, -5588, -5366, -5090, -4778, -4451, -4119, -3806, -3518, -3276, -3079, -2937, -2849, -2814, -2817, -2859, -2935, -3028, -3139, -3262, -3389, -3525, -3664, -3810, -3956, -4103, -4262, -4419, -4578, -4738, -4901, -5066, -5237, -5402, -5575, -5751, -5931, -6111, -6295, -6484, -6677, -6875, -7072, -7276, -7480, -7687, -7891, -8098, -8309, -8513, -8718, -8918, -9119, -9313, -9503, -9689, -9865, -10038, -10205, -10365, -10515, -10665, -10807, -10937, -11060, -11180, -11283, -11378, -11463, -11535, -11589, -11629, -11644, -11627, -11577, -11488, -11343, -11137, -10860, -10501, -10056, -9516, -8882, -8154, -7340, -6443, -5479, -4469, -3432, -2386, -1361, -381, 540, 1373, 2116, 2763, 3295, 3719, 4037, 4241, 4349, 4353, 4268, 4095, 3848, 3527, 3142, 2700, 2204, 1667, 1097, 492, -138, -788, -1452, -2133, -2811, -3502, -4190, -4876, -5560, -6231, -6891, -7546, -8178, -8796, -9395, -9971, -10525, -11059, -11569, -12055, -12518, -12953, -13363, -13749, -14108, -14443, -14749, -15031, -15290, -15523, -15729, -15911, -16069, -16199, -16301, -16378, -16422, -16434, -16414, -16354, -16253, -16114, -15926, -15684, -15386, -15017, -14572, -14044, -13413, -12661, -11778, -10742, -9548, -8168, -6593, -4816, -2849, -631};