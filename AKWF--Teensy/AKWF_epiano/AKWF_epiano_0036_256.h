/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0036 256 samples */
 
const int16_t AKWF_epiano_0036_256_DATA [256] = 
{743, 3274, 5808, 8378, 10927, 13443, 15889, 18219, 20407, 22440, 24277, 25941, 27410, 28685, 29775, 30677, 31406, 31973, 32378, 32641, 32760, 32751, 32623, 32376, 32020, 31565, 31010, 30362, 29630, 28817, 27925, 26968, 25940, 24856, 23719, 22532, 21318, 20068, 18792, 17504, 16206, 14914, 13636, 12362, 11114, 9896, 8703, 7555, 6439, 5358, 4315, 3313, 2350, 1425, 529, -331, -1159, -1955, -2717, -3446, -4141, -4795, -5404, -5968, -6468, -6902, -7265, -7554, -7750, -7855, -7864, -7773, -7585, -7291, -6898, -6402, -5808, -5117, -4321, -3432, -2455, -1381, -222, 996, 2263, 3555, 4851, 6128, 7357, 8519, 9594, 10576, 11455, 12241, 12931, 13534, 14057, 14513, 14916, 15280, 15607, 15905, 16186, 16458, 16723, 16988, 17252, 17515, 17787, 18064, 18348, 18635, 18924, 19220, 19519, 19811, 20098, 20381, 20646, 20902, 21139, 21351, 21537, 21687, 21803, 21888, 21922, 21911, 21854, 21745, 21586, 21364, 21087, 20751, 20354, 19893, 19367, 18775, 18118, 17399, 16615, 15766, 14853, 13874, 12844, 11745, 10578, 9348, 8048, 6672, 5230, 3699, 2083, 385, -1399, -3264, -5199, -7211, -9266, -11344, -13428, -15460, -17429, -19291, -20993, -22509, -23807, -24856, -25663, -26217, -26531, -26627, -26529, -26272, -25896, -25426, -24892, -24325, -23737, -23155, -22586, -22037, -21525, -21040, -20591, -20182, -19812, -19477, -19181, -18923, -18707, -18526, -18386, -18285, -18228, -18204, -18222, -18286, -18385, -18522, -18701, -18914, -19162, -19437, -19731, -20053, -20391, -20743, -21101, -21461, -21815, -22163, -22498, -22817, -23112, -23376, -23610, -23814, -23980, -24112, -24205, -24260, -24278, -24263, -24213, -24132, -24029, -23905, -23762, -23600, -23435, -23264, -23091, -22914, -22736, -22557, -22369, -22165, -21938, -21671, -21355, -20968, -20494, -19913, -19210, -18373, -17385, -16244, -14943, -13482, -11860, -10088, -8168, -6124, -3944, -1588};