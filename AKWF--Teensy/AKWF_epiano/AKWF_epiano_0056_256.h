/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0056 256 samples */
 
const int16_t AKWF_epiano_0056_256_DATA [256] = 
{905, 2439, 3912, 5387, 6839, 8271, 9685, 11061, 12405, 13728, 15012, 16261, 17469, 18624, 19748, 20830, 21862, 22849, 23793, 24681, 25525, 26325, 27074, 27772, 28425, 29032, 29588, 30098, 30562, 30978, 31354, 31683, 31963, 32203, 32403, 32560, 32674, 32743, 32767, 32758, 32714, 32628, 32504, 32343, 32153, 31927, 31660, 31365, 31040, 30683, 30296, 29884, 29444, 28978, 28488, 27976, 27457, 26919, 26356, 25780, 25193, 24592, 23983, 23368, 22749, 22117, 21471, 20826, 20184, 19535, 18873, 18219, 17568, 16912, 16254, 15603, 14955, 14317, 13687, 13063, 12447, 11843, 11247, 10669, 10105, 9554, 9021, 8510, 8019, 7544, 7084, 6647, 6233, 5841, 5474, 5123, 4793, 4494, 4216, 3954, 3715, 3495, 3291, 3111, 2949, 2806, 2680, 2570, 2479, 2399, 2327, 2270, 2226, 2193, 2164, 2140, 2120, 2105, 2091, 2076, 2058, 2037, 2009, 1969, 1916, 1849, 1772, 1678, 1559, 1426, 1271, 1082, 868, 628, 355, 53, -279, -646, -1049, -1485, -1952, -2452, -2985, -3548, -4140, -4758, -5396, -6053, -6725, -7409, -8096, -8788, -9482, -10166, -10834, -11495, -12135, -12747, -13339, -13900, -14428, -14930, -15402, -15832, -16234, -16608, -16940, -17243, -17521, -17768, -17989, -18191, -18366, -18515, -18646, -18766, -18867, -18953, -19036, -19112, -19179, -19240, -19302, -19371, -19439, -19507, -19581, -19670, -19767, -19866, -19979, -20104, -20245, -20392, -20549, -20728, -20917, -21110, -21314, -21531, -21759, -21994, -22249, -22527, -22816, -23105, -23394, -23682, -23969, -24257, -24536, -24809, -25079, -25335, -25580, -25816, -26040, -26247, -26433, -26602, -26755, -26888, -26989, -27065, -27118, -27137, -27121, -27064, -26958, -26799, -26592, -26325, -25994, -25590, -25119, -24576, -23956, -23258, -22479, -21625, -20705, -19710, -18642, -17509, -16313, -15069, -13773, -12423, -11032, -9609, -8156, -6682, -5177, -3659, -2139, -580};