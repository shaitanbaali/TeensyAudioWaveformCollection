/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0021 256 samples */
 
const int16_t AKWF_epiano_0021_256_DATA [256] = 
{298, 724, 1131, 1530, 1920, 2300, 2672, 3035, 3390, 3738, 4078, 4414, 4746, 5071, 5395, 5718, 6038, 6358, 6679, 7003, 7331, 7662, 7999, 8342, 8694, 9052, 9422, 9802, 10196, 10604, 11026, 11466, 11925, 12406, 12906, 13430, 13978, 14551, 15154, 15783, 16443, 17136, 17857, 18610, 19396, 20208, 21049, 21916, 22802, 23707, 24624, 25551, 26483, 27413, 28335, 29246, 30124, 30947, 31686, 32284, 32669, 32758, 32465, 31724, 30500, 28813, 26729, 24341, 21777, 19156, 16582, 14143, 11888, 9835, 7997, 6347, 4861, 3518, 2283, 1138, 66, -956, -1932, -2868, -3773, -4640, -5466, -6257, -7006, -7710, -8373, -8992, -9567, -10102, -10594, -11045, -11462, -11845, -12193, -12513, -12803, -13066, -13304, -13515, -13706, -13874, -14021, -14149, -14256, -14341, -14408, -14452, -14475, -14476, -14451, -14402, -14330, -14234, -14109, -13959, -13781, -13574, -13342, -13082, -12793, -12476, -12134, -11767, -11373, -10958, -10522, -10063, -9584, -9087, -8569, -8036, -7485, -6918, -6337, -5741, -5130, -4508, -3871, -3220, -2557, -1878, -1187, -484, 237, 974, 1728, 2499, 3287, 4094, 4923, 5769, 6631, 7516, 8420, 9342, 10284, 11246, 12223, 13217, 14212, 15195, 16144, 17009, 17739, 18255, 18471, 18310, 17710, 16646, 15131, 13232, 11052, 8693, 6286, 3937, 1718, -318, -2149, -3790, -5248, -6547, -7716, -8772, -9730, -10612, -11419, -12163, -12849, -13481, -14054, -14572, -15033, -15440, -15793, -16091, -16339, -16541, -16698, -16812, -16887, -16926, -16933, -16911, -16860, -16788, -16694, -16579, -16447, -16298, -16135, -15958, -15768, -15566, -15352, -15127, -14889, -14640, -14379, -14106, -13819, -13520, -13208, -12880, -12539, -12182, -11808, -11424, -11024, -10611, -10183, -9743, -9291, -8826, -8352, -7869, -7379, -6883, -6384, -5881, -5377, -4876, -4375, -3875, -3381, -2893, -2411, -1937, -1470, -1012, -566, -120};