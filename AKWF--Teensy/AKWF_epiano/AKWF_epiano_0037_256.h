/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0037 256 samples */
 
const int16_t AKWF_epiano_0037_256_DATA [256] = 
{1393, 3829, 6230, 8621, 11002, 13332, 15586, 17741, 19774, 21680, 23444, 25057, 26515, 27813, 28942, 29921, 30742, 31418, 31946, 32342, 32605, 32743, 32763, 32669, 32476, 32183, 31797, 31323, 30771, 30144, 29445, 28697, 27881, 27021, 26118, 25170, 24197, 23192, 22162, 21118, 20057, 18986, 17910, 16824, 15743, 14668, 13607, 12547, 11505, 10481, 9480, 8505, 7552, 6623, 5721, 4852, 4015, 3222, 2459, 1733, 1051, 416, -173, -709, -1194, -1616, -1981, -2284, -2518, -2695, -2798, -2835, -2803, -2700, -2533, -2291, -1978, -1596, -1138, -608, -11, 655, 1395, 2193, 3052, 3949, 4892, 5866, 6860, 7851, 8832, 9795, 10721, 11614, 12450, 13228, 13946, 14599, 15186, 15706, 16172, 16577, 16935, 17240, 17497, 17725, 17915, 18079, 18217, 18330, 18422, 18502, 18560, 18603, 18630, 18638, 18629, 18602, 18557, 18489, 18398, 18285, 18144, 17984, 17797, 17572, 17320, 17033, 16717, 16363, 15972, 15544, 15079, 14569, 14020, 13435, 12813, 12148, 11442, 10709, 9932, 9126, 8281, 7405, 6504, 5569, 4605, 3613, 2597, 1553, 497, -594, -1706, -2842, -3987, -5142, -6311, -7483, -8647, -9795, -10910, -11994, -13036, -14025, -14942, -15777, -16534, -17210, -17792, -18283, -18685, -19010, -19262, -19449, -19577, -19654, -19701, -19713, -19711, -19697, -19680, -19668, -19665, -19669, -19689, -19723, -19783, -19857, -19950, -20069, -20209, -20366, -20543, -20743, -20961, -21193, -21448, -21722, -21996, -22286, -22588, -22895, -23212, -23529, -23842, -24156, -24472, -24780, -25076, -25361, -25642, -25905, -26151, -26384, -26594, -26781, -26944, -27083, -27199, -27286, -27350, -27384, -27388, -27368, -27318, -27246, -27143, -27014, -26865, -26685, -26477, -26249, -25994, -25706, -25389, -25042, -24654, -24224, -23737, -23201, -22601, -21926, -21176, -20327, -19381, -18328, -17157, -15870, -14450, -12894, -11197, -9374, -7419, -5358, -3184, -870};