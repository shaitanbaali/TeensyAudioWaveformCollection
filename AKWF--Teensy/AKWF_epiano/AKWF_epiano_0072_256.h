/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0072 256 samples */
 
const int16_t AKWF_epiano_0072_256_DATA [256] = 
{1199, 3914, 6636, 9367, 12048, 14629, 17084, 19384, 21508, 23443, 25176, 26705, 28047, 29196, 30165, 30960, 31593, 32082, 32431, 32650, 32757, 32755, 32657, 32469, 32199, 31856, 31443, 30969, 30436, 29845, 29206, 28523, 27800, 27039, 26243, 25416, 24563, 23691, 22792, 21875, 20946, 19997, 19039, 18078, 17101, 16125, 15140, 14155, 13175, 12198, 11215, 10240, 9268, 8300, 7349, 6401, 5459, 4535, 3622, 2727, 1849, 984, 143, -678, -1484, -2258, -3010, -3741, -4441, -5111, -5750, -6357, -6932, -7471, -7976, -8441, -8867, -9248, -9576, -9844, -10043, -10165, -10214, -10186, -10088, -9928, -9723, -9474, -9202, -8917, -8626, -8337, -8059, -7795, -7549, -7321, -7111, -6918, -6743, -6580, -6426, -6282, -6142, -6006, -5869, -5730, -5586, -5436, -5276, -5110, -4931, -4742, -4543, -4332, -4116, -3889, -3654, -3413, -3172, -2929, -2689, -2457, -2231, -2017, -1820, -1640, -1477, -1341, -1230, -1147, -1094, -1070, -1077, -1119, -1196, -1305, -1446, -1619, -1826, -2062, -2323, -2610, -2921, -3256, -3608, -3977, -4361, -4756, -5164, -5581, -6005, -6436, -6872, -7313, -7760, -8206, -8654, -9102, -9545, -9979, -10394, -10777, -11117, -11390, -11577, -11652, -11595, -11386, -11019, -10488, -9805, -8983, -8053, -7036, -5954, -4845, -3737, -2644, -1596, -602, 321, 1164, 1920, 2584, 3149, 3622, 4001, 4285, 4478, 4580, 4603, 4540, 4400, 4184, 3898, 3542, 3120, 2639, 2099, 1505, 864, 176, -548, -1311, -2102, -2913, -3743, -4583, -5428, -6275, -7114, -7929, -8732, -9507, -10246, -10954, -11618, -12235, -12811, -13335, -13808, -14233, -14603, -14931, -15225, -15466, -15662, -15814, -15922, -15993, -16029, -16032, -16007, -15958, -15889, -15806, -15707, -15598, -15482, -15358, -15226, -15087, -14932, -14755, -14536, -14256, -13882, -13384, -12719, -11858, -10752, -9383, -7743, -5829, -3689, -1265};