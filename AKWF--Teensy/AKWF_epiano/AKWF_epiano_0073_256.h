/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0073 256 samples */
 
const int16_t AKWF_epiano_0073_256_DATA [256] = 
{778, 3079, 5441, 7851, 10272, 12678, 15014, 17258, 19400, 21409, 23260, 24952, 26463, 27811, 28978, 29980, 30811, 31483, 32000, 32382, 32629, 32751, 32761, 32667, 32475, 32197, 31841, 31418, 30928, 30380, 29779, 29133, 28446, 27723, 26961, 26168, 25351, 24510, 23651, 22772, 21870, 20957, 20036, 19098, 18159, 17207, 16252, 15296, 14338, 13385, 12434, 11491, 10549, 9618, 8700, 7799, 6908, 6037, 5180, 4344, 3533, 2742, 1970, 1225, 507, -183, -843, -1480, -2084, -2660, -3206, -3715, -4196, -4647, -5062, -5447, -5796, -6107, -6384, -6618, -6809, -6952, -7045, -7088, -7082, -7030, -6932, -6799, -6633, -6446, -6241, -6028, -5812, -5603, -5403, -5216, -5045, -4893, -4755, -4639, -4542, -4457, -4392, -4334, -4295, -4264, -4239, -4223, -4211, -4205, -4200, -4198, -4202, -4205, -4209, -4213, -4223, -4228, -4241, -4256, -4275, -4301, -4331, -4367, -4414, -4469, -4533, -4607, -4694, -4790, -4899, -5020, -5154, -5298, -5456, -5624, -5803, -5993, -6194, -6403, -6617, -6839, -7068, -7304, -7542, -7785, -8031, -8273, -8521, -8766, -9012, -9257, -9495, -9731, -9959, -10183, -10396, -10595, -10773, -10928, -11051, -11132, -11162, -11135, -11028, -10843, -10569, -10195, -9719, -9149, -8483, -7736, -6917, -6044, -5138, -4209, -3281, -2365, -1483, -647, 128, 838, 1475, 2030, 2497, 2875, 3168, 3372, 3486, 3516, 3464, 3333, 3131, 2859, 2519, 2125, 1679, 1181, 641, 64, -545, -1177, -1834, -2507, -3195, -3890, -4585, -5281, -5973, -6657, -7332, -7987, -8624, -9242, -9836, -10406, -10951, -11468, -11951, -12408, -12836, -13232, -13595, -13927, -14231, -14501, -14745, -14958, -15141, -15295, -15426, -15526, -15599, -15648, -15669, -15664, -15633, -15573, -15484, -15363, -15208, -15012, -14772, -14474, -14110, -13668, -13128, -12473, -11685, -10749, -9643, -8351, -6876, -5214, -3370, -1327};