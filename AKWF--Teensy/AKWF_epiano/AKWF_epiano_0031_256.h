/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0031 256 samples */
 
const int16_t AKWF_epiano_0031_256_DATA [256] = 
{1145, 4135, 7238, 10419, 13553, 16588, 19427, 21996, 24276, 26241, 27895, 29262, 30360, 31212, 31848, 32297, 32588, 32738, 32768, 32697, 32534, 32293, 31980, 31609, 31179, 30701, 30178, 29610, 29007, 28367, 27697, 26997, 26261, 25504, 24718, 23904, 23074, 22220, 21349, 20466, 19569, 18668, 17758, 16834, 15907, 14977, 14035, 13099, 12157, 11218, 10284, 9359, 8447, 7553, 6668, 5798, 4946, 4109, 3294, 2495, 1720, 963, 235, -461, -1128, -1769, -2379, -2962, -3516, -4039, -4539, -5007, -5441, -5844, -6210, -6537, -6833, -7091, -7316, -7512, -7672, -7795, -7874, -7892, -7838, -7704, -7488, -7199, -6847, -6458, -6063, -5677, -5323, -5016, -4759, -4559, -4414, -4308, -4245, -4209, -4193, -4192, -4201, -4217, -4229, -4235, -4239, -4236, -4226, -4207, -4182, -4149, -4109, -4064, -4020, -3966, -3914, -3862, -3811, -3758, -3714, -3672, -3638, -3612, -3601, -3599, -3614, -3646, -3697, -3765, -3853, -3961, -4087, -4225, -4381, -4555, -4744, -4945, -5161, -5390, -5629, -5880, -6140, -6408, -6679, -6954, -7231, -7505, -7781, -8054, -8323, -8592, -8865, -9131, -9397, -9658, -9917, -10171, -10422, -10658, -10878, -11073, -11239, -11354, -11409, -11378, -11240, -10977, -10554, -9954, -9180, -8214, -7099, -5858, -4535, -3188, -1875, -640, 489, 1490, 2350, 3069, 3647, 4088, 4410, 4616, 4715, 4714, 4623, 4450, 4199, 3880, 3498, 3066, 2581, 2050, 1482, 880, 251, -404, -1091, -1797, -2514, -3247, -3978, -4713, -5442, -6163, -6873, -7561, -8230, -8877, -9501, -10097, -10661, -11192, -11690, -12150, -12576, -12962, -13314, -13626, -13907, -14153, -14368, -14553, -14708, -14832, -14932, -15005, -15054, -15079, -15080, -15062, -15027, -14969, -14895, -14803, -14696, -14568, -14419, -14249, -14053, -13828, -13563, -13251, -12876, -12419, -11851, -11137, -10232, -9094, -7682, -5963, -3909, -1467};