/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0059 256 samples */
 
const int16_t AKWF_epiano_0059_256_DATA [256] = 
{725, 2917, 5064, 7186, 9289, 11347, 13359, 15306, 17178, 18970, 20674, 22277, 23788, 25180, 26462, 27640, 28689, 29622, 30431, 31120, 31685, 32133, 32462, 32674, 32765, 32747, 32619, 32387, 32051, 31629, 31105, 30504, 29815, 29054, 28230, 27347, 26403, 25405, 24362, 23283, 22173, 21033, 19877, 18695, 17501, 16298, 15096, 13887, 12681, 11480, 10292, 9113, 7959, 6825, 5716, 4634, 3591, 2587, 1630, 717, -140, -944, -1676, -2344, -2950, -3474, -3920, -4289, -4570, -4766, -4870, -4886, -4815, -4658, -4410, -4074, -3660, -3173, -2615, -1992, -1324, -597, 172, 959, 1779, 2620, 3471, 4326, 5185, 6037, 6879, 7714, 8536, 9343, 10123, 10880, 11629, 12350, 13041, 13716, 14371, 15001, 15605, 16190, 16756, 17301, 17821, 18322, 18797, 19259, 19693, 20106, 20495, 20867, 21211, 21529, 21817, 22083, 22319, 22523, 22699, 22836, 22932, 22997, 23022, 23007, 22952, 22846, 22695, 22498, 22247, 21946, 21602, 21199, 20740, 20226, 19646, 19016, 18329, 17573, 16755, 15875, 14923, 13914, 12844, 11702, 10493, 9226, 7896, 6527, 5093, 3630, 2128, 608, -918, -2452, -3967, -5467, -6935, -8356, -9725, -11037, -12281, -13463, -14566, -15597, -16551, -17427, -18224, -18949, -19608, -20194, -20711, -21168, -21573, -21917, -22214, -22466, -22680, -22861, -23003, -23121, -23215, -23295, -23357, -23410, -23456, -23497, -23539, -23582, -23635, -23696, -23761, -23841, -23936, -24046, -24175, -24311, -24464, -24635, -24818, -25016, -25224, -25428, -25634, -25845, -26061, -26275, -26489, -26701, -26906, -27109, -27301, -27486, -27656, -27820, -27964, -28101, -28218, -28322, -28408, -28479, -28531, -28569, -28590, -28591, -28581, -28545, -28493, -28412, -28304, -28170, -27993, -27777, -27514, -27197, -26819, -26370, -25843, -25230, -24529, -23732, -22825, -21807, -20675, -19427, -18064, -16578, -14986, -13286, -11480, -9594, -7634, -5601, -3516, -1353};