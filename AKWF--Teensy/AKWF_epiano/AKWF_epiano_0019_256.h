/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0019 256 samples */
 
const int16_t AKWF_epiano_0019_256_DATA [256] = 
{239, 785, 1302, 1796, 2282, 2780, 3299, 3834, 4372, 4906, 5435, 5972, 6525, 7090, 7664, 8240, 8818, 9408, 10013, 10633, 11267, 11904, 12544, 13193, 13852, 14523, 15203, 15886, 16566, 17248, 17932, 18617, 19302, 19981, 20648, 21305, 21951, 22587, 23213, 23821, 24413, 24986, 25538, 26075, 26592, 27087, 27560, 28012, 28444, 28860, 29257, 29633, 29986, 30318, 30629, 30924, 31202, 31462, 31700, 31915, 32106, 32277, 32425, 32548, 32643, 32712, 32753, 32768, 32758, 32718, 32645, 32539, 32401, 32231, 32033, 31804, 31543, 31252, 30929, 30578, 30202, 29801, 29375, 28926, 28454, 27965, 27463, 26944, 26413, 25867, 25306, 24734, 24154, 23565, 22967, 22357, 21735, 21104, 20466, 19821, 19169, 18506, 17830, 17144, 16447, 15739, 15021, 14289, 13543, 12786, 12014, 11233, 10445, 9645, 8833, 8016, 7191, 6364, 5535, 4700, 3860, 3020, 2181, 1349, 527, -292, -1107, -1918, -2726, -3523, -4310, -5087, -5854, -6616, -7372, -8121, -8864, -9600, -10329, -11053, -11774, -12489, -13202, -13914, -14624, -15335, -16044, -16744, -17441, -18131, -18818, -19507, -20191, -20865, -21527, -22171, -22801, -23421, -24030, -24624, -25204, -25759, -26293, -26805, -27295, -27764, -28210, -28629, -29024, -29395, -29742, -30066, -30367, -30642, -30894, -31123, -31330, -31514, -31674, -31808, -31919, -32009, -32078, -32125, -32147, -32140, -32105, -32045, -31959, -31849, -31713, -31546, -31351, -31129, -30880, -30607, -30308, -29980, -29624, -29245, -28843, -28421, -27979, -27514, -27026, -26520, -25997, -25461, -24915, -24353, -23777, -23192, -22598, -22001, -21403, -20797, -20185, -19566, -18944, -18326, -17713, -17098, -16483, -15868, -15254, -14652, -14058, -13469, -12884, -12301, -11723, -11158, -10603, -10060, -9523, -8989, -8465, -7957, -7466, -6987, -6515, -6041, -5574, -5122, -4690, -4276, -3867, -3451, -3031, -2621, -2239, -1886, -1541, -1168, -739, -236};