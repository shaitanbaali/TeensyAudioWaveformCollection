/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0058 256 samples */
 
const int16_t AKWF_epiano_0058_256_DATA [256] = 
{854, 2170, 3472, 4778, 6073, 7355, 8629, 9889, 11117, 12334, 13540, 14714, 15854, 16967, 18057, 19127, 20154, 21148, 22108, 23026, 23904, 24733, 25529, 26291, 27012, 27686, 28321, 28919, 29468, 29976, 30449, 30875, 31251, 31581, 31877, 32130, 32334, 32505, 32636, 32714, 32758, 32768, 32745, 32667, 32554, 32423, 32257, 32051, 31809, 31547, 31256, 30928, 30570, 30199, 29819, 29397, 28954, 28523, 28051, 27552, 27062, 26558, 26049, 25545, 25011, 24463, 23939, 23393, 22829, 22279, 21738, 21192, 20630, 20065, 19504, 18961, 18407, 17845, 17302, 16750, 16187, 15639, 15094, 14555, 14028, 13497, 12952, 12421, 11897, 11375, 10863, 10359, 9852, 9341, 8843, 8357, 7867, 7383, 6915, 6443, 5980, 5529, 5078, 4627, 4174, 3736, 3305, 2870, 2450, 2033, 1597, 1189, 795, 382, -36, -446, -842, -1234, -1629, -2027, -2423, -2817, -3211, -3606, -4000, -4397, -4790, -5183, -5596, -6002, -6393, -6802, -7214, -7626, -8039, -8449, -8861, -9273, -9681, -10091, -10522, -10940, -11330, -11734, -12144, -12537, -12914, -13288, -13664, -14015, -14346, -14666, -14977, -15270, -15536, -15790, -16035, -16268, -16463, -16633, -16812, -16972, -17101, -17205, -17309, -17409, -17481, -17535, -17583, -17635, -17677, -17705, -17720, -17732, -17746, -17760, -17771, -17786, -17818, -17840, -17853, -17899, -17943, -17972, -18031, -18103, -18169, -18252, -18336, -18419, -18530, -18661, -18800, -18939, -19081, -19238, -19407, -19587, -19779, -19985, -20198, -20408, -20615, -20828, -21058, -21286, -21512, -21741, -21969, -22192, -22403, -22611, -22819, -23012, -23193, -23361, -23506, -23636, -23752, -23845, -23918, -23965, -23975, -23950, -23890, -23797, -23668, -23504, -23298, -23049, -22753, -22403, -22002, -21558, -21072, -20526, -19912, -19257, -18557, -17807, -17011, -16154, -15250, -14317, -13334, -12294, -11241, -10144, -9001, -7838, -6643, -5422, -4186, -2937, -1679, -388};