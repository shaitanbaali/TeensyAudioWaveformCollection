/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0003 256 samples */
 
const int16_t AKWF_epiano_0003_256_DATA [256] = 
{818, 2530, 4414, 6428, 8561, 10815, 13151, 15568, 17935, 20244, 22430, 24487, 26328, 27957, 29369, 30503, 31398, 32079, 32492, 32708, 32730, 32572, 32304, 31895, 31410, 30859, 30287, 29683, 29043, 28367, 27707, 27067, 26384, 25733, 25083, 24446, 23810, 23115, 22586, 21949, 21358, 20755, 20162, 19603, 19046, 18482, 17952, 17393, 16844, 16304, 15790, 15269, 14773, 14255, 13756, 13304, 12832, 12374, 11913, 11479, 11033, 10631, 10217, 9788, 9395, 9016, 8643, 8243, 7888, 7524, 7153, 6805, 6475, 6133, 5768, 5450, 5097, 4740, 4403, 4071, 3723, 3392, 3066, 2704, 2379, 2043, 1711, 1367, 1050, 693, 324, -27, -415, -785, -1178, -1556, -1930, -2359, -2790, -3176, -3577, -4063, -4498, -4939, -5389, -5853, -6336, -6840, -7334, -7842, -8361, -8877, -9432, -9949, -10513, -11081, -11642, -12231, -12799, -13378, -13944, -14555, -15130, -15717, -16319, -16923, -17531, -18137, -18759, -19373, -19990, -20614, -21228, -21837, -22446, -23044, -23664, -24275, -24845, -25414, -25979, -26525, -27064, -27560, -28074, -28541, -29002, -29403, -29810, -30127, -30463, -30731, -30956, -31108, -31209, -31262, -31272, -31185, -31061, -30856, -30530, -30158, -29701, -29126, -28461, -27665, -26755, -25675, -24476, -23067, -21515, -19767, -17852, -15799, -13573, -11184, -8709, -6185, -3602, -1104, 1455, 3751, 5888, 7817, 9450, 10818, 11924, 12743, 13285, 13597, 13691, 13586, 13301, 12950, 12399, 11771, 11125, 10423, 9705, 8991, 8267, 7562, 6887, 6221, 5585, 5056, 4474, 3986, 3514, 3060, 2642, 2255, 1869, 1491, 1135, 763, 423, 85, -248, -591, -922, -1273, -1621, -1966, -2327, -2643, -3000, -3306, -3636, -3974, -4303, -4646, -4943, -5272, -5530, -5830, -6108, -6361, -6557, -6761, -6941, -7085, -7182, -7212, -7250, -7161, -7056, -6861, -6545, -6141, -5598, -4951, -4127, -3152, -2002, -661};