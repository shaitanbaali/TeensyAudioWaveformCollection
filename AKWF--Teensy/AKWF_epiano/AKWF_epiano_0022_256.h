/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0022 256 samples */
 
const int16_t AKWF_epiano_0022_256_DATA [256] = 
{1755, 6168, 10437, 14540, 18351, 21784, 24773, 27279, 29309, 30873, 31973, 32609, 32768, 32441, 31627, 30348, 28656, 26610, 24304, 21843, 19311, 16798, 14353, 11983, 9692, 7469, 5297, 3192, 1171, -752, -2543, -4180, -5640, -6896, -7934, -8748, -9342, -9742, -9986, -10126, -10219, -10321, -10475, -10711, -11040, -11443, -11888, -12317, -12644, -12773, -12593, -12008, -10947, -9381, -7331, -4852, -2049, 952, 4029, 7041, 9873, 12445, 14684, 16571, 18120, 19351, 20314, 21051, 21592, 21960, 22166, 22214, 22114, 21876, 21518, 21056, 20511, 19915, 19295, 18689, 18133, 17649, 17248, 16921, 16646, 16394, 16142, 15877, 15598, 15312, 15026, 14744, 14461, 14170, 13862, 13529, 13162, 12746, 12263, 11687, 10995, 10162, 9164, 7991, 6627, 5064, 3311, 1373, -720, -2922, -5198, -7492, -9750, -11937, -13998, -15881, -17542, -18922, -19975, -20681, -21042, -21095, -20900, -20533, -20071, -19570, -19060, -18531, -17946, -17272, -16487, -15606, -14682, -13785, -12985, -12326, -11815, -11429, -11134, -10894, -10677, -10457, -10213, -9941, -9646, -9340, -9039, -8764, -8533, -8354, -8226, -8143, -8094, -8048, -7966, -7810, -7560, -7223, -6832, -6435, -6092, -5855, -5752, -5785, -5927, -6135, -6353, -6523, -6585, -6491, -6220, -5760, -5122, -4342, -3471, -2577, -1730, -989, -409, -41, 78, -86, -559, -1350, -2430, -3744, -5208, -6716, -8168, -9484, -10598, -11491, -12167, -12653, -12986, -13202, -13318, -13327, -13196, -12865, -12267, -11338, -10041, -8362, -6325, -3988, -1407, 1343, 4187, 7081, 9958, 12754, 15421, 17879, 20060, 21912, 23381, 24427, 25030, 25166, 24818, 23975, 22636, 20815, 18541, 15873, 12869, 9599, 6159, 2621, -936, -4430, -7827, -11092, -14196, -17135, -19872, -22348, -24507, -26274, -27590, -28441, -28832, -28803, -28405, -27687, -26686, -25405, -23832, -21936, -19665, -16995, -13909, -10424, -6599, -2411};