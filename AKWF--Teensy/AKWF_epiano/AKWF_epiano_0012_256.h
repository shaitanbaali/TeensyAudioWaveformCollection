/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0012 256 samples */
 
const int16_t AKWF_epiano_0012_256_DATA [256] = 
{1823, 4234, 6506, 8756, 10952, 13058, 15087, 17016, 18824, 20525, 22110, 23574, 24923, 26145, 27249, 28258, 29145, 29923, 30600, 31172, 31659, 32047, 32354, 32572, 32701, 32764, 32755, 32684, 32552, 32358, 32118, 31827, 31492, 31123, 30732, 30307, 29870, 29420, 28960, 28491, 28023, 27548, 27084, 26619, 26157, 25699, 25239, 24779, 24327, 23864, 23401, 22933, 22453, 21986, 21511, 21028, 20545, 20061, 19572, 19090, 18608, 18128, 17664, 17208, 16760, 16323, 15917, 15500, 15102, 14718, 14344, 13986, 13625, 13276, 12933, 12592, 12258, 11917, 11582, 11247, 10915, 10570, 10229, 9896, 9562, 9229, 8894, 8567, 8255, 7947, 7639, 7343, 7060, 6781, 6522, 6259, 6010, 5765, 5532, 5299, 5058, 4831, 4596, 4365, 4136, 3893, 3648, 3403, 3159, 2916, 2661, 2411, 2167, 1922, 1673, 1435, 1195, 962, 736, 515, 301, 93, -104, -307, -511, -710, -910, -1109, -1308, -1514, -1728, -1948, -2177, -2395, -2615, -2843, -3082, -3314, -3538, -3775, -4007, -4242, -4470, -4691, -4915, -5138, -5360, -5572, -5786, -5993, -6202, -6416, -6628, -6840, -7053, -7273, -7501, -7746, -7987, -8243, -8498, -8764, -9034, -9299, -9574, -9849, -10130, -10408, -10688, -10968, -11241, -11511, -11787, -12056, -12320, -12593, -12855, -13129, -13410, -13688, -13976, -14270, -14567, -14882, -15203, -15533, -15870, -16217, -16580, -16930, -17288, -17662, -18028, -18392, -18757, -19123, -19485, -19840, -20195, -20547, -20887, -21227, -21567, -21906, -22239, -22579, -22917, -23259, -23608, -23964, -24313, -24673, -25027, -25387, -25738, -26080, -26407, -26724, -27023, -27302, -27558, -27792, -27991, -28175, -28322, -28419, -28492, -28516, -28504, -28453, -28356, -28221, -28045, -27805, -27528, -27193, -26803, -26351, -25822, -25226, -24544, -23767, -22906, -21937, -20860, -19669, -18364, -16944, -15423, -13786, -12051, -10205, -8266, -6266, -4170, -2011};