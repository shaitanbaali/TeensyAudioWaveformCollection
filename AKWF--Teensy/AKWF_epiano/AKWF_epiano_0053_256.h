/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0053 256 samples */
 
const int16_t AKWF_epiano_0053_256_DATA [256] = 
{1458, 3834, 6169, 8516, 10836, 13116, 15325, 17433, 19433, 21326, 23078, 24689, 26149, 27463, 28622, 29632, 30492, 31203, 31772, 32210, 32517, 32701, 32769, 32722, 32574, 32329, 31989, 31567, 31062, 30487, 29844, 29138, 28373, 27558, 26702, 25799, 24865, 23901, 22908, 21896, 20874, 19831, 18781, 17729, 16674, 15629, 14584, 13542, 12517, 11505, 10507, 9537, 8581, 7649, 6747, 5870, 5036, 4232, 3462, 2737, 2049, 1410, 818, 275, -214, -649, -1027, -1350, -1607, -1801, -1934, -2001, -2001, -1935, -1804, -1602, -1330, -994, -586, -110, 434, 1048, 1720, 2450, 3243, 4077, 4953, 5865, 6787, 7718, 8655, 9573, 10465, 11325, 12135, 12898, 13603, 14247, 14830, 15349, 15806, 16207, 16553, 16849, 17099, 17307, 17479, 17618, 17726, 17810, 17871, 17916, 17940, 17945, 17935, 17907, 17865, 17807, 17726, 17630, 17515, 17378, 17217, 17033, 16824, 16586, 16322, 16030, 15704, 15348, 14960, 14540, 14089, 13598, 13073, 12513, 11915, 11288, 10626, 9927, 9195, 8436, 7642, 6821, 5970, 5086, 4181, 3249, 2298, 1320, 319, -697, -1735, -2781, -3836, -4900, -5965, -7028, -8079, -9105, -10118, -11093, -12029, -12921, -13750, -14517, -15228, -15864, -16427, -16918, -17344, -17698, -17997, -18239, -18433, -18584, -18707, -18803, -18883, -18953, -19014, -19080, -19148, -19226, -19318, -19422, -19543, -19680, -19837, -20014, -20211, -20426, -20658, -20910, -21176, -21457, -21754, -22059, -22378, -22703, -23039, -23380, -23717, -24059, -24407, -24748, -25086, -25414, -25730, -26036, -26328, -26603, -26862, -27098, -27314, -27511, -27685, -27828, -27953, -28048, -28118, -28160, -28175, -28162, -28121, -28052, -27951, -27822, -27666, -27482, -27264, -27019, -26741, -26425, -26078, -25691, -25256, -24776, -24238, -23642, -22986, -22243, -21422, -20515, -19503, -18394, -17169, -15822, -14355, -12766, -11049, -9221, -7266, -5207, -3055, -773};