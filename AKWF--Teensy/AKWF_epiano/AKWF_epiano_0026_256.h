/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0026 256 samples */
 
const int16_t AKWF_epiano_0026_256_DATA [256] = 
{751, 2575, 4381, 6204, 8037, 9875, 11720, 13532, 15307, 17038, 18697, 20294, 21811, 23232, 24562, 25792, 26910, 27930, 28837, 29642, 30346, 30944, 31447, 31868, 32205, 32450, 32620, 32724, 32768, 32750, 32671, 32544, 32375, 32167, 31906, 31604, 31272, 30911, 30526, 30111, 29670, 29198, 28701, 28190, 27668, 27130, 26572, 25994, 25405, 24804, 24187, 23558, 22912, 22255, 21596, 20925, 20236, 19534, 18827, 18127, 17413, 16692, 15967, 15242, 14518, 13797, 13078, 12368, 11665, 10976, 10305, 9643, 9008, 8403, 7825, 7273, 6756, 6281, 5834, 5417, 5045, 4710, 4406, 4138, 3900, 3685, 3493, 3314, 3149, 3000, 2854, 2706, 2560, 2409, 2251, 2078, 1890, 1689, 1482, 1272, 1064, 838, 606, 378, 140, -99, -330, -551, -768, -987, -1210, -1424, -1623, -1819, -2017, -2207, -2387, -2562, -2739, -2916, -3094, -3271, -3446, -3624, -3797, -3979, -4167, -4354, -4544, -4741, -4946, -5158, -5375, -5610, -5850, -6086, -6337, -6605, -6886, -7165, -7449, -7746, -8063, -8385, -8705, -9037, -9384, -9746, -10108, -10474, -10854, -11245, -11638, -12041, -12445, -12850, -13263, -13678, -14090, -14507, -14912, -15291, -15649, -15987, -16294, -16571, -16802, -16973, -17099, -17172, -17180, -17128, -17012, -16836, -16604, -16316, -15974, -15592, -15183, -14745, -14294, -13840, -13377, -12920, -12486, -12077, -11701, -11361, -11054, -10786, -10560, -10383, -10253, -10172, -10139, -10151, -10202, -10294, -10429, -10604, -10804, -11039, -11317, -11615, -11938, -12291, -12658, -13038, -13431, -13841, -14259, -14673, -15095, -15521, -15936, -16348, -16755, -17151, -17533, -17900, -18244, -18569, -18879, -19168, -19430, -19660, -19855, -20020, -20154, -20249, -20304, -20321, -20289, -20206, -20072, -19890, -19648, -19336, -18972, -18546, -18052, -17482, -16831, -16106, -15307, -14423, -13456, -12401, -11259, -10042, -8728, -7331, -5849, -4289, -2667, -947};