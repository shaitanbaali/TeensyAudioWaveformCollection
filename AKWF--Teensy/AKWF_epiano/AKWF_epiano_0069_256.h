/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0069 256 samples */
 
const int16_t AKWF_epiano_0069_256_DATA [256] = 
{620, 2269, 4515, 6608, 8708, 10777, 12798, 14755, 16646, 18451, 20174, 21808, 23342, 24770, 26087, 27292, 28382, 29352, 30200, 30924, 31530, 32016, 32374, 32619, 32748, 32761, 32660, 32454, 32145, 31733, 31228, 30643, 29970, 29222, 28400, 27511, 26567, 25575, 24530, 23452, 22334, 21180, 20018, 18829, 17619, 16407, 15187, 13974, 12754, 11543, 10339, 9158, 8000, 6858, 5747, 4666, 3620, 2624, 1671, 764, -82, -872, -1596, -2253, -2840, -3351, -3778, -4124, -4389, -4555, -4641, -4631, -4530, -4338, -4059, -3695, -3250, -2728, -2140, -1489, -789, -35, 754, 1573, 2414, 3276, 4145, 5023, 5905, 6776, 7646, 8497, 9338, 10163, 10974, 11761, 12528, 13274, 14005, 14716, 15405, 16072, 16719, 17352, 17964, 18553, 19124, 19679, 20216, 20727, 21220, 21694, 22141, 22567, 22972, 23348, 23700, 24024, 24312, 24567, 24788, 24975, 25124, 25222, 25286, 25301, 25265, 25184, 25045, 24857, 24613, 24310, 23951, 23527, 23041, 22488, 21874, 21188, 20435, 19613, 18717, 17744, 16694, 15564, 14360, 13085, 11722, 10290, 8788, 7215, 5595, 3928, 2209, 476, -1279, -3026, -4771, -6484, -8161, -9788, -11345, -12835, -14252, -15583, -16830, -17982, -19035, -20002, -20875, -21664, -22366, -22979, -23515, -23975, -24364, -24695, -24961, -25173, -25335, -25452, -25534, -25584, -25603, -25604, -25586, -25554, -25510, -25464, -25420, -25384, -25349, -25324, -25309, -25308, -25327, -25366, -25419, -25491, -25582, -25691, -25815, -25958, -26112, -26284, -26463, -26653, -26849, -27050, -27248, -27449, -27646, -27837, -28020, -28196, -28353, -28504, -28636, -28755, -28863, -28951, -29019, -29072, -29112, -29129, -29136, -29118, -29083, -29023, -28944, -28839, -28700, -28526, -28314, -28051, -27739, -27369, -26930, -26416, -25826, -25146, -24376, -23500, -22533, -21459, -20266, -18967, -17561, -16041, -14427, -12712, -10895, -9003, -7041, -5017, -2971, -760};