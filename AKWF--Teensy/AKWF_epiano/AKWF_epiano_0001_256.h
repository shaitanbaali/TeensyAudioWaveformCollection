/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0001 256 samples */
 
const int16_t AKWF_epiano_0001_256_DATA [256] = 
{813, 3099, 5313, 7630, 9953, 12363, 14725, 17016, 19265, 21393, 23392, 25209, 26874, 28332, 29600, 30635, 31486, 32101, 32503, 32723, 32744, 32494, 32267, 31881, 31260, 30709, 29941, 29197, 28413, 27525, 26704, 25812, 24989, 24116, 23288, 22403, 21543, 20748, 19914, 19149, 18331, 17593, 16852, 16170, 15441, 14806, 14135, 13503, 12904, 12336, 11783, 11244, 10712, 10212, 9716, 9216, 8775, 8299, 7857, 7433, 6967, 6540, 6132, 5654, 5236, 4809, 4346, 3929, 3484, 3044, 2601, 2139, 1697, 1229, 787, 340, -153, -608, -1046, -1539, -2003, -2472, -2975, -3411, -3872, -4347, -4818, -5270, -5718, -6171, -6638, -7105, -7539, -8024, -8452, -8898, -9361, -9805, -10284, -10741, -11199, -11658, -12117, -12578, -13082, -13522, -14005, -14491, -14945, -15443, -15895, -16383, -16859, -17332, -17802, -18285, -18731, -19225, -19675, -20120, -20591, -20979, -21419, -21814, -22173, -22562, -22904, -23235, -23570, -23830, -24105, -24332, -24493, -24653, -24787, -24854, -24881, -24865, -24788, -24660, -24448, -24164, -23809, -23348, -22817, -22133, -21309, -20376, -19238, -18011, -16636, -15079, -13365, -11540, -9555, -7470, -5268, -3001, -691, 1673, 3941, 6201, 8388, 10462, 12391, 14133, 15712, 17101, 18270, 19221, 19953, 20458, 20785, 20933, 20855, 20643, 20269, 19770, 19149, 18399, 17594, 16718, 15800, 14859, 13853, 12824, 11842, 10780, 9789, 8829, 7821, 6872, 5927, 5010, 4193, 3325, 2520, 1749, 982, 273, -404, -1022, -1644, -2283, -2869, -3396, -3987, -4468, -4976, -5481, -5924, -6444, -6860, -7313, -7751, -8152, -8594, -9001, -9451, -9844, -10256, -10654, -11068, -11459, -11845, -12268, -12620, -12985, -13365, -13674, -14006, -14330, -14622, -14892, -15114, -15310, -15480, -15589, -15657, -15633, -15559, -15429, -15212, -14871, -14435, -13921, -13291, -12534, -11602, -10571, -9371, -8042, -6564, -4921, -3183, -1231};