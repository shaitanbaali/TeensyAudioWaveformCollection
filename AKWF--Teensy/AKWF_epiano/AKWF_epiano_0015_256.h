/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0015 256 samples */
 
const int16_t AKWF_epiano_0015_256_DATA [256] = 
{174, 584, 1113, 1351, 1519, 1733, 1931, 2300, 2987, 3730, 4628, 5642, 6433, 7045, 7602, 7718, 7825, 7973, 8091, 8452, 9169, 9921, 10894, 11956, 12810, 13508, 14085, 14236, 14362, 14521, 14639, 15012, 15746, 16496, 17521, 18595, 19447, 20186, 20734, 20891, 21005, 21095, 21146, 21466, 22097, 22738, 23713, 24720, 25485, 26181, 26657, 26744, 26793, 26779, 26746, 26970, 27450, 27987, 28803, 29652, 30272, 30826, 31132, 31018, 30918, 30697, 30427, 30440, 30634, 30914, 31463, 32007, 32366, 32660, 32684, 32312, 31941, 31394, 30811, 30511, 30355, 30295, 30492, 30669, 30670, 30618, 30264, 29572, 28857, 27940, 26994, 26315, 25755, 25311, 25159, 24965, 24596, 24218, 23470, 22427, 21332, 20042, 18751, 17686, 16738, 15952, 15440, 14890, 14193, 13511, 12428, 11088, 9688, 8095, 6503, 5206, 4005, 3009, 2332, 1624, 842, 88, -1033, -2372, -3747, -5286, -6801, -7985, -9112, -9953, -10508, -11084, -11646, -12206, -13037, -14039, -15046, -16129, -17189, -17954, -18696, -19173, -19444, -19699, -19878, -20055, -20402, -20813, -21283, -21870, -22448, -22910, -23373, -23624, -23719, -23772, -23653, -23563, -23553, -23540, -23663, -23897, -24130, -24368, -24616, -24713, -24710, -24644, -24415, -24188, -24024, -23874, -23847, -23917, -23989, -24077, -24171, -24146, -24066, -23908, -23630, -23373, -23145, -22913, -22766, -22708, -22652, -22638, -22618, -22505, -22373, -22178, -21907, -21640, -21398, -21165, -21016, -20942, -20870, -20864, -20860, -20766, -20692, -20533, -20279, -20041, -19816, -19578, -19434, -19337, -19270, -19276, -19266, -19187, -19090, -18884, -18552, -18232, -17839, -17446, -17157, -16910, -16721, -16611, -16499, -16301, -16093, -15715, -15204, -14675, -14041, -13393, -12911, -12455, -12127, -11944, -11734, -11452, -11151, -10612, -9931, -9214, -8353, -7523, -6864, -6255, -5823, -5608, -5336, -5017, -4707, -4054, -3290, -2436, -1431, -489};