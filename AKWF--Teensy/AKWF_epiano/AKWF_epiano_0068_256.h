/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0068 256 samples */
 
const int16_t AKWF_epiano_0068_256_DATA [256] = 
{658, 2889, 5090, 7293, 9459, 11606, 13705, 15729, 17690, 19550, 21320, 22987, 24539, 25972, 27278, 28449, 29489, 30391, 31152, 31768, 32233, 32554, 32733, 32760, 32641, 32380, 31979, 31442, 30776, 29979, 29068, 28054, 26935, 25728, 24435, 23072, 21657, 20198, 18693, 17168, 15626, 14071, 12528, 10992, 9462, 7960, 6480, 5032, 3617, 2228, 883, -425, -1694, -2920, -4099, -5234, -6312, -7339, -8298, -9196, -10018, -10768, -11437, -12001, -12471, -12842, -13096, -13231, -13252, -13151, -12927, -12591, -12136, -11585, -10942, -10215, -9420, -8571, -7675, -6739, -5784, -4815, -3833, -2855, -1873, -903, 47, 993, 1924, 2835, 3734, 4609, 5475, 6327, 7168, 7996, 8817, 9620, 10428, 11233, 12035, 12831, 13636, 14446, 15257, 16075, 16896, 17720, 18559, 19396, 20232, 21079, 21910, 22741, 23568, 24380, 25176, 25952, 26705, 27432, 28134, 28793, 29423, 30007, 30540, 31031, 31467, 31842, 32166, 32418, 32601, 32709, 32742, 32696, 32554, 32329, 31997, 31558, 31004, 30330, 29532, 28586, 27484, 26226, 24809, 23219, 21456, 19520, 17413, 15139, 12722, 10179, 7519, 4778, 1974, -824, -3621, -6385, -9059, -11637, -14083, -16362, -18499, -20464, -22237, -23831, -25240, -26459, -27511, -28395, -29113, -29675, -30094, -30376, -30528, -30567, -30495, -30330, -30073, -29737, -29332, -28866, -28345, -27782, -27182, -26550, -25905, -25246, -24584, -23931, -23289, -22672, -22076, -21513, -20993, -20515, -20087, -19707, -19381, -19108, -18891, -18726, -18611, -18542, -18522, -18546, -18601, -18696, -18823, -18974, -19143, -19339, -19554, -19771, -19989, -20217, -20442, -20670, -20896, -21122, -21342, -21567, -21792, -22016, -22247, -22477, -22712, -22947, -23178, -23397, -23596, -23772, -23907, -23995, -24016, -23968, -23835, -23615, -23303, -22899, -22396, -21789, -21084, -20279, -19356, -18316, -17161, -15871, -14466, -12929, -11262, -9487, -7603, -5627, -3593, -1435};