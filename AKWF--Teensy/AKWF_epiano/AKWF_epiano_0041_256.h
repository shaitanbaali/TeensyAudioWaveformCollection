/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0041 256 samples */
 
const int16_t AKWF_epiano_0041_256_DATA [256] = 
{649, 2466, 4282, 6130, 7989, 9853, 11698, 13527, 15323, 17063, 18734, 20335, 21853, 23280, 24612, 25840, 26961, 27975, 28885, 29685, 30386, 30990, 31494, 31903, 32231, 32478, 32646, 32740, 32767, 32740, 32652, 32506, 32315, 32080, 31806, 31493, 31144, 30761, 30350, 29913, 29451, 28963, 28455, 27930, 27382, 26816, 26239, 25642, 25031, 24412, 23773, 23121, 22459, 21785, 21102, 20408, 19701, 18983, 18258, 17527, 16795, 16052, 15307, 14560, 13814, 13075, 12344, 11612, 10893, 10189, 9499, 8832, 8182, 7559, 6966, 6400, 5869, 5377, 4916, 4496, 4113, 3763, 3452, 3177, 2932, 2713, 2517, 2343, 2190, 2049, 1909, 1779, 1656, 1524, 1392, 1260, 1119, 972, 821, 662, 502, 338, 176, 13, -152, -313, -471, -626, -777, -922, -1062, -1194, -1319, -1441, -1552, -1658, -1764, -1864, -1960, -2057, -2151, -2242, -2342, -2443, -2543, -2652, -2765, -2881, -3012, -3149, -3291, -3447, -3614, -3791, -3985, -4191, -4405, -4635, -4880, -5136, -5407, -5692, -5995, -6311, -6638, -6980, -7333, -7701, -8088, -8488, -8897, -9322, -9757, -10210, -10676, -11153, -11634, -12123, -12616, -13111, -13604, -14087, -14555, -14997, -15416, -15807, -16159, -16464, -16715, -16916, -17059, -17138, -17152, -17104, -16996, -16826, -16603, -16327, -16011, -15661, -15280, -14879, -14473, -14062, -13656, -13269, -12897, -12551, -12235, -11952, -11710, -11511, -11352, -11235, -11164, -11138, -11154, -11216, -11313, -11448, -11623, -11826, -12062, -12338, -12640, -12961, -13301, -13662, -14038, -14428, -14824, -15223, -15624, -16028, -16428, -16820, -17204, -17575, -17932, -18272, -18590, -18893, -19170, -19421, -19647, -19840, -20001, -20134, -20230, -20283, -20303, -20280, -20210, -20095, -19935, -19723, -19459, -19141, -18763, -18325, -17825, -17260, -16627, -15925, -15147, -14284, -13344, -12323, -11212, -10019, -8734, -7363, -5908, -4372, -2763, -1049};