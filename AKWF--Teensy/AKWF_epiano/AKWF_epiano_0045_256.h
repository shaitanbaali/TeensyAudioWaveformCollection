/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0045 256 samples */
 
const int16_t AKWF_epiano_0045_256_DATA [256] = 
{1255, 3570, 5860, 8128, 10377, 12582, 14731, 16788, 18760, 20612, 22349, 23963, 25440, 26778, 27973, 29018, 29938, 30717, 31360, 31875, 32271, 32544, 32714, 32771, 32734, 32604, 32380, 32069, 31692, 31235, 30714, 30134, 29494, 28809, 28073, 27297, 26483, 25635, 24749, 23849, 22922, 21982, 21022, 20051, 19076, 18097, 17113, 16142, 15170, 14204, 13250, 12319, 11401, 10497, 9618, 8762, 7930, 7139, 6376, 5647, 4953, 4302, 3693, 3128, 2610, 2137, 1714, 1344, 1029, 767, 559, 401, 302, 266, 293, 380, 530, 743, 1017, 1361, 1763, 2231, 2762, 3344, 3984, 4660, 5382, 6146, 6929, 7718, 8518, 9319, 10109, 10879, 11610, 12302, 12953, 13549, 14091, 14582, 15013, 15381, 15689, 15947, 16157, 16313, 16428, 16503, 16542, 16555, 16543, 16495, 16433, 16351, 16251, 16129, 15994, 15842, 15680, 15498, 15300, 15083, 14848, 14597, 14328, 14035, 13723, 13392, 13039, 12662, 12258, 11834, 11383, 10913, 10417, 9895, 9338, 8761, 8158, 7529, 6878, 6202, 5506, 4781, 4046, 3291, 2509, 1718, 916, 100, -714, -1543, -2378, -3210, -4046, -4864, -5673, -6474, -7256, -8010, -8743, -9448, -10121, -10767, -11365, -11939, -12466, -12958, -13416, -13834, -14213, -14571, -14890, -15190, -15470, -15726, -15964, -16195, -16420, -16636, -16862, -17087, -17315, -17562, -17816, -18085, -18372, -18668, -18982, -19316, -19663, -20030, -20413, -20800, -21210, -21630, -22054, -22482, -22920, -23356, -23798, -24244, -24680, -25114, -25535, -25949, -26360, -26761, -27144, -27506, -27855, -28185, -28498, -28783, -29043, -29285, -29500, -29690, -29856, -29989, -30094, -30170, -30218, -30238, -30222, -30172, -30091, -29975, -29828, -29636, -29408, -29138, -28822, -28460, -28051, -27587, -27065, -26483, -25836, -25119, -24319, -23439, -22477, -21424, -20264, -19008, -17655, -16192, -14617, -12941, -11155, -9272, -7316, -5259, -3139, -911};