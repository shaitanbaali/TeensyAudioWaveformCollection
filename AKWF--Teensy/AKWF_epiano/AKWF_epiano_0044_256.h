/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0044 256 samples */
 
const int16_t AKWF_epiano_0044_256_DATA [256] = 
{1343, 3717, 6056, 8419, 10751, 13039, 15265, 17387, 19402, 21306, 23070, 24693, 26157, 27476, 28642, 29650, 30510, 31221, 31793, 32230, 32530, 32712, 32769, 32717, 32558, 32297, 31944, 31501, 30978, 30382, 29713, 28983, 28197, 27355, 26474, 25547, 24585, 23591, 22573, 21539, 20488, 19423, 18350, 17276, 16202, 15138, 14076, 13026, 11990, 10965, 9961, 8982, 8017, 7080, 6172, 5290, 4449, 3639, 2862, 2130, 1442, 795, 198, -348, -847, -1291, -1673, -2000, -2267, -2471, -2611, -2687, -2692, -2635, -2506, -2308, -2037, -1695, -1278, -789, -228, 406, 1115, 1881, 2716, 3605, 4532, 5498, 6480, 7474, 8469, 9447, 10390, 11304, 12161, 12968, 13715, 14396, 15014, 15567, 16057, 16490, 16865, 17191, 17472, 17711, 17916, 18090, 18231, 18349, 18446, 18519, 18575, 18615, 18639, 18639, 18624, 18591, 18542, 18467, 18374, 18257, 18113, 17946, 17747, 17520, 17265, 16978, 16654, 16299, 15907, 15480, 15016, 14511, 13970, 13392, 12772, 12117, 11420, 10691, 9924, 9124, 8289, 7425, 6530, 5602, 4648, 3665, 2657, 1617, 560, -528, -1639, -2763, -3910, -5072, -6238, -7413, -8585, -9729, -10863, -11963, -13025, -14031, -14967, -15834, -16623, -17324, -17936, -18456, -18891, -19239, -19506, -19706, -19846, -19931, -19973, -19987, -19973, -19944, -19910, -19874, -19846, -19823, -19814, -19823, -19853, -19902, -19974, -20069, -20190, -20329, -20493, -20679, -20887, -21113, -21355, -21611, -21890, -22173, -22470, -22778, -23087, -23410, -23742, -24072, -24397, -24719, -25033, -25341, -25634, -25912, -26173, -26417, -26639, -26840, -27018, -27170, -27295, -27394, -27466, -27509, -27525, -27512, -27474, -27403, -27305, -27181, -27030, -26854, -26646, -26410, -26147, -25852, -25527, -25164, -24761, -24315, -23815, -23261, -22643, -21950, -21172, -20308, -19338, -18270, -17084, -15773, -14338, -12773, -11080, -9273, -7340, -5293, -3154, -882};