/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0027 256 samples */
 
const int16_t AKWF_epiano_0027_256_DATA [256] = 
{966, 3583, 6201, 8831, 11424, 13959, 16379, 18676, 20826, 22807, 24599, 26208, 27624, 28853, 29906, 30777, 31472, 32014, 32404, 32650, 32762, 32750, 32621, 32373, 32023, 31566, 31024, 30394, 29678, 28883, 28021, 27098, 26118, 25082, 24000, 22877, 21731, 20551, 19354, 18142, 16919, 15696, 14481, 13277, 12093, 10927, 9781, 8668, 7590, 6546, 5527, 4542, 3590, 2665, 1779, 916, 78, -723, -1498, -2241, -2939, -3607, -4233, -4812, -5344, -5811, -6216, -6561, -6826, -7025, -7136, -7168, -7117, -6978, -6749, -6437, -6034, -5543, -4961, -4282, -3512, -2641, -1672, -617, 516, 1720, 2962, 4230, 5501, 6740, 7943, 9080, 10128, 11106, 11984, 12769, 13470, 14082, 14617, 15100, 15511, 15885, 16215, 16512, 16791, 17047, 17296, 17532, 17760, 17989, 18206, 18426, 18641, 18848, 19043, 19232, 19416, 19584, 19729, 19857, 19973, 20062, 20121, 20154, 20154, 20114, 20041, 19925, 19767, 19564, 19310, 19010, 18665, 18264, 17818, 17317, 16762, 16153, 15495, 14779, 14015, 13199, 12333, 11417, 10450, 9436, 8383, 7282, 6131, 4923, 3664, 2350, 981, -452, -1948, -3499, -5096, -6730, -8386, -10049, -11696, -13300, -14829, -16245, -17548, -18702, -19687, -20495, -21119, -21564, -21847, -21984, -21988, -21891, -21708, -21469, -21194, -20892, -20587, -20284, -19993, -19720, -19475, -19251, -19052, -18884, -18740, -18630, -18550, -18496, -18467, -18472, -18499, -18558, -18650, -18766, -18914, -19083, -19281, -19506, -19749, -20015, -20302, -20604, -20913, -21230, -21546, -21865, -22189, -22505, -22809, -23099, -23378, -23634, -23871, -24085, -24269, -24425, -24554, -24647, -24714, -24749, -24755, -24729, -24672, -24594, -24484, -24356, -24215, -24054, -23876, -23689, -23499, -23295, -23086, -22868, -22636, -22385, -22111, -21802, -21445, -21029, -20535, -19955, -19259, -18438, -17484, -16369, -15093, -13654, -12035, -10244, -8286, -6159, -3898, -1465};