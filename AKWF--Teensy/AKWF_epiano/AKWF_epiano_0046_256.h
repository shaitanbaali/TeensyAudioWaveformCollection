/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0046 256 samples */
 
const int16_t AKWF_epiano_0046_256_DATA [256] = 
{1752, 5559, 9381, 13197, 16825, 20157, 23102, 25578, 27608, 29214, 30432, 31326, 31957, 32379, 32632, 32750, 32760, 32679, 32520, 32293, 32007, 31665, 31275, 30838, 30358, 29835, 29270, 28665, 28024, 27339, 26613, 25846, 25038, 24200, 23334, 22439, 21533, 20615, 19692, 18778, 17855, 16934, 16014, 15090, 14162, 13241, 12311, 11387, 10474, 9570, 8683, 7809, 6943, 6086, 5237, 4389, 3553, 2721, 1899, 1093, 310, -444, -1169, -1872, -2552, -3208, -3846, -4471, -5077, -5668, -6236, -6768, -7270, -7740, -8182, -8618, -9070, -9567, -10141, -10796, -11514, -12248, -12906, -13396, -13624, -13529, -13105, -12394, -11494, -10499, -9514, -8617, -7857, -7247, -6778, -6427, -6171, -5987, -5852, -5750, -5665, -5588, -5512, -5429, -5336, -5229, -5106, -4963, -4802, -4623, -4426, -4211, -3982, -3739, -3483, -3214, -2936, -2648, -2355, -2060, -1772, -1493, -1230, -987, -772, -588, -435, -317, -235, -188, -176, -200, -261, -356, -489, -658, -863, -1102, -1372, -1674, -2004, -2353, -2717, -3097, -3482, -3877, -4274, -4674, -5077, -5490, -5905, -6325, -6752, -7180, -7612, -8046, -8478, -8911, -9334, -9742, -10127, -10465, -10734, -10913, -10974, -10893, -10646, -10207, -9552, -8658, -7523, -6168, -4651, -3053, -1468, 43, 1403, 2584, 3573, 4369, 4996, 5472, 5818, 6051, 6186, 6238, 6212, 6116, 5958, 5737, 5462, 5136, 4756, 4327, 3849, 3321, 2745, 2115, 1429, 693, -97, -931, -1798, -2714, -3662, -4617, -5576, -6528, -7466, -8390, -9288, -10151, -10974, -11743, -12459, -13113, -13701, -14218, -14669, -15051, -15367, -15621, -15818, -15960, -16051, -16094, -16094, -16056, -15984, -15883, -15757, -15613, -15453, -15284, -15112, -14936, -14761, -14592, -14431, -14282, -14148, -14034, -13948, -13895, -13873, -13876, -13880, -13836, -13674, -13297, -12594, -11463, -9818, -7625, -4913, -1660};