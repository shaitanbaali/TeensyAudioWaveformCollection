/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0023 256 samples */
 
const int16_t AKWF_epiano_0023_256_DATA [256] = 
{1131, 3696, 6116, 8447, 10678, 12817, 14868, 16830, 18711, 20515, 22230, 23862, 25397, 26821, 28128, 29297, 30309, 31151, 31805, 32255, 32497, 32524, 32339, 31952, 31379, 30641, 29759, 28762, 27675, 26517, 25312, 24076, 22818, 21556, 20296, 19040, 17800, 16572, 15358, 14159, 12970, 11790, 10624, 9472, 8342, 7250, 6202, 5216, 4307, 3481, 2750, 2119, 1586, 1151, 814, 571, 418, 353, 371, 467, 634, 860, 1138, 1457, 1808, 2185, 2580, 2991, 3408, 3830, 4247, 4651, 5029, 5371, 5667, 5909, 6092, 6213, 6275, 6280, 6234, 6142, 6006, 5830, 5615, 5360, 5068, 4733, 4359, 3940, 3470, 2944, 2357, 1698, 965, 151, -742, -1709, -2741, -3825, -4940, -6069, -7193, -8287, -9339, -10336, -11261, -12114, -12890, -13589, -14218, -14788, -15305, -15787, -16245, -16690, -17132, -17572, -18010, -18445, -18865, -19257, -19606, -19894, -20105, -20225, -20242, -20150, -19945, -19634, -19224, -18729, -18168, -17561, -16928, -16293, -15668, -15069, -14508, -13984, -13503, -13059, -12645, -12250, -11862, -11465, -11047, -10595, -10098, -9555, -8963, -8326, -7657, -6969, -6272, -5585, -4920, -4283, -3685, -3127, -2605, -2121, -1667, -1236, -818, -404, 19, 462, 939, 1461, 2033, 2660, 3342, 4070, 4839, 5639, 6459, 7293, 8132, 8970, 9806, 10636, 11454, 12261, 13046, 13807, 14537, 15229, 15880, 16487, 17043, 17545, 17986, 18358, 18652, 18861, 18974, 18983, 18884, 18674, 18353, 17918, 17375, 16718, 15946, 15057, 14043, 12901, 11627, 10215, 8669, 6997, 5194, 3276, 1259, -853, -3038, -5273, -7548, -9827, -12084, -14302, -16445, -18494, -20434, -22241, -23911, -25440, -26820, -28056, -29150, -30100, -30912, -31584, -32111, -32489, -32710, -32766, -32646, -32336, -31824, -31097, -30148, -28971, -27557, -25915, -24057, -21988, -19736, -17331, -14793, -12168, -9489, -6785, -4098, -1397};