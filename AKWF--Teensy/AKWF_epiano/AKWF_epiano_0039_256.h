/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0039 256 samples */
 
const int16_t AKWF_epiano_0039_256_DATA [256] = 
{1000, 4249, 7628, 11055, 14435, 17635, 20570, 23168, 25403, 27277, 28813, 30036, 30986, 31691, 32191, 32522, 32706, 32769, 32726, 32595, 32388, 32111, 31777, 31387, 30946, 30463, 29930, 29359, 28750, 28102, 27423, 26718, 25978, 25214, 24425, 23620, 22792, 21946, 21081, 20205, 19323, 18429, 17526, 16618, 15704, 14791, 13879, 12960, 12044, 11127, 10211, 9307, 8409, 7512, 6632, 5759, 4902, 4065, 3240, 2432, 1646, 875, 131, -586, -1289, -1962, -2613, -3240, -3832, -4400, -4944, -5454, -5937, -6388, -6803, -7190, -7543, -7866, -8160, -8424, -8647, -8822, -8926, -8937, -8840, -8625, -8293, -7868, -7379, -6873, -6377, -5922, -5529, -5209, -4956, -4771, -4640, -4553, -4501, -4471, -4459, -4454, -4449, -4440, -4423, -4396, -4358, -4310, -4249, -4177, -4093, -3999, -3895, -3780, -3660, -3533, -3405, -3272, -3139, -3005, -2878, -2759, -2647, -2548, -2463, -2390, -2339, -2307, -2299, -2314, -2352, -2415, -2505, -2620, -2760, -2923, -3107, -3318, -3543, -3791, -4056, -4335, -4628, -4932, -5246, -5567, -5897, -6228, -6561, -6895, -7230, -7566, -7897, -8227, -8555, -8883, -9211, -9536, -9857, -10177, -10486, -10781, -11054, -11295, -11488, -11615, -11652, -11570, -11331, -10901, -10245, -9358, -8235, -6927, -5485, -3989, -2516, -1126, 142, 1250, 2189, 2962, 3570, 4031, 4360, 4568, 4667, 4667, 4579, 4410, 4167, 3854, 3479, 3046, 2556, 2019, 1437, 815, 157, -535, -1257, -2005, -2772, -3544, -4323, -5106, -5891, -6667, -7429, -8169, -8891, -9585, -10249, -10878, -11467, -12019, -12531, -12999, -13424, -13803, -14137, -14429, -14679, -14888, -15057, -15193, -15293, -15361, -15399, -15410, -15397, -15363, -15307, -15237, -15150, -15048, -14938, -14817, -14684, -14542, -14389, -14225, -14046, -13851, -13631, -13377, -13078, -12706, -12229, -11606, -10784, -9709, -8324, -6568, -4427, -1817};