/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0006 256 samples */
 
const int16_t AKWF_epiano_0006_256_DATA [256] = 
{1295, 6396, 11505, 16429, 20917, 24827, 27978, 30345, 31881, 32662, 32734, 32223, 31269, 29984, 28494, 26892, 25271, 23683, 22159, 20739, 19395, 18157, 17025, 15957, 14967, 14043, 13198, 12397, 11658, 10977, 10382, 9828, 9355, 8956, 8629, 8336, 8106, 7880, 7709, 7533, 7377, 7235, 7090, 6940, 6813, 6684, 6560, 6437, 6301, 6165, 6031, 5894, 5762, 5638, 5489, 5343, 5207, 5071, 4932, 4795, 4649, 4492, 4345, 4198, 4041, 3901, 3744, 3594, 3462, 3337, 3200, 3094, 2979, 2866, 2780, 2680, 2594, 2502, 2428, 2345, 2286, 2214, 2144, 2054, 2007, 1927, 1871, 1807, 1748, 1680, 1608, 1570, 1516, 1477, 1428, 1402, 1342, 1305, 1259, 1222, 1156, 1123, 1062, 1013, 934, 888, 807, 743, 669, 584, 500, 403, 301, 200, 118, 6, -84, -192, -277, -385, -491, -614, -719, -858, -959, -1081, -1186, -1312, -1440, -1554, -1659, -1772, -1908, -2016, -2136, -2235, -2344, -2429, -2548, -2645, -2740, -2821, -2914, -2991, -3068, -3147, -3222, -3287, -3349, -3426, -3491, -3564, -3609, -3661, -3698, -3771, -3797, -3847, -3882, -3934, -3962, -3990, -4028, -4060, -4078, -4103, -4130, -4159, -4174, -4203, -4217, -4247, -4269, -4299, -4332, -4365, -4391, -4417, -4468, -4499, -4550, -4588, -4646, -4692, -4751, -4805, -4858, -4925, -4998, -5050, -5123, -5202, -5283, -5383, -5479, -5599, -5713, -5852, -6008, -6161, -6310, -6488, -6661, -6848, -7048, -7274, -7503, -7735, -7968, -8229, -8496, -8758, -9044, -9346, -9681, -10020, -10387, -10767, -11189, -11610, -12071, -12552, -13052, -13532, -14042, -14552, -15066, -15588, -16107, -16634, -17137, -17634, -18111, -18567, -18991, -19400, -19780, -20143, -20497, -20819, -21141, -21443, -21706, -21922, -22069, -22108, -21995, -21637, -20994, -19983, -18454, -16404, -13716, -10411, -6516, -2084};