/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0018 256 samples */
 
const int16_t AKWF_epiano_0018_256_DATA [256] = 
{902, 3449, 5895, 8370, 10828, 13236, 15569, 17799, 19910, 21903, 23736, 25415, 26911, 28230, 29368, 30333, 31130, 31757, 32228, 32545, 32718, 32768, 32698, 32533, 32271, 31934, 31513, 31030, 30498, 29921, 29307, 28668, 28002, 27309, 26601, 25882, 25162, 24443, 23712, 22973, 22234, 21496, 20769, 20044, 19318, 18592, 17873, 17152, 16439, 15733, 15043, 14359, 13673, 12996, 12328, 11675, 11030, 10399, 9779, 9170, 8573, 7977, 7400, 6841, 6280, 5736, 5198, 4657, 4126, 3603, 3090, 2570, 2054, 1529, 1005, 480, -43, -567, -1100, -1642, -2192, -2744, -3301, -3855, -4427, -4998, -5579, -6164, -6762, -7355, -7949, -8548, -9163, -9777, -10390, -11003, -11617, -12229, -12845, -13473, -14090, -14723, -15350, -15972, -16600, -17246, -17896, -18550, -19214, -19885, -20553, -21235, -21924, -22624, -23327, -24027, -24729, -25432, -26123, -26809, -27486, -28145, -28772, -29370, -29923, -30443, -30912, -31330, -31685, -31956, -32138, -32243, -32244, -32149, -31939, -31602, -31140, -30531, -29788, -28899, -27854, -26654, -25284, -23759, -22083, -20251, -18281, -16190, -13977, -11660, -9269, -6818, -4331, -1835, 640, 3070, 5426, 7705, 9863, 11887, 13774, 15497, 17048, 18424, 19612, 20623, 21462, 22126, 22617, 22940, 23114, 23150, 23064, 22863, 22555, 22159, 21682, 21131, 20529, 19879, 19193, 18475, 17728, 16950, 16164, 15363, 14560, 13748, 12935, 12114, 11284, 10457, 9627, 8809, 7982, 7144, 6312, 5470, 4629, 3790, 2962, 2130, 1299, 465, -363, -1180, -1983, -2793, -3584, -4370, -5153, -5918, -6669, -7408, -8126, -8838, -9544, -10238, -10916, -11583, -12230, -12871, -13504, -14122, -14735, -15320, -15890, -16441, -16978, -17500, -17992, -18456, -18889, -19270, -19608, -19900, -20134, -20287, -20353, -20333, -20210, -19970, -19606, -19115, -18484, -17689, -16750, -15649, -14381, -12955, -11379, -9658, -7799, -5815, -3732, -1535};