/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0010 256 samples */
 
const int16_t AKWF_epiano_0010_256_DATA [256] = 
{329, 1205, 2123, 3087, 4097, 5153, 6242, 7363, 8522, 9696, 10883, 12108, 13344, 14561, 15779, 17007, 18211, 19390, 20559, 21694, 22781, 23831, 24845, 25813, 26722, 27582, 28382, 29114, 29786, 30387, 30910, 31374, 31781, 32110, 32365, 32568, 32706, 32763, 32762, 32710, 32592, 32415, 32199, 31932, 31606, 31236, 30834, 30390, 29903, 29381, 28830, 28251, 27644, 27008, 26350, 25677, 24981, 24257, 23521, 22781, 22019, 21240, 20464, 19675, 18866, 18059, 17254, 16428, 15588, 14756, 13926, 13090, 12255, 11415, 10570, 9725, 8892, 8056, 7215, 6384, 5555, 4713, 3876, 3056, 2232, 1406, 594, -214, -1024, -1823, -2614, -3405, -4190, -4967, -5737, -6499, -7245, -7988, -8740, -9481, -10202, -10925, -11642, -12337, -13028, -13721, -14401, -15074, -15747, -16409, -17054, -17696, -18333, -18953, -19563, -20175, -20778, -21369, -21951, -22526, -23080, -23623, -24156, -24667, -25162, -25654, -26132, -26589, -27032, -27453, -27849, -28235, -28611, -28953, -29265, -29568, -29851, -30104, -30329, -30524, -30683, -30821, -30935, -31004, -31037, -31047, -31011, -30924, -30811, -30662, -30444, -30176, -29884, -29539, -29127, -28675, -28164, -27572, -26939, -26272, -25523, -24709, -23877, -22978, -21992, -20985, -19964, -18860, -17703, -16557, -15365, -14100, -12860, -11630, -10319, -9023, -7808, -6527, -5201, -4027, -2877, -1538, -357, 267, 739, 1670, 2869, 3840, 4653, 5547, 6390, 7068, 7713, 8339, 8838, 9255, 9657, 9973, 10184, 10370, 10508, 10535, 10508, 10459, 10325, 10112, 9885, 9624, 9289, 8920, 8532, 8090, 7609, 7121, 6604, 6048, 5492, 4932, 4336, 3734, 3146, 2545, 1942, 1358, 775, 187, -373, -911, -1448, -1963, -2432, -2884, -3326, -3720, -4072, -4407, -4703, -4944, -5152, -5323, -5427, -5479, -5493, -5450, -5345, -5200, -5004, -4734, -4399, -4009, -3552, -3037, -2475, -1848, -1153, -389};