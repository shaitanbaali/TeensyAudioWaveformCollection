/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0004 256 samples */
 
const int16_t AKWF_epiano_0004_256_DATA [256] = 
{253, 965, 1665, 2341, 2974, 3565, 4121, 4646, 5141, 5604, 6039, 6452, 6836, 7184, 7495, 7775, 8038, 8296, 8543, 8768, 8960, 9116, 9252, 9389, 9540, 9707, 9872, 10021, 10146, 10262, 10391, 10547, 10728, 10921, 11120, 11330, 11566, 11834, 12128, 12434, 12749, 13080, 13438, 13827, 14244, 14682, 15141, 15627, 16139, 16678, 17236, 17808, 18396, 18998, 19611, 20238, 20874, 21522, 22182, 22846, 23504, 24154, 24793, 25426, 26058, 26679, 27279, 27854, 28402, 28931, 29442, 29928, 30377, 30782, 31143, 31472, 31773, 32038, 32256, 32421, 32545, 32646, 32726, 32767, 32746, 32657, 32521, 32365, 32201, 32015, 31776, 31474, 31123, 30748, 30362, 29956, 29508, 29016, 28485, 27932, 27372, 26798, 26202, 25584, 24940, 24276, 23592, 22885, 22160, 21430, 20699, 19967, 19225, 18459, 17668, 16868, 16070, 15284, 14503, 13711, 12905, 12089, 11268, 10453, 9640, 8823, 8001, 7178, 6358, 5545, 4733, 3924, 3122, 2327, 1532, 734, -66, -860, -1636, -2397, -3160, -3935, -4721, -5499, -6251, -6982, -7705, -8434, -9166, -9884, -10574, -11247, -11915, -12585, -13254, -13909, -14545, -15176, -15806, -16432, -17045, -17627, -18187, -18739, -19285, -19824, -20344, -20844, -21345, -21864, -22399, -22928, -23413, -23838, -24223, -24609, -25030, -25491, -25953, -26369, -26717, -27015, -27308, -27638, -28003, -28368, -28694, -28961, -29190, -29410, -29642, -29880, -30100, -30288, -30449, -30598, -30742, -30875, -30985, -31072, -31145, -31210, -31262, -31281, -31251, -31182, -31104, -31034, -30967, -30869, -30715, -30506, -30269, -30038, -29815, -29568, -29264, -28896, -28487, -28072, -27663, -27239, -26773, -26249, -25680, -25088, -24482, -23851, -23189, -22492, -21775, -21048, -20297, -19507, -18678, -17825, -16971, -16124, -15260, -14360, -13430, -12493, -11574, -10676, -9770, -8842, -7906, -6984, -6098, -5237, -4373, -3503, -2653, -1854, -1122, -419};