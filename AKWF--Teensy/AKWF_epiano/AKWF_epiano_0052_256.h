/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0052 256 samples */
 
const int16_t AKWF_epiano_0052_256_DATA [256] = 
{961, 3400, 5836, 8292, 10736, 13128, 15465, 17703, 19828, 21806, 23630, 25294, 26790, 28106, 29248, 30213, 31017, 31660, 32149, 32489, 32694, 32768, 32718, 32551, 32276, 31898, 31423, 30856, 30205, 29470, 28662, 27789, 26852, 25859, 24815, 23725, 22600, 21452, 20273, 19077, 17869, 16655, 15447, 14247, 13052, 11876, 10717, 9580, 8481, 7403, 6352, 5337, 4348, 3394, 2480, 1591, 739, -75, -854, -1585, -2274, -2921, -3514, -4049, -4524, -4937, -5279, -5550, -5748, -5865, -5905, -5867, -5748, -5547, -5268, -4908, -4464, -3938, -3325, -2624, -1846, -976, -27, 989, 2071, 3195, 4344, 5511, 6667, 7792, 8879, 9906, 10866, 11757, 12568, 13303, 13967, 14559, 15091, 15565, 15993, 16379, 16731, 17051, 17356, 17640, 17911, 18175, 18429, 18676, 18919, 19154, 19382, 19604, 19815, 20016, 20204, 20376, 20530, 20666, 20771, 20853, 20905, 20924, 20905, 20849, 20749, 20604, 20413, 20175, 19886, 19542, 19145, 18696, 18193, 17635, 17018, 16343, 15617, 14833, 14002, 13113, 12172, 11175, 10129, 9038, 7891, 6690, 5432, 4120, 2752, 1331, -159, -1706, -3316, -4977, -6677, -8410, -10167, -11920, -13650, -15331, -16925, -18427, -19797, -21015, -22059, -22921, -23598, -24089, -24398, -24548, -24552, -24429, -24211, -23914, -23560, -23171, -22761, -22349, -21940, -21547, -21175, -20831, -20517, -20233, -19982, -19764, -19578, -19426, -19310, -19227, -19177, -19163, -19181, -19233, -19316, -19433, -19581, -19760, -19964, -20196, -20452, -20731, -21025, -21331, -21649, -21972, -22295, -22617, -22932, -23233, -23521, -23792, -24039, -24261, -24457, -24624, -24761, -24862, -24934, -24972, -24979, -24955, -24902, -24823, -24720, -24595, -24452, -24292, -24117, -23933, -23734, -23523, -23302, -23061, -22797, -22510, -22184, -21811, -21381, -20877, -20294, -19616, -18822, -17909, -16868, -15683, -14367, -12905, -11291, -9541, -7659, -5649, -3542, -1277};