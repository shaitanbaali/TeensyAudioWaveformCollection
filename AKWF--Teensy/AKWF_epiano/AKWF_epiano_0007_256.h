/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0007 256 samples */
 
const int16_t AKWF_epiano_0007_256_DATA [256] = 
{103, 477, 909, 1423, 2024, 2711, 3478, 4306, 5178, 6073, 6967, 7843, 8687, 9485, 10239, 10949, 11619, 12264, 12893, 13517, 14150, 14797, 15460, 16144, 16839, 17540, 18242, 18931, 19600, 20247, 20862, 21448, 22004, 22536, 23048, 23546, 24036, 24521, 25006, 25487, 25965, 26437, 26897, 27341, 27765, 28163, 28536, 28883, 29203, 29502, 29782, 30046, 30299, 30542, 30777, 31004, 31220, 31422, 31608, 31775, 31917, 32033, 32121, 32181, 32214, 32223, 32209, 32177, 32129, 32067, 31992, 31905, 31804, 31688, 31555, 31402, 31227, 31027, 30801, 30550, 30274, 29974, 29653, 29313, 28955, 28582, 28195, 27793, 27378, 26950, 26504, 26042, 25563, 25063, 24545, 24009, 23452, 22880, 22291, 21686, 21068, 20439, 19795, 19142, 18477, 17799, 17110, 16409, 15694, 14968, 14228, 13475, 12715, 11942, 11160, 10372, 9575, 8772, 7965, 7150, 6330, 5508, 4678, 3846, 3010, 2171, 1330, 490, -352, -1192, -2031, -2869, -3703, -4536, -5368, -6195, -7022, -7845, -8663, -9478, -10287, -11087, -11880, -12664, -13434, -14197, -14947, -15685, -16415, -17133, -17842, -18543, -19234, -19914, -20587, -21246, -21890, -22520, -23132, -23726, -24303, -24857, -25393, -25912, -26412, -26896, -27365, -27819, -28258, -28682, -29088, -29476, -29843, -30186, -30505, -30801, -31067, -31310, -31529, -31725, -31902, -32061, -32205, -32335, -32452, -32553, -32637, -32703, -32747, -32767, -32760, -32725, -32660, -32568, -32451, -32311, -32152, -31978, -31790, -31593, -31385, -31165, -30932, -30682, -30409, -30113, -29788, -29432, -29047, -28631, -28190, -27730, -27254, -26768, -26280, -25789, -25299, -24808, -24313, -23809, -23291, -22750, -22183, -21586, -20957, -20301, -19620, -18920, -18212, -17505, -16804, -16119, -15449, -14795, -14152, -13512, -12862, -12193, -11492, -10749, -9966, -9136, -8269, -7380, -6479, -5592, -4740, -3940, -3213, -2570, -2013, -1543, -1146, -803, -495, -184};