/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0013 256 samples */
 
const int16_t AKWF_epiano_0013_256_DATA [256] = 
{943, 3692, 4944, 5841, 6069, 5991, 6212, 6475, 7249, 8235, 9790, 11714, 14307, 17337, 20055, 22644, 24002, 24442, 24382, 23765, 23882, 24446, 25370, 26738, 27596, 28130, 28129, 27650, 26982, 26054, 24678, 22810, 20393, 17245, 13969, 10380, 6774, 3120, -468, -3926, -7025, -9319, -11210, -12262, -13149, -13901, -14655, -15504, -16141, -16256, -16031, -15005, -13978, -13499, -13617, -15772, -18761, -23085, -27615, -30413, -32492, -32119, -30695, -28498, -25949, -24273, -22854, -21696, -20650, -18855, -16764, -14816, -12939, -12310, -12483, -12220, -12063, -9981, -6730, -3679, -518, 1154, 1757, 1638, 857, 268, -246, -108, 671, 1812, 3504, 4005, 2865, 618, -3498, -6786, -8872, -9933, -8588, -6935, -4642, -2156, 690, 3331, 5515, 6817, 6210, 4804, 1985, -977, -4012, -7102, -10293, -13469, -16506, -19345, -21060, -22159, -21302, -19425, -15083, -10082, -4867, 65, 2471, 3585, 2475, 446, -1741, -3948, -4722, -4592, -2161, 1416, 5957, 11052, 14395, 16534, 16756, 15564, 14035, 12184, 10719, 9593, 8331, 7017, 5327, 3196, 1165, -860, -2495, -3731, -4944, -6071, -7275, -8660, -9626, -10102, -9943, -8710, -7219, -4991, -2715, -231, 1881, 3050, 3726, 2690, 1616, 584, 131, 1669, 3481, 5819, 7670, 7380, 6180, 2959, -656, -3568, -5916, -5948, -4880, -1962, 1579, 4726, 7572, 8634, 8710, 7037, 4612, 1224, -2694, -6401, -10096, -12170, -13535, -12874, -10848, -8942, -6785, -5770, -5614, -5578, -5745, -4734, -2483, 830, 5422, 9816, 14085, 17108, 18325, 18377, 16731, 14979, 13073, 11673, 11294, 11162, 11517, 11842, 12051, 12156, 12042, 11512, 10173, 8187, 4566, 655, -4053, -8619, -12551, -15989, -17790, -19014, -17797, -15565, -10955, -5365, 1331, 8317, 13626, 18014, 19519, 19520, 16981, 13467, 9110, 4408, 552, -2903, -4356, -4973, -3751, -1365};