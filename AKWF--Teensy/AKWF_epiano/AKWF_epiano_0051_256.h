/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0051 256 samples */
 
const int16_t AKWF_epiano_0051_256_DATA [256] = 
{1073, 3396, 5817, 8356, 10959, 13550, 16061, 18423, 20579, 22518, 24203, 25638, 26827, 27775, 28508, 29047, 29402, 29597, 29643, 29554, 29341, 29010, 28569, 28019, 27370, 26625, 25774, 24831, 23795, 22660, 21446, 20142, 18751, 17290, 15761, 14173, 12552, 10889, 9209, 7537, 5883, 4272, 2721, 1233, -165, -1459, -2647, -3732, -4701, -5564, -6325, -6989, -7575, -8096, -8560, -8986, -9386, -9768, -10143, -10517, -10895, -11274, -11647, -12009, -12352, -12661, -12921, -13114, -13226, -13244, -13150, -12927, -12563, -12043, -11357, -10494, -9450, -8235, -6858, -5362, -3767, -2124, -497, 1062, 2506, 3797, 4916, 5853, 6611, 7212, 7678, 8039, 8326, 8563, 8771, 8968, 9174, 9395, 9637, 9905, 10199, 10523, 10873, 11251, 11656, 12086, 12542, 13028, 13542, 14081, 14650, 15241, 15859, 16500, 17161, 17836, 18521, 19205, 19891, 20565, 21221, 21850, 22442, 22995, 23500, 23953, 24352, 24688, 24961, 25174, 25320, 25403, 25420, 25369, 25253, 25067, 24810, 24481, 24082, 23604, 23042, 22397, 21661, 20826, 19899, 18850, 17673, 16363, 14904, 13278, 11469, 9461, 7247, 4821, 2191, -655, -3682, -6872, -10163, -13488, -16789, -19994, -23001, -25730, -28084, -29993, -31428, -32345, -32748, -32686, -32204, -31378, -30293, -29034, -27678, -26285, -24922, -23600, -22349, -21181, -20094, -19090, -18166, -17296, -16486, -15728, -15009, -14333, -13691, -13078, -12498, -11955, -11444, -10977, -10551, -10178, -9860, -9605, -9418, -9303, -9264, -9304, -9420, -9610, -9862, -10174, -10542, -10956, -11400, -11870, -12348, -12823, -13286, -13725, -14132, -14503, -14833, -15117, -15356, -15553, -15707, -15825, -15909, -15963, -15997, -16016, -16028, -16042, -16064, -16102, -16167, -16263, -16397, -16574, -16795, -17054, -17344, -17651, -17951, -18213, -18402, -18475, -18388, -18099, -17575, -16805, -15789, -14558, -13141, -11598, -9967, -8300, -6590, -4829, -2989, -984};