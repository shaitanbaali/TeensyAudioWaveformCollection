/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0062 256 samples */
 
const int16_t AKWF_epiano_0062_256_DATA [256] = 
{1026, 3780, 6549, 9309, 12021, 14648, 17142, 19465, 21608, 23547, 25291, 26832, 28170, 29314, 30271, 31055, 31679, 32149, 32480, 32683, 32764, 32741, 32619, 32406, 32110, 31741, 31304, 30805, 30250, 29643, 28989, 28296, 27561, 26788, 25982, 25146, 24287, 23403, 22496, 21573, 20631, 19679, 18722, 17752, 16772, 15788, 14799, 13807, 12818, 11825, 10836, 9854, 8877, 7914, 6963, 6019, 5087, 4174, 3279, 2395, 1533, 691, -130, -920, -1691, -2434, -3146, -3829, -4481, -5097, -5686, -6240, -6762, -7263, -7728, -8171, -8593, -8982, -9338, -9645, -9894, -10078, -10185, -10211, -10159, -10040, -9855, -9620, -9352, -9058, -8750, -8438, -8133, -7839, -7560, -7301, -7060, -6836, -6635, -6447, -6276, -6116, -5963, -5819, -5679, -5538, -5398, -5255, -5104, -4946, -4783, -4614, -4437, -4250, -4054, -3855, -3653, -3446, -3239, -3031, -2827, -2626, -2435, -2254, -2089, -1939, -1809, -1704, -1623, -1570, -1544, -1548, -1580, -1648, -1744, -1869, -2025, -2211, -2422, -2660, -2923, -3208, -3514, -3842, -4183, -4537, -4902, -5278, -5662, -6052, -6443, -6841, -7245, -7648, -8059, -8468, -8873, -9273, -9657, -10012, -10325, -10578, -10756, -10832, -10785, -10600, -10268, -9782, -9150, -8380, -7497, -6527, -5496, -4424, -3340, -2270, -1236, -257, 661, 1501, 2263, 2935, 3512, 3997, 4393, 4693, 4907, 5033, 5073, 5033, 4914, 4720, 4457, 4125, 3734, 3280, 2773, 2214, 1602, 953, 258, -478, -1240, -2037, -2862, -3694, -4545, -5395, -6243, -7080, -7904, -8704, -9482, -10228, -10938, -11603, -12234, -12816, -13351, -13839, -14271, -14658, -14993, -15280, -15520, -15713, -15864, -15975, -16047, -16085, -16090, -16072, -16028, -15963, -15880, -15786, -15681, -15570, -15455, -15337, -15222, -15107, -14981, -14843, -14671, -14439, -14117, -13662, -13039, -12200, -11107, -9737, -8080, -6148, -3965, -1492};