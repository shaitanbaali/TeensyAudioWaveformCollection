/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0035 256 samples */
 
const int16_t AKWF_epiano_0035_256_DATA [256] = 
{831, 2061, 3001, 3719, 4242, 4624, 4900, 5119, 5312, 5514, 5746, 6027, 6360, 6741, 7173, 7635, 8126, 8639, 9163, 9696, 10236, 10780, 11332, 11896, 12472, 13054, 13657, 14275, 14904, 15551, 16203, 16861, 17530, 18190, 18839, 19476, 20086, 20668, 21217, 21718, 22177, 22580, 22923, 23214, 23445, 23612, 23728, 23789, 23794, 23749, 23654, 23510, 23311, 23066, 22766, 22409, 21988, 21503, 20946, 20303, 19560, 18700, 17706, 16550, 15206, 13645, 11839, 9762, 7407, 4771, 1852, -1328, -4729, -8290, -11893, -15507, -19004, -22281, -25272, -27857, -29965, -31527, -32467, -32769, -32457, -31619, -30362, -28832, -27162, -25470, -23839, -22315, -20916, -19648, -18507, -17466, -16516, -15628, -14788, -13982, -13203, -12438, -11685, -10935, -10187, -9442, -8703, -7976, -7256, -6561, -5892, -5262, -4688, -4177, -3739, -3389, -3138, -2998, -2972, -3060, -3260, -3568, -3969, -4447, -4988, -5578, -6188, -6804, -7402, -7974, -8506, -8985, -9407, -9772, -10072, -10314, -10507, -10647, -10742, -10802, -10833, -10843, -10845, -10849, -10867, -10908, -10988, -11117, -11304, -11553, -11870, -12253, -12694, -13177, -13678, -14173, -14626, -15009, -15262, -15339, -15183, -14754, -14029, -13019, -11790, -10428, -9036, -7725, -6516, -5413, -4332, -3140, -1729, -2, 2090, 4502, 7116, 9810, 12478, 14975, 17228, 19192, 20838, 22196, 23275, 24101, 24712, 25131, 25385, 25503, 25496, 25378, 25163, 24862, 24471, 23994, 23436, 22800, 22078, 21278, 20388, 19411, 18344, 17185, 15945, 14617, 13185, 11668, 10082, 8431, 6749, 5033, 3308, 1600, -59, -1649, -3154, -4551, -5829, -6972, -7976, -8839, -9578, -10196, -10710, -11137, -11496, -11806, -12082, -12340, -12593, -12845, -13106, -13371, -13639, -13902, -14153, -14379, -14569, -14713, -14804, -14837, -14803, -14686, -14462, -14100, -13562, -12813, -11831, -10606, -9153, -7521, -5762, -3971, -2215, -559};