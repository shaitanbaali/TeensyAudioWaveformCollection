/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0061 256 samples */
 
const int16_t AKWF_epiano_0061_256_DATA [256] = 
{920, 2862, 4776, 6661, 8519, 10346, 12125, 13858, 15532, 17137, 18666, 20125, 21515, 22817, 24030, 25147, 26178, 27127, 27981, 28730, 29391, 29971, 30440, 30825, 31111, 31317, 31439, 31477, 31433, 31307, 31112, 30846, 30516, 30130, 29662, 29130, 28576, 27948, 27291, 26592, 25832, 25047, 24255, 23423, 22562, 21701, 20816, 19909, 19008, 18099, 17193, 16290, 15397, 14521, 13666, 12807, 11989, 11196, 10423, 9670, 8969, 8309, 7664, 7056, 6513, 6030, 5562, 5158, 4811, 4501, 4253, 4069, 3934, 3841, 3827, 3843, 3938, 4071, 4260, 4495, 4773, 5114, 5475, 5855, 6290, 6728, 7203, 7693, 8194, 8696, 9208, 9728, 10230, 10729, 11213, 11701, 12145, 12584, 13010, 13415, 13787, 14130, 14454, 14757, 15040, 15303, 15516, 15702, 15887, 16020, 16144, 16230, 16286, 16338, 16348, 16317, 16284, 16217, 16132, 16013, 15865, 15701, 15504, 15280, 15034, 14748, 14449, 14107, 13757, 13385, 12965, 12528, 12073, 11577, 11064, 10529, 9972, 9376, 8762, 8129, 7475, 6800, 6103, 5384, 4647, 3891, 3130, 2365, 1573, 779, -8, -794, -1605, -2403, -3195, -3969, -4742, -5507, -6248, -6990, -7704, -8415, -9084, -9739, -10370, -11002, -11601, -12164, -12732, -13265, -13783, -14284, -14775, -15236, -15691, -16140, -16580, -17000, -17409, -17839, -18245, -18654, -19051, -19438, -19848, -20254, -20662, -21066, -21475, -21902, -22307, -22732, -23152, -23589, -24002, -24437, -24876, -25307, -25724, -26159, -26577, -26998, -27417, -27837, -28238, -28631, -29027, -29407, -29773, -30123, -30464, -30782, -31081, -31358, -31614, -31860, -32072, -32265, -32423, -32554, -32661, -32723, -32757, -32761, -32731, -32658, -32537, -32375, -32169, -31903, -31599, -31238, -30810, -30318, -29765, -29137, -28432, -27669, -26824, -25886, -24880, -23781, -22596, -21341, -19998, -18570, -17071, -15489, -13849, -12148, -10379, -8572, -6719, -4836, -2937, -962};