/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0025 256 samples */
 
const int16_t AKWF_epiano_0025_256_DATA [256] = 
{577, 2475, 4397, 6375, 8371, 10374, 12365, 14305, 16206, 18043, 19792, 21452, 23010, 24439, 25757, 26957, 28034, 28991, 29820, 30533, 31140, 31642, 32039, 32342, 32562, 32703, 32763, 32762, 32703, 32581, 32413, 32196, 31932, 31630, 31291, 30917, 30508, 30071, 29612, 29132, 28636, 28122, 27584, 27027, 26459, 25880, 25287, 24673, 24053, 23421, 22776, 22124, 21460, 20782, 20096, 19400, 18702, 17989, 17269, 16546, 15815, 15078, 14337, 13594, 12851, 12115, 11381, 10658, 9947, 9249, 8563, 7901, 7264, 6649, 6064, 5511, 4996, 4525, 4098, 3708, 3369, 3067, 2801, 2583, 2394, 2223, 2081, 1960, 1846, 1740, 1633, 1519, 1401, 1280, 1154, 1016, 863, 704, 545, 385, 221, 56, -107, -267, -417, -558, -690, -815, -929, -1030, -1120, -1202, -1276, -1344, -1408, -1461, -1509, -1554, -1593, -1636, -1682, -1720, -1765, -1820, -1876, -1941, -2016, -2096, -2194, -2309, -2429, -2566, -2718, -2883, -3065, -3265, -3481, -3716, -3964, -4234, -4520, -4822, -5148, -5493, -5854, -6233, -6630, -7044, -7476, -7920, -8387, -8870, -9373, -9894, -10432, -10984, -11554, -12131, -12709, -13296, -13884, -14455, -15007, -15536, -16024, -16470, -16864, -17195, -17457, -17640, -17744, -17766, -17703, -17560, -17343, -17058, -16711, -16310, -15869, -15398, -14904, -14404, -13907, -13427, -12972, -12544, -12151, -11800, -11491, -11238, -11030, -10866, -10761, -10706, -10692, -10719, -10796, -10920, -11078, -11270, -11497, -11760, -12053, -12366, -12702, -13059, -13434, -13816, -14207, -14610, -15013, -15416, -15826, -16223, -16611, -16996, -17367, -17720, -18055, -18366, -18655, -18921, -19162, -19376, -19560, -19714, -19834, -19920, -19972, -19989, -19966, -19905, -19805, -19663, -19477, -19249, -18971, -18646, -18274, -17848, -17370, -16834, -16237, -15576, -14845, -14044, -13174, -12212, -11164, -10028, -8789, -7457, -6036, -4506, -2889, -1147};