/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0063 256 samples */
 
const int16_t AKWF_epiano_0063_256_DATA [256] = 
{820, 3181, 5608, 8074, 10546, 12988, 15352, 17613, 19761, 21764, 23598, 25266, 26752, 28068, 29205, 30173, 30963, 31605, 32098, 32445, 32664, 32762, 32751, 32638, 32431, 32141, 31772, 31336, 30835, 30277, 29669, 29012, 28316, 27582, 26810, 26009, 25182, 24332, 23457, 22570, 21659, 20735, 19800, 18854, 17903, 16945, 15977, 15011, 14042, 13078, 12120, 11165, 10217, 9277, 8352, 7439, 6536, 5654, 4788, 3940, 3119, 2318, 1538, 784, 55, -645, -1315, -1961, -2575, -3162, -3716, -4239, -4728, -5184, -5605, -5993, -6344, -6658, -6934, -7165, -7348, -7483, -7561, -7590, -7565, -7489, -7370, -7218, -7031, -6827, -6609, -6383, -6159, -5943, -5737, -5549, -5372, -5220, -5084, -4963, -4859, -4772, -4699, -4634, -4576, -4527, -4488, -4448, -4413, -4379, -4339, -4303, -4270, -4231, -4192, -4155, -4116, -4076, -4037, -4003, -3972, -3946, -3927, -3912, -3910, -3916, -3937, -3970, -4014, -4076, -4150, -4242, -4346, -4468, -4606, -4758, -4926, -5108, -5303, -5512, -5733, -5961, -6203, -6454, -6710, -6971, -7239, -7509, -7783, -8059, -8335, -8616, -8893, -9167, -9441, -9711, -9971, -10223, -10455, -10669, -10852, -11001, -11096, -11132, -11093, -10968, -10743, -10415, -9976, -9429, -8781, -8038, -7215, -6337, -5410, -4460, -3511, -2570, -1662, -804, -1, 732, 1391, 1970, 2454, 2848, 3155, 3372, 3500, 3539, 3498, 3379, 3180, 2913, 2581, 2190, 1746, 1251, 702, 123, -492, -1137, -1805, -2489, -3189, -3895, -4607, -5317, -6025, -6723, -7411, -8083, -8732, -9363, -9968, -10548, -11098, -11615, -12101, -12558, -12977, -13364, -13717, -14039, -14326, -14579, -14802, -14996, -15158, -15293, -15396, -15474, -15528, -15556, -15561, -15541, -15498, -15430, -15339, -15219, -15073, -14892, -14671, -14400, -14070, -13662, -13162, -12543, -11789, -10882, -9792, -8504, -7017, -5327, -3441, -1347};