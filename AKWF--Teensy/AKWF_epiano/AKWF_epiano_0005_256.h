/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0005 256 samples */
 
const int16_t AKWF_epiano_0005_256_DATA [256] = 
{138, 553, 965, 1370, 1757, 2160, 2557, 2905, 3269, 3596, 3904, 4208, 4494, 4725, 4961, 5167, 5348, 5518, 5675, 5787, 5917, 6023, 6111, 6179, 6250, 6304, 6357, 6403, 6456, 6497, 6546, 6606, 6639, 6692, 6754, 6832, 6907, 6991, 7100, 7218, 7333, 7484, 7638, 7809, 8012, 8217, 8441, 8680, 8955, 9234, 9527, 9868, 10214, 10604, 10999, 11443, 11930, 12418, 12953, 13521, 14105, 14731, 15409, 16104, 16830, 17602, 18390, 19196, 20019, 20843, 21661, 22461, 23239, 23965, 24649, 25279, 25841, 26335, 26742, 27097, 27258, 27179, 26732, 25692, 23745, 20561, 15933, 9875, 2686, -5062, -12665, -19301, -24505, -27963, -29654, -29814, -28768, -26969, -24840, -22639, -20665, -19008, -17695, -16701, -16042, -15586, -15302, -15155, -15051, -14973, -14843, -14672, -14466, -14229, -13925, -13608, -13250, -12894, -12543, -12162, -11813, -11477, -11176, -10856, -10578, -10290, -10019, -9761, -9523, -9277, -9043, -8814, -8582, -8328, -8072, -7806, -7504, -7199, -6853, -6498, -6125, -5732, -5306, -4858, -4398, -3895, -3396, -2895, -2359, -1809, -1263, -700, -161, 369, 913, 1443, 1971, 2480, 3009, 3523, 4041, 4527, 5028, 5541, 6024, 6519, 7016, 7524, 8027, 8543, 9069, 9587, 10142, 10725, 11316, 11920, 12550, 13185, 13868, 14536, 15212, 15904, 16632, 17352, 18048, 18795, 19551, 20272, 20921, 21416, 21690, 21494, 20606, 18716, 15537, 10971, 5069, -1877, -9344, -16614, -22949, -27886, -31133, -32644, -32622, -31434, -29583, -27459, -25358, -23457, -21840, -20521, -19413, -18528, -17798, -17158, -16616, -16097, -15568, -15019, -14445, -13841, -13226, -12596, -11957, -11352, -10749, -10188, -9640, -9096, -8602, -8142, -7708, -7303, -6932, -6564, -6241, -5913, -5626, -5340, -5037, -4767, -4501, -4222, -3947, -3671, -3379, -3081, -2768, -2437, -2097, -1752, -1391, -1003, -616, -206};