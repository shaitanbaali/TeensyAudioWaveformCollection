/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0008 256 samples */
 
const int16_t AKWF_epiano_0008_256_DATA [256] = 
{4137, 13169, 21414, 27930, 31564, 32376, 30313, 26230, 20831, 14845, 9196, 4413, 1209, -23, 667, 3172, 6490, 10003, 12770, 14526, 15291, 15427, 15396, 15448, 15694, 16106, 16703, 17599, 18918, 20700, 22714, 24432, 25375, 24988, 23515, 21208, 19050, 17442, 16810, 16822, 17101, 17113, 16677, 15858, 14862, 13838, 12719, 11287, 9364, 6876, 3943, 847, -2287, -5355, -8385, -11367, -14091, -16254, -17627, -18052, -17776, -16998, -16192, -15302, -14264, -12663, -10446, -7539, -4551, -2099, -1072, -2080, -4938, -9294, -13973, -18151, -20411, -19999, -17159, -13072, -9867, -8526, -10138, -13756, -18623, -22129, -23441, -22073, -19700, -17006, -14522, -12077, -10107, -9050, -8783, -9084, -9731, -10940, -12240, -12989, -13105, -12760, -12315, -10698, -7968, -4387, -1897, -1043, -2116, -4720, -8462, -12649, -15688, -16882, -16000, -13743, -10469, -6362, -2015, 2544, 5363, 7370, 8516, 8078, 6028, 2546, -1354, -5291, -9034, -12589, -16068, -19535, -23018, -25788, -27171, -26088, -22879, -17765, -12070, -6690, -2606, -555, -412, -2098, -4645, -7335, -9153, -9120, -6985, -2420, 3595, 10368, 16469, 20956, 23484, 23963, 23274, 21921, 20762, 19899, 19326, 18491, 17064, 14793, 11885, 8744, 5742, 3121, 664, -1861, -4789, -7994, -11316, -14123, -16208, -17282, -17514, -17039, -15992, -14561, -13021, -11832, -11604, -12479, -14439, -16367, -17539, -16683, -14055, -9997, -6048, -3288, -2445, -3547, -5642, -7863, -8803, -7960, -4855, 259, 6742, 13879, 20245, 25200, 27913, 28581, 27519, 25275, 22111, 18223, 13777, 9742, 6680, 5634, 6097, 7543, 8450, 8156, 6392, 3807, 1289, -518, -1006, -114, 2264, 5840, 9739, 13128, 14583, 14050, 11400, 8071, 4808, 2567, 1325, 863, 811, 1019, 1457, 2169, 2865, 3338, 3092, 1899, -336, -3629, -7535, -11760, -15572, -18558, -20374, -20713, -19466, -16446, -11435, -4476};