/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0017 256 samples */
 
const int16_t AKWF_epiano_0017_256_DATA [256] = 
{1724, 5193, 8771, 12263, 15403, 17953, 19699, 20656, 20855, 20459, 19749, 19251, 19058, 19207, 19731, 20426, 21132, 21682, 21976, 22041, 21909, 21753, 21618, 21548, 21449, 21223, 20677, 19666, 18200, 16266, 14138, 11951, 9972, 8292, 6896, 5671, 4370, 2831, 807, -1770, -4891, -8452, -12177, -15911, -19368, -22438, -25071, -27278, -29109, -30595, -31621, -32119, -31992, -31178, -29774, -27875, -25811, -23793, -22087, -20955, -20464, -20711, -21576, -22897, -24446, -25888, -27027, -27641, -27598, -26898, -25453, -23264, -20309, -16588, -12283, -7534, -2698, 1911, 6441, 10445, 13564, 15666, 16769, 16794, 15782, 14006, 11638, 9114, 6748, 4817, 3569, 3128, 3610, 5132, 7565, 10875, 14679, 18698, 22508, 25795, 28411, 30167, 31085, 31166, 30362, 28762, 26430, 23503, 20280, 16998, 14016, 11648, 10095, 9596, 10153, 11743, 14173, 17045, 20076, 22821, 25076, 26668, 27626, 28044, 27994, 27546, 26678, 25391, 23659, 21573, 19256, 16990, 14975, 13514, 12805, 12861, 13736, 15150, 16773, 18348, 19576, 20303, 20483, 20281, 19829, 19357, 18930, 18590, 18246, 17778, 17106, 16120, 14914, 13584, 12361, 11377, 10742, 10397, 10170, 9891, 9271, 8235, 6751, 4939, 3008, 1182, -222, -1113, -1378, -1146, -591, 65, 549, 778, 655, 258, -372, -1196, -2236, -3556, -5285, -7482, -10125, -13081, -16082, -18918, -21246, -22848, -23593, -23358, -22266, -20437, -18168, -15782, -13528, -11683, -10335, -9602, -9510, -10095, -11404, -13468, -16154, -19375, -22760, -26011, -28863, -31000, -32341, -32710, -32080, -30510, -28028, -24924, -21437, -17909, -14707, -12035, -10153, -9190, -9180, -10215, -12135, -14805, -17950, -21152, -24137, -26540, -28232, -29141, -29215, -28489, -26942, -24595, -21595, -18079, -14324, -10625, -7252, -4541, -2646, -1721, -1806, -2749, -4403, -6319, -8199, -9686, -10559, -10782, -10355, -9395, -7979, -6132, -3862, -1097};