/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0067 256 samples */
 
const int16_t AKWF_epiano_0067_256_DATA [256] = 
{864, 2275, 3665, 5051, 6422, 7780, 9130, 10452, 11748, 13014, 14259, 15476, 16660, 17808, 18919, 19991, 21023, 22014, 22968, 23879, 24744, 25570, 26354, 27096, 27784, 28423, 29022, 29582, 30096, 30562, 30982, 31352, 31679, 31963, 32205, 32405, 32564, 32675, 32741, 32767, 32758, 32710, 32621, 32489, 32321, 32116, 31883, 31621, 31318, 30983, 30623, 30235, 29821, 29385, 28929, 28450, 27951, 27442, 26917, 26370, 25822, 25268, 24699, 24122, 23537, 22954, 22369, 21777, 21190, 20600, 20003, 19415, 18826, 18236, 17657, 17078, 16503, 15934, 15366, 14805, 14257, 13713, 13177, 12651, 12136, 11635, 11143, 10655, 10178, 9715, 9265, 8837, 8412, 8000, 7608, 7222, 6849, 6497, 6155, 5825, 5508, 5207, 4914, 4630, 4358, 4099, 3854, 3612, 3377, 3158, 2943, 2732, 2527, 2324, 2124, 1933, 1736, 1536, 1344, 1148, 948, 752, 543, 323, 107, -119, -358, -606, -863, -1133, -1424, -1728, -2043, -2370, -2714, -3081, -3464, -3868, -4292, -4726, -5178, -5652, -6140, -6638, -7150, -7672, -8207, -8742, -9284, -9827, -10368, -10905, -11440, -11962, -12474, -12968, -13447, -13910, -14354, -14783, -15190, -15574, -15938, -16282, -16604, -16904, -17182, -17441, -17684, -17911, -18120, -18310, -18486, -18652, -18809, -18959, -19100, -19231, -19358, -19481, -19598, -19717, -19839, -19955, -20078, -20208, -20337, -20469, -20604, -20750, -20901, -21057, -21215, -21380, -21554, -21738, -21925, -22111, -22307, -22506, -22705, -22908, -23118, -23328, -23535, -23736, -23933, -24132, -24330, -24522, -24705, -24876, -25045, -25206, -25352, -25479, -25595, -25697, -25779, -25843, -25888, -25906, -25898, -25863, -25798, -25700, -25566, -25392, -25177, -24918, -24610, -24254, -23842, -23380, -22861, -22281, -21648, -20962, -20208, -19395, -18528, -17608, -16638, -15614, -14534, -13410, -12246, -11046, -9816, -8547, -7248, -5924, -4582, -3235, -1877, -477};