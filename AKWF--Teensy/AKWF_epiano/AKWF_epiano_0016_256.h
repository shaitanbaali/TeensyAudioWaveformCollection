/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_epiano_0016 256 samples */
 
const int16_t AKWF_epiano_0016_256_DATA [256] = 
{1453, 4886, 8473, 11966, 15127, 17731, 19546, 20543, 20793, 20491, 19970, 19442, 19209, 19351, 19848, 20541, 21239, 21812, 22131, 22211, 22115, 21953, 21797, 21732, 21618, 21413, 20880, 19910, 18469, 16554, 14426, 12231, 10202, 8482, 7038, 5782, 4501, 2974, 955, -1610, -4704, -8248, -12015, -15785, -19289, -22411, -25111, -27385, -29259, -30779, -31845, -32394, -32311, -31552, -30179, -28314, -26249, -24196, -22450, -21257, -20700, -20904, -21716, -23022, -24556, -26026, -27224, -27872, -27903, -27217, -25834, -23683, -20755, -17069, -12769, -8005, -3148, 1475, 6114, 10137, 13334, 15554, 16745, 16832, 15902, 14180, 11873, 9342, 6938, 4953, 3646, 3146, 3562, 5009, 7378, 10612, 14407, 18415, 22260, 25595, 28258, 30109, 31097, 31222, 30503, 28968, 26697, 23804, 20605, 17303, 14287, 11843, 10235, 9630, 10123, 11626, 13983, 16844, 19889, 22677, 24977, 26617, 27623, 28087, 28069, 27651, 26813, 25551, 23858, 21798, 19493, 17199, 15148, 13642, 12844, 12849, 13684, 15050, 16736, 18363, 19642, 20423, 20629, 20458, 20014, 19533, 19089, 18746, 18408, 17964, 17299, 16327, 15120, 13775, 12534, 11515, 10859, 10478, 10263, 9977, 9387, 8417, 6909, 5066, 3127, 1307, -156, -1103, -1387, -1212, -658, -5, 499, 767, 661, 295, -336, -1139, -2161, -3426, -5138, -7290, -9894, -12844, -15821, -18723, -21083, -22770, -23584, -23399, -22406, -20596, -18364, -15978, -13668, -11795, -10420, -9610, -9478, -9986, -11237, -13269, -15895, -19104, -22468, -25756, -28666, -30845, -32284, -32719, -32157, -30668, -28239, -25197, -21712, -18144, -14928, -12178, -10258, -9215, -9108, -10087, -11917, -14565, -17698, -20882, -23906, -26359, -28100, -29083, -29217, -28558, -27086, -24782, -21857, -18363, -14612, -10902, -7497, -4732, -2748, -1745, -1782, -2669, -4268, -6169, -8067, -9595, -10513, -10795, -10399, -9492, -8120, -6319, -4065, -1331};