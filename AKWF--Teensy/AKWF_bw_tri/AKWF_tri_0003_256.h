/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0003 256 samples */
 
const int16_t AKWF_tri_0003_256_DATA [256] = 
{573, 1379, 2139, 2880, 3606, 4330, 5073, 5859, 6715, 7653, 8683, 9817, 11057, 12388, 13798, 15259, 16745, 18241, 19719, 21154, 22531, 23830, 25038, 26151, 27161, 28065, 28867, 29568, 30174, 30693, 31128, 31492, 31792, 32035, 32230, 32384, 32504, 32596, 32664, 32713, 32744, 32761, 32766, 32758, 32735, 32699, 32647, 32577, 32487, 32374, 32235, 32067, 31865, 31624, 31340, 31002, 30587, 30071, 29537, 29066, 28651, 28268, 27906, 27566, 27251, 26965, 26706, 26471, 26256, 26061, 25882, 25721, 25573, 25437, 25311, 25192, 25078, 24967, 24857, 24745, 24630, 24509, 24380, 24242, 24093, 23930, 23753, 23561, 23351, 23124, 22877, 22610, 22323, 22014, 21684, 21332, 20956, 20559, 20140, 19698, 19234, 18748, 18240, 17711, 17161, 16590, 16001, 15392, 14764, 14120, 13457, 12778, 12085, 11376, 10653, 9918, 9169, 8409, 7641, 6859, 6070, 5274, 4468, 3657, 2841, 2018, 1193, 364, -464, -1262, -2027, -2773, -3500, -4224, -4962, -5740, -6585, -7510, -8525, -9643, -10869, -12187, -13588, -15043, -16525, -18021, -19503, -20946, -22333, -23644, -24866, -25994, -27019, -27938, -28756, -29472, -30091, -30621, -31070, -31444, -31752, -32002, -32205, -32364, -32489, -32584, -32655, -32707, -32741, -32761, -32766, -32760, -32740, -32706, -32656, -32589, -32502, -32392, -32258, -32094, -31897, -31662, -31385, -31055, -30656, -30152, -29613, -29131, -28709, -28323, -27958, -27614, -27296, -27006, -26744, -26505, -26287, -26088, -25906, -25744, -25595, -25457, -25330, -25209, -25095, -24984, -24874, -24762, -24648, -24528, -24400, -24263, -24116, -23955, -23781, -23591, -23384, -23160, -22916, -22652, -22368, -22063, -21735, -21386, -21014, -20621, -20205, -19765, -19305, -18822, -18316, -17792, -17244, -16676, -16091, -15484, -14858, -14218, -13557, -12880, -12190, -11483, -10761, -10029, -9282, -8523, -7756, -6976, -6188, -5394, -4589, -3779, -2964, -2143, -1320, -479};