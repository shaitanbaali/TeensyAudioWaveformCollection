/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0002 256 samples */
 
const int16_t AKWF_tri_0002_256_DATA [256] = 
{344, 848, 1363, 1890, 2427, 2975, 3531, 4095, 4666, 5245, 5829, 6419, 7017, 7618, 8225, 8838, 9452, 10071, 10694, 11319, 11946, 12574, 13202, 13832, 14461, 15087, 15715, 16340, 16961, 17581, 18196, 18806, 19415, 20015, 20611, 21202, 21784, 22361, 22930, 23490, 24043, 24588, 25123, 25648, 26164, 26668, 27163, 27648, 28120, 28580, 29029, 29465, 29889, 30301, 30698, 31083, 31453, 31809, 32150, 32486, 32747, 32698, 32508, 32302, 32089, 31869, 31638, 31391, 31128, 30849, 30548, 30229, 29890, 29531, 29154, 28759, 28345, 27916, 27470, 27008, 26532, 26042, 25539, 25025, 24498, 23960, 23413, 22854, 22288, 21714, 21130, 20541, 19944, 19341, 18733, 18120, 17501, 16880, 16255, 15625, 14997, 14366, 13731, 13098, 12465, 11832, 11202, 10573, 9946, 9325, 8707, 8093, 7489, 6888, 6296, 5716, 5144, 4586, 4042, 3513, 3005, 2520, 2064, 1648, 1309, 990, 601, 161, -313, -810, -1323, -1851, -2388, -2935, -3491, -4053, -4624, -5203, -5785, -6376, -6974, -7574, -8181, -8793, -9408, -10027, -10650, -11273, -11900, -12528, -13156, -13786, -14415, -15042, -15670, -16294, -16915, -17536, -18151, -18762, -19370, -19971, -20567, -21159, -21742, -22319, -22888, -23449, -24004, -24549, -25083, -25610, -26126, -26632, -27127, -27612, -28085, -28547, -28997, -29434, -29858, -30270, -30669, -31055, -31426, -31783, -32125, -32461, -32738, -32710, -32522, -32318, -32105, -31885, -31656, -31410, -31149, -30870, -30571, -30253, -29916, -29559, -29184, -28789, -28377, -27949, -27503, -27043, -26569, -26079, -25578, -25064, -24538, -24000, -23454, -22896, -22331, -21758, -21175, -20585, -19989, -19386, -18778, -18165, -17547, -16926, -16303, -15673, -15044, -14413, -13779, -13146, -12513, -11880, -11250, -10620, -9993, -9371, -8753, -8139, -7533, -6933, -6341, -5759, -5187, -4626, -4082, -3553, -3042, -2556, -2097, -1678, -1332, -1017, -637, -183};