/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0007 256 samples */
 
const int16_t AKWF_tri_0007_256_DATA [256] = 
{152, 610, 1044, 1467, 1878, 2280, 2675, 3063, 3447, 3831, 4211, 4595, 4980, 5370, 5766, 6169, 6580, 6999, 7429, 7869, 8321, 8784, 9256, 9742, 10238, 10743, 11261, 11787, 12322, 12867, 13418, 13975, 14539, 15106, 15677, 16251, 16825, 17401, 17976, 18548, 19120, 19690, 20254, 20815, 21373, 21924, 22469, 23010, 23545, 24075, 24599, 25116, 25629, 26136, 26638, 27137, 27631, 28120, 28608, 29092, 29574, 30055, 30533, 31009, 31495, 31922, 32182, 32412, 32597, 32719, 32767, 32740, 32639, 32470, 32243, 31960, 31629, 31257, 30847, 30405, 29940, 29451, 28946, 28428, 27897, 27356, 26808, 26251, 25688, 25119, 24540, 23954, 23360, 22756, 22142, 21518, 20882, 20234, 19575, 18902, 18219, 17524, 16817, 16102, 15377, 14645, 13909, 13167, 12424, 11682, 10941, 10203, 9475, 8752, 8040, 7342, 6655, 5986, 5332, 4696, 4080, 3482, 2903, 2345, 1808, 1288, 788, 306, -160, -609, -1044, -1468, -1879, -2281, -2676, -3064, -3448, -3831, -4212, -4596, -4981, -5371, -5767, -6169, -6581, -7000, -7430, -7870, -8321, -8784, -9257, -9742, -10239, -10744, -11262, -11788, -12323, -12868, -13418, -13976, -14539, -15106, -15677, -16251, -16825, -17401, -17976, -18548, -19121, -19690, -20254, -20816, -21373, -21924, -22470, -23010, -23546, -24075, -24599, -25116, -25629, -26137, -26638, -27137, -27631, -28120, -28608, -29092, -29574, -30055, -30533, -31009, -31495, -31922, -32182, -32412, -32597, -32719, -32767, -32740, -32639, -32470, -32243, -31960, -31629, -31257, -30847, -30405, -29939, -29452, -28946, -28428, -27897, -27356, -26809, -26251, -25688, -25119, -24540, -23955, -23361, -22756, -22143, -21519, -20882, -20235, -19575, -18902, -18219, -17524, -16818, -16103, -15378, -14645, -13909, -13168, -12425, -11683, -10942, -10204, -9476, -8753, -8041, -7342, -6656, -5986, -5333, -4697, -4081, -3483, -2904, -2346, -1808, -1290, -791, -300};