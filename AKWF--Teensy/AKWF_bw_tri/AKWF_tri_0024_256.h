/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0024 256 samples */
 
const int16_t AKWF_tri_0024_256_DATA [256] = 
{3675, 8425, 9891, 11357, 12712, 13792, 14784, 15683, 16502, 17266, 17972, 18636, 19262, 19850, 20411, 20941, 21448, 21931, 22393, 22837, 23262, 23672, 24065, 24443, 24808, 25161, 25502, 25832, 26148, 26457, 26756, 27045, 27326, 27600, 27863, 28119, 28369, 28610, 28846, 29075, 29296, 29513, 29723, 29928, 30128, 30322, 30509, 30690, 30862, 31028, 31188, 31341, 31488, 31629, 31765, 31895, 32020, 32138, 32252, 32361, 32465, 32566, 32659, 32753, 32738, 32520, 32285, 32072, 31850, 31628, 31404, 31180, 30954, 30725, 30499, 30269, 30037, 29805, 29571, 29335, 29099, 28861, 28619, 28372, 28121, 27864, 27604, 27338, 27068, 26792, 26509, 26222, 25928, 25627, 25321, 25007, 24685, 24356, 24020, 23674, 23319, 22957, 22581, 22197, 21801, 21393, 20973, 20537, 20087, 19622, 19139, 18636, 18115, 17567, 16997, 16399, 15767, 15098, 14391, 13633, 12820, 11941, 10972, 9895, 8671, 7213, 5473, 2538, -3699, -8423, -9880, -11358, -12713, -13792, -14785, -15684, -16504, -17266, -17974, -18637, -19262, -19850, -20411, -20942, -21448, -21932, -22393, -22837, -23262, -23672, -24065, -24444, -24808, -25161, -25502, -25831, -26150, -26457, -26757, -27045, -27326, -27599, -27863, -28119, -28369, -28610, -28846, -29075, -29296, -29514, -29723, -29928, -30129, -30321, -30508, -30690, -30862, -31028, -31188, -31341, -31488, -31629, -31765, -31895, -32020, -32139, -32254, -32361, -32465, -32566, -32659, -32753, -32738, -32521, -32284, -32073, -31851, -31628, -31404, -31180, -30954, -30725, -30499, -30268, -30038, -29805, -29572, -29336, -29099, -28861, -28618, -28372, -28121, -27864, -27604, -27338, -27068, -26791, -26510, -26222, -25929, -25627, -25320, -25007, -24685, -24356, -24021, -23674, -23319, -22957, -22581, -22197, -21801, -21394, -20974, -20537, -20087, -19623, -19140, -18636, -18115, -17568, -16997, -16399, -15767, -15098, -14392, -13634, -12821, -11941, -10973, -9896, -8672, -7225, -5503, -2406};