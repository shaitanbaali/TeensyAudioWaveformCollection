/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0011 256 samples */
 
const int16_t AKWF_tri_0011_256_DATA [256] = 
{78, 195, 297, 381, 455, 522, 568, 605, 633, 648, 651, 664, 696, 731, 784, 854, 935, 1026, 1137, 1262, 1394, 1548, 1718, 1901, 2096, 2313, 2544, 2786, 3048, 3326, 3623, 3937, 4263, 4605, 4966, 5347, 5746, 6157, 6587, 7040, 7505, 7989, 8495, 9021, 9561, 10119, 10704, 11300, 11916, 12561, 13223, 13897, 14600, 15325, 16061, 16826, 17617, 18418, 19228, 20055, 20891, 21735, 22591, 23461, 24339, 25220, 26118, 27023, 27931, 28854, 29787, 30718, 31658, 32605, 32433, 30895, 29497, 28259, 26999, 25792, 24641, 23522, 22445, 21416, 20421, 19460, 18541, 17657, 16802, 15983, 15200, 14445, 13716, 13018, 12351, 11701, 11073, 10470, 9882, 9309, 8760, 8230, 7711, 7217, 6741, 6278, 5832, 5408, 4997, 4598, 4221, 3862, 3513, 3178, 2866, 2564, 2274, 2004, 1750, 1504, 1272, 1061, 855, 664, 491, 330, 177, 40, -81, -197, -297, -381, -455, -520, -570, -607, -637, -648, -650, -664, -696, -733, -785, -857, -936, -1026, -1136, -1262, -1396, -1549, -1721, -1901, -2096, -2313, -2546, -2786, -3050, -3332, -3623, -3931, -4263, -4609, -4966, -5349, -5746, -6158, -6587, -7040, -7507, -7990, -8497, -9021, -9561, -10119, -10704, -11301, -11917, -12563, -13222, -13897, -14599, -15325, -16063, -16827, -17619, -18417, -19228, -20055, -20893, -21736, -22593, -23463, -24338, -25220, -26117, -27025, -27932, -28855, -29787, -30715, -31657, -32604, -32435, -30894, -29498, -28260, -26998, -25792, -24641, -23523, -22446, -21418, -20421, -19460, -18541, -17657, -16803, -15985, -15202, -14445, -13716, -13018, -12352, -11702, -11074, -10471, -9882, -9309, -8760, -8231, -7713, -7218, -6742, -6278, -5832, -5407, -4997, -4600, -4224, -3863, -3514, -3179, -2867, -2566, -2275, -2007, -1751, -1503, -1272, -1060, -857, -666, -494, -331, -178, -37};