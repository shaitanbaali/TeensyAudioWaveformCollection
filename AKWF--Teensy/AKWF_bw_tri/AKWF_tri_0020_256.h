/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0020 256 samples */
 
const int16_t AKWF_tri_0020_256_DATA [256] = 
{650, 1778, 2833, 3787, 4678, 5521, 6325, 7089, 7822, 8531, 9215, 9879, 10523, 11150, 11762, 12359, 12942, 13514, 14074, 14623, 15163, 15693, 16214, 16727, 17232, 17728, 18219, 18702, 19178, 19650, 20115, 20572, 21025, 21474, 21917, 22356, 22787, 23217, 23641, 24058, 24474, 24886, 25292, 25695, 26097, 26492, 26885, 27275, 27655, 28027, 28392, 28749, 29098, 29440, 29774, 30101, 30420, 30733, 31038, 31336, 31628, 31914, 32189, 32459, 32727, 32662, 32151, 31657, 31208, 30740, 30275, 29818, 29362, 28909, 28460, 28014, 27568, 27130, 26692, 26257, 25825, 25396, 24970, 24545, 24121, 23696, 23267, 22836, 22404, 21969, 21528, 21089, 20646, 20196, 19747, 19294, 18836, 18375, 17911, 17441, 16966, 16489, 16007, 15520, 15025, 14526, 14020, 13507, 12988, 12464, 11930, 11385, 10835, 10271, 9698, 9113, 8515, 7900, 7273, 6626, 5958, 5269, 4554, 3806, 3025, 2198, 1320, 375, -664, -1775, -2832, -3788, -4679, -5522, -6325, -7089, -7823, -8532, -9216, -9879, -10524, -11150, -11761, -12360, -12942, -13514, -14075, -14623, -15164, -15693, -16213, -16727, -17233, -17728, -18220, -18703, -19179, -19650, -20115, -20573, -21026, -21475, -21917, -22355, -22788, -23217, -23641, -24058, -24475, -24887, -25292, -25695, -26097, -26492, -26886, -27275, -27655, -28027, -28392, -28749, -29099, -29440, -29774, -30101, -30421, -30732, -31038, -31336, -31628, -31914, -32189, -32459, -32727, -32662, -32151, -31657, -31207, -30739, -30275, -29818, -29362, -28909, -28460, -28014, -27569, -27130, -26692, -26257, -25825, -25397, -24970, -24545, -24121, -23697, -23268, -22836, -22404, -21970, -21529, -21089, -20646, -20197, -19748, -19294, -18836, -18375, -17911, -17442, -16967, -16490, -16008, -15520, -15025, -14525, -14022, -13508, -12990, -12465, -11929, -11385, -10835, -10272, -9698, -9116, -8515, -7901, -7273, -6626, -5959, -5270, -4554, -3807, -3026, -2201, -1326, -359};