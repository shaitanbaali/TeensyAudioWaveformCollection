/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0019 256 samples */
 
const int16_t AKWF_tri_0019_256_DATA [256] = 
{408, 1211, 2007, 2770, 3505, 4221, 4920, 5595, 6258, 6907, 7540, 8162, 8776, 9376, 9965, 10549, 11124, 11691, 12249, 12801, 13348, 13885, 14418, 14947, 15469, 15983, 16496, 17003, 17504, 18003, 18496, 18986, 19471, 19952, 20428, 20902, 21373, 21840, 22302, 22762, 23221, 23674, 24122, 24571, 25017, 25457, 25896, 26334, 26762, 27183, 27597, 28003, 28399, 28789, 29172, 29546, 29913, 30273, 30626, 30971, 31308, 31640, 31963, 32277, 32600, 32761, 32340, 31734, 31222, 30697, 30172, 29656, 29142, 28631, 28130, 27629, 27131, 26641, 26157, 25672, 25194, 24720, 24250, 23783, 23319, 22858, 22394, 21928, 21464, 20997, 20525, 20054, 19583, 19106, 18630, 18152, 17669, 17187, 16702, 16213, 15722, 15228, 14732, 14233, 13730, 13223, 12714, 12198, 11679, 11158, 10629, 10097, 9559, 9014, 8462, 7907, 7340, 6766, 6186, 5593, 4989, 4376, 3748, 3104, 2446, 1767, 1067, 338, -419, -1209, -2006, -2771, -3505, -4222, -4919, -5596, -6259, -6908, -7541, -8163, -8776, -9377, -9966, -10550, -11125, -11692, -12250, -12802, -13349, -13886, -14419, -14947, -15469, -15984, -16497, -17005, -17505, -18004, -18497, -18986, -19470, -19952, -20429, -20902, -21373, -21841, -22303, -22762, -23221, -23674, -24122, -24572, -25018, -25457, -25896, -26334, -26762, -27183, -27598, -28003, -28400, -28789, -29172, -29546, -29913, -30274, -30626, -30971, -31308, -31641, -31963, -32277, -32600, -32761, -32340, -31733, -31223, -30697, -30172, -29656, -29142, -28631, -28129, -27629, -27132, -26642, -26156, -25672, -25194, -24721, -24250, -23783, -23320, -22859, -22394, -21929, -21463, -20997, -20525, -20055, -19583, -19106, -18630, -18152, -17669, -17187, -16702, -16214, -15722, -15229, -14733, -14233, -13730, -13224, -12714, -12199, -11680, -11158, -10630, -10097, -9559, -9015, -8463, -7908, -7341, -6766, -6187, -5594, -4990, -4377, -3750, -3105, -2446, -1769, -1071, -328};