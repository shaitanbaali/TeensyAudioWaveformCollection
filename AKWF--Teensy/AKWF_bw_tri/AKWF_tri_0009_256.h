/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0009 256 samples */
 
const int16_t AKWF_tri_0009_256_DATA [256] = 
{156, 656, 1147, 1638, 2129, 2622, 3116, 3608, 4101, 4595, 5085, 5578, 6071, 6564, 7056, 7548, 8039, 8534, 9026, 9518, 10012, 10504, 10996, 11490, 11983, 12473, 12966, 13459, 13952, 14444, 14936, 15428, 15922, 16414, 16906, 17400, 17892, 18385, 18879, 19370, 19862, 20355, 20848, 21340, 21832, 22323, 22817, 23311, 23802, 24294, 24787, 25280, 25772, 26265, 26758, 27250, 27742, 28234, 28729, 29220, 29711, 30206, 30698, 31190, 31680, 32168, 32674, 32625, 31419, 29899, 28769, 28017, 27446, 26935, 26437, 25943, 25448, 24956, 24463, 23969, 23479, 22986, 22492, 22000, 21508, 21015, 20522, 20029, 19538, 19044, 18552, 18060, 17568, 17074, 16582, 16091, 15598, 15106, 14612, 14120, 13628, 13136, 12641, 12148, 11655, 11164, 10672, 10180, 9685, 9194, 8702, 8210, 7717, 7223, 6732, 6241, 5747, 5253, 4762, 4270, 3776, 3284, 2790, 2297, 1806, 1314, 821, 328, -164, -655, -1147, -1639, -2130, -2623, -3117, -3608, -4102, -4596, -5086, -5578, -6072, -6565, -7057, -7549, -8040, -8535, -9027, -9519, -10013, -10505, -10996, -11491, -11983, -12474, -12967, -13459, -13953, -14445, -14936, -15428, -15923, -16415, -16906, -17401, -17892, -18385, -18879, -19371, -19862, -20355, -20848, -21341, -21833, -22323, -22817, -23311, -23802, -24294, -24787, -25280, -25772, -26265, -26758, -27250, -27742, -28235, -28729, -29220, -29711, -30206, -30698, -31190, -31680, -32168, -32674, -32625, -31419, -29899, -28769, -28017, -27446, -26935, -26438, -25943, -25448, -24957, -24463, -23970, -23479, -22986, -22492, -22000, -21509, -21016, -20523, -20030, -19538, -19045, -18552, -18060, -17569, -17075, -16582, -16091, -15598, -15106, -14612, -14120, -13629, -13137, -12642, -12149, -11656, -11164, -10673, -10180, -9686, -9195, -8703, -8210, -7718, -7224, -6733, -6241, -5748, -5254, -4763, -4271, -3777, -3285, -2791, -2298, -1807, -1316, -824, -322};