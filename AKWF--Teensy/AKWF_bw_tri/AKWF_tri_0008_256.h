/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0008 256 samples */
 
const int16_t AKWF_tri_0008_256_DATA [256] = 
{263, 1074, 1818, 2567, 3296, 4025, 4743, 5444, 6146, 6835, 7502, 8166, 8822, 9489, 10092, 10697, 11322, 11926, 12520, 13097, 13654, 14212, 14748, 15282, 15807, 16312, 16809, 17305, 17768, 18237, 18691, 19134, 19560, 19986, 20395, 20801, 21200, 21575, 21936, 22300, 22654, 23001, 23331, 23643, 23973, 24280, 24539, 24816, 25115, 25377, 25635, 25888, 26118, 26343, 26576, 26790, 26990, 27188, 27372, 27558, 27728, 27894, 28054, 28199, 28349, 28487, 28605, 28732, 28850, 28949, 29058, 29154, 29238, 29321, 29395, 29464, 29553, 29600, 29614, 29663, 29714, 29748, 29778, 29809, 29809, 29828, 29834, 29834, 29833, 29825, 29807, 29792, 29774, 29746, 29716, 29682, 29641, 29658, 29277, 31551, 32337, 30967, 30110, 29135, 28123, 27078, 26001, 24897, 23818, 22656, 21431, 20303, 19135, 17946, 16763, 15565, 14372, 13167, 11982, 10797, 9611, 8437, 7265, 6116, 4976, 3835, 2715, 1610, 511, -563, -1617, -2669, -3696, -4707, -5695, -6670, -7620, -8548, -9469, -10360, -11190, -12083, -12969, -13755, -14540, -15292, -16043, -16786, -17490, -18179, -18841, -19488, -20111, -20721, -21308, -21879, -22427, -22947, -23460, -23957, -24419, -24866, -25301, -25722, -26113, -26499, -26852, -27185, -27522, -27834, -28117, -28398, -28623, -28931, -29192, -29370, -29571, -29764, -29939, -30095, -30228, -30368, -30480, -30580, -30675, -30751, -30825, -30883, -30930, -30961, -30980, -30984, -30983, -30961, -30939, -30903, -30855, -30802, -30731, -30663, -30568, -30461, -30361, -30215, -30057, -29951, -29809, -29581, -29388, -29178, -28948, -28698, -28435, -28125, -27794, -27441, -27052, -26633, -26191, -25717, -25212, -24706, -24174, -23628, -23062, -22610, -22284, -21441, -20841, -20271, -19671, -19068, -18448, -17790, -17135, -16418, -15694, -14998, -14239, -13446, -12669, -11873, -11074, -10268, -9458, -8636, -7829, -7006, -6191, -5379, -4559, -3761, -2959, -2168, -1383, -587};