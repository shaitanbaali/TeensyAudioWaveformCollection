/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0021 256 samples */
 
const int16_t AKWF_tri_0021_256_DATA [256] = 
{1143, 3090, 4592, 5813, 6921, 7920, 8839, 9696, 10499, 11258, 11980, 12672, 13334, 13967, 14583, 15175, 15747, 16304, 16844, 17369, 17882, 18381, 18866, 19342, 19809, 20264, 20711, 21147, 21576, 21996, 22409, 22815, 23213, 23605, 23990, 24370, 24741, 25108, 25472, 25826, 26179, 26525, 26866, 27202, 27535, 27862, 28186, 28504, 28815, 29118, 29413, 29700, 29981, 30254, 30520, 30780, 31033, 31278, 31518, 31752, 31978, 32200, 32413, 32628, 32770, 32527, 32088, 31713, 31337, 30955, 30575, 30199, 29823, 29449, 29076, 28705, 28335, 27966, 27597, 27233, 26868, 26503, 26140, 25775, 25408, 25036, 24665, 24288, 23905, 23522, 23132, 22739, 22343, 21941, 21536, 21125, 20708, 20286, 19860, 19427, 18987, 18541, 18088, 17628, 17159, 16681, 16198, 15701, 15192, 14678, 14149, 13605, 13049, 12477, 11887, 11280, 10650, 9998, 9317, 8606, 7862, 7078, 6238, 5343, 4370, 3293, 2082, 652, -1163, -3086, -4589, -5814, -6922, -7921, -8840, -9695, -10499, -11258, -11981, -12672, -13334, -13968, -14582, -15175, -15747, -16305, -16845, -17369, -17882, -18382, -18868, -19345, -19811, -20264, -20711, -21148, -21576, -21996, -22410, -22815, -23213, -23605, -23990, -24370, -24741, -25109, -25472, -25826, -26179, -26525, -26866, -27202, -27535, -27862, -28185, -28504, -28814, -29118, -29413, -29700, -29981, -30254, -30520, -30780, -31033, -31278, -31518, -31752, -31977, -32199, -32413, -32628, -32770, -32527, -32087, -31712, -31337, -30954, -30575, -30200, -29824, -29448, -29076, -28705, -28335, -27965, -27599, -27234, -26868, -26503, -26140, -25775, -25408, -25037, -24664, -24287, -23906, -23522, -23132, -22739, -22344, -21943, -21536, -21125, -20709, -20289, -19860, -19428, -18988, -18542, -18088, -17628, -17159, -16682, -16199, -15701, -15193, -14679, -14149, -13604, -13050, -12478, -11888, -11280, -10650, -9998, -9318, -8608, -7862, -7078, -6239, -5344, -4371, -3297, -2094, -618};