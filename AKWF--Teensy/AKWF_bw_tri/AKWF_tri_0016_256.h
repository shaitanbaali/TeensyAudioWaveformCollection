/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0016 256 samples */
 
const int16_t AKWF_tri_0016_256_DATA [256] = 
{71, 279, 473, 658, 833, 1012, 1205, 1410, 1629, 1862, 2105, 2360, 2629, 2908, 3199, 3503, 3820, 4146, 4484, 4835, 5196, 5568, 5953, 6350, 6756, 7174, 7604, 8044, 8494, 8958, 9432, 9913, 10409, 10916, 11431, 11958, 12496, 13043, 13602, 14171, 14750, 15337, 15936, 16548, 17168, 17796, 18438, 19088, 19745, 20415, 21088, 21758, 22431, 23107, 23779, 24451, 25123, 25795, 26464, 27132, 27798, 28461, 29123, 29783, 30441, 31091, 31733, 32408, 32751, 31941, 30787, 29841, 28882, 27935, 27020, 26123, 25250, 24402, 23571, 22762, 21978, 21213, 20465, 19741, 19034, 18346, 17676, 17024, 16390, 15772, 15168, 14576, 13995, 13421, 12860, 12309, 11766, 11237, 10717, 10206, 9708, 9221, 8741, 8273, 7816, 7370, 6932, 6505, 6091, 5684, 5289, 4904, 4531, 4165, 3811, 3469, 3134, 2811, 2498, 2196, 1902, 1621, 1348, 1085, 833, 592, 359, 135, -76, -279, -474, -658, -834, -1013, -1206, -1410, -1631, -1863, -2106, -2361, -2630, -2909, -3200, -3505, -3820, -4147, -4485, -4835, -5197, -5569, -5954, -6351, -6757, -7174, -7605, -8045, -8494, -8959, -9432, -9914, -10410, -10916, -11431, -11959, -12496, -13043, -13602, -14170, -14751, -15338, -15938, -16550, -17168, -17796, -18437, -19088, -19745, -20415, -21088, -21759, -22432, -23106, -23779, -24451, -25123, -25795, -26464, -27132, -27799, -28462, -29123, -29784, -30441, -31091, -31733, -32408, -32751, -31941, -30788, -29840, -28881, -27933, -27020, -26124, -25250, -24403, -23572, -22762, -21978, -21212, -20465, -19741, -19034, -18347, -17677, -17024, -16390, -15775, -15170, -14577, -13994, -13421, -12860, -12310, -11767, -11238, -10718, -10208, -9708, -9221, -8742, -8273, -7817, -7371, -6933, -6506, -6091, -5686, -5290, -4905, -4531, -4166, -3811, -3470, -3135, -2812, -2500, -2196, -1903, -1621, -1348, -1086, -835, -593, -361, -133};