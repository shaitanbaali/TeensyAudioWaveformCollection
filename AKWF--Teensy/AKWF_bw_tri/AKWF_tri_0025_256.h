/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0025 256 samples */
 
const int16_t AKWF_tri_0025_256_DATA [256] = 
{3859, 8916, 10403, 11916, 13318, 14426, 15441, 16357, 17191, 17963, 18679, 19348, 19977, 20566, 21125, 21656, 22159, 22638, 23097, 23535, 23952, 24353, 24738, 25108, 25463, 25805, 26134, 26452, 26759, 27055, 27339, 27615, 27883, 28142, 28390, 28631, 28864, 29091, 29311, 29523, 29728, 29926, 30120, 30308, 30488, 30665, 30833, 30995, 31147, 31294, 31434, 31568, 31697, 31819, 31934, 32047, 32152, 32252, 32347, 32439, 32525, 32606, 32680, 32757, 32737, 32544, 32335, 32146, 31945, 31745, 31543, 31339, 31135, 30929, 30721, 30510, 30299, 30085, 29869, 29653, 29435, 29213, 28988, 28758, 28522, 28281, 28038, 27786, 27530, 27269, 27002, 26728, 26447, 26161, 25868, 25565, 25256, 24939, 24612, 24278, 23934, 23580, 23215, 22838, 22451, 22049, 21636, 21206, 20760, 20299, 19817, 19318, 18796, 18250, 17676, 17075, 16438, 15763, 15046, 14277, 13448, 12550, 11559, 10453, 9194, 7685, 5882, 2807, -3874, -8916, -10393, -11916, -13319, -14426, -15441, -16356, -17191, -17964, -18679, -19349, -19977, -20567, -21125, -21656, -22160, -22639, -23098, -23534, -23951, -24354, -24738, -25109, -25464, -25805, -26135, -26452, -26759, -27056, -27340, -27616, -27883, -28140, -28390, -28631, -28865, -29091, -29311, -29523, -29728, -29926, -30121, -30308, -30490, -30665, -30833, -30994, -31146, -31295, -31435, -31568, -31697, -31820, -31934, -32046, -32152, -32252, -32347, -32439, -32525, -32605, -32680, -32757, -32737, -32544, -32335, -32146, -31945, -31745, -31543, -31339, -31135, -30929, -30721, -30510, -30299, -30086, -29869, -29653, -29435, -29212, -28987, -28758, -28522, -28282, -28038, -27787, -27530, -27269, -27001, -26728, -26448, -26162, -25868, -25565, -25256, -24940, -24614, -24278, -23934, -23580, -23215, -22839, -22451, -22050, -21636, -21206, -20761, -20299, -19818, -19318, -18797, -18250, -17677, -17075, -16437, -15763, -15046, -14277, -13449, -12551, -11560, -10453, -9194, -7698, -5914, -2659};