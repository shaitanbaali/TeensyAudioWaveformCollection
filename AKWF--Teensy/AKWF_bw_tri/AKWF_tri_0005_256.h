/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0005 256 samples */
 
const int16_t AKWF_tri_0005_256_DATA [256] = 
{215, 782, 1337, 1895, 2451, 3008, 3566, 4122, 4679, 5237, 5794, 6351, 6909, 7465, 8023, 8581, 9137, 9695, 10252, 10809, 11367, 11924, 12481, 13038, 13596, 14152, 14710, 15267, 15824, 16382, 16939, 17496, 18054, 18611, 19168, 19726, 20282, 20839, 21397, 21954, 22511, 23069, 23625, 24182, 24740, 25296, 25854, 26412, 26968, 27526, 28084, 28640, 29198, 29755, 30311, 30869, 31425, 31986, 32512, 32739, 32764, 32707, 32592, 32433, 32234, 31996, 31724, 31424, 31104, 30762, 30402, 30027, 29635, 29226, 28806, 28371, 27925, 27468, 27000, 26522, 26036, 25542, 25040, 24533, 24019, 23500, 22976, 22448, 21916, 21381, 20842, 20301, 19759, 19213, 18666, 18118, 17567, 17017, 16466, 15912, 15359, 14805, 14250, 13696, 13140, 12584, 12029, 11472, 10915, 10360, 9803, 9246, 8689, 8132, 7575, 7019, 6461, 5904, 5347, 4790, 4232, 3676, 3118, 2561, 2005, 1447, 890, 333, -224, -781, -1337, -1896, -2452, -3009, -3567, -4123, -4680, -5238, -5795, -6352, -6910, -7466, -8024, -8582, -9138, -9696, -10253, -10809, -11367, -11925, -12481, -13039, -13596, -14153, -14711, -15268, -15824, -16383, -16939, -17496, -18054, -18611, -19168, -19726, -20283, -20840, -21398, -21954, -22511, -23070, -23625, -24183, -24740, -25297, -25854, -26412, -26968, -27526, -28084, -28640, -29198, -29755, -30311, -30869, -31425, -31986, -32512, -32739, -32764, -32707, -32592, -32433, -32234, -31996, -31724, -31424, -31104, -30762, -30402, -30027, -29635, -29226, -28806, -28372, -27925, -27468, -27000, -26522, -26036, -25542, -25040, -24533, -24020, -23500, -22977, -22448, -21916, -21382, -20842, -20302, -19760, -19213, -18666, -18119, -17568, -17017, -16466, -15912, -15359, -14806, -14251, -13696, -13141, -12585, -12030, -11473, -10916, -10361, -9804, -9246, -8690, -8133, -7576, -7019, -6462, -5905, -5348, -4791, -4233, -3677, -3119, -2562, -2006, -1449, -893, -327};