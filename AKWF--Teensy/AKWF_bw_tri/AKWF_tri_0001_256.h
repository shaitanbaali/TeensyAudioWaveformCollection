/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0001 256 samples */
 
const int16_t AKWF_tri_0001_256_DATA [256] = 
{184, 837, 1468, 2093, 2710, 3318, 3919, 4512, 5097, 5676, 6245, 6809, 7365, 7911, 8452, 8986, 9511, 10030, 10543, 11048, 11546, 12038, 12523, 13001, 13473, 13938, 14397, 14849, 15294, 15735, 16168, 16595, 17017, 17433, 17842, 18246, 18644, 19036, 19422, 19802, 20178, 20549, 20912, 21271, 21625, 21972, 22315, 22654, 22985, 23314, 23636, 23954, 24267, 24575, 24878, 25176, 25470, 25759, 26044, 26324, 26599, 26870, 27136, 27398, 27656, 27910, 28160, 28405, 28646, 28882, 29116, 29345, 29570, 29791, 30008, 30222, 30431, 30637, 30839, 31037, 31232, 31423, 31611, 31795, 31976, 32153, 32327, 32486, 32706, 32508, 31473, 30450, 29442, 28441, 27455, 26479, 25513, 24559, 23616, 22684, 21764, 20855, 19955, 19068, 18191, 17323, 16468, 15622, 14786, 13962, 13147, 12340, 11547, 10760, 9984, 9220, 8462, 7714, 6977, 6247, 5528, 4818, 4115, 3423, 2739, 2063, 1397, 738, 88, -552, -1186, -1812, -2429, -3037, -3639, -4233, -4818, -5397, -5966, -6530, -7085, -7632, -8174, -8708, -9233, -9754, -10267, -10772, -11271, -11762, -12247, -12726, -13199, -13663, -14123, -14576, -15021, -15462, -15896, -16323, -16745, -17161, -17571, -17975, -18373, -18765, -19153, -19534, -19910, -20280, -20644, -21003, -21358, -21706, -22049, -22388, -22722, -23050, -23373, -23691, -24004, -24313, -24616, -24915, -25209, -25499, -25783, -26064, -26340, -26610, -26878, -27141, -27399, -27653, -27903, -28149, -28390, -28628, -28862, -29091, -29316, -29539, -29756, -29970, -30181, -30386, -30589, -30788, -30983, -31176, -31364, -31548, -31730, -31908, -32082, -32240, -32465, -32164, -31099, -30082, -29074, -28074, -27088, -26114, -25147, -24195, -23253, -22319, -21401, -20492, -19592, -18706, -17830, -16963, -16109, -15263, -14427, -13604, -12789, -11984, -11190, -10405, -9629, -8865, -8108, -7361, -6625, -5896, -5176, -4467, -3765, -3073, -2390, -1716, -1052, -383};