/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0017 256 samples */
 
const int16_t AKWF_tri_0017_256_DATA [256] = 
{129, 441, 738, 1030, 1329, 1642, 1968, 2304, 2653, 3011, 3378, 3754, 4143, 4537, 4941, 5356, 5775, 6205, 6642, 7086, 7538, 7997, 8463, 8937, 9416, 9903, 10397, 10894, 11400, 11913, 12429, 12950, 13480, 14013, 14551, 15097, 15646, 16199, 16759, 17323, 17891, 18464, 19042, 19624, 20209, 20798, 21395, 21991, 22592, 23193, 23790, 24377, 24965, 25549, 26123, 26695, 27263, 27825, 28380, 28931, 29476, 30013, 30546, 31073, 31592, 32100, 32626, 32660, 31816, 30932, 30162, 29367, 28587, 27824, 27074, 26337, 25614, 24905, 24210, 23527, 22859, 22200, 21555, 20925, 20306, 19696, 19100, 18516, 17938, 17367, 16801, 16241, 15685, 15134, 14591, 14053, 13518, 12993, 12470, 11953, 11445, 10942, 10441, 9951, 9467, 8986, 8512, 8047, 7586, 7132, 6685, 6244, 5811, 5383, 4963, 4552, 4144, 3746, 3355, 2971, 2595, 2228, 1864, 1512, 1168, 830, 500, 178, -135, -441, -739, -1031, -1329, -1643, -1969, -2305, -2654, -3012, -3378, -3755, -4144, -4537, -4942, -5357, -5775, -6206, -6643, -7087, -7538, -7998, -8464, -8938, -9417, -9904, -10399, -10895, -11401, -11914, -12430, -12950, -13480, -14014, -14552, -15097, -15647, -16200, -16759, -17323, -17891, -18464, -19042, -19624, -20209, -20798, -21393, -21992, -22592, -23194, -23788, -24377, -24965, -25548, -26124, -26696, -27264, -27824, -28381, -28930, -29474, -30014, -30546, -31073, -31592, -32099, -32624, -32660, -31817, -30932, -30161, -29367, -28587, -27824, -27075, -26337, -25615, -24908, -24210, -23525, -22859, -22201, -21555, -20927, -20306, -19696, -19101, -18517, -17939, -17367, -16802, -16241, -15685, -15135, -14592, -14053, -13519, -12993, -12471, -11953, -11446, -10943, -10442, -9952, -9467, -8986, -8512, -8047, -7587, -7133, -6685, -6245, -5812, -5383, -4964, -4553, -4145, -3747, -3357, -2972, -2595, -2228, -1865, -1513, -1170, -831, -502, -175};