/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0013 256 samples */
 
const int16_t AKWF_tri_0013_256_DATA [256] = 
{50, 167, 270, 365, 442, 510, 570, 617, 648, 675, 707, 748, 807, 879, 964, 1059, 1172, 1298, 1435, 1591, 1762, 1945, 2141, 2358, 2586, 2827, 3088, 3366, 3655, 3960, 4287, 4624, 4977, 5351, 5741, 6145, 6566, 7008, 7461, 7935, 8430, 8939, 9463, 10010, 10578, 11156, 11757, 12380, 13020, 13676, 14356, 15054, 15770, 16509, 17268, 18040, 18818, 19610, 20413, 21220, 22041, 22873, 23710, 24552, 25411, 26271, 27137, 28017, 28902, 29790, 30684, 31583, 32516, 32577, 31170, 29741, 28517, 27277, 26086, 24937, 23831, 22767, 21740, 20751, 19798, 18884, 18001, 17151, 16337, 15555, 14795, 14071, 13376, 12702, 12058, 11439, 10833, 10249, 9685, 9134, 8602, 8089, 7594, 7114, 6648, 6203, 5772, 5355, 4956, 4574, 4204, 3849, 3513, 3188, 2876, 2583, 2301, 2032, 1778, 1539, 1309, 1094, 894, 707, 528, 365, 216, 74, -52, -165, -270, -365, -445, -512, -573, -618, -649, -674, -708, -750, -807, -881, -964, -1060, -1172, -1300, -1437, -1591, -1763, -1945, -2141, -2357, -2588, -2829, -3090, -3368, -3656, -3961, -4286, -4626, -4979, -5353, -5741, -6145, -6565, -7008, -7463, -7935, -8430, -8940, -9464, -10010, -10578, -11157, -11758, -12382, -13020, -13676, -14356, -15055, -15771, -16510, -17270, -18040, -18819, -19610, -20414, -21221, -22041, -22874, -23708, -24552, -25410, -26272, -27138, -28018, -28902, -29790, -30684, -31582, -32516, -32578, -31171, -29740, -28517, -27277, -26085, -24938, -23831, -22767, -21740, -20753, -19799, -18880, -18003, -17153, -16338, -15554, -14796, -14071, -13377, -12703, -12059, -11441, -10835, -10249, -9684, -9136, -8603, -8092, -7595, -7114, -6649, -6203, -5773, -5355, -4958, -4575, -4204, -3850, -3514, -3188, -2877, -2584, -2302, -2032, -1777, -1539, -1310, -1096, -897, -708, -530, -366, -217, -74};