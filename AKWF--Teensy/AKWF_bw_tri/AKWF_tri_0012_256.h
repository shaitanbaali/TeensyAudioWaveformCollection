/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0012 256 samples */
 
const int16_t AKWF_tri_0012_256_DATA [256] = 
{33, 150, 254, 350, 426, 494, 554, 597, 626, 649, 662, 679, 713, 764, 824, 894, 984, 1086, 1198, 1329, 1476, 1635, 1805, 1999, 2204, 2421, 2659, 2914, 3181, 3463, 3767, 4082, 4413, 4765, 5133, 5515, 5915, 6338, 6770, 7222, 7697, 8188, 8693, 9220, 9768, 10328, 10912, 11517, 12139, 12778, 13442, 14125, 14824, 15548, 16294, 17059, 17839, 18634, 19440, 20251, 21077, 21917, 22760, 23613, 24481, 25352, 26231, 27124, 28023, 28928, 29840, 30759, 31684, 32608, 32434, 30906, 29507, 28272, 27021, 25817, 24665, 23554, 22484, 21452, 20457, 19502, 18585, 17701, 16853, 16037, 15248, 14496, 13774, 13072, 12404, 11764, 11140, 10534, 9953, 9386, 8835, 8308, 7798, 7303, 6824, 6366, 5923, 5493, 5084, 4693, 4312, 3948, 3604, 3269, 2949, 2650, 2363, 2086, 1826, 1583, 1348, 1129, 926, 735, 553, 387, 236, 92, -36, -150, -254, -350, -428, -495, -555, -598, -627, -648, -664, -681, -715, -766, -824, -895, -984, -1087, -1199, -1330, -1479, -1636, -1806, -1999, -2206, -2422, -2661, -2916, -3181, -3463, -3767, -4083, -4414, -4767, -5134, -5516, -5915, -6338, -6773, -7223, -7699, -8189, -8693, -9220, -9769, -10330, -10912, -11519, -12138, -12778, -13442, -14126, -14825, -15549, -16295, -17059, -17839, -18632, -19440, -20253, -21078, -21918, -22761, -23612, -24481, -25354, -26231, -27124, -28024, -28928, -29844, -30758, -31683, -32609, -32435, -30906, -29508, -28272, -27020, -25818, -24665, -23555, -22483, -21451, -20457, -19505, -18586, -17701, -16853, -16037, -15249, -14496, -13773, -13073, -12406, -11766, -11140, -10534, -9953, -9387, -8836, -8309, -7799, -7303, -6825, -6367, -5925, -5494, -5087, -4693, -4312, -3948, -3605, -3270, -2950, -2652, -2363, -2086, -1827, -1584, -1350, -1130, -928, -736, -554, -388, -237, -92};