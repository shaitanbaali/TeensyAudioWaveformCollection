/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0015 256 samples */
 
const int16_t AKWF_tri_0015_256_DATA [256] = 
{52, 199, 335, 460, 573, 679, 777, 879, 995, 1128, 1271, 1426, 1598, 1782, 1978, 2187, 2412, 2647, 2895, 3158, 3437, 3726, 4029, 4349, 4678, 5022, 5383, 5756, 6140, 6542, 6957, 7383, 7827, 8285, 8756, 9240, 9741, 10255, 10782, 11326, 11885, 12459, 13041, 13645, 14262, 14890, 15538, 16201, 16875, 17565, 18273, 18987, 19709, 20438, 21169, 21906, 22647, 23394, 24142, 24892, 25649, 26410, 27168, 27930, 28698, 29461, 30228, 30997, 31759, 32550, 32609, 31385, 30122, 29038, 27938, 26868, 25833, 24834, 23864, 22920, 22011, 21129, 20274, 19448, 18649, 17875, 17127, 16403, 15704, 15029, 14372, 13742, 13129, 12528, 11946, 11379, 10822, 10281, 9756, 9243, 8743, 8260, 7789, 7329, 6885, 6454, 6036, 5631, 5239, 4861, 4492, 4138, 3799, 3466, 3150, 2848, 2554, 2272, 2005, 1747, 1500, 1268, 1047, 834, 633, 447, 268, 100, -54, -199, -335, -461, -574, -680, -778, -880, -996, -1129, -1272, -1427, -1599, -1782, -1978, -2188, -2411, -2647, -2896, -3160, -3438, -3727, -4029, -4349, -4680, -5023, -5385, -5757, -6141, -6542, -6958, -7385, -7828, -8286, -8757, -9241, -9741, -10256, -10783, -11327, -11886, -12457, -13042, -13645, -14263, -14891, -15539, -16201, -16875, -17565, -18274, -18988, -19709, -20439, -21170, -21906, -22647, -23393, -24142, -24892, -25650, -26410, -27168, -27930, -28698, -29462, -30228, -30997, -31759, -32549, -32608, -31385, -30122, -29039, -27939, -26868, -25833, -24834, -23864, -22920, -22011, -21129, -20274, -19450, -18650, -17875, -17128, -16404, -15704, -15028, -14373, -13742, -13129, -12528, -11948, -11380, -10822, -10282, -9758, -9244, -8744, -8261, -7789, -7330, -6885, -6455, -6037, -5631, -5240, -4861, -4493, -4139, -3799, -3468, -3151, -2849, -2555, -2273, -2005, -1748, -1501, -1269, -1048, -835, -634, -447, -270, -99};