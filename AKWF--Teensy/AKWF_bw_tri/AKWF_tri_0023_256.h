/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0023 256 samples */
 
const int16_t AKWF_tri_0023_256_DATA [256] = 
{3217, 7223, 8780, 10199, 11496, 12566, 13543, 14430, 15246, 16007, 16716, 17385, 18016, 18613, 19184, 19726, 20245, 20743, 21222, 21681, 22124, 22551, 22963, 23362, 23748, 24123, 24485, 24837, 25178, 25509, 25833, 26144, 26451, 26749, 27038, 27321, 27596, 27865, 28126, 28383, 28633, 28877, 29114, 29349, 29577, 29798, 30015, 30226, 30430, 30625, 30815, 30998, 31174, 31344, 31509, 31667, 31819, 31967, 32108, 32244, 32376, 32503, 32623, 32744, 32734, 32478, 32206, 31960, 31703, 31444, 31188, 30931, 30672, 30412, 30153, 29892, 29629, 29369, 29106, 28842, 28577, 28311, 28042, 27768, 27492, 27211, 26923, 26632, 26337, 26037, 25730, 25419, 25103, 24780, 24451, 24115, 23772, 23422, 23067, 22700, 22326, 21944, 21552, 21150, 20737, 20313, 19876, 19428, 18964, 18487, 17990, 17478, 16947, 16393, 15816, 15213, 14578, 13909, 13204, 12451, 11645, 10777, 9826, 8772, 7581, 6177, 4489, 1804, -3253, -7218, -8770, -10201, -11497, -12567, -13542, -14430, -15247, -16008, -16717, -17385, -18017, -18613, -19184, -19727, -20246, -20744, -21222, -21681, -22125, -22551, -22963, -23362, -23748, -24122, -24485, -24836, -25178, -25509, -25833, -26145, -26452, -26749, -27038, -27321, -27596, -27865, -28126, -28383, -28633, -28878, -29114, -29349, -29577, -29798, -30015, -30226, -30430, -30625, -30815, -30998, -31174, -31344, -31509, -31667, -31820, -31967, -32108, -32244, -32376, -32502, -32622, -32744, -32734, -32478, -32206, -31960, -31703, -31444, -31188, -30931, -30672, -30412, -30153, -29892, -29629, -29368, -29107, -28842, -28578, -28311, -28042, -27768, -27492, -27211, -26923, -26633, -26337, -26037, -25730, -25420, -25104, -24780, -24451, -24115, -23772, -23422, -23067, -22699, -22325, -21944, -21552, -21150, -20737, -20314, -19877, -19427, -18965, -18488, -17991, -17478, -16948, -16393, -15816, -15213, -14579, -13910, -13203, -12453, -11646, -10777, -9826, -8772, -7582, -6185, -4511, -1703};