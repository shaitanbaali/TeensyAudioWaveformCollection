/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0004 256 samples */
 
const int16_t AKWF_tri_0004_256_DATA [256] = 
{369, 1199, 1961, 2707, 3438, 4160, 4898, 5671, 6510, 7429, 8437, 9547, 10764, 12076, 13472, 14925, 16406, 17904, 19389, 20835, 22230, 23548, 24776, 25913, 26946, 27874, 28699, 29423, 30049, 30587, 31040, 31420, 31733, 31988, 32193, 32355, 32482, 32579, 32652, 32705, 32740, 32760, 32767, 32761, 32741, 32708, 32661, 32595, 32509, 32401, 32267, 32106, 31910, 31678, 31404, 31077, 30682, 30183, 29643, 29157, 28732, 28344, 27978, 27633, 27312, 27021, 26757, 26517, 26298, 26099, 25916, 25752, 25602, 25464, 25336, 25215, 25101, 24989, 24879, 24768, 24653, 24533, 24405, 24270, 24122, 23962, 23788, 23599, 23392, 23168, 22925, 22662, 22378, 22073, 21747, 21398, 21027, 20633, 20218, 19779, 19319, 18837, 18332, 17807, 17260, 16692, 16106, 15499, 14874, 14233, 13573, 12897, 12206, 11499, 10777, 10044, 9297, 8538, 7770, 6990, 6203, 5408, 4602, 3792, 2976, 2153, 1328, 500, -331, -1135, -1906, -2654, -3384, -4108, -4843, -5614, -6447, -7360, -8360, -9462, -10672, -11977, -13368, -14818, -16297, -17794, -19281, -20731, -22129, -23454, -24689, -25833, -26874, -27810, -28643, -29374, -30007, -30550, -31011, -31395, -31713, -31972, -32180, -32345, -32474, -32573, -32648, -32702, -32739, -32760, -32767, -32762, -32745, -32713, -32665, -32600, -32517, -32409, -32278, -32119, -31926, -31697, -31425, -31103, -30714, -30223, -29682, -29190, -28762, -28371, -28004, -27657, -27335, -27042, -26777, -26534, -26314, -26112, -25929, -25764, -25613, -25474, -25346, -25225, -25109, -24998, -24888, -24776, -24662, -24543, -24416, -24281, -24134, -23975, -23803, -23614, -23409, -23187, -22944, -22683, -22402, -22097, -21772, -21425, -21056, -20664, -20250, -19813, -19355, -18874, -18370, -17847, -17302, -16736, -16152, -15547, -14922, -14283, -13624, -12948, -12259, -11553, -10832, -10100, -9354, -8596, -7829, -7050, -6262, -5467, -4663, -3854, -3038, -2217, -1394, -553};