/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0022 256 samples */
 
const int16_t AKWF_tri_0022_256_DATA [256] = 
{1057, 4387, 6361, 7716, 8982, 10071, 11046, 11942, 12769, 13544, 14270, 14958, 15612, 16234, 16831, 17405, 17953, 18481, 18994, 19489, 19967, 20431, 20882, 21321, 21746, 22161, 22566, 22960, 23345, 23721, 24088, 24447, 24800, 25143, 25480, 25810, 26135, 26452, 26763, 27069, 27369, 27663, 27954, 28238, 28517, 28790, 29061, 29327, 29583, 29835, 30079, 30312, 30542, 30766, 30980, 31190, 31395, 31593, 31783, 31969, 32150, 32324, 32492, 32662, 32770, 32567, 32204, 31894, 31581, 31263, 30947, 30630, 30315, 30000, 29687, 29371, 29057, 28745, 28430, 28116, 27804, 27490, 27176, 26860, 26540, 26214, 25886, 25554, 25219, 24879, 24535, 24184, 23829, 23470, 23106, 22735, 22357, 21976, 21588, 21190, 20787, 20376, 19956, 19528, 19093, 18645, 18188, 17720, 17239, 16747, 16240, 15717, 15179, 14621, 14042, 13444, 12817, 12165, 11482, 10757, 9991, 9176, 8293, 7332, 6271, 5060, 3636, 1825, -1079, -4383, -6357, -7717, -8982, -10072, -11047, -11941, -12769, -13544, -14271, -14959, -15613, -16234, -16831, -17404, -17953, -18482, -18996, -19489, -19968, -20432, -20882, -21321, -21747, -22161, -22566, -22960, -23345, -23722, -24088, -24447, -24800, -25144, -25482, -25812, -26135, -26452, -26763, -27069, -27370, -27664, -27954, -28238, -28517, -28791, -29063, -29328, -29583, -29835, -30079, -30312, -30542, -30766, -30980, -31190, -31395, -31593, -31783, -31970, -32150, -32324, -32492, -32662, -32770, -32567, -32204, -31894, -31581, -31263, -30946, -30631, -30315, -30001, -29686, -29371, -29057, -28744, -28430, -28116, -27804, -27490, -27176, -26860, -26540, -26214, -25887, -25555, -25220, -24880, -24534, -24185, -23830, -23471, -23106, -22735, -22357, -21976, -21587, -21189, -20788, -20376, -19955, -19528, -19093, -18645, -18188, -17720, -17240, -16748, -16240, -15717, -15180, -14622, -14044, -13444, -12818, -12166, -11482, -10757, -9992, -9177, -8294, -7333, -6271, -5066, -3657, -1753};