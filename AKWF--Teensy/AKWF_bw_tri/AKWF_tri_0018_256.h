/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0018 256 samples */
 
const int16_t AKWF_tri_0018_256_DATA [256] = 
{140, 656, 1164, 1675, 2189, 2710, 3233, 3755, 4279, 4805, 5330, 5856, 6383, 6908, 7434, 7961, 8487, 9013, 9539, 10064, 10590, 11114, 11639, 12165, 12687, 13210, 13734, 14255, 14778, 15300, 15821, 16340, 16861, 17380, 17899, 18417, 18934, 19452, 19968, 20483, 20998, 21511, 22024, 22537, 23050, 23560, 24071, 24581, 25086, 25588, 26081, 26566, 27044, 27516, 27978, 28434, 28884, 29327, 29761, 30187, 30608, 31021, 31426, 31825, 32213, 32614, 32730, 32141, 31423, 30812, 30182, 29557, 28941, 28333, 27734, 27140, 26552, 25976, 25405, 24841, 24285, 23735, 23190, 22655, 22125, 21601, 21083, 20566, 20049, 19534, 19019, 18505, 17993, 17478, 16968, 16458, 15945, 15435, 14927, 14418, 13911, 13406, 12897, 12392, 11887, 11383, 10879, 10375, 9872, 9370, 8867, 8367, 7866, 7363, 6864, 6365, 5862, 5363, 4864, 4365, 3864, 3366, 2865, 2364, 1864, 1363, 861, 357, -148, -655, -1164, -1676, -2190, -2711, -3235, -3756, -4282, -4807, -5331, -5857, -6384, -6909, -7435, -7962, -8487, -9013, -9539, -10064, -10591, -11115, -11640, -12165, -12688, -13211, -13735, -14258, -14779, -15302, -15822, -16341, -16861, -17381, -17899, -18417, -18936, -19451, -19968, -20482, -20999, -21512, -22025, -22538, -23050, -23560, -24071, -24581, -25086, -25588, -26081, -26565, -27044, -27516, -27979, -28435, -28884, -29327, -29761, -30187, -30609, -31022, -31426, -31826, -32213, -32614, -32730, -32140, -31424, -30812, -30182, -29557, -28941, -28333, -27735, -27140, -26553, -25977, -25405, -24840, -24285, -23735, -23190, -22656, -22125, -21601, -21083, -20566, -20050, -19534, -19019, -18505, -17993, -17479, -16968, -16458, -15945, -15436, -14928, -14418, -13911, -13405, -12898, -12393, -11889, -11383, -10879, -10376, -9872, -9370, -8869, -8368, -7867, -7364, -6864, -6366, -5864, -5364, -4866, -4366, -3865, -3366, -2867, -2365, -1865, -1365, -864, -351};