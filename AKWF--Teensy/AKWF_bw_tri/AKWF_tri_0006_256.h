/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0006 256 samples */
 
const int16_t AKWF_tri_0006_256_DATA [256] = 
{337, 1211, 2051, 2878, 3689, 4486, 5270, 6037, 6791, 7533, 8260, 8976, 9680, 10370, 11049, 11718, 12373, 13020, 13655, 14278, 14894, 15499, 16094, 16680, 17257, 17825, 18385, 18935, 19476, 20010, 20537, 21054, 21565, 22068, 22563, 23053, 23534, 24008, 24477, 24938, 25393, 25842, 26285, 26722, 27153, 27577, 27997, 28410, 28818, 29221, 29619, 30010, 30398, 30781, 31158, 31532, 31899, 32265, 32604, 32749, 32765, 32729, 32655, 32554, 32425, 32272, 32095, 31898, 31687, 31460, 31219, 30966, 30699, 30419, 30127, 29822, 29506, 29179, 28840, 28491, 28132, 27762, 27382, 26994, 26595, 26185, 25769, 25343, 24907, 24464, 24011, 23550, 23082, 22604, 22118, 21624, 21120, 20610, 20090, 19560, 19024, 18479, 17923, 17361, 16786, 16203, 15613, 15010, 14397, 13777, 13143, 12499, 11847, 11181, 10504, 9816, 9115, 8402, 7677, 6939, 6187, 5422, 4641, 3848, 3040, 2215, 1376, 520, -349, -1209, -2051, -2879, -3690, -4487, -5271, -6037, -6792, -7534, -8260, -8976, -9681, -10370, -11050, -11718, -12374, -13020, -13656, -14279, -14895, -15500, -16094, -16680, -17258, -17825, -18385, -18935, -19477, -20011, -20537, -21055, -21566, -22069, -22564, -23053, -23534, -24009, -24477, -24938, -25393, -25843, -26285, -26722, -27153, -27577, -27997, -28410, -28818, -29221, -29619, -30010, -30399, -30781, -31158, -31532, -31899, -32265, -32604, -32749, -32765, -32729, -32655, -32554, -32425, -32272, -32095, -31898, -31687, -31460, -31219, -30967, -30700, -30419, -30127, -29822, -29506, -29179, -28840, -28491, -28132, -27762, -27382, -26994, -26595, -26186, -25769, -25343, -24907, -24464, -24011, -23550, -23083, -22604, -22119, -21625, -21120, -20610, -20090, -19561, -19025, -18479, -17924, -17361, -16787, -16204, -15613, -15011, -14398, -13777, -13143, -12500, -11847, -11182, -10504, -9817, -9116, -8403, -7678, -6939, -6188, -5423, -4642, -3849, -3041, -2217, -1381, -509};