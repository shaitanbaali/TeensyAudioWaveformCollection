/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0014 256 samples */
 
const int16_t AKWF_tri_0014_256_DATA [256] = 
{72, 196, 309, 410, 497, 575, 644, 699, 756, 831, 915, 1010, 1122, 1246, 1380, 1531, 1699, 1876, 2067, 2274, 2496, 2726, 2976, 3242, 3519, 3808, 4119, 4441, 4775, 5129, 5498, 5879, 6276, 6693, 7121, 7566, 8029, 8509, 9001, 9511, 10041, 10583, 11141, 11722, 12319, 12927, 13559, 14209, 14870, 15553, 16259, 16977, 17713, 18463, 19218, 19982, 20755, 21535, 22325, 23122, 23922, 24731, 25545, 26367, 27196, 28028, 28864, 29710, 30555, 31393, 32287, 32742, 31696, 30230, 29050, 27860, 26694, 25584, 24506, 23463, 22460, 21492, 20554, 19653, 18785, 17948, 17139, 16359, 15611, 14888, 14190, 13521, 12877, 12251, 11648, 11062, 10488, 9935, 9399, 8876, 8369, 7880, 7405, 6944, 6502, 6074, 5658, 5256, 4873, 4502, 4143, 3800, 3473, 3155, 2850, 2564, 2285, 2020, 1770, 1533, 1305, 1091, 891, 698, 519, 355, 200, 54, -77, -196, -311, -410, -497, -576, -645, -700, -757, -832, -916, -1011, -1122, -1248, -1383, -1533, -1701, -1877, -2067, -2274, -2497, -2728, -2977, -3243, -3519, -3809, -4119, -4441, -4775, -5131, -5499, -5879, -6277, -6693, -7124, -7566, -8030, -8509, -9002, -9510, -10040, -10585, -11142, -11723, -12319, -12928, -13558, -14209, -14870, -15554, -16259, -16977, -17713, -18461, -19219, -19983, -20755, -21538, -22325, -23119, -23922, -24734, -25546, -26368, -27198, -28027, -28863, -29708, -30554, -31393, -32287, -32742, -31694, -30230, -29049, -27860, -26694, -25584, -24506, -23462, -22460, -21492, -20554, -19653, -18786, -17948, -17139, -16360, -15612, -14889, -14191, -13522, -12878, -12251, -11648, -11063, -10489, -9935, -9400, -8876, -8370, -7880, -7406, -6946, -6503, -6075, -5658, -5257, -4874, -4503, -4143, -3801, -3473, -3155, -2850, -2564, -2286, -2020, -1773, -1534, -1305, -1091, -892, -700, -521, -357, -201, -54};