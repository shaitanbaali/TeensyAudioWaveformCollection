/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri_0010 256 samples */
 
const int16_t AKWF_tri_0010_256_DATA [256] = 
{140, 604, 1057, 1513, 1967, 2421, 2876, 3328, 3781, 4232, 4683, 5135, 5586, 6037, 6489, 6941, 7391, 7843, 8295, 8746, 9197, 9649, 10098, 10550, 11003, 11454, 11906, 12357, 12809, 13262, 13714, 14165, 14617, 15069, 15521, 15973, 16424, 16876, 17329, 17782, 18234, 18686, 19137, 19591, 20043, 20493, 20945, 21398, 21850, 22301, 22755, 23206, 23658, 24110, 24561, 25015, 25466, 25917, 26371, 26823, 27273, 27726, 28179, 28630, 29082, 29534, 29986, 30438, 30889, 31341, 31791, 32239, 32701, 32600, 31284, 29475, 27868, 26543, 25379, 24301, 23288, 22326, 21424, 20583, 19799, 19069, 18399, 17774, 17196, 16658, 16156, 15685, 15239, 14815, 14405, 14011, 13625, 13243, 12866, 12488, 12110, 11729, 11342, 10951, 10554, 10149, 9741, 9326, 8903, 8475, 8042, 7604, 7163, 6715, 6264, 5813, 5359, 4903, 4444, 3984, 3525, 3065, 2605, 2145, 1686, 1227, 768, 312, -147, -603, -1057, -1514, -1968, -2422, -2876, -3329, -3781, -4233, -4684, -5135, -5587, -6038, -6489, -6942, -7392, -7844, -8296, -8746, -9198, -9650, -10098, -10551, -11004, -11454, -11906, -12358, -12809, -13263, -13714, -14165, -14617, -15069, -15522, -15974, -16425, -16876, -17330, -17782, -18235, -18686, -19137, -19591, -20043, -20494, -20945, -21399, -21850, -22302, -22755, -23207, -23658, -24110, -24561, -25015, -25466, -25917, -26371, -26823, -27273, -27726, -28179, -28630, -29082, -29534, -29986, -30439, -30889, -31341, -31791, -32239, -32701, -32600, -31284, -29475, -27868, -26543, -25379, -24301, -23288, -22327, -21424, -20583, -19799, -19070, -18399, -17775, -17197, -16659, -16157, -15686, -15240, -14815, -14406, -14012, -13626, -13244, -12867, -12489, -12111, -11729, -11343, -10952, -10554, -10150, -9742, -9327, -8904, -8476, -8042, -7605, -7164, -6716, -6264, -5814, -5360, -4904, -4445, -3984, -3526, -3066, -2606, -2146, -1687, -1228, -771, -306};