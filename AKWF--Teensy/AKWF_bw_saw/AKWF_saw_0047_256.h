/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0047 256 samples */
 
const int16_t AKWF_saw_0047_256_DATA [256] = 
{151, 471, 784, 1098, 1406, 1713, 2016, 2320, 2621, 2921, 3218, 3512, 3802, 4093, 4383, 4670, 4956, 5237, 5517, 5796, 6074, 6349, 6623, 6894, 7162, 7429, 7695, 7961, 8221, 8480, 8739, 8995, 9251, 9505, 9756, 10005, 10252, 10498, 10744, 10987, 11228, 11467, 11703, 11941, 12176, 12409, 12640, 12868, 13096, 13323, 13549, 13773, 13995, 14214, 14433, 14651, 14867, 15082, 15295, 15505, 15715, 15924, 16132, 16337, 16541, 16743, 16944, 17145, 17344, 17541, 17738, 17931, 18125, 18317, 18508, 18698, 18884, 19070, 19256, 19441, 19624, 19806, 19985, 20165, 20343, 20519, 20695, 20870, 21041, 21212, 21384, 21554, 21722, 21889, 22054, 22219, 22383, 22546, 22708, 22868, 23027, 23185, 23342, 23498, 23653, 23806, 23959, 24110, 24261, 24412, 24560, 24707, 24854, 24999, 25144, 25288, 25431, 25572, 25711, 25851, 25990, 26129, 26266, 26402, 26547, 26508, 27980, 25820, -25820, -27980, -26508, -26547, -26403, -26266, -26129, -25991, -25851, -25712, -25572, -25431, -25288, -25145, -24999, -24854, -24708, -24560, -24412, -24262, -24111, -23959, -23807, -23654, -23498, -23342, -23185, -23027, -22868, -22708, -22547, -22384, -22219, -22054, -21890, -21722, -21554, -21385, -21213, -21041, -20870, -20695, -20519, -20343, -20165, -19985, -19806, -19625, -19442, -19256, -19071, -18885, -18698, -18508, -18318, -18125, -17931, -17738, -17542, -17344, -17146, -16945, -16743, -16541, -16338, -16132, -15924, -15715, -15506, -15295, -15082, -14868, -14651, -14434, -14215, -13995, -13774, -13550, -13324, -13097, -12869, -12640, -12410, -12176, -11941, -11704, -11467, -11228, -10988, -10745, -10499, -10253, -10006, -9757, -9506, -9252, -8996, -8740, -8481, -8222, -7961, -7696, -7429, -7162, -6894, -6623, -6350, -6075, -5797, -5518, -5237, -4956, -4671, -4384, -4094, -3803, -3513, -3219, -2922, -2622, -2321, -2017, -1714, -1407, -1099, -785, -472, -152};