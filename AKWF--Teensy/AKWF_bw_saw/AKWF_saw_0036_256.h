/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0036 256 samples */
 
const int16_t AKWF_saw_0036_256_DATA [256] = 
{59, 183, 304, 424, 545, 667, 788, 908, 1030, 1152, 1272, 1393, 1515, 1636, 1756, 1877, 1999, 2120, 2241, 2362, 2483, 2605, 2725, 2846, 2968, 3089, 3209, 3331, 3453, 3573, 3694, 3815, 3937, 4057, 4178, 4301, 4421, 4541, 4663, 4785, 4905, 5026, 5148, 5269, 5390, 5510, 5632, 5754, 5874, 5995, 6117, 6238, 6358, 6479, 6601, 6722, 6842, 6964, 7086, 7206, 7326, 7449, 7570, 7690, 7811, 7933, 8054, 8175, 8295, 8417, 8538, 8659, 8780, 8902, 9022, 9143, 9265, 9386, 9507, 9628, 9749, 9870, 9991, 10112, 10234, 10355, 10475, 10597, 10718, 10839, 10960, 11081, 11202, 11323, 11444, 11566, 11687, 11808, 11929, 12050, 12171, 12292, 12413, 12535, 12656, 12777, 12897, 13019, 13140, 13261, 13382, 13504, 13624, 13745, 13867, 13988, 14109, 14230, 14351, 14472, 14593, 14714, 14836, 14957, 15077, 15199, 15320, 15441, 15562, 15682, 15204, 18710, -16643, -32954, -27346, -26363, -24862, -23527, -22336, -21268, -20311, -19453, -18679, -17981, -17352, -16781, -16263, -15791, -15361, -14966, -14603, -14268, -13959, -13671, -13403, -13152, -12916, -12693, -12483, -12283, -12091, -11909, -11733, -11564, -11400, -11242, -11087, -10937, -10790, -10646, -10505, -10366, -10229, -10094, -9960, -9828, -9698, -9568, -9439, -9312, -9185, -9059, -8933, -8808, -8683, -8559, -8436, -8312, -8188, -8065, -7942, -7820, -7697, -7575, -7453, -7332, -7209, -7088, -6966, -6844, -6723, -6601, -6479, -6358, -6237, -6115, -5994, -5873, -5751, -5630, -5509, -5387, -5266, -5146, -5025, -4903, -4782, -4661, -4539, -4418, -4297, -4176, -4055, -3934, -3813, -3692, -3570, -3449, -3329, -3208, -3086, -2965, -2844, -2723, -2602, -2480, -2360, -2239, -2117, -1996, -1876, -1754, -1633, -1512, -1391, -1270, -1148, -1027, -907, -785, -664, -544, -423, -301, -180, -58};