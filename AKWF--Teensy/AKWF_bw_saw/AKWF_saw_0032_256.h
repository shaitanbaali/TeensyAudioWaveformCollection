/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0032 256 samples */
 
const int16_t AKWF_saw_0032_256_DATA [256] = 
{2298, 4695, 5637, 6482, 7242, 7877, 8455, 8982, 9468, 9921, 10346, 10745, 11124, 11483, 11827, 12155, 12467, 12770, 13061, 13339, 13609, 13871, 14123, 14367, 14605, 14834, 15058, 15275, 15487, 15693, 15892, 16088, 16280, 16464, 16646, 16825, 16997, 17165, 17332, 17493, 17651, 17807, 17958, 18105, 18252, 18395, 18535, 18672, 18807, 18938, 19066, 19194, 19318, 19439, 19560, 19678, 19793, 19907, 20018, 20128, 20235, 20340, 20445, 20546, 20647, 20745, 20842, 20938, 21031, 21123, 21212, 21302, 21390, 21476, 21560, 21644, 21726, 21805, 21886, 21964, 22040, 22115, 22190, 22262, 22334, 22406, 22474, 22543, 22610, 22677, 22742, 22805, 22869, 22931, 22992, 23052, 23112, 23169, 23226, 23284, 23338, 23393, 23447, 23499, 23552, 23603, 23653, 23701, 23748, 23795, 23841, 23884, 23925, 23966, 24006, 24044, 24081, 24117, 24152, 24185, 24219, 24250, 24280, 24310, 24335, 24066, 25333, 17226, -20992, -32068, -25237, -26508, -26657, -26200, -26126, -25974, -25817, -25676, -25535, -25400, -25266, -25136, -25007, -24882, -24758, -24638, -24519, -24403, -24288, -24173, -24061, -23949, -23840, -23732, -23624, -23518, -23413, -23308, -23203, -23101, -22999, -22897, -22795, -22693, -22589, -22484, -22379, -22274, -22167, -22061, -21952, -21842, -21734, -21623, -21511, -21398, -21286, -21171, -21055, -20940, -20823, -20705, -20586, -20465, -20345, -20223, -20099, -19974, -19848, -19722, -19594, -19463, -19332, -19201, -19068, -18932, -18796, -18659, -18519, -18378, -18236, -18091, -17945, -17797, -17648, -17496, -17342, -17187, -17030, -16869, -16707, -16543, -16377, -16207, -16036, -15861, -15684, -15505, -15321, -15135, -14946, -14751, -14555, -14355, -14151, -13943, -13729, -13511, -13291, -13063, -12830, -12592, -12348, -12095, -11837, -11571, -11296, -11015, -10723, -10419, -10105, -9780, -9439, -9085, -8711, -8318, -7903, -7461, -6989, -6480, -5923, -5306, -4609, -3787, -2819, -1001};