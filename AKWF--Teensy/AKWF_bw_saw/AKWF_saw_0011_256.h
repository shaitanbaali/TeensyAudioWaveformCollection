/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0011 256 samples */
 
const int16_t AKWF_saw_0011_256_DATA [256] = 
{13906, 18039, 20592, 25559, 30371, 32756, 31658, 28002, 23792, 21015, 20406, 21281, 22230, 22082, 20555, 18273, 16232, 15128, 15016, 15380, 15538, 15088, 14086, 12930, 12067, 11711, 11757, 11900, 11850, 11496, 10944, 10410, 10070, 9964, 9993, 10003, 9886, 9630, 9317, 9049, 8887, 8821, 8789, 8720, 8579, 8386, 8184, 8016, 7902, 7820, 7740, 7632, 7492, 7334, 7180, 7048, 6937, 6838, 6733, 6612, 6477, 6338, 6205, 6084, 5971, 5860, 5744, 5621, 5493, 5365, 5241, 5123, 5007, 4891, 4773, 4651, 4528, 4406, 4287, 4170, 4054, 3937, 3818, 3699, 3579, 3461, 3344, 3227, 3112, 2996, 2880, 2762, 2646, 2530, 2415, 2301, 2185, 2071, 1956, 1841, 1726, 1613, 1499, 1386, 1273, 1160, 1046, 934, 821, 710, 598, 485, 375, 263, 152, 41, -68, -178, -288, -399, -508, -619, -728, -837, -945, -1053, -1162, -1270, -1378, -1485, -1594, -1702, -1809, -1916, -2023, -2129, -2235, -2342, -2447, -2553, -2658, -2764, -2869, -2975, -3079, -3184, -3288, -3391, -3496, -3600, -3703, -3807, -3910, -4012, -4115, -4217, -4319, -4422, -4524, -4625, -4727, -4829, -4929, -5030, -5130, -5231, -5331, -5432, -5532, -5631, -5731, -5830, -5929, -6029, -6127, -6225, -6324, -6422, -6521, -6618, -6716, -6813, -6910, -7007, -7104, -7200, -7297, -7393, -7489, -7585, -7681, -7777, -7872, -7967, -8062, -8156, -8251, -8346, -8440, -8534, -8627, -8721, -8815, -8908, -9001, -9094, -9187, -9280, -9372, -9464, -9556, -9648, -9740, -9831, -9922, -10014, -10105, -10195, -10286, -10376, -10467, -10557, -10646, -10736, -10825, -10915, -11005, -11093, -11182, -11271, -11360, -11447, -11536, -11624, -11711, -11799, -11886, -11974, -12061, -12147, -12234, -12321, -12408, -12494, -12580, -12666, -12751, -12838, -12922, -13002, -13096, -13177, -13259, -13272, -13767, -11933};