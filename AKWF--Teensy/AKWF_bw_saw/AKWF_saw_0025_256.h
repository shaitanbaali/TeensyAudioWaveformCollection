/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0025 256 samples */
 
const int16_t AKWF_saw_0025_256_DATA [256] = 
{85, 209, 328, 450, 570, 695, 824, 957, 1092, 1229, 1371, 1514, 1660, 1808, 1960, 2112, 2266, 2426, 2585, 2745, 2910, 3077, 3244, 3414, 3588, 3759, 3935, 4114, 4294, 4474, 4657, 4842, 5027, 5215, 5405, 5597, 5789, 5984, 6180, 6376, 6575, 6776, 6977, 7180, 7386, 7590, 7797, 8006, 8217, 8428, 8640, 8854, 9068, 9284, 9502, 9721, 9940, 10160, 10384, 10605, 10828, 11054, 11282, 11507, 11736, 11966, 12194, 12426, 12660, 12891, 13126, 13361, 13597, 13833, 14070, 14309, 14549, 14787, 15029, 15272, 15513, 15756, 16002, 16246, 16491, 16737, 16979, 17220, 17458, 17694, 17928, 18158, 18387, 18612, 18835, 19056, 19275, 19490, 19703, 19914, 20121, 20326, 20530, 20730, 20926, 21123, 21314, 21503, 21691, 21877, 22059, 22238, 22415, 22590, 22761, 22931, 23099, 23263, 23424, 23584, 23742, 23895, 24049, 24199, 24345, 24490, 24634, 24773, 24897, 24703, 26478, 13010, -25885, -30514, -24556, -25884, -25456, -24816, -24486, -24069, -23664, -23280, -22899, -22525, -22161, -21805, -21455, -21114, -20779, -20450, -20129, -19813, -19505, -19202, -18903, -18613, -18327, -18045, -17770, -17501, -17233, -16974, -16720, -16467, -16220, -15977, -15740, -15504, -15274, -15047, -14820, -14594, -14371, -14149, -13926, -13705, -13487, -13267, -13050, -12835, -12620, -12406, -12194, -11983, -11773, -11563, -11355, -11149, -10944, -10740, -10536, -10335, -10133, -9935, -9736, -9538, -9344, -9148, -8955, -8763, -8572, -8382, -8194, -8007, -7820, -7635, -7452, -7270, -7088, -6909, -6731, -6553, -6376, -6202, -6029, -5855, -5686, -5517, -5346, -5179, -5015, -4851, -4687, -4525, -4364, -4204, -4046, -3891, -3734, -3580, -3429, -3277, -3127, -2978, -2832, -2685, -2539, -2398, -2255, -2114, -1975, -1837, -1700, -1565, -1432, -1298, -1167, -1036, -907, -779, -652, -528, -403, -279, -157, -33};