/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0005 256 samples */
 
const int16_t AKWF_saw_0005_256_DATA [256] = 
{97, 272, 448, 627, 811, 996, 1185, 1373, 1565, 1758, 1951, 2147, 2343, 2540, 2739, 2938, 3138, 3340, 3542, 3743, 3947, 4152, 4356, 4562, 4768, 4974, 5181, 5389, 5596, 5805, 6015, 6224, 6434, 6644, 6855, 7066, 7277, 7488, 7701, 7912, 8125, 8339, 8551, 8763, 8978, 9190, 9404, 9618, 9832, 10047, 10261, 10475, 10689, 10904, 11119, 11334, 11548, 11763, 11979, 12193, 12407, 12623, 12838, 13053, 13268, 13483, 13697, 13911, 14126, 14341, 14556, 14769, 14983, 15197, 15412, 15625, 15839, 16053, 16266, 16479, 16691, 16904, 17117, 17329, 17541, 17754, 17964, 18176, 18387, 18597, 18809, 19019, 19229, 19438, 19648, 19857, 20065, 20274, 20482, 20689, 20897, 21104, 21311, 21517, 21722, 21928, 22133, 22338, 22543, 22746, 22950, 23153, 23355, 23557, 23758, 23959, 24161, 24361, 24561, 24760, 24959, 25158, 25356, 25552, 25176, 28474, 3980, -30453, -29984, -30952, -32635, -29655, -23224, -18836, -19569, -22909, -24818, -23968, -21883, -20731, -21160, -22134, -22451, -21893, -21107, -20743, -20862, -21055, -20979, -20641, -20287, -20097, -20043, -19981, -19817, -19580, -19356, -19189, -19058, -18914, -18733, -18533, -18342, -18170, -18005, -17833, -17647, -17457, -17271, -17090, -16911, -16726, -16537, -16347, -16158, -15971, -15783, -15592, -15399, -15207, -15013, -14819, -14626, -14431, -14235, -14038, -13842, -13645, -13447, -13248, -13048, -12849, -12648, -12448, -12248, -12046, -11844, -11641, -11438, -11236, -11032, -10828, -10625, -10421, -10216, -10012, -9806, -9601, -9396, -9190, -8985, -8781, -8573, -8368, -8163, -7957, -7751, -7545, -7339, -7134, -6929, -6723, -6518, -6312, -6107, -5903, -5698, -5494, -5290, -5086, -4883, -4681, -4478, -4275, -4074, -3872, -3672, -3472, -3273, -3074, -2877, -2679, -2482, -2287, -2092, -1898, -1706, -1515, -1325, -1137, -950, -766, -584, -405, -230, -58};