/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0020 256 samples */
 
const int16_t AKWF_saw_0020_256_DATA [256] = 
{10, 49, 86, 115, 144, 174, 196, 217, 240, 259, 272, 283, 297, 301, 306, 314, 321, 328, 342, 359, 373, 394, 420, 447, 473, 507, 543, 577, 620, 667, 713, 761, 818, 876, 933, 999, 1068, 1137, 1210, 1291, 1370, 1452, 1543, 1635, 1728, 1825, 1931, 2034, 2141, 2257, 2375, 2493, 2617, 2747, 2874, 3008, 3149, 3291, 3434, 3584, 3739, 3892, 4053, 4220, 4387, 4555, 4733, 4912, 5092, 5280, 5473, 5665, 5861, 6067, 6271, 6479, 6695, 6914, 7134, 7359, 7591, 7822, 8058, 8302, 8550, 8797, 9050, 9311, 9570, 9835, 10110, 10385, 10660, 10944, 11234, 11521, 11818, 12122, 12426, 12731, 13046, 13364, 13677, 13995, 14314, 14628, 14946, 15266, 15583, 15897, 16215, 16534, 16848, 17162, 17480, 17793, 18105, 18421, 18735, 19046, 19356, 19669, 19978, 20285, 20594, 20902, 21205, 21509, 21816, 22115, 22416, 22718, 23017, 23312, 23609, 23905, 24195, 24488, 24781, 24995, 25155, 26387, 129, -32127, -27068, -24315, -25202, -24206, -23533, -22979, -22370, -21791, -21231, -20686, -20158, -19641, -19143, -18657, -18184, -17723, -17278, -16845, -16421, -16012, -15614, -15224, -14846, -14482, -14124, -13775, -13440, -13112, -12790, -12479, -12178, -11883, -11594, -11318, -11045, -10775, -10510, -10251, -9993, -9741, -9494, -9248, -9005, -8769, -8538, -8305, -8080, -7860, -7640, -7423, -7213, -7006, -6799, -6600, -6404, -6209, -6017, -5831, -5648, -5465, -5290, -5117, -4944, -4775, -4614, -4452, -4292, -4139, -3988, -3837, -3691, -3550, -3410, -3271, -3140, -3010, -2880, -2753, -2631, -2514, -2396, -2282, -2171, -2060, -1955, -1853, -1750, -1654, -1560, -1465, -1373, -1287, -1202, -1117, -1038, -962, -885, -810, -741, -673, -604, -542, -482, -419, -361, -309, -256, -203, -159, -113, -66, -24};