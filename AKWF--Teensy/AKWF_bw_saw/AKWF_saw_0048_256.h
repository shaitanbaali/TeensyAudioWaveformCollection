/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0048 256 samples */
 
const int16_t AKWF_saw_0048_256_DATA [256] = 
{136, 429, 715, 1000, 1282, 1562, 1840, 2116, 2392, 2666, 2939, 3207, 3474, 3740, 4005, 4270, 4530, 4790, 5047, 5302, 5558, 5811, 6062, 6311, 6559, 6804, 7051, 7294, 7535, 7775, 8013, 8250, 8486, 8720, 8952, 9183, 9412, 9640, 9867, 10093, 10315, 10537, 10757, 10976, 11195, 11412, 11627, 11840, 12051, 12262, 12473, 12680, 12887, 13092, 13295, 13500, 13702, 13901, 14100, 14297, 14493, 14688, 14883, 15075, 15266, 15455, 15644, 15832, 16019, 16204, 16388, 16570, 16751, 16933, 17112, 17290, 17466, 17641, 17816, 17991, 18163, 18334, 18504, 18672, 18841, 19008, 19174, 19339, 19501, 19664, 19826, 19987, 20146, 20304, 20461, 20617, 20774, 20928, 21082, 21233, 21384, 21534, 21684, 21833, 21981, 22127, 22272, 22417, 22561, 22704, 22846, 22986, 23126, 23265, 23404, 23541, 23678, 23813, 23948, 24082, 24215, 24347, 24478, 24610, 24752, 24731, 26168, 24691, -24691, -26168, -24731, -24753, -24611, -24478, -24348, -24215, -24082, -23948, -23814, -23678, -23542, -23404, -23265, -23127, -22987, -22846, -22704, -22561, -22417, -22273, -22127, -21981, -21834, -21685, -21534, -21385, -21234, -21082, -20929, -20774, -20618, -20461, -20305, -20146, -19988, -19826, -19664, -19501, -19340, -19175, -19008, -18841, -18673, -18504, -18334, -18164, -17992, -17817, -17642, -17467, -17291, -17112, -16933, -16752, -16571, -16388, -16204, -16020, -15833, -15645, -15456, -15267, -15075, -14884, -14689, -14494, -14297, -14101, -13902, -13703, -13501, -13296, -13093, -12887, -12681, -12473, -12263, -12051, -11841, -11628, -11413, -11196, -10977, -10758, -10537, -10315, -10094, -9868, -9641, -9413, -9184, -8952, -8721, -8486, -8251, -8014, -7776, -7536, -7295, -7051, -6805, -6560, -6311, -6063, -5812, -5558, -5303, -5048, -4790, -4531, -4271, -4006, -3741, -3475, -3208, -2940, -2667, -2393, -2117, -1841, -1563, -1283, -1001, -716, -430, -137};