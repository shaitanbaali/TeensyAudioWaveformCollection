/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0037 256 samples */
 
const int16_t AKWF_saw_0037_256_DATA [256] = 
{66, 200, 330, 461, 591, 722, 854, 984, 1115, 1246, 1377, 1507, 1639, 1769, 1900, 2031, 2162, 2293, 2424, 2554, 2685, 2816, 2947, 3078, 3209, 3340, 3470, 3601, 3732, 3863, 3993, 4125, 4256, 4387, 4517, 4648, 4779, 4910, 5040, 5172, 5303, 5434, 5564, 5695, 5826, 5956, 6087, 6219, 6350, 6480, 6611, 6742, 6873, 7003, 7134, 7265, 7397, 7527, 7658, 7789, 7920, 8050, 8182, 8312, 8444, 8574, 8705, 8836, 8966, 9097, 9229, 9359, 9490, 9621, 9752, 9882, 10013, 10144, 10275, 10406, 10537, 10668, 10799, 10929, 11060, 11192, 11322, 11453, 11584, 11715, 11846, 11976, 12107, 12238, 12369, 12499, 12631, 12762, 12892, 13023, 13154, 13285, 13416, 13547, 13678, 13809, 13939, 14070, 14201, 14332, 14462, 14594, 14725, 14856, 14986, 15117, 15248, 15379, 15509, 15641, 15771, 15902, 16033, 16164, 16294, 16426, 16556, 16688, 16818, 16949, 17009, 17354, 17042, -22499, -24474, -26177, -28071, -28692, -28654, -28163, -27380, -26419, -25354, -24243, -23131, -22040, -20992, -20000, -19070, -18209, -17419, -16696, -16042, -15452, -14921, -14447, -14024, -13647, -13312, -13013, -12747, -12508, -12295, -12099, -11922, -11759, -11608, -11466, -11331, -11201, -11076, -10954, -10833, -10714, -10595, -10475, -10356, -10236, -10115, -9993, -9869, -9746, -9620, -9494, -9367, -9239, -9108, -8979, -8849, -8718, -8587, -8456, -8325, -8192, -8061, -7928, -7796, -7664, -7532, -7400, -7268, -7136, -7004, -6872, -6741, -6608, -6477, -6345, -6215, -6083, -5951, -5820, -5689, -5558, -5427, -5296, -5165, -5034, -4903, -4772, -4641, -4511, -4379, -4249, -4118, -3987, -3856, -3725, -3595, -3464, -3332, -3202, -3071, -2941, -2810, -2678, -2548, -2418, -2286, -2155, -2025, -1894, -1763, -1632, -1501, -1370, -1239, -1109, -978, -847, -716, -585, -455, -324, -193, -60};