/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0008 256 samples */
 
const int16_t AKWF_saw_0008_256_DATA [256] = 
{224, 686, 1135, 1581, 2021, 2459, 2893, 3320, 3745, 4166, 4581, 4992, 5401, 5804, 6204, 6600, 6990, 7378, 7762, 8141, 8518, 8891, 9260, 9625, 9987, 10343, 10698, 11049, 11396, 11739, 12080, 12416, 12750, 13080, 13406, 13730, 14050, 14367, 14682, 14993, 15300, 15605, 15906, 16205, 16500, 16793, 17083, 17370, 17654, 17935, 18213, 18489, 18762, 19031, 19299, 19564, 19825, 20084, 20342, 20596, 20848, 21097, 21343, 21588, 21830, 22069, 22306, 22541, 22772, 23003, 23231, 23456, 23679, 23900, 24118, 24335, 24550, 24761, 24972, 25179, 25385, 25590, 25792, 25991, 26189, 26385, 26579, 26771, 26961, 27149, 27335, 27519, 27702, 27883, 28062, 28239, 28415, 28588, 28760, 28930, 29098, 29265, 29430, 29593, 29755, 29915, 30074, 30231, 30386, 30540, 30693, 30844, 30993, 31141, 31287, 31432, 31576, 31718, 31858, 31997, 32135, 32271, 32406, 32525, 32538, 33100, 26043, 1822, -18658, -27546, -30847, -31978, -32293, -32318, -32239, -32123, -31992, -31855, -31715, -31573, -31430, -31286, -31139, -30991, -30842, -30691, -30539, -30385, -30229, -30073, -29914, -29753, -29591, -29428, -29263, -29097, -28928, -28757, -28586, -28412, -28237, -28060, -27881, -27700, -27518, -27334, -27147, -26959, -26768, -26577, -26383, -26187, -25989, -25790, -25587, -25384, -25179, -24970, -24759, -24548, -24333, -24117, -23899, -23677, -23454, -23228, -23001, -22770, -22538, -22303, -22066, -21827, -21586, -21341, -21094, -20846, -20593, -20340, -20082, -19823, -19561, -19297, -19029, -18759, -18486, -18211, -17932, -17651, -17367, -17080, -16791, -16498, -16202, -15904, -15602, -15297, -14989, -14679, -14365, -14047, -13727, -13403, -13077, -12747, -12413, -12077, -11736, -11392, -11046, -10695, -10340, -9983, -9621, -9256, -8887, -8515, -8138, -7759, -7375, -6987, -6596, -6200, -5800, -5398, -4989, -4577, -4162, -3741, -3317, -2889, -2455, -2018, -1577, -1130, -681, -218};