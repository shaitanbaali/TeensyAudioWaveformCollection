/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0019 256 samples */
 
const int16_t AKWF_saw_0019_256_DATA [256] = 
{25, 64, 95, 125, 157, 180, 201, 226, 245, 259, 271, 286, 291, 296, 303, 305, 305, 311, 322, 329, 343, 362, 382, 400, 427, 457, 483, 517, 557, 596, 635, 684, 734, 782, 839, 901, 961, 1023, 1096, 1165, 1238, 1320, 1404, 1487, 1575, 1672, 1766, 1863, 1969, 2078, 2185, 2300, 2422, 2539, 2663, 2796, 2929, 3062, 3203, 3349, 3491, 3643, 3801, 3955, 4118, 4288, 4456, 4626, 4804, 4989, 5174, 5358, 5554, 5751, 5946, 6153, 6364, 6574, 6788, 7012, 7234, 7459, 7694, 7932, 8169, 8412, 8664, 8914, 9168, 9431, 9699, 9964, 10237, 10518, 10795, 11081, 11374, 11669, 11965, 12269, 12579, 12887, 13204, 13528, 13851, 14171, 14497, 14822, 15143, 15468, 15795, 16118, 16439, 16765, 17088, 17407, 17732, 18057, 18376, 18694, 19019, 19336, 19652, 19974, 20292, 20606, 20920, 21238, 21548, 21859, 22173, 22484, 22789, 23097, 23407, 23708, 24011, 24317, 24619, 24908, 24879, 26661, 16389, -23116, -31238, -24157, -25143, -24669, -23764, -23235, -22631, -22035, -21471, -20923, -20384, -19865, -19362, -18868, -18389, -17927, -17476, -17035, -16610, -16197, -15792, -15399, -15019, -14649, -14286, -13938, -13598, -13263, -12939, -12628, -12322, -12022, -11734, -11452, -11175, -10900, -10629, -10365, -10104, -9848, -9594, -9343, -9098, -8860, -8620, -8386, -8159, -7932, -7707, -7490, -7277, -7063, -6856, -6654, -6452, -6253, -6062, -5873, -5683, -5502, -5323, -5144, -4970, -4803, -4637, -4470, -4312, -4157, -4001, -3848, -3704, -3559, -3415, -3279, -3144, -3009, -2879, -2754, -2630, -2508, -2393, -2276, -2162, -2052, -1948, -1842, -1740, -1644, -1546, -1450, -1361, -1274, -1185, -1102, -1024, -944, -866, -793, -724, -651, -587, -525, -461, -400, -345, -291, -235, -188, -141, -94, -50, -11};