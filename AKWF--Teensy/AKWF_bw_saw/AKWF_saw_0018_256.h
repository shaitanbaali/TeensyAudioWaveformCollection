/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0018 256 samples */
 
const int16_t AKWF_saw_0018_256_DATA [256] = 
{20469, 34968, 32262, 32754, 32738, 32717, 32689, 32657, 32618, 32573, 32523, 32467, 32407, 32341, 32270, 32193, 32111, 32024, 31933, 31836, 31734, 31627, 31516, 31399, 31277, 31152, 31021, 30885, 30745, 30600, 30450, 30296, 30137, 29974, 29806, 29633, 29456, 29275, 29090, 28899, 28705, 28506, 28303, 28097, 27885, 27670, 27450, 27226, 26999, 26767, 26531, 26292, 26048, 25801, 25549, 25295, 25036, 24773, 24507, 24237, 23964, 23688, 23406, 23123, 22834, 22545, 22251, 21952, 21653, 21349, 21042, 20733, 20418, 20103, 19784, 19463, 19136, 18809, 18479, 18145, 17811, 17471, 17129, 16789, 16441, 16093, 15743, 15389, 15035, 14677, 14317, 13954, 13592, 13226, 12857, 12490, 12117, 11744, 11371, 10992, 10616, 10236, 9854, 9472, 9088, 8704, 8316, 7930, 7540, 7150, 6761, 6368, 5977, 5584, 5187, 4795, 4398, 4002, 3605, 3207, 2811, 2413, 2014, 1616, 1217, 819, 419, 21, -376, -776, -1173, -1574, -1970, -2368, -2765, -3160, -3558, -3952, -4347, -4742, -5134, -5527, -5918, -6310, -6699, -7087, -7476, -7860, -8246, -8630, -9011, -9394, -9772, -10149, -10526, -10901, -11274, -11644, -12015, -12381, -12747, -13111, -13471, -13831, -14188, -14542, -14896, -15245, -15594, -15940, -16282, -16624, -16961, -17297, -17629, -17959, -18288, -18611, -18934, -19251, -19567, -19881, -20189, -20496, -20799, -21099, -21397, -21690, -21980, -22268, -22550, -22832, -23107, -23381, -23649, -23916, -24178, -24435, -24692, -24941, -25188, -25432, -25670, -25906, -26138, -26364, -26589, -26807, -27023, -27233, -27441, -27643, -27841, -28037, -28226, -28412, -28593, -28768, -28942, -29110, -29273, -29432, -29587, -29737, -29882, -30023, -30160, -30292, -30419, -30541, -30659, -30772, -30881, -30984, -31083, -31177, -31267, -31352, -31432, -31507, -31577, -31642, -31703, -31759, -31810, -31856, -31897, -31934, -31965, -31992, -32013, -32030, -32042, -32049, -32051, -32048};