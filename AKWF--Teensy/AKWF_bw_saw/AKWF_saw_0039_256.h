/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0039 256 samples */
 
const int16_t AKWF_saw_0039_256_DATA [256] = 
{108, 338, 565, 792, 1019, 1244, 1469, 1696, 1923, 2150, 2377, 2604, 2828, 3055, 3281, 3510, 3736, 3961, 4187, 4413, 4640, 4868, 5095, 5321, 5546, 5772, 6000, 6227, 6453, 6678, 6904, 7131, 7358, 7585, 7811, 8037, 8262, 8490, 8717, 8944, 9170, 9396, 9622, 9849, 10076, 10303, 10528, 10754, 10980, 11207, 11435, 11661, 11887, 12112, 12339, 12566, 12793, 13020, 13247, 13472, 13698, 13925, 14152, 14379, 14604, 14829, 15056, 15284, 15510, 15738, 15963, 16188, 16415, 16643, 16869, 17096, 17321, 17547, 17774, 18001, 18228, 18455, 18680, 18905, 19133, 19360, 19587, 19814, 20038, 20264, 20492, 20719, 20946, 21172, 21396, 21623, 21850, 22077, 22304, 22530, 22755, 22982, 23210, 23436, 23663, 23888, 24114, 24341, 24568, 24794, 25022, 25248, 25473, 25699, 25927, 26154, 26381, 26606, 26831, 27059, 27286, 27512, 27740, 27966, 28201, 28228, 29809, 26946, -26946, -29809, -28229, -28201, -27967, -27740, -27513, -27286, -27059, -26831, -26606, -26381, -26154, -25927, -25699, -25473, -25248, -25022, -24795, -24569, -24341, -24114, -23888, -23663, -23437, -23210, -22983, -22755, -22531, -22304, -22077, -21851, -21623, -21396, -21172, -20946, -20719, -20492, -20264, -20038, -19815, -19587, -19361, -19134, -18905, -18680, -18456, -18229, -18002, -17775, -17547, -17321, -17097, -16869, -16643, -16416, -16189, -15964, -15739, -15511, -15284, -15057, -14830, -14604, -14379, -14153, -13926, -13698, -13472, -13248, -13020, -12794, -12566, -12340, -12113, -11888, -11662, -11436, -11208, -10981, -10755, -10529, -10303, -10076, -9849, -9622, -9397, -9171, -8944, -8718, -8491, -8263, -8038, -7812, -7586, -7359, -7132, -6905, -6679, -6454, -6227, -6001, -5773, -5547, -5321, -5095, -4869, -4641, -4414, -4188, -3962, -3737, -3510, -3282, -3055, -2829, -2605, -2378, -2151, -1924, -1697, -1470, -1245, -1020, -793, -566, -339, -109};