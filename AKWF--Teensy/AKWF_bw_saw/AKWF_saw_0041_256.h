/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0041 256 samples */
 
const int16_t AKWF_saw_0041_256_DATA [256] = 
{83, 272, 456, 642, 827, 1011, 1196, 1382, 1566, 1752, 1938, 2122, 2307, 2492, 2677, 2863, 3049, 3234, 3420, 3603, 3790, 3975, 4160, 4344, 4530, 4714, 4900, 5086, 5271, 5455, 5640, 5826, 6011, 6197, 6382, 6567, 6752, 6936, 7122, 7308, 7493, 7678, 7863, 8049, 8233, 8419, 8604, 8789, 8973, 9159, 9345, 9530, 9716, 9900, 10084, 10271, 10456, 10641, 10827, 11011, 11196, 11382, 11567, 11752, 11938, 12122, 12307, 12493, 12678, 12863, 13049, 13233, 13417, 13604, 13790, 13974, 14159, 14344, 14529, 14716, 14900, 15085, 15271, 15455, 15641, 15826, 16012, 16197, 16381, 16567, 16751, 16936, 17122, 17308, 17493, 17678, 17862, 18049, 18235, 18418, 18603, 18788, 18973, 19160, 19345, 19529, 19715, 19899, 20085, 20270, 20455, 20642, 20826, 21011, 21196, 21382, 21567, 21753, 21937, 22123, 22307, 22492, 22679, 22866, 23065, 23135, 24507, 24068, -23277, -24607, -23124, -23076, -22876, -22689, -22505, -22319, -22134, -21948, -21763, -21578, -21394, -21208, -21022, -20836, -20652, -20467, -20282, -20097, -19911, -19725, -19541, -19357, -19171, -18987, -18800, -18615, -18430, -18245, -18060, -17875, -17689, -17504, -17318, -17134, -16949, -16763, -16577, -16392, -16208, -16023, -15838, -15653, -15468, -15282, -15097, -14911, -14727, -14542, -14355, -14170, -13987, -13801, -13616, -13431, -13245, -13060, -12874, -12690, -12505, -12319, -12134, -11949, -11764, -11579, -11393, -11208, -11022, -10838, -10653, -10468, -10282, -10097, -9912, -9726, -9542, -9357, -9171, -8985, -8800, -8615, -8430, -8245, -8060, -7874, -7690, -7504, -7320, -7135, -6948, -6763, -6579, -6393, -6209, -6023, -5837, -5652, -5467, -5282, -5097, -4911, -4726, -4541, -4357, -4172, -3986, -3802, -3616, -3431, -3245, -3060, -2876, -2690, -2503, -2319, -2135, -1949, -1765, -1579, -1393, -1209, -1023, -839, -654, -468, -284, -95};