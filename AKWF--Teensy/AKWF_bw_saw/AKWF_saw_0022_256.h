/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0022 256 samples */
 
const int16_t AKWF_saw_0022_256_DATA [256] = 
{19, 60, 100, 140, 175, 207, 241, 269, 295, 322, 346, 368, 394, 425, 455, 489, 528, 567, 610, 658, 708, 759, 813, 874, 937, 999, 1067, 1141, 1212, 1290, 1373, 1457, 1542, 1633, 1728, 1823, 1923, 2029, 2136, 2243, 2358, 2475, 2593, 2716, 2844, 2973, 3104, 3243, 3382, 3522, 3670, 3821, 3972, 4128, 4290, 4451, 4617, 4788, 4962, 5137, 5317, 5503, 5687, 5877, 6074, 6272, 6470, 6675, 6885, 7094, 7309, 7529, 7752, 7975, 8206, 8440, 8674, 8914, 9160, 9407, 9656, 9913, 10171, 10430, 10697, 10969, 11241, 11516, 11800, 12083, 12370, 12664, 12960, 13259, 13557, 13858, 14156, 14453, 14754, 15053, 15349, 15647, 15947, 16240, 16535, 16833, 17127, 17418, 17713, 18006, 18294, 18586, 18876, 19164, 19448, 19735, 20020, 20301, 20584, 20866, 21146, 21421, 21700, 21974, 22246, 22520, 22792, 23060, 23326, 23595, 23858, 24119, 24381, 24641, 24900, 24977, 25738, 23478, -11503, -33110, -25225, -24837, -25116, -24112, -23567, -23011, -22428, -21882, -21349, -20828, -20322, -19832, -19352, -18885, -18433, -17993, -17563, -17144, -16740, -16344, -15957, -15583, -15219, -14862, -14517, -14182, -13853, -13532, -13222, -12919, -12623, -12336, -12057, -11783, -11515, -11256, -11000, -10745, -10498, -10254, -10009, -9769, -9536, -9303, -9073, -8849, -8627, -8406, -8191, -7980, -7770, -7564, -7362, -7162, -6964, -6771, -6582, -6393, -6209, -6030, -5851, -5673, -5502, -5334, -5164, -5002, -4843, -4683, -4527, -4376, -4227, -4078, -3935, -3794, -3654, -3516, -3384, -3254, -3123, -2999, -2877, -2754, -2635, -2522, -2408, -2296, -2190, -2084, -1979, -1878, -1780, -1683, -1588, -1498, -1409, -1320, -1236, -1155, -1073, -994, -920, -845, -772, -703, -637, -570, -508, -447, -386, -328, -273, -220, -167, -118, -71, -23};