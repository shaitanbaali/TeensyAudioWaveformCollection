/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0016 256 samples */
 
const int16_t AKWF_saw_0016_256_DATA [256] = 
{33, 108, 181, 255, 329, 403, 478, 552, 626, 699, 773, 847, 920, 994, 1068, 1142, 1216, 1290, 1364, 1437, 1511, 1585, 1659, 1733, 1807, 1881, 1955, 2029, 2103, 2176, 2250, 2324, 2398, 2472, 2546, 2620, 2693, 2767, 2841, 2915, 2989, 3063, 3136, 3211, 3284, 3359, 3433, 3506, 3580, 3654, 3728, 3802, 3876, 3949, 4023, 4097, 4171, 4245, 4319, 4393, 4466, 4540, 4614, 4688, 4763, 4837, 4911, 4984, 5058, 5132, 5205, 5279, 5353, 5427, 5501, 5575, 5649, 5722, 5796, 5870, 5943, 6017, 6091, 6167, 6240, 6314, 6387, 6462, 6535, 6609, 6683, 6757, 6830, 6905, 6978, 7052, 7126, 7199, 7273, 7347, 7421, 7495, 7569, 7643, 7717, 7791, 7865, 7939, 8013, 8086, 8161, 8234, 8308, 8382, 8456, 8529, 8603, 8677, 8751, 8825, 8899, 8972, 9047, 9121, 9195, 9096, 10609, 4190, -10512, -6664, -10620, -8778, -9230, -9029, -8980, -8904, -8829, -8757, -8682, -8608, -8535, -8461, -8387, -8312, -8238, -8164, -8090, -8017, -7943, -7869, -7795, -7722, -7648, -7574, -7500, -7426, -7352, -7279, -7205, -7131, -7057, -6982, -6908, -6834, -6761, -6687, -6613, -6539, -6466, -6391, -6318, -6244, -6170, -6096, -6023, -5949, -5875, -5801, -5727, -5653, -5579, -5506, -5431, -5357, -5284, -5210, -5136, -5062, -4988, -4914, -4840, -4767, -4693, -4619, -4545, -4472, -4398, -4324, -4250, -4176, -4102, -4028, -3954, -3880, -3806, -3732, -3658, -3584, -3511, -3437, -3363, -3289, -3216, -3141, -3068, -2994, -2920, -2846, -2773, -2699, -2625, -2550, -2476, -2402, -2329, -2255, -2181, -2107, -2033, -1959, -1885, -1812, -1738, -1664, -1590, -1516, -1443, -1369, -1295, -1221, -1146, -1073, -999, -925, -851, -777, -703, -629, -556, -482, -408, -334, -261, -186, -113, -37};