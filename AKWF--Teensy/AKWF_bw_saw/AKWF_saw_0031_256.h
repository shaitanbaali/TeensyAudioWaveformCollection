/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0031 256 samples */
 
const int16_t AKWF_saw_0031_256_DATA [256] = 
{795, 3210, 4493, 5323, 6095, 6752, 7335, 7869, 8360, 8817, 9245, 9651, 10034, 10398, 10746, 11080, 11399, 11706, 12001, 12287, 12563, 12831, 13089, 13341, 13585, 13821, 14053, 14278, 14497, 14711, 14919, 15123, 15322, 15516, 15706, 15893, 16074, 16252, 16428, 16598, 16766, 16930, 17092, 17250, 17406, 17558, 17707, 17854, 18000, 18141, 18280, 18418, 18552, 18685, 18816, 18944, 19071, 19195, 19318, 19438, 19555, 19672, 19788, 19900, 20012, 20122, 20230, 20336, 20441, 20546, 20647, 20747, 20847, 20944, 21040, 21135, 21229, 21321, 21412, 21502, 21590, 21678, 21764, 21849, 21932, 22014, 22096, 22177, 22256, 22334, 22413, 22487, 22564, 22638, 22711, 22784, 22856, 22925, 22994, 23063, 23131, 23197, 23264, 23329, 23393, 23454, 23514, 23572, 23630, 23685, 23740, 23792, 23843, 23893, 23941, 23988, 24035, 24079, 24122, 24164, 24206, 24245, 24283, 24321, 24358, 24290, 24355, 24621, -3879, -32749, -27073, -25647, -26806, -26250, -26068, -25947, -25764, -25605, -25450, -25298, -25149, -25003, -24861, -24721, -24583, -24448, -24315, -24184, -24056, -23930, -23804, -23680, -23560, -23440, -23320, -23202, -23086, -22970, -22855, -22742, -22629, -22517, -22406, -22293, -22180, -22066, -21953, -21837, -21721, -21604, -21488, -21369, -21251, -21132, -21011, -20890, -20769, -20646, -20522, -20397, -20272, -20145, -20018, -19890, -19761, -19631, -19500, -19367, -19234, -19099, -18964, -18827, -18689, -18550, -18410, -18268, -18125, -17981, -17835, -17687, -17539, -17388, -17236, -17083, -16927, -16770, -16611, -16451, -16289, -16124, -15958, -15788, -15617, -15443, -15269, -15090, -14909, -14727, -14539, -14350, -14159, -13963, -13765, -13563, -13357, -13147, -12934, -12717, -12495, -12268, -12035, -11798, -11555, -11305, -11050, -10789, -10518, -10242, -9955, -9659, -9354, -9037, -8707, -8363, -8005, -7629, -7232, -6812, -6365, -5886, -5367, -4798, -4162, -3435, -2575, -1339};