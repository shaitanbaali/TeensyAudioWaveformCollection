/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0021 256 samples */
 
const int16_t AKWF_saw_0021_256_DATA [256] = 
{24, 63, 95, 128, 159, 187, 210, 235, 256, 273, 290, 304, 315, 323, 338, 351, 365, 387, 411, 435, 461, 495, 528, 563, 604, 649, 693, 742, 798, 852, 910, 974, 1041, 1107, 1180, 1259, 1335, 1417, 1505, 1595, 1686, 1783, 1885, 1985, 2092, 2205, 2319, 2433, 2556, 2682, 2807, 2939, 3077, 3214, 3353, 3503, 3651, 3802, 3960, 4122, 4285, 4450, 4622, 4797, 4974, 5159, 5346, 5534, 5726, 5926, 6125, 6329, 6540, 6754, 6967, 7189, 7415, 7639, 7871, 8110, 8349, 8591, 8840, 9093, 9346, 9606, 9872, 10139, 10409, 10687, 10967, 11248, 11538, 11833, 12129, 12427, 12735, 13042, 13349, 13661, 13973, 14281, 14590, 14902, 15210, 15518, 15829, 16139, 16447, 16754, 17064, 17368, 17673, 17982, 18288, 18589, 18894, 19198, 19497, 19799, 20100, 20399, 20694, 20992, 21288, 21580, 21873, 22167, 22457, 22744, 23033, 23320, 23603, 23886, 24170, 24451, 24729, 24991, 24935, 26914, 11938, -26942, -29956, -24092, -25244, -24543, -23723, -23195, -22586, -22006, -21449, -20900, -20372, -19858, -19354, -18867, -18396, -17934, -17485, -17053, -16628, -16216, -15816, -15428, -15048, -14679, -14323, -13974, -13632, -13303, -12984, -12669, -12365, -12071, -11781, -11500, -11229, -10962, -10697, -10439, -10186, -9933, -9685, -9442, -9203, -8966, -8734, -8506, -8280, -8057, -7840, -7626, -7412, -7207, -7003, -6801, -6602, -6410, -6219, -6030, -5847, -5666, -5487, -5312, -5142, -4972, -4806, -4646, -4487, -4329, -4176, -4027, -3877, -3733, -3595, -3454, -3317, -3185, -3057, -2927, -2804, -2684, -2563, -2445, -2333, -2223, -2112, -2007, -1905, -1803, -1704, -1611, -1517, -1424, -1338, -1253, -1168, -1087, -1010, -933, -858, -788, -719, -649, -585, -523, -461, -403, -349, -294, -240, -192, -146, -97, -55, -15};