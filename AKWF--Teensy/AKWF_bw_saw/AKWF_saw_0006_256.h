/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0006 256 samples */
 
const int16_t AKWF_saw_0006_256_DATA [256] = 
{201, 556, 903, 1253, 1603, 1953, 2303, 2654, 3006, 3360, 3713, 4066, 4420, 4773, 5129, 5484, 5828, 6159, 6484, 6810, 7131, 7451, 7772, 8092, 8408, 8722, 9040, 9353, 9666, 9979, 10287, 10595, 10905, 11215, 11522, 11830, 12138, 12442, 12746, 13049, 13353, 13654, 13954, 14254, 14557, 14855, 15154, 15454, 15752, 16049, 16345, 16643, 16939, 17233, 17527, 17822, 18115, 18407, 18702, 18993, 19286, 19578, 19867, 20159, 20446, 20735, 21025, 21314, 21603, 21891, 22180, 22468, 22755, 23042, 23326, 23610, 23896, 24182, 24466, 24750, 25036, 25319, 25602, 25883, 26168, 26449, 26730, 27015, 27295, 27574, 27856, 28136, 28416, 28697, 28979, 29256, 29535, 29815, 30091, 30370, 30649, 30924, 31204, 31482, 31758, 32033, 31906, 34284, 16352, 6857, 5306, 3312, 1807, 428, -879, -2083, -3205, -4270, -5278, -6240, -7155, -8024, -8854, -9641, -10392, -11104, -11784, -12428, -13041, -13622, -14175, -14697, -15188, -15657, -16100, -16517, -16912, -17284, -17633, -17959, -18266, -18553, -18820, -19071, -19302, -19517, -19715, -19896, -20063, -20215, -20352, -20474, -20585, -20679, -20764, -20837, -20893, -20942, -20982, -21008, -21026, -21033, -21029, -21016, -20994, -20964, -20928, -20883, -20826, -20764, -20694, -20619, -20533, -20441, -20344, -20241, -20130, -20018, -19896, -19768, -19635, -19498, -19353, -19205, -19053, -18896, -18735, -18567, -18396, -18224, -18042, -17859, -17673, -17483, -17289, -17090, -16889, -16684, -16475, -16263, -16048, -15833, -15612, -15388, -15162, -14933, -14701, -14469, -14232, -13994, -13747, -13504, -13259, -13010, -12757, -12504, -12245, -11987, -11726, -11463, -11197, -10927, -10658, -10384, -10109, -9835, -9556, -9274, -8991, -8708, -8420, -8131, -7839, -7538, -7220, -6897, -6569, -6246, -5918, -5585, -5252, -4917, -4581, -4246, -3910, -3573, -3235, -2897, -2554, -2209, -1868, -1522, -1180, -836, -490, -137};