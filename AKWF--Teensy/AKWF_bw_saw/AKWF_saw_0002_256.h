/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0002 256 samples */
 
const int16_t AKWF_saw_0002_256_DATA [256] = 
{451, 888, 1223, 1536, 1826, 2093, 2332, 2533, 2730, 2945, 3171, 3406, 3648, 3898, 4157, 4423, 4696, 4978, 5265, 5558, 5856, 6159, 6466, 6777, 7091, 7408, 7727, 8050, 8373, 8699, 9027, 9355, 9686, 10017, 10349, 10683, 11016, 11350, 11686, 12019, 12354, 12689, 13023, 13358, 13692, 14024, 14357, 14689, 15019, 15349, 15679, 16004, 16332, 16657, 16979, 17302, 17621, 17939, 18255, 18570, 18882, 19192, 19501, 19805, 20108, 20409, 20707, 21003, 21294, 21584, 21872, 22156, 22436, 22714, 22988, 23260, 23528, 23792, 24054, 24311, 24565, 24815, 25061, 25304, 25542, 25778, 26008, 26235, 26457, 26675, 26890, 27099, 27304, 27505, 27702, 27893, 28082, 28264, 28442, 28615, 28784, 28947, 29106, 29259, 29409, 29552, 29691, 29824, 29953, 30077, 30195, 30308, 30415, 30518, 30614, 30705, 30792, 30873, 30947, 31017, 31082, 31140, 31193, 31240, 31283, 31319, 31349, 31348, 31370, 31269, 24147, 12208, 3519, -4220, -9261, -13313, -16913, -20016, -22608, -24732, -26441, -27801, -28887, -29752, -30442, -30998, -31444, -31799, -32082, -32305, -32476, -32602, -32689, -32743, -32766, -32763, -32736, -32687, -32619, -32532, -32428, -32310, -32177, -32029, -31871, -31700, -31519, -31327, -31125, -30914, -30693, -30465, -30229, -29986, -29733, -29475, -29210, -28937, -28659, -28377, -28087, -27792, -27493, -27187, -26877, -26562, -26243, -25919, -25592, -25260, -24925, -24587, -24244, -23899, -23549, -23196, -22842, -22484, -22124, -21761, -21396, -21027, -20658, -20285, -19911, -19536, -19157, -18779, -18399, -18015, -17632, -17249, -16862, -16475, -16088, -15700, -15310, -14921, -14530, -14140, -13750, -13358, -12967, -12576, -12186, -11795, -11405, -11015, -10625, -10236, -9848, -9461, -9074, -8689, -8306, -7921, -7539, -7159, -6780, -6402, -6026, -5653, -5279, -4908, -4540, -4171, -3806, -3442, -3079, -2718, -2356, -1994, -1631, -1261, -881, -444};