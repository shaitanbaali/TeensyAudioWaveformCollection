/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0027 256 samples */
 
const int16_t AKWF_saw_0027_256_DATA [256] = 
{120, 435, 753, 1073, 1389, 1700, 2006, 2308, 2607, 2900, 3189, 3474, 3756, 4033, 4309, 4582, 4849, 5115, 5379, 5637, 5895, 6151, 6404, 6654, 6903, 7149, 7393, 7635, 7875, 8114, 8349, 8584, 8817, 9047, 9277, 9505, 9731, 9955, 10180, 10400, 10619, 10839, 11057, 11273, 11486, 11701, 11913, 12123, 12333, 12543, 12750, 12955, 13161, 13364, 13566, 13770, 13970, 14169, 14367, 14566, 14762, 14957, 15153, 15346, 15537, 15731, 15922, 16110, 16300, 16489, 16675, 16861, 17047, 17232, 17415, 17599, 17781, 17962, 18142, 18322, 18501, 18680, 18858, 19035, 19210, 19385, 19560, 19735, 19907, 20078, 20248, 20414, 20577, 20738, 20895, 21050, 21203, 21353, 21500, 21645, 21786, 21925, 22062, 22197, 22329, 22458, 22585, 22710, 22831, 22951, 23071, 23185, 23297, 23410, 23518, 23625, 23730, 23833, 23933, 24031, 24129, 24223, 24314, 24405, 24495, 24582, 24666, 24522, 25420, 20819, -16001, -32841, -25304, -25888, -26207, -25553, -25328, -25051, -24755, -24485, -24213, -23947, -23689, -23434, -23183, -22939, -22698, -22461, -22229, -22001, -21776, -21553, -21335, -21123, -20910, -20703, -20498, -20295, -20095, -19898, -19704, -19511, -19323, -19136, -18950, -18767, -18585, -18402, -18219, -18036, -17853, -17669, -17484, -17302, -17119, -16934, -16751, -16567, -16382, -16197, -16014, -15828, -15643, -15459, -15273, -15087, -14902, -14716, -14529, -14342, -14157, -13969, -13782, -13594, -13406, -13217, -13029, -12840, -12650, -12460, -12270, -12080, -11889, -11698, -11506, -11313, -11119, -10927, -10733, -10538, -10343, -10147, -9950, -9752, -9557, -9357, -9157, -8959, -8758, -8556, -8354, -8150, -7945, -7740, -7534, -7328, -7119, -6908, -6698, -6485, -6272, -6058, -5842, -5622, -5405, -5183, -4959, -4734, -4509, -4279, -4047, -3815, -3578, -3339, -3098, -2853, -2605, -2353, -2099, -1840, -1575, -1308, -1035, -755, -470, -173};