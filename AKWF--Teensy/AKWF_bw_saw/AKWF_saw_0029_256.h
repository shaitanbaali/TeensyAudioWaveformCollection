/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0029 256 samples */
 
const int16_t AKWF_saw_0029_256_DATA [256] = 
{421, 1237, 1979, 2611, 3182, 3710, 4198, 4656, 5090, 5502, 5893, 6270, 6633, 6981, 7318, 7645, 7961, 8269, 8568, 8860, 9144, 9423, 9694, 9960, 10219, 10475, 10724, 10968, 11209, 11446, 11677, 11905, 12131, 12351, 12568, 12783, 12994, 13201, 13405, 13607, 13806, 14003, 14196, 14388, 14577, 14763, 14947, 15129, 15307, 15485, 15661, 15834, 16005, 16176, 16343, 16509, 16674, 16836, 16997, 17156, 17314, 17469, 17623, 17777, 17928, 18077, 18226, 18374, 18519, 18663, 18807, 18948, 19088, 19228, 19364, 19501, 19638, 19772, 19904, 20037, 20168, 20298, 20427, 20555, 20683, 20807, 20932, 21056, 21178, 21299, 21421, 21541, 21659, 21778, 21895, 22010, 22121, 22231, 22340, 22445, 22549, 22650, 22748, 22846, 22943, 23035, 23126, 23216, 23303, 23387, 23471, 23554, 23634, 23711, 23788, 23862, 23935, 24008, 24077, 24146, 24212, 24278, 24342, 24403, 24464, 24511, 24242, 25898, 13029, -25529, -30784, -24974, -26471, -26265, -25812, -25670, -25441, -25218, -25010, -24802, -24600, -24402, -24207, -24017, -23830, -23645, -23465, -23288, -23112, -22940, -22770, -22601, -22436, -22274, -22114, -21954, -21797, -21643, -21489, -21337, -21187, -21039, -20891, -20745, -20598, -20449, -20301, -20153, -20004, -19854, -19705, -19555, -19403, -19252, -19100, -18946, -18793, -18640, -18485, -18329, -18173, -18019, -17861, -17703, -17545, -17386, -17225, -17065, -16905, -16741, -16579, -16416, -16250, -16083, -15918, -15751, -15582, -15413, -15243, -15070, -14898, -14724, -14550, -14373, -14196, -14017, -13837, -13656, -13473, -13290, -13102, -12916, -12727, -12536, -12343, -12150, -11952, -11754, -11554, -11351, -11147, -10940, -10730, -10518, -10304, -10087, -9866, -9641, -9414, -9184, -8950, -8712, -8471, -8224, -7973, -7717, -7456, -7189, -6917, -6638, -6352, -6057, -5756, -5444, -5122, -4790, -4445, -4084, -3709, -3316, -2900, -2460, -1990, -1480, -924, -283};