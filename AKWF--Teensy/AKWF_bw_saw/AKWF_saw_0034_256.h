/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0034 256 samples */
 
const int16_t AKWF_saw_0034_256_DATA [256] = 
{82, 218, 350, 483, 617, 749, 881, 1014, 1148, 1281, 1413, 1546, 1679, 1812, 1944, 2077, 2211, 2344, 2476, 2609, 2742, 2875, 3007, 3140, 3274, 3406, 3539, 3672, 3805, 3937, 4070, 4203, 4336, 4469, 4602, 4735, 4867, 5000, 5134, 5266, 5398, 5532, 5665, 5797, 5930, 6063, 6196, 6329, 6462, 6595, 6727, 6860, 6993, 7126, 7259, 7392, 7524, 7657, 7791, 7923, 8056, 8189, 8322, 8454, 8588, 8720, 8853, 8986, 9119, 9251, 9385, 9517, 9650, 9783, 9916, 10049, 10182, 10314, 10448, 10580, 10713, 10846, 10979, 11111, 11244, 11378, 11510, 11643, 11776, 11909, 12042, 12175, 12307, 12440, 12574, 12706, 12839, 12972, 13105, 13237, 13370, 13504, 13636, 13769, 13902, 14035, 14167, 14301, 14433, 14566, 14700, 14832, 14964, 15098, 15231, 15364, 15496, 15630, 15762, 15895, 16028, 16161, 16294, 16426, 16559, 16692, 16825, 16910, 16915, 18271, -20205, -34539, -30948, -29048, -27160, -25533, -24062, -22690, -21403, -20194, -19069, -18039, -17102, -16262, -15517, -14860, -14289, -13798, -13374, -13016, -12715, -12461, -12250, -12076, -11932, -11813, -11714, -11632, -11561, -11500, -11447, -11396, -11348, -11302, -11253, -11203, -11150, -11095, -11035, -10971, -10903, -10831, -10754, -10673, -10586, -10496, -10402, -10303, -10201, -10096, -9988, -9877, -9763, -9645, -9526, -9405, -9282, -9156, -9031, -8902, -8773, -8642, -8511, -8379, -8246, -8113, -7979, -7844, -7709, -7574, -7439, -7303, -7167, -7031, -6895, -6758, -6622, -6486, -6351, -6214, -6078, -5942, -5807, -5671, -5536, -5399, -5264, -5129, -4994, -4858, -4724, -4589, -4454, -4319, -4185, -4051, -3917, -3782, -3648, -3514, -3380, -3246, -3113, -2978, -2845, -2711, -2577, -2444, -2310, -2178, -2044, -1911, -1777, -1644, -1511, -1377, -1245, -1112, -978, -846, -712, -579, -447, -314, -181, -46};