/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0043 256 samples */
 
const int16_t AKWF_saw_0043_256_DATA [256] = 
{67, 206, 345, 483, 621, 759, 898, 1036, 1175, 1312, 1450, 1590, 1728, 1867, 2005, 2143, 2281, 2419, 2558, 2697, 2835, 2973, 3111, 3250, 3388, 3527, 3664, 3803, 3941, 4080, 4218, 4357, 4495, 4633, 4772, 4910, 5048, 5187, 5326, 5463, 5602, 5740, 5879, 6018, 6154, 6293, 6432, 6570, 6709, 6847, 6985, 7124, 7262, 7400, 7539, 7677, 7816, 7953, 8092, 8232, 8370, 8508, 8644, 8783, 8923, 9061, 9199, 9338, 9475, 9614, 9753, 9891, 10029, 10167, 10305, 10444, 10582, 10721, 10860, 10997, 11136, 11274, 11413, 11551, 11690, 11828, 11966, 12104, 12243, 12381, 12520, 12659, 12796, 12934, 13074, 13212, 13350, 13488, 13626, 13765, 13903, 14041, 14180, 14317, 14457, 14595, 14733, 14873, 15010, 15148, 15287, 15425, 15564, 15702, 15840, 15978, 16117, 16255, 16394, 16532, 16670, 16808, 16947, 17090, 17253, 17005, 20360, 18525, -18526, -20360, -17005, -17253, -17091, -16948, -16809, -16671, -16533, -16394, -16255, -16117, -15978, -15841, -15702, -15564, -15426, -15287, -15148, -15010, -14873, -14733, -14596, -14457, -14317, -14180, -14042, -13903, -13766, -13626, -13489, -13351, -13212, -13074, -12935, -12796, -12659, -12521, -12382, -12243, -12105, -11967, -11828, -11690, -11552, -11414, -11274, -11136, -10998, -10861, -10722, -10583, -10445, -10306, -10168, -10030, -9892, -9754, -9614, -9476, -9338, -9200, -9062, -8923, -8784, -8645, -8508, -8370, -8232, -8092, -7954, -7817, -7678, -7540, -7400, -7263, -7125, -6986, -6848, -6710, -6571, -6433, -6294, -6155, -6019, -5880, -5741, -5603, -5464, -5326, -5188, -5049, -4911, -4773, -4633, -4496, -4357, -4219, -4081, -3942, -3804, -3665, -3528, -3389, -3251, -3112, -2974, -2836, -2698, -2559, -2420, -2282, -2144, -2006, -1868, -1729, -1591, -1451, -1313, -1176, -1037, -899, -760, -622, -484, -346, -207, -68};