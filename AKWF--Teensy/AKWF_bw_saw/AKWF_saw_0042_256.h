/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0042 256 samples */
 
const int16_t AKWF_saw_0042_256_DATA [256] = 
{75, 239, 399, 560, 721, 881, 1041, 1201, 1362, 1524, 1685, 1844, 2004, 2165, 2325, 2487, 2647, 2808, 2968, 3127, 3289, 3450, 3611, 3770, 3931, 4091, 4252, 4413, 4573, 4733, 4893, 5054, 5215, 5375, 5535, 5697, 5856, 6017, 6179, 6340, 6498, 6659, 6819, 6980, 7142, 7302, 7463, 7623, 7782, 7944, 8105, 8266, 8425, 8586, 8746, 8907, 9068, 9227, 9389, 9548, 9709, 9870, 10032, 10191, 10352, 10511, 10672, 10834, 10995, 11154, 11315, 11475, 11635, 11797, 11957, 12118, 12278, 12437, 12599, 12760, 12920, 13080, 13241, 13401, 13562, 13723, 13882, 14044, 14203, 14364, 14524, 14685, 14846, 15006, 15166, 15326, 15487, 15648, 15809, 15969, 16128, 16289, 16450, 16611, 16771, 16932, 17092, 17252, 17413, 17574, 17735, 17895, 18055, 18215, 18376, 18537, 18699, 18858, 19019, 19179, 19340, 19501, 19661, 19823, 20001, 20085, 21371, 21856, -21856, -21371, -20085, -20001, -19823, -19662, -19501, -19340, -19179, -19019, -18858, -18699, -18538, -18377, -18215, -18055, -17896, -17736, -17574, -17414, -17253, -17092, -16932, -16772, -16611, -16450, -16289, -16129, -15970, -15809, -15648, -15487, -15326, -15167, -15007, -14846, -14685, -14525, -14365, -14204, -14044, -13883, -13724, -13562, -13402, -13241, -13081, -12921, -12761, -12599, -12438, -12278, -12119, -11958, -11797, -11636, -11476, -11316, -11155, -10995, -10834, -10673, -10512, -10353, -10191, -10032, -9871, -9710, -9549, -9389, -9228, -9069, -8908, -8746, -8587, -8426, -8266, -8106, -7945, -7783, -7624, -7463, -7303, -7143, -6981, -6820, -6659, -6499, -6341, -6179, -6018, -5857, -5698, -5536, -5376, -5216, -5055, -4894, -4734, -4574, -4414, -4253, -4092, -3932, -3771, -3611, -3451, -3290, -3128, -2968, -2808, -2648, -2488, -2326, -2166, -2005, -1845, -1686, -1525, -1363, -1202, -1042, -882, -722, -561, -400, -240, -76};