/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0014 256 samples */
 
const int16_t AKWF_saw_0014_256_DATA [256] = 
{-24919, -30263, -30346, -31088, -31604, -32006, -32323, -32551, -32695, -32761, -32753, -32695, -32486, -32340, -32215, -31893, -31540, -31191, -30797, -30373, -29919, -29444, -28949, -28423, -27893, -27347, -26777, -26193, -25596, -25010, -24407, -23794, -23178, -22555, -21938, -21321, -20699, -20078, -19459, -18845, -18228, -17617, -17014, -16403, -15727, -15216, -14719, -14065, -13479, -12915, -12353, -11797, -11249, -10711, -10181, -9654, -9135, -8637, -8133, -7637, -7155, -6682, -6214, -5755, -5304, -4859, -4423, -3998, -3578, -3168, -2764, -2371, -1991, -1599, -1235, -840, -438, -184, 53, 313, 571, 983, 1299, 1605, 1904, 2204, 2486, 2775, 3040, 3315, 3573, 3832, 4088, 4323, 4564, 4794, 5018, 5230, 5456, 5658, 5859, 6055, 6246, 6432, 6602, 6785, 6955, 7114, 7271, 7471, 7652, 7679, 7810, 8011, 8129, 8264, 8383, 8502, 8617, 8734, 8846, 8947, 9047, 9143, 9237, 9333, 9274, 9360, 9566, 9625, 9701, 9774, 9836, 9903, 9956, 10013, 10070, 10118, 10164, 10216, 10246, 10335, 10365, 10304, 10362, 10418, 10433, 10462, 10475, 10493, 10517, 10530, 10540, 10552, 10558, 10559, 10567, 10568, 10567, 10557, 10553, 10555, 10544, 10535, 10526, 10506, 10488, 10471, 10459, 10442, 10420, 10394, 10371, 10407, 10325, 10223, 10242, 10218, 10186, 10156, 10118, 10079, 10037, 10007, 9971, 9926, 9885, 9854, 9805, 9763, 9717, 9668, 9621, 9568, 9531, 9474, 9427, 9373, 9324, 9272, 9221, 9168, 9112, 9049, 9009, 9011, 8855, 8763, 8763, 8705, 8642, 8581, 8522, 8463, 8396, 8332, 8269, 8216, 8149, 8082, 8016, 7951, 7897, 7821, 7749, 7689, 7626, 7556, 7487, 7422, 7351, 7281, 7205, 7140, 7083, 6998, 6978, 6927, 6753, 6681, 6662, 6582, 6517, 6449, 6383, 6308, 6232, 6168, 6096, 6028, 5954, 5881, 5812, 5688, 5955, 4220};