/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0033 256 samples */
 
const int16_t AKWF_saw_0033_256_DATA [256] = 
{2437, 4992, 5960, 6836, 7626, 8281, 8878, 9420, 9920, 10384, 10817, 11227, 11614, 11979, 12328, 12662, 12980, 13285, 13579, 13861, 14133, 14396, 14649, 14895, 15132, 15361, 15585, 15802, 16012, 16218, 16416, 16609, 16798, 16983, 17161, 17337, 17508, 17673, 17835, 17995, 18151, 18301, 18450, 18594, 18735, 18875, 19011, 19143, 19272, 19400, 19525, 19646, 19766, 19883, 19998, 20110, 20222, 20328, 20434, 20539, 20641, 20741, 20839, 20935, 21029, 21121, 21213, 21303, 21389, 21474, 21560, 21641, 21722, 21802, 21881, 21957, 22032, 22107, 22178, 22249, 22320, 22389, 22456, 22521, 22586, 22649, 22712, 22774, 22834, 22893, 22952, 23008, 23063, 23118, 23172, 23226, 23276, 23327, 23377, 23426, 23473, 23520, 23567, 23612, 23657, 23699, 23740, 23782, 23825, 23864, 23903, 23940, 23976, 24010, 24044, 24078, 24108, 24138, 24167, 24195, 24222, 24248, 24273, 24297, 24317, 24045, 25303, 17197, -20997, -32074, -25258, -26537, -26695, -26248, -26185, -26043, -25895, -25765, -25633, -25505, -25382, -25260, -25139, -25022, -24909, -24796, -24684, -24576, -24469, -24362, -24257, -24153, -24051, -23949, -23850, -23750, -23650, -23553, -23456, -23359, -23263, -23167, -23072, -22974, -22878, -22779, -22679, -22582, -22481, -22378, -22276, -22174, -22070, -21965, -21860, -21752, -21644, -21535, -21426, -21315, -21203, -21090, -20976, -20860, -20744, -20627, -20508, -20389, -20268, -20145, -20020, -19896, -19770, -19641, -19512, -19381, -19249, -19114, -18979, -18842, -18702, -18562, -18420, -18274, -18127, -17980, -17829, -17675, -17522, -17364, -17204, -17043, -16878, -16710, -16541, -16368, -16193, -16013, -15832, -15647, -15459, -15265, -15070, -14870, -14665, -14456, -14243, -14025, -13802, -13574, -13338, -13098, -12852, -12597, -12335, -12067, -11790, -11504, -11205, -10897, -10579, -10246, -9898, -9535, -9153, -8750, -8324, -7870, -7384, -6859, -6284, -5645, -4921, -4068, -3064, -1135};