/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0050 256 samples */
 
const int16_t AKWF_saw_0050_256_DATA [256] = 
{82, 260, 432, 604, 776, 949, 1121, 1290, 1460, 1630, 1797, 1967, 2132, 2299, 2465, 2630, 2796, 2959, 3123, 3286, 3448, 3610, 3770, 3932, 4091, 4250, 4408, 4565, 4724, 4881, 5037, 5193, 5348, 5501, 5655, 5810, 5961, 6113, 6265, 6416, 6567, 6715, 6865, 7014, 7161, 7309, 7455, 7602, 7748, 7893, 8039, 8182, 8326, 8468, 8611, 8754, 8895, 9036, 9175, 9316, 9455, 9593, 9732, 9869, 10007, 10144, 10279, 10416, 10550, 10684, 10818, 10954, 11086, 11218, 11349, 11481, 11614, 11743, 11873, 12004, 12131, 12261, 12388, 12515, 12644, 12770, 12896, 13021, 13147, 13272, 13396, 13520, 13643, 13766, 13888, 14010, 14132, 14252, 14373, 14492, 14612, 14732, 14850, 14969, 15085, 15204, 15321, 15437, 15553, 15668, 15784, 15898, 16012, 16127, 16241, 16353, 16465, 16577, 16689, 16800, 16911, 17021, 17132, 17245, 17362, 17191, 20136, 17945, -17946, -20136, -17191, -17362, -17245, -17133, -17021, -16912, -16801, -16689, -16577, -16465, -16353, -16241, -16127, -16012, -15898, -15784, -15668, -15554, -15437, -15322, -15205, -15086, -14970, -14851, -14732, -14613, -14493, -14374, -14252, -14132, -14011, -13889, -13766, -13643, -13520, -13396, -13272, -13147, -13022, -12897, -12770, -12644, -12516, -12389, -12262, -12132, -12004, -11873, -11743, -11614, -11482, -11350, -11218, -11086, -10954, -10819, -10685, -10551, -10417, -10280, -10145, -10008, -9870, -9732, -9594, -9456, -9316, -9176, -9037, -8896, -8755, -8611, -8469, -8327, -8182, -8040, -7894, -7749, -7603, -7456, -7310, -7162, -7015, -6865, -6716, -6568, -6417, -6266, -6114, -5962, -5811, -5656, -5502, -5348, -5194, -5038, -4881, -4725, -4566, -4409, -4251, -4092, -3933, -3771, -3611, -3449, -3287, -3124, -2960, -2797, -2631, -2466, -2300, -2133, -1968, -1798, -1631, -1461, -1291, -1122, -950, -777, -605, -433, -261, -83};