/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0017 256 samples */
 
const int16_t AKWF_saw_0017_256_DATA [256] = 
{106, 289, 468, 647, 822, 998, 1177, 1356, 1533, 1713, 1891, 2070, 2247, 2426, 2605, 2782, 2959, 3139, 3313, 3486, 3665, 3843, 4019, 4197, 4376, 4552, 4728, 4906, 5085, 5258, 5436, 5613, 5783, 5957, 6136, 6312, 6485, 6663, 6840, 7011, 7188, 7366, 7536, 7712, 7890, 8059, 8228, 8406, 8582, 8752, 8926, 9104, 9274, 9445, 9622, 9798, 9964, 10140, 10315, 10477, 10648, 10825, 10997, 11163, 11338, 11513, 11677, 11849, 12026, 12192, 12359, 12536, 12699, 12860, 13036, 13207, 13368, 13540, 13714, 13876, 14042, 14218, 14385, 14544, 14717, 14888, 15041, 15209, 15382, 15545, 15704, 15878, 16046, 16201, 16369, 16541, 16699, 16859, 17032, 17194, 17342, 17512, 17684, 17835, 17997, 18169, 18319, 18480, 18652, 18810, 18961, 19130, 19295, 19437, 19600, 19768, 19921, 20074, 20243, 20404, 20548, 20712, 20879, 21025, 21180, 21347, 20790, 24353, -2798, -10115, -25232, -18903, -21580, -20575, -20818, -20623, -20559, -20435, -20325, -20202, -20039, -19907, -19779, -19639, -19487, -19347, -19197, -19034, -18885, -18734, -18564, -18403, -18249, -18081, -17907, -17750, -17588, -17409, -17244, -17084, -16906, -16732, -16570, -16399, -16216, -16050, -15885, -15706, -15532, -15367, -15191, -15007, -14841, -14672, -14486, -14312, -14146, -13964, -13784, -13616, -13446, -13261, -13090, -12920, -12736, -12557, -12388, -12203, -12025, -11855, -11676, -11491, -11320, -11147, -10965, -10790, -10618, -10438, -10254, -10082, -9906, -9720, -9545, -9372, -9187, -9007, -8834, -8657, -8476, -8301, -8126, -7941, -7762, -7588, -7408, -7224, -7049, -6872, -6687, -6509, -6335, -6156, -5976, -5800, -5622, -5437, -5261, -5084, -4900, -4720, -4544, -4364, -4181, -4004, -3827, -3649, -3470, -3293, -3109, -2931, -2753, -2573, -2391, -2215, -2035, -1854, -1675, -1497, -1320, -1143, -965, -786, -605, -427, -249, -65};