/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0024 256 samples */
 
const int16_t AKWF_saw_0024_256_DATA [256] = 
{38, 119, 195, 271, 347, 422, 497, 575, 657, 741, 829, 922, 1015, 1112, 1213, 1317, 1421, 1531, 1643, 1756, 1873, 1994, 2116, 2241, 2369, 2500, 2632, 2768, 2908, 3049, 3192, 3339, 3489, 3639, 3793, 3951, 4109, 4270, 4436, 4602, 4771, 4944, 5119, 5294, 5472, 5656, 5839, 6024, 6215, 6407, 6600, 6795, 6995, 7195, 7396, 7603, 7812, 8020, 8233, 8449, 8665, 8884, 9106, 9330, 9555, 9784, 10015, 10247, 10482, 10721, 10959, 11199, 11444, 11690, 11937, 12188, 12441, 12695, 12951, 13210, 13470, 13733, 13998, 14265, 14534, 14804, 15075, 15343, 15609, 15875, 16140, 16401, 16661, 16922, 17177, 17432, 17686, 17937, 18186, 18435, 18681, 18922, 19165, 19405, 19643, 19877, 20112, 20343, 20572, 20798, 21023, 21246, 21466, 21684, 21900, 22113, 22325, 22535, 22741, 22944, 23148, 23347, 23544, 23740, 23933, 24124, 24312, 24498, 24681, 24863, 24982, 24977, 26340, 1713, -31682, -27605, -24598, -25689, -24849, -24290, -23862, -23366, -22902, -22448, -22005, -21572, -21149, -20735, -20331, -19938, -19553, -19176, -18808, -18450, -18098, -17754, -17420, -17091, -16769, -16456, -16150, -15848, -15555, -15267, -14986, -14710, -14442, -14178, -13919, -13666, -13420, -13176, -12935, -12698, -12462, -12227, -11997, -11768, -11539, -11314, -11091, -10869, -10650, -10434, -10219, -10005, -9795, -9587, -9380, -9175, -8974, -8774, -8574, -8379, -8186, -7992, -7803, -7615, -7429, -7244, -7063, -6884, -6705, -6530, -6356, -6184, -6014, -5847, -5682, -5517, -5356, -5196, -5038, -4881, -4729, -4577, -4427, -4280, -4133, -3989, -3846, -3707, -3569, -3432, -3299, -3166, -3035, -2906, -2780, -2655, -2531, -2412, -2292, -2174, -2059, -1946, -1833, -1724, -1617, -1511, -1404, -1302, -1202, -1102, -1006, -910, -815, -722, -633, -544, -455, -370, -286, -202, -120, -39};