/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0007 256 samples */
 
const int16_t AKWF_saw_0007_256_DATA [256] = 
{588, 718, 886, 1081, 1280, 1476, 1668, 1859, 2049, 2238, 2426, 2615, 2803, 2991, 3179, 3367, 3553, 3739, 3924, 4108, 4291, 4474, 4654, 4834, 5014, 5192, 5369, 5545, 5720, 5894, 6067, 6239, 6411, 6581, 6750, 6920, 7088, 7255, 7423, 7589, 7755, 7920, 8085, 8249, 8413, 8576, 8740, 8902, 9064, 9227, 9389, 9551, 9712, 9873, 10034, 10195, 10356, 10516, 10677, 10838, 10998, 11158, 11318, 11478, 11637, 11797, 11957, 12117, 12276, 12436, 12596, 12755, 12915, 13074, 13234, 13393, 13552, 13712, 13871, 14031, 14189, 14349, 14510, 14668, 14828, 14987, 15146, 15307, 15467, 15626, 15792, 15939, 16101, 16264, 16414, 16571, 16728, 16883, 17038, 17194, 17347, 17502, 17655, 17809, 17963, 18115, 18268, 18420, 18572, 18723, 18875, 19026, 19176, 19326, 19477, 19626, 19775, 19924, 20073, 20221, 20370, 20518, 20666, 20813, 20286, 24063, 7067, -20017, -21311, -20335, -20267, -20236, -20200, -20134, -20044, -19941, -19833, -19727, -19623, -19521, -19421, -19322, -19225, -19125, -19025, -18923, -18817, -18708, -18597, -18481, -18361, -18237, -18110, -17980, -17845, -17706, -17564, -17418, -17270, -17119, -16963, -16809, -16630, -16483, -16307, -16137, -15965, -15792, -15617, -15440, -15261, -15080, -14900, -14718, -14534, -14351, -14166, -13981, -13795, -13609, -13423, -13235, -13049, -12861, -12673, -12485, -12297, -12110, -11923, -11735, -11548, -11361, -11174, -10987, -10802, -10615, -10429, -10244, -10059, -9874, -9689, -9506, -9322, -9139, -8956, -8773, -8591, -8409, -8228, -8047, -7865, -7685, -7505, -7324, -7145, -6965, -6785, -6606, -6427, -6249, -6069, -5890, -5712, -5534, -5355, -5177, -5000, -4821, -4643, -4465, -4286, -4108, -3930, -3752, -3575, -3396, -3217, -3038, -2859, -2680, -2501, -2322, -2141, -1962, -1781, -1601, -1418, -1237, -1054, -871, -686, -499, -318, -70, -103, 70};