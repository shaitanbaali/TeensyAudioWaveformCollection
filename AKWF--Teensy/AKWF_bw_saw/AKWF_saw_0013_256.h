/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0013 256 samples */
 
const int16_t AKWF_saw_0013_256_DATA [256] = 
{24221, 25465, 28107, 29981, 31312, 32170, 32610, 32751, 32528, 32067, 31406, 30588, 29654, 28639, 27570, 26474, 25375, 24286, 23224, 22200, 21221, 20293, 19424, 18609, 17855, 17158, 16517, 15931, 15397, 14909, 14468, 14066, 13702, 13371, 13072, 12797, 12548, 12318, 12105, 11909, 11724, 11550, 11386, 11229, 11075, 10928, 10784, 10641, 10502, 10361, 10222, 10084, 9945, 9805, 9665, 9523, 9379, 9236, 9092, 8944, 8798, 8649, 8499, 8348, 8196, 8044, 7890, 7736, 7581, 7424, 7266, 7109, 6951, 6792, 6635, 6475, 6315, 6156, 5996, 5836, 5676, 5515, 5355, 5196, 5035, 4875, 4715, 4555, 4395, 4236, 4077, 3919, 3760, 3601, 3443, 3285, 3126, 2969, 2813, 2656, 2498, 2343, 2187, 2032, 1877, 1721, 1568, 1414, 1259, 1107, 954, 800, 649, 496, 344, 193, 43, -107, -258, -408, -557, -707, -856, -1005, -1153, -1301, -1449, -1595, -1744, -1890, -2038, -2184, -2330, -2476, -2622, -2766, -2911, -3056, -3200, -3345, -3489, -3632, -3775, -3919, -4061, -4203, -4346, -4488, -4630, -4770, -4911, -5052, -5193, -5333, -5473, -5612, -5752, -5891, -6030, -6168, -6307, -6445, -6582, -6720, -6858, -6995, -7131, -7268, -7404, -7540, -7675, -7810, -7946, -8081, -8215, -8350, -8484, -8618, -8751, -8885, -9018, -9151, -9283, -9416, -9547, -9678, -9811, -9941, -10072, -10204, -10333, -10464, -10593, -10723, -10853, -10983, -11111, -11240, -11368, -11496, -11623, -11751, -11878, -12006, -12133, -12260, -12387, -12512, -12638, -12764, -12890, -13014, -13140, -13265, -13388, -13513, -13637, -13761, -13884, -14007, -14131, -14253, -14376, -14497, -14620, -14742, -14864, -14985, -15106, -15227, -15348, -15467, -15587, -15708, -15827, -15948, -16066, -16184, -16304, -16422, -16540, -16659, -16776, -16895, -17012, -17128, -17245, -17363, -17476, -17586, -17717, -17824, -17937, -17918, -18801, -15337};