/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0046 256 samples */
 
const int16_t AKWF_saw_0046_256_DATA [256] = 
{169, 526, 872, 1219, 1561, 1901, 2240, 2574, 2906, 3236, 3562, 3887, 4209, 4527, 4845, 5161, 5471, 5781, 6089, 6392, 6695, 6994, 7292, 7588, 7881, 8170, 8459, 8746, 9029, 9311, 9590, 9867, 10143, 10415, 10685, 10954, 11221, 11484, 11748, 12007, 12265, 12522, 12775, 13028, 13278, 13526, 13771, 14017, 14258, 14499, 14739, 14974, 15210, 15443, 15674, 15903, 16131, 16356, 16581, 16803, 17023, 17243, 17460, 17674, 17888, 18101, 18311, 18520, 18727, 18931, 19136, 19338, 19538, 19738, 19935, 20131, 20326, 20518, 20709, 20899, 21087, 21274, 21460, 21644, 21827, 22008, 22187, 22365, 22542, 22717, 22892, 23064, 23236, 23406, 23575, 23742, 23907, 24073, 24236, 24398, 24559, 24719, 24877, 25034, 25189, 25344, 25499, 25650, 25801, 25951, 26100, 26248, 26394, 26539, 26683, 26826, 26968, 27109, 27248, 27387, 27524, 27660, 27796, 27932, 28074, 28009, 29493, 26702, -26702, -29493, -28010, -28074, -27933, -27796, -27660, -27524, -27387, -27248, -27109, -26968, -26826, -26683, -26539, -26394, -26248, -26100, -25951, -25802, -25651, -25499, -25344, -25189, -25034, -24878, -24719, -24559, -24398, -24236, -24073, -23908, -23742, -23575, -23407, -23236, -23065, -22892, -22718, -22543, -22366, -22188, -22008, -21827, -21644, -21460, -21275, -21087, -20900, -20710, -20518, -20326, -20132, -19935, -19738, -19539, -19338, -19137, -18932, -18727, -18520, -18311, -18101, -17889, -17674, -17460, -17243, -17024, -16804, -16582, -16357, -16132, -15904, -15675, -15444, -15210, -14975, -14739, -14500, -14258, -14018, -13772, -13527, -13279, -13029, -12776, -12523, -12265, -12008, -11748, -11485, -11221, -10955, -10686, -10416, -10143, -9868, -9591, -9312, -9030, -8746, -8460, -8171, -7882, -7588, -7293, -6995, -6695, -6393, -6090, -5781, -5472, -5161, -4846, -4528, -4210, -3888, -3563, -3237, -2907, -2575, -2241, -1902, -1562, -1220, -873, -527, -170};