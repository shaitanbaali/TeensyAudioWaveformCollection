/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0030 256 samples */
 
const int16_t AKWF_saw_0030_256_DATA [256] = 
{780, 2268, 3295, 4057, 4737, 5337, 5881, 6380, 6845, 7282, 7693, 8084, 8456, 8812, 9154, 9484, 9799, 10106, 10402, 10690, 10968, 11239, 11502, 11760, 12010, 12253, 12494, 12726, 12952, 13176, 13395, 13609, 13819, 14025, 14227, 14425, 14619, 14810, 14999, 15183, 15365, 15543, 15719, 15892, 16062, 16230, 16395, 16559, 16718, 16876, 17032, 17186, 17337, 17487, 17634, 17780, 17923, 18065, 18206, 18342, 18479, 18614, 18747, 18880, 19009, 19137, 19263, 19389, 19513, 19636, 19756, 19876, 19994, 20111, 20228, 20342, 20455, 20567, 20678, 20788, 20896, 21003, 21109, 21214, 21318, 21423, 21523, 21623, 21724, 21822, 21920, 22018, 22113, 22208, 22303, 22396, 22488, 22579, 22670, 22759, 22845, 22930, 23012, 23093, 23172, 23250, 23325, 23399, 23472, 23543, 23611, 23678, 23744, 23808, 23871, 23931, 23991, 24049, 24106, 24161, 24216, 24268, 24319, 24369, 24418, 24364, 24440, 24717, -3837, -32750, -27036, -25579, -26712, -26128, -25921, -25772, -25562, -25378, -25199, -25020, -24845, -24676, -24508, -24345, -24185, -24027, -23871, -23720, -23569, -23420, -23274, -23131, -22988, -22847, -22709, -22573, -22435, -22302, -22169, -22038, -21907, -21778, -21649, -21519, -21390, -21259, -21128, -20996, -20864, -20731, -20597, -20464, -20330, -20194, -20059, -19922, -19785, -19646, -19507, -19368, -19228, -19087, -18945, -18802, -18659, -18514, -18368, -18222, -18076, -17928, -17777, -17628, -17478, -17325, -17171, -17017, -16862, -16704, -16547, -16388, -16227, -16065, -15903, -15737, -15571, -15404, -15234, -15063, -14890, -14717, -14540, -14363, -14182, -14000, -13817, -13631, -13442, -13251, -13057, -12862, -12663, -12461, -12258, -12051, -11839, -11625, -11409, -11188, -10962, -10733, -10499, -10260, -10017, -9768, -9514, -9254, -8986, -8713, -8431, -8141, -7843, -7534, -7213, -6883, -6537, -6176, -5801, -5402, -4980, -4533, -4050, -3526, -2950, -2300, -1546, -556};