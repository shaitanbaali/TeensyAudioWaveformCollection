/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0015 256 samples */
 
const int16_t AKWF_saw_0015_256_DATA [256] = 
{-24901, -30220, -30301, -31046, -31559, -31974, -32295, -32527, -32670, -32746, -32757, -32696, -32575, -32400, -32185, -31923, -31630, -31269, -30883, -30471, -30029, -29561, -29077, -28571, -28041, -27502, -26945, -26375, -25801, -25210, -24612, -24015, -23407, -22792, -22178, -21566, -20955, -20333, -19724, -19111, -18504, -17896, -17300, -16702, -16102, -15514, -14926, -14347, -13782, -13221, -12656, -12106, -11557, -11018, -10493, -9970, -9458, -8957, -8448, -7953, -7468, -6996, -6519, -6060, -5607, -5162, -4726, -4295, -3876, -3460, -3051, -2656, -2268, -1884, -1511, -1146, -785, -439, -98, 229, 555, 884, 1195, 1503, 1801, 2092, 2386, 2675, 2944, 3210, 3477, 3730, 3980, 4226, 4464, 4688, 4915, 5134, 5345, 5556, 5761, 5954, 6146, 6337, 6519, 6690, 6860, 7036, 7200, 7350, 7503, 7651, 7793, 7929, 8066, 8195, 8313, 8431, 8554, 8661, 8765, 8879, 8982, 9083, 9173, 9265, 9352, 9438, 9519, 9595, 9667, 9740, 9808, 9869, 9928, 9984, 10037, 10092, 10140, 10184, 10229, 10270, 10309, 10339, 10374, 10404, 10433, 10460, 10485, 10501, 10526, 10536, 10554, 10564, 10571, 10577, 10581, 10592, 10593, 10586, 10584, 10582, 10582, 10571, 10564, 10548, 10537, 10530, 10509, 10493, 10477, 10455, 10433, 10409, 10383, 10357, 10333, 10304, 10274, 10241, 10212, 10179, 10142, 10106, 10072, 10029, 9998, 9960, 9916, 9879, 9831, 9787, 9748, 9696, 9654, 9611, 9560, 9505, 9458, 9409, 9356, 9300, 9248, 9191, 9143, 9088, 9030, 8971, 8917, 8860, 8801, 8738, 8679, 8620, 8562, 8503, 8440, 8375, 8314, 8247, 8189, 8127, 8056, 7990, 7927, 7858, 7796, 7728, 7662, 7601, 7533, 7466, 7399, 7338, 7270, 7199, 7128, 7061, 6992, 6928, 6858, 6786, 6725, 6651, 6581, 6510, 6447, 6375, 6309, 6238, 6168, 6100, 6032, 5895, 6167, 4422};