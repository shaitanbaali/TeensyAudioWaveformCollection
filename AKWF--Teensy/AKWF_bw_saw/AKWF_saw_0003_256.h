/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0003 256 samples */
 
const int16_t AKWF_saw_0003_256_DATA [256] = 
{116, 395, 662, 930, 1199, 1467, 1737, 2005, 2275, 2543, 2811, 3081, 3351, 3619, 3888, 4157, 4425, 4695, 4964, 5232, 5502, 5771, 6039, 6308, 6578, 6845, 7116, 7384, 7653, 7923, 8191, 8459, 8729, 8997, 9267, 9536, 9804, 10073, 10343, 10611, 10880, 11150, 11418, 11686, 11956, 12224, 12493, 12762, 13031, 13300, 13570, 13838, 14108, 14377, 14645, 14914, 15182, 15452, 15721, 15990, 16258, 16528, 16797, 17065, 17334, 17603, 17872, 18141, 18410, 18679, 18948, 19216, 19486, 19755, 20024, 20292, 20562, 20830, 21099, 21368, 21637, 21905, 22175, 22444, 22713, 22982, 23250, 23519, 23789, 24057, 24327, 24595, 24864, 25133, 25403, 25671, 25941, 26208, 26478, 26747, 27016, 27285, 27554, 27822, 28091, 28361, 28630, 28898, 29167, 29435, 29705, 29974, 30243, 30511, 30781, 31049, 31318, 31588, 31856, 32125, 32258, 33047, 30209, 12299, -2406, -9332, -13326, -15832, -17591, -18939, -20044, -20986, -21801, -22514, -23140, -23687, -24164, -24579, -24933, -25235, -25488, -25698, -25865, -25997, -26094, -26160, -26198, -26209, -26197, -26163, -26109, -26036, -25948, -25843, -25724, -25593, -25451, -25297, -25134, -24962, -24781, -24592, -24398, -24196, -23989, -23777, -23560, -23339, -23113, -22884, -22652, -22416, -22178, -21936, -21693, -21446, -21200, -20950, -20698, -20447, -20192, -19937, -19681, -19424, -19164, -18905, -18646, -18385, -18122, -17860, -17598, -17335, -17071, -16807, -16543, -16277, -16012, -15747, -15480, -15215, -14948, -14681, -14415, -14148, -13881, -13613, -13345, -13078, -12811, -12542, -12275, -12007, -11739, -11470, -11202, -10934, -10665, -10397, -10129, -9860, -9593, -9323, -9055, -8787, -8518, -8249, -7981, -7711, -7443, -7174, -6905, -6637, -6368, -6099, -5831, -5562, -5293, -5024, -4755, -4486, -4218, -3949, -3680, -3411, -3142, -2873, -2605, -2336, -2067, -1798, -1529, -1260, -991, -723, -454, -182};