/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0026 256 samples */
 
const int16_t AKWF_saw_0026_256_DATA [256] = 
{64, 269, 472, 678, 886, 1098, 1311, 1526, 1741, 1958, 2175, 2392, 2610, 2828, 3047, 3265, 3484, 3704, 3924, 4142, 4363, 4584, 4802, 5021, 5243, 5463, 5682, 5902, 6122, 6341, 6560, 6782, 7000, 7220, 7440, 7659, 7876, 8095, 8315, 8532, 8751, 8971, 9187, 9405, 9623, 9841, 10058, 10275, 10492, 10708, 10924, 11141, 11357, 11573, 11787, 12003, 12217, 12432, 12648, 12862, 13075, 13289, 13503, 13715, 13929, 14142, 14354, 14565, 14778, 14989, 15200, 15411, 15622, 15833, 16042, 16252, 16461, 16669, 16880, 17088, 17296, 17505, 17713, 17919, 18126, 18333, 18541, 18745, 18947, 19149, 19344, 19537, 19730, 19918, 20103, 20286, 20467, 20642, 20816, 20989, 21158, 21324, 21487, 21649, 21806, 21962, 22116, 22266, 22414, 22559, 22703, 22842, 22981, 23117, 23250, 23380, 23509, 23635, 23758, 23881, 24001, 24117, 24231, 24345, 24454, 24562, 24670, 24771, 24567, 25968, 17395, -21385, -31868, -24835, -25967, -25900, -25258, -24999, -24666, -24328, -24012, -23697, -23390, -23088, -22793, -22504, -22219, -21941, -21667, -21398, -21134, -20874, -20619, -20368, -20120, -19878, -19641, -19405, -19174, -18948, -18723, -18500, -18284, -18070, -17858, -17649, -17444, -17240, -17036, -16832, -16630, -16427, -16225, -16023, -15821, -15619, -15420, -15219, -15018, -14819, -14618, -14418, -14218, -14020, -13821, -13622, -13425, -13227, -13029, -12831, -12635, -12437, -12240, -12045, -11849, -11652, -11457, -11262, -11066, -10871, -10677, -10483, -10288, -10094, -9902, -9707, -9514, -9321, -9128, -8935, -8743, -8551, -8358, -8167, -7975, -7783, -7592, -7401, -7209, -7018, -6828, -6637, -6446, -6256, -6065, -5875, -5686, -5496, -5306, -5115, -4925, -4737, -4546, -4356, -4167, -3977, -3786, -3597, -3407, -3216, -3028, -2837, -2646, -2455, -2264, -2074, -1881, -1690, -1498, -1304, -1111, -918, -724, -526, -331, -130};