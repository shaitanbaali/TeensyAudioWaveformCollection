/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0040 256 samples */
 
const int16_t AKWF_saw_0040_256_DATA [256] = 
{94, 295, 491, 689, 887, 1083, 1281, 1478, 1675, 1872, 2069, 2267, 2465, 2661, 2859, 3057, 3253, 3450, 3648, 3844, 4042, 4239, 4437, 4633, 4832, 5028, 5226, 5423, 5620, 5818, 6016, 6213, 6409, 6607, 6804, 7002, 7199, 7396, 7594, 7791, 7987, 8186, 8382, 8580, 8777, 8974, 9171, 9369, 9565, 9763, 9961, 10157, 10355, 10553, 10749, 10947, 11144, 11341, 11538, 11736, 11933, 12130, 12328, 12524, 12722, 12919, 13117, 13314, 13511, 13708, 13906, 14103, 14299, 14498, 14695, 14893, 15089, 15287, 15484, 15682, 15878, 16075, 16273, 16471, 16668, 16865, 17061, 17259, 17457, 17654, 17851, 18048, 18246, 18444, 18641, 18837, 19035, 19232, 19430, 19626, 19823, 20021, 20219, 20416, 20613, 20811, 21009, 21205, 21402, 21599, 21796, 21994, 22191, 22388, 22586, 22783, 22980, 23177, 23375, 23572, 23770, 23967, 24164, 24365, 24575, 24629, 26128, 24838, -24838, -26128, -24629, -24575, -24365, -24164, -23967, -23770, -23573, -23375, -23178, -22980, -22783, -22586, -22388, -22191, -21994, -21796, -21599, -21402, -21205, -21009, -20811, -20613, -20416, -20219, -20021, -19824, -19627, -19430, -19233, -19035, -18838, -18641, -18444, -18246, -18049, -17852, -17654, -17457, -17260, -17062, -16865, -16669, -16471, -16274, -16076, -15879, -15682, -15485, -15287, -15090, -14894, -14696, -14498, -14300, -14103, -13907, -13708, -13512, -13315, -13117, -12920, -12723, -12525, -12328, -12131, -11934, -11736, -11539, -11342, -11145, -10947, -10750, -10554, -10356, -10158, -9962, -9764, -9566, -9369, -9171, -8975, -8778, -8581, -8382, -8186, -7988, -7792, -7594, -7397, -7199, -7003, -6805, -6608, -6410, -6214, -6016, -5819, -5621, -5424, -5227, -5029, -4833, -4634, -4438, -4240, -4043, -3845, -3649, -3451, -3254, -3058, -2860, -2662, -2466, -2268, -2070, -1873, -1676, -1479, -1282, -1084, -888, -690, -492, -296, -95};