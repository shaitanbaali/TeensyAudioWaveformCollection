/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0023 256 samples */
 
const int16_t AKWF_saw_0023_256_DATA [256] = 
{34, 89, 139, 187, 234, 280, 324, 365, 407, 450, 495, 547, 601, 656, 713, 777, 841, 909, 982, 1057, 1132, 1213, 1299, 1385, 1474, 1568, 1665, 1763, 1865, 1972, 2079, 2190, 2305, 2423, 2542, 2667, 2794, 2922, 3056, 3193, 3331, 3472, 3619, 3768, 3918, 4072, 4231, 4392, 4554, 4721, 4892, 5063, 5240, 5421, 5603, 5787, 5976, 6168, 6361, 6560, 6762, 6965, 7172, 7384, 7595, 7812, 8032, 8254, 8480, 8711, 8943, 9177, 9415, 9658, 9903, 10149, 10400, 10656, 10911, 11172, 11436, 11703, 11972, 12246, 12523, 12800, 13083, 13371, 13657, 13941, 14229, 14514, 14796, 15082, 15366, 15646, 15926, 16208, 16486, 16763, 17040, 17317, 17590, 17862, 18136, 18404, 18673, 18941, 19208, 19470, 19733, 19995, 20253, 20511, 20769, 21022, 21274, 21525, 21774, 22020, 22266, 22510, 22751, 22990, 23229, 23464, 23696, 23928, 24159, 24386, 24611, 24836, 25027, 24949, 26819, 7310, -29611, -28809, -24273, -25472, -24676, -23983, -23504, -22950, -22424, -21913, -21415, -20931, -20456, -19995, -19549, -19111, -18683, -18270, -17864, -17468, -17084, -16710, -16344, -15986, -15639, -15301, -14969, -14646, -14332, -14024, -13724, -13434, -13148, -12868, -12598, -12333, -12072, -11820, -11572, -11325, -11082, -10842, -10606, -10371, -10140, -9913, -9688, -9463, -9244, -9029, -8814, -8602, -8395, -8187, -7984, -7786, -7588, -7392, -7202, -7012, -6824, -6640, -6459, -6280, -6104, -5931, -5760, -5590, -5424, -5263, -5100, -4942, -4788, -4633, -4481, -4334, -4189, -4044, -3903, -3765, -3629, -3494, -3363, -3234, -3106, -2981, -2859, -2739, -2620, -2506, -2393, -2281, -2174, -2067, -1962, -1859, -1760, -1662, -1566, -1473, -1382, -1291, -1204, -1120, -1035, -954, -877, -799, -722, -650, -579, -509, -441, -377, -312, -248, -189, -131, -72, -17};