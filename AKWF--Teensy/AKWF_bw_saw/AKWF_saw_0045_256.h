/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0045 256 samples */
 
const int16_t AKWF_saw_0045_256_DATA [256] = 
{191, 593, 988, 1378, 1766, 2149, 2526, 2904, 3278, 3649, 4017, 4380, 4737, 5096, 5451, 5803, 6152, 6495, 6837, 7175, 7512, 7847, 8177, 8503, 8826, 9148, 9468, 9784, 10096, 10406, 10713, 11018, 11322, 11622, 11919, 12212, 12502, 12793, 13081, 13365, 13646, 13925, 14201, 14476, 14749, 15019, 15285, 15549, 15811, 16072, 16331, 16587, 16840, 17090, 17339, 17587, 17832, 18074, 18316, 18552, 18788, 19023, 19255, 19485, 19713, 19938, 20162, 20385, 20606, 20824, 21040, 21252, 21466, 21677, 21886, 22093, 22297, 22500, 22703, 22903, 23101, 23298, 23491, 23683, 23875, 24065, 24253, 24440, 24622, 24805, 24987, 25167, 25346, 25522, 25696, 25870, 26043, 26213, 26383, 26550, 26715, 26879, 27043, 27205, 27366, 27523, 27681, 27837, 27993, 28146, 28298, 28449, 28597, 28745, 28893, 29038, 29183, 29325, 29466, 29607, 29747, 29885, 30022, 30158, 30297, 30200, 31679, 27916, -27916, -31679, -30200, -30297, -30158, -30022, -29885, -29747, -29607, -29466, -29325, -29183, -29038, -28893, -28746, -28598, -28449, -28299, -28146, -27993, -27837, -27681, -27524, -27366, -27205, -27043, -26880, -26715, -26550, -26383, -26213, -26043, -25871, -25696, -25522, -25346, -25167, -24988, -24805, -24623, -24440, -24254, -24066, -23876, -23684, -23491, -23298, -23101, -22903, -22703, -22500, -22297, -22094, -21886, -21678, -21466, -21253, -21040, -20824, -20606, -20386, -20162, -19938, -19713, -19486, -19256, -19023, -18788, -18552, -18316, -18075, -17833, -17588, -17339, -17091, -16840, -16587, -16332, -16073, -15812, -15550, -15285, -15019, -14749, -14476, -14201, -13925, -13647, -13366, -13081, -12793, -12503, -12213, -11919, -11623, -11323, -11019, -10713, -10406, -10097, -9785, -9468, -9148, -8827, -8504, -8177, -7848, -7513, -7176, -6838, -6496, -6152, -5804, -5452, -5097, -4738, -4381, -4018, -3650, -3279, -2905, -2527, -2150, -1767, -1379, -989, -594, -192};