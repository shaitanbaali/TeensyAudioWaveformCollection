/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0044 256 samples */
 
const int16_t AKWF_saw_0044_256_DATA [256] = 
{46, 149, 249, 348, 447, 547, 648, 747, 848, 948, 1047, 1148, 1246, 1347, 1447, 1547, 1648, 1747, 1847, 1947, 2047, 2147, 2247, 2348, 2446, 2546, 2647, 2746, 2846, 2946, 3047, 3146, 3247, 3346, 3446, 3547, 3646, 3746, 3846, 3945, 4046, 4145, 4245, 4346, 4445, 4545, 4645, 4745, 4845, 4945, 5046, 5145, 5245, 5344, 5444, 5545, 5645, 5745, 5844, 5944, 6045, 6144, 6244, 6344, 6445, 6544, 6643, 6744, 6844, 6944, 7044, 7144, 7244, 7343, 7443, 7543, 7643, 7743, 7843, 7944, 8043, 8143, 8242, 8342, 8443, 8542, 8643, 8743, 8842, 8942, 9042, 9142, 9242, 9342, 9442, 9542, 9642, 9742, 9841, 9942, 10042, 10142, 10242, 10342, 10441, 10542, 10642, 10741, 10842, 10940, 11042, 11141, 11241, 11341, 11441, 11542, 11640, 11740, 11840, 11940, 12040, 12140, 12241, 12344, 12457, 12263, 15180, 16997, -16998, -15181, -12264, -12458, -12344, -12242, -12141, -12041, -11941, -11841, -11741, -11641, -11542, -11442, -11342, -11241, -11142, -11042, -10941, -10842, -10742, -10642, -10542, -10441, -10343, -10243, -10142, -10042, -9942, -9842, -9742, -9643, -9543, -9443, -9343, -9243, -9143, -9043, -8943, -8843, -8743, -8643, -8543, -8444, -8343, -8243, -8144, -8043, -7945, -7844, -7743, -7644, -7544, -7443, -7344, -7245, -7145, -7045, -6945, -6845, -6745, -6644, -6545, -6446, -6344, -6245, -6144, -6045, -5945, -5845, -5746, -5646, -5545, -5445, -5345, -5245, -5146, -5047, -4946, -4845, -4746, -4645, -4546, -4446, -4347, -4246, -4146, -4047, -3946, -3847, -3746, -3646, -3548, -3447, -3347, -3248, -3147, -3048, -2947, -2847, -2747, -2648, -2547, -2447, -2349, -2248, -2148, -2048, -1948, -1848, -1748, -1649, -1548, -1448, -1348, -1247, -1149, -1048, -949, -849, -748, -649, -548, -448, -349, -250, -150, -47};