/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0012 256 samples */
 
const int16_t AKWF_saw_0012_256_DATA [256] = 
{120, 338, 551, 768, 987, 1208, 1430, 1649, 1867, 2082, 2292, 2499, 2701, 2900, 3094, 3285, 3473, 3658, 3840, 4018, 4195, 4367, 4538, 4706, 4872, 5036, 5198, 5358, 5515, 5671, 5825, 5978, 6129, 6277, 6425, 6570, 6714, 6856, 6998, 7138, 7276, 7412, 7547, 7681, 7814, 7946, 8075, 8204, 8331, 8458, 8582, 8706, 8829, 8950, 9070, 9189, 9306, 9422, 9538, 9651, 9765, 9877, 9987, 10097, 10205, 10312, 10419, 10525, 10628, 10732, 10834, 10935, 11036, 11135, 11232, 11329, 11427, 11521, 11615, 11709, 11801, 11892, 11983, 12072, 12161, 12249, 12336, 12423, 12508, 12592, 12676, 12758, 12840, 12921, 13001, 13081, 13159, 13238, 13315, 13391, 13467, 13541, 13616, 13689, 13762, 13833, 13904, 13975, 14044, 14114, 14182, 14249, 14317, 14383, 14448, 14513, 14578, 14642, 14705, 14767, 14829, 14891, 14951, 15011, 15071, 15129, 15187, 15245, 15302, 15348, 15341, 15637, 10987, -2140, -12141, -18220, -23673, -28700, -32049, -32675, -30712, -27463, -24572, -23095, -23037, -23558, -23654, -22780, -21093, -19243, -17892, -17312, -17308, -17405, -17180, -16512, -15586, -14738, -14220, -14067, -14108, -14111, -13920, -13540, -13099, -12750, -12575, -12545, -12558, -12512, -12363, -12139, -11913, -11751, -11667, -11632, -11594, -11512, -11380, -11226, -11081, -10971, -10894, -10828, -10750, -10647, -10523, -10393, -10273, -10169, -10076, -9984, -9881, -9765, -9642, -9518, -9399, -9288, -9179, -9067, -8948, -8824, -8696, -8569, -8444, -8321, -8198, -8071, -7940, -7807, -7672, -7537, -7403, -7267, -7131, -6992, -6850, -6707, -6562, -6417, -6270, -6123, -5974, -5822, -5669, -5515, -5358, -5201, -5042, -4882, -4720, -4556, -4390, -4222, -4054, -3884, -3711, -3538, -3361, -3184, -3005, -2823, -2640, -2455, -2268, -2080, -1891, -1696, -1502, -1306, -1108, -908, -705, -501, -296, -83};