/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0001 256 samples */
 
const int16_t AKWF_saw_0001_256_DATA [256] = 
{26281, 30577, 29362, 29252, 28979, 28710, 28434, 28237, 27964, 27691, 27419, 27146, 26875, 26605, 26335, 26065, 25796, 25528, 25259, 24992, 24725, 24458, 24192, 23926, 23662, 23397, 23134, 22870, 22608, 22345, 22084, 21822, 21561, 21301, 21041, 20781, 20523, 20265, 20007, 19750, 19493, 19236, 18981, 18726, 18471, 18217, 17964, 17709, 17458, 17205, 16953, 16701, 16451, 16201, 15951, 15701, 15452, 15204, 14957, 14709, 14462, 14216, 13970, 13725, 13479, 13235, 12991, 12748, 12505, 12262, 12020, 11778, 11537, 11296, 11057, 10816, 10577, 10338, 10100, 9862, 9625, 9388, 9151, 8916, 8679, 8445, 8210, 7975, 7742, 7509, 7276, 7044, 6812, 6580, 6349, 6119, 5888, 5659, 5430, 5201, 4973, 4745, 4517, 4291, 4065, 3837, 3613, 3387, 3162, 2939, 2715, 2490, 2268, 2046, 1823, 1602, 1381, 1159, 939, 719, 500, 280, 62, -156, -373, -590, -808, -1024, -1240, -1455, -1671, -1886, -2100, -2315, -2528, -2740, -2954, -3166, -3378, -3589, -3801, -4012, -4222, -4432, -4641, -4850, -5059, -5267, -5475, -5682, -5888, -6096, -6302, -6507, -6713, -6918, -7123, -7327, -7530, -7734, -7936, -8139, -8341, -8543, -8745, -8946, -9146, -9347, -9546, -9746, -9945, -10143, -10342, -10540, -10737, -10934, -11131, -11327, -11524, -11719, -11915, -12109, -12303, -12498, -12691, -12884, -13078, -13270, -13461, -13654, -13845, -14036, -14227, -14417, -14606, -14797, -14986, -15175, -15363, -15551, -15738, -15926, -16113, -16299, -16485, -16671, -16857, -17042, -17227, -17411, -17596, -17779, -17962, -18145, -18327, -18510, -18692, -18874, -19054, -19235, -19416, -19596, -19776, -19955, -20135, -20313, -20492, -20670, -20847, -21025, -21202, -21378, -21554, -21731, -21906, -22082, -22256, -22431, -22605, -22779, -22952, -23126, -23299, -23471, -23643, -23815, -23987, -24159, -24327, -24487, -24677, -24837, -25004, -25035, -25999, -22438};