/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0038 256 samples */
 
const int16_t AKWF_saw_0038_256_DATA [256] = 
{73, 195, 314, 434, 553, 673, 792, 912, 1032, 1151, 1271, 1391, 1511, 1630, 1750, 1870, 1989, 2108, 2229, 2348, 2468, 2587, 2707, 2827, 2946, 3066, 3186, 3306, 3425, 3545, 3665, 3784, 3904, 4023, 4143, 4263, 4382, 4502, 4622, 4741, 4861, 4981, 5101, 5220, 5340, 5459, 5579, 5699, 5818, 5938, 6058, 6177, 6297, 6417, 6536, 6656, 6776, 6896, 7015, 7135, 7254, 7374, 7494, 7613, 7733, 7853, 7972, 8092, 8212, 8331, 8451, 8571, 8690, 8810, 8929, 9049, 9169, 9289, 9408, 9528, 9648, 9767, 9887, 10007, 10127, 10246, 10366, 10485, 10605, 10724, 10844, 10964, 11084, 11203, 11323, 11443, 11563, 11682, 11802, 11922, 12041, 12161, 12280, 12400, 12520, 12639, 12759, 12879, 12998, 13118, 13238, 13358, 13477, 13597, 13716, 13836, 13955, 14075, 14195, 14315, 14434, 14554, 14674, 14793, 14913, 15033, 15152, 15272, 15392, 15511, 15001, 18702, 1672, -32027, -23593, -24860, -25138, -24998, -24551, -23890, -23097, -22232, -21333, -20431, -19553, -18705, -17900, -17148, -16447, -15800, -15209, -14667, -14177, -13733, -13333, -12972, -12648, -12356, -12094, -11856, -11641, -11446, -11266, -11100, -10946, -10802, -10665, -10535, -10410, -10289, -10171, -10054, -9939, -9825, -9711, -9597, -9484, -9370, -9254, -9139, -9024, -8907, -8790, -8672, -8554, -8436, -8317, -8197, -8078, -7958, -7838, -7718, -7597, -7476, -7356, -7235, -7114, -6993, -6873, -6753, -6632, -6511, -6391, -6271, -6150, -6031, -5910, -5790, -5670, -5550, -5430, -5310, -5190, -5070, -4951, -4831, -4711, -4592, -4471, -4352, -4232, -4113, -3993, -3873, -3753, -3634, -3514, -3394, -3275, -3155, -3036, -2916, -2797, -2676, -2557, -2438, -2318, -2198, -2079, -1959, -1839, -1719, -1600, -1480, -1360, -1241, -1122, -1001, -881, -762, -643, -523, -403, -284, -165, -43};