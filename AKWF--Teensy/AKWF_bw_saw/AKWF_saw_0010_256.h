/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0010 256 samples */
 
const int16_t AKWF_saw_0010_256_DATA [256] = 
{119, 325, 524, 722, 916, 1111, 1303, 1491, 1680, 1865, 2049, 2230, 2409, 2586, 2762, 2934, 3105, 3275, 3442, 3607, 3770, 3931, 4090, 4247, 4403, 4555, 4707, 4857, 5005, 5149, 5292, 5434, 5574, 5713, 5849, 5984, 6117, 6247, 6377, 6504, 6630, 6755, 6877, 6999, 7117, 7234, 7350, 7464, 7576, 7687, 7796, 7903, 8008, 8112, 8215, 8315, 8414, 8511, 8606, 8701, 8794, 8884, 8974, 9061, 9148, 9233, 9317, 9398, 9478, 9557, 9634, 9710, 9784, 9858, 9929, 10000, 10068, 10135, 10201, 10266, 10328, 10390, 10450, 10508, 10567, 10621, 10676, 10729, 10781, 10831, 10880, 10928, 10975, 11019, 11063, 11105, 11146, 11186, 11225, 11261, 11298, 11333, 11366, 11398, 11429, 11459, 11489, 11516, 11542, 11567, 11591, 11614, 11635, 11655, 11674, 11691, 11708, 11724, 11737, 11751, 11763, 11773, 11782, 11789, 11798, 11803, 11807, 11812, 11813, 11816, 11817, 11816, 11814, 11811, 11806, 11803, 11796, 11790, 11782, 11772, 11764, 11753, 11740, 11729, 11713, 11699, 11685, 11664, 11648, 11629, 11605, 11589, 11563, 11538, 11511, 11155, 12766, 2170, -29669, -32592, -31270, -31009, -30541, -30067, -29603, -29145, -28684, -28232, -27780, -27331, -26890, -26447, -26009, -25577, -25145, -24718, -24295, -23872, -23455, -23041, -22629, -22222, -21817, -21415, -21018, -20622, -20231, -19842, -19456, -19074, -18694, -18319, -17946, -17575, -17211, -16846, -16486, -16129, -15774, -15423, -15075, -14728, -14387, -14048, -13711, -13378, -13047, -12719, -12395, -12071, -11752, -11437, -11122, -10811, -10503, -10197, -9894, -9594, -9296, -9002, -8709, -8419, -8134, -7849, -7567, -7289, -7013, -6739, -6468, -6200, -5934, -5670, -5410, -5151, -4896, -4642, -4391, -4143, -3897, -3653, -3413, -3174, -2937, -2703, -2471, -2242, -2015, -1789, -1567, -1347, -1128, -913, -699, -488, -283, 68};