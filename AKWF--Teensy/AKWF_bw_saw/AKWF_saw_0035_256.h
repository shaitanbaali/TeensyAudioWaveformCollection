/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0035 256 samples */
 
const int16_t AKWF_saw_0035_256_DATA [256] = 
{26, 95, 160, 227, 293, 360, 426, 493, 560, 626, 693, 759, 826, 892, 958, 1025, 1092, 1158, 1225, 1291, 1357, 1424, 1491, 1557, 1624, 1690, 1757, 1823, 1889, 1957, 2023, 2090, 2156, 2223, 2289, 2357, 2423, 2489, 2556, 2622, 2689, 2756, 2823, 2889, 2956, 3022, 3088, 3154, 3221, 3288, 3355, 3421, 3488, 3555, 3622, 3688, 3754, 3821, 3887, 3954, 4020, 4087, 4154, 4220, 4287, 4354, 4420, 4487, 4554, 4620, 4686, 4753, 4819, 4886, 4953, 5019, 5086, 5153, 5219, 5286, 5352, 5419, 5486, 5552, 5618, 5685, 5752, 5818, 5886, 5952, 6018, 6085, 6151, 6217, 6285, 6350, 6418, 6484, 6551, 6618, 6684, 6751, 6818, 6884, 6950, 7017, 7083, 7150, 7217, 7284, 7350, 7417, 7483, 7550, 7616, 7683, 7750, 7816, 7882, 7949, 8016, 8083, 8149, 8216, 8282, 8349, 8415, 8482, 8548, 8615, 8681, 8748, 8815, 8881, 8949, 9014, 8700, 10707, 1484, -28183, -32838, -31682, -29579, -27250, -24907, -22587, -20332, -18185, -16166, -14312, -12639, -11146, -9842, -8721, -7768, -6975, -6327, -5807, -5402, -5094, -4870, -4716, -4621, -4571, -4558, -4573, -4607, -4654, -4711, -4770, -4829, -4885, -4936, -4981, -5017, -5045, -5064, -5074, -5074, -5067, -5051, -5027, -4996, -4959, -4915, -4866, -4812, -4754, -4693, -4628, -4562, -4492, -4422, -4349, -4276, -4201, -4126, -4051, -3975, -3900, -3825, -3749, -3673, -3599, -3524, -3451, -3376, -3303, -3231, -3157, -3085, -3014, -2943, -2871, -2801, -2731, -2660, -2591, -2521, -2453, -2384, -2316, -2246, -2178, -2110, -2042, -1974, -1907, -1840, -1772, -1705, -1637, -1571, -1503, -1436, -1370, -1303, -1236, -1170, -1103, -1037, -970, -903, -837, -769, -703, -637, -570, -503, -438, -371, -304, -238, -170, -105, -37};