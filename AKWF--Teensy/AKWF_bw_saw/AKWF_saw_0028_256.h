/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0028 256 samples */
 
const int16_t AKWF_saw_0028_256_DATA [256] = 
{143, 582, 1027, 1460, 1873, 2270, 2652, 3021, 3380, 3728, 4065, 4395, 4717, 5030, 5338, 5639, 5933, 6223, 6508, 6787, 7061, 7333, 7600, 7861, 8120, 8376, 8627, 8874, 9120, 9363, 9601, 9837, 10072, 10302, 10530, 10757, 10980, 11201, 11421, 11637, 11851, 12065, 12276, 12484, 12691, 12896, 13100, 13301, 13501, 13700, 13896, 14090, 14284, 14477, 14666, 14856, 15044, 15229, 15413, 15598, 15779, 15960, 16140, 16318, 16495, 16670, 16846, 17019, 17190, 17363, 17534, 17701, 17870, 18038, 18203, 18367, 18531, 18694, 18854, 19016, 19176, 19334, 19492, 19650, 19805, 19961, 20115, 20269, 20421, 20573, 20725, 20873, 21019, 21165, 21305, 21443, 21581, 21714, 21845, 21974, 22101, 22224, 22346, 22466, 22583, 22696, 22809, 22920, 23027, 23133, 23237, 23339, 23439, 23536, 23633, 23725, 23817, 23908, 23995, 24081, 24166, 24248, 24329, 24407, 24485, 24561, 24609, 24380, 26103, 7870, -29063, -29374, -24950, -26452, -25993, -25584, -25398, -25123, -24867, -24622, -24380, -24142, -23911, -23681, -23458, -23238, -23022, -22810, -22600, -22395, -22193, -21994, -21797, -21604, -21413, -21224, -21040, -20856, -20675, -20496, -20320, -20146, -19973, -19803, -19635, -19466, -19297, -19128, -18958, -18788, -18619, -18447, -18276, -18105, -17935, -17762, -17591, -17419, -17246, -17072, -16899, -16726, -16551, -16376, -16201, -16025, -15849, -15673, -15496, -15317, -15140, -14962, -14782, -14602, -14423, -14241, -14060, -13878, -13694, -13510, -13327, -13142, -12956, -12769, -12582, -12393, -12204, -12014, -11824, -11631, -11438, -11245, -11049, -10853, -10656, -10457, -10256, -10055, -9853, -9649, -9444, -9237, -9029, -8818, -8606, -8393, -8177, -7959, -7739, -7518, -7293, -7067, -6838, -6605, -6371, -6135, -5893, -5648, -5401, -5150, -4895, -4634, -4371, -4102, -3826, -3546, -3259, -2965, -2664, -2355, -2036, -1707, -1366, -1013, -645, -252};