/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0009 256 samples */
 
const int16_t AKWF_saw_0009_256_DATA [256] = 
{187, 474, 755, 1038, 1321, 1604, 1889, 2173, 2458, 2743, 3029, 3314, 3601, 3887, 4174, 4461, 4748, 5036, 5323, 5610, 5900, 6188, 6476, 6765, 7054, 7344, 7633, 7923, 8212, 8503, 8792, 9082, 9373, 9664, 9954, 10245, 10537, 10827, 11119, 11410, 11701, 11993, 12284, 12575, 12868, 13160, 13452, 13744, 14035, 14328, 14621, 14912, 15205, 15497, 15790, 16083, 16375, 16667, 16961, 17253, 17545, 17839, 18131, 18424, 18718, 19010, 19303, 19597, 19889, 20183, 20476, 20768, 21062, 21355, 21648, 21941, 22234, 22527, 22821, 23114, 23406, 23700, 23994, 24286, 24580, 24873, 25165, 25459, 25753, 26046, 26340, 26632, 26925, 27219, 27512, 27805, 28098, 28392, 28685, 28978, 29271, 29564, 29858, 30151, 30443, 30737, 31030, 31324, 31617, 31909, 32158, 32661, 31872, 27610, 22236, 14402, 7490, 1363, -3412, -7097, -9967, -12219, -14002, -15412, -16532, -17430, -18150, -18733, -19207, -19594, -19913, -20178, -20398, -20583, -20738, -20868, -20978, -21071, -21148, -21212, -21265, -21307, -21340, -21364, -21379, -21387, -21387, -21380, -21366, -21347, -21320, -21288, -21250, -21205, -21155, -21100, -21039, -20972, -20900, -20824, -20742, -20655, -20564, -20468, -20367, -20261, -20150, -20037, -19917, -19794, -19667, -19536, -19401, -19262, -19118, -18971, -18821, -18667, -18509, -18348, -18183, -18016, -17845, -17670, -17492, -17313, -17130, -16943, -16754, -16562, -16367, -16170, -15970, -15767, -15563, -15354, -15145, -14933, -14718, -14502, -14283, -14062, -13840, -13614, -13387, -13159, -12928, -12695, -12461, -12225, -11987, -11748, -11507, -11264, -11020, -10775, -10527, -10280, -10029, -9779, -9527, -9273, -9017, -8762, -8504, -8246, -7986, -7724, -7463, -7201, -6937, -6673, -6406, -6140, -5873, -5605, -5335, -5065, -4794, -4523, -4251, -3978, -3703, -3430, -3154, -2878, -2603, -2325, -2048, -1770, -1491, -1212, -933, -652, -373, -87};