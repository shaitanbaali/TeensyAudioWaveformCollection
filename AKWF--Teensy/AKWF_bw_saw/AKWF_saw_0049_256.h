/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0049 256 samples */
 
const int16_t AKWF_saw_0049_256_DATA [256] = 
{112, 352, 587, 819, 1051, 1282, 1513, 1743, 1970, 2194, 2420, 2646, 2870, 3092, 3312, 3531, 3750, 3968, 4185, 4400, 4614, 4828, 5039, 5251, 5461, 5670, 5878, 6084, 6291, 6496, 6700, 6902, 7104, 7304, 7505, 7703, 7900, 8099, 8294, 8488, 8682, 8875, 9068, 9259, 9446, 9636, 9825, 10012, 10198, 10382, 10566, 10750, 10933, 11114, 11295, 11475, 11653, 11831, 12008, 12185, 12360, 12534, 12706, 12879, 13051, 13222, 13392, 13562, 13729, 13897, 14064, 14229, 14395, 14558, 14721, 14883, 15046, 15207, 15366, 15525, 15683, 15841, 15998, 16153, 16310, 16464, 16617, 16770, 16923, 17074, 17225, 17374, 17523, 17671, 17820, 17966, 18112, 18256, 18401, 18546, 18689, 18831, 18973, 19113, 19254, 19394, 19533, 19672, 19809, 19945, 20081, 20217, 20352, 20487, 20620, 20751, 20884, 21016, 21146, 21277, 21406, 21535, 21664, 21795, 21941, 21658, 24940, 19442, -19443, -24940, -21659, -21941, -21795, -21664, -21535, -21406, -21277, -21147, -21016, -20884, -20752, -20620, -20487, -20352, -20217, -20082, -19946, -19810, -19672, -19533, -19394, -19255, -19114, -18973, -18831, -18689, -18546, -18402, -18257, -18112, -17966, -17820, -17671, -17523, -17374, -17225, -17074, -16923, -16770, -16618, -16464, -16310, -16154, -15999, -15842, -15683, -15525, -15367, -15207, -15047, -14884, -14721, -14558, -14395, -14230, -14064, -13897, -13730, -13562, -13393, -13223, -13052, -12880, -12707, -12535, -12361, -12185, -12009, -11832, -11654, -11475, -11296, -11115, -10934, -10751, -10567, -10383, -10198, -10012, -9826, -9636, -9447, -9260, -9068, -8876, -8683, -8489, -8294, -8100, -7901, -7704, -7506, -7305, -7104, -6903, -6700, -6497, -6292, -6085, -5879, -5671, -5462, -5252, -5040, -4829, -4615, -4401, -4186, -3969, -3751, -3532, -3313, -3092, -2871, -2647, -2421, -2195, -1971, -1744, -1514, -1282, -1052, -820, -588, -353, -113};