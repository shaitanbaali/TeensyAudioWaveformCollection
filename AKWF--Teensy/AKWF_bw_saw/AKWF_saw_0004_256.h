/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw_0004 256 samples */
 
const int16_t AKWF_saw_0004_256_DATA [256] = 
{100, 342, 567, 782, 983, 1161, 1316, 1482, 1658, 1846, 2041, 2245, 2455, 2672, 2898, 3131, 3369, 3614, 3864, 4119, 4378, 4642, 4909, 5180, 5454, 5730, 6009, 6290, 6572, 6857, 7142, 7430, 7719, 8008, 8299, 8590, 8882, 9175, 9468, 9760, 10053, 10348, 10641, 10933, 11225, 11517, 11809, 12100, 12389, 12679, 12967, 13253, 13539, 13823, 14107, 14389, 14669, 14947, 15224, 15500, 15774, 16044, 16314, 16580, 16846, 17108, 17368, 17627, 17881, 18134, 18385, 18632, 18877, 19119, 19358, 19593, 19826, 20056, 20283, 20507, 20727, 20944, 21157, 21366, 21573, 21776, 21974, 22170, 22362, 22549, 22734, 22914, 23090, 23262, 23431, 23595, 23755, 23910, 24061, 24210, 24351, 24490, 24625, 24755, 24879, 25000, 25117, 25229, 25336, 25439, 25536, 25630, 25719, 25802, 25881, 25955, 26025, 26090, 26150, 26204, 26254, 26299, 26339, 26375, 26405, 26430, 26450, 26465, 26476, 26481, 26481, 26426, 26520, 25632, 15389, 3131, -5139, -11360, -15756, -19550, -22793, -25486, -27615, -29232, -30412, -31255, -31840, -32233, -32490, -32647, -32732, -32766, -32762, -32727, -32666, -32584, -32479, -32354, -32208, -32041, -31850, -31640, -31407, -31151, -30876, -30581, -30266, -29936, -29588, -29227, -28853, -28469, -28075, -27675, -27268, -26858, -26446, -26031, -25617, -25205, -24794, -24386, -23982, -23579, -23183, -22790, -22402, -22020, -21642, -21269, -20900, -20537, -20177, -19822, -19469, -19121, -18778, -18435, -18096, -17759, -17425, -17093, -16762, -16431, -16103, -15775, -15447, -15120, -14795, -14468, -14141, -13815, -13489, -13162, -12835, -12506, -12179, -11851, -11522, -11193, -10864, -10533, -10203, -9874, -9543, -9213, -8883, -8553, -8226, -7896, -7568, -7241, -6914, -6588, -6265, -5942, -5620, -5301, -4982, -4666, -4354, -4042, -3733, -3428, -3125, -2825, -2530, -2237, -1949, -1665, -1386, -1112, -843, -580, -324, -73};