/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0008 256 samples */
 
const int16_t AKWF_cello_0008_256_DATA [256] = 
{1440, 3831, 6190, 8501, 10475, 12103, 13232, 13752, 13756, 13301, 12353, 11113, 9720, 8306, 7128, 6359, 6088, 6502, 7600, 9404, 11828, 14766, 18029, 21265, 24431, 27238, 29578, 31386, 32463, 32741, 32120, 30769, 28702, 26154, 23321, 20383, 17514, 14804, 12470, 10581, 9016, 7814, 7109, 6808, 6904, 7202, 7495, 7726, 7735, 7420, 6766, 5697, 4266, 2618, 826, -984, -2727, -4435, -6095, -7657, -9035, -10213, -11173, -11831, -12176, -12194, -11926, -11372, -10589, -9675, -8457, -7095, -5624, -4060, -2559, -1177, -102, 496, 491, -58, -1102, -2518, -4157, -5749, -7157, -8199, -8811, -9017, -8841, -8378, -7731, -6924, -6136, -5409, -4809, -4218, -3788, -3488, -3370, -3468, -3830, -4354, -5045, -5778, -6480, -7097, -7559, -7693, -7612, -7302, -6647, -5869, -4926, -3934, -2990, -1906, -889, 152, 1360, 2589, 3900, 5331, 6659, 7975, 9313, 10524, 11502, 12267, 12909, 13651, 14076, 14061, 13529, 12525, 11614, 10710, 10072, 9971, 10161, 10389, 10701, 11264, 11794, 12263, 12554, 12542, 12205, 11279, 9822, 7831, 5339, 2539, -537, -3446, -6013, -8113, -9668, -10630, -11096, -10991, -10416, -9456, -8182, -6404, -4122, -1654, 550, 2201, 3316, 3959, 4136, 4019, 3763, 3320, 2796, 2492, 2579, 2810, 3045, 3173, 3105, 2904, 2731, 2489, 2014, 1154, -121, -1518, -2869, -4168, -5254, -6201, -6893, -7302, -7481, -7457, -7443, -7507, -7715, -8017, -8502, -9210, -10015, -10933, -11944, -13050, -14007, -14697, -15089, -15001, -14242, -12813, -10910, -8751, -6565, -4476, -2605, -1082, 104, 650, 630, 131, -805, -2125, -3824, -5747, -7732, -9634, -11147, -12008, -12160, -11673, -10629, -9085, -7160, -5009, -2731, -553, 1260, 2547, 3228, 3273, 2593, 1242, -599, -2684, -4769, -6626, -7954, -8660, -8701, -8068, -6801, -5128, -3112, -766};