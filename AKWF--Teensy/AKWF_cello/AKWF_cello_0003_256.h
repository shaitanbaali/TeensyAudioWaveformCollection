/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0003 256 samples */
 
const int16_t AKWF_cello_0003_256_DATA [256] = 
{793, 2423, 3223, 3533, 3955, 4880, 6217, 7602, 8796, 9830, 10830, 11799, 12590, 13100, 13429, 13791, 14337, 15064, 15883, 16743, 17654, 18603, 19504, 20240, 20743, 21026, 21137, 21098, 20919, 20628, 20293, 19988, 19751, 19580, 19450, 19345, 19274, 19278, 19419, 19744, 20247, 20861, 21503, 22132, 22742, 23314, 23792, 24139, 24437, 24909, 25773, 27067, 28599, 30072, 31280, 32160, 32677, 32736, 32229, 31206, 29935, 28774, 27924, 27318, 26741, 26050, 25253, 24420, 23564, 22623, 21592, 20613, 19883, 19502, 19375, 19277, 19016, 18513, 17759, 16750, 15460, 13897, 12164, 10420, 8770, 7230, 5730, 4176, 2526, 758, -1166, -3277, -5573, -7962, -10246, -12232, -13817, -15024, -15969, -16769, -17498, -18230, -19067, -20117, -21416, -22850, -24201, -25299, -26130, -26813, -27484, -28163, -28773, -29254, -29620, -29909, -30094, -30052, -29683, -29026, -28274, -27654, -27280, -27143, -27182, -27363, -27670, -28035, -28326, -28410, -28219, -27760, -27050, -26079, -24839, -23388, -21818, -20201, -18529, -16728, -14768, -12683, -10494, -8174, -5668, -2998, -389, 1826, 3404, 4296, 4636, 4595, 4268, 3728, 3116, 2646, 2472, 2548, 2652, 2545, 2149, 1591, 1078, 754, 653, 756, 1059, 1571, 2276, 3080, 3839, 4455, 4914, 5291, 5676, 6091, 6457, 6645, 6546, 6146, 5504, 4708, 3818, 2871, 1939, 1124, 518, 149, -32, -105, -109, -41, 92, 251, 378, 445, 468, 459, 403, 272, 70, -176, -479, -939, -1694, -2820, -4270, -5917, -7665, -9493, -11371, -13201, -14859, -16281, -17549, -18830, -20203, -21601, -22871, -23887, -24615, -25064, -25216, -25041, -24544, -23790, -22863, -21803, -20607, -19237, -17662, -15870, -13874, -11772, -9756, -8006, -6615, -5537, -4679, -4032, -3661, -3571, -3627, -3650, -3608, -3671, -4019, -4593, -5097, -5266, -5122, -4888, -4658, -4178, -3061, -1207};