/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0005 256 samples */
 
const int16_t AKWF_cello_0005_256_DATA [256] = 
{824, 2909, 4700, 6457, 8106, 9833, 11660, 13484, 15240, 16668, 17866, 19279, 20785, 22190, 23551, 24513, 24927, 24926, 24444, 23590, 22391, 20840, 19042, 17044, 14966, 12871, 10737, 8508, 6312, 4402, 2865, 1725, 950, 353, -144, -517, -654, -418, 18, 300, 336, 221, -123, -855, -1882, -2976, -4025, -4874, -5343, -5461, -5334, -4977, -4307, -3197, -1677, -157, 987, 1883, 2699, 3397, 4005, 4600, 5310, 6128, 7097, 8353, 9618, 10919, 12619, 14501, 16131, 17345, 18456, 19763, 20937, 21978, 23168, 24006, 24114, 23889, 23682, 23405, 23197, 23117, 22388, 21458, 21059, 20473, 20053, 20107, 19694, 18676, 17553, 16708, 15969, 14951, 14042, 13264, 12451, 12182, 12297, 12193, 11819, 11443, 11294, 10918, 10204, 9330, 8074, 6818, 5480, 3760, 2357, 1175, -123, -725, -634, -1030, -1830, -1893, -1583, -1911, -2565, -3580, -5225, -6832, -8094, -9239, -10434, -11125, -11161, -10990, -10315, -9811, -10162, -10491, -10906, -12069, -13467, -14881, -16469, -17787, -18292, -18070, -17438, -16231, -14712, -13366, -11857, -10240, -8957, -7662, -6154, -4840, -3616, -2051, -126, 2085, 4546, 7122, 9593, 11716, 13541, 15249, 16632, 17432, 17746, 17640, 17206, 16675, 15996, 15254, 14998, 15355, 15723, 15904, 16030, 15843, 15306, 14561, 13353, 11704, 9984, 8130, 6090, 4217, 2635, 1245, 146, -487, -887, -1328, -1546, -1694, -2257, -3112, -4142, -5590, -7286, -8585, -9486, -10287, -10834, -11488, -12714, -14074, -15384, -16751, -17987, -19290, -20897, -22634, -24396, -26192, -27727, -28670, -29313, -29888, -30283, -30792, -31568, -32283, -32693, -32758, -32600, -32253, -31635, -30951, -30338, -29575, -28615, -27682, -26853, -26027, -25152, -24275, -23387, -22264, -21076, -20148, -19344, -18647, -18146, -17805, -17568, -17105, -16310, -15418, -14314, -12964, -11608, -10145, -8267, -6000, -3725, -1672};