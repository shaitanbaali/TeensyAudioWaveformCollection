/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0019 256 samples */
 
const int16_t AKWF_cello_0019_256_DATA [256] = 
{202, 894, 1650, 2438, 3307, 4199, 5098, 6024, 7016, 8072, 9117, 10030, 10930, 11743, 12461, 13160, 13762, 14294, 14734, 15131, 15533, 15838, 16168, 16517, 16855, 17264, 17836, 18511, 19246, 19976, 20674, 21450, 22206, 22921, 23567, 24031, 24219, 24110, 23757, 23189, 22372, 21308, 19977, 18491, 16957, 15456, 14113, 12955, 12015, 11281, 10723, 10423, 10360, 10457, 10591, 10662, 10684, 10752, 10839, 10845, 10679, 10318, 9851, 9175, 8179, 6896, 5386, 3660, 1746, -349, -2615, -4876, -7094, -9198, -11135, -12878, -14376, -15610, -16593, -17264, -17605, -17682, -17490, -17034, -16351, -15511, -14602, -13633, -12612, -11615, -10723, -9922, -9279, -8812, -8546, -8489, -8634, -9030, -9709, -10688, -11940, -13390, -15061, -16930, -18949, -21007, -22989, -24879, -26633, -28190, -29533, -30636, -31541, -32227, -32636, -32772, -32671, -32324, -31782, -31052, -30214, -29408, -28568, -27697, -26862, -26109, -25411, -24759, -24106, -23450, -22800, -22104, -21308, -20388, -19317, -18110, -16776, -15326, -13757, -12114, -10450, -8783, -7080, -5371, -3664, -1936, -251, 1389, 2987, 4550, 6083, 7578, 8982, 10296, 11570, 12779, 13870, 14882, 15759, 16541, 17224, 17712, 18074, 18239, 18246, 18132, 17865, 17557, 17215, 16883, 16584, 16333, 16292, 16370, 16531, 16819, 17218, 17702, 18201, 18693, 19135, 19432, 19596, 19587, 19315, 18807, 18135, 17200, 16028, 14697, 13197, 11508, 9768, 8077, 6578, 5251, 3909, 2704, 1665, 822, 206, -240, -669, -1103, -1452, -1711, -1976, -2253, -2426, -2594, -2806, -2948, -3070, -3162, -3303, -3447, -3480, -3564, -3659, -3750, -3708, -3524, -3609, -3486, -3122, -2728, -2303, -1919, -1355, -750, -254, 203, 536, 791, 910, 870, 725, 403, -51, -545, -1064, -1631, -2192, -2678, -2965, -3058, -3075, -2999, -2777, -2536, -2280, -1929, -1599, -1171, -634, -164};