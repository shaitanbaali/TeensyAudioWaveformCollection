/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0004 256 samples */
 
const int16_t AKWF_cello_0004_256_DATA [256] = 
{545, 1534, 1506, 2382, 2775, 3503, 5523, 8622, 11690, 13255, 14115, 14388, 14620, 16637, 19450, 22761, 26289, 28740, 29261, 29285, 29241, 29573, 29391, 29633, 30584, 32345, 32481, 30867, 28467, 24989, 21339, 17815, 14753, 12102, 10097, 6366, 1589, -2371, -5335, -7945, -9711, -11096, -12324, -13687, -14883, -15830, -16609, -17345, -18565, -19666, -20359, -20939, -21483, -22254, -23662, -24786, -25849, -27281, -27659, -26861, -25677, -24078, -22226, -21195, -20427, -19763, -19365, -18684, -17273, -15626, -13424, -11068, -9307, -8638, -7605, -6019, -4278, -2691, -1343, 185, 1610, 3131, 4875, 6759, 8040, 8771, 8324, 7467, 7181, 7542, 7849, 8133, 8843, 9181, 9325, 9983, 10886, 12320, 14085, 14965, 15143, 14902, 14521, 14252, 14693, 15560, 16331, 17370, 17516, 17343, 17740, 18604, 19661, 20777, 21923, 22923, 23617, 23369, 22567, 21416, 20182, 18600, 16651, 14698, 13032, 11531, 9429, 7322, 5412, 3814, 2425, 942, -929, -2861, -4620, -6270, -7909, -9137, -9918, -11061, -12003, -12797, -13570, -14527, -15518, -16607, -17719, -18274, -18294, -17982, -17673, -17256, -17292, -17529, -17718, -17416, -17251, -17125, -16505, -15619, -14478, -13061, -11586, -10153, -9036, -7970, -7223, -6744, -6209, -5400, -4360, -3140, -1830, -869, -67, 63, 65, -232, -529, -509, -574, -6, 726, 1200, 657, -627, -2006, -3149, -4296, -5092, -5085, -4929, -4735, -4697, -4779, -4532, -3354, -1854, 59, 2338, 4533, 6656, 8506, 10348, 11773, 12918, 14013, 15227, 16568, 17691, 18378, 18528, 18431, 18076, 17417, 16594, 15892, 15140, 14013, 12949, 11154, 9447, 8138, 6945, 5187, 2957, 582, -2252, -4563, -6807, -8671, -9839, -10893, -12621, -15444, -18355, -20590, -21280, -21796, -22077, -22277, -22854, -22529, -22685, -21549, -20892, -20118, -18998, -18244, -17128, -16181, -12626, -10147, -7537, -5092, -1823};