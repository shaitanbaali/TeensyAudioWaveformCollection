/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0015 256 samples */
 
const int16_t AKWF_cello_0015_256_DATA [256] = 
{765, 1886, 2661, 3140, 3408, 3589, 3679, 3653, 3568, 3424, 3447, 3667, 4147, 4890, 5965, 7326, 8807, 10408, 12129, 13700, 15235, 16528, 17402, 17841, 17924, 17663, 17069, 16310, 15432, 14556, 13771, 13187, 13081, 13319, 13898, 14701, 15629, 16541, 17278, 17761, 17855, 17615, 17079, 16249, 15215, 14235, 13337, 12623, 12101, 11799, 11738, 11945, 12418, 13202, 14253, 15425, 16721, 18028, 19114, 19884, 20128, 19809, 18818, 17199, 15084, 12482, 9437, 6176, 2834, -426, -3477, -6277, -8571, -10419, -11810, -12706, -13118, -13235, -13221, -13178, -13296, -13468, -13783, -14312, -14968, -15661, -16329, -16933, -17512, -17954, -18117, -18033, -17413, -16408, -14895, -12986, -10631, -7901, -5069, -2132, 785, 3854, 6722, 9067, 11508, 13826, 15243, 16444, 17275, 17546, 17615, 17006, 16123, 15601, 14436, 12945, 11182, 9057, 7270, 5327, 3438, 1963, 994, -88, -919, -561, -21, 140, 567, 1295, 1986, 2651, 3291, 3190, 2743, 2418, 1652, 759, -502, -2211, -3587, -4382, -4840, -5365, -5735, -5540, -4881, -3559, -2236, -1108, -55, 1225, 2605, 3756, 4887, 6001, 7045, 8377, 9357, 9620, 9056, 7663, 5755, 3753, 439, -3531, -6028, -8673, -10715, -11891, -12470, -12757, -13097, -13641, -14338, -15161, -16297, -17955, -19950, -22213, -24660, -27094, -29361, -31297, -32521, -32789, -32233, -31057, -29544, -27901, -26092, -23947, -21653, -19411, -17458, -15737, -14214, -12685, -11190, -9880, -8570, -7110, -5679, -4304, -3075, -2051, -1059, -96, 805, 1777, 2733, 3648, 4715, 5999, 7473, 9111, 10859, 12576, 13945, 14938, 15479, 15582, 15450, 15033, 14251, 13115, 11721, 10184, 8694, 7481, 6565, 5811, 5082, 4351, 3583, 2954, 2420, 2008, 1658, 1134, 402, -380, -1386, -2514, -3565, -4571, -5505, -6212, -6688, -6843, -6574, -5860, -4750, -3376, -1920, -479};