/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0002 256 samples */
 
const int16_t AKWF_cello_0002_256_DATA [256] = 
{368, 1739, 2949, 3972, 4626, 5699, 6711, 7059, 7427, 7440, 7551, 9047, 10290, 11194, 12149, 12639, 13122, 13856, 14401, 15188, 16058, 16988, 18676, 20595, 22428, 23821, 25110, 25860, 26502, 26800, 26661, 26922, 27287, 27620, 27765, 27191, 26160, 24761, 22500, 19771, 16997, 14005, 10964, 8313, 5955, 3725, 1352, -1464, -4625, -7861, -11034, -13983, -16749, -18702, -19646, -20106, -20320, -20877, -21984, -23185, -24374, -25654, -26602, -26853, -26658, -26274, -25356, -24035, -22354, -20611, -19070, -17753, -16641, -15586, -14383, -13174, -12010, -10557, -8845, -6994, -5185, -3442, -1851, -485, 674, 1601, 2434, 3411, 4360, 5431, 6464, 7290, 8378, 9525, 10488, 11330, 12114, 13078, 14370, 15894, 17390, 18576, 19473, 19814, 19773, 19483, 19207, 19271, 19617, 20020, 20168, 19856, 19253, 18494, 17287, 15697, 13995, 12276, 10518, 9068, 7979, 7087, 6405, 5973, 5787, 6164, 6842, 7706, 8595, 9296, 9723, 9705, 9571, 9267, 9154, 9450, 10424, 11855, 13531, 15517, 17242, 18298, 18579, 18278, 17686, 17274, 16991, 16631, 16357, 16157, 15946, 15785, 15616, 15242, 14752, 13764, 12760, 11963, 11152, 10531, 9971, 9293, 8688, 8023, 7239, 6323, 5392, 4377, 3310, 2226, 962, -460, -2309, -4724, -7420, -10079, -12599, -14916, -16882, -18729, -20336, -21833, -23302, -24769, -26109, -27561, -29075, -30548, -31944, -32663, -32764, -32514, -31746, -30804, -29742, -28851, -28292, -28201, -28420, -28608, -28724, -28783, -28669, -28412, -28082, -27929, -27917, -27667, -27253, -26646, -25758, -24548, -22976, -21222, -19363, -17685, -15958, -14048, -12146, -10288, -8519, -6666, -4723, -2612, -357, 1463, 2969, 4270, 5230, 5561, 5211, 4591, 3966, 3251, 2439, 1654, 1004, 720, 197, -1026, -1651, -2048, -2362, -2577, -2996, -3392, -3879, -4094, -4293, -3804, -3349, -2777, -2431, -2276, -1766, -612};