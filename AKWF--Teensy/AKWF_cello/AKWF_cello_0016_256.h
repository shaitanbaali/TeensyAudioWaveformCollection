/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0016 256 samples */
 
const int16_t AKWF_cello_0016_256_DATA [256] = 
{99, 537, 1094, 1500, 1758, 1850, 1912, 2035, 2140, 2205, 2368, 2584, 2813, 3093, 3586, 4380, 5428, 6833, 8639, 10700, 13016, 15439, 17838, 20063, 22038, 23655, 24875, 25673, 25951, 25825, 25326, 24434, 23227, 22055, 20894, 19916, 19134, 18614, 18403, 18588, 18996, 19679, 20460, 21415, 22272, 22958, 23502, 23824, 23885, 23733, 23302, 22482, 21168, 19378, 17138, 14468, 11474, 8329, 5139, 2162, -499, -2860, -4796, -6356, -7487, -8258, -8567, -8514, -8093, -7322, -6298, -4942, -3262, -1421, 440, 2131, 3513, 4551, 5263, 5712, 5951, 5842, 5570, 5034, 4358, 3610, 2796, 1896, 862, -86, -995, -1866, -2740, -3372, -3823, -3885, -3598, -2897, -1823, -422, 1408, 3607, 5895, 8368, 10772, 12621, 14211, 15721, 16780, 17502, 17677, 17067, 15824, 14350, 12812, 11074, 9289, 7058, 5175, 3875, 2680, 1205, -558, -2532, -4349, -5955, -7366, -8553, -9416, -9987, -10082, -9977, -9720, -8912, -8158, -7357, -6452, -5951, -5499, -5037, -4916, -4741, -4385, -4219, -4405, -4801, -5443, -6112, -6935, -7755, -8848, -10134, -10966, -11196, -10754, -10045, -9332, -8167, -6481, -4069, -1136, 1716, 4634, 7546, 10258, 12434, 13533, 13306, 12107, 10331, 8094, 5404, 2367, -623, -3411, -5454, -6680, -7260, -7432, -7419, -7257, -7202, -7447, -8339, -9695, -11433, -13758, -16475, -19538, -22755, -26096, -28998, -31107, -32341, -32762, -32615, -32213, -31419, -30384, -29273, -28185, -27246, -26531, -25979, -25614, -25463, -25641, -26057, -26472, -26751, -26816, -26710, -26393, -25595, -24166, -22088, -19409, -16270, -12795, -9139, -5273, -1347, 2525, 6147, 9542, 12591, 15370, 17730, 19593, 20761, 21607, 22288, 22887, 23202, 23179, 22720, 21795, 20396, 18567, 16515, 14151, 11524, 8690, 5955, 3357, 1115, -721, -2064, -2939, -3313, -3327, -3071, -2495, -1819, -1062, -256};