/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0006 256 samples */
 
const int16_t AKWF_cello_0006_256_DATA [256] = 
{557, 2136, 3859, 5507, 7162, 8768, 10506, 12237, 13882, 15429, 16787, 17818, 18623, 19459, 20287, 21085, 21827, 22477, 22926, 23309, 23744, 24228, 24749, 25310, 25812, 26160, 26408, 26617, 26814, 26982, 27094, 27121, 27276, 27712, 28260, 28663, 29113, 29886, 30829, 31621, 32164, 32532, 32743, 32720, 32191, 31144, 30003, 28989, 27799, 26307, 24884, 23423, 21917, 20650, 19857, 19025, 18323, 17866, 17279, 16334, 15593, 15139, 14363, 13334, 12092, 10446, 8333, 6367, 4562, 2890, 1523, 371, -803, -1824, -2383, -2799, -3029, -3034, -3023, -3318, -3722, -4290, -5263, -6475, -7757, -9223, -10976, -12720, -14418, -16108, -17808, -19510, -21099, -22213, -22644, -22731, -22609, -22356, -22120, -22103, -21995, -21655, -21192, -20780, -20472, -20357, -20364, -20214, -19762, -19048, -18118, -16918, -15385, -13566, -11599, -9606, -7609, -5639, -3739, -1955, -322, 1234, 2693, 3872, 4647, 5274, 5942, 6542, 6890, 7095, 7247, 7277, 7198, 7098, 7062, 7119, 7266, 7296, 7099, 6753, 6325, 5830, 5225, 4410, 3235, 1977, 911, 94, -515, -756, -669, -482, -332, -310, -394, -509, -658, -1040, -1678, -2526, -3679, -5084, -6502, -7812, -9155, -10332, -11159, -11688, -12126, -12346, -12361, -12396, -12692, -13312, -14109, -14851, -15398, -15816, -16064, -16096, -15987, -15882, -15836, -15850, -15940, -16106, -16301, -16440, -16459, -16349, -16162, -15982, -15865, -15748, -15620, -15524, -15459, -15295, -15069, -14890, -14788, -14676, -14549, -14400, -14200, -13945, -13524, -12840, -11957, -11097, -10138, -9020, -7965, -7286, -6738, -6131, -5560, -5155, -4840, -4605, -4469, -4346, -4285, -4314, -4349, -4254, -4169, -4182, -4264, -4365, -4532, -4787, -5099, -5418, -5698, -5893, -5964, -5925, -5897, -5927, -6007, -6118, -6287, -6438, -6528, -6581, -6589, -6506, -6327, -6096, -5704, -5132, -4419, -3607, -2587, -1125};