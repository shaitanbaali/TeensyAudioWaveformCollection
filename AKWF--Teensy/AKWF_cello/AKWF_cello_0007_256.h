/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0007 256 samples */
 
const int16_t AKWF_cello_0007_256_DATA [256] = 
{879, 3469, 6168, 8953, 11658, 14240, 16624, 18660, 20354, 21719, 22694, 23162, 23066, 22465, 21561, 20479, 19266, 17896, 16536, 15297, 14153, 13196, 12476, 11985, 11755, 11700, 11767, 12016, 12327, 12654, 13036, 13385, 13621, 13671, 13482, 13040, 12339, 11346, 10073, 8595, 6978, 5164, 3244, 1263, -828, -3013, -5220, -7321, -9355, -11357, -13305, -15151, -16865, -18413, -19837, -21070, -22058, -22793, -23292, -23507, -23382, -22941, -22238, -21261, -19930, -18350, -16625, -14820, -13025, -11262, -9588, -8087, -6758, -5601, -4653, -3939, -3507, -3374, -3500, -3890, -4558, -5470, -6557, -7743, -8966, -10144, -11202, -12049, -12629, -12975, -13114, -12999, -12574, -11825, -10802, -9578, -8159, -6542, -4870, -3153, -1432, 175, 1683, 3020, 4066, 4908, 5491, 5760, 5819, 5530, 4896, 4133, 3183, 2016, 684, -709, -2126, -3538, -4957, -6324, -7632, -8932, -10168, -11327, -12408, -13348, -14146, -14776, -15143, -15236, -15024, -14475, -13641, -12511, -11092, -9526, -7747, -5760, -3746, -1730, 245, 2054, 3703, 5132, 6257, 7026, 7432, 7490, 7227, 6676, 5866, 4813, 3635, 2408, 1192, 63, -905, -1669, -2158, -2199, -1979, -1424, 596, 3117, 5358, 7912, 10767, 13717, 16542, 19272, 21988, 24664, 27106, 29112, 30729, 32117, 32779, 32671, 31913, 30771, 29075, 26648, 23865, 20778, 17569, 14458, 11357, 8314, 5473, 2895, 770, -934, -2455, -3513, -4078, -4378, -4376, -4113, -3636, -2897, -2113, -1343, -354, 753, 1788, 2694, 3763, 4862, 5700, 6174, 6418, 6500, 6299, 5731, 4784, 3553, 2233, 737, -1006, -2827, -4575, -6181, -7585, -8722, -9609, -10230, -10412, -10254, -9871, -9250, -8444, -7458, -6260, -4983, -3703, -2461, -1342, -484, 94, 488, 597, 400, -52, -783, -1710, -2722, -3758, -4686, -5439, -6007, -6240, -6107, -5619, -4669, -3247, -1330};