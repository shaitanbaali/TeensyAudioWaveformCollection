/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0012 256 samples */
 
const int16_t AKWF_cello_0012_256_DATA [256] = 
{229, 599, 985, 1420, 1693, 1765, 1843, 2031, 2203, 2164, 2254, 2271, 1949, 1894, 2189, 2433, 2416, 2766, 3125, 3262, 3402, 3485, 3845, 4375, 4607, 5033, 5445, 5720, 6258, 7161, 8211, 9257, 10471, 12052, 13996, 16179, 18606, 21490, 24310, 26496, 28273, 29763, 31041, 32062, 32640, 32793, 32507, 31499, 30007, 28137, 25985, 23552, 20668, 17596, 14613, 11698, 8806, 5944, 3189, 645, -1799, -4071, -6000, -7528, -8738, -9812, -10732, -11159, -11175, -10850, -10189, -9209, -7861, -6136, -4064, -1658, 924, 3461, 5757, 7853, 9791, 11452, 12725, 13862, 14787, 15392, 15783, 16273, 16920, 17635, 18360, 19069, 19885, 20886, 21975, 22983, 23864, 24561, 24948, 25104, 25017, 24609, 23882, 22937, 21668, 19916, 17747, 15328, 12685, 9682, 6343, 3000, -177, -3217, -6012, -8536, -10728, -12487, -13827, -14741, -15292, -15634, -15935, -16158, -16254, -16266, -16165, -15997, -15842, -15738, -15644, -15543, -15442, -15324, -15201, -15083, -15032, -15167, -15467, -15907, -16413, -16799, -17134, -17391, -17428, -17186, -16641, -15812, -14681, -13116, -11147, -8898, -6441, -3814, -990, 1894, 4591, 7124, 9361, 11220, 12794, 13836, 14347, 14441, 14092, 13260, 11971, 10357, 8568, 6529, 4299, 1986, -377, -2735, -5091, -7377, -9531, -11614, -13632, -15562, -17514, -19434, -21273, -23011, -24554, -25960, -27216, -28185, -28882, -29315, -29505, -29510, -29345, -29024, -28588, -28107, -27488, -26731, -25873, -24880, -23781, -22514, -21036, -19402, -17537, -15562, -13578, -11431, -9209, -6973, -4763, -2751, -860, 892, 2423, 3755, 4917, 6007, 7102, 8057, 8929, 9784, 10541, 11141, 11651, 12092, 12348, 12558, 12781, 12975, 13098, 13239, 13397, 13514, 13598, 13558, 13400, 13136, 12616, 11841, 10837, 9609, 8204, 6701, 5185, 3682, 2154, 827, -173, -986, -1598, -1934, -1933, -1600, -1062, -385};