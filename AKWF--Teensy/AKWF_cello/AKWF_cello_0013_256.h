/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0013 256 samples */
 
const int16_t AKWF_cello_0013_256_DATA [256] = 
{956, 4015, 7314, 10663, 13975, 17149, 20073, 22673, 24919, 26788, 28108, 28785, 28947, 28489, 27465, 25884, 23837, 21338, 18494, 15433, 12291, 9111, 6018, 3073, 402, -1902, -3830, -5380, -6475, -7083, -7249, -6824, -5935, -4622, -2999, -1165, 740, 2585, 4298, 5916, 7334, 8552, 9679, 10791, 11935, 13149, 14403, 15865, 17642, 19709, 22040, 24462, 26851, 29179, 31059, 32331, 32794, 32516, 31463, 29760, 27558, 24941, 22081, 19189, 16198, 13398, 10641, 7884, 5356, 3231, 1300, -777, -2392, -4083, -5562, -7132, -9142, -11258, -13922, -16063, -18178, -20132, -21257, -22115, -22398, -22400, -22165, -21518, -20891, -20127, -18951, -17725, -16560, -14957, -13015, -10864, -8270, -5431, -2528, 703, 3426, 5655, 7567, 8615, 9198, 9164, 7900, 5879, 3404, 744, -1788, -4372, -6757, -8668, -9561, -9679, -9382, -9047, -8622, -7957, -7495, -7308, -7438, -7977, -8783, -10072, -12160, -14699, -16963, -18525, -19556, -20361, -20766, -20336, -18793, -16365, -13466, -10579, -7676, -4858, -2933, -1875, -1440, -1675, -2363, -3310, -4610, -5574, -5299, -3938, -1738, 944, 3905, 7007, 9968, 12242, 13848, 14777, 14942, 14522, 13444, 11832, 10162, 8623, 7291, 6021, 4609, 3513, 3078, 3039, 3191, 3319, 3525, 4119, 4846, 5582, 6309, 7099, 8196, 9428, 10419, 11088, 11543, 11733, 11587, 10862, 9515, 7470, 5113, 2401, -573, -3651, -6610, -9308, -11638, -13551, -14718, -14918, -14062, -12593, -10691, -8429, -5892, -3197, -651, 1523, 3314, 4729, 5960, 6884, 7552, 8053, 8339, 8458, 8232, 7435, 6346, 5027, 3545, 2113, 725, -424, -1278, -1827, -2134, -2225, -2146, -1982, -2089, -2487, -3246, -4274, -5416, -6566, -7749, -8836, -9679, -10293, -10546, -10531, -10357, -9956, -9282, -8439, -7613, -6867, -6251, -5746, -5439, -5362, -5499, -5541, -5358, -4784, -3705, -1917};