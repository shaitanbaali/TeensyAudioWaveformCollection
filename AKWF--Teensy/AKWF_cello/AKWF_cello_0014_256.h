/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0014 256 samples */
 
const int16_t AKWF_cello_0014_256_DATA [256] = 
{1411, 5487, 9183, 12252, 14383, 15898, 17322, 18514, 19626, 20666, 21640, 22743, 24094, 25363, 26141, 26217, 25689, 24550, 22818, 20564, 18037, 15460, 13062, 11047, 9498, 8450, 7925, 7948, 8364, 9098, 9901, 10696, 11595, 12564, 13559, 14498, 15414, 16131, 16532, 16793, 16617, 15850, 14694, 13213, 11479, 9653, 7806, 5997, 4400, 2829, 1502, 393, -662, -1476, -1976, -2089, -1643, -951, -188, 629, 1241, 1676, 1921, 2140, 2256, 2573, 3461, 4983, 7078, 9757, 12794, 15840, 18571, 20648, 21994, 22631, 22335, 21131, 19159, 16372, 13055, 9224, 5080, 770, -3583, -7838, -11728, -15122, -17789, -19706, -20565, -20293, -18995, -16728, -13603, -9880, -5846, -1721, 2186, 5919, 9174, 11770, 13647, 14671, 15154, 14920, 13884, 12304, 10216, 7727, 5082, 2378, -95, -2089, -3439, -4182, -4095, -3120, -1441, 1138, 4168, 7884, 12101, 15814, 19826, 23559, 26138, 27836, 28142, 26802, 24829, 21712, 17690, 13546, 9316, 4922, 89, -5160, -10473, -15211, -19104, -22629, -26919, -29985, -31643, -32718, -32205, -30959, -29340, -26755, -22796, -18490, -14886, -10951, -6884, -2614, 637, 4036, 8026, 11512, 14669, 17906, 20750, 22991, 25040, 26604, 27556, 28284, 28651, 28191, 27012, 25466, 23760, 21856, 19670, 17318, 15201, 12950, 10212, 6830, 3016, -1080, -5598, -10348, -15441, -19978, -23628, -26333, -28141, -28580, -27465, -25032, -21699, -18410, -15531, -12976, -10970, -10306, -10959, -12690, -15402, -18833, -21819, -24136, -25820, -26403, -25671, -23603, -20570, -17122, -13328, -9487, -5534, -1762, 1379, 3797, 5445, 6446, 6793, 6272, 5181, 3826, 2531, 1613, 851, 85, -223, -142, 199, 698, 1388, 2037, 2475, 2631, 2331, 1277, -476, -2735, -5370, -8616, -12058, -15487, -19092, -22481, -25288, -27145, -27996, -27639, -26363, -24349, -21619, -18358, -14674, -10652, -6511, -2382};