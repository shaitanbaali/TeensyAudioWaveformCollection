/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0001 256 samples */
 
const int16_t AKWF_cello_0001_256_DATA [256] = 
{54, 1254, 2516, 3395, 4958, 6559, 7422, 7424, 7185, 6782, 6243, 5328, 4354, 3458, 3047, 3637, 5511, 8498, 11745, 14142, 16354, 18110, 18802, 18793, 18876, 20069, 21930, 24336, 27600, 30631, 32583, 32478, 31113, 29484, 28390, 27228, 25465, 23451, 21978, 20980, 19844, 18367, 16674, 14963, 13392, 11990, 10085, 7750, 5063, 2298, -593, -3642, -6334, -8183, -9111, -9806, -11326, -13687, -16705, -19938, -23596, -26603, -28544, -29415, -29015, -27675, -26615, -26219, -25656, -24731, -24385, -25062, -25962, -26590, -26800, -26131, -24138, -21511, -19358, -17212, -16229, -17384, -18825, -20185, -21171, -21191, -20561, -19086, -17557, -16471, -15479, -14262, -13234, -12301, -11170, -9975, -8511, -7009, -5710, -3189, -88, 2143, 3164, 4056, 5579, 6845, 7392, 8169, 8867, 8776, 7898, 7075, 6514, 5691, 4789, 4527, 4230, 3234, 1321, -952, -2909, -4320, -5221, -5599, -5102, -4158, -3814, -4477, -4844, -5192, -5472, -5685, -5387, -4166, -2013, 112, 2675, 4957, 6185, 7197, 6565, 6221, 5691, 6246, 7369, 7563, 8271, 8224, 9343, 10918, 11189, 12012, 11523, 11973, 12545, 12708, 12814, 14159, 16506, 18221, 18413, 18430, 20234, 20057, 20372, 20090, 18683, 17564, 15606, 15173, 12659, 10116, 9979, 8997, 6826, 2709, -1103, -3620, -5657, -6011, -4852, -2221, 244, 1814, 2122, 1998, 657, -691, -472, 221, 2754, 5451, 8043, 11126, 12093, 10784, 7130, 2584, -1516, -5177, -7908, -9688, -10385, -11456, -13749, -16672, -19688, -22368, -24710, -25630, -24889, -22846, -21067, -18906, -16106, -13959, -12672, -12020, -11135, -9884, -8784, -7322, -5673, -3478, -1339, -155, 315, -752, -1917, -2467, -2392, -1885, -538, 2242, 4909, 6063, 5478, 3910, 2640, 1618, 342, -703, -830, -516, -606, -1042, -1814, -2568, -3671, -4056, -3758, -3184, -2359, -1469, -667, -137};