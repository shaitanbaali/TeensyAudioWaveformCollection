/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0018 256 samples */
 
const int16_t AKWF_cello_0018_256_DATA [256] = 
{842, 2822, 4587, 6027, 7116, 7796, 8059, 7971, 7595, 6969, 6260, 5662, 5262, 5166, 5412, 5992, 6905, 8109, 9452, 10834, 12196, 13389, 14339, 14976, 15182, 14907, 14192, 13189, 12003, 10696, 9355, 8125, 7079, 6154, 5361, 4892, 4696, 4763, 5129, 5712, 6413, 7157, 7857, 8576, 9108, 9424, 9533, 9329, 8852, 8064, 7083, 5957, 4772, 3638, 2580, 1686, 1081, 724, 624, 825, 1331, 2252, 3673, 5471, 7602, 10284, 13291, 16397, 19663, 22862, 25643, 28195, 30311, 31794, 32598, 32774, 32285, 31025, 29132, 26771, 24052, 21099, 17976, 14881, 11863, 8821, 5855, 3228, 834, -1583, -3893, -5994, -8022, -9827, -11502, -13371, -15318, -17115, -18594, -19884, -21121, -21899, -22115, -22189, -21745, -20618, -19097, -17396, -15650, -13813, -11891, -9774, -7828, -6212, -4852, -3864, -3216, -2937, -2890, -2836, -2891, -3493, -4417, -5030, -5665, -6616, -7692, -8667, -9661, -10594, -11175, -11554, -11909, -12277, -12441, -12550, -12597, -12315, -11727, -10981, -10361, -9849, -9340, -8988, -8916, -8989, -9220, -9882, -10710, -11554, -12415, -13329, -14305, -15236, -16065, -16842, -17415, -17791, -18122, -18470, -18775, -19028, -19350, -19598, -19640, -19731, -19986, -20148, -20090, -19904, -19476, -18634, -17457, -16027, -14182, -11932, -9494, -6886, -4246, -1803, 459, 2562, 4455, 6045, 7205, 8147, 8791, 9151, 9353, 9493, 9551, 9486, 9419, 9353, 9341, 9468, 9672, 9914, 10301, 10829, 11428, 12081, 12789, 13481, 14113, 14734, 15370, 15935, 16378, 16735, 16898, 16884, 16814, 16681, 16458, 16036, 15384, 14315, 12818, 11009, 8979, 6741, 4167, 1484, -1144, -3494, -5429, -6964, -8138, -8911, -9174, -8892, -8104, -6836, -5186, -3319, -1394, 457, 2195, 3626, 4493, 4797, 4556, 3677, 2265, 623, -1133, -2730, -4070, -5123, -5727, -5781, -5130, -3884, -2161, -645};