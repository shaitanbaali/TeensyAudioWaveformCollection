/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0010 256 samples */
 
const int16_t AKWF_cello_0010_256_DATA [256] = 
{1511, 3907, 6280, 8568, 10532, 12146, 13257, 13761, 13749, 13279, 12316, 11073, 9675, 8256, 7098, 6343, 6089, 6530, 7654, 9479, 11911, 14865, 18138, 21385, 24543, 27319, 29644, 31430, 32488, 32732, 32085, 30716, 28629, 26064, 23213, 20274, 17422, 14724, 12407, 10520, 8966, 7785, 7094, 6805, 6912, 7214, 7503, 7731, 7729, 7406, 6734, 5653, 4218, 2564, 768, -1039, -2793, -4488, -6146, -7703, -9073, -10250, -11202, -11845, -12181, -12189, -11914, -11344, -10562, -9642, -8416, -7044, -5568, -4005, -2514, -1137, -75, 507, 479, -83, -1142, -2566, -4215, -5804, -7203, -8223, -8824, -9018, -8826, -8361, -7707, -6899, -6111, -5388, -4788, -4203, -3776, -3482, -3370, -3477, -3844, -4373, -5069, -5800, -6501, -7118, -7567, -7693, -7607, -7287, -6619, -5842, -4894, -3905, -2957, -1871, -853, 186, 1399, 2628, 3943, 5383, 6702, 8017, 9352, 10561, 11535, 12288, 12931, 13672, 14081, 14054, 13495, 12491, 11586, 10684, 10061, 9975, 10171, 10396, 10714, 11282, 11811, 12277, 12558, 12538, 12187, 11238, 9759, 7760, 5255, 2447, -631, -3546, -6092, -8168, -9707, -10652, -11100, -10978, -10391, -9422, -8135, -6342, -4033, -1572, 608, 2244, 3343, 3972, 4136, 4014, 3753, 3303, 2778, 2490, 2586, 2819, 3052, 3174, 3098, 2896, 2725, 2478, 1994, 1114, -172, -1567, -2909, -4205, -5286, -6234, -6909, -7313, -7482, -7455, -7444, -7511, -7722, -8029, -8522, -9234, -10050, -10962, -11979, -13082, -14033, -14716, -15097, -14987, -14206, -12760, -10847, -8668, -6497, -4414, -2552, -1040, 134, 657, 622, 106, -839, -2172, -3894, -5810, -7794, -9688, -11190, -12026, -12154, -11649, -10589, -9027, -7085, -4925, -2656, -490, 1308, 2582, 3241, 3262, 2560, 1190, -661, -2765, -4832, -6676, -7985, -8672, -8690, -8032, -6754, -5071, -3043, -693};