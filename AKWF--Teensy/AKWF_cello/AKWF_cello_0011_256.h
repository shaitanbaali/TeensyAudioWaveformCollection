/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0011 256 samples */
 
const int16_t AKWF_cello_0011_256_DATA [256] = 
{1100, 2936, 4580, 6116, 7480, 8585, 9522, 10383, 11046, 11650, 12206, 12844, 13578, 14353, 15306, 16426, 17719, 19252, 20985, 22879, 24857, 26875, 28656, 30146, 31398, 32302, 32709, 32753, 32350, 31610, 30624, 29499, 28160, 26745, 25276, 23728, 22143, 20638, 19139, 17770, 16540, 15461, 14473, 13563, 12804, 12041, 11210, 10362, 9427, 8375, 7270, 6067, 4713, 3336, 1893, 346, -1235, -2930, -4482, -6065, -7536, -8843, -10037, -11077, -11939, -12567, -12969, -13184, -13063, -12707, -12127, -11338, -10384, -9457, -8641, -7963, -7448, -7178, -7103, -7039, -7056, -7086, -7048, -7047, -6918, -6755, -6664, -6631, -6582, -6498, -6463, -6367, -6244, -6190, -6210, -6214, -6377, -6675, -7021, -7438, -7886, -8230, -8580, -8793, -8822, -8748, -8488, -8038, -7543, -6983, -6148, -5125, -3979, -2573, -1016, 705, 2490, 4353, 6208, 8212, 10138, 12023, 13502, 14783, 16050, 16989, 17425, 17631, 17466, 16887, 15905, 14723, 13723, 12677, 12019, 11542, 11381, 11602, 11801, 11981, 11933, 11866, 11536, 11110, 10495, 9573, 8314, 6796, 4966, 2913, 847, -1068, -2867, -4275, -5195, -5841, -6265, -6503, -6390, -5984, -5321, -4533, -3590, -2442, -1293, -478, -2, 132, -131, -484, -865, -1272, -1588, -1816, -1812, -1704, -1657, -1718, -1904, -2092, -2419, -2939, -3767, -4661, -5357, -6053, -6676, -7152, -7331, -7184, -6924, -6657, -6355, -6003, -5694, -5559, -5659, -5959, -6399, -7026, -7836, -8820, -9941, -11032, -11875, -12508, -13007, -13239, -13077, -12598, -11866, -11017, -10051, -9074, -8067, -7209, -6678, -6415, -6333, -6442, -6794, -7383, -8192, -8931, -9581, -10098, -10346, -10129, -9519, -8518, -7298, -5878, -4379, -2868, -1454, -350, 391, 762, 628, 0, -975, -2359, -3925, -5478, -6899, -7985, -8663, -8916, -8783, -8349, -7593, -6596, -5434, -4181, -2809, -1183};