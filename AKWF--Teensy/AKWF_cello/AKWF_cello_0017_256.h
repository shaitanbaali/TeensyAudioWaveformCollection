/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0017 256 samples */
 
const int16_t AKWF_cello_0017_256_DATA [256] = 
{615, 1935, 3413, 5168, 7187, 9497, 11973, 14584, 17209, 19722, 22096, 24235, 26008, 27421, 28588, 29375, 29900, 30127, 30207, 30115, 29962, 29838, 29737, 29661, 29551, 29370, 29128, 28763, 28174, 27349, 26314, 25051, 23625, 22051, 20361, 18587, 16991, 15484, 14090, 12927, 11926, 11179, 10757, 10627, 10729, 11091, 11636, 12394, 13372, 14403, 15482, 16522, 17543, 18568, 19572, 20570, 21539, 22486, 23400, 24307, 25246, 26137, 26917, 27615, 28167, 28564, 28853, 28974, 28937, 28802, 28548, 28201, 27752, 27176, 26526, 25724, 24752, 23608, 22323, 20962, 19529, 17966, 16239, 14446, 12641, 10762, 8811, 6820, 4747, 2688, 590, -1540, -3370, -5162, -6958, -8452, -10049, -11316, -12184, -12979, -13249, -13041, -12601, -11716, -10258, -8365, -6243, -3822, -1265, 1146, 3591, 6039, 8321, 10463, 12178, 13604, 14974, 15915, 16695, 17458, 17921, 18029, 18047, 18385, 18533, 18292, 17866, 17174, 15991, 14405, 12621, 10432, 7693, 4714, 1423, -2228, -6000, -9705, -13407, -16928, -20278, -23423, -26006, -28128, -29852, -30955, -31725, -32416, -32782, -32587, -32009, -31257, -30130, -28930, -27842, -26741, -25697, -24919, -24371, -23881, -23457, -23042, -22433, -21543, -20391, -18973, -17116, -14895, -12291, -9455, -6601, -3862, -1378, 621, 2103, 3074, 3389, 3018, 2108, 718, -1180, -3188, -5049, -6667, -7900, -8714, -9102, -9184, -9143, -9051, -8909, -8819, -8824, -8922, -9350, -10115, -11082, -12125, -13403, -14817, -16338, -17971, -19749, -21502, -23071, -24567, -25984, -27247, -28334, -29151, -29652, -29761, -29547, -28896, -27871, -26359, -24463, -22303, -19892, -17274, -14550, -11822, -9149, -6664, -4380, -2459, -1016, -63, 307, 173, -535, -1640, -3074, -4969, -7138, -9340, -11526, -13594, -15330, -16694, -17587, -17945, -17733, -17049, -15937, -14346, -12517, -10658, -8824, -7121, -5622, -4398, -3389, -2455, -1551, -482};