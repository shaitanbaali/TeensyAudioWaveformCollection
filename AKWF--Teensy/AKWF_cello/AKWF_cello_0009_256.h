/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cello_0009 256 samples */
 
const int16_t AKWF_cello_0009_256_DATA [256] = 
{1524, 3919, 6291, 8590, 10552, 12154, 13261, 13762, 13747, 13271, 12306, 11067, 9667, 8250, 7087, 6338, 6088, 6534, 7660, 9495, 11941, 14895, 18151, 21404, 24558, 27342, 29667, 31440, 32491, 32730, 32078, 30697, 28606, 26052, 23196, 20262, 17396, 14696, 12391, 10513, 8956, 7774, 7090, 6805, 6914, 7215, 7506, 7732, 7729, 7404, 6730, 5644, 4200, 2548, 761, -1049, -2800, -4504, -6164, -7713, -9078, -10256, -11208, -11851, -12184, -12188, -11911, -11340, -10555, -9629, -8407, -7037, -5560, -3996, -2498, -1125, -71, 509, 478, -92, -1156, -2577, -4223, -5811, -7209, -8232, -8827, -9018, -8825, -8356, -7698, -6893, -6107, -5386, -4784, -4197, -3772, -3481, -3370, -3478, -3848, -4381, -5075, -5804, -6504, -7121, -7572, -7692, -7606, -7285, -6615, -5835, -4883, -3897, -2953, -1865, -848, 198, 1413, 2635, 3950, 5389, 6713, 8033, 9363, 10565, 11540, 12292, 12938, 13679, 14083, 14052, 13491, 12484, 11576, 10676, 10061, 9975, 10172, 10397, 10720, 11286, 11813, 12281, 12560, 12538, 12184, 11232, 9750, 7736, 5226, 2432, -648, -3558, -6110, -8190, -9718, -10655, -11101, -10977, -10383, -9409, -8127, -6331, -4022, -1554, 631, 2257, 3345, 3974, 4136, 4011, 3749, 3300, 2776, 2490, 2586, 2821, 3054, 3174, 3098, 2895, 2724, 2474, 1990, 1108, -179, -1575, -2924, -4217, -5291, -6238, -6914, -7315, -7483, -7455, -7443, -7513, -7726, -8033, -8525, -9238, -10054, -10971, -11991, -13089, -14037, -14718, -15097, -14983, -14196, -12752, -10835, -8658, -6476, -4390, -2540, -1034, 138, 658, 620, 98, -844, -2180, -3901, -5829, -7816, -9701, -11196, -12027, -12153, -11640, -10576, -9019, -7073, -4915, -2637, -467, 1321, 2585, 3243, 3260, 2550, 1172, -671, -2775, -4852, -6693, -7993, -8673, -8689, -8026, -6738, -5052, -3031, -684};