/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1449 256 samples */
 
const int16_t AKWF_1449_256_DATA [256] = 
{7395, 10781, 7840, 9701, 10417, 10153, 20723, 31618, 27973, 29003, 29663, 27000, 12572, 10878, 11900, 12493, 12385, 12376, 12673, 12349, 11897, 11335, 10752, 9880, 9077, 8953, 9192, 9556, 9994, 10250, 10613, 11051, 11377, 11948, 25619, 31911, 28001, 29511, 29971, 30245, 30447, 30667, 30862, 31047, 31206, 31335, 31424, 31478, 31495, 31483, 31470, 31651, 31704, 31465, 31162, 30728, 30168, 28890, 27336, 26867, 27067, 27329, 27654, 27549, 27643, 27842, 27922, 27917, 27830, 27707, 27516, 27278, 26992, 26659, 26291, 25894, 25446, 24974, 24468, 23936, 23381, 22829, 22309, 21882, 21646, 22090, 22861, 23430, 24182, 24732, 24874, 23356, 20546, 19358, 19494, 19557, 19645, 18811, 18087, 17702, 17042, 16243, 15295, 14320, 13254, 12137, 10988, 9813, 8622, 7436, 6239, 5047, 3864, 2690, 1534, 417, -628, -1510, -2112, -1604, -313, 419, 1574, 2597, 3119, 908, -4310, -6729, -5884, -4957, -3815, -4204, -4780, -4294, -4312, -4507, -4953, -5394, -5929, -6520, -7130, -7742, -8359, -8990, -9564, -10083, -10591, -11098, -11629, -12211, -12866, -13505, -14067, -13314, -11251, -10979, -10264, -9398, -8971, -10507, -13771, -16342, -15851, -14509, -12983, -13836, -15829, -14990, -14896, -14976, -15477, -15915, -16447, -17076, -17719, -18362, -18991, -19660, -20233, -20696, -21147, -21632, -22219, -22999, -24073, -25364, -26824, -26626, -23519, -24262, -24970, -24863, -25069, -24920, -18087, -15240, -16744, -15750, -14991, -17696, -23891, -23200, -22974, -22685, -22924, -22901, -22832, -22916, -22986, -23032, -23048, -23145, -23114, -22858, -22589, -22402, -22435, -22863, -23908, -25493, -27443, -27174, -20108, -19840, -21120, -20310, -20118, -20250, -7957, 358, -3330, -1947, -1160, -5308, -19098, -18791, -17642, -16397, -15976, -15179, -14079, -13351, -12665, -11996, -11315, -10753, -10092, -9086, -7967, -6910, -6083, -5749, -5967, -6790, -8126, -7080};