/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1495 256 samples */
 
const int16_t AKWF_1495_256_DATA [256] = 
{266, 1042, 1827, 2636, 3461, 4300, 5148, 5996, 6844, 7686, 8517, 9336, 10141, 10927, 11695, 12445, 13174, 13883, 14574, 15246, 15903, 16546, 17178, 17804, 18423, 19038, 19651, 20260, 20865, 21467, 22058, 22637, 23203, 23749, 24275, 24780, 25263, 25725, 26169, 26596, 27008, 27410, 27801, 28186, 28564, 28937, 29305, 29666, 30018, 30364, 30698, 31018, 31324, 31611, 31875, 32113, 32321, 32493, 32626, 32716, 32762, 32764, 32722, 32639, 32520, 32370, 32195, 32005, 31805, 31601, 31399, 31206, 31022, 30851, 30691, 30542, 30399, 30261, 30120, 29972, 29807, 29621, 29405, 29154, 28861, 28520, 28130, 27685, 27190, 26646, 26057, 25428, 24766, 24078, 23371, 22654, 21934, 21221, 20519, 19832, 19169, 18527, 17908, 17314, 16738, 16176, 15625, 15076, 14522, 13956, 13370, 12756, 12113, 11430, 10709, 9949, 9149, 8315, 7451, 6562, 5655, 4737, 3812, 2890, 1975, 1071, 185, -682, -1529, -2349, -3146, -3920, -4670, -5403, -6120, -6823, -7521, -8217, -8914, -9618, -10331, -11052, -11783, -12522, -13264, -14008, -14750, -15483, -16208, -16921, -17618, -18300, -18967, -19615, -20250, -20871, -21476, -22069, -22649, -23215, -23769, -24311, -24841, -25357, -25862, -26354, -26834, -27297, -27746, -28176, -28583, -28965, -29320, -29641, -29931, -30186, -30407, -30595, -30754, -30889, -31001, -31098, -31186, -31269, -31349, -31430, -31516, -31604, -31695, -31790, -31884, -31974, -32056, -32125, -32176, -32204, -32203, -32170, -32095, -31978, -31814, -31601, -31339, -31029, -30674, -30281, -29853, -29399, -28926, -28442, -27954, -27471, -26997, -26536, -26093, -25667, -25260, -24870, -24492, -24122, -23755, -23383, -22999, -22597, -22166, -21704, -21215, -20700, -20145, -19542, -18892, -18202, -17470, -16701, -15906, -15086, -14252, -13413, -12572, -11738, -10918, -10114, -9332, -8574, -7839, -7128, -6443, -5775, -5120, -4476, -3834, -3190, -2535, -1865, -1178, -452};