/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1452 256 samples */
 
const int16_t AKWF_1452_256_DATA [256] = 
{2257, 5627, 8892, 11859, 14619, 17219, 19645, 21908, 24040, 26094, 27982, 29555, 30817, 31777, 32412, 32715, 32775, 32671, 32286, 31587, 30629, 29661, 28627, 27454, 26372, 25332, 24393, 23665, 23103, 22648, 22174, 21521, 20655, 19742, 18687, 17316, 15672, 13874, 11949, 9966, 8125, 6545, 5097, 3585, 1520, -1445, -3285, -4541, -5403, -5836, -5865, -5607, -5183, -4539, -3515, -2183, -381, 1286, 1622, 1473, 788, -881, -2484, -4234, -6191, -8168, -9989, -11637, -13159, -14589, -15978, -17316, -18587, -19821, -20929, -21864, -22656, -23334, -24000, -24660, -25247, -25707, -26129, -26336, -26243, -26173, -26089, -26099, -26273, -26451, -26748, -26909, -26736, -26488, -26181, -25784, -25247, -24535, -23695, -22737, -21542, -19984, -18188, -16217, -14022, -11619, -9180, -6644, -4000, -192, 3602, 5661, 7534, 9269, 10781, 12042, 13145, 14149, 14915, 15520, 15978, 16280, 16637, 16993, 17414, 18090, 18964, 20017, 21192, 22388, 23535, 24566, 25406, 25984, 26260, 26387, 26374, 26208, 26136, 26035, 25928, 25939, 26022, 26164, 26322, 26443, 26489, 26462, 26276, 25908, 25487, 24927, 24240, 23501, 22706, 21865, 21069, 20415, 19884, 19387, 18906, 18447, 17926, 17283, 16492, 15523, 14355, 13049, 11582, 9968, 8292, 6487, 4529, 2542, -313, -2848, -4482, -6164, -7700, -9144, -10478, -11786, -13136, -14291, -15211, -16007, -16759, -17454, -18215, -19076, -19965, -20856, -21847, -22864, -23719, -24314, -24759, -24931, -24716, -24451, -24028, -23510, -23143, -22964, -22810, -22758, -22905, -22975, -22654, -22140, -21648, -20896, -20128, -19603, -19256, -18829, -18472, -18301, -18193, -17995, -18148, -18471, -18510, -18140, -17276, -16192, -15080, -13829, -12442, -11129, -10099, -9396, -9157, -9503, -10365, -11498, -12691, -13493, -13827, -14016, -13938, -13631, -13277, -13023, -12821, -12855, -12986, -12842, -12496, -12151, -11638, -10645, -9430, -7877, -5637, -2244};