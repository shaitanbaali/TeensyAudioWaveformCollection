/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1464 256 samples */
 
const int16_t AKWF_1464_256_DATA [256] = 
{1683, 4515, 7060, 8871, 9953, 10613, 11221, 11982, 12836, 13722, 14571, 15380, 16171, 16943, 17703, 18446, 19170, 19877, 20562, 21229, 21875, 22499, 23101, 23682, 24244, 24787, 25310, 25807, 26281, 26737, 27174, 27595, 27999, 28387, 28759, 29116, 29457, 29782, 30092, 30384, 30659, 30919, 31163, 31389, 31599, 31790, 31964, 32121, 32261, 32385, 32493, 32582, 32658, 32714, 32750, 32767, 32761, 32730, 32674, 32592, 32480, 32342, 32174, 31979, 31754, 31503, 31225, 30921, 30590, 30233, 29850, 29440, 29005, 28542, 28055, 27542, 27004, 26443, 25856, 25239, 24602, 23938, 23252, 22553, 21831, 21100, 20362, 19617, 18871, 18134, 17397, 16669, 15951, 15243, 14543, 13853, 13170, 12496, 11829, 11169, 10518, 9877, 9243, 8627, 8030, 7451, 6891, 6352, 5836, 5342, 4870, 4418, 3986, 3573, 3173, 2786, 2404, 2027, 1652, 1271, 885, 491, 86, -325, -749, -1185, -1629, -2082, -2546, -3019, -3506, -4010, -4525, -5057, -5607, -6173, -6758, -7361, -7982, -8625, -9287, -9964, -10660, -11370, -12093, -12827, -13569, -14312, -15063, -15812, -16557, -17300, -18035, -18761, -19477, -20175, -20855, -21521, -22170, -22802, -23416, -24011, -24583, -25135, -25662, -26168, -26649, -27106, -27538, -27943, -28323, -28680, -29013, -29320, -29603, -29862, -30096, -30306, -30492, -30655, -30796, -30912, -31006, -31077, -31122, -31145, -31146, -31125, -31081, -31018, -30937, -30841, -30731, -30608, -30475, -30334, -30187, -30031, -29870, -29704, -29531, -29350, -29166, -28973, -28772, -28567, -28354, -28135, -27911, -27677, -27437, -27191, -26937, -26677, -26410, -26135, -25852, -25560, -25260, -24947, -24623, -24283, -23926, -23551, -23155, -22736, -22293, -21823, -21332, -20815, -20271, -19710, -19134, -18542, -17936, -17312, -16670, -16009, -15325, -14621, -13900, -13156, -12391, -11602, -10783, -9943, -9082, -8199, -7277, -6316, -5392, -4576, -3953, -3359, -2407, -689};