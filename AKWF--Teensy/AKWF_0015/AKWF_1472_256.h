/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1472 256 samples */
 
const int16_t AKWF_1472_256_DATA [256] = 
{114, 294, 471, 648, 825, 1003, 1180, 1358, 1532, 1727, 1914, 2099, 2282, 2460, 2638, 2813, 2990, 3166, 3340, 3516, 3692, 3866, 4041, 4218, 4394, 4568, 4744, 4920, 5095, 5271, 5447, 5622, 5798, 5973, 6148, 6324, 6499, 6676, 6851, 7026, 7202, 7377, 7552, 7727, 7902, 8078, 8252, 8427, 8603, 8778, 8953, 9128, 9302, 9478, 9653, 9827, 10002, 10177, 10352, 10526, 10701, 10876, 11049, 11224, 11398, 11572, 11747, 11922, 12095, 12269, 12445, 12618, 12792, 12966, 13139, 13314, 13488, 13660, 13835, 14010, 14182, 14356, 14530, 14703, 14876, 15051, 15224, 15396, 15569, 15743, 15916, 16089, 16263, 16436, 16608, 16781, 16954, 17127, 17299, 17473, 17645, 17817, 17990, 18163, 18335, 18509, 18679, 18854, 19027, 19198, 19370, 19543, 19714, 19886, 20060, 20231, 20404, 20575, 20746, 20919, 21090, 21261, 21433, 21604, 21777, 21949, 22120, 22291, 22463, 22596, 22827, 22738, 13606, 1784, -9156, -18185, -24476, -28561, -30983, -32251, -32734, -32698, -32332, -31759, -31068, -30310, -29525, -28735, -27952, -27191, -26456, -25747, -25067, -24418, -23796, -23205, -22639, -22099, -21584, -21094, -20623, -20175, -19746, -19333, -18939, -18561, -18196, -17847, -17510, -17183, -16869, -16564, -16268, -15983, -15704, -15433, -15171, -14913, -14661, -14417, -14176, -13941, -13709, -13481, -13259, -13038, -12823, -12607, -12398, -12188, -11983, -11778, -11575, -11375, -11176, -10979, -10784, -10590, -10395, -10203, -10012, -9822, -9634, -9446, -9257, -9069, -8884, -8697, -8512, -8328, -8143, -7960, -7776, -7593, -7410, -7228, -7045, -6864, -6683, -6501, -6320, -6139, -5959, -5778, -5597, -5417, -5237, -5057, -4877, -4699, -4519, -4340, -4160, -3982, -3802, -3624, -3444, -3266, -3087, -2909, -2730, -2551, -2372, -2195, -2017, -1838, -1661, -1482, -1304, -1127, -949, -770, -594, -415, -239, -58};