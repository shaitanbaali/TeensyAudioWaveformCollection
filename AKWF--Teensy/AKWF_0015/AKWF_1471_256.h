/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1471 256 samples */
 
const int16_t AKWF_1471_256_DATA [256] = 
{98, 318, 528, 734, 935, 1126, 1317, 1501, 1678, 1853, 2020, 2183, 2338, 2488, 2641, 2785, 2929, 3066, 3199, 3332, 3464, 3590, 3709, 3830, 3943, 4056, 4163, 4268, 4367, 4464, 4558, 4648, 4736, 4824, 4905, 4985, 5064, 5140, 5211, 5279, 5349, 5417, 5477, 5538, 5595, 5650, 5702, 5753, 5801, 5846, 5885, 5929, 5967, 6001, 6040, 6075, 6112, 6142, 6172, 6201, 6227, 6254, 6276, 6298, 6318, 6339, 6353, 6369, 6380, 6391, 6401, 6410, 6417, 6424, 6429, 6435, 6435, 6438, 6437, 6438, 6436, 6436, 6429, 6427, 6418, 6414, 6405, 6395, 6384, 6370, 6360, 6349, 6332, 6318, 6301, 6286, 6270, 6253, 6234, 6212, 6196, 6174, 6153, 6133, 6109, 6086, 6061, 6035, 6009, 5985, 5958, 5930, 5902, 5875, 5847, 5817, 5786, 5758, 5725, 5695, 5666, 5633, 5604, 5570, 5536, 5503, 5468, 5435, 5402, 5368, 5329, 5293, 5257, 5220, 5182, 5145, 5105, 5068, 5031, 4992, 4953, 4913, 4874, 4836, 4794, 4755, 4714, 4673, 4634, 4595, 4553, 4513, 4468, 4428, 4388, 4345, 4301, 4260, 4216, 4175, 4132, 4088, 4048, 4007, 3964, 3922, 3882, 3842, 3799, 3755, 3711, 3668, 3628, 3586, 3542, 3501, 3458, 3416, 3370, 3330, 3287, 3246, 3205, 3162, 3121, 3078, 3034, 2723, 4024, -8776, -17877, -24690, -29318, -31566, -32570, -32758, -32442, -31805, -30982, -30059, -29077, -28072, -27068, -26078, -25107, -24173, -23253, -22360, -21497, -20660, -19849, -19069, -18314, -17580, -16876, -16189, -15523, -14882, -14258, -13650, -13066, -12495, -11939, -11400, -10876, -10373, -9875, -9399, -8931, -8481, -8037, -7614, -7198, -6791, -6397, -6010, -5634, -5271, -4920, -4573, -4240, -3909, -3589, -3281, -2979, -2686, -2405, -2121, -1848, -1581, -1324, -1068, -822, -581, -348, -116};