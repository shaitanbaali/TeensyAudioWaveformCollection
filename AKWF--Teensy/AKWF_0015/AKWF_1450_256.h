/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1450 256 samples */
 
const int16_t AKWF_1450_256_DATA [256] = 
{1344, 5479, 9257, 12596, 15367, 17518, 19064, 20059, 20607, 20811, 20775, 20581, 20290, 19951, 19591, 19239, 18923, 18677, 18534, 18526, 18678, 18991, 19450, 20029, 20679, 21360, 22052, 22745, 23457, 24208, 25009, 25843, 26656, 27343, 27763, 27760, 27184, 25918, 23907, 21176, 17804, 13932, 9756, 5450, 1208, -2784, -6414, -9563, -12152, -14150, -15528, -16280, -16416, -15955, -14922, -13358, -11326, -8908, -6197, -3328, -438, 2341, 4865, 7019, 8713, 9874, 10471, 10493, 9948, 8862, 7272, 5225, 2764, -53, -3150, -6462, -9906, -13374, -16789, -20050, -23062, -25765, -28087, -29980, -31414, -32349, -32755, -32604, -31868, -30541, -28629, -26184, -23291, -20063, -16666, -13262, -10012, -7073, -4555, -2531, -1043, -91, 346, 301, -184, -1070, -2314, -3877, -5713, -7750, -9925, -12148, -14315, -16346, -18150, -19652, -20811, -21595, -21982, -21951, -21475, -20516, -19021, -16964, -14326, -11126, -7461, -3462, 696, 4791, 8627, 12034, 14883, 17128, 18777, 19886, 20548, 20866, 20937, 20845, 20649, 20390, 20100, 19804, 19534, 19320, 19199, 19210, 19375, 19704, 20187, 20793, 21479, 22206, 22946, 23685, 24432, 25201, 25998, 26808, 27577, 28207, 28567, 28504, 27877, 26575, 24544, 21810, 18445, 14592, 10442, 6165, 1953, -2015, -5620, -8753, -11332, -13326, -14706, -15465, -15615, -15165, -14147, -12594, -10569, -8153, -5441, -2565, 338, 3138, 5690, 7879, 9619, 10839, 11510, 11615, 11169, 10185, 8700, 6758, 4395, 1669, -1346, -4591, -7979, -11404, -14793, -18042, -21056, -23781, -26144, -28097, -29608, -30637, -31150, -31111, -30492, -29278, -27474, -25128, -22325, -19175, -15847, -12501, -9299, -6399, -3908, -1892, -396, 579, 1061, 1074, 655, -155, -1323, -2810, -4568, -6534, -8646, -10807, -12925, -14915, -16689, -18183, -19354, -20169, -20608, -20652, -20265, -19401, -18001, -16027, -13461, -10324, -6712, -2669};