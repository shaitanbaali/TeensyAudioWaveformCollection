/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1432 256 samples */
 
const int16_t AKWF_1432_256_DATA [256] = 
{113, 312, 501, 686, 872, 1050, 1227, 1402, 1574, 1740, 1904, 2066, 2223, 2379, 2531, 2682, 2826, 2973, 3114, 3250, 3387, 3521, 3649, 3779, 3905, 4029, 4148, 4268, 4383, 4495, 4606, 4714, 4822, 4926, 5029, 5128, 5225, 5322, 5417, 5507, 5596, 5684, 5770, 5855, 5937, 6016, 6094, 6173, 6246, 6320, 6391, 6461, 6528, 6595, 6660, 6724, 6784, 6845, 6903, 6959, 7015, 7070, 7122, 7174, 7224, 7273, 7319, 7366, 7410, 7452, 7495, 7536, 7575, 7614, 7652, 7688, 7721, 7755, 7792, 7820, 7852, 7880, 7910, 7938, 7963, 7988, 8011, 8036, 8060, 8081, 8103, 8122, 8141, 8160, 8177, 8195, 8210, 8223, 8237, 8250, 8263, 8274, 8288, 8298, 8307, 8317, 8323, 8330, 8337, 8343, 8351, 8354, 8358, 8361, 8365, 8379, 8363, 8382, 8502, 8672, 8850, 9024, 9183, 9328, 9463, 9589, 9712, 9826, 9939, 10049, 10153, 10257, 10358, 10457, 10551, 10643, 10734, 10819, 10902, 10986, 11066, 11143, 11218, 11295, 11364, 11430, 11497, 11561, 11625, 11685, 11742, 11798, 11852, 11906, 11954, 12002, 12051, 12092, 12138, 12177, 12217, 12256, 12286, 12324, 12292, 12575, 9836, 1022, -10121, -19631, -26170, -30024, -31962, -32689, -32729, -32406, -31897, -31302, -30667, -30024, -29377, -28733, -28097, -27469, -26849, -26240, -25633, -25037, -24452, -23873, -23303, -22740, -22188, -21642, -21104, -20572, -20050, -19535, -19028, -18527, -18036, -17550, -17072, -16600, -16138, -15683, -15233, -14790, -14353, -13925, -13502, -13085, -12673, -12270, -11875, -11484, -11098, -10720, -10346, -9979, -9616, -9262, -8913, -8567, -8227, -7893, -7566, -7243, -6924, -6613, -6304, -6003, -5705, -5412, -5125, -4842, -4563, -4287, -4020, -3755, -3494, -3236, -2987, -2738, -2495, -2257, -2022, -1790, -1560, -1339, -1120, -904, -694, -485, -281, -78};