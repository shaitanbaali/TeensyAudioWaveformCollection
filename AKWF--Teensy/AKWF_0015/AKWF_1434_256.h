/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1434 256 samples */
 
const int16_t AKWF_1434_256_DATA [256] = 
{571, 1361, 2136, 2909, 3683, 4456, 5238, 6029, 6830, 7647, 8473, 9323, 10200, 11097, 12019, 13366, 14422, 15026, 15778, 16565, 17366, 18158, 18938, 19701, 20442, 21158, 21853, 22529, 23182, 23815, 24429, 25020, 25595, 26148, 26685, 27201, 27701, 28178, 28643, 29085, 29511, 29920, 30306, 30675, 31027, 31357, 31666, 31955, 32222, 32461, 32692, 32771, 32756, 32732, 32684, 32617, 32527, 32415, 32280, 32125, 31946, 31740, 31415, 31201, 31031, 30792, 30530, 30247, 29929, 29510, 29186, 28885, 28544, 28128, 27481, 27250, 27104, 26623, 26104, 25583, 25044, 24464, 23847, 23189, 22471, 21719, 20865, 19190, 18275, 18045, 17515, 16932, 16328, 15729, 15154, 14608, 14096, 13612, 13158, 12732, 12332, 11954, 11599, 11258, 10935, 10619, 10312, 10010, 9709, 9404, 9091, 8765, 8424, 8062, 7666, 7263, 6680, 5967, 5668, 5239, 4587, 4070, 3548, 2992, 2449, 1731, 966, 104, -1290, -2115, -2591, -3271, -3998, -4754, -5517, -6282, -7041, -7792, -8531, -9257, -9972, -10675, -11368, -12051, -12744, -13385, -13998, -14605, -15200, -15784, -16347, -16894, -17426, -17938, -18435, -18910, -19362, -19800, -20212, -20607, -20981, -21330, -21653, -21955, -22231, -22479, -22706, -22869, -22902, -23097, -23324, -23491, -23632, -23754, -23862, -23955, -24037, -24108, -24168, -24214, -24263, -24242, -24132, -24237, -24362, -24451, -24536, -24622, -24711, -24806, -24908, -25020, -25135, -25256, -25383, -25515, -25652, -25791, -25933, -26076, -26223, -26369, -26511, -26655, -26795, -26931, -27062, -27188, -27305, -27414, -27514, -27600, -27672, -27728, -27768, -27787, -27786, -27759, -27705, -27624, -27508, -27356, -27020, -26603, -26145, -25632, -25063, -24429, -23766, -22831, -21475, -20885, -20377, -19682, -18928, -18130, -17303, -16459, -15590, -14703, -13797, -12853, -11923, -10743, -9355, -8609, -7873, -7034, -6180, -5316, -4458, -3612, -2777, -1957, -1162, -316};