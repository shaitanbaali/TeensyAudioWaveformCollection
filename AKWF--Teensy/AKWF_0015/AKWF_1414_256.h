/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1414 256 samples */
 
const int16_t AKWF_1414_256_DATA [256] = 
{839, 2301, 3812, 5390, 7022, 8707, 10430, 12174, 13929, 15690, 17451, 19202, 20914, 22558, 24122, 25582, 26915, 28115, 29164, 30054, 30790, 31374, 31816, 32138, 32351, 32478, 32537, 32543, 32511, 32453, 32377, 32294, 32206, 32122, 32045, 31976, 31919, 31876, 31847, 31833, 31833, 31847, 31875, 31915, 31964, 32024, 32090, 32162, 32240, 32317, 32395, 32470, 32542, 32608, 32666, 32712, 32745, 32765, 32767, 32751, 32715, 32655, 32571, 32459, 32315, 32141, 31930, 31682, 31393, 31061, 30683, 30256, 29778, 29243, 28651, 27998, 27280, 26498, 25647, 24727, 23741, 22683, 21558, 20373, 19126, 17824, 16479, 15092, 13677, 12246, 10805, 9374, 7966, 6591, 5274, 4035, 2920, 1935, 971, -26, -1055, -2107, -3174, -4244, -5323, -6408, -7489, -8560, -9616, -10646, -11649, -12618, -13549, -14441, -15291, -16095, -16859, -17577, -18251, -18883, -19473, -20022, -20531, -21004, -21439, -21841, -22210, -22547, -22856, -23136, -23390, -23619, -23826, -24010, -24173, -24317, -24443, -24552, -24644, -24721, -24782, -24830, -24865, -24887, -24898, -24896, -24884, -24859, -24824, -24778, -24720, -24652, -24574, -24485, -24384, -24273, -24151, -24016, -23871, -23714, -23544, -23364, -23172, -22967, -22751, -22524, -22285, -22035, -21776, -21508, -21231, -20948, -20658, -20366, -20071, -19776, -19484, -19196, -18915, -18647, -18390, -18149, -17928, -17729, -17555, -17411, -17298, -17220, -17183, -17189, -17243, -17364, -17590, -17932, -18387, -18947, -19606, -20359, -21198, -22101, -23048, -24012, -24965, -25885, -26752, -27545, -28259, -28886, -29425, -29880, -30258, -30562, -30804, -30988, -31123, -31212, -31260, -31273, -31250, -31191, -31100, -30975, -30815, -30621, -30390, -30123, -29816, -29469, -29080, -28646, -28167, -27642, -27064, -26434, -25751, -25009, -24209, -23350, -22426, -21439, -20392, -19277, -18099, -16864, -15568, -14220, -12828, -11393, -9932, -8458, -6984, -5540, -4164, -2924, -1748, -474};