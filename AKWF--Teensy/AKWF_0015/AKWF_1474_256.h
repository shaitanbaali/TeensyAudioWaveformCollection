/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1474 256 samples */
 
const int16_t AKWF_1474_256_DATA [256] = 
{5055, 7770, 7197, 7249, 7196, 7150, 7097, 7050, 7002, 6950, 6903, 6853, 6804, 6754, 6705, 6658, 6609, 6560, 6513, 6464, 6417, 6370, 6320, 6274, 6227, 6179, 6133, 6087, 6043, 5997, 5952, 5907, 5862, 5817, 5774, 5729, 5688, 5645, 5601, 5560, 5519, 5478, 5437, 5395, 5355, 5315, 5275, 5236, 5197, 5157, 5118, 5078, 5041, 5000, 4963, 4926, 4887, 4851, 4812, 4771, 4739, 4856, 4059, 8587, 25460, 28412, 27441, 27289, 26988, 26685, 26384, 26090, 25794, 25501, 25212, 24921, 24636, 24352, 24070, 23791, 23514, 23241, 22968, 22697, 22430, 22164, 21902, 21640, 21379, 21123, 20870, 20617, 20368, 20121, 19875, 19632, 19390, 19154, 18916, 18681, 18450, 18219, 17990, 17765, 17541, 17317, 17098, 16880, 16664, 16448, 16236, 16026, 15818, 15611, 15405, 15201, 15001, 14801, 14604, 14407, 14213, 14022, 13831, 13642, 13454, 13269, 13087, 12905, 12724, 12546, 12370, 12196, 12024, 11851, 11681, 11513, 11345, 11181, 11018, 10853, 10695, 10535, 10377, 10220, 10065, 9914, 9759, 9608, 9459, 9145, 9787, 4551, -11213, -13443, -12800, -12816, -12694, -12583, -12466, -12352, -12242, -12127, -12019, -11909, -11798, -11691, -11583, -11475, -11371, -11263, -11160, -11057, -10952, -10853, -10749, -10650, -10551, -10451, -10356, -10257, -10160, -10067, -9970, -9878, -9783, -9688, -9598, -9505, -9416, -9473, -8716, -12905, -29545, -32906, -31792, -31604, -31246, -30891, -30541, -30193, -29847, -29504, -29165, -28830, -28495, -28164, -27836, -27510, -27187, -26867, -26549, -26236, -25923, -25614, -25308, -25003, -24703, -24405, -24108, -23816, -23524, -23236, -22951, -22668, -22387, -22108, -21833, -21559, -21289, -21020, -20753, -20491, -20231, -19971, -19714, -19460, -19207, -18960, -18711, -18466, -18224, -17983, -17745, -17509, -17274, -17044, -16813, -16585, -16361, -16136, -15916, -15694, -15475, -15152, -15544, -10707};