/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1415 256 samples */
 
const int16_t AKWF_1415_256_DATA [256] = 
{698, 2864, 5077, 7423, 9928, 12615, 15429, 18239, 20967, 23589, 26009, 28066, 29676, 30896, 31793, 32381, 32690, 32765, 32642, 32362, 31944, 31392, 30772, 30173, 29652, 29230, 28929, 28721, 28539, 28310, 27957, 27382, 26453, 25136, 23540, 21795, 19911, 17836, 15602, 13309, 11019, 8732, 6457, 4249, 2180, 304, -1362, -2756, -3731, -4234, -4356, -4216, -3860, -3338, -2747, -2223, -1859, -1711, -1821, -2223, -2916, -3884, -5109, -6556, -8151, -9757, -11260, -12674, -14093, -15503, -16950, -18516, -20145, -21731, -23174, -24405, -25359, -25957, -26215, -26221, -26062, -25830, -25603, -25399, -25247, -25250, -25378, -25576, -25830, -26069, -26264, -26448, -26659, -26894, -27085, -27173, -27126, -26855, -26199, -25082, -23576, -21778, -19728, -17425, -14905, -12317, -9816, -7338, -4891, -2597, -415, 1682, 3651, 5436, 6987, 8226, 9133, 9760, 10220, 10646, 11142, 11764, 12563, 13614, 14919, 16405, 18016, 19736, 21424, 22968, 24374, 25600, 26629, 27468, 28107, 28542, 28756, 28816, 28822, 28812, 28801, 28780, 28755, 28720, 28593, 28401, 28186, 27893, 27460, 26864, 26172, 25491, 24880, 24371, 23996, 23751, 23566, 23379, 23192, 22991, 22705, 22280, 21692, 20936, 20037, 19014, 17884, 16648, 15290, 13813, 12218, 10511, 8719, 6847, 4911, 2973, 1073, -826, -2710, -4540, -6327, -8071, -9742, -11385, -13029, -14629, -16182, -17689, -19160, -20627, -22092, -23494, -24764, -25890, -26889, -27689, -28208, -28456, -28486, -28368, -28178, -27946, -27673, -27419, -27213, -27035, -26842, -26584, -26243, -25807, -25259, -24616, -23853, -22990, -22080, -21116, -20144, -19268, -18531, -17893, -17392, -16992, -16610, -16235, -15862, -15537, -15263, -14988, -14762, -14530, -14267, -14053, -13848, -13600, -13240, -12671, -11896, -10952, -9915, -8891, -7955, -7177, -6680, -6497, -6521, -6750, -7139, -7553, -7834, -7783, -7411, -6802, -5932, -4781, -3244, -1304};