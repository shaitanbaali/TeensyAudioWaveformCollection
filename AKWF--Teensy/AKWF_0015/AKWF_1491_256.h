/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1491 256 samples */
 
const int16_t AKWF_1491_256_DATA [256] = 
{730, 1897, 3022, 4133, 5220, 6282, 7319, 8323, 9300, 10244, 11152, 12026, 12862, 13656, 14410, 15123, 15790, 16413, 16991, 17520, 18001, 18435, 18818, 19152, 19434, 19666, 19848, 19978, 20057, 20085, 20062, 19990, 19868, 19697, 19478, 19212, 18900, 18543, 18144, 17701, 17218, 16695, 16139, 15545, 14915, 14258, 13570, 12856, 12118, 11356, 10576, 9780, 8967, 8144, 7312, 6473, 5631, 4790, 3952, 3119, 2296, 1483, 688, -88, -844, -1572, -2275, -2947, -3583, -4180, -4739, -5252, -5717, -6131, -6488, -6789, -7028, -7202, -7308, -7341, -7299, -7180, -6977, -6691, -6318, -5854, -5302, -4656, -3918, -3090, -2169, -1161, -70, 1100, 2342, 3642, 4993, 6375, 7772, 9161, 10516, 11819, 13049, 14192, 15241, 16184, 17016, 17737, 18344, 18837, 19219, 19495, 19666, 19738, 19717, 19608, 19420, 19155, 18823, 18427, 17978, 17477, 16933, 16350, 15736, 15093, 14430, 13751, 13059, 12364, 11667, 10974, 10294, 9627, 8981, 8366, 7784, 7239, 6743, 6297, 5909, 5584, 5328, 5145, 5038, 5011, 5068, 5205, 5424, 5720, 6089, 6520, 7003, 7527, 8072, 8616, 9137, 9616, 10035, 10380, 10642, 10814, 10895, 10877, 10764, 10552, 10244, 9846, 9355, 8781, 8125, 7391, 6587, 5717, 4784, 3796, 2758, 1674, 550, -606, -1795, -3011, -4241, -5491, -6750, -8013, -9281, -10547, -11803, -13052, -14287, -15503, -16699, -17871, -19015, -20131, -21211, -22255, -23264, -24229, -25152, -26031, -26860, -27640, -28372, -29051, -29675, -30244, -30758, -31215, -31614, -31954, -32236, -32458, -32620, -32724, -32767, -32751, -32674, -32540, -32348, -32097, -31789, -31427, -31008, -30537, -30012, -29436, -28811, -28137, -27417, -26654, -25846, -24997, -24109, -23182, -22222, -21230, -20205, -19152, -18075, -16971, -15848, -14707, -13546, -12372, -11190, -9994, -8794, -7591, -6383, -5178, -3978, -2782, -1600, -403};