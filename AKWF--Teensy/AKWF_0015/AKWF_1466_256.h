/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1466 256 samples */
 
const int16_t AKWF_1466_256_DATA [256] = 
{495, 1248, 1984, 2724, 3462, 4199, 4935, 5667, 6397, 7128, 7854, 8576, 9295, 10008, 10718, 11425, 12119, 12803, 13476, 14143, 14802, 15454, 16099, 16738, 17366, 17984, 18590, 19175, 19743, 20293, 20824, 21340, 21842, 22327, 22795, 23252, 23693, 24120, 24534, 24935, 25323, 25699, 26061, 26414, 26755, 27085, 27404, 27713, 28010, 28298, 28576, 28844, 29105, 29352, 29593, 29825, 30047, 30259, 30464, 30659, 30848, 31026, 31195, 31357, 31509, 31654, 31790, 31918, 32038, 32149, 32250, 32344, 32429, 32504, 32569, 32625, 32673, 32711, 32739, 32759, 32767, 32766, 32754, 32728, 32696, 32650, 32592, 32524, 32443, 32348, 32241, 32121, 31987, 31840, 31678, 31499, 31307, 31099, 30872, 30631, 30372, 30094, 29798, 29493, 29178, 28854, 28310, 29096, 19029, 13463, 12132, 10558, 9242, 7987, 6765, 5596, 4466, 3362, 2285, 1229, 195, -813, -1806, -2777, -3729, -4663, -5581, -6478, -7360, -8224, -9072, -9904, -10717, -11518, -12303, -13072, -13825, -14565, -15288, -15995, -16689, -17367, -18030, -18681, -19315, -19937, -20542, -21131, -21709, -22271, -22817, -23351, -23868, -24370, -24852, -25309, -25738, -26148, -26536, -26900, -27246, -27571, -27873, -28157, -28423, -28672, -28904, -29118, -29314, -29496, -29661, -29812, -29947, -30067, -30175, -30269, -30348, -30418, -30472, -30514, -30544, -30562, -30567, -30563, -30548, -30520, -30481, -30432, -30372, -30303, -30220, -30129, -30029, -29918, -29794, -29662, -29520, -29367, -29204, -29030, -28846, -28654, -28450, -28233, -28009, -27772, -27524, -27267, -26998, -26717, -26422, -26117, -25801, -25472, -25130, -24775, -24404, -24024, -23627, -23216, -22791, -22350, -21895, -21422, -20933, -20429, -19906, -19365, -18806, -18230, -17632, -17023, -16404, -15773, -15127, -14471, -13805, -13136, -12458, -11772, -11082, -10384, -9682, -8977, -8266, -7550, -6831, -6109, -5381, -4652, -3920, -3185, -2449, -1713, -976, -225};