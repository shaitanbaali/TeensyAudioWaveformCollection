/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1492 256 samples */
 
const int16_t AKWF_1492_256_DATA [256] = 
{240, 736, 1135, 1459, 1717, 1921, 2094, 2255, 2431, 2642, 2907, 3236, 3639, 4114, 4660, 5271, 5942, 6672, 7457, 8293, 9190, 10143, 11154, 12221, 13339, 14495, 15677, 16863, 18031, 19169, 20249, 21259, 22188, 23024, 23763, 24407, 24950, 25403, 25770, 26063, 26298, 26495, 26673, 26854, 27053, 27281, 27546, 27843, 28161, 28490, 28812, 29117, 29391, 29627, 29821, 29974, 30093, 30185, 30261, 30335, 30420, 30526, 30661, 30826, 31017, 31225, 31439, 31646, 31832, 31988, 32107, 32183, 32216, 32210, 32175, 32117, 32053, 31993, 31950, 31933, 31945, 31981, 32028, 32068, 32077, 32034, 31921, 31719, 31420, 31018, 30506, 29889, 29168, 28349, 27444, 26466, 25433, 24366, 23287, 22216, 21176, 20178, 19233, 18345, 17512, 16731, 16003, 15322, 14690, 14107, 13576, 13101, 12687, 12336, 12047, 11813, 11617, 11444, 11265, 11057, 10796, 10465, 10046, 9537, 8936, 8240, 7456, 6584, 5624, 4581, 3456, 2251, 972, -370, -1765, -3190, -4626, -6047, -7428, -8751, -10000, -11156, -12218, -13178, -14031, -14781, -15423, -15961, -16403, -16754, -17030, -17249, -17434, -17608, -17796, -18016, -18281, -18596, -18957, -19359, -19792, -20246, -20713, -21188, -21663, -22143, -22634, -23134, -23656, -24208, -24793, -25416, -26072, -26753, -27449, -28141, -28811, -29440, -30014, -30520, -30952, -31304, -31578, -31776, -31908, -31986, -32027, -32049, -32070, -32106, -32167, -32255, -32367, -32489, -32607, -32704, -32761, -32762, -32697, -32557, -32339, -32043, -31674, -31237, -30743, -30207, -29648, -29079, -28521, -27985, -27484, -27021, -26597, -26210, -25850, -25511, -25184, -24869, -24560, -24262, -23979, -23719, -23489, -23298, -23150, -23046, -22979, -22933, -22891, -22832, -22728, -22556, -22302, -21952, -21501, -20944, -20281, -19514, -18642, -17672, -16614, -15470, -14256, -12995, -11699, -10396, -9106, -7847, -6642, -5501, -4431, -3443, -2538, -1714, -976, -314};