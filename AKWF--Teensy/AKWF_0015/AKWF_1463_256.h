/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1463 256 samples */
 
const int16_t AKWF_1463_256_DATA [256] = 
{32760, 32764, 32766, 32768, 32767, 32768, 32767, 32765, 32763, 32759, 32756, 32751, 32745, 32740, 32735, 32729, 32722, 32716, 32709, 32702, 32695, 32687, 32679, 32672, 32664, 32656, 32648, 32639, 32631, 32623, 32614, 32606, 32597, 32589, 32581, 32571, 32563, 32554, 32546, 32538, 32529, 32520, 32512, 32503, 32495, 32486, 32477, 32468, 32460, 32452, 32443, 32435, 32426, 32417, 32409, 32401, 32392, 32384, 32376, 32367, 32358, 32351, 32342, 32333, 32325, 32317, 32308, 32301, 32291, 32283, 32275, 32267, 32259, 32249, 32241, 32233, 32225, 32217, 32208, 32200, 32192, 32183, 32175, 32167, 32159, 32150, 32142, 32134, 32126, 32117, 32109, 32101, 32093, 32085, 32077, 32069, 32061, 32053, 32044, 32036, 32028, 32020, 32013, 32005, 31997, 31989, 31981, 31974, 31966, 31958, 31951, 31942, 31935, 31927, 31920, 31913, 31906, 31898, 30984, 35951, -9721, -33060, -28241, -29119, -29121, -29123, -29124, -29121, -29120, -29118, -29116, -29113, -29109, -29105, -29101, -29095, -29090, -29085, -29079, -29073, -29066, -29061, -29053, -29047, -29040, -29033, -29026, -29019, -29012, -29005, -28997, -28989, -28981, -28974, -28966, -28959, -28951, -28943, -28935, -28928, -28920, -28912, -28904, -28897, -28889, -28880, -28872, -28864, -28856, -28849, -28841, -28833, -28825, -28817, -28808, -28801, -28794, -28785, -28777, -28769, -28761, -28754, -28746, -28738, -28730, -28722, -28715, -28707, -28699, -28691, -28683, -28676, -28668, -28660, -28652, -28645, -28637, -28629, -28622, -28614, -28607, -28599, -28592, -28584, -28577, -28569, -28562, -28554, -28547, -28539, -28532, -28525, -28517, -28510, -28503, -28495, -28488, -28481, -28474, -28466, -28459, -28452, -28445, -28438, -28431, -28424, -28417, -28410, -28403, -28396, -28389, -28383, -28376, -28369, -28362, -28356, -28349, -28342, -28336, -28329, -28323, -28316, -28310, -28303, -28297, -28291, -28284, -28278, -28270, -28265, -28259, -28252, -28247, -28240, -28233, -28228};