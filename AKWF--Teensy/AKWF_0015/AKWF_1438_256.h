/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1438 256 samples */
 
const int16_t AKWF_1438_256_DATA [256] = 
{136, 449, 756, 1065, 1372, 1679, 1988, 2294, 2601, 2909, 3205, 3567, 3689, 2266, 3916, 4921, 5133, 5517, 5874, 6231, 6588, 6946, 7301, 7658, 8015, 8370, 8726, 9082, 9437, 9794, 10149, 10504, 10859, 11213, 11567, 11922, 12276, 12629, 12983, 13336, 13690, 14043, 14396, 14749, 15102, 15454, 15805, 16158, 16510, 16862, 17213, 17564, 17915, 18266, 18616, 18964, 19328, 19613, 19602, 19594, 19584, 19575, 19566, 19558, 19548, 19538, 19529, 19518, 19509, 19500, 19488, 19479, 19470, 19460, 19449, 19440, 19430, 19418, 19408, 19399, 19389, 19377, 19370, 19358, 19345, 19337, 19329, 19314, 19304, 19299, 19285, 19268, 19266, 19264, 19240, 19209, 19092, 19792, 17184, -5981, -6044, -5948, -5971, -5984, -6006, -6009, -6003, -6007, -6016, -6013, -6012, -6017, -6019, -6014, -6016, -6019, -6015, -6014, -6015, -6012, -6009, -6009, -6008, -6005, -6003, -6002, -5999, -5997, -5994, -5993, -5990, -5987, -5984, -5982, -5979, -5976, -5974, -5970, -5967, -5965, -5962, -5959, -5956, -5975, -6000, -6023, -6048, -6073, -6097, -6120, -6144, -6169, -6191, -6216, -6241, -6264, -6288, -6313, -6335, -6359, -6383, -6406, -6431, -6456, -6479, -6502, -6527, -6550, -6572, -6596, -6623, -6645, -6667, -6695, -6718, -6736, -6762, -6792, -6812, -6821, -6845, -7333, -4915, -17236, -30796, -21690, -21744, -21479, -21140, -20820, -20511, -20198, -19879, -19564, -19252, -18934, -18617, -18305, -17988, -17671, -17355, -17041, -16722, -16407, -16092, -15776, -15459, -15145, -14830, -14512, -14198, -13883, -13568, -13253, -12938, -12622, -12307, -11993, -11678, -11364, -11050, -10736, -10422, -10108, -9795, -9482, -9168, -8855, -8542, -8229, -7916, -7604, -7292, -6979, -6667, -6355, -6043, -5732, -5420, -5108, -4799, -4488, -4176, -3867, -3555, -3245, -2936, -2625, -2315, -2005, -1697, -1387, -1078, -769, -461, -146};