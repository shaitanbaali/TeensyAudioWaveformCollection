/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1499 256 samples */
 
const int16_t AKWF_1499_256_DATA [256] = 
{632, 2313, 4000, 5713, 7432, 9144, 10834, 12479, 14071, 15596, 17032, 18373, 19603, 20708, 21681, 22511, 23189, 23705, 24056, 24235, 24240, 24067, 23717, 23189, 22485, 21611, 20564, 19353, 17984, 16457, 14786, 12974, 11020, 8942, 6738, 4411, 1977, -563, -3207, -5930, -8732, -11593, -14476, -17362, -20201, -22924, -25467, -27726, -29613, -31083, -32100, -32652, -32751, -32413, -31671, -30556, -29112, -27382, -25403, -23225, -20891, -18434, -15903, -13334, -10755, -8213, -5735, -3351, -1104, 983, 2882, 4559, 5991, 7158, 8037, 8621, 8902, 8887, 8589, 8038, 7277, 6362, 5373, 4399, 3503, 2736, 2131, 1699, 1450, 1374, 1468, 1712, 2092, 2589, 3180, 3847, 4570, 5326, 6098, 6871, 7625, 8347, 9026, 9645, 10197, 10674, 11066, 11369, 11578, 11688, 11701, 11612, 11424, 11140, 10760, 10290, 9734, 9098, 8390, 7614, 6780, 5900, 4977, 4026, 3054, 2070, 1089, 118, -833, -1751, -2628, -3455, -4219, -4913, -5530, -6056, -6486, -6813, -7026, -7121, -7090, -6925, -6622, -6175, -5580, -4830, -3926, -2869, -1656, -297, 1194, 2809, 4516, 6275, 8045, 9747, 11295, 12609, 13624, 14304, 14639, 14628, 14288, 13643, 12731, 11583, 10238, 8743, 7128, 5430, 3692, 1939, 206, -1473, -3076, -4569, -5922, -7108, -8097, -8861, -9384, -9645, -9644, -9395, -8933, -8330, -7689, -7118, -6688, -6426, -6341, -6418, -6634, -6959, -7362, -7812, -8278, -8734, -9159, -9529, -9827, -10034, -10131, -10101, -9928, -9593, -9080, -8376, -7475, -6370, -5073, -3610, -2011, -345, 1300, 2829, 4149, 5212, 5995, 6486, 6693, 6633, 6327, 5803, 5089, 4215, 3211, 2102, 921, -310, -1566, -2822, -4062, -5263, -6403, -7467, -8440, -9303, -10051, -10670, -11153, -11492, -11681, -11718, -11600, -11321, -10892, -10307, -9574, -8700, -7689, -6552, -5299, -3939, -2491, -927};