/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1421 256 samples */
 
const int16_t AKWF_1421_256_DATA [256] = 
{286, 1263, 2138, 3001, 3877, 4739, 5447, 6131, 6839, 7488, 8052, 8466, 8606, 8790, 9004, 9150, 9225, 9135, 8898, 8676, 8415, 8090, 7714, 7299, 6856, 6420, 5971, 5564, 5117, 4571, 4061, 3560, 3223, 3112, 2893, 2610, 2332, 2055, 2027, 2140, 2170, 2213, 2432, 2715, 3046, 3370, 3552, 3827, 4319, 4830, 5389, 5858, 6231, 6609, 6981, 7407, 7866, 8252, 8595, 8935, 9262, 9656, 10028, 10283, 10513, 10772, 11023, 11278, 11481, 11602, 11728, 11848, 11983, 12121, 12245, 12355, 12354, 12291, 12295, 12317, 12398, 12478, 12513, 12552, 12705, 12807, 12779, 12798, 12924, 13018, 13144, 13010, 12622, 12430, 12325, 12285, 12262, 12053, 11784, 12004, 12119, 11492, 10376, 7653, 5183, 3144, 1287, -596, -2758, -5489, -7931, -10238, -12824, -15642, -18275, -20770, -22639, -24205, -25979, -27645, -29391, -30829, -31885, -32546, -32742, -32688, -32313, -31861, -31263, -30406, -29220, -27579, -25462, -23222, -20696, -18345, -15897, -13591, -11239, -9058, -6808, -4470, -2213, -72, 1726, 3049, 4342, 5578, 6847, 8161, 9296, 10349, 11003, 11442, 11417, 11183, 10884, 10442, 9776, 8870, 7536, 6067, 4456, 2733, 840, -946, -2636, -4186, -5582, -7145, -8767, -10307, -11774, -12892, -13857, -14716, -15499, -16200, -16797, -17172, -17423, -17480, -17358, -16961, -16331, -15333, -14318, -13168, -12024, -10787, -9305, -7636, -6008, -4374, -2942, -1520, -35, 1419, 2731, 4020, 5309, 6599, 8020, 9080, 9777, 10403, 10938, 11484, 11998, 12216, 12230, 12257, 12171, 11760, 11186, 10405, 9605, 9053, 8358, 7413, 6399, 5286, 4195, 3102, 2008, 856, -78, -906, -1839, -2827, -3929, -5038, -5932, -6730, -7385, -7943, -8263, -8579, -8916, -9232, -9577, -9633, -9367, -9017, -8536, -8116, -7686, -7129, -6463, -5845, -5181, -4404, -3558, -2659, -1685, -647};