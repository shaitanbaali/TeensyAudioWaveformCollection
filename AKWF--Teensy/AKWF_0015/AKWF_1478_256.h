/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1478 256 samples */
 
const int16_t AKWF_1478_256_DATA [256] = 
{422, 1390, 2322, 3239, 4135, 5010, 5865, 6693, 7497, 8277, 9026, 9749, 10444, 11106, 11740, 12343, 12912, 13451, 13957, 14430, 14870, 15278, 15651, 15991, 16299, 16573, 16815, 17023, 17200, 17345, 17458, 17540, 17592, 17615, 17608, 17573, 17510, 17421, 17304, 17163, 16997, 16808, 16597, 16364, 16110, 15837, 15544, 15235, 14910, 14567, 14210, 13842, 13460, 13066, 12663, 12250, 11829, 11402, 10968, 10529, 10087, 9640, 9192, 8742, 8291, 7842, 7395, 6949, 6506, 6068, 5633, 5205, 4782, 4366, 3958, 3558, 3165, 2783, 2409, 2045, 1693, 1351, 1020, 702, 395, 100, -180, -450, -707, -950, -1180, -1397, -1601, -1791, -1968, -2133, -2283, -2421, -2546, -2658, -2756, -2843, -2917, -2980, -3029, -3068, -3095, -3112, -3118, -3112, -3098, -3073, -3039, -2996, -2944, -2885, -2817, -2742, -2661, -2572, -2477, -2377, -2271, -2160, -2045, -1926, -1803, -1677, -1548, -1416, -1283, -1147, -1011, -873, -735, -597, -458, -321, -184, -48, 85, 217, 348, 477, 602, 724, 844, 961, 1074, 1184, 1289, 1391, 1489, 1581, 1670, 1755, 1834, 1909, 1979, 2045, 2105, 2161, 2211, 2255, 2296, 2332, 2363, 2388, 2408, 2424, 2435, 2441, 2443, 2440, 2432, 2420, 2404, 2384, 2360, 2331, 2299, 2264, 2224, 2181, 2135, 2087, 2035, 1981, 1924, 1865, 1804, 1740, 1674, 1607, 1538, 1468, 1397, 1324, 1251, 1176, 1101, 1022, 919, 959, -949, -6075, -9953, -12742, -14506, -15948, -17788, -19949, -22162, -24266, -26251, -28184, -30091, -32154, -32291, -29159, -27212, -26300, -26364, -26718, -26629, -26161, -25586, -25056, -24580, -24092, -23536, -22900, -22200, -21461, -20699, -19910, -19090, -18238, -17354, -16443, -15513, -14563, -13596, -12617, -11622, -10618, -9607, -8589, -7569, -6551, -5531, -4516, -3507, -2506, -1517, -520};