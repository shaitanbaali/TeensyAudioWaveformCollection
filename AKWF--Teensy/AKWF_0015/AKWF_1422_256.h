/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1422 256 samples */
 
const int16_t AKWF_1422_256_DATA [256] = 
{954, 2204, 2614, 2724, 3103, 4135, 5244, 5163, 4099, 4014, 5453, 6720, 6677, 5917, 5382, 5640, 6702, 7415, 6814, 5953, 6469, 7743, 7955, 7387, 7707, 8793, 9350, 9840, 11219, 12147, 11554, 11475, 13245, 14465, 13882, 14015, 15757, 16646, 16298, 17136, 19105, 19755, 19331, 19846, 20619, 20289, 20209, 21293, 21640, 20678, 20622, 21637, 21443, 20448, 20845, 21699, 21123, 20490, 21241, 21489, 20043, 19116, 19957, 20909, 20564, 18620, 15234, 12635, 13400, 15435, 15150, 14966, 17390, 14294, -600, -15365, -16816, -12595, -15529, -21599, -22902, -23349, -27166, -29832, -29998, -31610, -32736, -28787, -23264, -22200, -23490, -22292, -19706, -18646, -18063, -16876, -16414, -16246, -14553, -13066, -15488, -20400, -22893, -22264, -21484, -20863, -19301, -18068, -17524, -15536, -12798, -12691, -14576, -14734, -13027, -12009, -11779, -10945, -9968, -9461, -8522, -7410, -7633, -8684, -8515, -7099, -6098, -5899, -5424, -4310, -3312, -3073, -3750, -5265, -6743, -6580, -4675, -3429, -4218, -5051, -4357, -3426, -3357, -3655, -4138, -4401, -3031, -365, 1248, 1190, 963, 1421, 2180, 2432, 1558, 138, -222, 860, 1860, 1603, 672, 414, 1075, 1533, 1198, 592, 33, -45, 1404, 3527, 3788, 2511, 2513, 3866, 3952, 2253, 1129, 2001, 3487, 3627, 2427, 1514, 1706, 2002, 1359, 392, 410, 1454, 2266, 1889, 763, 340, 1240, 2307, 2352, 1623, 1187, 1734, 2555, 2044, 187, -915, -228, 690, 357, -639, -1277, -1421, -1066, -460, -701, -1910, -2180, -821, 75, -657, -1729, -1924, -1267, -679, -1106, -2068, -2226, -1461, -792, -1112, -2769, -4522, -4137, -2118, -1454, -2557, -3157, -2677, -1970, -1172, -992, -2256, -3260, -2179, -451, -239, -1243, -2123, -2274, -1579, -809, -1239, -2435, -2680, -1708, -742, -531, -919, -1232, -581};