/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1451 256 samples */
 
const int16_t AKWF_1451_256_DATA [256] = 
{1576, 3854, 5988, 8022, 9918, 11646, 13198, 14585, 15835, 16965, 18009, 19001, 19942, 20864, 21799, 22717, 23614, 24518, 25422, 26320, 27212, 28119, 28999, 29847, 30637, 31337, 31925, 32375, 32667, 32769, 32667, 32362, 31800, 30979, 29895, 28549, 26992, 25222, 23268, 21163, 18941, 16626, 14244, 11810, 9361, 6931, 4499, 2101, -261, -2591, -4893, -7163, -9409, -11626, -13800, -15926, -17990, -19974, -21853, -23606, -25195, -26599, -27806, -28795, -29553, -30072, -30350, -30407, -30261, -29929, -29425, -28777, -28011, -27146, -26217, -25237, -24245, -23259, -22283, -21348, -20460, -19607, -18762, -17933, -17068, -16178, -15238, -14216, -13121, -11940, -10667, -9319, -7904, -6427, -4910, -3364, -1810, -270, 1243, 2719, 4115, 5431, 6660, 7772, 8783, 9693, 10487, 11195, 11800, 12307, 12716, 13042, 13269, 13409, 13475, 13461, 13380, 13242, 13047, 12819, 12567, 12307, 12046, 11797, 11572, 11362, 11164, 10963, 10750, 10505, 10213, 9880, 9496, 9051, 8576, 8092, 7594, 7119, 6669, 6259, 5906, 5604, 5352, 5144, 4989, 4872, 4793, 4747, 4743, 4770, 4809, 4875, 4939, 5001, 5049, 5065, 5052, 5005, 4920, 4807, 4679, 4540, 4396, 4250, 4116, 3980, 3837, 3697, 3547, 3384, 3210, 3011, 2795, 2563, 2312, 2053, 1794, 1524, 1264, 1023, 788, 570, 376, 203, 52, -64, -156, -231, -288, -313, -331, -338, -333, -336, -349, -372, -424, -530, -660, -822, -1007, -1217, -1451, -1694, -1952, -2232, -2529, -2844, -3194, -3592, -4050, -4580, -5202, -5914, -6707, -7603, -8580, -9603, -10651, -11698, -12708, -13664, -14555, -15332, -16044, -16673, -17224, -17731, -18211, -18652, -19066, -19463, -19810, -20077, -20283, -20396, -20413, -20346, -20165, -19891, -19549, -19109, -18615, -18044, -17405, -16677, -15801, -14787, -13643, -12298, -10759, -9038, -7129, -5065, -2900, -621};