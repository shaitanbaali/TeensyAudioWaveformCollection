/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1405 256 samples */
 
const int16_t AKWF_1405_256_DATA [256] = 
{665, 1531, 2270, 2932, 3528, 4072, 4569, 5023, 5443, 5829, 6185, 6515, 6819, 7098, 7356, 7592, 7807, 8004, 8182, 8341, 8482, 8606, 8714, 8804, 8878, 8937, 8977, 9011, 8999, 8366, 8091, 7976, 7872, 7788, 7717, 7653, 7597, 7545, 7499, 7455, 7415, 7378, 7343, 7311, 7279, 7251, 7224, 7198, 7175, 7152, 7130, 7111, 7092, 7074, 7058, 7042, 7028, 7014, 7002, 6991, 6981, 6971, 6962, 6955, 6948, 6943, 6938, 7087, 6294, 10616, 18293, 19877, 21483, 22692, 23696, 24565, 25332, 26016, 26637, 27203, 27720, 28198, 28639, 29046, 29425, 29776, 30101, 30404, 30684, 30942, 31181, 31401, 31602, 31787, 31953, 32104, 32239, 32357, 32460, 32548, 32621, 32679, 32723, 32642, 33218, 30789, 18806, 15360, 13086, 11256, 9729, 8400, 7218, 6143, 5155, 4238, 3379, 2570, 1806, 1077, 381, -283, -923, -1538, -2132, -2706, -3262, -3801, -4325, -4834, -5330, -5813, -6284, -6744, -7193, -7632, -8062, -8483, -8895, -9299, -9696, -10083, -10465, -10840, -11208, -11570, -11925, -12272, -12617, -12955, -13287, -13615, -13937, -14254, -14566, -14873, -15177, -15384, -15557, -15738, -15919, -16097, -16274, -16449, -16622, -16792, -16959, -17122, -17283, -17441, -17595, -17747, -17895, -18039, -18182, -18320, -18454, -18586, -18714, -18839, -18962, -19080, -19194, -19306, -19414, -19519, -19621, -19719, -19814, -19906, -19994, -20078, -20159, -20238, -20312, -20382, -20450, -20514, -20575, -20632, -20685, -20736, -20782, -20825, -20864, -20900, -20933, -20961, -20986, -21007, -21026, -21040, -21049, -21056, -20804, -22155, -10556, 114, 2416, 4797, 6370, 7434, 8159, 8252, 4211, 2562, 1959, 1540, 1141, 1998, 3619, 3926, 4217, 4351, 4647, 3985, -4317, -7390, -8859, -10103, -11080, -11889, -12568, -13140, -13624, -14028, -14359, -14625, -14827, -14872, -15467, -13145, -5066, -3056, -1519, -313};