/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1459 256 samples */
 
const int16_t AKWF_1459_256_DATA [256] = 
{32768, 32768, 32767, 32768, 32766, 32764, 32761, 32758, 32754, 32749, 32745, 32739, 32733, 32729, 32723, 32715, 32258, 34784, 23354, -9586, -7386, -7765, -7777, -7780, -7783, -7786, -7788, -7790, -7792, -7794, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7794, -7793, -7790, -7791, -7789, -7787, -7787, -7785, -7783, -7782, -7781, -7779, -7777, -7776, -7775, -7773, -7772, -7769, -7768, -7765, -7764, -7763, -7761, -7758, -7758, -7756, -7233, -10130, 21385, 35101, 32175, 32701, 32699, 32697, 32694, 32691, 32687, 32683, 32678, 32673, 32667, 32661, 32655, 32649, 32643, 32637, 32630, 32622, 32616, 32608, 32601, 32593, 32585, 32578, 32570, 32562, 32322, 33488, 28392, -6262, -8403, -7788, -7939, -7942, -7946, -7951, -7953, -7956, -7957, -7960, -7961, -7961, -7963, -7962, -7962, -7962, -7962, -7963, -7961, -7960, -7961, -7958, -7957, -7956, -7956, -7954, -7952, -7951, -7951, -7948, -7947, -7945, -7943, -7942, -7940, -7938, -7936, -7934, -7933, -7931, -7929, -7926, -7925, -7923, -7921, -7919, -7917, -7915, -7913, -7911, -7908, -7907, -7905, -7903, -7901, -7899, -7897, -7895, -7891, -7890, -7888, -7885, -7884, -7882, -7880, -7878, -7875, -7872, -7871, -7869, -7867, -7865, -7863, -7860, -7859, -7857, -7854, -7853, -7851, -7848, -7846, -7844, -7841, -7840, -7838, -7836, -7834, -7831, -7829, -7827, -7824, -7823, -7821, -7818, -7817, -7815, -7813, -7810, -7808, -7805, -7804, -7802, -7800, -7798, -7796, -7794, -7792, -7790, -7787, -7786, -7784, -7781, -7779, -7777, -7775, -7773, -7771, -7769, -7767, -7765, -7763, -7760, -7758, -7756, -7754, -7751, -7750, -7748, -7746, -7743, -7741, -7739, -7737, -7735, -7733, -7731, -7729, -7727, -7725, -7723, -7722, -7719, -7716, -7714, -7712, -7710, -7708, -7706, -7704, -7702, -7700, -7698, -7696, -7694, -7692, -7690, -7688, -7685, -7683};