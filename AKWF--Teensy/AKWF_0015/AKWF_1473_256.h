/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1473 256 samples */
 
const int16_t AKWF_1473_256_DATA [256] = 
{354, 900, 1428, 1954, 2489, 3020, 3543, 4068, 4590, 5110, 5626, 6144, 6659, 7167, 7669, 8178, 8678, 9172, 9671, 10160, 10645, 11123, 11595, 12064, 12527, 12982, 13430, 13872, 14307, 14734, 15148, 15558, 15958, 16349, 16735, 17108, 17473, 17830, 18179, 18520, 18845, 19164, 19475, 19776, 20068, 20352, 20618, 20884, 21133, 21376, 21608, 21825, 22033, 22229, 22420, 22597, 22756, 22906, 23049, 23180, 23296, 23400, 23489, 23566, 23636, 23689, 23730, 23762, 23780, 23785, 23769, 23747, 23727, 23697, 23645, 23581, 23507, 23425, 23329, 23220, 23101, 22973, 22829, 22678, 22515, 22335, 22148, 21942, 21725, 21501, 21257, 21006, 20745, 20467, 20176, 19878, 19568, 19243, 18904, 18552, 18186, 17808, 17413, 17004, 16582, 16147, 15706, 15246, 14775, 14297, 13808, 13314, 12812, 12301, 11787, 11275, 10759, 10254, 9750, 9245, 8746, 8262, 7782, 7318, 6866, 6427, 6008, 5603, 5212, 4841, 4493, 4161, 3850, 3562, 3295, 3052, 2832, 2633, 2449, 2292, 2149, 2023, 1902, 1779, 1657, 1555, 1483, 1454, 1478, 1557, 1694, 1942, 2526, -11783, -18090, -17589, -18395, -19275, -20449, -21905, -23569, -25324, -27068, -28712, -30124, -31228, -31999, -32482, -32720, -32767, -32664, -32489, -32311, -32175, -32082, -32004, -31937, -31866, -31796, -31710, -31601, -31461, -31292, -31105, -30912, -30702, -30478, -30243, -30000, -29748, -29479, -29210, -28926, -28638, -28337, -28033, -27719, -27395, -27063, -26724, -26378, -26029, -25675, -25306, -24934, -24554, -24166, -23774, -23377, -22971, -22563, -22142, -21716, -21287, -20857, -20414, -19971, -19523, -19068, -18611, -18150, -17685, -17215, -16740, -16261, -15785, -15300, -14811, -14322, -13826, -13328, -12832, -12332, -11829, -11315, -10804, -10288, -9773, -9254, -8725, -8195, -7667, -7141, -6606, -6074, -5537, -5002, -4464, -3932, -3395, -2856, -2319, -1780, -1243, -712, -166};