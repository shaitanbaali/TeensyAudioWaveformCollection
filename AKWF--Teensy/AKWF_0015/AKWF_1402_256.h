/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1402 256 samples */
 
const int16_t AKWF_1402_256_DATA [256] = 
{289, 1066, 1796, 2501, 3177, 3827, 4450, 5045, 5614, 6157, 6672, 7162, 7625, 8061, 8471, 8854, 9209, 9539, 9841, 10116, 10365, 10586, 10780, 10948, 11088, 11201, 11286, 11345, 11376, 11382, 11398, 11411, 11421, 11431, 11439, 11447, 11455, 11462, 11469, 11475, 11481, 11487, 11493, 11498, 11503, 11508, 11513, 11518, 11522, 11526, 11531, 11535, 11539, 11543, 11546, 11550, 11554, 11557, 11560, 11564, 11567, 11570, 11573, 11575, 11578, 11581, 11584, 11586, 11589, 11591, 11593, 11595, 11597, 11599, 11601, 11603, 11605, 11606, 11608, 11610, 11611, 11612, 11613, 11615, 11615, 11616, 11618, 11618, 11619, 11620, 11620, 11621, 11621, 11621, 11621, 11623, 11623, 11623, 11623, 11623, 11622, 11621, 11621, 11621, 11620, 11620, 11619, 11619, 11618, 11616, 11616, 11615, 11614, 11612, 11611, 11610, 11609, 11607, 11605, 11603, 11602, 11599, 11598, 11596, 11594, 11592, 11589, 11587, 11584, 11582, 11579, 11576, 11573, 11571, 11570, 11542, 11709, 10696, 9426, 8483, 7600, 6784, 6013, 5281, 4584, 3912, 3265, 2642, 2037, 1452, 886, 334, -200, -718, -1225, -1716, -2194, -2659, -3112, -3551, -3979, -4395, -4799, -5191, -5573, -5943, -6303, -6651, -6988, -7317, -7634, -7941, -8238, -8525, -8803, -9070, -9328, -9577, -9816, -10045, -10265, -10493, -10715, -10923, -11121, -11306, -11480, -11642, -11793, -11933, -12062, -12179, -12285, -12382, -12467, -12542, -12606, -12660, -12704, -12739, -12802, -12708, -12915, -30302, -33162, -32248, -32189, -31963, -31703, -31403, -31060, -30670, -30225, -29724, -29161, -28533, -27834, -27066, -26218, -25322, -24452, -23620, -22827, -22071, -21350, -20669, -20024, -19414, -18844, -18310, -17814, -17355, -16933, -16548, -16202, -15894, -15623, -15390, -15195, -15038, -14920, -14816, -14877, -14265, -12205, -10702, -9385, -8172, -7041, -5977, -4961, -3994, -3068, -2178, -1324, -487};