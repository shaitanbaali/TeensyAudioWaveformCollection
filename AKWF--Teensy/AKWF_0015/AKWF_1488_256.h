/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1488 256 samples */
 
const int16_t AKWF_1488_256_DATA [256] = 
{6110, 14402, 18036, 20270, 21990, 23245, 24261, 25237, 26314, 27499, 28723, 29872, 30869, 31659, 32229, 32593, 32758, 32730, 32503, 32090, 31513, 30797, 29971, 29068, 28161, 27357, 26727, 26233, 25671, 24726, 23248, 20629, 16014, 11543, 8064, 5061, 2210, -760, -5127, -9485, -12742, -14682, -15721, -16771, -17928, -19113, -20422, -21569, -22375, -22817, -22933, -22832, -22626, -22413, -22107, -21866, -21702, -21260, -20317, -18778, -16787, -14656, -12734, -11209, -9988, -8753, -7517, -6532, -5586, -4776, -4042, -3305, -2502, -1648, -854, -267, 60, 218, 421, 796, 1904, 3981, 6115, 8008, 9450, 9871, 9472, 8379, 6695, 4868, 3375, 2479, 2131, 1928, 1328, -129, -1867, -3530, -5309, -7164, -9168, -11651, -14957, -18379, -20403, -21103, -21264, -21060, -20617, -20427, -20952, -21478, -21822, -22044, -22072, -21908, -21553, -21079, -20619, -20178, -19731, -19142, -17916, -15990, -13657, -10901, -7111, -2333, 2332, 7110, 10900, 13656, 15989, 17915, 19141, 19731, 20178, 20619, 21078, 21553, 21908, 22072, 22044, 21821, 21478, 20951, 20426, 20616, 21060, 21263, 21103, 20403, 18379, 14957, 11650, 9168, 7163, 5309, 3529, 1866, 128, -1329, -1929, -2132, -2480, -3376, -4869, -6696, -8380, -9473, -9872, -9451, -8009, -6116, -3982, -1905, -797, -422, -219, -61, 266, 853, 1647, 2501, 3304, 4041, 4775, 5585, 6531, 7517, 8752, 9987, 11208, 12733, 14655, 16786, 18777, 20317, 21260, 21702, 21866, 22107, 22413, 22626, 22832, 22933, 22817, 22375, 21569, 20422, 19113, 17927, 16771, 15720, 14682, 12741, 9484, 5126, 759, -2211, -5062, -8065, -11544, -16014, -20629, -23249, -24727, -25671, -26233, -26727, -27357, -28161, -29068, -29971, -30797, -31513, -32090, -32503, -32730, -32758, -32593, -32229, -31659, -30869, -29872, -28723, -27499, -26314, -25237, -24262, -23245, -21990, -20270, -18036, -14402, -6111};