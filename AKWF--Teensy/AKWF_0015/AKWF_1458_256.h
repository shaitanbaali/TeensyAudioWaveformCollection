/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1458 256 samples */
 
const int16_t AKWF_1458_256_DATA [256] = 
{13946, 13953, 13960, 13964, 13968, 13971, 13974, 13976, 13979, 13979, 13979, 13979, 13979, 13979, 13979, 13978, 13976, 13976, 13973, 13972, 13969, 13967, 13965, 13963, 13961, 13958, 13955, 13952, 13950, 13947, 13943, 13940, 13936, 13934, 13931, 13927, 13924, 13920, 13917, 13913, 13910, 13906, 13903, 13900, 13897, 13893, 13888, 13884, 13881, 13877, 13874, 13870, 13867, 13863, 13860, 13856, 13851, 13848, 13844, 13841, 13838, 13834, 13830, 13826, 13823, 13819, 13816, 13814, 13803, 13770, 13804, 13796, 13793, 13790, 13785, 13781, 13778, 13775, 13771, 13768, 13764, 13761, 13756, 13752, 13749, 13745, 13742, 13738, 12894, 17385, -11246, -36875, -29558, 10661, 14550, 13512, 13717, 13716, 13714, 13711, 13709, 13707, 13703, 13246, 15803, 4511, -34206, -32411, -32681, -32206, -34992, -22533, 15601, 13309, 13687, 13699, 13699, 13699, 13699, 13699, 13696, 13696, 13693, 13692, 13690, 13687, 13686, 13684, 13681, 13679, 13675, 13673, 13670, 13668, 13664, 13661, 13659, 13656, 13652, 13649, 13645, 13642, 13638, 12784, 17329, -9887, -36451, -31920, -32767, -32768, -32767, -32765, -32763, -32760, -32756, -32752, -32747, -32742, -32736, -32732, -32724, -32720, -32714, -32707, -32700, -32693, -32686, -32679, -32672, -32663, -32655, -32648, -32642, -32633, -31900, -35846, -16040, 17162, 13038, 13803, 13808, 13812, 13814, 13816, 13818, 13820, 13820, 13820, 13820, 13820, 13820, 13820, 13818, 13817, 13816, 13813, 13811, 13810, 13807, 13805, 13803, 13800, 13797, 13795, 13791, 13789, 13785, 13782, 13780, 13777, 13774, 13770, 13767, 13765, 13761, 13758, 13754, 13090, 16730, -18497, -35574, -32007, -32652, -32653, -32651, -32648, -32646, -32644, -32641, -32636, -32631, -32626, -32622, -32615, -32609, -32604, -32597, -32590, -32584, -32577, -32570, -32563, -32556, -32549, -32539, -32532, -32525, -32517, -32508, -32502, -32493, -32485, -32476, -32467, -32461, -32452};