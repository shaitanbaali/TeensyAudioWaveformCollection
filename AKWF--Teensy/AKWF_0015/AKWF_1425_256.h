/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1425 256 samples */
 
const int16_t AKWF_1425_256_DATA [256] = 
{2716, 5902, 8068, 12607, 15410, 16510, 17653, 18978, 20102, 21721, 24542, 27841, 30224, 31326, 31873, 32410, 32755, 32655, 32319, 32113, 32095, 32092, 32037, 32023, 32077, 32084, 31934, 31646, 31234, 31119, 28678, 24832, 23440, 20288, 17897, 17171, 16858, 16440, 16208, 15834, 14607, 12695, 11062, 10226, 9821, 9356, 8853, 8564, 8474, 8340, 8071, 7809, 7468, 7203, 7020, 6812, 6820, 7054, 7384, 7757, 8180, 8602, 8936, 9149, 9277, 9335, 9292, 9131, 8876, 8572, 8250, 7924, 7617, 7360, 7172, 7078, 6995, 5908, 5497, 5078, 4369, 4138, 4198, 4192, 4136, 4062, 3778, 3180, 2486, 1983, 1693, 1463, 1220, 1031, 946, 910, 856, 806, 717, 472, 409, 272, 149, 175, 272, 369, 473, 579, 630, 601, 538, 489, 447, 375, 268, 152, 44, -62, -170, -265, -335, -380, -380, -493, -673, -676, -781, -843, -804, -752, -724, -708, -721, -808, -952, -1095, -1194, -1271, -1348, -1423, -1477, -1508, -1533, -1568, -1520, -1852, -2946, -3234, -3965, -4687, -4926, -5009, -5162, -5306, -5476, -5874, -6514, -7131, -7514, -7718, -7904, -8091, -8208, -8240, -8260, -8308, -8365, -8397, -8412, -8430, -8426, -8456, -8590, -8554, -8581, -8604, -8536, -8447, -8396, -8376, -8391, -8478, -8638, -8820, -8975, -9103, -9224, -9337, -9423, -9470, -9507, -9493, -9527, -13065, -14857, -16530, -19409, -20802, -21160, -21646, -22238, -22766, -23820, -25805, -28056, -29633, -30422, -30948, -31502, -31894, -31965, -31891, -31901, -31994, -32041, -32023, -32008, -32007, -31937, -31674, -31726, -29452, -23794, -22008, -17842, -13999, -12573, -11906, -10998, -10271, -9492, -7656, -4762, -2127, -706, -111, 431, 1019, 1301, 1249, 1212, 1390, 1648, 1823, 1945, 2094, 2203, 2137, 1865, 1458, 973, 419, -177, -746, -1205, -1517};