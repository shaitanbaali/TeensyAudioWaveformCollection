/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1439 256 samples */
 
const int16_t AKWF_1439_256_DATA [256] = 
{606, 1611, 2600, 3599, 4613, 5642, 6668, 7705, 8749, 9784, 10819, 11868, 12900, 13923, 14944, 15963, 16958, 17940, 18920, 19873, 20802, 21717, 22616, 23480, 24316, 25132, 25919, 26667, 27383, 28074, 28720, 29328, 29904, 30439, 30931, 31378, 31788, 32147, 32475, 32710, 32755, 32765, 32741, 32679, 32585, 32456, 32292, 32096, 31873, 31618, 31332, 31024, 30686, 30322, 29938, 29533, 29104, 28650, 28188, 27708, 27205, 26692, 26169, 25633, 25078, 24526, 23964, 23387, 22811, 22232, 21647, 21055, 20468, 19882, 19289, 18698, 18115, 17533, 16945, 16371, 15802, 15232, 14665, 14112, 13561, 13010, 12471, 11939, 11404, 10888, 10375, 9864, 9360, 8868, 8379, 7890, 7412, 6942, 6472, 6004, 5548, 5094, 4638, 4188, 3746, 3304, 2859, 2422, 1987, 1552, 1114, 684, 254, -181, -612, -1040, -1475, -1910, -2340, -2771, -3205, -3641, -4074, -4504, -4942, -5377, -5807, -6240, -6679, -7108, -7536, -7968, -8395, -8817, -9239, -9662, -10075, -10484, -10893, -11298, -11691, -12085, -12469, -12845, -13212, -13578, -13931, -14273, -14611, -14940, -15251, -15556, -15855, -16137, -16410, -16673, -16922, -17158, -17384, -17598, -17799, -17987, -18165, -18330, -18482, -18621, -18751, -18869, -18975, -19072, -19157, -19232, -19299, -19357, -19405, -19446, -19478, -19506, -19525, -19538, -19549, -19555, -19555, -19555, -19554, -19548, -19543, -19539, -19534, -19529, -19527, -19527, -19530, -19538, -19548, -19563, -19581, -19605, -19637, -19673, -19713, -19760, -19813, -19872, -19936, -20006, -20083, -20157, -20236, -20341, -20373, -20335, -20300, -20253, -20194, -20124, -20046, -19952, -19845, -19722, -19583, -19429, -19255, -19066, -18857, -18623, -18372, -18101, -17806, -17484, -17142, -16777, -16383, -15964, -15525, -15056, -14554, -14035, -13489, -12908, -12302, -11679, -11022, -10333, -9628, -8895, -8136, -7347, -6543, -5715, -4855, -3981, -3091, -2175, -1240, -277};