/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1411 256 samples */
 
const int16_t AKWF_1411_256_DATA [256] = 
{133, 405, 672, 942, 1211, 1480, 1750, 2019, 2289, 2558, 2826, 3095, 3365, 3632, 3901, 4168, 4435, 4703, 4971, 5238, 5505, 5772, 6037, 6305, 6570, 6834, 7100, 7364, 7627, 7891, 8154, 8416, 8680, 8941, 9203, 9463, 9723, 9984, 10242, 10499, 10758, 11015, 11272, 11528, 11783, 12038, 12292, 12545, 12798, 13049, 13301, 13551, 13801, 14050, 14298, 14544, 14791, 15036, 15281, 15524, 15767, 16009, 16251, 16490, 16730, 16968, 17204, 17441, 17675, 17910, 18143, 18375, 18606, 18836, 19064, 19292, 19519, 19744, 19969, 20192, 20414, 20635, 20854, 21073, 21290, 21506, 21722, 21934, 22147, 22358, 22567, 22775, 22982, 23188, 23392, 23595, 23796, 23996, 24195, 24392, 24588, 24783, 24976, 25167, 25359, 25547, 25733, 25920, 26104, 26286, 26468, 26647, 26825, 27002, 27176, 27350, 27521, 27691, 27859, 28026, 28191, 28355, 28517, 28677, 28835, 28315, 31950, 14205, -31316, -30344, -26258, -23195, -18170, -17295, -20298, -23807, -26168, -27325, -27661, -27547, -27245, -26920, -26645, -26448, -26314, -26213, -26107, -25977, -25817, -25628, -25419, -25198, -24972, -24748, -24530, -24319, -24112, -23910, -23712, -23515, -23320, -23126, -22931, -22736, -22540, -22343, -22143, -21940, -21736, -21528, -21321, -21109, -20895, -20682, -20466, -20249, -20029, -19809, -19587, -19364, -19140, -18916, -18692, -18465, -18237, -18009, -17780, -17552, -17320, -17088, -16854, -16619, -16382, -16146, -15907, -15669, -15430, -15189, -14947, -14705, -14462, -14217, -13973, -13726, -13479, -13232, -12983, -12734, -12484, -12233, -11982, -11730, -11476, -11222, -10969, -10713, -10458, -10202, -9944, -9687, -9429, -9170, -8910, -8650, -8390, -8130, -7867, -7604, -7343, -7081, -6816, -6553, -6288, -6023, -5759, -5494, -5228, -4962, -4694, -4429, -4162, -3895, -3626, -3359, -3091, -2822, -2554, -2285, -2016, -1748, -1480, -1210, -940, -671, -403, -129};