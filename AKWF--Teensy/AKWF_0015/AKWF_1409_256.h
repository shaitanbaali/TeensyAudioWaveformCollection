/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1409 256 samples */
 
const int16_t AKWF_1409_256_DATA [256] = 
{8986, 18099, 22062, 22654, 22329, 22869, 24513, 26688, 28788, 30458, 31592, 32256, 32578, 32690, 32705, 32692, 32688, 32702, 32727, 32750, 32766, 32767, 32754, 32734, 32707, 32681, 32658, 32640, 32626, 32621, 32617, 32615, 32618, 32620, 32623, 32626, 32631, 32636, 32639, 32642, 32645, 32644, 32645, 32644, 32645, 32649, 32645, 32644, 32645, 32644, 32645, 32644, 32641, 32640, 32641, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32640, 32615, 32562, 32836, 23692, 5107, -9330, -17996, -22032, -22651, -22325, -22865, -24509, -26684, -28785, -30453, -31587, -32252, -32574, -32684, -32700, -32688, -32684, -32698, -32723, -32746, -32762, -32761, -32749, -32729, -32703, -32676, -32652, -32635, -32622, -32615, -32612, -32611, -32612, -32616, -32619, -32622, -32627, -32632, -32635, -32637, -32640, -32641, -32641, -32640, -32643, -32645, -32644, -32645, -32641, -32640, -32641, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32640, -32615, -32562, -32861, -23715, -4980};