/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1430 256 samples */
 
const int16_t AKWF_1430_256_DATA [256] = 
{4192, 11828, 18025, 19977, 19242, 17633, 15357, 13106, 12431, 13527, 14531, 13680, 11054, 7751, 4269, 455, -3566, -7199, -9940, -11803, -12996, -13544, -13414, -12758, -11855, -10879, -9831, -8686, -7469, -6181, -4779, -3186, -1394, 532, 2516, 4470, 6268, 7769, 8831, 9342, 9239, 8490, 7110, 5155, 2730, -22, -2960, -5929, -8768, -11358, -13581, -15358, -16653, -17439, -17734, -17573, -17010, -16107, -14933, -13559, -12050, -10461, -8846, -7241, -5678, -4180, -2758, -1419, -172, 989, 2065, 3053, 3958, 4785, 5527, 6189, 6768, 7256, 7653, 7952, 8148, 8237, 8217, 8083, 7837, 7482, 7025, 6470, 5827, 5114, 4340, 3525, 2689, 1842, 1006, 203, -561, -1262, -1893, -2449, -2915, -3289, -3568, -3751, -3840, -3839, -3748, -3575, -3325, -3005, -2622, -2180, -1690, -1157, -587, 10, 631, 1266, 1908, 2550, 3187, 3809, 4412, 4987, 5525, 6026, 6479, 6880, 7226, 7510, 7732, 7884, 7969, 7983, 7929, 7803, 7611, 7353, 7031, 6650, 6213, 5725, 5189, 4613, 4000, 3355, 2685, 1997, 1293, 581, -134, -849, -1560, -2256, -2940, -3602, -4242, -4853, -5434, -5980, -6490, -6959, -7388, -7775, -8115, -8409, -8656, -8856, -9005, -9109, -9164, -9171, -9132, -9047, -8919, -8747, -8536, -8283, -7994, -7670, -7310, -6921, -6504, -6062, -5595, -5109, -4605, -4089, -3562, -3025, -2489, -1950, -1415, -889, -376, 120, 595, 1045, 1462, 1845, 2186, 2481, 2724, 2912, 3042, 3103, 3095, 3011, 2849, 2602, 2270, 1850, 1334, 725, 25, -775, -1669, -2653, -3731, -4896, -6141, -7469, -8866, -10323, -11839, -13396, -14985, -16598, -18216, -19826, -21418, -22969, -24467, -25895, -27230, -28465, -29577, -30545, -31361, -32003, -32458, -32714, -32756, -32574, -32155, -31495, -30589, -29431, -28019, -26360, -24447, -22294, -19828, -17654, -11929, -1690};