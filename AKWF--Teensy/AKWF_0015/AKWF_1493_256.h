/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1493 256 samples */
 
const int16_t AKWF_1493_256_DATA [256] = 
{857, 2456, 3834, 5106, 6366, 7715, 9216, 10867, 12619, 14372, 16016, 17479, 18720, 19739, 20577, 21283, 21910, 22512, 23127, 23780, 24494, 25271, 26111, 27006, 27933, 28862, 29755, 30559, 31219, 31685, 31919, 31913, 31696, 31338, 30934, 30580, 30344, 30245, 30245, 30268, 30218, 30011, 29590, 28934, 28067, 27040, 25914, 24753, 23613, 22533, 21545, 20671, 19913, 19278, 18760, 18343, 18002, 17702, 17392, 17014, 16506, 15814, 14916, 13827, 12600, 11333, 10124, 9053, 8162, 7419, 6735, 6009, 5144, 4094, 2873, 1533, 167, -1125, -2283, -3261, -4038, -4617, -5000, -5202, -5233, -5099, -4800, -4330, -3680, -2845, -1818, -615, 736, 2189, 3667, 5091, 6384, 7484, 8380, 9110, 9750, 10405, 11165, 12078, 13145, 14318, 15514, 16655, 17661, 18477, 19075, 19448, 19604, 19561, 19338, 18953, 18411, 17717, 16867, 15842, 14632, 13225, 11612, 9814, 7867, 5829, 3793, 1844, 52, -1540, -2958, -4278, -5601, -7030, -8619, -10352, -12169, -13971, -15655, -17156, -18434, -19490, -20368, -21119, -21798, -22459, -23139, -23862, -24653, -25511, -26436, -27416, -28427, -29433, -30398, -31262, -31969, -32470, -32731, -32754, -32577, -32271, -31932, -31649, -31485, -31454, -31515, -31587, -31569, -31376, -30957, -30303, -29445, -28438, -27340, -26213, -25109, -24063, -23106, -22254, -21513, -20886, -20368, -19939, -19576, -19242, -18889, -18457, -17890, -17135, -16172, -15018, -13733, -12418, -11177, -10085, -9170, -8388, -7647, -6852, -5908, -4778, -3479, -2068, -632, 736, 1974, 3032, 3888, 4546, 5011, 5295, 5411, 5368, 5164, 4793, 4247, 3519, 2597, 1494, 230, -1150, -2571, -3949, -5206, -6273, -7139, -7835, -8434, -9036, -9730, -10571, -11574, -12700, -13866, -14990, -15990, -16804, -17403, -17779, -17942, -17911, -17707, -17344, -16834, -16178, -15374, -14407, -13264, -11930, -10393, -8667, -6783, -4800, -2805, -858};