/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1469 256 samples */
 
const int16_t AKWF_1469_256_DATA [256] = 
{12548, 18639, 28240, 31302, 32669, 32628, 31811, 30595, 29147, 27637, 26138, 24694, 23335, 22076, 20914, 19850, 18883, 18000, 17196, 16467, 15801, 15195, 14642, 14135, 13669, 13242, 12846, 12481, 12144, 11829, 11534, 11258, 10998, 10753, 10521, 10299, 10089, 9887, 9693, 9509, 9328, 9154, 8985, 8821, 8662, 8505, 8352, 8201, 8053, 7907, 7764, 7623, 7483, 7345, 7209, 7072, 6937, 6804, 6672, 6541, 6411, 6280, 6151, 6022, 5895, 5767, 5640, 5514, 5388, 5262, 5137, 5012, 4888, 4764, 4640, 4516, 4393, 4270, 4148, 4026, 3905, 3783, 3661, 3541, 3420, 3298, 3178, 3057, 2939, 2819, 2700, 2582, 2463, 2344, 2225, 2108, 1990, 1873, 1756, 1637, 1520, 1405, 1288, 1172, 1056, 940, 825, 709, 594, 480, 365, 250, 136, 23, -90, -203, -316, -431, -542, -655, -767, -879, -991, -1103, -1214, -1325, -1436, -1546, -1657, -1767, -1877, -1988, -2097, -2208, -2316, -2425, -2534, -2643, -2751, -2859, -2968, -3075, -3183, -3290, -3398, -3505, -3611, -3719, -3825, -3930, -4036, -4142, -4247, -4352, -4458, -4562, -4667, -4772, -4876, -4980, -5084, -5187, -5291, -5394, -5497, -5600, -5702, -5805, -5907, -6009, -6111, -6213, -6315, -6416, -6517, -6618, -6719, -6819, -6919, -7020, -7120, -7219, -7318, -7418, -7516, -7615, -7714, -7813, -7911, -8009, -8107, -8204, -8302, -8400, -8497, -8594, -8690, -8788, -8884, -8980, -9076, -9172, -9268, -9363, -9458, -9553, -9648, -9743, -9837, -9932, -10026, -10120, -10214, -10308, -10401, -10493, -10588, -10680, -10772, -10865, -10958, -11049, -11143, -11234, -11325, -11416, -11508, -11599, -11690, -11781, -11871, -11961, -12051, -12142, -12233, -12322, -12410, -12500, -12589, -12678, -12767, -12856, -12945, -13033, -13120, -13209, -13296, -13385, -13470, -13554, -13649, -13731, -13816, -13775, -14582, -11368};