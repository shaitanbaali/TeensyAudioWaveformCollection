/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1410 256 samples */
 
const int16_t AKWF_1410_256_DATA [256] = 
{249, 765, 1269, 1776, 2284, 2789, 3295, 3797, 4300, 4799, 5293, 5788, 6280, 6767, 7252, 7732, 8207, 8683, 9153, 9616, 10076, 10530, 10981, 11425, 11865, 12298, 12727, 13149, 13563, 13975, 14378, 14774, 15166, 15548, 15926, 16298, 16662, 17018, 17368, 17710, 18047, 18377, 18699, 19014, 19322, 19622, 19916, 20203, 20482, 20756, 21022, 21280, 21533, 21779, 22016, 22248, 22474, 22690, 22903, 23109, 23309, 23502, 23690, 23871, 24047, 24215, 24378, 24537, 24689, 24836, 24979, 25115, 25246, 25372, 25493, 25611, 25724, 25831, 25934, 26032, 26125, 26215, 26302, 26384, 26463, 26536, 26609, 26675, 26738, 26799, 26857, 26910, 26961, 27010, 27055, 27097, 27138, 27174, 27211, 27243, 27273, 27300, 27326, 27351, 27371, 27391, 27409, 27426, 27441, 27453, 27466, 27476, 27486, 27493, 27499, 27505, 27510, 27515, 27519, 27520, 27522, 27523, 27524, 27524, 27526, 26884, 30170, 13289, -31017, -29185, -25143, -22501, -17792, -17018, -20015, -23585, -26107, -27470, -28009, -28072, -27915, -27710, -27545, -27455, -27437, -27458, -27490, -27511, -27508, -27480, -27437, -27381, -27323, -27268, -27215, -27167, -27124, -27082, -27044, -27003, -26961, -26918, -26873, -26824, -26770, -26713, -26651, -26585, -26517, -26445, -26368, -26288, -26202, -26113, -26022, -25925, -25826, -25721, -25612, -25499, -25381, -25260, -25134, -25004, -24869, -24727, -24583, -24432, -24278, -24117, -23951, -23779, -23603, -23421, -23232, -23038, -22838, -22631, -22420, -22202, -21976, -21747, -21511, -21266, -21016, -20760, -20499, -20229, -19953, -19670, -19379, -19084, -18779, -18471, -18155, -17832, -17500, -17164, -16820, -16469, -16113, -15748, -15378, -15002, -14616, -14227, -13831, -13428, -13020, -12604, -12183, -11756, -11324, -10886, -10444, -9995, -9543, -9085, -8623, -8155, -7684, -7207, -6728, -6246, -5759, -5268, -4778, -4282, -3783, -3284, -2781, -2278, -1774, -1267, -762, -245};