/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1496 256 samples */
 
const int16_t AKWF_1496_256_DATA [256] = 
{326, 1354, 2324, 3252, 4138, 4982, 5791, 6569, 7326, 8070, 8804, 9538, 10273, 11007, 11744, 12480, 13208, 13930, 14640, 15334, 16014, 16677, 17324, 17957, 18576, 19179, 19772, 20350, 20915, 21468, 22007, 22533, 23048, 23550, 24041, 24522, 24992, 25449, 25894, 26323, 26732, 27120, 27481, 27818, 28129, 28416, 28684, 28939, 29188, 29437, 29694, 29962, 30247, 30546, 30857, 31175, 31490, 31791, 32066, 32306, 32500, 32644, 32733, 32768, 32750, 32686, 32580, 32437, 32264, 32066, 31845, 31603, 31338, 31048, 30728, 30372, 29969, 29514, 28997, 28409, 27748, 27000, 26168, 25252, 24249, 23171, 22031, 20837, 19608, 18358, 17095, 15836, 14589, 13360, 12160, 10995, 9869, 8791, 7767, 6798, 5891, 5047, 4266, 3546, 2881, 2265, 1689, 1145, 623, 116, -386, -888, -1393, -1907, -2427, -2950, -3477, -3999, -4510, -5005, -5476, -5912, -6309, -6658, -6953, -7189, -7363, -7477, -7532, -7535, -7494, -7421, -7328, -7230, -7141, -7076, -7052, -7084, -7180, -7356, -7613, -7957, -8383, -8887, -9456, -10081, -10749, -11443, -12155, -12872, -13589, -14300, -15000, -15685, -16358, -17012, -17652, -18277, -18881, -19468, -20035, -20577, -21090, -21571, -22008, -22396, -22725, -22983, -23163, -23257, -23264, -23179, -23005, -22753, -22430, -22049, -21626, -21174, -20711, -20253, -19813, -19402, -19036, -18720, -18460, -18261, -18119, -18036, -18005, -18018, -18069, -18148, -18247, -18356, -18467, -18574, -18669, -18749, -18811, -18854, -18877, -18884, -18881, -18872, -18867, -18871, -18893, -18942, -19025, -19143, -19302, -19502, -19741, -20016, -20320, -20648, -20992, -21343, -21694, -22037, -22362, -22662, -22925, -23139, -23296, -23383, -23391, -23310, -23136, -22864, -22497, -22031, -21465, -20822, -20120, -19368, -18577, -17759, -16921, -16068, -15209, -14343, -13472, -12597, -11710, -10811, -9899, -8962, -8001, -7016, -5999, -4959, -3903, -2834, -1765, -686};