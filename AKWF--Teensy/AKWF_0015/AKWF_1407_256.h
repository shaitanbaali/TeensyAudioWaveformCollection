/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1407 256 samples */
 
const int16_t AKWF_1407_256_DATA [256] = 
{1248, 3509, 5684, 7799, 9830, 11763, 13590, 15288, 16868, 18329, 19665, 20888, 22007, 23020, 23940, 24776, 25529, 26213, 26831, 27386, 27892, 28348, 28757, 29128, 29465, 29768, 30047, 30293, 30521, 30726, 30912, 31084, 31240, 31381, 31511, 31632, 31741, 31840, 31931, 32016, 32093, 32163, 32228, 32289, 32344, 32395, 32441, 32480, 32519, 32554, 32585, 32614, 32641, 32664, 32683, 32701, 32717, 32731, 32743, 32752, 32760, 32765, 32767, 32768, 32767, 32767, 32765, 32759, 32752, 32741, 32727, 32712, 32695, 32676, 32653, 32628, 32601, 32570, 32537, 32500, 32460, 32416, 32369, 32315, 32258, 32194, 32126, 32052, 31970, 31882, 31787, 31682, 31568, 31443, 31308, 31160, 30996, 30820, 30625, 30410, 30177, 29921, 29638, 29329, 28986, 28610, 28194, 27734, 27226, 26665, 26043, 25355, 24596, 23753, 22827, 21806, 20678, 19441, 18091, 16619, 15025, 13313, 11477, 9534, 7494, 5369, 3187, 964, -1272, -3492, -5672, -7791, -9823, -11755, -13582, -15280, -16860, -18321, -19657, -20881, -22000, -23012, -23933, -24768, -25521, -26205, -26822, -27379, -27885, -28340, -28749, -29120, -29458, -29761, -30038, -30286, -30512, -30718, -30903, -31076, -31233, -31374, -31505, -31624, -31732, -31833, -31923, -32007, -32086, -32155, -32221, -32282, -32337, -32387, -32433, -32474, -32512, -32547, -32578, -32607, -32633, -32656, -32676, -32694, -32709, -32723, -32735, -32745, -32751, -32757, -32761, -32762, -32761, -32762, -32759, -32752, -32744, -32733, -32720, -32705, -32688, -32669, -32646, -32621, -32594, -32563, -32530, -32492, -32452, -32409, -32361, -32308, -32249, -32186, -32117, -32044, -31964, -31875, -31779, -31673, -31561, -31435, -31300, -31151, -30988, -30812, -30618, -30403, -30170, -29913, -29631, -29320, -28978, -28600, -28186, -27726, -27217, -26657, -26036, -25346, -24589, -23747, -22819, -21799, -20671, -19433, -18083, -16612, -15018, -13305, -11469, -9527, -7486, -5365, -3189, -927};