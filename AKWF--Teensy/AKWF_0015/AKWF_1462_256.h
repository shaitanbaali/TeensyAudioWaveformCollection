/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1462 256 samples */
 
const int16_t AKWF_1462_256_DATA [256] = 
{32750, 32755, 32759, 32763, 32765, 32768, 32767, 32768, 32764, 32763, 32761, 32758, 32753, 32750, 32746, 32740, 32734, 32729, 32723, 32718, 32709, 32703, 32697, 32689, 32682, 32675, 32668, 32660, 32653, 32643, 32636, 32628, 32619, 32613, 32604, 32594, 32587, 32579, 32569, 32561, 32555, 32546, 32535, 32528, 32521, 32511, 32501, 32493, 32487, 32477, 32467, 32458, 32452, 32443, 32434, 32424, 32415, 32409, 32399, 32390, 32380, 32375, 32365, 32355, 32346, 32338, 32331, 32322, 32312, 32303, 32296, 32287, 32278, 32268, 32260, 32254, 32244, 32234, 32225, 32219, 32210, 32200, 32191, 32184, 32176, 32166, 32157, 32151, 32142, 32132, 32122, 32115, 32108, 32098, 32088, 32083, 32074, 32063, 32054, 32048, 32039, 32030, 32021, 32015, 32005, 31995, 31987, 31981, 31971, 31962, 31954, 31946, 31937, 31928, 31922, 31913, 31903, 31896, 31888, 31878, 31870, 31864, 31854, 31845, 31006, 35624, 13923, -35919, -31338, -32167, -32170, -32173, -32174, -32173, -32174, -32172, -32169, -32167, -32164, -32160, -32157, -32152, -32147, -32141, -32136, -32131, -32123, -32117, -32110, -32103, -32097, -32090, -32084, -32075, -32067, -32060, -32052, -32045, -32035, -32030, -32021, -32012, -32005, -31995, -31988, -31981, -31971, -31962, -31956, -31947, -31937, -31930, -31923, -31913, -31904, -31898, -31888, -31878, -31870, -31864, -31854, -31845, -31836, -31829, -31820, -31810, -31803, -31796, -31786, -31776, -31768, -31761, -31752, -31742, -31735, -31728, -31717, -31708, -31701, -31694, -31684, -31675, -31669, -31659, -31649, -31641, -31635, -31625, -31616, -31608, -31600, -31590, -31582, -31576, -31567, -31557, -31550, -31542, -31532, -31523, -31517, -31508, -31498, -31491, -31483, -31473, -31464, -31459, -31449, -31440, -31434, -31424, -31415, -31408, -31400, -31390, -31382, -31376, -31365, -31357, -31351, -31341, -31333, -31327, -31317, -31307, -31301, -31292, -31283, -31277, -31268, -31258, -31252, -31243, -31233, -31227};