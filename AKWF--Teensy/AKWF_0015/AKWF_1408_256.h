/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1408 256 samples */
 
const int16_t AKWF_1408_256_DATA [256] = 
{1382, 3886, 6297, 8640, 10876, 12988, 14964, 16781, 18446, 19960, 21321, 22548, 23646, 24623, 25494, 26270, 26958, 27571, 28113, 28593, 29023, 29403, 29742, 30044, 30314, 30555, 30772, 30965, 31140, 31296, 31437, 31566, 31682, 31787, 31883, 31971, 32052, 32124, 32187, 32250, 32306, 32356, 32403, 32445, 32482, 32518, 32550, 32579, 32606, 32630, 32652, 32672, 32689, 32704, 32718, 32730, 32740, 32747, 32755, 32762, 32764, 32766, 32767, 32767, 32765, 32764, 32762, 32754, 32746, 32737, 32727, 32714, 32698, 32682, 32663, 32642, 32621, 32596, 32568, 32538, 32504, 32467, 32428, 32386, 32338, 32285, 32230, 32169, 32102, 32030, 31950, 31864, 31769, 31663, 31551, 31427, 31290, 31139, 30975, 30794, 30593, 30373, 30127, 29857, 29557, 29224, 28857, 28446, 27987, 27479, 26907, 26272, 25563, 24768, 23884, 22901, 21804, 20585, 19239, 17751, 16122, 14350, 12428, 10370, 8186, 5885, 3502, 1061, -1412, -3870, -6288, -8635, -10871, -12983, -14959, -16776, -18441, -19954, -21316, -22542, -23640, -24618, -25489, -26265, -26953, -27566, -28108, -28589, -29018, -29398, -29737, -30039, -30309, -30551, -30767, -30960, -31134, -31291, -31432, -31561, -31677, -31782, -31878, -31966, -32048, -32119, -32183, -32245, -32301, -32351, -32398, -32440, -32478, -32513, -32545, -32575, -32601, -32625, -32647, -32667, -32684, -32699, -32713, -32725, -32735, -32743, -32750, -32757, -32759, -32761, -32762, -32762, -32760, -32761, -32757, -32750, -32742, -32733, -32722, -32709, -32693, -32677, -32658, -32638, -32616, -32591, -32563, -32533, -32499, -32462, -32423, -32381, -32333, -32281, -32225, -32165, -32098, -32025, -31945, -31859, -31764, -31658, -31546, -31422, -31286, -31134, -30970, -30789, -30588, -30368, -30122, -29852, -29552, -29219, -28852, -28441, -27982, -27474, -26902, -26267, -25559, -24763, -23879, -22895, -21798, -20580, -19233, -17746, -16117, -14346, -12423, -10365, -8182, -5884, -3508, -1023};