/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1426 256 samples */
 
const int16_t AKWF_1426_256_DATA [256] = 
{132, 309, 418, 482, 522, 548, 559, 557, 551, 544, 534, 521, 501, 481, 458, 432, 408, 387, 374, 370, 376, 395, 427, 467, 517, 568, 623, 674, 719, 757, 786, 804, 814, 814, 808, 797, 784, 770, 758, 748, 743, 741, 744, 751, 763, 775, 789, 804, 820, 833, 845, 855, 862, 867, 870, 871, 869, 865, 860, 856, 850, 844, 838, 832, 827, 823, 817, 813, 810, 806, 803, 799, 794, 790, 784, 778, 772, 762, 755, 745, 734, 723, 711, 699, 685, 672, 658, 644, 630, 615, 601, 587, 571, 556, 540, 524, 507, 491, 473, 455, 436, 417, 398, 376, 355, 334, 312, 290, 267, 245, 221, 197, 173, 146, 124, 109, 96, 88, 84, 81, 76, 69, 64, 56, 49, 53, 92, -209, 4986, 8677, 10679, 15236, 17515, 17689, 17882, 18294, 18512, 19382, 21710, 24603, 26425, 26773, 26506, 26236, 25734, 24684, 23330, 22093, 21022, 19913, 18694, 17476, 16304, 15052, 13603, 11999, 10328, 8622, 6890, 5175, 3566, 2129, 873, -212, -1123, -1880, -2523, -3109, -3697, -4328, -5031, -5844, -6785, -7852, -9035, -10315, -11661, -13056, -14464, -15854, -17215, -18527, -19778, -20975, -22112, -23195, -24242, -25257, -26253, -27246, -28237, -29247, -30229, -30942, -31544, -32001, -32252, -32419, -32564, -32677, -32746, -32768, -32693, -32442, -32004, -31442, -30810, -30126, -29391, -28618, -27836, -27056, -26269, -25473, -24675, -23879, -23087, -22302, -21524, -20770, -20044, -19351, -18692, -18070, -17478, -16912, -16363, -15820, -15276, -14721, -14143, -13542, -12912, -12253, -11572, -10867, -10145, -9416, -8685, -7955, -7236, -6528, -5834, -5157, -4492, -3840, -3205, -2669, -2200, -1783, -1448, -1155, -872, -600, -338, -86};