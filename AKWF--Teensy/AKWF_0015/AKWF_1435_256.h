/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1435 256 samples */
 
const int16_t AKWF_1435_256_DATA [256] = 
{181, 751, 1322, 1901, 2503, 3118, 3745, 4387, 5044, 5715, 6393, 7088, 7796, 8516, 9239, 9976, 10722, 11477, 12237, 12999, 13761, 14506, 15250, 16011, 16774, 17536, 18302, 19066, 19826, 20582, 21327, 22066, 22795, 23512, 24211, 24892, 25557, 26201, 26826, 27424, 27999, 28547, 29069, 29560, 30021, 30447, 30843, 31205, 31530, 31823, 32073, 32285, 32461, 32601, 32694, 32753, 32768, 32739, 32672, 32562, 32412, 32217, 31981, 31709, 31391, 31035, 30636, 30195, 29721, 29208, 28656, 28066, 27444, 26781, 26101, 25378, 24622, 23843, 23038, 22208, 21352, 20480, 19583, 18671, 17746, 16805, 15856, 14895, 13927, 12963, 11997, 11030, 10064, 9106, 8155, 7226, 6300, 5400, 4514, 3650, 2818, 2009, 1228, 482, -224, -897, -1520, -2110, -2650, -3138, -3580, -3970, -4289, -4626, -4647, -4480, -6556, -7275, -7220, -7479, -7771, -8085, -8433, -8585, -9599, -6827, -2213, -5822, -6364, -5962, -5751, -5577, -5436, -5321, -5248, -5209, -5213, -5261, -5350, -5484, -5658, -5877, -6143, -6449, -6800, -7198, -7641, -8123, -8660, -9229, -9846, -10511, -11220, -11975, -12766, -13600, -14474, -15396, -16357, -17350, -18382, -19450, -20555, -21694, -22843, -24042, -25153, -27330, -17823, -16206, -23203, -22898, -22993, -23048, -23110, -23187, -23282, -23427, -23522, -23206, -23323, -23642, -23877, -24114, -24361, -24617, -24889, -25168, -25453, -25740, -26036, -26183, -26233, -26268, -26272, -26239, -26167, -26060, -25912, -25719, -25483, -25194, -24863, -24481, -24038, -23550, -22998, -22394, -21726, -21005, -20216, -19370, -18465, -17483, -16452, -15342, -14167, -12938, -11599, -10435, -8126, -10766, -15993, -12568, -11247, -10835, -10472, -10205, -9982, -9771, -9557, -9332, -9099, -8852, -8591, -8319, -8031, -7733, -7420, -7096, -6762, -6416, -6053, -5680, -5296, -4900, -4491, -4070, -3637, -3192, -2728, -2255, -1770, -1269, -748, -237};