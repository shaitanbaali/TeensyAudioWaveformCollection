/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1461 256 samples */
 
const int16_t AKWF_1461_256_DATA [256] = 
{25635, 25641, 25646, 25650, 25653, 25655, 25655, 25655, 25655, 25655, 25655, 25652, 25651, 25648, 25645, 25642, 25638, 25633, 25629, 25625, 25620, 25614, 25610, 25604, 25599, 25594, 25588, 25582, 25575, 25569, 25564, 25558, 25551, 25545, 25538, 25532, 25526, 25521, 25514, 25506, 25500, 25494, 25487, 25481, 25474, 25468, 25460, 25454, 25447, 25441, 25435, 25428, 25421, 25414, 25409, 25400, 25394, 25387, 25381, 25375, 25369, 25360, 25355, 25348, 25342, 25334, 25328, 25322, 25315, 25309, 25301, 25295, 25288, 25282, 25274, 25268, 25261, 25255, 25247, 25242, 25235, 25229, 25221, 25215, 25207, 25201, 25195, 25188, 25180, 25175, 25166, 25161, 25153, 25147, 25140, 25134, 25126, 25121, 25112, 25107, 25099, 25093, 25086, 25080, 25072, 25066, 25058, 25052, 25044, 25039, 25031, 25026, 25017, 25012, 25005, 24999, 24991, 24985, 24978, 24972, 24964, 24958, 24950, 24944, 24938, 24932, 24925, 24918, 24912, 24905, 24899, 24891, 24885, 24878, 24872, 24865, 24859, 24851, 24845, 24839, 24832, 24212, 27662, 12200, -35119, -32276, -32749, -32766, -32768, -32767, -32767, -32765, -32763, -32760, -32757, -32754, -32749, -32744, -32740, -32734, -32729, -32723, -32716, -32710, -32702, -32697, -32688, -32681, -32675, -32666, -32658, -32652, -32644, -32636, -32627, -32618, -32610, -32604, -32596, -32588, -32579, -32571, -32562, -32553, -32545, -32536, -32528, -32519, -32510, -32502, -32493, -32485, -32476, -32468, -32459, -32451, -32442, -32433, -32425, -32416, -32408, -32399, -32390, -32382, -32373, -32365, -32356, -32347, -32339, -32330, -32322, -32313, -32304, -32296, -32287, -32279, -32270, -32262, -32253, -32244, -32233, -32223, -32215, -32206, -32198, -32189, -32181, -32172, -32164, -32155, -32147, -32142, -32133, -32124, -32116, -32107, -32099, -32090, -32081, -32073, -32064, -32056, -32047, -32038, -32030, -32021, -32013, -32004, -31995, -31987, -31978, -31970, -31961, -31952, -31944, -31935};