/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1440 256 samples */
 
const int16_t AKWF_1440_256_DATA [256] = 
{5382, 4497, 6162, 4855, 4155, 3844, 3921, 4272, 4837, 5543, 6323, 7157, 8028, 8905, 9780, 10651, 11511, 12354, 13181, 13991, 14785, 15557, 16314, 17060, 17785, 18495, 19195, 19884, 20554, 21214, 21870, 22511, 23138, 23765, 24389, 24992, 25587, 26194, 26798, 27376, 27529, 30350, 22306, 11718, 13483, 13472, 15819, 17474, 18633, 19333, 19714, 19861, 19827, 19676, 19458, 19181, 18869, 18547, 18218, 17883, 17556, 17241, 16933, 16638, 16355, 16083, 15824, 15579, 15348, 15126, 14916, 14719, 14530, 14351, 14184, 14023, 13868, 13724, 13588, 13454, 13331, 13210, 13096, 12985, 12881, 12779, 12678, 12586, 12492, 12400, 12314, 12228, 12143, 12058, 11975, 11893, 11811, 11729, 11647, 11564, 11479, 11397, 11312, 11224, 11138, 11047, 10955, 10865, 10784, 10650, 10482, 10322, 10162, 10002, 9841, 9682, 9526, 9367, 9212, 9056, 8900, 8742, 8585, 8432, 8276, 8121, 7964, 7808, 7655, 7498, 7343, 7186, 7034, 6878, 6723, 6569, 6411, 6256, 6108, 5950, 5790, 5639, 5487, 5326, 5168, 5024, 4873, 4706, 4278, 5659, -412, -10591, -9452, -10154, -8716, -7881, -7438, -7361, -7531, -7882, -8367, -8932, -9538, -10181, -10839, -11494, -12146, -12790, -13421, -14034, -14633, -15217, -15783, -16329, -16863, -17381, -17880, -18370, -18844, -19303, -19750, -20186, -20608, -21022, -21423, -21814, -22198, -22572, -22938, -23296, -23644, -23985, -24319, -24655, -24947, -25009, -25051, -25120, -25194, -25260, -25307, -25334, -25341, -25325, -25289, -25236, -25158, -25064, -24958, -24834, -24695, -24544, -24381, -24205, -24017, -23819, -23611, -23392, -23161, -22925, -22677, -22423, -22159, -21888, -21609, -21322, -21029, -20726, -20419, -20103, -19780, -19452, -19116, -18775, -18426, -18073, -17713, -17346, -16971, -16594, -16211, -15816, -15422, -15023, -14612, -14197, -13782, -13356, -12919, -12490, -12058, -11601, -11131, -10637, -10555, -9448};