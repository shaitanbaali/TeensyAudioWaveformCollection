/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1497 256 samples */
 
const int16_t AKWF_1497_256_DATA [256] = 
{193, 554, 875, 1168, 1429, 1661, 1865, 2039, 2188, 2311, 2410, 2488, 2544, 2582, 2606, 2616, 2616, 2607, 2594, 2579, 2565, 2554, 2548, 2553, 2569, 2600, 2646, 2712, 2796, 2902, 3029, 3178, 3352, 3547, 3765, 4006, 4266, 4547, 4849, 5168, 5505, 5856, 6221, 6600, 6991, 7391, 7802, 8221, 8648, 9081, 9521, 9966, 10417, 10872, 11330, 11794, 12263, 12734, 13210, 13689, 14170, 14657, 15145, 15635, 16130, 16624, 17120, 17617, 18113, 18609, 19104, 19594, 20081, 20565, 21040, 21509, 21971, 22423, 22867, 23298, 23718, 24126, 24521, 24902, 25271, 25625, 25964, 26291, 26602, 26901, 27186, 27458, 27716, 27963, 28198, 28420, 28633, 28833, 29023, 29202, 29369, 29524, 29667, 29795, 29909, 30007, 30084, 30143, 30178, 30187, 30170, 30121, 30039, 29921, 29766, 29572, 29334, 29052, 28725, 28351, 27928, 27457, 26936, 26365, 25745, 25075, 24356, 23590, 22777, 21919, 21015, 20068, 19082, 18055, 16988, 15890, 14755, 13587, 12394, 11169, 9919, 8651, 7358, 6047, 4724, 3386, 2038, 686, -671, -2029, -3383, -4735, -6076, -7404, -8720, -10018, -11292, -12545, -13770, -14966, -16131, -17261, -18355, -19413, -20427, -21403, -22337, -23225, -24071, -24872, -25625, -26335, -27000, -27618, -28194, -28727, -29214, -29663, -30070, -30440, -30773, -31072, -31338, -31576, -31784, -31966, -32126, -32264, -32381, -32482, -32566, -32634, -32689, -32728, -32755, -32767, -32765, -32749, -32717, -32667, -32600, -32513, -32405, -32274, -32118, -31937, -31727, -31490, -31222, -30923, -30591, -30227, -29829, -29398, -28933, -28433, -27901, -27338, -26741, -26115, -25458, -24772, -24060, -23324, -22563, -21781, -20981, -20163, -19332, -18488, -17634, -16775, -15911, -15045, -14181, -13320, -12464, -11620, -10785, -9962, -9159, -8371, -7602, -6858, -6133, -5434, -4761, -4116, -3498, -2910, -2350, -1822, -1324, -857, -424, -14};