/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1500 256 samples */
 
const int16_t AKWF_1500_256_DATA [256] = 
{695, 2151, 3593, 5028, 6867, 8808, 10409, 12051, 13678, 15286, 16860, 18403, 19910, 21369, 22786, 24152, 25516, 25426, 25727, 26602, 27083, 27465, 27776, 28030, 28231, 28386, 28493, 28557, 28580, 28565, 28512, 28422, 28299, 28144, 27963, 27757, 27530, 27298, 27060, 26908, 26441, 25776, 25868, 26046, 26294, 26678, 26921, 27037, 27448, 27856, 28249, 28631, 29003, 29361, 29703, 30033, 30347, 30645, 30926, 31190, 31436, 31663, 31871, 32060, 32228, 32374, 32499, 32600, 32680, 32733, 32763, 32768, 32746, 32699, 32623, 32520, 32387, 32222, 32027, 31795, 31529, 31219, 30866, 30433, 30070, 29844, 29182, 28406, 27582, 26874, 26565, 25892, 25135, 24385, 23628, 22496, 21613, 20977, 20312, 19651, 18985, 18311, 17631, 16949, 16261, 15571, 14886, 14203, 13537, 12944, 12240, 11432, 10826, 10208, 9570, 8922, 8258, 7582, 6895, 6197, 5490, 4775, 4052, 3323, 2591, 1852, 1112, 371, -372, -1113, -1853, -2592, -3324, -4052, -4776, -5491, -6198, -6896, -7583, -8259, -8923, -9571, -10208, -10827, -11433, -12241, -12945, -13538, -14204, -14886, -15572, -16262, -16949, -17631, -18312, -18985, -19651, -20313, -20977, -21613, -22496, -23628, -24385, -25135, -25893, -26565, -26874, -27582, -28406, -29182, -29844, -30070, -30434, -30866, -31219, -31529, -31795, -32027, -32222, -32387, -32520, -32623, -32699, -32746, -32768, -32763, -32733, -32680, -32600, -32499, -32374, -32228, -32060, -31871, -31664, -31436, -31190, -30926, -30645, -30347, -30033, -29703, -29361, -29003, -28631, -28249, -27857, -27448, -27037, -26922, -26678, -26294, -26046, -25868, -25776, -26442, -26909, -27060, -27298, -27530, -27757, -27963, -28144, -28299, -28423, -28512, -28565, -28580, -28557, -28493, -28386, -28232, -28030, -27776, -27465, -27083, -26602, -25727, -25426, -25516, -24152, -22786, -21370, -19910, -18404, -16861, -15287, -13679, -12051, -10410, -8809, -6867, -5029, -3594, -2152, -696};