/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1482 256 samples */
 
const int16_t AKWF_1482_256_DATA [256] = 
{1118, 3095, 5150, 7273, 9415, 11543, 13631, 15644, 17573, 19403, 21117, 22714, 24191, 25538, 26762, 27862, 28835, 29692, 30432, 31059, 31582, 32002, 32324, 32556, 32701, 32764, 32750, 32665, 32513, 32299, 32028, 31703, 31327, 30907, 30446, 29946, 29413, 28848, 28254, 27637, 26997, 26337, 25662, 24971, 24268, 23556, 22835, 22108, 21379, 20646, 19913, 19182, 18451, 17725, 17004, 16289, 15580, 14881, 14189, 13507, 12836, 12176, 11528, 10893, 10269, 9659, 9064, 8482, 7915, 7362, 6822, 6300, 5792, 5298, 4820, 4357, 3908, 3475, 3057, 2652, 2264, 1891, 1530, 1185, 853, 536, 232, -60, -337, -602, -855, -1096, -1324, -1542, -1747, -1942, -2127, -2300, -2464, -2617, -2761, -2897, -3024, -3141, -3251, -3352, -3446, -3534, -3613, -3687, -3754, -3815, -3869, -3918, -3962, -4000, -4033, -4062, -4087, -4107, -4123, -4135, -4144, -4149, -4151, -4150, -4146, -4139, -4131, -4120, -4107, -4092, -4075, -4056, -4036, -4014, -3992, -3968, -3943, -3917, -3890, -3863, -3835, -3806, -3777, -3747, -3717, -3686, -3655, -3624, -3594, -3562, -3531, -3500, -3468, -3438, -3407, -3376, -3345, -3315, -3284, -3255, -3226, -3196, -3168, -3139, -3112, -3084, -3058, -3031, -3005, -2980, -2955, -2930, -2905, -2882, -2858, -2835, -2813, -2790, -2773, -2842, -3104, -3609, -4363, -5336, -6490, -7774, -9149, -10578, -12026, -13469, -14887, -16255, -17564, -18806, -19965, -21042, -22031, -22928, -23736, -24454, -25080, -25622, -26077, -26450, -26747, -26966, -27114, -27193, -27206, -27159, -27053, -26894, -26683, -26426, -26123, -25779, -25396, -24978, -24530, -24049, -23543, -23011, -22456, -21883, -21292, -20683, -20062, -19428, -18784, -18133, -17474, -16809, -16143, -15472, -14801, -14132, -13462, -12795, -12133, -11474, -10821, -10175, -9534, -8902, -8279, -7664, -7059, -6464, -5878, -5265, -4503, -3494, -2209, -616};