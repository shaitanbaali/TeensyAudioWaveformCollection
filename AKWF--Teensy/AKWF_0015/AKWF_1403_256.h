/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1403 256 samples */
 
const int16_t AKWF_1403_256_DATA [256] = 
{174, 1824, 3730, 4708, 5593, 6356, 7042, 7667, 8247, 8792, 9303, 9788, 10250, 10690, 11111, 11516, 11904, 12278, 12637, 12984, 13318, 13642, 13954, 14256, 14547, 14830, 15102, 15365, 15620, 15866, 16104, 16333, 16555, 16769, 16975, 17173, 17365, 17548, 17724, 17893, 18054, 18209, 18357, 18499, 18633, 18760, 18881, 18996, 19103, 19204, 19298, 19385, 19467, 19541, 19610, 19671, 19726, 19776, 19818, 19854, 19884, 19907, 19924, 19983, 19755, 20840, 25429, 27784, 29488, 30787, 31737, 32309, 32961, 30804, 27220, 25458, 23863, 22493, 21253, 20114, 19055, 18055, 17106, 16202, 15334, 14499, 13694, 12913, 12156, 11420, 10703, 10004, 9323, 8655, 8003, 7364, 6736, 6122, 5518, 4925, 4343, 3770, 3206, 2651, 2104, 1566, 1036, 514, -1, -508, -1009, -1503, -1991, -2472, -2948, -3417, -3880, -4337, -4788, -5235, -5676, -6110, -6540, -6966, -7385, -7799, -8209, -8613, -9013, -9409, -9799, -10186, -10567, -10943, -11316, -11684, -12047, -12407, -12761, -13113, -13459, -13801, -14139, -14473, -14803, -15128, -15450, -15767, -16081, -16391, -16696, -16998, -17296, -17590, -17879, -18166, -18448, -18726, -19000, -19271, -19537, -19799, -20066, -20275, -20395, -20526, -20658, -20791, -20924, -21057, -21190, -21321, -21452, -21580, -21709, -21834, -21957, -22077, -22197, -22311, -22424, -22534, -22641, -22745, -22846, -22943, -23038, -23127, -23212, -23295, -23373, -23446, -23515, -23579, -23639, -23694, -23744, -23789, -23829, -23863, -23892, -23915, -23933, -23920, -23891, -24217, -11678, -1152, 4466, 9008, 12272, 14396, 15742, 14201, 11699, 10475, 9361, 8409, 7555, 6778, 6062, 5394, 4769, 4182, 3628, 3104, 2607, 2135, 1690, 1265, 862, 480, 118, -224, -549, -854, -1143, -1413, -1668, -1905, -2125, -2330, -2517, -2689, -2845, -2985, -3109, -3218, -3310, -3388, -3451, -3497, -3495, -3689, -2136, -266};