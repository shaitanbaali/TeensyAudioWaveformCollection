/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1487 256 samples */
 
const int16_t AKWF_1487_256_DATA [256] = 
{2418, 7132, 11547, 15878, 19428, 22398, 26039, 28862, 31058, 32356, 32770, 32459, 31600, 30406, 29016, 27242, 25435, 23670, 21620, 19223, 16458, 13393, 10179, 7021, 4123, 2033, -29, -2331, -4176, -5791, -7029, -7917, -8486, -8749, -8737, -8497, -8074, -7504, -6815, -6044, -5221, -4378, -3549, -2760, -2036, -1401, -868, -454, -170, -21, -7, -176, -448, -622, -857, -1085, -1323, -1564, -1801, -2029, -2247, -2449, -2629, -2784, -2913, -3013, -3082, -3117, -3116, -3076, -2994, -2872, -2703, -2486, -2222, -1908, -1541, -1124, -653, -130, 444, 1068, 1738, 2449, 3194, 3960, 4736, 5505, 6247, 6939, 7558, 8080, 8474, 8704, 8726, 8506, 8034, 7289, 6240, 5006, 3421, 1969, 639, -1461, -3869, -6409, -8888, -11172, -13163, -14827, -16202, -17351, -18349, -19259, -20093, -20749, -21361, -21817, -21912, -21525, -20533, -18904, -16665, -13928, -10943, -7744, -4801, -1850, 1849, 4801, 7744, 10942, 13928, 16665, 18903, 20533, 21525, 21911, 21817, 21360, 20748, 20093, 19258, 18348, 17351, 16201, 14826, 13162, 11172, 8887, 6408, 3868, 1460, -640, -1970, -3422, -5006, -6241, -7290, -8035, -8506, -8726, -8705, -8475, -8081, -7559, -6939, -6247, -5506, -4737, -3961, -3194, -2450, -1739, -1069, -445, 129, 652, 1123, 1540, 1907, 2221, 2485, 2702, 2871, 2994, 3075, 3115, 3117, 3081, 3012, 2912, 2783, 2628, 2448, 2246, 2028, 1800, 1563, 1322, 1084, 856, 621, 447, 175, 6, 20, 169, 454, 867, 1400, 2035, 2759, 3548, 4377, 5220, 6044, 6815, 7503, 8074, 8496, 8736, 8748, 8486, 7916, 7029, 5790, 4175, 2330, 28, -2034, -4124, -7022, -10180, -13393, -16458, -19224, -21620, -23671, -25435, -27242, -29016, -30406, -31600, -32459, -32770, -32356, -31058, -28862, -26039, -22398, -19428, -15879, -11547, -7133, -2419};