/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1433 256 samples */
 
const int16_t AKWF_1433_256_DATA [256] = 
{757, 1928, 3102, 4311, 5558, 6858, 8214, 9618, 11101, 12641, 14237, 15882, 17538, 19188, 20835, 22381, 23803, 25152, 26276, 27165, 28058, 28628, 28951, 29687, 30086, 30324, 31942, 32769, 31783, 30772, 29778, 28759, 27716, 26654, 25569, 24439, 23278, 22086, 20856, 19608, 18337, 17062, 15792, 14543, 13360, 12223, 11152, 10221, 9322, 8504, 7883, 7140, 6371, 5856, 4851, 3669, 3480, 3592, 3638, 3699, 3761, 3827, 3894, 3961, 4030, 4098, 4162, 4230, 4300, 4364, 4427, 4496, 4563, 4632, 4708, 4789, 4874, 4970, 5076, 5190, 5314, 5449, 5596, 5733, 5844, 5992, 5995, 6658, 8213, 4507, 4460, 5220, 5802, 6315, 6433, 6538, 6478, 6519, 6962, 6871, 6546, 6465, 6377, 6309, 6247, 6204, 6172, 6128, 6094, 6060, 5996, 5933, 5679, 6555, 2429, -8022, -6463, -6079, -5513, -5240, -5006, -4788, -4581, -4391, -4214, -4058, -3915, -3781, -3665, -3563, -3461, -3378, -3320, -3265, -3210, -3173, -3255, -2899, -9692, -2443, -2378, -3116, -3649, -4197, -4967, -5537, -6051, -7079, -7500, -7747, -9607, -10344, -9657, -11434, -12966, -13540, -14250, -14920, -15534, -16127, -16739, -17271, -17834, -18495, -19041, -19684, -20720, -21460, -21814, -22209, -22576, -22934, -23266, -23472, -23660, -23817, -23744, -23768, -24008, -23988, -23910, -24430, -24665, -24061, -23417, -22788, -22147, -21496, -20837, -20164, -19477, -18773, -18045, -17295, -16515, -15703, -14871, -14007, -13117, -12218, -11305, -10394, -9518, -8650, -7820, -7084, -6370, -5694, -5085, -4850, -8352, -2974, -2574, -1728, -1536, -1601, -1576, -1493, -1539, -1650, -1713, -1770, -1827, -1871, -1918, -1963, -2003, -2042, -2085, -2135, -2192, -2262, -2352, -2458, -2585, -2740, -2917, -3107, -3316, -3527, -3725, -3912, -4052, -4132, -4170, -4112, -3928, -3727, -3408, -2928, -2607, -2213, -1614, -1623, -1599, -554};