/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1436 256 samples */
 
const int16_t AKWF_1436_256_DATA [256] = 
{186, 633, 1053, 1481, 1912, 2343, 2776, 3212, 3651, 4093, 4533, 4977, 5423, 5872, 6323, 6775, 7226, 7682, 8141, 8600, 9059, 9523, 9985, 10449, 10918, 11386, 11857, 12328, 12798, 13273, 13749, 14226, 14702, 15182, 15663, 16145, 16629, 17112, 17597, 18084, 18573, 19063, 19551, 20039, 20533, 21025, 21520, 22015, 22510, 23005, 23503, 24001, 24501, 25000, 25499, 26001, 26504, 27007, 27513, 28017, 28519, 29026, 29531, 30040, 30551, 31055, 31562, 32075, 32574, 32763, 32455, 31880, 31186, 30434, 29656, 28866, 28072, 27278, 26481, 25681, 24885, 24089, 23295, 22500, 21707, 20912, 20125, 19334, 18545, 17759, 16972, 16187, 15409, 14628, 13847, 13012, 12175, 11362, 10558, 9767, 8992, 8228, 7480, 6748, 6025, 5312, 4617, 3932, 3262, 2604, 1955, 1320, 697, 87, -509, -1097, -1676, -2241, -2798, -3341, -3873, -4397, -4910, -5413, -5905, -6384, -6858, -7319, -7771, -8214, -8647, -9072, -9486, -9893, -10290, -10675, -11055, -11426, -11787, -12143, -12486, -12824, -13153, -13474, -13789, -14093, -14390, -14681, -14964, -15240, -15507, -15769, -16021, -16269, -16510, -16743, -16970, -17189, -17401, -17607, -17807, -18002, -18189, -18369, -18544, -18716, -18879, -19037, -19187, -19333, -19473, -19609, -19738, -19861, -19980, -20093, -20203, -20305, -20401, -20504, -20525, -20470, -20416, -20350, -20276, -20194, -20106, -20007, -19903, -19791, -19669, -19542, -19406, -19264, -19115, -18959, -18795, -18623, -18447, -18264, -18075, -17879, -17677, -17467, -17252, -17032, -16807, -16576, -16337, -16094, -15845, -15594, -15334, -15068, -14800, -14524, -14246, -13963, -13673, -13381, -13081, -12778, -12475, -12163, -11846, -11527, -11202, -10873, -10544, -10206, -9867, -9522, -9174, -8825, -8468, -8112, -7748, -7385, -7018, -6645, -6269, -5890, -5508, -5127, -4739, -4347, -3955, -3557, -3158, -2758, -2354, -1945, -1535, -1123, -710, -287};