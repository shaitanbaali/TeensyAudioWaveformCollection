/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1429 256 samples */
 
const int16_t AKWF_1429_256_DATA [256] = 
{5, 17, -69, 1576, 2941, 3934, 5827, 7187, 7996, 8846, 9794, 10727, 11904, 13604, 15609, 17423, 18879, 20200, 21554, 22865, 24033, 25109, 26211, 27368, 28515, 29623, 30712, 31932, 31168, 26619, 24229, 21146, 17143, 15428, 14906, 14155, 13338, 12380, 10294, 6875, 3412, 1175, 83, -695, -1441, -1838, -1780, -1606, -1621, -1765, -1862, -1915, -2017, -2125, -2096, -1857, -1458, -965, -391, 248, 881, 1420, 1806, 2028, 2077, 1945, 1649, 1232, 749, 248, -229, -643, -958, -1159, -1238, -1210, -1085, -887, -643, -379, -121, 111, 303, 446, 534, 571, 531, 631, -307, -2314, -3116, -4915, -6601, -7551, -8328, -9228, -10097, -11044, -12434, -14248, -16008, -17390, -18522, -19638, -20759, -21756, -22620, -23482, -24407, -25350, -26268, -27175, -28098, -29019, -29883, -30677, -31417, -32125, -32789, -31585, -27449, -24133, -21178, -17246, -15286, -14752, -14216, -13559, -12715, -10855, -7696, -4320, -1971, -705, 190, 1046, 1620, 1765, 1749, 1859, 2073, 2227, 2303, 2375, 2427, 2339, 2038, 1569, 1001, 362, -322, -993, -1558, -1958, -2181, -2221, -2073, -1755, -1314, -802, -272, 230, 666, 1003, 1216, 1306, 1282, 1156, 953, 699, 422, 150, -97, -303, -459, -559, -603, -598, -550, -470, -369, -255, -140, -33, 63, 142, 203, 242, 260, 260, 243, 212, 172, 124, 75, 26, -20, -60, -93, -115, -128, -132, -125, -112, -92, -68, -41, -14, 11, 32, 50, 61, 68, 68, 63, 55, 44, 31, 16, 2, -8, -19, -28, -33, -35, -34, -31, -26, -21, -13, -7, 0, 5, 10, 13, 16, 15, 16, 14, 11, 9, 5, 2, -1, -4, -5, -6, -8, -10, -8, -6, -6, -4, -3, -2, 0};