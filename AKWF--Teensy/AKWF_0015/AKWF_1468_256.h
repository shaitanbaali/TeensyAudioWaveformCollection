/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1468 256 samples */
 
const int16_t AKWF_1468_256_DATA [256] = 
{16341, 19579, 19469, 20029, 20487, 20948, 21403, 21902, 22351, 22799, 23242, 23682, 24119, 24548, 24976, 25398, 25814, 26225, 26630, 27027, 27418, 27801, 28176, 28545, 28905, 29256, 29591, 29906, 30201, 30476, 30734, 30972, 31194, 31400, 31589, 31762, 31920, 32063, 32192, 32306, 32407, 32496, 32570, 32633, 32684, 32723, 32749, 32764, 32768, 32763, 32746, 32718, 32681, 32632, 32576, 32510, 32433, 32346, 32251, 32146, 32032, 31910, 31778, 31636, 31486, 31326, 31158, 30981, 30795, 30598, 30393, 30179, 29954, 29720, 29477, 29224, 28960, 28687, 28403, 28107, 27802, 27484, 27156, 26816, 26462, 26098, 25722, 25331, 24927, 24510, 24077, 23631, 23170, 22694, 22200, 21690, 21163, 20620, 20058, 19477, 18877, 18257, 17615, 16965, 16302, 15632, 14956, 14271, 13580, 12883, 12177, 11465, 10750, 10027, 9300, 8571, 7834, 7093, 6350, 5604, 4854, 4103, 3347, 2593, 1836, 1076, 318, -438, -1199, -1956, -2712, -3471, -4224, -4977, -5728, -6474, -7218, -7959, -8695, -9427, -10157, -10878, -11596, -12309, -13014, -13713, -14407, -15091, -15770, -16440, -17102, -17756, -18401, -19036, -19655, -20253, -20829, -21388, -21927, -22447, -22949, -23436, -23904, -24357, -24792, -25213, -25621, -26012, -26389, -26753, -27102, -27438, -27765, -28076, -28376, -28664, -28940, -29206, -29460, -29703, -29936, -30156, -30369, -30571, -30761, -30941, -31113, -31275, -31426, -31569, -31702, -31824, -31938, -32042, -32136, -32220, -32295, -32361, -32417, -32461, -32497, -32522, -32536, -32541, -32534, -32519, -32490, -32451, -32401, -32339, -32265, -32178, -32079, -31968, -31843, -31705, -31552, -31387, -31204, -31008, -30796, -30569, -30324, -30063, -29783, -29486, -29172, -28836, -28482, -28107, -27711, -27303, -26884, -26459, -26025, -25584, -25133, -24678, -24213, -23742, -23266, -22784, -22296, -21803, -21304, -20802, -20296, -19786, -19273, -18751, -18242, -17716, -17192, -16583, -16541, -13748};