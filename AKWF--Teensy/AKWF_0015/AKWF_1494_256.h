/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1494 256 samples */
 
const int16_t AKWF_1494_256_DATA [256] = 
{332, 1292, 2130, 2876, 3534, 4113, 4619, 5060, 5447, 5784, 6089, 6366, 6625, 6878, 7134, 7402, 7690, 8007, 8364, 8765, 9222, 9734, 10309, 10954, 11665, 12443, 13288, 14193, 15152, 16154, 17182, 18224, 19258, 20261, 21206, 22071, 22822, 23434, 23881, 24137, 24184, 24009, 23607, 22981, 22133, 21073, 19816, 18391, 16835, 15180, 13472, 11755, 10064, 8442, 6927, 5544, 4324, 3286, 2443, 1805, 1374, 1148, 1151, 1362, 1745, 2282, 2954, 3744, 4631, 5599, 6633, 7712, 8825, 9959, 11100, 12243, 13381, 14502, 15609, 16697, 17762, 18805, 19825, 20822, 21797, 22751, 23679, 24586, 25469, 26324, 27153, 27949, 28706, 29422, 30086, 30695, 31235, 31699, 32079, 32362, 32538, 32599, 32535, 32339, 32003, 31524, 30899, 30124, 29206, 28148, 26955, 25636, 24209, 22681, 21071, 19399, 17677, 15929, 14174, 12426, 10707, 9036, 7420, 5879, 4426, 3059, 1795, 634, -424, -1377, -2230, -2989, -3652, -4235, -4743, -5182, -5565, -5904, -6204, -6479, -6738, -6991, -7250, -7521, -7816, -8146, -8515, -8935, -9412, -9950, -10553, -11229, -11974, -12787, -13667, -14600, -15582, -16600, -17633, -18666, -19679, -20646, -21542, -22347, -23029, -23570, -23943, -24131, -24117, -23890, -23447, -22783, -21908, -20832, -19571, -18155, -16611, -14969, -13269, -11554, -9855, -8218, -6683, -5277, -4036, -2983, -2131, -1497, -1080, -875, -872, -1058, -1427, -1958, -2634, -3438, -4344, -5334, -6391, -7491, -8626, -9777, -10933, -12087, -13232, -14357, -15466, -16552, -17612, -18650, -19664, -20652, -21622, -22569, -23492, -24397, -25281, -26139, -26976, -27782, -28557, -29295, -29986, -30624, -31202, -31704, -32123, -32448, -32664, -32763, -32732, -32561, -32244, -31778, -31162, -30396, -29479, -28417, -27209, -25870, -24415, -22852, -21206, -19499, -17741, -15962, -14186, -12421, -10692, -9018, -7408, -5876, -4436, -3087, -1843, -683};