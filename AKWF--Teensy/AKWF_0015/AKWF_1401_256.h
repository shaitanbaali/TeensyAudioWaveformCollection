/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1401 256 samples */
 
const int16_t AKWF_1401_256_DATA [256] = 
{987, 4301, 7245, 9940, 12389, 14601, 16580, 18319, 19826, 21097, 22125, 22918, 23473, 23828, 23674, 25564, 29120, 31142, 32446, 32556, 31468, 30667, 29963, 29311, 28699, 28119, 27561, 27025, 26503, 25996, 25504, 25023, 24551, 24090, 23636, 23190, 22752, 22320, 21895, 21477, 21063, 20656, 20252, 19855, 19461, 19073, 18689, 18307, 17931, 17558, 17190, 16823, 16461, 16103, 15748, 15395, 15046, 14701, 14356, 14016, 13679, 13345, 13013, 12684, 12357, 12032, 11710, 11391, 11076, 10761, 10448, 10138, 9830, 9525, 9222, 8922, 8623, 8327, 8032, 7740, 7451, 7161, 6876, 6593, 6310, 6029, 5752, 5476, 5202, 4932, 4660, 4392, 4125, 3860, 3597, 3338, 3078, 2821, 2566, 2312, 2060, 1811, 1562, 1315, 1072, 829, 587, 349, 112, -122, -357, -590, -819, -1049, -1276, -1500, -1724, -1946, -2166, -2385, -2600, -2816, -3029, -3240, -3452, -3659, -3865, -4071, -4274, -4474, -4674, -4872, -5069, -5264, -5457, -5647, -5838, -6027, -6212, -6397, -6580, -6761, -6942, -7120, -7296, -7471, -7644, -7815, -7985, -8153, -8319, -8484, -8648, -8808, -8969, -9127, -9283, -9438, -9591, -9742, -9893, -10042, -10187, -10333, -10475, -10617, -10757, -10896, -11033, -11167, -11301, -11433, -11563, -11691, -11817, -11943, -12066, -12187, -12308, -12424, -12542, -12658, -12771, -12884, -12993, -13102, -13210, -13315, -13417, -13519, -13619, -13718, -13815, -13911, -14004, -14096, -14185, -14274, -14361, -14447, -14530, -14613, -14692, -14770, -14848, -14922, -14996, -15068, -15137, -15205, -15274, -15339, -15402, -15464, -15524, -15583, -15641, -15696, -15749, -15802, -15852, -15901, -15947, -15992, -16036, -16077, -16118, -16156, -16193, -16229, -16262, -16293, -16324, -16353, -16379, -16405, -16429, -16450, -16469, -16488, -16506, -16521, -16535, -16546, -16556, -16565, -16571, -16577, -16581, -16583, -16570, -16572, -16618, -11730, -6476, -2501};