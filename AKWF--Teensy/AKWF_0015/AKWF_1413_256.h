/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1413 256 samples */
 
const int16_t AKWF_1413_256_DATA [256] = 
{191, 859, 1515, 2172, 2827, 3485, 4141, 4796, 5451, 6104, 6757, 7408, 8057, 8705, 9352, 9997, 10638, 11278, 11916, 12550, 13183, 13812, 14439, 15062, 15682, 16297, 16912, 17520, 18125, 18727, 19324, 19916, 20506, 21089, 21667, 22242, 22810, 23373, 23933, 24486, 25034, 25578, 26112, 26642, 27167, 27684, 28196, 28702, 29199, 29693, 30179, 30656, 31128, 31592, 32026, 32558, 32403, 29810, 25970, 21960, 18116, 14616, 11516, 8771, 6334, 4209, 2384, 853, -391, -1376, -2132, -2686, -3073, -3313, -3430, -3441, -3354, -3185, -2940, -2626, -2253, -1827, -1354, -844, -299, 272, 862, 1471, 2093, 2723, 3360, 4002, 4645, 5293, 5938, 6584, 7231, 7874, 8517, 9159, 9800, 10439, 11077, 11710, 12345, 12978, 13605, 14231, 14856, 15475, 16093, 16708, 17317, 17925, 18527, 19125, 19719, 20310, 20871, 21532, 21514, 19005, 15105, 10917, 6895, 3275, 109, -2691, -5206, -7448, -9423, -11126, -12549, -13710, -14631, -15334, -15851, -16210, -16430, -16531, -16529, -16436, -16262, -16012, -15700, -15330, -14912, -14450, -13952, -13426, -12875, -12303, -11715, -11117, -10505, -9887, -9264, -8634, -8001, -7366, -6725, -6084, -5442, -4795, -4150, -3500, -2849, -2199, -1545, -890, -237, 419, 1076, 1733, 2389, 3047, 3702, 4358, 5015, 5670, 6322, 6975, 7603, 8327, 8406, 6186, 2512, -1541, -5357, -8654, -11432, -13856, -16068, -18111, -19987, -21673, -23140, -24377, -25390, -26190, -26803, -27250, -27557, -27742, -27824, -27816, -27729, -27569, -27349, -27075, -26753, -26390, -25993, -25565, -25114, -24640, -24149, -23645, -23127, -22598, -22063, -21517, -20967, -20409, -19845, -19278, -18704, -18122, -17538, -16948, -16354, -15756, -15152, -14543, -13932, -13317, -12696, -12073, -11446, -10815, -10184, -9548, -8909, -8269, -7627, -6981, -6336, -5687, -5037, -4386, -3733, -3079, -2425, -1770, -1116, -449};