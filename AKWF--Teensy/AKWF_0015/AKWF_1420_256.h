/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1420 256 samples */
 
const int16_t AKWF_1420_256_DATA [256] = 
{1020, 3940, 6935, 9997, 13657, 17410, 20029, 21928, 22853, 23666, 23902, 24114, 24039, 23255, 22254, 20442, 19546, 18852, 17933, 16882, 15354, 14294, 12988, 11869, 11359, 10469, 9301, 7662, 5768, 4058, 1742, -1425, -5045, -8550, -12189, -15461, -18385, -20936, -23038, -24883, -26273, -27315, -27798, -27842, -27587, -26746, -25736, -24190, -21744, -18878, -15643, -12370, -9171, -5942, -2737, 304, 3097, 5634, 7560, 9299, 11062, 12577, 13782, 14475, 15004, 15428, 16019, 16546, 16958, 17356, 17650, 18168, 18671, 18778, 18269, 17393, 16432, 15253, 13924, 12249, 10296, 8183, 5843, 3388, 809, -1959, -4978, -8095, -11219, -14121, -16537, -18585, -20295, -21529, -22311, -22630, -22536, -21980, -21036, -19888, -18461, -16685, -14678, -12591, -10457, -8295, -6111, -4278, -3161, -2370, -985, 842, 2319, 3202, 3932, 5236, 6931, 8492, 9421, 9630, 9782, 10535, 11668, 12246, 12169, 12140, 12429, 13048, 13164, 11279, 7728, 5285, 3432, 379, -3349, -8224, -12354, -14430, -16953, -19904, -23356, -26742, -28418, -29182, -30736, -32165, -32563, -31968, -29947, -27264, -25165, -23291, -21093, -18184, -14954, -11825, -9246, -7054, -4462, -1973, 342, 2758, 4437, 5664, 6648, 7187, 7718, 8165, 8054, 7955, 8125, 8277, 8201, 7650, 6892, 5967, 5233, 4574, 3566, 3949, 5771, 7196, 7975, 8379, 8548, 8248, 7905, 7509, 6701, 6802, 6864, 6584, 6825, 6567, 6307, 6312, 6281, 6925, 7367, 8128, 9958, 12020, 13502, 15023, 17347, 19909, 22451, 24234, 25812, 26890, 27318, 28440, 28257, 27605, 26813, 25094, 24154, 23482, 22348, 21331, 20906, 19115, 19042, 19921, 17735, 16931, 16375, 15481, 14499, 10924, 7049, 3370, 1431, -1374, -4721, -10039, -15609, -16810, -16975, -19124, -23958, -27960, -29327, -29493, -29217, -30503, -32509, -32538, -29832, -25074, -21272, -18770, -16577, -12260, -7408, -3231};