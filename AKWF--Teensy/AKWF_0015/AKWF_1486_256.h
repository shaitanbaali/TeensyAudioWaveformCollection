/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1486 256 samples */
 
const int16_t AKWF_1486_256_DATA [256] = 
{-3496, -11348, -16533, -17708, -18137, -19320, -20748, -22268, -24074, -25920, -27476, -28787, -30025, -31227, -32508, -32224, -26879, -20248, -17907, -18452, -18634, -18097, -17449, -16553, -15341, -14196, -13320, -12566, -11786, -10967, -10131, -9275, -8413, -7577, -6768, -5976, -5198, -4431, -3678, -2944, -2225, -1526, -851, -195, 439, 1049, 1640, 2209, 2752, 3273, 3771, 4243, 4694, 5120, 5523, 5901, 6258, 6590, 6900, 7187, 7451, 7695, 7916, 8117, 8297, 8456, 8596, 8718, 8820, 8905, 8971, 9021, 9055, 9073, 9077, 9066, 9041, 9003, 8953, 8891, 8817, 8734, 8639, 8536, 8425, 8305, 8176, 8041, 7900, 7754, 7601, 7444, 7283, 7117, 6949, 6778, 6604, 6429, 6253, 6074, 5896, 5718, 5539, 5361, 5185, 5008, 4834, 4661, 4491, 4322, 4156, 3993, 3833, 3675, 3521, 3371, 3224, 3081, 2942, 2806, 2675, 2549, 2426, 2308, 2193, 2084, 1978, 1877, 1780, 1689, 1600, 1517, 1438, 1363, 1293, 1227, 1164, 1105, 1052, 1002, 954, 911, 873, 838, 806, 778, 752, 730, 712, 695, 682, 672, 664, 659, 656, 656, 658, 662, 668, 675, 685, 697, 709, 722, 738, 756, 774, 793, 811, 833, 855, 877, 900, 924, 947, 971, 995, 1020, 1045, 1070, 1094, 1120, 1146, 1170, 1194, 1219, 1243, 1267, 1290, 1313, 1335, 1356, 1378, 1400, 1419, 1439, 1458, 1477, 1495, 1511, 1528, 1545, 1559, 1573, 1588, 1600, 1613, 1625, 1635, 1645, 1655, 1664, 1672, 1680, 1687, 1693, 1698, 1703, 1708, 1711, 1714, 1717, 1719, 1721, 1722, 1722, 1722, 1722, 1721, 1719, 1717, 1714, 1713, 1709, 1706, 1703, 1699, 1694, 1691, 1685, 1680, 1675, 1669, 1663, 1658, 1652, 1646, 1640, 1633, 1627, 1621, 1615, 1607, 1587, 1658, 889};