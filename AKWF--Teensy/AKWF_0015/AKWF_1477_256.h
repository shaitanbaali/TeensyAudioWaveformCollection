/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1477 256 samples */
 
const int16_t AKWF_1477_256_DATA [256] = 
{27630, 27631, 27629, 27627, 27625, 27623, 27619, 27616, 27613, 27608, 27604, 27599, 27594, 27589, 27583, 27578, 27573, 27567, 27560, 27554, 27548, 27541, 27536, 27529, 27522, 27515, 27509, 27502, 27495, 27488, 27481, 27474, 27467, 27460, 27453, 27446, 27439, 27431, 27424, 27417, 27410, 27403, 27396, 27389, 27381, 27374, 27366, 27359, 27352, 27345, 27338, 27330, 27323, 27316, 27309, 27301, 27294, 27287, 27279, 27272, 27265, 27258, 27250, 27243, 27235, 27228, 27221, 27213, 27206, 27199, 27192, 27185, 27178, 27170, 27163, 27155, 27148, 27141, 27134, 27126, 27119, 27112, 27105, 27098, 27090, 27083, 27075, 27068, 27061, 27054, 27046, 27039, 27031, 27024, 27017, 27010, 27003, 26727, 28226, 21732, -3933, -3145, -3240, -3269, -3273, -3277, -3281, -3283, -3286, -3289, -3291, -3292, -3294, -3295, -3297, -3297, -3299, -3300, -3299, -3299, -3299, -3299, -3299, -3299, -3329, -3372, -2790, -27971, -33912, -32515, -32763, -32759, -32756, -32751, -32748, -32743, -32737, -32732, -32726, -32719, -32713, -32706, -32700, -32692, -32685, -32678, -32671, -32663, -32656, -32648, -32640, -32632, -32624, -32616, -32608, -32599, -32591, -32584, -32575, -32566, -32558, -32550, -32541, -32533, -32525, -32516, -32508, -32498, -32491, -32481, -32473, -32464, -32456, -32447, -32439, -32430, -32421, -32412, -32404, -32395, -32387, -32378, -32370, -32361, -32352, -32343, -32335, -32326, -32318, -32309, -32300, -32292, -32283, -32275, -32266, -32257, -32249, -32240, -32231, -32223, -32214, -32206, -32191, -31904, -33541, -8924, -382, -2266, -1922, -1917, -1912, -1906, -1902, -1898, -1894, -1890, -1887, -1885, -1881, -1879, -1876, -1873, -1872, -1870, -1869, -1866, -1864, -1863, -1862, -1861, -1859, -1858, -1856, -1857, -1855, -1855, -1853, -1852, -1853, -1851, -1849, -1850, -1848, -1847, -1848, -1846, -1845, -1846, -1846, -1843, -1842, -1843, -1842, -1841, -1840, -1841};