/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1481 256 samples */
 
const int16_t AKWF_1481_256_DATA [256] = 
{598, 2492, 4159, 5649, 6959, 8094, 9066, 9878, 10545, 11079, 11490, 11793, 11997, 12117, 12164, 12147, 12076, 11962, 11811, 11631, 11428, 11209, 10978, 10737, 10491, 10244, 9995, 9747, 9501, 9259, 9020, 8785, 8553, 8325, 8101, 7881, 7663, 7448, 7237, 7029, 6822, 6616, 6414, 6213, 6014, 5817, 5623, 5431, 5240, 5051, 4866, 4684, 4502, 4326, 4152, 3980, 3814, 3651, 3491, 3337, 3185, 3038, 2895, 2756, 2623, 2493, 2367, 2247, 2130, 2018, 1910, 1806, 1707, 1611, 1519, 1432, 1348, 1269, 1191, 1119, 1050, 984, 920, 860, 802, 748, 697, 648, 602, 558, 517, 479, 442, 406, 374, 344, 315, 288, 262, 238, 216, 195, 176, 158, 141, 125, 111, 97, 85, 74, 65, 54, 46, 39, 31, 26, 20, 15, 11, 6, 4, 2, -1, -3, -4, -6, -7, -6, -7, -9, -8, -7, -6, -6, -7, -5, -5, -3, -3, -2, 0, 0, 2, 2, 3, 5, 6, 6, 8, 8, 10, 9, 11, 12, 11, 13, 14, 13, 14, 13, 15, 16, 15, 16, 16, 15, 16, 14, 13, 14, 13, 14, 12, 11, 12, 11, 9, 9, 8, 7, 6, 5, 4, 2, 1, 0, -1, -2, -4, -6, -7, -9, -10, -11, -13, -14, -16, -18, -20, -22, -24, -25, -27, -29, -31, -33, -34, -37, -38, -41, -44, -45, -48, -50, -52, -54, -56, -58, -59, -63, -64, -67, -68, -70, -73, -72, -115, -470, -1431, -3146, -5660, -8927, -12831, -16994, -20990, -24568, -27559, -29877, -31511, -32465, -32769, -32471, -31631, -30316, -28594, -26543, -24236, -21733, -19106, -16420, -13714, -11044, -8452, -5964, -3614, -1381};