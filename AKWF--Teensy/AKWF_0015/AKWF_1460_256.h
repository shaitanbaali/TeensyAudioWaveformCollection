/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1460 256 samples */
 
const int16_t AKWF_1460_256_DATA [256] = 
{7841, 8121, 8075, 8090, 8095, 8098, 8101, 8104, 8106, 8108, 8110, 8110, 8112, 8113, 8113, 8113, 8113, 8113, 8111, 8110, 8110, 8109, 8108, 8107, 8105, 8105, 8102, 8101, 8100, 8098, 8096, 8095, 8093, 8092, 8089, 8088, 8086, 8083, 8082, 8081, 8078, 8077, 8075, 8072, 8070, 8069, 8066, 8064, 8062, 8059, 8057, 8056, 8053, 8052, 8050, 8047, 8046, 8044, 8041, 8038, 8037, 8034, 8033, 8030, 8028, 8026, 8023, 8021, 8020, 8017, 8016, 8014, 8011, 8009, 8007, 8004, 8003, 8001, 7998, 7996, 7994, 7991, 7990, 7988, 7985, 7984, 7982, 7979, 7976, 7975, 7972, 7971, 7968, 7966, 7964, 7961, 7959, 7958, 7955, 7953, 7951, 7950, 7947, 7945, 7942, 7941, 7939, 7936, 7934, 7932, 7929, 7928, 7926, 7923, 7921, 7919, 7917, 7914, 7913, 7910, 7909, 7907, 7904, 7902, 7901, 7898, 7896, 7893, 7891, 7889, 7887, 7885, 7883, 7881, 7879, 7877, 7874, 7872, 7870, 7868, 7866, 7864, 7861, 7859, 7857, 7855, 7853, 7852, 7848, 7114, 11037, -14013, -35931, -32041, -32767, -32766, -32764, -32761, -32758, -32755, -32750, -32745, -32684, -32749, -32976, 1678, 11422, -22669, -34963, -32213, -32699, -32695, -32688, -32680, -32673, -32668, -32661, -32651, -31914, -35826, -11298, 11167, 7258, 7995, 8000, 8004, 8007, 8010, 8012, 8014, 8015, 8017, 8017, 8018, 8020, 8020, 8020, 8020, 8018, 8017, 8017, 8016, 8015, 8014, 8012, 8012, 8009, 8008, 8007, 8005, 8004, 8002, 8001, 7999, 7996, 7995, 7994, 7991, 7990, 7989, 7986, 7985, 7983, 7980, 7978, 7976, 7974, 7972, 7971, 7968, 7234, 11150, -10944, -35886, -31905, -32648, -32646, -32644, -32643, -32639, -32635, -32631, -32626, -32622, -32617, -32610, -32605, -32599, -32592, -32587, -32580, -32572, -32566, -32558, -32551, -32543};