/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1419 256 samples */
 
const int16_t AKWF_1419_256_DATA [256] = 
{534, 1578, 2773, 4109, 5511, 6939, 8380, 9824, 11289, 12766, 14213, 15661, 17102, 18512, 19920, 21267, 22453, 23510, 24472, 25373, 26293, 27208, 28130, 29141, 30161, 31106, 31923, 32480, 32747, 32662, 32091, 30895, 28783, 25670, 21917, 18039, 14682, 12293, 10744, 9665, 8555, 7068, 5359, 3647, 1946, 225, -1539, -3201, -4683, -6157, -7710, -9377, -11150, -12806, -14169, -15226, -16113, -17143, -18503, -20112, -21748, -23132, -24074, -24496, -24380, -23855, -23129, -22364, -21619, -20862, -20082, -19277, -18474, -17789, -17318, -17049, -16782, -16212, -15156, -13629, -11772, -9770, -7778, -5869, -4041, -2255, -496, 1243, 2976, 4681, 6303, 7723, 8829, 9682, 10463, 11345, 12431, 13703, 15027, 16233, 17189, 17883, 18396, 18802, 19167, 19535, 19889, 20171, 20291, 20181, 19841, 19305, 18636, 17912, 17171, 16390, 15530, 14571, 13507, 12341, 11088, 9776, 8442, 7141, 5928, 4813, 3758, 2688, 1523, 227, -1195, -2693, -4189, -5635, -7012, -8337, -9665, -11036, -12453, -13850, -15109, -16125, -16868, -17372, -17719, -17984, -18212, -18397, -18517, -18551, -18488, -18334, -18088, -17757, -17351, -16877, -16318, -15649, -14857, -13952, -12967, -11954, -10960, -10008, -9079, -8122, -7085, -5960, -4761, -3522, -2289, -1083, 89, 1244, 2430, 3660, 4918, 6150, 7293, 8304, 9179, 9935, 10615, 11266, 11897, 12495, 13016, 13417, 13683, 13821, 13857, 13836, 13767, 13623, 13328, 12790, 12004, 11056, 10033, 9009, 8019, 7018, 5967, 4883, 3768, 2605, 1399, 174, -1076, -2368, -3657, -4943, -6281, -7660, -9004, -10255, -11350, -12297, -13185, -14080, -14979, -15825, -16557, -17155, -17630, -18034, -18419, -18759, -19007, -19123, -19063, -18849, -18530, -18125, -17650, -17135, -16601, -16005, -15323, -14576, -13765, -12887, -11986, -11093, -10205, -9307, -8366, -7361, -6299, -5205, -4152, -3245, -2491, -1793, -1107, -328};