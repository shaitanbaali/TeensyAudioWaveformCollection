/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1480 256 samples */
 
const int16_t AKWF_1480_256_DATA [256] = 
{640, 2355, 3797, 5015, 6010, 6795, 7382, 7788, 8038, 8152, 8155, 8071, 7924, 7739, 7534, 7329, 7143, 6989, 6879, 6821, 6823, 6887, 7014, 7203, 7450, 7748, 8092, 8473, 8881, 9308, 9743, 10176, 10600, 11002, 11377, 11717, 12014, 12267, 12468, 12616, 12710, 12748, 12732, 12663, 12543, 12376, 12166, 11916, 11632, 11317, 10977, 10617, 10240, 9853, 9458, 9059, 8660, 8265, 7872, 7488, 7112, 6745, 6389, 6043, 5706, 5381, 5064, 4755, 4455, 4162, 3875, 3592, 3313, 3038, 2766, 2494, 2225, 1958, 1691, 1427, 1163, 901, 641, 385, 131, -116, -360, -598, -829, -1051, -1266, -1472, -1667, -1853, -2027, -2189, -2340, -2479, -2605, -2719, -2821, -2911, -2988, -3053, -3108, -3150, -3183, -3204, -3216, -3218, -3211, -3196, -3173, -3143, -3104, -3061, -3010, -2953, -2891, -2825, -2753, -2677, -2596, -2512, -2425, -2333, -2239, -2141, -2041, -1939, -1834, -1727, -1618, -1508, -1396, -1283, -1169, -1055, -940, -824, -710, -596, -482, -369, -257, -146, -38, 67, 172, 275, 375, 471, 566, 656, 744, 828, 909, 986, 1059, 1128, 1194, 1255, 1313, 1367, 1416, 1462, 1504, 1541, 1574, 1604, 1630, 1652, 1670, 1683, 1694, 1701, 1704, 1704, 1700, 1693, 1683, 1669, 1653, 1634, 1612, 1587, 1559, 1530, 1497, 1462, 1425, 1387, 1345, 1302, 1258, 1212, 1165, 1116, 1066, 1016, 964, 911, 858, 804, 749, 695, 639, 584, 530, 474, 420, 366, 312, 258, 206, 155, 103, 54, 5, -43, -89, -135, -180, -227, -432, -1062, -2244, -4026, -6380, -9283, -12561, -15908, -19168, -22222, -24997, -27445, -29493, -31069, -32141, -32689, -32721, -32258, -31330, -29982, -28255, -26211, -23914, -21414, -18785, -16088, -13371, -10695, -8109, -5646, -3351, -1211};