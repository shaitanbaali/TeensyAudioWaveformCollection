/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1489 256 samples */
 
const int16_t AKWF_1489_256_DATA [256] = 
{128, 433, 821, 1299, 1832, 2424, 3120, 3935, 4786, 5480, 6083, 6655, 7192, 7694, 8155, 8567, 8924, 9234, 9504, 9743, 9959, 10152, 10323, 10476, 10618, 10751, 10885, 11017, 11136, 11236, 11339, 11479, 11671, 11917, 12224, 12584, 12984, 13426, 13907, 14415, 14947, 15510, 16122, 16790, 17498, 18210, 18903, 19557, 20158, 20702, 21182, 21590, 21928, 22203, 22433, 22646, 22863, 23103, 23382, 23717, 24124, 24619, 25211, 25904, 26704, 27596, 28491, 29310, 30032, 30655, 31190, 31636, 32001, 32287, 32499, 32644, 32730, 32765, 32759, 32717, 32645, 32545, 32415, 32249, 32038, 31772, 31449, 31073, 30668, 30268, 29900, 29586, 29347, 29196, 29090, 28990, 28888, 28782, 28668, 28542, 28403, 28244, 28062, 27852, 27603, 27309, 26967, 26572, 26121, 25607, 25022, 24367, 23640, 22838, 21962, 21010, 19963, 18813, 17559, 16186, 14697, 13041, 11097, 9051, 7048, 5072, 3084, 1041, -1042, -3085, -5073, -7049, -9052, -11098, -13042, -14698, -16186, -17559, -18814, -19963, -21010, -21963, -22838, -23641, -24367, -25022, -25607, -26121, -26573, -26967, -27309, -27603, -27853, -28063, -28244, -28403, -28542, -28668, -28782, -28888, -28990, -29090, -29196, -29347, -29586, -29900, -30268, -30668, -31073, -31449, -31772, -32038, -32249, -32415, -32545, -32645, -32717, -32759, -32765, -32730, -32644, -32499, -32287, -32001, -31636, -31190, -30655, -30032, -29310, -28491, -27597, -26704, -25904, -25211, -24620, -24125, -23717, -23382, -23103, -22863, -22646, -22433, -22203, -21929, -21591, -21182, -20702, -20159, -19557, -18903, -18211, -17498, -16791, -16122, -15511, -14948, -14416, -13908, -13426, -12985, -12584, -12225, -11918, -11671, -11480, -11340, -11237, -11137, -11018, -10886, -10752, -10619, -10477, -10324, -10153, -9960, -9744, -9505, -9235, -8925, -8568, -8156, -7695, -7193, -6656, -6084, -5481, -4787, -3936, -3121, -2425, -1833, -1300, -822, -434, -129};