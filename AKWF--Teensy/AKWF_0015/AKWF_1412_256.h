/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1412 256 samples */
 
const int16_t AKWF_1412_256_DATA [256] = 
{199, 507, 809, 1111, 1413, 1717, 2021, 2324, 2627, 2929, 3232, 3535, 3838, 4139, 4441, 4743, 5043, 5346, 5648, 5948, 6247, 6548, 6847, 7147, 7445, 7743, 8043, 8339, 8637, 8933, 9228, 9525, 9820, 10114, 10408, 10701, 10994, 11287, 11579, 11869, 12158, 12448, 12738, 13026, 13312, 13599, 13884, 14170, 14454, 14737, 15020, 15302, 15582, 15863, 16142, 16419, 16696, 16972, 17248, 17523, 17795, 18067, 18339, 18608, 18878, 19145, 19411, 19677, 19942, 20205, 20468, 20728, 20988, 21246, 21504, 21760, 22016, 22269, 22520, 22772, 23022, 23270, 23518, 23763, 24007, 24250, 24492, 24731, 24970, 25207, 25443, 25676, 25909, 26140, 26370, 26599, 26825, 27049, 27273, 27496, 27715, 27933, 28152, 28367, 28582, 28793, 29003, 29211, 29419, 29624, 29828, 30030, 30229, 30427, 30624, 30819, 31012, 31203, 31393, 31580, 31766, 31950, 32132, 32312, 32182, 33783, 23617, -5439, -21934, -27002, -26873, -23739, -21480, -22040, -24459, -27124, -29129, -30278, -30727, -30732, -30518, -30240, -29986, -29785, -29629, -29497, -29358, -29197, -29010, -28795, -28562, -28317, -28067, -27821, -27577, -27340, -27108, -26882, -26658, -26436, -26216, -25997, -25778, -25557, -25337, -25113, -24887, -24659, -24428, -24195, -23959, -23722, -23481, -23240, -22997, -22750, -22505, -22257, -22006, -21755, -21503, -21251, -20998, -20742, -20487, -20229, -19971, -19713, -19453, -19189, -18927, -18662, -18396, -18131, -17863, -17592, -17323, -17052, -16780, -16507, -16233, -15957, -15681, -15405, -15126, -14848, -14569, -14287, -14006, -13724, -13439, -13155, -12871, -12585, -12299, -12011, -11724, -11435, -11145, -10855, -10565, -10273, -9981, -9688, -9395, -9101, -8807, -8512, -8216, -7919, -7623, -7327, -7030, -6730, -6433, -6133, -5834, -5534, -5235, -4935, -4634, -4333, -4032, -3730, -3429, -3126, -2825, -2523, -2220, -1917, -1614, -1311, -1008, -705, -403, -94};