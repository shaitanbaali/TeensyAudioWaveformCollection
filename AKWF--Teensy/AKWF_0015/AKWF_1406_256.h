/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1406 256 samples */
 
const int16_t AKWF_1406_256_DATA [256] = 
{1397, 5354, 7956, 10050, 11799, 13311, 14647, 15838, 16916, 17901, 18801, 19631, 20397, 21106, 21763, 22373, 22936, 23458, 23943, 24389, 24803, 25181, 25526, 25842, 26127, 26382, 26610, 26809, 26979, 27124, 27241, 27334, 27380, 27494, 27250, 22546, 20612, 19735, 18949, 18308, 17752, 17256, 16805, 16391, 16008, 15650, 15313, 14995, 14693, 14408, 14135, 13874, 13666, 13488, 13311, 13143, 12982, 12828, 12682, 12543, 12411, 12287, 12168, 12056, 11951, 11851, 11759, 11672, 11591, 11516, 11447, 11384, 11328, 11277, 11232, 11193, 11161, 11133, 11092, 11111, 11085, 2606, -1546, -3070, -4508, -5648, -6617, -7469, -8228, -8914, -9543, -10118, -10652, -11149, -11612, -12043, -12450, -12831, -13189, -13527, -13843, -14142, -14425, -14689, -14939, -15173, -15393, -15599, -15791, -15971, -16137, -16293, -16435, -16565, -16685, -16793, -16890, -16977, -17052, -17117, -17171, -17215, -17248, -17265, -17308, -17188, -16377, -16119, -15967, -15842, -15740, -15649, -15570, -15499, -15433, -15373, -15317, -15266, -15216, -15170, -15127, -15086, -15046, -15010, -14975, -14941, -14908, -14878, -14849, -14821, -14795, -14769, -14745, -14722, -14700, -14679, -14659, -14639, -14622, -14605, -14589, -14574, -14559, -14546, -14533, -14521, -14511, -14501, -14490, -14483, -14475, -14468, -14179, -15816, -9098, 27261, 23233, 21634, 20470, 19504, 18690, 17983, 17358, 16795, 16285, 15819, 15390, 14997, 14631, 14292, 13979, 13685, 13414, 13164, 12929, 12713, 12514, 12330, 12162, 12008, 11868, 11743, 11631, 11532, 11446, 11374, 11314, 11267, 11139, 11602, 9423, 575, -1773, -3439, -4747, -5831, -6762, -7583, -8321, -8988, -9599, -10162, -10683, -11169, -11624, -12047, -12445, -12819, -13170, -13502, -13815, -14109, -14385, -14645, -14890, -15119, -15335, -15538, -15726, -15903, -16065, -16215, -16356, -16484, -16600, -16705, -16798, -16881, -16953, -17015, -17066, -17107, -17138, -16914, -18233, -11212};