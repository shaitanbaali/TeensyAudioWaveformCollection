/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1498 256 samples */
 
const int16_t AKWF_1498_256_DATA [256] = 
{750, 2100, 3390, 4661, 5914, 7154, 8386, 9605, 10813, 12000, 13150, 14258, 15306, 16273, 17155, 17947, 18643, 19258, 19802, 20285, 20721, 21117, 21474, 21797, 22080, 22320, 22507, 22639, 22704, 22701, 22626, 22476, 22257, 21970, 21626, 21235, 20813, 20378, 19952, 19552, 19188, 18868, 18591, 18347, 18133, 17940, 17764, 17605, 17461, 17335, 17236, 17165, 17127, 17124, 17160, 17235, 17350, 17500, 17685, 17897, 18132, 18373, 18602, 18802, 18951, 19038, 19046, 18971, 18815, 18575, 18256, 17866, 17399, 16859, 16248, 15562, 14806, 13984, 13096, 12148, 11147, 10089, 8976, 7811, 6591, 5320, 4008, 2664, 1307, -34, -1352, -2620, -3821, -4955, -6009, -6982, -7874, -8686, -9422, -10085, -10681, -11219, -11708, -12153, -12561, -12938, -13275, -13575, -13827, -14023, -14149, -14198, -14165, -14052, -13863, -13614, -13313, -12976, -12609, -12219, -11809, -11378, -10919, -10430, -9902, -9325, -8694, -8008, -7262, -6456, -5592, -4669, -3696, -2676, -1617, -535, 559, 1646, 2705, 3722, 4685, 5581, 6408, 7159, 7835, 8442, 8977, 9444, 9852, 10212, 10537, 10833, 11115, 11388, 11661, 11931, 12200, 12462, 12708, 12928, 13111, 13240, 13305, 13301, 13222, 13066, 12835, 12533, 12160, 11716, 11206, 10627, 9983, 9285, 8534, 7746, 6935, 6108, 5278, 4457, 3639, 2828, 2021, 1210, 390, -452, -1326, -2236, -3186, -4180, -5213, -6285, -7396, -8536, -9711, -10919, -12149, -13397, -14650, -15891, -17107, -18282, -19401, -20457, -21441, -22354, -23194, -23965, -24674, -25331, -25945, -26528, -27091, -27645, -28190, -28733, -29274, -29810, -30339, -30850, -31333, -31772, -32151, -32449, -32653, -32757, -32754, -32648, -32434, -32116, -31696, -31177, -30562, -29854, -29062, -28193, -27251, -26248, -25185, -24067, -22896, -21662, -20366, -19005, -17571, -16071, -14519, -12921, -11306, -9686, -8075, -6497, -4956, -3459, -2010, -580};