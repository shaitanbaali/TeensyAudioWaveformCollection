/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1416 256 samples */
 
const int16_t AKWF_1416_256_DATA [256] = 
{2133, 5716, 9314, 12873, 16195, 19138, 21834, 24391, 26639, 28507, 30095, 31409, 32346, 32766, 32581, 31905, 30927, 29580, 27778, 25589, 23201, 20814, 18471, 16187, 14033, 12003, 10083, 8373, 7028, 6185, 5845, 5872, 6121, 6413, 6494, 6214, 5602, 4673, 3479, 2121, 634, -1000, -2770, -4539, -6232, -7790, -9116, -10361, -11723, -13318, -15242, -17443, -19610, -21507, -23075, -24258, -24960, -25060, -24602, -23807, -22855, -21842, -20901, -20172, -19726, -19573, -19662, -19889, -20192, -20539, -20869, -21132, -21311, -21368, -21179, -20565, -19445, -17875, -15920, -13773, -11677, -9643, -7649, -5690, -3731, -1848, -250, 957, 1701, 1889, 1553, 900, 151, -537, -1143, -1759, -2354, -2775, -2885, -2666, -2157, -1353, -297, 845, 1938, 2961, 3970, 5065, 6281, 7572, 8898, 10205, 11453, 12546, 13384, 13943, 14186, 14135, 13893, 13538, 13199, 13104, 13373, 14036, 15086, 16413, 17900, 19439, 20911, 22226, 23368, 24307, 24960, 25295, 25304, 24949, 24300, 23512, 22701, 21924, 21227, 20596, 19983, 19401, 18861, 18308, 17728, 17122, 16428, 15581, 14577, 13411, 12132, 10831, 9578, 8479, 7565, 6781, 6020, 5154, 4125, 2923, 1514, -83, -1782, -3570, -5528, -7677, -9934, -12155, -14224, -16089, -17701, -19066, -20259, -21315, -22196, -22819, -23133, -23193, -23093, -22880, -22604, -22368, -22199, -21941, -21558, -21114, -20602, -20061, -19564, -19046, -18357, -17516, -16647, -15725, -14769, -13886, -13156, -12622, -12175, -11678, -11105, -10449, -9712, -9063, -8581, -8086, -7425, -6648, -5813, -4944, -4183, -3680, -3375, -3127, -2925, -2658, -2088, -1183, -25, 1122, 1858, 1993, 1582, 688, -616, -2177, -3896, -5684, -7075, -7602, -7357, -6602, -5243, -3401, -1460, 354, 1890, 2918, 3491, 3877, 4124, 4053, 3580, 2833, 1928, 856, -293, -1337, -2404, -3528, -4249, -4133, -3089, -887};