/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1441 256 samples */
 
const int16_t AKWF_1441_256_DATA [256] = 
{131, 419, 721, 1038, 1373, 1720, 2085, 2463, 2854, 3258, 3672, 4100, 4534, 4981, 5434, 5897, 6365, 6841, 7322, 7820, 8174, 8386, 8596, 8803, 9010, 9223, 9440, 9667, 9902, 10140, 10386, 10638, 10896, 11153, 11421, 11690, 11967, 12254, 12549, 12851, 13160, 13489, 13821, 14165, 14526, 14903, 15281, 15666, 16080, 16501, 16903, 16900, 19599, 9561, -9093, -8063, -9253, -9139, -8439, -7287, -5764, -3932, -1864, 371, 2732, 5198, 7666, 9950, 12029, 13937, 15694, 17329, 18883, 20374, 21817, 23237, 24629, 25988, 27311, 28583, 29736, 30721, 31519, 32120, 32524, 32731, 32747, 32564, 32165, 31551, 30730, 29711, 28509, 27124, 25580, 23885, 22085, 20246, 18384, 16508, 14639, 12776, 10922, 9095, 7289, 5507, 3764, 2047, 366, -1263, -2849, -4386, -5872, -7311, -8701, -10047, -11352, -12615, -13837, -15021, -16165, -17270, -18327, -19316, -20232, -21078, -21853, -22561, -23204, -23784, -24306, -24773, -25183, -25546, -25856, -26113, -26315, -26462, -26560, -26603, -26602, -26553, -26459, -26321, -26147, -25929, -25674, -25394, -24973, -24462, -23934, -23377, -22798, -22195, -21574, -20935, -20292, -19567, -19156, -20048, -20119, -19988, -19727, -19369, -18932, -18435, -17888, -17306, -16691, -16054, -15399, -14720, -14028, -13321, -12601, -11869, -11126, -10376, -9618, -8862, -8102, -7348, -6602, -5866, -5146, -4444, -3766, -3114, -2491, -1897, -1341, -822, -343, 79, 453, 772, 1044, 1267, 1442, 1586, 1620, 2038, 2704, 3003, 3263, 3443, 3570, 3643, 3679, 3678, 3650, 3597, 3521, 3429, 3320, 3195, 3054, 2901, 2731, 2552, 2356, 2150, 1932, 1704, 1467, 1222, 976, 722, 469, 216, -35, -278, -511, -725, -899, -1059, -1204, -1332, -1443, -1535, -1609, -1660, -1690, -1704, -1691, -1655, -1600, -1521, -1421, -1299, -1153, -987, -802, -594, -366, -113};