/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1490 256 samples */
 
const int16_t AKWF_1490_256_DATA [256] = 
{315, 792, 1204, 1576, 1917, 2244, 2566, 2894, 3243, 3622, 4037, 4499, 5009, 5571, 6187, 6854, 7567, 8326, 9125, 9951, 10805, 11675, 12552, 13433, 14310, 15172, 16020, 16844, 17642, 18412, 19151, 19857, 20530, 21170, 21780, 22363, 22922, 23458, 23981, 24494, 25002, 25514, 26032, 26563, 27110, 27672, 28252, 28844, 29440, 30035, 30612, 31154, 31650, 32075, 32412, 32646, 32759, 32744, 32599, 32324, 31932, 31438, 30869, 30246, 29595, 28942, 28299, 27677, 27080, 26496, 25910, 25308, 24661, 23949, 23157, 22265, 21267, 20165, 18961, 17671, 16318, 14918, 13498, 12082, 10686, 9330, 8027, 6780, 5597, 4478, 3415, 2407, 1450, 530, -354, -1212, -2053, -2874, -3688, -4495, -5295, -6092, -6886, -7672, -8450, -9217, -9967, -10693, -11390, -12047, -12658, -13212, -13700, -14114, -14445, -14688, -14842, -14905, -14885, -14793, -14644, -14458, -14256, -14062, -13899, -13782, -13721, -13715, -13752, -13819, -13888, -13933, -13926, -13846, -13682, -13436, -13117, -12755, -12378, -12018, -11702, -11444, -11245, -11095, -10969, -10838, -10674, -10450, -10151, -9775, -9330, -8835, -8320, -7817, -7347, -6938, -6596, -6324, -6111, -5941, -5794, -5646, -5475, -5261, -4993, -4659, -4254, -3781, -3247, -2662, -2038, -1390, -733, -84, 545, 1143, 1695, 2196, 2635, 3006, 3305, 3527, 3671, 3734, 3716, 3616, 3434, 3170, 2825, 2401, 1899, 1322, 669, -54, -847, -1708, -2630, -3610, -4646, -5728, -6853, -8017, -9206, -10420, -11648, -12879, -14111, -15331, -16531, -17705, -18843, -19936, -20979, -21964, -22883, -23731, -24504, -25191, -25796, -26310, -26729, -27055, -27282, -27412, -27443, -27375, -27208, -26942, -26580, -26123, -25571, -24931, -24202, -23390, -22502, -21538, -20505, -19415, -18269, -17077, -15853, -14600, -13332, -12062, -10796, -9550, -8335, -7161, -6039, -4981, -3988, -3072, -2238, -1482, -807, -201};