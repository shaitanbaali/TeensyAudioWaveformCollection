/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1485 256 samples */
 
const int16_t AKWF_1485_256_DATA [256] = 
{12681, 14821, 6751, 2727, 2497, 2824, 4123, 6424, 8149, 8737, 8991, 9491, 10171, 10915, 11717, 12507, 13194, 13781, 14324, 14848, 15358, 15842, 16301, 16729, 17124, 17487, 17820, 18131, 18418, 18681, 18924, 19142, 19340, 19517, 19674, 19814, 19936, 20041, 20129, 20201, 20259, 20304, 20334, 20351, 20355, 20349, 20330, 20299, 20260, 20209, 20151, 20083, 20005, 19920, 19827, 19725, 19617, 19502, 19380, 19254, 19123, 18980, 18837, 18688, 18531, 18372, 18209, 18040, 17868, 17691, 17510, 17328, 17139, 16949, 16754, 16559, 16360, 16158, 15953, 15745, 15536, 15325, 15110, 14894, 14676, 14455, 14233, 14010, 13783, 13557, 13328, 13097, 12868, 12633, 12399, 12163, 11925, 11688, 11449, 11207, 10966, 10723, 10480, 10236, 9990, 9743, 9495, 9247, 8996, 8747, 8497, 8244, 7991, 7740, 7485, 7230, 6973, 6718, 6460, 6202, 5944, 5684, 5426, 5165, 4903, 4643, 4380, 4117, 3853, 3588, 3324, 3059, 2794, 2526, 2260, 1993, 1724, 1455, 1186, 916, 644, 373, 102, -169, -439, -714, -988, -1261, -1535, -1810, -2086, -2363, -2639, -2917, -3194, -3473, -3749, -4029, -4308, -4588, -4872, -5151, -5432, -5715, -5997, -6280, -6563, -6846, -7132, -7416, -7701, -7987, -8274, -8559, -8846, -9135, -9422, -9711, -9999, -10288, -10579, -10868, -11159, -11450, -11741, -12033, -12326, -12618, -12911, -13205, -13499, -13793, -14088, -14382, -14679, -14975, -15269, -15566, -15866, -16163, -16459, -16758, -17056, -17355, -17655, -17954, -18255, -18555, -18855, -19156, -19459, -19759, -20062, -20365, -20667, -20971, -21274, -21579, -21884, -22189, -22494, -22799, -23104, -23409, -23714, -24022, -24328, -24635, -24943, -25251, -25559, -25867, -26176, -26484, -26793, -27103, -27414, -27723, -28034, -28345, -28655, -28966, -29278, -29588, -29902, -30214, -30525, -30839, -31152, -31465, -31779, -32087, -32281, -33034, -28763, -7594};