/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1427 256 samples */
 
const int16_t AKWF_1427_256_DATA [256] = 
{611, 1884, 2958, 3926, 4978, 6126, 7220, 8168, 9007, 9768, 10394, 10835, 11115, 11299, 11429, 11522, 11611, 11751, 11983, 12313, 12742, 13261, 13862, 14525, 15215, 15898, 16558, 17171, 17722, 18201, 18606, 18942, 19221, 19451, 19647, 19821, 19988, 20160, 20343, 20540, 20758, 20995, 21249, 21519, 21799, 22086, 22375, 22663, 22944, 23217, 23478, 23726, 23959, 24179, 24383, 24574, 24752, 24919, 25076, 25226, 25371, 25511, 25650, 25788, 25925, 26064, 26206, 26347, 26489, 26632, 26774, 26914, 27049, 27182, 27308, 27430, 27546, 27652, 27755, 27852, 27942, 28027, 28106, 28182, 28256, 28325, 28392, 28457, 28522, 28583, 28642, 28701, 28757, 28810, 28861, 28909, 28953, 28994, 29032, 29066, 29097, 29124, 29146, 29166, 29179, 29137, 29444, 26342, 22644, 20582, 16466, 13276, 11675, 10345, 8885, 7570, 5909, 3159, -356, -3501, -5679, -7271, -8762, -10083, -10985, -11552, -12074, -12669, -13230, -13679, -14085, -14495, -14838, -15020, -15038, -14943, -14767, -14519, -14227, -13959, -13776, -13713, -13775, -13974, -14315, -14777, -15323, -15911, -16506, -17075, -17583, -18005, -18328, -18550, -18682, -18732, -18719, -18665, -18591, -18516, -18459, -18429, -18438, -18486, -18574, -18698, -18852, -19028, -19218, -19415, -19609, -19796, -19972, -20130, -20272, -20395, -20500, -20587, -20659, -20719, -20769, -20811, -20849, -20887, -20925, -20966, -21012, -21063, -21121, -21183, -21252, -21325, -21401, -21479, -21556, -21632, -21706, -21776, -21838, -21896, -21948, -21993, -22033, -22069, -22101, -22130, -22157, -22183, -22207, -22234, -22261, -22288, -22317, -22346, -22374, -22403, -22433, -22461, -22489, -22514, -22537, -22559, -22578, -22593, -22608, -22621, -22630, -22638, -22644, -22648, -22653, -22655, -22666, -22713, -22315, -29431, -27650, -26987, -28947, -25998, -22619, -21080, -19857, -18428, -18118, -18915, -18823, -16691, -13637, -11178, -9355, -7383, -5130, -3174, -1790, -608};