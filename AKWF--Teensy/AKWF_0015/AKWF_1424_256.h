/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1424 256 samples */
 
const int16_t AKWF_1424_256_DATA [256] = 
{443, 1680, 2925, 4351, 5693, 7073, 8791, 10275, 11341, 12436, 13573, 14564, 15423, 16182, 16847, 17436, 17985, 18523, 19057, 19570, 20042, 20455, 20801, 21099, 21368, 21628, 21893, 22154, 22399, 22563, 22558, 22540, 22553, 22602, 22615, 22485, 22337, 22244, 22164, 22157, 22516, 22809, 22714, 22638, 22692, 22847, 23022, 23144, 23180, 23145, 23082, 23032, 23054, 22924, 22481, 22307, 22387, 22385, 22301, 22203, 22093, 21996, 22107, 22200, 21848, 21526, 21475, 21257, 20882, 20596, 20184, 19418, 18869, 18575, 18069, 17422, 16871, 16070, 14945, 14324, 13947, 13052, 12072, 11332, 10475, 9528, 8722, 8048, 7444, 6896, 6352, 5460, 4466, 3872, 3283, 2493, 1691, 946, 315, -292, -989, -1354, -1367, -1634, -1975, -2138, -2158, -2101, -1962, -1856, -1939, -2098, -2229, -2325, -2321, -1897, -1405, -1257, -1078, -725, -231, 323, 851, 1305, 1677, 1989, 2274, 2551, 2822, 3077, 3329, 3542, 3382, 3146, 3306, 3515, 3608, 3610, 3545, 3375, 3258, 3288, 3023, 2477, 2248, 2099, 1723, 1331, 978, 170, -801, -1265, -1857, -2948, -3889, -4605, -5437, -6246, -6866, -7696, -8781, -9533, -10123, -10821, -11580, -12347, -13044, -13642, -14171, -14680, -15213, -15781, -16376, -17053, -17683, -18135, -18511, -18883, -19272, -19665, -20046, -20381, -20636, -21123, -21748, -21939, -22017, -22307, -22620, -22906, -23532, -24209, -24450, -24595, -24830, -25135, -25466, -25854, -26147, -26262, -26352, -26501, -26695, -27068, -27847, -28464, -28743, -29062, -29491, -29999, -30511, -30962, -31326, -31605, -31826, -32017, -32194, -32363, -32516, -32688, -32759, -32449, -32269, -32457, -32534, -32446, -32422, -32195, -31486, -31079, -31018, -30383, -29526, -29109, -28446, -27292, -26527, -25956, -24784, -23606, -22858, -21397, -19332, -18099, -17036, -15294, -13641, -12328, -10901, -9434, -8152, -6763, -5105, -3822, -2764, -1152};