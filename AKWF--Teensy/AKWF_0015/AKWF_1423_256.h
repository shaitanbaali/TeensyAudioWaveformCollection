/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1423 256 samples */
 
const int16_t AKWF_1423_256_DATA [256] = 
{102, 433, 783, 1245, 1582, 1770, 2003, 2198, 2425, 2847, 3232, 3312, 3385, 3817, 4331, 4438, 4288, 4422, 4870, 5153, 5090, 5061, 5298, 5581, 5783, 5901, 5777, 5605, 5879, 6332, 6303, 6102, 6346, 6713, 6834, 6987, 7228, 7458, 7817, 8254, 8530, 8768, 9277, 10013, 10566, 10804, 11338, 12436, 13234, 13319, 13639, 14693, 15751, 16231, 16461, 16914, 17684, 18443, 18807, 18939, 19319, 19723, 19765, 19855, 20119, 19890, 19410, 19452, 19268, 18048, 17170, 17440, 17016, 15423, 14984, 15241, 12546, 8077, 6911, 7527, 4582, 43, -1123, -1697, -5568, -9575, -11157, -13511, -17578, -19958, -20733, -23284, -27055, -28779, -28870, -30018, -31947, -32677, -32479, -32609, -32733, -32144, -31051, -29846, -28660, -27499, -25764, -23026, -20421, -19014, -17580, -14680, -11401, -9444, -8210, -6276, -3844, -1970, -770, 321, 1441, 2412, 3195, 3678, 3768, 3727, 3792, 3611, 2936, 2215, 1683, 1022, 157, -820, -1918, -2857, -3492, -4418, -5809, -6732, -6940, -7471, -8472, -8929, -8800, -8878, -9135, -9083, -8790, -8436, -7827, -6974, -6258, -5631, -4704, -3597, -2625, -1612, -503, 450, 1369, 2509, 3518, 4129, 4762, 5626, 6258, 6462, 6666, 7060, 7268, 7145, 7045, 7088, 6914, 6366, 5795, 5372, 4861, 4215, 3661, 3032, 2107, 1461, 1379, 910, -229, -900, -928, -1321, -2006, -2334, -2547, -2821, -2849, -2791, -2913, -2907, -2639, -2436, -2377, -2318, -2110, -1612, -1116, -941, -715, -231, 134, 376, 697, 839, 805, 1046, 1489, 1609, 1388, 1241, 1273, 1364, 1327, 901, 326, 164, 258, -32, -602, -907, -1137, -1613, -1916, -1957, -2333, -2930, -3108, -3012, -3211, -3582, -3611, -3413, -3509, -3723, -3461, -3031, -3086, -3217, -2761, -2229, -2182, -2092, -1647, -1331, -1172, -757, -277, -68};