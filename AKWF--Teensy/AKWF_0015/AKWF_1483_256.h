/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1483 256 samples */
 
const int16_t AKWF_1483_256_DATA [256] = 
{768, 3424, 5736, 7772, 9524, 11004, 12225, 13198, 13950, 14499, 14868, 15079, 15157, 15119, 14987, 14779, 14511, 14198, 13852, 13485, 13104, 12717, 12333, 11951, 11578, 11216, 10865, 10527, 10201, 9886, 9581, 9287, 9000, 8721, 8446, 8175, 7908, 7642, 7376, 7110, 6845, 6576, 6307, 6036, 5763, 5489, 5214, 4937, 4661, 4384, 4107, 3833, 3559, 3288, 3020, 2756, 2496, 2242, 1991, 1748, 1510, 1279, 1055, 838, 629, 427, 234, 48, -129, -298, -459, -612, -756, -892, -1020, -1141, -1254, -1359, -1457, -1546, -1628, -1704, -1772, -1833, -1889, -1938, -1980, -2017, -2047, -2072, -2093, -2108, -2117, -2122, -2123, -2119, -2111, -2099, -2084, -2065, -2042, -2016, -1988, -1957, -1923, -1886, -1848, -1808, -1765, -1721, -1676, -1630, -1581, -1533, -1483, -1432, -1381, -1329, -1277, -1224, -1172, -1120, -1068, -1015, -964, -912, -862, -812, -762, -713, -665, -618, -573, -528, -485, -442, -400, -360, -321, -283, -246, -212, -178, -145, -114, -84, -56, -29, -4, 20, 43, 65, 85, 104, 121, 138, 154, 168, 180, 192, 202, 212, 221, 228, 234, 239, 243, 246, 250, 251, 253, 253, 251, 250, 248, 245, 242, 237, 233, 228, 222, 217, 210, 204, 197, 189, 181, 173, 165, 157, 147, 139, 130, 121, 111, 103, 93, 84, 75, 66, 57, 48, 38, 30, 21, 12, 4, -4, -12, -20, -28, -36, -44, -51, -59, -65, -72, -79, -85, -92, -98, -104, -109, -114, -119, -124, -128, -132, -136, -139, -170, -378, -991, -2211, -4178, -6973, -10553, -14668, -18983, -23122, -26746, -29629, -31613, -32632, -32702, -31890, -30304, -28066, -25321, -22210, -18850, -15372, -11878, -8447, -5164, -2020};