/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1467 256 samples */
 
const int16_t AKWF_1467_256_DATA [256] = 
{424, 1092, 1739, 2382, 3016, 3637, 4246, 4856, 5469, 6087, 6705, 7323, 7942, 8559, 9178, 9795, 10409, 11023, 11633, 12239, 12842, 13442, 14034, 14624, 15208, 15784, 16349, 16896, 17425, 17941, 18442, 18927, 19400, 19857, 20300, 20731, 21148, 21554, 21947, 22326, 22695, 23054, 23399, 23734, 24059, 24373, 24676, 24969, 25250, 25525, 25787, 26041, 26286, 26520, 26746, 26963, 27169, 27366, 27555, 27735, 27907, 28068, 28222, 28364, 28499, 28625, 28741, 28848, 28946, 29034, 29112, 29182, 29242, 29292, 29332, 29360, 29378, 29387, 29384, 29371, 29347, 29309, 29263, 29203, 29130, 29046, 28947, 28837, 28712, 28574, 28422, 28254, 28071, 27875, 27660, 27430, 27183, 26918, 26636, 26336, 26017, 25679, 25320, 24949, 24566, 24176, 23777, 23369, 22951, 22527, 22092, 21651, 21203, 20745, 20283, 19814, 19337, 18855, 18368, 17874, 17374, 16873, 16363, 15852, 15335, 14815, 14292, 13767, 13239, 12708, 12174, 11612, 11131, 10145, 4346, -2483, -7260, -10982, -13760, -16227, -18405, -20295, -21893, -23222, -24320, -25242, -26025, -26703, -27303, -27848, -28347, -28815, -29255, -29671, -30060, -30421, -30753, -31057, -31335, -31588, -31813, -32013, -32187, -32336, -32462, -32565, -32646, -32705, -32743, -32765, -32768, -32754, -32726, -32684, -32628, -32560, -32482, -32394, -32296, -32189, -32075, -31953, -31825, -31690, -31549, -31401, -31247, -31089, -30926, -30756, -30581, -30400, -30213, -30020, -29821, -29617, -29406, -29189, -28965, -28733, -28495, -28248, -27994, -27732, -27463, -27184, -26896, -26600, -26295, -25979, -25653, -25317, -24972, -24614, -24246, -23865, -23474, -23070, -22653, -22225, -21782, -21326, -20856, -20371, -19872, -19358, -18828, -18283, -17721, -17142, -16545, -15939, -15326, -14704, -14079, -13448, -12809, -12167, -11519, -10867, -10213, -9553, -8890, -8226, -7558, -6888, -6217, -5545, -4872, -4202, -3527, -2857, -2187, -1519, -855, -183};