/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1431 256 samples */
 
const int16_t AKWF_1431_256_DATA [256] = 
{28, 157, 289, 443, 609, 788, 991, 1197, 1428, 1666, 1921, 2200, 2478, 2789, 3097, 3435, 3783, 4133, 4527, 4900, 5320, 5737, 6165, 6637, 7076, 7588, 8060, 8577, 9121, 9623, 10224, 10782, 10980, 10936, 10855, 10933, 10734, 10665, 11019, 9382, -714, -304, -448, -292, -448, -409, -422, -494, -444, -523, -500, -523, -550, -531, -581, -559, -581, -589, -582, -609, -591, -608, -601, -600, -610, -593, -602, -590, -588, -583, -572, -570, -557, -548, -534, -524, -513, -497, -486, -468, -450, -437, -418, -401, -394, -395, -395, -394, -396, -394, -397, -398, -396, -400, -395, -399, -397, -392, -422, -321, -815, -2014, -3067, -4145, -5191, -6236, -7260, -8272, -9268, -10241, -11213, -12150, -13097, -14006, -14915, -15809, -16670, -17551, -18372, -19220, -20028, -20814, -21629, -22359, -23154, -23866, -24595, -25329, -25975, -26718, -27321, -28010, -28645, -29214, -29913, -30388, -31069, -31554, -32148, -32510, -31082, -30283, -29055, -27490, -28888, -18944, 2053, -1076, -79, -484, -325, -278, -434, -248, -399, -315, -321, -375, -286, -379, -307, -339, -347, -309, -363, -309, -346, -334, -324, -352, -317, -349, -328, -335, -341, -328, -347, -332, -342, -338, -336, -345, -336, -345, -340, -344, -345, -342, -348, -344, -346, -347, -348, -350, -351, -352, -352, -353, -352, -355, -352, -350, -351, -352, -354, -357, -356, -358, -357, -359, -360, -362, -363, -362, -363, -364, -365, -366, -367, -370, -369, -371, -372, -372, -374, -375, -376, -376, -378, -378, -380, -382, -382, -383, -383, -384, -386, -388, -389, -389, -390, -392, -394, -393, -395, -395, -396, -397, -400, -400, -382, -350, -303, -244, -167, -72};