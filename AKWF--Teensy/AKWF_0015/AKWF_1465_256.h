/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1465 256 samples */
 
const int16_t AKWF_1465_256_DATA [256] = 
{475, 1230, 1964, 2702, 3437, 4171, 4904, 5632, 6360, 7084, 7804, 8522, 9234, 9943, 10646, 11346, 12036, 12725, 13407, 14081, 14749, 15411, 16063, 16711, 17349, 17978, 18593, 19188, 19762, 20320, 20861, 21384, 21891, 22383, 22857, 23318, 23764, 24196, 24615, 25019, 25410, 25790, 26156, 26510, 26854, 27186, 27506, 27816, 28115, 28403, 28683, 28951, 29210, 29458, 29698, 29930, 30150, 30361, 30564, 30760, 30945, 31122, 31289, 31447, 31598, 31740, 31872, 31995, 32111, 32217, 32314, 32403, 32483, 32551, 32612, 32663, 32703, 32734, 32756, 32766, 32766, 32757, 32736, 32703, 32659, 32603, 32536, 32455, 32363, 32256, 32136, 32002, 31854, 31693, 31514, 31320, 31111, 30884, 30641, 30378, 30099, 29801, 29482, 29154, 28816, 28470, 28117, 27758, 27389, 27017, 26638, 26251, 25861, 25463, 25062, 24656, 24245, 23831, 23413, 22990, 22490, 22359, 20172, 9464, 567, -3934, -6778, -8782, -10364, -11712, -12922, -14041, -15085, -16070, -17005, -17891, -18736, -19543, -20310, -21047, -21751, -22424, -23071, -23693, -24288, -24860, -25412, -25940, -26449, -26939, -27410, -27864, -28299, -28718, -29113, -29481, -29824, -30143, -30439, -30714, -30967, -31199, -31412, -31607, -31784, -31944, -32087, -32214, -32326, -32423, -32506, -32577, -32633, -32676, -32706, -32725, -32733, -32729, -32712, -32687, -32651, -32602, -32546, -32479, -32401, -32315, -32218, -32114, -31998, -31874, -31742, -31600, -31449, -31288, -31120, -30942, -30754, -30559, -30354, -30140, -29916, -29683, -29440, -29189, -28926, -28653, -28372, -28079, -27777, -27463, -27138, -26803, -26455, -26096, -25724, -25341, -24942, -24534, -24109, -23672, -23220, -22753, -22272, -21774, -21260, -20729, -20183, -19616, -19034, -18432, -17809, -17176, -16534, -15884, -15228, -14565, -13893, -13216, -12531, -11842, -11147, -10446, -9740, -9031, -8316, -7597, -6875, -6150, -5421, -4692, -3957, -3224, -2487, -1750, -1014, -263};