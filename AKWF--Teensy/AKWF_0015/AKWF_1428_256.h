/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1428 256 samples */
 
const int16_t AKWF_1428_256_DATA [256] = 
{2203, 5898, 8541, 10435, 12227, 13977, 15348, 16293, 17132, 18055, 18949, 19681, 20288, 20845, 21302, 21540, 21530, 21339, 21025, 20610, 20121, 19643, 19265, 19034, 18968, 19080, 19379, 19847, 20441, 21110, 21804, 22478, 23094, 23610, 24006, 24275, 24421, 24457, 24398, 24274, 24110, 23931, 23759, 23611, 23503, 23439, 23423, 23452, 23520, 23620, 23734, 23864, 24067, 21384, 19311, 17635, 14705, 12721, 11707, 10738, 9696, 8724, 7375, 5197, 2592, 396, -1111, -2276, -3376, -4308, -4916, -5303, -5681, -6096, -6457, -6736, -6990, -7240, -7429, -7496, -7451, -7337, -7172, -6959, -6728, -6526, -6397, -6356, -6408, -6560, -6811, -7143, -7525, -7931, -8332, -8705, -9027, -9282, -9460, -9567, -9605, -9585, -9522, -9431, -9329, -9230, -9144, -9081, -9045, -9038, -9059, -9104, -9169, -9248, -9334, -9395, -9610, -8814, -6958, -6185, -4532, -2976, -2167, -1599, -955, -351, 323, 1433, 2966, 4442, 5505, 6245, 6897, 7493, 7913, 8152, 8337, 8547, 8748, 8897, 9015, 9131, 9227, 9257, 9210, 9108, 8963, 8788, 8655, 5743, 3464, 1635, -1329, -3301, -4249, -5075, -5912, -6640, -7712, -9582, -11881, -13815, -15122, -16145, -17147, -18028, -18630, -19043, -19462, -19919, -20319, -20630, -20896, -21137, -21293, -21307, -21192, -20987, -20714, -20331, -20235, -18168, -14042, -12208, -8734, -5571, -4042, -3112, -2106, -1230, -230, 1648, 4423, 7152, 9125, 10525, 11823, 13074, 14030, 14658, 15196, 15792, 16364, 16814, 17171, 17493, 17740, 17826, 17729, 17493, 17154, 16741, 16379, 11474, 7620, 4528, -393, -3654, -5207, -6525, -7835, -8946, -10608, -13572, -17238, -20319, -22395, -24023, -25638, -27072, -28067, -28769, -29490, -30280, -30980, -31531, -32006, -32433, -32714, -32755, -32573, -32238, -31786, -31163, -30914, -28012, -22352, -19827, -15097, -10829, -8792, -7584, -6290, -5187, -3924, -1374};