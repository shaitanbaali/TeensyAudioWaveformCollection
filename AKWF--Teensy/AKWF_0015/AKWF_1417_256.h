/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1417 256 samples */
 
const int16_t AKWF_1417_256_DATA [256] = 
{1794, 4565, 7275, 9963, 12588, 15125, 17547, 19823, 21931, 23850, 25570, 27093, 28402, 29486, 30349, 30984, 31387, 31558, 31498, 31211, 30697, 29964, 29016, 27856, 26488, 24916, 23144, 21184, 19049, 16739, 14284, 11688, 8975, 6177, 3311, 404, -2497, -5370, -8189, -10901, -13489, -15927, -18192, -20284, -22197, -23922, -25474, -26853, -28065, -29122, -30033, -30804, -31444, -31957, -32343, -32606, -32746, -32759, -32637, -32377, -31978, -31435, -30750, -29927, -28971, -27900, -26726, -25457, -24113, -22698, -21238, -19756, -18275, -16812, -15391, -14008, -12674, -11396, -10166, -8985, -7857, -6768, -5718, -4699, -3698, -2706, -1717, -721, 287, 1306, 2338, 3373, 4405, 5423, 6414, 7377, 8308, 9198, 10048, 10849, 11592, 12277, 12898, 13461, 13972, 14438, 14871, 15271, 15645, 15992, 16308, 16584, 16815, 16987, 17098, 17140, 17107, 16992, 16794, 16507, 16117, 15631, 15052, 14383, 13631, 12801, 11900, 10935, 9911, 8842, 7726, 6569, 5382, 4166, 2926, 1679, 426, -825, -2058, -3265, -4433, -5547, -6602, -7586, -8486, -9300, -10019, -10640, -11160, -11571, -11874, -12070, -12154, -12137, -12003, -11762, -11411, -10940, -10358, -9662, -8848, -7933, -6912, -5798, -4630, -3447, -2259, -1045, 185, 1415, 2639, 3874, 5111, 6356, 7614, 8894, 10188, 11502, 12832, 14164, 15500, 16818, 18104, 19336, 20491, 21548, 22492, 23304, 23980, 24507, 24881, 25105, 25173, 25103, 24914, 24618, 24244, 23805, 23312, 22766, 22167, 21507, 20783, 19986, 19104, 18128, 17041, 15828, 14493, 13021, 11416, 9689, 7847, 5906, 3894, 1825, -270, -2359, -4435, -6468, -8450, -10382, -12239, -14022, -15734, -17372, -18938, -20443, -21880, -23244, -24530, -25718, -26798, -27750, -28550, -29184, -29632, -29880, -29913, -29724, -29300, -28645, -27759, -26652, -25324, -23791, -22070, -20190, -18175, -15992, -13669, -11253, -8757, -6189, -3568, -841};