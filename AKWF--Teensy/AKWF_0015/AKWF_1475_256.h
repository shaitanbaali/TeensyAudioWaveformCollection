/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1475 256 samples */
 
const int16_t AKWF_1475_256_DATA [256] = 
{14776, 18485, 17588, 17565, 17398, 17239, 17074, 16915, 16755, 16593, 16437, 16277, 16123, 15968, 15813, 15660, 15508, 15354, 15205, 15055, 14907, 14761, 14613, 14468, 14323, 14180, 14037, 13897, 13759, 13620, 13483, 13347, 13213, 13079, 12945, 12814, 12684, 12555, 12427, 12301, 12174, 12049, 11926, 11802, 11680, 11559, 11440, 11322, 11201, 11084, 10968, 10851, 10740, 10740, 10021, 14076, 24851, 25800, 25224, 25013, 24730, 24446, 24167, 23891, 23612, 23340, 23069, 22797, 22532, 22266, 22003, 21743, 21484, 21230, 20976, 20724, 20475, 20227, 19982, 19739, 19497, 19259, 19022, 18788, 18556, 18325, 18098, 17870, 17645, 17425, 17203, 16985, 16769, 16554, 16343, 16132, 15923, 15716, 15511, 15306, 15108, 14908, 14710, 14515, 14321, 14130, 13939, 13749, 13563, 13377, 13194, 13013, 12832, 12654, 12477, 12302, 12127, 11956, 11786, 11616, 11449, 11284, 11118, 10957, 10796, 10635, 10479, 10323, 10167, 10016, 9863, 9711, 9564, 9415, 9271, 9125, 8980, 8839, 8699, 8557, 8421, 8283, 8150, 8016, 7882, 7753, 7619, 7489, 7359, 7001, 7984, 719, -21314, -24363, -23384, -23329, -23083, -22850, -22615, -22384, -22154, -21924, -21699, -21475, -21249, -21029, -20810, -20592, -20376, -20160, -19951, -19739, -19529, -19325, -19119, -18914, -18712, -18510, -18314, -18116, -17922, -17837, -17111, -20837, -31506, -32637, -31925, -31648, -31283, -30923, -30567, -30213, -29862, -29515, -29171, -28829, -28490, -28153, -27821, -27490, -27162, -26837, -26517, -26200, -25881, -25567, -25259, -24951, -24647, -24343, -24044, -23749, -23453, -23162, -22874, -22586, -22301, -22020, -21741, -21465, -21190, -20919, -20649, -20383, -20118, -19855, -19596, -19339, -19084, -18832, -18581, -18332, -18087, -17842, -17602, -17364, -17126, -16893, -16660, -16431, -16205, -15979, -15756, -15535, -15314, -15098, -14881, -14668, -14458, -14245, -14041, -13830, -13623, -13271, -13917, -7236};