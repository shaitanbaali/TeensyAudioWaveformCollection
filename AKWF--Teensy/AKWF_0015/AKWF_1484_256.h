/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1484 256 samples */
 
const int16_t AKWF_1484_256_DATA [256] = 
{248, 1625, 3981, 7304, 11370, 15842, 20317, 24402, 27820, 30381, 32005, 32723, 32626, 31851, 30555, 28891, 27002, 25000, 22980, 21016, 19147, 17411, 15827, 14397, 13129, 12021, 11060, 10241, 9554, 8984, 8519, 8149, 7859, 7638, 7474, 7357, 7277, 7225, 7193, 7177, 7167, 7162, 7158, 7149, 7138, 7117, 7090, 7054, 7011, 6957, 6896, 6828, 6752, 6669, 6581, 6486, 6388, 6287, 6180, 6073, 5964, 5854, 5743, 5632, 5521, 5410, 5301, 5192, 5085, 4979, 4875, 4772, 4670, 4569, 4471, 4376, 4280, 4186, 4094, 4003, 3913, 3824, 3736, 3650, 3564, 3479, 3396, 3312, 3228, 3148, 3067, 2986, 2906, 2828, 2751, 2674, 2599, 2524, 2449, 2375, 2303, 2230, 2157, 2086, 2017, 1947, 1878, 1809, 1742, 1675, 1609, 1545, 1482, 1420, 1357, 1296, 1234, 1174, 1112, 1051, 991, 931, 872, 814, 757, 698, 642, 587, 515, 233, -586, -2190, -4650, -7874, -11615, -15534, -19308, -22647, -25336, -27277, -28443, -28878, -28684, -27978, -26893, -25543, -24037, -22468, -20892, -19367, -17923, -16579, -15352, -14249, -13263, -12400, -11648, -11002, -10456, -10000, -9621, -9315, -9068, -8871, -8718, -8599, -8507, -8436, -8378, -8332, -8291, -8252, -8211, -8168, -8119, -8064, -8004, -7937, -7864, -7782, -7695, -7601, -7502, -7398, -7290, -7177, -7061, -6943, -6822, -6699, -6575, -6450, -6325, -6200, -6074, -5950, -5827, -5705, -5582, -5462, -5344, -5225, -5109, -4994, -4881, -4768, -4657, -4547, -4438, -4330, -4223, -4118, -4014, -3910, -3809, -3710, -3611, -3513, -3417, -3322, -3228, -3133, -3041, -2949, -2858, -2769, -2680, -2592, -2504, -2417, -2332, -2247, -2162, -2079, -1995, -1912, -1831, -1751, -1671, -1592, -1515, -1440, -1365, -1291, -1218, -1148, -1076, -1007, -937, -869, -801, -734, -668, -601, -537, -342};