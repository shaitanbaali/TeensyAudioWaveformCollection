/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1479 256 samples */
 
const int16_t AKWF_1479_256_DATA [256] = 
{113, 484, 834, 1179, 1521, 1867, 2216, 2571, 2934, 3305, 3681, 4065, 4454, 4844, 5236, 5627, 6013, 6392, 6764, 7123, 7470, 7801, 8113, 8408, 8682, 8934, 9164, 9370, 9554, 9712, 9848, 9959, 10047, 10113, 10155, 10177, 10177, 10157, 10118, 10060, 9985, 9893, 9785, 9663, 9526, 9378, 9216, 9043, 8860, 8667, 8464, 8253, 8035, 7808, 7576, 7338, 7094, 6845, 6592, 6336, 6077, 5814, 5549, 5284, 5017, 4750, 4482, 4214, 3948, 3684, 3420, 3160, 2902, 2647, 2396, 2148, 1906, 1668, 1435, 1208, 987, 771, 562, 360, 164, -23, -204, -378, -544, -701, -852, -994, -1128, -1254, -1372, -1482, -1585, -1678, -1764, -1841, -1911, -1973, -2026, -2073, -2112, -2143, -2168, -2185, -2195, -2199, -2197, -2188, -2173, -2152, -2125, -2094, -2056, -2014, -1968, -1917, -1862, -1802, -1740, -1673, -1603, -1531, -1456, -1378, -1299, -1218, -1134, -1049, -964, -877, -790, -702, -614, -526, -438, -350, -264, -177, -92, -7, 74, 155, 236, 314, 389, 463, 535, 605, 672, 737, 799, 859, 915, 969, 1020, 1068, 1113, 1155, 1194, 1230, 1264, 1293, 1320, 1344, 1365, 1381, 1396, 1407, 1416, 1422, 1425, 1424, 1421, 1416, 1408, 1397, 1384, 1369, 1351, 1330, 1308, 1285, 1259, 1231, 1201, 1170, 1137, 1102, 1066, 1029, 990, 951, 910, 869, 827, 785, 740, 697, 653, 608, 563, 518, 473, 429, 384, 339, 295, 252, 208, 166, 124, 83, 42, 4, -33, -82, -128, -152, -3598, -10645, -16914, -22560, -27116, -31377, -32460, -30047, -28260, -26745, -25945, -25159, -23857, -22159, -20348, -18594, -16924, -15315, -13747, -12213, -10747, -9383, -8129, -6988, -5957, -5019, -4176, -3420, -2745, -2143, -1605, -1117, -675, -260};