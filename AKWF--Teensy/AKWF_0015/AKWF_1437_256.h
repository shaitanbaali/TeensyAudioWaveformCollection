/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1437 256 samples */
 
const int16_t AKWF_1437_256_DATA [256] = 
{11712, 18701, 17392, 17857, 18072, 18260, 18439, 18633, 18830, 19017, 19201, 19394, 19584, 19767, 19956, 20146, 20330, 20515, 20703, 20890, 21073, 21258, 21445, 21630, 21811, 21998, 22184, 22367, 22547, 22733, 22919, 23097, 23279, 23469, 23655, 23824, 23796, 25176, 20081, 8798, 10495, 10203, 10278, 10337, 10378, 10420, 10472, 10523, 10569, 10617, 10667, 10717, 10764, 10814, 10865, 10914, 10963, 11015, 11064, 11114, 11164, 11214, 11264, 11315, 11365, 11415, 11464, 11517, 11566, 11615, 11667, 11717, 11767, 11818, 11868, 11917, 11969, 12019, 12069, 12119, 12169, 12219, 12270, 12320, 12370, 12420, 12470, 12521, 12570, 12621, 12671, 12721, 12771, 12821, 12870, 12920, 12970, 13019, 13070, 13120, 13169, 13220, 13270, 13318, 13372, 13402, 13391, 13386, 13379, 13372, 13365, 13357, 13351, 13344, 13336, 13329, 13323, 13314, 13308, 13301, 13293, 13286, 13280, 13273, 13264, 13259, 13252, 13241, 13236, 13233, 13222, 13213, 13211, 13203, 13189, 13187, 13185, 13169, 13160, 13165, 13156, 13131, 13131, 13157, 13163, 12251, 16797, -8959, -31463, -26790, -27707, -27704, -27673, -27657, -27670, -27671, -27654, -27647, -27648, -27638, -27624, -27619, -27613, -27597, -27587, -27581, -27567, -27554, -27545, -27533, -27518, -27507, -27496, -27481, -27468, -27457, -27443, -27428, -27416, -27402, -27387, -27374, -27360, -27345, -27332, -27318, -27304, -27288, -27274, -27267, -27223, -26856, -26459, -26071, -25679, -25290, -24900, -24510, -24118, -23728, -23340, -22949, -22560, -22170, -21780, -21392, -21002, -20612, -20225, -19836, -19447, -19059, -18671, -18281, -17894, -17506, -17119, -16732, -16345, -15959, -15571, -15185, -14799, -14412, -14026, -13641, -13256, -12869, -12486, -12101, -11715, -11331, -10947, -10562, -10179, -9795, -9410, -9027, -8645, -8263, -7878, -7496, -7116, -6732, -6348, -5971, -5589, -5201, -4825, -4451, -4062, -3671, -3304, -3028, -2124, -3985};