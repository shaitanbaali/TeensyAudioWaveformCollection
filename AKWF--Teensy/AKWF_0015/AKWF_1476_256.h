/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1476 256 samples */
 
const int16_t AKWF_1476_256_DATA [256] = 
{4836, 6297, 5899, 5913, 5866, 5814, 5769, 5721, 5671, 5626, 5577, 5530, 5484, 5435, 5390, 5344, 5299, 5253, 5206, 5161, 5117, 5072, 5028, 4983, 4939, 4896, 4851, 4808, 4765, 4722, 4679, 4637, 4596, 4555, 4513, 4473, 4431, 4392, 4352, 4312, 4273, 4232, 4195, 4156, 4117, 4080, 4041, 4005, 3968, 3932, 3895, 3860, 3824, 3787, 3752, 3718, 3683, 3649, 3614, 3581, 3547, 3514, 3480, 3448, 3415, 3383, 3350, 3319, 3288, 3256, 3225, 3195, 3164, 3134, 3103, 3075, 3045, 3016, 2986, 2957, 2930, 2901, 2873, 2845, 2818, 2790, 2762, 2737, 2710, 2683, 2657, 2630, 2605, 2579, 2555, 2528, 2505, 2479, 2455, 2430, 2405, 2381, 2356, 2333, 2309, 2286, 2263, 2241, 2218, 2194, 2173, 2150, 2130, 2108, 2086, 2065, 2043, 2023, 2003, 1982, 1963, 1942, 1924, 1908, 1887, 2056, 1169, 7253, 25344, 27762, 26821, 26663, 26340, 26030, 25720, 25411, 25110, 24805, 24506, 24211, 23914, 23624, 23334, 23046, 22765, 22481, 22202, 21928, 21650, 21381, 21113, 20843, 20581, 20147, 20744, 14466, -3922, -6715, -6036, -6131, -6083, -6031, -5983, -5936, -5886, -5839, -5791, -5743, -5697, -5648, -5602, -5556, -5509, -5463, -5416, -5370, -5326, -5281, -5234, -5190, -5147, -5103, -5058, -5015, -4973, -4928, -4886, -4844, -4801, -4760, -4718, -4677, -4636, -4596, -4555, -4516, -4476, -4436, -4396, -4359, -4319, -4281, -4243, -4205, -4168, -4131, -4094, -4058, -4021, -3986, -3949, -3914, -3880, -3843, -3810, -3776, -3741, -3709, -3676, -3642, -3611, -3577, -3546, -3519, -3496, -3677, -2532, -12793, -31918, -32468, -31799, -31535, -31162, -30802, -30441, -30081, -29731, -29376, -29029, -28684, -28339, -28001, -27663, -27330, -27001, -26670, -26347, -26024, -25703, -25390, -25075, -24762, -24451, -23979, -24647, -14605};