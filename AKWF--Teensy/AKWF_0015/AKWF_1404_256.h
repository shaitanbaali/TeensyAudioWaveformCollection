/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1404 256 samples */
 
const int16_t AKWF_1404_256_DATA [256] = 
{2069, 6626, 9895, 12638, 15003, 17091, 18961, 20646, 22175, 23570, 24837, 25993, 27044, 27992, 28848, 29613, 30289, 30881, 31390, 31816, 32163, 32432, 32620, 32704, 32899, 30368, 28155, 27124, 26174, 25363, 24641, 23981, 23366, 22790, 22245, 21725, 21227, 20748, 20284, 19836, 19400, 18976, 18562, 18157, 17760, 17373, 16992, 16617, 16249, 15886, 15529, 15176, 14829, 14486, 14148, 13812, 13480, 13153, 12828, 12507, 12189, 11872, 11560, 11250, 10942, 10637, 10334, 10033, 9735, 9439, 9144, 8851, 8560, 8271, 7985, 7700, 7415, 7132, 6852, 6572, 6295, 6019, 5745, 5471, 5198, 4928, 4660, 4390, 4123, 3857, 3592, 3329, 3067, 2806, 2547, 2288, 2029, 1773, 1518, 1262, 1010, 757, 506, 255, 7, -242, -486, -742, -928, -1014, -1114, -1215, -1320, -1425, -1534, -1643, -1752, -1863, -1973, -2084, -2196, -2307, -2419, -2531, -2644, -2757, -2868, -2980, -3092, -3202, -3313, -3424, -3534, -3645, -3754, -3863, -3973, -4082, -4189, -4298, -4405, -4511, -4618, -4724, -4829, -4934, -5038, -5142, -5244, -5347, -5449, -5551, -5651, -5751, -5851, -5950, -6048, -6146, -6242, -6339, -6434, -6528, -6623, -6717, -6810, -6902, -6993, -7084, -7174, -7263, -7350, -7438, -7525, -7611, -7697, -7781, -7865, -7949, -8030, -8111, -8192, -8272, -8351, -8429, -8506, -8583, -8657, -8733, -8806, -8879, -8951, -9022, -9092, -9161, -9229, -9296, -9362, -9429, -9493, -9556, -9620, -9680, -9741, -9802, -9860, -9917, -9975, -10030, -10084, -10138, -10190, -10242, -10292, -10342, -10390, -10438, -10484, -10528, -10572, -10615, -10657, -10698, -10737, -10776, -10813, -10848, -10883, -10917, -10950, -10981, -11011, -11039, -11066, -11092, -11118, -11142, -11164, -11186, -11205, -11225, -11242, -11258, -11273, -11287, -11299, -11309, -11319, -11327, -11335, -11340, -11343, -11345, -11348, -11197, -12001, -7677};