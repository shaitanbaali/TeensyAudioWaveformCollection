/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1418 256 samples */
 
const int16_t AKWF_1418_256_DATA [256] = 
{418, 1586, 2691, 3760, 4793, 5801, 6794, 7787, 8791, 9815, 10865, 11948, 13069, 14218, 15394, 16578, 17754, 18912, 20032, 21096, 22080, 22964, 23737, 24399, 24949, 25395, 25746, 26023, 26239, 26405, 26524, 26583, 26567, 26456, 26202, 25744, 25000, 23869, 22301, 20302, 17931, 15301, 12536, 9721, 6935, 4246, 1707, -607, -2666, -4504, -6162, -7684, -9124, -10543, -12009, -13578, -15262, -17048, -18894, -20733, -22513, -24210, -25809, -27295, -28648, -29840, -30850, -31665, -32263, -32631, -32767, -32675, -32351, -31787, -30989, -29960, -28729, -27345, -25867, -24365, -22894, -21467, -20090, -18758, -17456, -16169, -14874, -13526, -12096, -10543, -8831, -6951, -4908, -2705, -393, 1975, 4331, 6591, 8710, 10660, 12417, 13983, 15356, 16536, 17534, 18363, 19048, 19621, 20102, 20508, 20854, 21143, 21366, 21507, 21553, 21495, 21326, 21046, 20661, 20168, 19574, 18874, 18065, 17149, 16121, 14968, 13700, 12315, 10823, 9248, 7608, 5917, 4205, 2488, 787, -866, -2459, -3969, -5380, -6698, -7931, -9092, -10213, -11306, -12379, -13432, -14454, -15434, -16363, -17220, -17992, -18659, -19197, -19591, -19828, -19904, -19820, -19581, -19201, -18692, -18068, -17339, -16515, -15599, -14606, -13542, -12420, -11257, -10060, -8838, -7597, -6338, -5069, -3798, -2524, -1255, 6, 1266, 2528, 3799, 5089, 6396, 7706, 9015, 10299, 11539, 12721, 13823, 14829, 15729, 16500, 17129, 17612, 17946, 18135, 18197, 18142, 17986, 17737, 17395, 16950, 16410, 15782, 15070, 14280, 13417, 12480, 11471, 10407, 9285, 8113, 6905, 5659, 4382, 3078, 1750, 399, -978, -2380, -3783, -5168, -6523, -7827, -9070, -10244, -11326, -12301, -13157, -13884, -14486, -14974, -15355, -15636, -15824, -15921, -15930, -15858, -15708, -15479, -15171, -14789, -14327, -13780, -13148, -12430, -11628, -10751, -9805, -8801, -7749, -6651, -5518, -4351, -3158, -1954, -730};