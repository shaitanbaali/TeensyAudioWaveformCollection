/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri 256 samples */
 
const int16_t AKWF_tri_256_DATA [256] = 
{358, 878, 1389, 1900, 2412, 2924, 3437, 3948, 4460, 4973, 5484, 5996, 6509, 7020, 7533, 8045, 8556, 9068, 9581, 10093, 10605, 11117, 11628, 12141, 12653, 13165, 13677, 14189, 14700, 15214, 15725, 16237, 16749, 17261, 17773, 18285, 18797, 19308, 19822, 20333, 20845, 21358, 21868, 22382, 22893, 23405, 23917, 24429, 24941, 25453, 25966, 26476, 26990, 27502, 28013, 28526, 29037, 29549, 30061, 30574, 31085, 31596, 32105, 32635, 32442, 31880, 31379, 30867, 30355, 29843, 29330, 28819, 28308, 27794, 27284, 26771, 26258, 25747, 25235, 24723, 24211, 23699, 23186, 22675, 22163, 21650, 21139, 20626, 20115, 19603, 19090, 18578, 18067, 17555, 17042, 16531, 16018, 15507, 14995, 14482, 13970, 13459, 12946, 12435, 11922, 11409, 10899, 10387, 9874, 9362, 8850, 8338, 7827, 7314, 6801, 6291, 5778, 5266, 4754, 4241, 3730, 3218, 2706, 2193, 1682, 1169, 658, 147, -366, -877, -1389, -1901, -2413, -2925, -3437, -3949, -4460, -4974, -5485, -5997, -6510, -7020, -7534, -8046, -8557, -9069, -9582, -10093, -10606, -11118, -11628, -12141, -12654, -13165, -13677, -14189, -14701, -15214, -15725, -16237, -16749, -17261, -17774, -18286, -18797, -19309, -19822, -20333, -20845, -21358, -21869, -22382, -22893, -23405, -23917, -24430, -24941, -25453, -25966, -26476, -26990, -27502, -28013, -28526, -29037, -29549, -30062, -30574, -31085, -31596, -32105, -32635, -32442, -31880, -31379, -30867, -30355, -29844, -29331, -28819, -28308, -27794, -27284, -26771, -26258, -25748, -25235, -24723, -24211, -23699, -23186, -22675, -22163, -21650, -21140, -20626, -20115, -19603, -19090, -18579, -18067, -17555, -17043, -16531, -16019, -15507, -14996, -14482, -13971, -13459, -12947, -12435, -11923, -11410, -10899, -10387, -9875, -9363, -8851, -8338, -7827, -7315, -6802, -6292, -5778, -5267, -4755, -4242, -3731, -3219, -2707, -2194, -1683, -1171, -661, -141};