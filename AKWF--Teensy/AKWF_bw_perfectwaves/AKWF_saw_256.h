/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw 256 samples */
 
const int16_t AKWF_saw_256_DATA [256] = 
{69, 330, 585, 841, 1097, 1353, 1609, 1865, 2121, 2377, 2633, 2889, 3145, 3401, 3657, 3913, 4168, 4425, 4681, 4937, 5193, 5449, 5705, 5961, 6217, 6472, 6729, 6985, 7241, 7497, 7753, 8009, 8265, 8521, 8777, 9033, 9289, 9545, 9801, 10057, 10313, 10569, 10825, 11081, 11337, 11593, 11849, 12105, 12360, 12617, 12873, 13129, 13385, 13641, 13897, 14153, 14409, 14665, 14921, 15177, 15433, 15689, 15945, 16201, 16457, 16713, 16969, 17225, 17481, 17737, 17993, 18249, 18505, 18761, 19017, 19273, 19529, 19785, 20041, 20297, 20553, 20809, 21065, 21321, 21577, 21833, 22089, 22345, 22601, 22857, 23113, 23369, 23624, 23881, 24137, 24393, 24649, 24905, 25161, 25417, 25673, 25929, 26185, 26441, 26697, 26953, 27209, 27465, 27721, 27977, 28233, 28489, 28745, 29001, 29257, 29513, 29769, 30025, 30281, 30537, 30793, 31049, 31305, 31561, 31817, 31805, 33372, 28807, -28916, -33481, -31914, -31926, -31670, -31414, -31158, -30902, -30647, -30390, -30134, -29878, -29622, -29366, -29110, -28854, -28599, -28342, -28086, -27831, -27574, -27318, -27062, -26806, -26550, -26295, -26038, -25782, -25526, -25270, -25014, -24758, -24502, -24247, -23991, -23734, -23478, -23223, -22966, -22710, -22455, -22198, -21943, -21686, -21430, -21175, -20919, -20662, -20407, -20150, -19894, -19639, -19383, -19126, -18871, -18614, -18359, -18103, -17846, -17591, -17335, -17078, -16822, -16567, -16310, -16055, -15799, -15542, -15286, -15031, -14774, -14519, -14263, -14007, -13751, -13495, -13238, -12983, -12727, -12470, -12215, -11959, -11703, -11447, -11191, -10935, -10679, -10422, -10167, -9911, -9655, -9399, -9143, -8887, -8631, -8375, -8119, -7863, -7607, -7351, -7095, -6839, -6583, -6327, -6071, -5815, -5559, -5303, -5046, -4791, -4535, -4279, -4023, -3767, -3511, -3255, -2999, -2743, -2487, -2231, -1975, -1719, -1463, -1207, -951, -695, -440, -180};