/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin 256 samples */
 
const int16_t AKWF_sin_256_DATA [256] = 
{220, 1037, 1838, 2641, 3440, 4239, 5036, 5829, 6618, 7404, 8185, 8961, 9733, 10496, 11255, 12008, 12751, 13489, 14218, 14937, 15649, 16351, 17042, 17725, 18396, 19055, 19705, 20341, 20965, 21577, 22175, 22760, 23333, 23890, 24433, 24962, 25475, 25973, 26456, 26922, 27372, 27807, 28223, 28623, 29007, 29372, 29719, 30049, 30361, 30654, 30929, 31185, 31423, 31641, 31840, 32021, 32182, 32324, 32446, 32549, 32631, 32695, 32738, 32763, 32767, 32751, 32716, 32661, 32586, 32492, 32378, 32245, 32092, 31920, 31729, 31518, 31289, 31041, 30774, 30488, 30185, 29862, 29522, 29165, 28789, 28396, 27987, 27559, 27116, 26657, 26181, 25689, 25183, 24660, 24124, 23572, 23006, 22427, 21834, 21227, 20609, 19978, 19333, 18679, 18012, 17334, 16648, 15950, 15242, 14526, 13801, 13067, 12327, 11577, 10821, 10060, 9291, 8516, 7738, 6954, 6166, 5375, 4579, 3781, 2983, 2180, 1377, 574, -232, -1035, -1838, -2642, -3441, -4240, -5037, -5829, -6619, -7405, -8185, -8962, -9734, -10497, -11256, -12009, -12752, -13490, -14219, -14938, -15650, -16352, -17043, -17725, -18397, -19056, -19705, -20341, -20965, -21577, -22176, -22761, -23333, -23890, -24433, -24962, -25475, -25973, -26456, -26922, -27372, -27807, -28223, -28623, -29007, -29372, -29719, -30049, -30361, -30654, -30929, -31185, -31423, -31641, -31840, -32021, -32182, -32324, -32446, -32549, -32631, -32695, -32738, -32763, -32767, -32751, -32716, -32661, -32586, -32492, -32378, -32245, -32092, -31920, -31729, -31518, -31289, -31041, -30774, -30488, -30185, -29862, -29522, -29165, -28789, -28396, -27987, -27560, -27116, -26657, -26181, -25690, -25183, -24660, -24124, -23573, -23006, -22427, -21834, -21228, -20609, -19978, -19334, -18680, -18013, -17335, -16648, -15950, -15243, -14527, -13802, -13067, -12327, -11578, -10821, -10061, -9292, -8517, -7739, -6955, -6167, -5376, -4580, -3782, -2984, -2182, -1381, -564};