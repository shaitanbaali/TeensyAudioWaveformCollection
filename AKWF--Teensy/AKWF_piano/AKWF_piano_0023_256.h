/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0023 256 samples */
 
const int16_t AKWF_piano_0023_256_DATA [256] = 
{236, 847, 1786, 2964, 4371, 5946, 7629, 9328, 10952, 12427, 13741, 14938, 16114, 17349, 18680, 20121, 21640, 23198, 24735, 26227, 27696, 29131, 30486, 31659, 32467, 32774, 32508, 31731, 30536, 29059, 27420, 25639, 23717, 21654, 19506, 17372, 15341, 13473, 11763, 10163, 8578, 6980, 5363, 3760, 2210, 784, -491, -1594, -2490, -3176, -3673, -4012, -4230, -4341, -4376, -4345, -4306, -4313, -4430, -4781, -5446, -6476, -7817, -9373, -11034, -12709, -14316, -15810, -17123, -18223, -19075, -19628, -19879, -19825, -19519, -19029, -18405, -17688, -16900, -16056, -15177, -14323, -13612, -13185, -13090, -13323, -13816, -14479, -15234, -16056, -16913, -17788, -18666, -19526, -20347, -21085, -21717, -22243, -22717, -23187, -23704, -24285, -24889, -25399, -25750, -25883, -25741, -25282, -24480, -23352, -21947, -20360, -18668, -16922, -15126, -13275, -11407, -9549, -7749, -5977, -4217, -2395, -433, 1690, 3966, 6327, 8689, 10958, 13068, 14959, 16631, 18060, 19189, 19958, 20322, 20274, 19917, 19347, 18639, 17832, 16953, 16032, 15096, 14172, 13297, 12471, 11666, 10861, 10063, 9304, 8611, 8006, 7522, 7201, 7100, 7254, 7660, 8306, 9154, 10129, 11130, 12037, 12801, 13405, 13872, 14252, 14551, 14768, 14915, 15012, 15071, 15161, 15319, 15561, 15881, 16217, 16493, 16672, 16753, 16742, 16626, 16388, 16007, 15475, 14845, 14228, 13732, 13411, 13238, 13140, 12999, 12702, 12120, 11174, 9854, 8216, 6352, 4344, 2240, 117, -1942, -3820, -5326, -6370, -6908, -6939, -6550, -5873, -5024, -4155, -3428, -3006, -3004, -3507, -4537, -6075, -8039, -10319, -12733, -15100, -17245, -19064, -20471, -21444, -22045, -22389, -22606, -22795, -23004, -23204, -23313, -23283, -23135, -22893, -22609, -22232, -21648, -20715, -19385, -17727, -15876, -14000, -12254, -10706, -9366, -8178, -7118, -6145, -5284, -4521, -3877, -3283, -2719, -2082, -1387, -537};