/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0021 256 samples */
 
const int16_t AKWF_piano_0021_256_DATA [256] = 
{189, 483, 782, 1093, 1418, 1759, 2119, 2496, 2893, 3311, 3749, 4209, 4691, 5193, 5716, 6260, 6820, 7400, 7995, 8604, 9228, 9861, 10502, 11153, 11807, 12462, 13119, 13774, 14424, 15071, 15709, 16339, 16960, 17567, 18162, 18744, 19312, 19864, 20402, 20924, 21431, 21923, 22400, 22861, 23311, 23745, 24168, 24579, 24978, 25367, 25746, 26116, 26477, 26830, 27175, 27514, 27846, 28170, 28487, 28798, 29101, 29397, 29685, 29964, 30235, 30496, 30746, 30986, 31213, 31428, 31630, 31817, 31988, 32145, 32285, 32408, 32514, 32601, 32671, 32722, 32754, 32767, 32762, 32737, 32694, 32633, 32553, 32456, 32340, 32207, 32057, 31891, 31709, 31511, 31297, 31069, 30825, 30568, 30297, 30011, 29712, 29400, 29073, 28733, 28381, 28014, 27636, 27244, 26838, 26420, 25989, 25544, 25089, 24619, 24136, 23643, 23136, 22618, 22090, 21549, 20998, 20438, 19867, 19289, 18702, 18106, 17504, 16896, 16280, 15662, 15038, 14409, 13779, 13146, 12508, 11871, 11232, 10591, 9952, 9311, 8670, 8031, 7391, 6753, 6117, 5481, 4846, 4215, 3584, 2956, 2331, 1709, 1090, 475, -137, -742, -1342, -1939, -2528, -3109, -3684, -4249, -4806, -5353, -5888, -6411, -6923, -7422, -7907, -8378, -8833, -9273, -9697, -10105, -10496, -10871, -11229, -11571, -11897, -12205, -12499, -12775, -13036, -13283, -13516, -13734, -13940, -14133, -14313, -14482, -14639, -14785, -14921, -15047, -15162, -15267, -15360, -15444, -15517, -15578, -15628, -15665, -15689, -15699, -15695, -15674, -15637, -15582, -15509, -15418, -15306, -15173, -15019, -14844, -14646, -14427, -14184, -13921, -13635, -13328, -13002, -12655, -12292, -11911, -11514, -11105, -10684, -10252, -9814, -9369, -8919, -8470, -8020, -7572, -7130, -6693, -6263, -5843, -5433, -5034, -4649, -4275, -3915, -3568, -3234, -2912, -2603, -2303, -2013, -1731, -1455, -1184, -915, -647, -377, -99};