/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0016 256 samples */
 
const int16_t AKWF_piano_0016_256_DATA [256] = 
{335, 1519, 2483, 3508, 4701, 5874, 7074, 8361, 9631, 10917, 12277, 13629, 14957, 16300, 17581, 18759, 19851, 20796, 21564, 22205, 22702, 23045, 23288, 23438, 23506, 23547, 23569, 23587, 23662, 23791, 23985, 24307, 24754, 25294, 25968, 26768, 27621, 28520, 29437, 30294, 31070, 31744, 32252, 32590, 32761, 32719, 32460, 32010, 31346, 30469, 29426, 28234, 26906, 25503, 24071, 22630, 21235, 19915, 18671, 17517, 16468, 15532, 14709, 13984, 13369, 12862, 12426, 12035, 11673, 11285, 10836, 10301, 9647, 8876, 8009, 7022, 5940, 4832, 3708, 2593, 1549, 568, -358, -1185, -1912, -2576, -3157, -3644, -4065, -4400, -4636, -4822, -4951, -5000, -5013, -5003, -4946, -4872, -4805, -4735, -4696, -4720, -4806, -4993, -5326, -5791, -6392, -7146, -8004, -8933, -9927, -10943, -11944, -12919, -13820, -14619, -15325, -15901, -16330, -16638, -16809, -16846, -16799, -16669, -16447, -16181, -15889, -15538, -15148, -14738, -14280, -13766, -13212, -12612, -11985, -11363, -10743, -10148, -9626, -9187, -8841, -8609, -8500, -8538, -8750, -9131, -9688, -10455, -11421, -12538, -13780, -15118, -16483, -17808, -19033, -20102, -20977, -21615, -21982, -22074, -21873, -21367, -20588, -19561, -18314, -16912, -15418, -13875, -12350, -10929, -9649, -8539, -7649, -6975, -6497, -6228, -6136, -6153, -6256, -6425, -6593, -6729, -6838, -6892, -6872, -6803, -6697, -6554, -6401, -6260, -6148, -6098, -6130, -6237, -6429, -6708, -7046, -7440, -7905, -8412, -8956, -9554, -10178, -10812, -11459, -12079, -12641, -13160, -13607, -13938, -14176, -14337, -14390, -14341, -14198, -13923, -13510, -12960, -12235, -11339, -10294, -9078, -7729, -6301, -4783, -3213, -1671, -163, 1293, 2609, 3764, 4755, 5518, 6037, 6339, 6388, 6191, 5809, 5249, 4562, 3834, 3055, 2261, 1544, 868, 224, -305, -759, -1170, -1437, -1603, -1718, -1625, -1385, -1185, -666};