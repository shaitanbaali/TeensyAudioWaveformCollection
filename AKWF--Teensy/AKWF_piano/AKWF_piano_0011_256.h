/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0011 256 samples */
 
const int16_t AKWF_piano_0011_256_DATA [256] = 
{1195, 2911, 4312, 5260, 5678, 5645, 5400, 5237, 5377, 5903, 6710, 7588, 8332, 8803, 8965, 8937, 9017, 9543, 10696, 12405, 14517, 16846, 19295, 21743, 24008, 25882, 27211, 27903, 28042, 27925, 27956, 28453, 29512, 30921, 32199, 32772, 32270, 30720, 28563, 26386, 24611, 23363, 22369, 21129, 19139, 16131, 12216, 7960, 4038, 844, -1519, -3115, -4068, -4424, -4232, -3600, -2698, -1728, -853, -66, 783, 1974, 3693, 5914, 8409, 10808, 12731, 13913, 14294, 14046, 13448, 12822, 12461, 12494, 12851, 13410, 14049, 14660, 15123, 15210, 14623, 13195, 11108, 8860, 7011, 5996, 5848, 6110, 6121, 5360, 3692, 1404, -965, -2879, -4047, -4494, -4495, -4425, -4581, -5198, -6350, -7902, -9589, -11159, -12623, -14143, -15831, -17636, -19415, -21039, -22523, -23900, -25189, -26423, -27635, -28913, -30220, -31384, -32158, -32354, -31897, -30917, -29720, -28600, -27743, -27168, -26773, -26424, -26013, -25479, -24862, -24169, -23457, -22712, -21826, -20661, -19068, -17004, -14547, -11894, -9251, -6818, -4707, -2966, -1600, -491, 455, 1350, 2209, 3040, 3837, 4509, 4945, 5114, 5071, 4935, 4805, 4767, 4909, 5327, 6050, 7004, 8026, 8932, 9660, 10172, 10444, 10414, 10082, 9473, 8753, 8236, 8206, 8772, 9770, 10825, 11541, 11664, 11093, 9935, 8360, 6553, 4689, 2873, 1209, -262, -1617, -2947, -4237, -5434, -6494, -7321, -7834, -7885, -7399, -6401, -5007, -3358, -1625, -13, 1329, 2355, 3135, 3730, 4188, 4566, 4920, 5273, 5576, 5757, 5740, 5499, 4993, 4200, 3084, 1635, -38, -1798, -3462, -4986, -6430, -7947, -9531, -11116, -12662, -14093, -15249, -15984, -16331, -16505, -16756, -17188, -17691, -18035, -18033, -17541, -16552, -15322, -14247, -13630, -13548, -13791, -14003, -13855, -13218, -12205, -10950, -9512, -7962, -6417, -4920, -3521, -2302, -1353, -719, -358};