/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0027 256 samples */
 
const int16_t AKWF_piano_0027_256_DATA [256] = 
{717, 2363, 4610, 7587, 11228, 15290, 19404, 23070, 25844, 27321, 27436, 26401, 24666, 22657, 20620, 18635, 16719, 14928, 13354, 12140, 11385, 11051, 11010, 10975, 10639, 9766, 8255, 6205, 3796, 1121, -1690, -4402, -6655, -8048, -8412, -7873, -6743, -5281, -3705, -2273, -1195, -551, -239, -10, 265, 521, 592, 270, -612, -2186, -4386, -6914, -9224, -10753, -11167, -10547, -9318, -7970, -6808, -6026, -5841, -6495, -8078, -10296, -12668, -14648, -15868, -16072, -15100, -12923, -9756, -6034, -2194, 1500, 4928, 8098, 10889, 13202, 15029, 16362, 17086, 17038, 16117, 14468, 12408, 10353, 8636, 7504, 7157, 7761, 9369, 11756, 14480, 16919, 18584, 19181, 18658, 17136, 14933, 12497, 10227, 8310, 6721, 5396, 4275, 3308, 2445, 1607, 837, 307, 232, 745, 1826, 3415, 5349, 7469, 9597, 11598, 13416, 15064, 16525, 17799, 18868, 19738, 20421, 20885, 21053, 20788, 19977, 18506, 16402, 13768, 10804, 7776, 5071, 2991, 1697, 996, 544, 99, -435, -1071, -1857, -2833, -3994, -5281, -6736, -8378, -10179, -11954, -13508, -14800, -15871, -16694, -17114, -16962, -16191, -14888, -13225, -11293, -9147, -6916, -4860, -3350, -2563, -2311, -2162, -1744, -978, -47, 785, 1354, 1556, 1420, 1099, 882, 1034, 1519, 2119, 2560, 2768, 2825, 2791, 2632, 2322, 1942, 1693, 1741, 2083, 2644, 3310, 4055, 4868, 5618, 6051, 5924, 5154, 3882, 2376, 821, -729, -2231, -3567, -4590, -5210, -5435, -5288, -4864, -4324, -3920, -3908, -4443, -5476, -6905, -8634, -10546, -12398, -13821, -14527, -14462, -13791, -12817, -11878, -11193, -10792, -10631, -10652, -10875, -11375, -12289, -13784, -15992, -18902, -22198, -25421, -28228, -30442, -31964, -32717, -32614, -31693, -29991, -27553, -24397, -20701, -16937, -13690, -11397, -10093, -9446, -9025, -8481, -7539, -6068, -3957, -1152};