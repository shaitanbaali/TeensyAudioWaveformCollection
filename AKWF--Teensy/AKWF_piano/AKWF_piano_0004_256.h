/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0004 256 samples */
 
const int16_t AKWF_piano_0004_256_DATA [256] = 
{1317, 3570, 5602, 7382, 8911, 10161, 11161, 12025, 12967, 14148, 15594, 17152, 18546, 19521, 20005, 20121, 20084, 20099, 20272, 20631, 21193, 22000, 23131, 24625, 26418, 28344, 30162, 31632, 32548, 32743, 32128, 30678, 28418, 25466, 22034, 18389, 14824, 11561, 8741, 6434, 4601, 3168, 2040, 1056, 56, -1079, -2373, -3716, -4937, -5910, -6596, -7045, -7363, -7592, -7648, -7391, -6750, -5775, -4675, -3701, -3052, -2830, -2991, -3382, -3803, -4099, -4197, -4103, -3872, -3581, -3313, -3137, -3096, -3215, -3497, -3949, -4582, -5419, -6471, -7668, -8862, -9819, -10323, -10300, -9803, -9033, -8226, -7549, -7060, -6701, -6401, -6109, -5786, -5397, -4904, -4294, -3561, -2741, -1908, -1148, -488, 92, 647, 1232, 1822, 2348, 2727, 2926, 2967, 2930, 2909, 2979, 3198, 3632, 4299, 5187, 6184, 7127, 7832, 8223, 8350, 8420, 8704, 9413, 10620, 12224, 13974, 15568, 16699, 17182, 16925, 15944, 14328, 12221, 9798, 7265, 4769, 2437, 354, -1427, -2843, -3806, -4275, -4279, -3924, -3312, -2521, -1541, -322, 1109, 2631, 4010, 5006, 5499, 5532, 5264, 4882, 4511, 4172, 3789, 3212, 2366, 1254, -52, -1468, -2915, -4284, -5430, -6193, -6493, -6345, -5905, -5422, -5128, -5149, -5466, -5938, -6381, -6645, -6656, -6413, -5947, -5352, -4775, -4406, -4414, -4825, -5463, -6044, -6282, -6048, -5400, -4549, -3786, -3311, -3248, -3614, -4417, -5635, -7221, -9064, -10967, -12770, -14350, -15657, -16670, -17326, -17547, -17271, -16483, -15259, -13772, -12175, -10587, -9018, -7408, -5723, -4002, -2356, -960, 83, 785, 1260, 1626, 1955, 2241, 2411, 2364, 2036, 1325, 193, -1328, -3118, -4920, -6461, -7569, -8291, -8825, -9471, -10421, -11719, -13256, -14822, -16185, -17151, -17567, -17376, -16586, -15275, -13595, -11722, -9798, -7841, -5780, -3540, -935};