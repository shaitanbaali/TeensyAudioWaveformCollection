/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0009 256 samples */
 
const int16_t AKWF_piano_0009_256_DATA [256] = 
{2192, 7960, 13362, 17854, 21489, 24470, 26898, 28835, 30316, 31405, 32236, 32734, 32649, 31865, 30446, 28394, 25742, 22570, 18895, 15031, 11937, 10415, 10038, 9590, 8209, 5640, 2255, -961, -3236, -4456, -4579, -3622, -2155, -978, -307, 89, 432, 925, 1533, 1893, 1917, 2149, 3185, 5252, 8177, 11148, 12797, 12286, 10019, 7137, 4853, 4024, 4820, 6830, 9489, 11997, 13369, 13237, 12131, 10639, 8784, 6473, 3842, 1135, -1333, -3200, -4245, -4412, -3739, -2572, -1504, -883, -569, -389, -242, 51, 630, 1188, 1202, 405, -1294, -3953, -7364, -11119, -14671, -17216, -18063, -17023, -14527, -11420, -8678, -6842, -5464, -3632, -1102, 1623, 3909, 5118, 4546, 1952, -2036, -6403, -10320, -13201, -14731, -14987, -14469, -13877, -13547, -13084, -11931, -10459, -9748, -10365, -12030, -14022, -15438, -15371, -13625, -10741, -7200, -3176, 907, 4542, 7741, 10589, 12942, 14680, 15554, 15130, 13478, 11377, 9569, 8342, 7629, 6878, 5582, 4196, 3578, 3959, 5178, 7262, 9969, 12581, 14648, 16115, 16882, 16860, 16283, 15431, 14292, 12610, 10094, 6813, 3652, 1665, 1016, 1248, 1961, 2803, 3477, 3969, 4315, 4440, 4292, 3812, 2807, 1057, -1275, -3569, -4896, -4364, -1549, 2852, 7312, 10563, 12229, 12575, 12154, 11429, 10545, 9507, 8510, 7786, 7483, 7609, 7867, 7666, 6834, 5937, 5439, 5139, 4805, 4639, 4868, 5418, 6005, 5965, 4377, 908, -3833, -8731, -12863, -16073, -18809, -21460, -23723, -24989, -25194, -24859, -24650, -24892, -25401, -25523, -24817, -23458, -21848, -20165, -18649, -17705, -17717, -18712, -20158, -20984, -20254, -17913, -14700, -11623, -9634, -9291, -10147, -11267, -12484, -14073, -15758, -16983, -17323, -16561, -14851, -12780, -10811, -9158, -8394, -9133, -11097, -13118, -14114, -13550, -11618, -9276, -7485, -6477, -5911, -5203, -3602, -906};