/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0028 256 samples */
 
const int16_t AKWF_piano_0028_256_DATA [256] = 
{656, 2129, 3717, 5416, 7221, 9028, 10763, 12405, 13931, 15356, 16707, 18015, 19210, 20296, 21261, 22058, 22716, 23245, 23678, 24038, 24359, 24608, 24740, 24800, 24767, 24662, 24535, 24408, 24326, 24313, 24392, 24611, 24962, 25483, 26164, 26991, 27920, 28866, 29785, 30624, 31322, 31876, 32295, 32588, 32737, 32770, 32663, 32353, 31862, 31148, 30232, 29246, 28223, 27301, 26625, 26169, 26030, 26149, 26432, 26848, 27281, 27655, 27923, 27994, 27845, 27397, 26628, 25428, 23801, 21714, 19107, 16118, 12728, 9036, 5189, 1177, -2779, -6579, -10154, -13276, -15982, -18164, -19848, -21102, -21961, -22582, -23043, -23432, -23840, -24273, -24768, -25338, -25947, -26616, -27310, -27991, -28644, -29195, -29632, -29935, -30088, -30117, -30023, -29851, -29617, -29329, -28999, -28608, -28133, -27549, -26825, -25935, -24871, -23586, -22123, -20504, -18722, -16906, -15096, -13358, -11856, -10572, -9587, -8903, -8468, -8281, -8293, -8518, -8918, -9477, -10164, -10896, -11596, -12177, -12515, -12618, -12381, -11869, -11120, -10172, -9076, -7903, -6673, -5472, -4292, -3210, -2228, -1415, -792, -337, -82, 28, 32, -78, -252, -476, -704, -902, -1027, -1023, -892, -605, -189, 273, 721, 1099, 1336, 1443, 1400, 1258, 1104, 956, 865, 871, 933, 1068, 1223, 1368, 1500, 1585, 1641, 1634, 1574, 1461, 1232, 921, 526, 10, -589, -1312, -2102, -2962, -3853, -4681, -5404, -5928, -6216, -6296, -6147, -5863, -5520, -5148, -4780, -4416, -4034, -3627, -3208, -2761, -2308, -1900, -1517, -1215, -997, -871, -842, -907, -1052, -1269, -1567, -1940, -2422, -3025, -3763, -4657, -5694, -6844, -8091, -9392, -10738, -12039, -13228, -14290, -15112, -15691, -16013, -16083, -15981, -15748, -15407, -14992, -14520, -13973, -13358, -12673, -11953, -11214, -10481, -9745, -9001, -8216, -7327, -6301, -5124, -3783, -2328, -765};