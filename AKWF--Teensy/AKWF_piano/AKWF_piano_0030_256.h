/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0030 256 samples */
 
const int16_t AKWF_piano_0030_256_DATA [256] = 
{138, 452, 748, 1118, 1573, 2068, 2561, 3047, 3549, 4083, 4648, 5233, 5828, 6429, 7049, 7687, 8344, 9020, 9707, 10408, 11129, 11869, 12623, 13392, 14156, 14924, 15692, 16462, 17233, 17998, 18758, 19511, 20256, 20994, 21721, 22429, 23114, 23770, 24403, 25015, 25614, 26197, 26762, 27309, 27831, 28320, 28780, 29211, 29621, 30011, 30377, 30725, 31054, 31357, 31624, 31853, 32048, 32225, 32384, 32521, 32629, 32707, 32754, 32768, 32748, 32693, 32609, 32493, 32347, 32171, 31966, 31728, 31452, 31135, 30780, 30394, 29979, 29535, 29060, 28548, 28003, 27422, 26807, 26164, 25491, 24792, 24069, 23317, 22545, 21747, 20932, 20104, 19261, 18405, 17533, 16643, 15739, 14828, 13911, 12999, 12087, 11180, 10275, 9373, 8474, 7576, 6675, 5777, 4892, 4024, 3175, 2333, 1503, 682, -129, -928, -1715, -2488, -3240, -3974, -4692, -5391, -6079, -6752, -7412, -8055, -8677, -9270, -9845, -10400, -10936, -11458, -11963, -12457, -12942, -13406, -13851, -14279, -14689, -15095, -15490, -15875, -16250, -16619, -16977, -17327, -17666, -18002, -18338, -18675, -19004, -19324, -19638, -19946, -20254, -20562, -20868, -21173, -21474, -21769, -22058, -22339, -22614, -22885, -23149, -23414, -23682, -23946, -24200, -24438, -24659, -24869, -25071, -25261, -25438, -25599, -25741, -25869, -25980, -26075, -26145, -26190, -26210, -26205, -26173, -26117, -26041, -25950, -25844, -25716, -25565, -25393, -25196, -24978, -24741, -24489, -24232, -23966, -23682, -23377, -23052, -22716, -22374, -22024, -21664, -21293, -20909, -20516, -20111, -19692, -19264, -18833, -18394, -17952, -17500, -17040, -16576, -16109, -15645, -15177, -14705, -14230, -13756, -13283, -12816, -12350, -11893, -11443, -10999, -10561, -10126, -9695, -9266, -8840, -8424, -8021, -7630, -7248, -6874, -6506, -6143, -5778, -5410, -5043, -4675, -4310, -3943, -3575, -3203, -2827, -2449, -2064, -1659, -1208, -718, -240};