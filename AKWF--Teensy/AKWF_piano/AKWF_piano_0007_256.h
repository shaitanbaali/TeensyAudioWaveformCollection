/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0007 256 samples */
 
const int16_t AKWF_piano_0007_256_DATA [256] = 
{515, 2327, 3726, 4921, 6423, 8283, 10268, 12266, 14049, 15180, 15542, 15430, 15314, 15747, 17117, 19414, 22479, 26091, 29575, 31999, 32810, 31936, 29560, 26165, 22397, 18468, 14256, 10109, 6686, 4322, 2941, 2197, 1698, 1357, 1551, 2408, 3473, 4185, 4033, 2661, 192, -2639, -5069, -6875, -7994, -8376, -8020, -6627, -3828, 204, 4765, 9115, 12628, 14876, 16072, 16885, 17714, 18629, 19496, 19998, 19770, 18652, 16584, 13505, 9884, 6677, 4437, 3117, 2545, 2294, 1829, 1301, 1398, 2130, 2508, 1539, -956, -4289, -7219, -8700, -8484, -7100, -5483, -4466, -4281, -4466, -4421, -4077, -3747, -3658, -4011, -4988, -6581, -8494, -10342, -11792, -12504, -12198, -10899, -8972, -6782, -4592, -2775, -1735, -1593, -2217, -3329, -4581, -5759, -6876, -7910, -8823, -9644, -10209, -10057, -9038, -7657, -6487, -5882, -5937, -6291, -6229, -5280, -3628, -1802, -523, -487, -1822, -3961, -6069, -7245, -6759, -4733, -2180, 147, 2195, 3993, 5576, 7379, 9786, 12457, 14725, 16067, 16284, 15714, 14920, 14082, 13141, 12307, 11801, 11423, 10984, 10603, 10208, 9352, 7667, 5192, 2213, -830, -3636, -6263, -8569, -9975, -9947, -8205, -4793, -376, 3834, 6866, 8384, 8506, 7789, 7069, 6877, 7166, 7530, 7494, 6608, 4493, 1070, -3060, -6426, -7536, -6080, -3021, 436, 3509, 5860, 7525, 8677, 9418, 9615, 9143, 8219, 7353, 6810, 6308, 5456, 4183, 2571, 692, -1288, -3310, -5486, -7591, -8990, -9395, -9143, -9002, -9856, -12118, -15453, -19462, -23785, -27595, -29869, -30249, -29070, -26771, -23875, -21058, -18689, -16911, -15880, -15440, -15281, -15474, -16330, -17832, -19716, -21657, -22935, -22735, -20865, -17577, -13310, -9056, -5890, -3990, -2880, -2194, -1635, -919, -213, 11, -365, -1262, -2791, -4920, -7314, -9567, -11088, -11050, -9158, -5963, -2292};