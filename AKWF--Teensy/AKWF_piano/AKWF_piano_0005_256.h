/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0005 256 samples */
 
const int16_t AKWF_piano_0005_256_DATA [256] = 
{220, 1788, 4097, 6281, 8569, 10810, 12994, 15093, 17091, 19012, 20781, 22443, 23971, 25442, 26904, 28387, 29866, 31202, 32203, 32714, 32684, 32151, 31227, 30060, 28788, 27560, 26495, 25729, 25336, 25296, 25438, 25482, 25147, 24231, 22737, 20857, 18924, 17187, 15759, 14631, 13667, 12734, 11697, 10446, 8880, 6981, 4777, 2356, -74, -2341, -4253, -5686, -6616, -7067, -7124, -6866, -6357, -5633, -4767, -3831, -2927, -2113, -1432, -892, -516, -365, -506, -1046, -2040, -3489, -5282, -7258, -9254, -11157, -12971, -14709, -16412, -18045, -19542, -20801, -21772, -22534, -23188, -23799, -24405, -24950, -25383, -25661, -25778, -25781, -25726, -25675, -25670, -25741, -25895, -26095, -26240, -26169, -25698, -24667, -22982, -20688, -17928, -14960, -12020, -9313, -6929, -4789, -2806, -886, 1000, 2791, 4384, 5702, 6713, 7459, 8011, 8446, 8799, 9132, 9499, 9948, 10554, 11327, 12230, 13203, 14142, 15008, 15783, 16467, 17032, 17392, 17414, 16982, 16020, 14554, 12687, 10528, 8205, 5788, 3354, 943, -1412, -3692, -5874, -7982, -10057, -12084, -13982, -15659, -16971, -17848, -18277, -18321, -18100, -17746, -17313, -16797, -16106, -15155, -13883, -12347, -10654, -9021, -7649, -6668, -6109, -5915, -5919, -5897, -5575, -4730, -3238, -1172, 1284, 3808, 6048, 7733, 8695, 8913, 8467, 7484, 6118, 4535, 2885, 1306, -98, -1248, -2114, -2670, -2951, -2996, -2926, -2867, -2965, -3336, -3991, -4871, -5804, -6611, -7107, -7206, -6888, -6226, -5350, -4428, -3551, -2770, -2084, -1451, -896, -494, -342, -537, -1053, -1770, -2534, -3241, -3773, -4097, -4188, -4014, -3566, -2857, -2025, -1230, -689, -488, -655, -1044, -1460, -1747, -1781, -1574, -1163, -654, -142, 246, 343, -2, -944, -2483, -4534, -6809, -9010, -10848, -12123, -12820, -12930, -12554, -11686, -10374, -8620, -6454, -4121, -1464};