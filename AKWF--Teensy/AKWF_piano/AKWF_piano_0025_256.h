/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0025 256 samples */
 
const int16_t AKWF_piano_0025_256_DATA [256] = 
{409, 1210, 1951, 2638, 3266, 3846, 4394, 4928, 5467, 6020, 6590, 7173, 7759, 8338, 8902, 9448, 9977, 10499, 11018, 11542, 12076, 12619, 13166, 13714, 14256, 14788, 15313, 15832, 16348, 16868, 17392, 17921, 18455, 18988, 19515, 20037, 20549, 21054, 21555, 22052, 22549, 23046, 23539, 24028, 24508, 24976, 25433, 25878, 26310, 26735, 27151, 27558, 27957, 28346, 28720, 29081, 29424, 29749, 30058, 30352, 30628, 30889, 31132, 31354, 31556, 31734, 31888, 32019, 32125, 32210, 32274, 32317, 32338, 32334, 32306, 32251, 32170, 32062, 31928, 31771, 31591, 31388, 31164, 30917, 30647, 30352, 30033, 29691, 29328, 28944, 28543, 28125, 27689, 27236, 26764, 26273, 25761, 25229, 24676, 24104, 23514, 22907, 22281, 21640, 20979, 20300, 19604, 18890, 18158, 17411, 16649, 15873, 15084, 14282, 13466, 12637, 11792, 10935, 10069, 9191, 8307, 7418, 6522, 5621, 4715, 3801, 2882, 1959, 1030, 100, -830, -1761, -2689, -3614, -4540, -5461, -6383, -7304, -8222, -9136, -10045, -10944, -11835, -12715, -13581, -14438, -15283, -16113, -16934, -17740, -18529, -19304, -20061, -20796, -21514, -22209, -22883, -23539, -24172, -24786, -25379, -25950, -26498, -27024, -27524, -27999, -28449, -28873, -29274, -29651, -30005, -30338, -30650, -30939, -31207, -31453, -31675, -31875, -32051, -32205, -32339, -32453, -32550, -32631, -32694, -32738, -32763, -32766, -32747, -32705, -32641, -32557, -32455, -32337, -32203, -32053, -31885, -31697, -31485, -31251, -30994, -30715, -30418, -30104, -29779, -29443, -29093, -28729, -28349, -27949, -27532, -27096, -26645, -26184, -25713, -25236, -24752, -24260, -23751, -23228, -22688, -22129, -21560, -20983, -20401, -19821, -19242, -18659, -18070, -17466, -16845, -16208, -15556, -14895, -14235, -13581, -12936, -12301, -11667, -11028, -10378, -9708, -9025, -8335, -7648, -6979, -6341, -5730, -5143, -4567, -3977, -3356, -2687, -1965, -1196, -381};