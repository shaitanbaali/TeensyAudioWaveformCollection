/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0017 256 samples */
 
const int16_t AKWF_piano_0017_256_DATA [256] = 
{1353, 4892, 8097, 11322, 14420, 17377, 20015, 22159, 23822, 25091, 26225, 27410, 28706, 30040, 31238, 32177, 32698, 32662, 31937, 30529, 28647, 26545, 24417, 22331, 20334, 18517, 16919, 15534, 14236, 12879, 11477, 10192, 9264, 8785, 8723, 8949, 9331, 9739, 10051, 10153, 9945, 9447, 8739, 7879, 6853, 5511, 3680, 1313, -1494, -4552, -7657, -10659, -13429, -15796, -17610, -18816, -19444, -19628, -19505, -19186, -18800, -18422, -18081, -17734, -17291, -16647, -15790, -14813, -13837, -12908, -11991, -11032, -10049, -9117, -8288, -7489, -6593, -5504, -4245, -2908, -1602, -385, 656, 1406, 1783, 1817, 1630, 1399, 1203, 1053, 930, 875, 957, 1200, 1557, 1983, 2447, 2963, 3521, 4078, 4524, 4763, 4793, 4716, 4724, 4922, 5349, 6013, 6958, 8206, 9696, 11238, 12583, 13567, 14138, 14363, 14315, 14008, 13465, 12820, 12226, 11803, 11545, 11355, 11147, 10872, 10500, 9936, 9023, 7660, 5866, 3745, 1439, -982, -3399, -5589, -7307, -8388, -8912, -9156, -9417, -9863, -10510, -11255, -11954, -12449, -12584, -12244, -11397, -10089, -8407, -6474, -4398, -2215, 21, 2175, 4081, 5633, 6770, 7468, 7633, 7120, 5864, 4000, 1879, -116, -1727, -2836, -3457, -3618, -3407, -2968, -2515, -2189, -1940, -1601, -1007, -148, 848, 1871, 2934, 4114, 5427, 6832, 8234, 9566, 10807, 11935, 12903, 13679, 14255, 14656, 14868, 14807, 14386, 13569, 12422, 11093, 9748, 8486, 7291, 6074, 4792, 3497, 2282, 1268, 517, 69, -62, 27, 123, -134, -1019, -2568, -4557, -6701, -8777, -10629, -12143, -13205, -13799, -14051, -14207, -14574, -15323, -16534, -18177, -20146, -22223, -24139, -25627, -26500, -26810, -26769, -26622, -26543, -26554, -26604, -26670, -26745, -26850, -26921, -26921, -26810, -26578, -26216, -25565, -24468, -22773, -20479, -17662, -14394, -10893, -7293, -3723, -700};