/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0020 256 samples */
 
const int16_t AKWF_piano_0020_256_DATA [256] = 
{242, 941, 1519, 2025, 2528, 3081, 3688, 4311, 4919, 5507, 6097, 6713, 7353, 7992, 8616, 9226, 9834, 10455, 11078, 11680, 12252, 12795, 13321, 13842, 14349, 14827, 15274, 15689, 16087, 16474, 16839, 17173, 17475, 17751, 18012, 18263, 18495, 18700, 18878, 19036, 19182, 19322, 19447, 19555, 19648, 19732, 19816, 19900, 19977, 20044, 20103, 20162, 20225, 20294, 20363, 20430, 20499, 20576, 20663, 20761, 20862, 20969, 21085, 21214, 21357, 21510, 21669, 21835, 22011, 22206, 22420, 22648, 22882, 23119, 23357, 23601, 23850, 24100, 24347, 24583, 24805, 25012, 25205, 25381, 25537, 25671, 25776, 25850, 25892, 25902, 25881, 25828, 25743, 25622, 25467, 25280, 25067, 24830, 24565, 24272, 23950, 23604, 23240, 22863, 22470, 22059, 21634, 21195, 20751, 20300, 19840, 19365, 18878, 18380, 17876, 17370, 16850, 16314, 15762, 15196, 14620, 14031, 13418, 12777, 12107, 11413, 10704, 9978, 9228, 8453, 7653, 6834, 6007, 5172, 4324, 3463, 2589, 1710, 836, -36, -905, -1771, -2631, -3479, -4305, -5115, -5903, -6673, -7419, -8135, -8819, -9478, -10114, -10729, -11323, -11893, -12443, -12981, -13516, -14046, -14573, -15093, -15609, -16128, -16656, -17196, -17746, -18303, -18871, -19453, -20047, -20655, -21271, -21895, -22531, -23178, -23829, -24482, -25130, -25771, -26410, -27043, -27660, -28253, -28815, -29345, -29852, -30335, -30784, -31187, -31537, -31838, -32101, -32328, -32515, -32653, -32735, -32767, -32757, -32709, -32621, -32484, -32296, -32063, -31790, -31479, -31125, -30726, -30284, -29809, -29306, -28775, -28202, -27587, -26935, -26258, -25567, -24863, -24133, -23379, -22608, -21834, -21067, -20304, -19533, -18753, -17975, -17209, -16464, -15728, -14993, -14260, -13539, -12846, -12186, -11544, -10905, -10273, -9656, -9071, -8515, -7971, -7425, -6885, -6364, -5872, -5397, -4905, -4384, -3852, -3340, -2868, -2404, -1885, -1258, -520};