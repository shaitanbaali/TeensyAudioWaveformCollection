/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0002 256 samples */
 
const int16_t AKWF_piano_0002_256_DATA [256] = 
{1237, 4408, 7614, 10699, 13483, 15820, 17780, 19553, 21388, 23367, 25480, 27607, 29525, 31004, 31991, 32497, 32705, 32761, 32744, 32677, 32523, 32079, 31182, 29742, 27769, 25267, 22346, 19173, 15852, 12529, 9372, 6462, 3885, 1694, -162, -1806, -3401, -5129, -7156, -9416, -11603, -13347, -14385, -14746, -14611, -14210, -13697, -13157, -12596, -11962, -11242, -10224, -8769, -6828, -4542, -1936, 862, 3790, 6808, 9878, 12874, 15633, 17989, 19911, 21315, 22107, 22200, 21580, 20360, 18617, 16555, 14416, 12382, 10635, 9246, 8282, 7653, 7326, 7182, 7036, 6708, 6183, 5610, 5226, 5194, 5661, 6671, 8094, 9698, 11231, 12502, 13339, 13568, 13264, 12512, 11328, 9676, 7599, 5194, 2535, -322, -3356, -6492, -9683, -12875, -15989, -18919, -21567, -23728, -25214, -25911, -25806, -25053, -23729, -21895, -19656, -17234, -14827, -12642, -10719, -9034, -7472, -5960, -4488, -3164, -2279, -2088, -2695, -3997, -5791, -7815, -9832, -11596, -13087, -14306, -15335, -16282, -17098, -17739, -18048, -18065, -17974, -17865, -17771, -17642, -17326, -16860, -16256, -15633, -15036, -14435, -13693, -12737, -11532, -10084, -8481, -6933, -5641, -4728, -4208, -4046, -4178, -4454, -4730, -4929, -5093, -5272, -5437, -5477, -5366, -5118, -4783, -4418, -4219, -4272, -4611, -5161, -5977, -7046, -8355, -9881, -11442, -12850, -13846, -14197, -13742, -12525, -10698, -8378, -5825, -3266, -831, 1443, 3559, 5507, 7275, 8824, 10031, 10835, 11161, 11029, 10526, 9669, 8485, 6957, 5148, 3095, 947, -1187, -3116, -4853, -6376, -7701, -8721, -9322, -9388, -8782, -7436, -5418, -2853, 50, 3031, 5814, 8174, 10049, 11409, 12339, 12934, 13182, 13038, 12436, 11332, 9701, 7610, 5296, 3046, 1167, -355, -1593, -2656, -3681, -4819, -6089, -7425, -8731, -9818, -10471, -10569, -10181, -9506, -8655, -7709, -6560, -5099, -3284, -1207};