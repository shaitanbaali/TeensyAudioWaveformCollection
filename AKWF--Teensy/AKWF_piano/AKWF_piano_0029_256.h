/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0029 256 samples */
 
const int16_t AKWF_piano_0029_256_DATA [256] = 
{264, 1054, 1840, 2498, 3097, 3641, 4127, 4544, 4908, 5225, 5491, 5710, 5879, 6003, 6085, 6123, 6103, 6017, 5867, 5679, 5450, 5169, 4851, 4500, 4125, 3751, 3389, 3037, 2688, 2346, 2026, 1731, 1449, 1170, 903, 650, 408, 178, -27, -186, -300, -370, -392, -332, -161, 113, 469, 894, 1418, 2042, 2746, 3509, 4312, 5129, 5972, 6832, 7691, 8519, 9306, 10057, 10780, 11453, 12047, 12563, 13008, 13404, 13716, 13928, 14036, 14070, 14045, 13957, 13804, 13595, 13352, 13104, 12873, 12670, 12480, 12306, 12194, 12154, 12176, 12237, 12340, 12493, 12693, 12933, 13202, 13481, 13768, 14066, 14370, 14667, 14941, 15196, 15440, 15678, 15889, 16072, 16240, 16394, 16524, 16637, 16730, 16803, 16861, 16904, 16925, 16914, 16882, 16837, 16774, 16687, 16572, 16455, 16331, 16196, 16060, 15925, 15791, 15656, 15521, 15385, 15253, 15104, 14905, 14658, 14370, 14051, 13670, 13210, 12674, 12089, 11480, 10860, 10239, 9625, 9025, 8470, 7979, 7567, 7215, 6902, 6609, 6337, 6090, 5854, 5592, 5274, 4901, 4480, 4033, 3563, 3066, 2551, 2033, 1530, 1077, 678, 330, 21, -243, -456, -620, -745, -855, -977, -1109, -1245, -1390, -1568, -1789, -2043, -2327, -2636, -2966, -3328, -3715, -4110, -4511, -4924, -5338, -5759, -6191, -6644, -7127, -7640, -8172, -8750, -9399, -10124, -10912, -11738, -12629, -13598, -14629, -15710, -16826, -17963, -19130, -20310, -21493, -22672, -23821, -24931, -26023, -27089, -28083, -28993, -29822, -30595, -31276, -31819, -32224, -32519, -32719, -32776, -32732, -32543, -32252, -31886, -31450, -30949, -30387, -29782, -29147, -28483, -27792, -27085, -26353, -25577, -24758, -23890, -22987, -22036, -21032, -19972, -18858, -17709, -16549, -15371, -14186, -12985, -11791, -10629, -9489, -8365, -7249, -6153, -5082, -4030, -3001, -1987, -984, -254};