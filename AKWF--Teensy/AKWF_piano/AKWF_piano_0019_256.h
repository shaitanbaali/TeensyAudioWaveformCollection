/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0019 256 samples */
 
const int16_t AKWF_piano_0019_256_DATA [256] = 
{3518, 9808, 15348, 19598, 22642, 24944, 26681, 27995, 28370, 26563, 22363, 17578, 14511, 13930, 15358, 17839, 20184, 22061, 24174, 26970, 29974, 32271, 32695, 30244, 25466, 20301, 15714, 11367, 7185, 3843, 1761, 912, 844, 603, -199, -944, -1000, -524, 296, 1355, 1561, -294, -4338, -10281, -17320, -23432, -26683, -27347, -27092, -26570, -25522, -23722, -21087, -18070, -15613, -14581, -15127, -17024, -19520, -21216, -21589, -21437, -21287, -20749, -19300, -17036, -14218, -11200, -8432, -6057, -4222, -3375, -3517, -3787, -3361, -2255, -698, 1266, 3497, 5701, 7749, 9572, 11005, 12154, 13514, 15031, 16017, 16228, 16420, 17486, 19169, 20014, 18511, 14469, 9028, 3817, 188, -1361, -1228, -744, -1473, -3779, -6528, -8305, -8655, -8111, -7590, -7977, -9055, -9597, -8816, -6898, -4763, -3636, -4771, -7790, -10182, -9525, -5425, 302, 4763, 5889, 4065, 1213, -1606, -3945, -4777, -3676, -1463, 1217, 4316, 7363, 9452, 10210, 9812, 8765, 7805, 7197, 6202, 4578, 3705, 4734, 6822, 7743, 5300, -1169, -9630, -16242, -18394, -16379, -12337, -8402, -5758, -4209, -3309, -3352, -4556, -5938, -6305, -5390, -3238, 183, 4271, 7996, 11055, 13684, 15217, 14842, 12735, 10393, 9774, 11807, 15440, 18704, 20678, 21674, 22080, 21903, 20812, 18555, 15825, 13900, 13379, 13450, 12803, 10442, 6125, 892, -3560, -6388, -8163, -9865, -11668, -12962, -13182, -12886, -13579, -16350, -21087, -26440, -30378, -31468, -29856, -27042, -24830, -24458, -25677, -26537, -25563, -23356, -21414, -20335, -19419, -17696, -14554, -10164, -5306, -783, 2942, 5544, 7024, 7687, 7706, 7343, 7346, 8464, 10591, 12820, 13774, 12250, 8226, 3314, -847, -3688, -4844, -3898, -1277, 1815, 4579, 7057, 9559, 11925, 13016, 11340, 6843, 1216, -3771, -7901, -11647, -15103, -17643, -18185, -16122, -11994, -7151, -2389};