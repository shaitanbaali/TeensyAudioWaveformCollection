/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0024 256 samples */
 
const int16_t AKWF_piano_0024_256_DATA [256] = 
{2473, 5902, 8208, 9494, 9928, 9789, 9459, 9361, 9798, 10904, 12625, 14704, 16812, 18620, 19978, 20879, 21520, 22185, 23135, 24568, 26489, 28635, 30594, 32019, 32712, 32614, 31788, 30449, 28826, 27137, 25614, 24338, 23288, 22395, 21498, 20534, 19579, 18651, 17701, 16626, 15296, 13780, 12113, 10358, 8634, 7063, 5714, 4598, 3728, 2989, 2225, 1332, 315, -710, -1597, -2254, -2600, -2589, -2301, -1958, -1882, -2327, -3374, -4851, -6429, -7736, -8537, -8830, -8691, -8277, -7762, -7366, -7332, -7821, -8833, -10198, -11667, -12973, -13885, -14208, -13915, -13107, -11959, -10854, -10128, -10018, -10532, -11490, -12638, -13648, -14290, -14444, -14218, -13874, -13587, -13459, -13484, -13451, -13248, -12789, -12117, -11267, -10290, -9280, -8323, -7533, -7035, -6808, -6740, -6670, -6456, -5993, -5228, -4161, -2832, -1381, -91, 735, 940, 525, -340, -1370, -2316, -3010, -3346, -3257, -2847, -2289, -1798, -1494, -1490, -1830, -2477, -3363, -4366, -5362, -6232, -6840, -7170, -7240, -7140, -6985, -6985, -7379, -8285, -9636, -11170, -12500, -13139, -12697, -11058, -8345, -4966, -1535, 1346, 3177, 3821, 3519, 2761, 2041, 1763, 2170, 3346, 5195, 7395, 9618, 11655, 13347, 14708, 15852, 16892, 17844, 18683, 19346, 19846, 20242, 20519, 20657, 20626, 20438, 20091, 19648, 19195, 18868, 18728, 18782, 18977, 19179, 19280, 19269, 19143, 18971, 18805, 18665, 18466, 18142, 17498, 16310, 14455, 12026, 9302, 6673, 4473, 2836, 1693, 852, 88, -756, -1733, -2799, -3876, -4853, -5709, -6603, -7759, -9439, -11813, -14724, -17865, -20793, -23104, -24468, -24797, -24176, -22986, -21746, -20950, -20916, -21634, -22855, -24178, -25245, -25797, -25612, -24649, -23079, -21257, -19666, -18788, -18863, -19870, -21496, -23225, -24537, -24928, -24048, -21830, -18491, -14568, -10735, -7424, -4908, -3194, -2118, -1347, -508};