/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0018 256 samples */
 
const int16_t AKWF_piano_0018_256_DATA [256] = 
{327, 1494, 2378, 2906, 3115, 3100, 3019, 3061, 3473, 4430, 5911, 7698, 9533, 11241, 12775, 14127, 15329, 16394, 17459, 18759, 20471, 22595, 24982, 27391, 29545, 31210, 32286, 32739, 32700, 32346, 31855, 31258, 30471, 29370, 27749, 25503, 22719, 19629, 16513, 13574, 10813, 8221, 5909, 4074, 2817, 2070, 1716, 1702, 1930, 2299, 2731, 3101, 3316, 3439, 3679, 4156, 4810, 5529, 6221, 6922, 7688, 8583, 9653, 10864, 12086, 13129, 13879, 14322, 14521, 14496, 14295, 14026, 13765, 13528, 13241, 12758, 11955, 10816, 9515, 8215, 6984, 5865, 4898, 4247, 4134, 4590, 5360, 5954, 5991, 5274, 3836, 1943, -84, -2023, -3776, -5357, -6834, -8296, -9820, -11438, -13089, -14721, -16404, -18213, -20101, -21874, -23239, -23951, -23905, -23291, -22576, -22318, -22886, -24255, -25985, -27539, -28622, -29198, -29405, -29440, -29387, -29207, -28790, -27956, -26554, -24625, -22460, -20377, -18579, -17007, -15446, -13746, -11985, -10353, -9043, -8111, -7468, -6882, -6084, -4893, -3340, -1679, -230, 862, 1659, 2340, 3036, 3791, 4588, 5335, 5888, 6173, 6152, 5973, 5810, 5847, 6179, 6841, 7886, 9339, 11094, 12813, 14067, 14582, 14354, 13643, 12772, 12079, 11780, 11827, 11953, 11714, 10693, 8743, 6003, 2924, 47, -2173, -3499, -3997, -4021, -3905, -3810, -3815, -3930, -4091, -4202, -4211, -4067, -3682, -3032, -2098, -935, 348, 1632, 2758, 3539, 3838, 3661, 3337, 3269, 3675, 4473, 5301, 5697, 5351, 4129, 2147, -296, -2712, -4641, -5884, -6533, -6922, -7414, -8279, -9528, -11031, -12569, -13861, -14658, -14967, -14943, -14708, -14417, -14335, -14738, -15678, -16941, -18136, -18934, -19165, -18789, -17759, -16149, -14184, -12222, -10563, -9390, -8690, -8243, -7886, -7538, -7108, -6437, -5398, -4028, -2528, -1207, -356, -72, -265, -657, -905, -764, -239};