/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0015 256 samples */
 
const int16_t AKWF_piano_0015_256_DATA [256] = 
{244, 860, 1300, 1646, 1990, 2352, 2686, 2958, 3189, 3413, 3629, 3810, 3943, 4049, 4149, 4241, 4311, 4357, 4391, 4418, 4431, 4428, 4414, 4403, 4389, 4368, 4339, 4312, 4297, 4289, 4291, 4308, 4346, 4404, 4479, 4579, 4714, 4889, 5092, 5321, 5581, 5884, 6227, 6602, 7002, 7433, 7901, 8392, 8892, 9403, 9934, 10481, 11030, 11565, 12084, 12599, 13102, 13576, 14010, 14407, 14778, 15116, 15404, 15641, 15839, 16006, 16141, 16239, 16305, 16357, 16406, 16450, 16493, 16549, 16632, 16747, 16891, 17067, 17293, 17575, 17905, 18279, 18701, 19182, 19725, 20312, 20932, 21587, 22285, 23015, 23760, 24501, 25240, 25979, 26706, 27397, 28045, 28651, 29215, 29723, 30152, 30504, 30788, 31012, 31166, 31236, 31224, 31144, 31006, 30810, 30548, 30230, 29870, 29472, 29034, 28558, 28051, 27526, 26987, 26428, 25846, 25251, 24647, 24037, 23413, 22768, 22108, 21435, 20746, 20036, 19295, 18523, 17723, 16888, 16013, 15098, 14139, 13143, 12115, 11047, 9939, 8798, 7623, 6420, 5191, 3934, 2661, 1381, 91, -1208, -2514, -3823, -5120, -6402, -7679, -8945, -10189, -11408, -12598, -13765, -14915, -16040, -17136, -18208, -19255, -20278, -21272, -22230, -23157, -24057, -24920, -25747, -26535, -27279, -27981, -28637, -29242, -29801, -30311, -30766, -31167, -31516, -31823, -32090, -32313, -32487, -32614, -32701, -32753, -32768, -32744, -32685, -32593, -32470, -32314, -32125, -31910, -31672, -31407, -31111, -30785, -30432, -30058, -29659, -29232, -28778, -28298, -27794, -27267, -26713, -26138, -25544, -24931, -24301, -23658, -22998, -22331, -21663, -20995, -20328, -19659, -18989, -18333, -17702, -17092, -16498, -15913, -15344, -14802, -14280, -13770, -13268, -12780, -12305, -11836, -11355, -10862, -10369, -9875, -9365, -8833, -8291, -7756, -7219, -6653, -6060, -5475, -4921, -4378, -3803, -3196, -2626, -2132, -1659, -1102, -412};