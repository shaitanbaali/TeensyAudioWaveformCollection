/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0003 256 samples */
 
const int16_t AKWF_piano_0003_256_DATA [256] = 
{812, 2311, 3920, 5667, 7429, 9065, 10457, 11546, 12405, 13276, 14465, 16176, 18541, 21448, 24654, 27774, 30360, 32084, 32766, 32510, 31626, 30471, 29413, 28723, 28525, 28832, 29488, 30174, 30540, 30242, 29167, 27407, 25175, 22812, 20658, 18883, 17635, 16826, 16311, 15955, 15431, 14505, 13044, 11132, 8958, 6758, 4766, 3220, 2195, 1583, 1212, 962, 739, 485, 218, -86, -387, -724, -1141, -1734, -2593, -3808, -5363, -7006, -8496, -9607, -10269, -10520, -10488, -10258, -9993, -9812, -9739, -9793, -9997, -10320, -10840, -11634, -12787, -14191, -15574, -16607, -16995, -16641, -15637, -14170, -12646, -11494, -11117, -11665, -13064, -14851, -16474, -17461, -17587, -16940, -15667, -14007, -12256, -10723, -9681, -9240, -9300, -9589, -9835, -9759, -9184, -8021, -6307, -4243, -2240, -699, -41, -381, -1504, -3012, -4457, -5450, -5670, -5015, -3617, -1814, -86, 1219, 1903, 2014, 1742, 1221, 491, -499, -1785, -3311, -4948, -6544, -7933, -8931, -9358, -9225, -8706, -8093, -7669, -7631, -8000, -8649, -9338, -9767, -9725, -9176, -8201, -6992, -5863, -5004, -4402, -3901, -3339, -2573, -1530, -162, 1565, 3563, 5641, 7532, 9094, 10245, 11097, 11868, 12770, 13950, 15394, 17060, 18790, 20315, 21242, 21366, 20602, 19125, 17366, 15828, 15059, 15385, 16840, 19194, 21975, 24585, 26377, 26956, 26255, 24543, 22290, 20019, 18294, 17393, 17282, 17634, 17975, 17833, 17032, 15534, 13548, 11371, 9278, 7499, 6196, 5354, 4875, 4508, 4027, 3295, 2229, 709, -1403, -4134, -7403, -10936, -14361, -17280, -19427, -20718, -21228, -21099, -20560, -19904, -19444, -19363, -19713, -20380, -21178, -22053, -22926, -23723, -24338, -24804, -25162, -25557, -26106, -26871, -27764, -28568, -29002, -28831, -27957, -26357, -24227, -21885, -19643, -17700, -16085, -14727, -13493, -12186, -10662, -8822, -6707, -4426, -2235, -485};