/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0010 256 samples */
 
const int16_t AKWF_piano_0010_256_DATA [256] = 
{286, 973, 1652, 2343, 3044, 3756, 4481, 5213, 5955, 6705, 7458, 8215, 8970, 9719, 10464, 11200, 11923, 12636, 13335, 14019, 14691, 15349, 15994, 16629, 17254, 17868, 18475, 19074, 19667, 20253, 20831, 21401, 21964, 22517, 23058, 23588, 24105, 24607, 25097, 25569, 26027, 26470, 26897, 27309, 27707, 28091, 28463, 28823, 29169, 29504, 29827, 30137, 30433, 30717, 30985, 31238, 31473, 31691, 31890, 32070, 32229, 32367, 32486, 32583, 32660, 32716, 32752, 32767, 32764, 32741, 32699, 32637, 32556, 32454, 32332, 32188, 32023, 31836, 31626, 31392, 31134, 30853, 30548, 30220, 29869, 29495, 29101, 28684, 28248, 27793, 27319, 26827, 26318, 25789, 25245, 24684, 24105, 23510, 22900, 22270, 21627, 20967, 20291, 19602, 18898, 18181, 17455, 16717, 15969, 15215, 14452, 13683, 12911, 12131, 11348, 10563, 9773, 8982, 8188, 7390, 6590, 5791, 4987, 4184, 3382, 2579, 1778, 979, 183, -607, -1394, -2176, -2951, -3719, -4482, -5236, -5983, -6725, -7457, -8183, -8903, -9612, -10316, -11013, -11699, -12378, -13046, -13703, -14350, -14985, -15606, -16215, -16809, -17388, -17953, -18503, -19037, -19557, -20063, -20554, -21032, -21495, -21945, -22382, -22804, -23213, -23608, -23988, -24353, -24703, -25036, -25354, -25654, -25936, -26202, -26451, -26683, -26898, -27098, -27283, -27452, -27607, -27747, -27875, -27989, -28090, -28177, -28250, -28309, -28353, -28382, -28395, -28392, -28373, -28336, -28283, -28214, -28128, -28026, -27910, -27778, -27634, -27475, -27304, -27121, -26924, -26715, -26493, -26259, -26009, -25744, -25464, -25167, -24853, -24522, -24172, -23805, -23422, -23020, -22602, -22170, -21723, -21264, -20792, -20309, -19815, -19311, -18795, -18270, -17732, -17181, -16619, -16041, -15446, -14838, -14211, -13568, -12910, -12235, -11547, -10847, -10136, -9419, -8699, -7976, -7255, -6539, -5827, -5123, -4427, -3738, -3057, -2384, -1714, -1050, -370};