/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0026 256 samples */
 
const int16_t AKWF_piano_0026_256_DATA [256] = 
{937, 3910, 6994, 9962, 12867, 15652, 18180, 20319, 21879, 22765, 22966, 22542, 21685, 20584, 19462, 18552, 18062, 18111, 18693, 19668, 20752, 21641, 22052, 21845, 21031, 19781, 18347, 16982, 15891, 15200, 14966, 15135, 15621, 16268, 16907, 17384, 17567, 17419, 16950, 16208, 15281, 14253, 13197, 12184, 11272, 10542, 10025, 9735, 9643, 9699, 9863, 10088, 10303, 10442, 10409, 10151, 9633, 8842, 7801, 6559, 5172, 3721, 2286, 939, -265, -1298, -2186, -3010, -3887, -4963, -6371, -8156, -10264, -12555, -14810, -16841, -18493, -19706, -20531, -21082, -21510, -22002, -22685, -23637, -24935, -26521, -28259, -29953, -31370, -32339, -32756, -32593, -31890, -30723, -29162, -27227, -24921, -22279, -19341, -16155, -12812, -9375, -5936, -2635, 393, 3021, 5126, 6670, 7664, 8188, 8366, 8314, 8111, 7801, 7370, 6797, 6109, 5362, 4649, 4045, 3595, 3329, 3262, 3416, 3801, 4407, 5188, 6039, 6832, 7459, 7855, 8031, 7994, 7747, 7263, 6503, 5430, 4049, 2427, 625, -1257, -3120, -4916, -6593, -8114, -9458, -10586, -11439, -12013, -12322, -12404, -12306, -12042, -11642, -11127, -10521, -9872, -9192, -8490, -7715, -6819, -5765, -4550, -3258, -2006, -886, 39, 745, 1228, 1519, 1661, 1684, 1618, 1475, 1276, 1000, 645, 218, -271, -814, -1408, -2017, -2574, -3067, -3429, -3662, -3756, -3711, -3561, -3351, -3155, -3017, -2983, -3083, -3310, -3604, -3916, -4198, -4414, -4584, -4710, -4786, -4782, -4652, -4338, -3817, -3072, -2115, -979, 291, 1609, 2869, 3920, 4653, 4991, 4933, 4563, 4026, 3443, 2888, 2363, 1866, 1318, 654, -227, -1388, -2879, -4642, -6558, -8438, -10056, -11217, -11839, -11977, -11774, -11408, -11069, -10875, -10903, -11167, -11673, -12387, -13257, -14176, -14989, -15547, -15711, -15446, -14776, -13778, -12483, -10903, -9026, -6815, -4354, -1532};