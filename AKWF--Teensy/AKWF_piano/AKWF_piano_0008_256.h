/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0008 256 samples */
 
const int16_t AKWF_piano_0008_256_DATA [256] = 
{2248, 6452, 10612, 14320, 17260, 18870, 18753, 17478, 16200, 15792, 16615, 18611, 21376, 24389, 27282, 29704, 31356, 32309, 32759, 32544, 31443, 29586, 27001, 23399, 18995, 14685, 11168, 8588, 6883, 5593, 3886, 1537, -752, -2456, -3713, -4608, -5318, -6293, -7505, -8350, -8489, -7674, -5399, -1675, 2520, 6026, 8176, 8834, 8761, 9283, 10986, 13271, 15298, 16548, 16865, 16655, 16346, 15503, 13396, 10322, 7218, 4797, 3770, 4461, 6058, 7400, 8155, 8241, 7161, 4859, 2272, 378, -310, 10, 91, -1425, -4283, -6973, -8438, -8299, -6630, -4506, -3530, -4092, -5149, -5750, -5834, -5812, -6126, -7022, -8201, -9223, -9971, -10254, -9793, -8825, -7839, -6914, -6054, -5547, -5418, -5270, -4992, -5029, -5753, -7255, -9341, -11299, -12083, -11270, -9356, -7116, -5126, -3636, -2535, -1865, -2157, -3776, -6252, -8738, -10663, -11557, -11090, -9805, -8950, -9104, -9824, -10435, -10368, -8945, -5704, -899, 4694, 10215, 15009, 18947, 22278, 24747, 25745, 25038, 22746, 18972, 14234, 9945, 7312, 6541, 6967, 7339, 6636, 4937, 3270, 2450, 2879, 4798, 7771, 10478, 11775, 11190, 8802, 5442, 2477, 724, 184, 840, 2460, 4238, 5611, 6588, 6920, 6184, 4655, 2904, 1089, -533, -1529, -1969, -2147, -1963, -1413, -900, -596, -245, 393, 1662, 4025, 7383, 11026, 14557, 17847, 20161, 20496, 18456, 14087, 7955, 1531, -3445, -6135, -6612, -5329, -3183, -1270, -225, -267, -1500, -3738, -6318, -8705, -10873, -13077, -15631, -18716, -22017, -24909, -27009, -28280, -28724, -28384, -27574, -26579, -25382, -24084, -23030, -22493, -22474, -22875, -23473, -23913, -24086, -24076, -23639, -22210, -19645, -16488, -13456, -11187, -9962, -9253, -8144, -6405, -4472, -2783, -1854, -2273, -4031, -6733, -10155, -13901, -16924, -18301, -18010, -16430, -14031, -11355, -8498, -4934, -992};