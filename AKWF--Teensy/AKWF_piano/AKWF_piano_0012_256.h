/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0012 256 samples */
 
const int16_t AKWF_piano_0012_256_DATA [256] = 
{197, 1092, 2535, 4375, 6143, 7260, 7324, 6319, 4718, 3260, 2641, 3187, 4741, 6831, 8945, 10769, 12193, 13295, 14285, 15369, 16685, 18313, 20211, 22252, 24203, 25914, 27291, 28324, 29026, 29401, 29551, 29680, 30005, 30682, 31607, 32446, 32769, 32158, 30474, 27925, 24910, 21768, 18678, 15629, 12642, 9831, 7309, 5153, 3332, 1663, 19, -1703, -3405, -4793, -5515, -5261, -3904, -1554, 1378, 4269, 6467, 7648, 7937, 7791, 7753, 8167, 9118, 10468, 11963, 13313, 14226, 14577, 14400, 14005, 13703, 13656, 13787, 13945, 14007, 13879, 13510, 12870, 11996, 11005, 9912, 8620, 7031, 5222, 3438, 1962, 955, 422, 239, 227, 133, -322, -1254, -2582, -4052, -5454, -6696, -7816, -8902, -10087, -11431, -12955, -14670, -16561, -18533, -20455, -22258, -23940, -25516, -26994, -28302, -29349, -30088, -30412, -30272, -29773, -29102, -28383, -27734, -27255, -27063, -27184, -27489, -27762, -27774, -27396, -26642, -25619, -24431, -23152, -21771, -20171, -18256, -16101, -13845, -11641, -9557, -7641, -5841, -4076, -2327, -590, 1021, 2348, 3197, 3495, 3345, 2958, 2618, 2552, 2874, 3612, 4742, 6177, 7623, 8730, 9381, 9609, 9528, 9250, 8891, 8617, 8598, 8895, 9423, 10019, 10593, 11126, 11587, 11889, 12016, 12013, 11909, 11733, 11390, 10761, 9828, 8622, 7150, 5386, 3352, 1178, -935, -2849, -4515, -5915, -6944, -7456, -7350, -6768, -5945, -5067, -4243, -3483, -2697, -1762, -582, 797, 2148, 3173, 3782, 4057, 4229, 4501, 4965, 5562, 6099, 6303, 5952, 4968, 3481, 1842, 422, -587, -1350, -2241, -3531, -5271, -7233, -9154, -10881, -12400, -13851, -15298, -16670, -17715, -18153, -17820, -16864, -15730, -14960, -14882, -15565, -16732, -17937, -18631, -18414, -17259, -15478, -13640, -12231, -11510, -11350, -11399, -11268, -10726, -9699, -8254, -6492, -4453, -2221, -287};