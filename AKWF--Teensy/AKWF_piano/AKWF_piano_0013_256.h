/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0013 256 samples */
 
const int16_t AKWF_piano_0013_256_DATA [256] = 
{375, 1891, 4027, 6245, 8059, 9175, 9569, 9495, 9413, 9784, 10841, 12552, 14681, 16984, 19268, 21333, 23010, 24263, 25245, 26187, 27226, 28315, 29323, 30250, 31151, 32005, 32623, 32738, 32156, 30838, 28829, 26270, 23357, 20346, 17485, 14913, 12616, 10464, 8359, 6314, 4358, 2534, 903, -418, -1230, -1410, -992, -108, 1083, 2427, 3739, 4803, 5480, 5819, 6025, 6292, 6734, 7302, 7982, 8747, 9572, 10448, 11392, 12399, 13406, 14275, 14880, 15113, 14969, 14511, 13829, 13050, 12284, 11582, 10895, 10124, 9181, 8109, 6992, 5978, 5166, 4541, 4011, 3494, 2941, 2358, 1780, 1231, 722, 252, -216, -809, -1681, -3013, -4853, -7154, -9689, -12122, -14265, -16080, -17588, -18856, -19896, -20742, -21461, -22199, -23114, -24162, -25227, -26165, -26847, -27172, -27126, -26843, -26495, -26274, -26325, -26720, -27377, -28144, -28786, -29086, -28947, -28327, -27261, -25790, -23924, -21646, -18967, -16115, -13545, -11629, -10435, -9689, -9044, -8219, -7059, -5627, -4177, -2970, -2135, -1615, -1202, -643, 250, 1495, 2866, 4078, 4920, 5323, 5439, 5512, 5749, 6228, 6815, 7249, 7369, 7276, 7238, 7513, 8167, 9091, 10093, 11011, 11738, 12263, 12647, 12981, 13299, 13457, 13176, 12242, 10668, 8627, 6392, 4309, 2651, 1497, 677, -121, -1159, -2494, -3982, -5406, -6582, -7337, -7525, -7037, -5867, -4186, -2318, -683, 412, 827, 629, 72, -447, -467, 273, 1732, 3545, 5199, 6307, 6670, 6289, 5369, 4200, 3087, 2187, 1446, 682, -223, -1327, -2655, -4199, -5933, -7726, -9406, -10870, -12100, -13085, -13784, -14125, -14082, -13800, -13563, -13643, -14201, -15154, -16285, -17305, -17901, -17854, -17180, -16111, -15016, -14263, -14020, -14200, -14522, -14525, -13836, -12292, -10049, -7516, -5187, -3420, -2347, -1920, -1981, -2277, -2535, -2561, -2272, -1658, -717};