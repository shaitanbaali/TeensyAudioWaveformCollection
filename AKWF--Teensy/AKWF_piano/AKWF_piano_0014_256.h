/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0014 256 samples */
 
const int16_t AKWF_piano_0014_256_DATA [256] = 
{1715, 4681, 7292, 9672, 11815, 13832, 15706, 17562, 19462, 21409, 23364, 25274, 27179, 28985, 30541, 31755, 32503, 32767, 32554, 31823, 30589, 28971, 27261, 25843, 25030, 24994, 25532, 26366, 27251, 28001, 28410, 28313, 27608, 26190, 24260, 22051, 19909, 18122, 16910, 16299, 16188, 16447, 16672, 16382, 15266, 13247, 10551, 7623, 4962, 3052, 2115, 2153, 2884, 3713, 4093, 3628, 2261, 183, -2235, -4613, -6802, -8670, -10201, -11415, -12409, -13269, -14041, -14752, -15298, -15582, -15593, -15368, -15096, -15014, -15305, -16121, -17421, -19028, -20697, -22035, -22783, -22781, -22131, -21037, -19688, -18312, -17057, -16026, -15263, -14745, -14407, -14139, -13894, -13732, -13718, -13859, -13973, -13930, -13590, -12977, -12201, -11347, -10580, -10044, -9749, -9651, -9632, -9424, -8715, -7313, -5119, -2247, 995, 4191, 6882, 8572, 8896, 7777, 5362, 2072, -1475, -4621, -6813, -7682, -7199, -5710, -3804, -2090, -1104, -1111, -2185, -4056, -6324, -8464, -9987, -10628, -10468, -9788, -8948, -8179, -7655, -7343, -7114, -6796, -6313, -5602, -4587, -3351, -1932, -475, 857, 2036, 3084, 4007, 4722, 5209, 5508, 5629, 5736, 5905, 6193, 6625, 7214, 7914, 8578, 9072, 9405, 9654, 10058, 10798, 11953, 13519, 15449, 17587, 19699, 21563, 22852, 23472, 23480, 23081, 22594, 22283, 22269, 22551, 23017, 23556, 23848, 23589, 22534, 20708, 18272, 15681, 13409, 11855, 11307, 11889, 13471, 15584, 17594, 18706, 18349, 16205, 12469, 7670, 2632, -1816, -5010, -6603, -6629, -5539, -4008, -2797, -2434, -3197, -5091, -7919, -11299, -14796, -18073, -20804, -22913, -24373, -25235, -25543, -25419, -25064, -24715, -24682, -25077, -25885, -27044, -28327, -29574, -30574, -31170, -31301, -30829, -29819, -28443, -26940, -25575, -24416, -23522, -22800, -22101, -21340, -20410, -19307, -18044, -16519, -14694, -12515, -9958, -7171, -4321, -1681};