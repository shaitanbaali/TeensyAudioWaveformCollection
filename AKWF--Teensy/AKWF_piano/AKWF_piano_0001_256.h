/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0001 256 samples */
 
const int16_t AKWF_piano_0001_256_DATA [256] = 
{582, 2676, 4914, 6909, 8195, 8528, 8185, 7824, 7966, 8657, 9652, 10694, 11639, 12334, 12516, 12027, 10945, 9567, 8312, 7851, 8877, 11739, 16145, 21263, 26105, 29859, 31860, 31814, 29914, 26730, 22965, 19222, 15996, 13403, 11228, 9003, 6318, 3180, 199, -1609, -1385, 1127, 5356, 10299, 14925, 18526, 20802, 21605, 20939, 18923, 15851, 12186, 8483, 5159, 2245, -653, -3815, -7243, -10842, -14407, -17679, -20396, -22365, -23485, -23666, -22995, -21889, -20763, -19681, -18527, -17315, -16157, -14878, -13010, -10126, -6115, -1301, 3748, 8384, 11953, 14000, 14431, 13557, 12074, 10711, 9853, 9524, 9782, 10574, 11625, 12669, 13835, 15607, 18287, 21467, 24211, 25749, 25798, 24455, 21926, 18504, 14674, 11217, 8680, 7126, 6329, 6264, 7058, 8526, 10140, 11421, 12232, 12540, 12175, 11056, 9396, 7570, 5824, 4186, 2595, 1100, -146, -1156, -2060, -2826, -3211, -2939, -2179, -1522, -1323, -1483, -1812, -2588, -4354, -7445, -11499, -15643, -18938, -20740, -20907, -19808, -18334, -17219, -16525, -15886, -15071, -14270, -13862, -13993, -14661, -15807, -17032, -17518, -16496, -13652, -9282, -4446, -281, 2720, 4677, 5853, 6311, 5988, 4719, 2329, -1167, -5317, -9184, -11799, -12675, -11917, -9956, -7190, -3841, 74, 4439, 9033, 13588, 17552, 20117, 20679, 19304, 16785, 14266, 12573, 11868, 11995, 12610, 13342, 14019, 14916, 16439, 18507, 20462, 21534, 21315, 19889, 17587, 14800, 11782, 8621, 5289, 1920, -1237, -3866, -5714, -6819, -7535, -8221, -9241, -10919, -13363, -16445, -19737, -22671, -24988, -26741, -28275, -29869, -31427, -32527, -32686, -31417, -28397, -23783, -18439, -13430, -9526, -7230, -6810, -8225, -11073, -14814, -18847, -22423, -24852, -25874, -25810, -25231, -24531, -23902, -23336, -22624, -21507, -19868, -17696, -15054, -12018, -8813, -5909, -3904, -3135, -3327, -3621, -3127, -1352};