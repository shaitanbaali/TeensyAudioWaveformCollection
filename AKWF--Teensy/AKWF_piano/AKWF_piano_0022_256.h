/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0022 256 samples */
 
const int16_t AKWF_piano_0022_256_DATA [256] = 
{797, 1914, 2748, 4233, 6650, 9714, 12789, 15555, 18544, 21992, 24908, 25811, 23638, 18124, 10430, 2832, -3101, -7051, -9023, -9286, -8265, -6262, -3946, -2889, -4133, -6664, -8734, -9490, -8997, -8438, -9382, -12264, -15970, -18752, -19085, -16592, -12559, -8752, -5750, -3125, -466, 2456, 5538, 7781, 8488, 7904, 6474, 4794, 3935, 4444, 5872, 7878, 10530, 13275, 15194, 15950, 15775, 15292, 15406, 16121, 16185, 14623, 11338, 6569, 1110, -3930, -8049, -10845, -11440, -9544, -6290, -3098, -883, -324, -1408, -3028, -4232, -4950, -5014, -4777, -5316, -7142, -9567, -11311, -11366, -9280, -5216, 284, 6946, 14243, 20666, 24841, 26312, 25228, 22332, 18528, 14262, 9932, 6262, 3492, 1032, -1499, -3727, -5454, -6770, -7687, -8225, -8526, -8516, -8694, -10481, -14528, -19967, -25298, -29426, -31944, -32791, -31511, -27153, -19453, -9618, 543, 9385, 15154, 16754, 14394, 9399, 3895, 439, 383, 2602, 4763, 5358, 4294, 2633, 2050, 3254, 5607, 8030, 9415, 9043, 7811, 7806, 9728, 12013, 12219, 8546, 1210, -7378, -14103, -17340, -16735, -12640, -6591, -745, 3448, 5504, 5851, 5774, 6127, 6562, 6550, 6088, 5181, 3863, 2558, 1500, 435, -545, -1223, -1989, -2869, -3389, -3355, -2798, -1712, -538, -241, -1535, -4701, -9685, -15185, -18877, -19483, -17531, -14122, -10354, -7011, -3926, -937, 1531, 3076, 3852, 4274, 4941, 6199, 7482, 7318, 4918, 969, -3299, -6544, -7898, -7706, -6504, -3950, 296, 5541, 10634, 14328, 15240, 13042, 9302, 5875, 3458, 1792, 193, -1962, -4191, -5442, -5304, -4076, -1889, 1137, 4626, 8589, 12840, 16035, 16745, 14589, 10174, 4909, 312, -3410, -6585, -8828, -9647, -9342, -8415, -7295, -6717, -7024, -7295, -6301, -3708, 109, 3757, 4908, 2348, -2792, -8299, -11954, -12585, -10640, -7283, -2817};