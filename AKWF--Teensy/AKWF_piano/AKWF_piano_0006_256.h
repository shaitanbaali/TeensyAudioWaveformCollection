/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_piano_0006 256 samples */
 
const int16_t AKWF_piano_0006_256_DATA [256] = 
{313, 1352, 2542, 3662, 4783, 6062, 7465, 8887, 10379, 12012, 13728, 15465, 17249, 19094, 20940, 22723, 24447, 26111, 27641, 28991, 30176, 31177, 31940, 32452, 32724, 32750, 32516, 32048, 31389, 30556, 29569, 28481, 27340, 26171, 25006, 23900, 22897, 21997, 21209, 20556, 20027, 19598, 19257, 18987, 18747, 18499, 18222, 17898, 17483, 16946, 16287, 15499, 14553, 13449, 12205, 10818, 9280, 7603, 5807, 3912, 1920, -144, -2232, -4332, -6430, -8475, -10428, -12273, -13979, -15512, -16841, -17957, -18847, -19486, -19870, -20023, -19953, -19662, -19179, -18550, -17803, -16956, -16062, -15170, -14293, -13448, -12677, -12008, -11445, -10988, -10663, -10483, -10423, -10461, -10603, -10843, -11150, -11495, -11878, -12280, -12660, -12995, -13272, -13469, -13554, -13507, -13321, -12980, -12479, -11833, -11049, -10129, -9085, -7939, -6724, -5460, -4163, -2864, -1590, -353, 823, 1919, 2942, 3887, 4740, 5501, 6185, 6811, 7384, 7910, 8417, 8925, 9442, 9988, 10586, 11238, 11943, 12703, 13523, 14388, 15273, 16162, 17040, 17874, 18636, 19319, 19906, 20378, 20731, 20973, 21099, 21102, 20995, 20802, 20527, 20171, 19754, 19299, 18808, 18272, 17699, 17100, 16467, 15800, 15123, 14438, 13731, 13005, 12278, 11553, 10817, 10066, 9311, 8544, 7735, 6882, 5990, 5032, 3984, 2849, 1621, 289, -1149, -2684, -4289, -5957, -7677, -9393, -11068, -12690, -14224, -15632, -16894, -18003, -18951, -19722, -20319, -20758, -21038, -21162, -21162, -21054, -20843, -20539, -20176, -19772, -19326, -18855, -18390, -17946, -17528, -17160, -16870, -16657, -16512, -16447, -16471, -16565, -16714, -16921, -17175, -17437, -17682, -17912, -18108, -18231, -18271, -18240, -18118, -17877, -17531, -17102, -16567, -15920, -15212, -14471, -13678, -12835, -11998, -11195, -10395, -9602, -8887, -8250, -7614, -6990, -6451, -5953, -5383, -4771, -4205, -3583, -2719, -1722, -926, -328};