/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0064 256 samples */
 
const int16_t AKWF_dbass_0064_256_DATA [256] = 
{371, 984, 1269, 1437, 1775, 2128, 2575, 3513, 4332, 5129, 5815, 6711, 7002, 7474, 7397, 7149, 6541, 6429, 6372, 7488, 7903, 7956, 8315, 8299, 8112, 7878, 7236, 5997, 4655, 5181, 5151, 4437, 4604, 5988, 6315, 7026, 8487, 9149, 9036, 8767, 8793, 8158, 7620, 7442, 8273, 8785, 9327, 10603, 11070, 11797, 12356, 12788, 13400, 13344, 12403, 12636, 13317, 13502, 13910, 14859, 16041, 17276, 18270, 19395, 19980, 20786, 21511, 22144, 22331, 22381, 22013, 21403, 20558, 19655, 18645, 17995, 17392, 16894, 16824, 16792, 16583, 16239, 15612, 14646, 13383, 12435, 11747, 10998, 10653, 10297, 10307, 10559, 10805, 11048, 11283, 11483, 11547, 11708, 11554, 11713, 12402, 13313, 14075, 14865, 15801, 16757, 17462, 17893, 17991, 17680, 17086, 16551, 16070, 15415, 14974, 14624, 14710, 15147, 15540, 15903, 16362, 16770, 16942, 16987, 17199, 17341, 17322, 17012, 16279, 15903, 15413, 14814, 14126, 13602, 13105, 12666, 12246, 11845, 11384, 10717, 9910, 9130, 8220, 7057, 5754, 4353, 2955, 1596, -65, -1686, -2942, -3856, -4637, -5394, -5937, -6398, -7138, -7752, -8804, -9990, -11006, -12049, -13166, -14188, -15043, -15608, -15914, -16157, -16336, -16266, -16056, -15777, -15421, -15142, -14711, -14477, -14216, -14009, -13978, -13886, -13950, -14038, -14237, -14601, -14989, -15271, -15403, -15451, -15536, -15327, -14940, -14583, -14118, -13707, -13403, -13103, -12866, -12812, -12861, -12737, -12628, -12692, -12641, -12772, -13027, -13284, -13753, -14516, -15194, -16083, -16839, -17608, -18224, -18799, -19406, -20024, -20951, -22071, -23403, -24921, -26455, -28079, -29576, -30728, -31654, -32337, -32543, -32755, -32700, -32476, -32332, -32262, -32083, -31814, -31146, -30271, -28933, -27511, -25882, -24228, -22718, -21098, -19483, -17822, -15943, -13862, -11884, -10139, -8356, -6816, -5416, -4123, -3067, -1991, -1118, -319};