/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0045 256 samples */
 
const int16_t AKWF_dbass_0045_256_DATA [256] = 
{451, 1549, 2622, 3679, 4809, 5893, 6957, 8049, 9143, 10046, 10886, 11796, 12587, 13450, 14401, 15336, 16232, 17074, 17879, 18643, 19389, 20217, 20837, 21513, 22138, 22764, 23379, 23960, 24594, 25231, 25835, 26527, 27336, 28051, 28823, 29486, 30158, 30757, 31287, 31760, 32019, 32152, 32226, 32239, 32345, 32482, 32615, 32670, 32699, 32677, 32614, 32513, 32298, 31931, 31497, 30971, 30456, 29922, 29326, 28669, 28046, 27472, 26881, 26376, 25925, 25394, 24968, 24440, 23919, 23347, 22636, 21907, 21145, 20237, 19395, 18483, 17644, 16787, 15860, 15002, 14216, 13461, 12649, 11898, 11303, 10630, 9923, 9094, 8127, 7470, 6783, 6202, 5599, 5061, 4365, 3664, 3032, 2371, 1846, 1141, 647, 272, -7, -101, -205, -462, -1018, -1584, -2035, -2398, -2989, -3773, -4610, -5141, -5258, -5227, -5375, -5461, -5550, -5476, -5079, -4936, -4905, -4668, -4529, -4555, -4456, -4264, -4285, -4406, -4552, -4440, -4242, -3819, -3329, -2787, -2519, -2320, -1979, -1991, -2101, -2160, -2368, -2566, -2514, -2418, -2461, -2612, -2822, -2931, -3005, -3211, -3243, -3304, -3326, -3335, -3476, -3470, -3395, -3287, -3260, -3397, -3764, -4076, -4401, -4971, -5888, -6926, -7847, -8723, -9420, -10126, -10742, -11052, -11232, -11135, -11017, -10919, -10927, -10816, -10902, -11351, -11897, -12549, -13293, -13971, -14641, -15304, -15802, -16206, -16576, -16855, -17429, -18123, -18705, -19538, -20126, -20535, -20994, -21519, -21867, -22057, -22201, -22342, -22472, -22720, -22884, -23135, -23282, -23497, -23802, -24136, -24375, -24462, -24528, -24611, -24656, -24776, -24906, -24960, -25044, -25101, -25098, -24899, -24549, -24221, -23718, -23093, -22372, -21563, -20859, -20118, -19302, -18503, -17753, -17026, -16308, -15808, -15262, -14696, -14026, -13388, -12616, -11796, -10796, -9715, -8547, -7460, -6504, -5549, -4754, -4014, -3201, -2387, -1503, -664};