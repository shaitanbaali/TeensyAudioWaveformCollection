/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0031 256 samples */
 
const int16_t AKWF_dbass_0031_256_DATA [256] = 
{660, 1618, 2550, 3500, 4422, 5318, 6215, 7121, 8026, 8926, 9827, 10722, 11614, 12505, 13394, 14280, 15153, 15987, 16765, 17503, 18244, 18993, 19730, 20467, 21189, 21878, 22541, 23164, 23729, 24256, 24773, 25307, 25837, 26352, 26861, 27329, 27745, 28152, 28542, 28897, 29196, 29438, 29672, 29928, 30222, 30519, 30782, 30996, 31170, 31338, 31511, 31687, 31851, 31978, 32071, 32161, 32264, 32376, 32462, 32507, 32544, 32577, 32588, 32598, 32623, 32675, 32735, 32768, 32759, 32718, 32680, 32647, 32615, 32581, 32552, 32509, 32449, 32368, 32274, 32159, 32006, 31850, 31708, 31579, 31462, 31361, 31249, 31103, 30911, 30675, 30407, 30124, 29841, 29565, 29285, 29007, 28718, 28401, 28056, 27693, 27321, 26924, 26502, 26047, 25559, 25058, 24576, 24090, 23560, 22984, 22378, 21749, 21098, 20416, 19742, 19086, 18403, 17677, 16917, 16146, 15356, 14535, 13705, 12887, 12063, 11216, 10331, 9397, 8476, 7583, 6686, 5769, 4831, 3912, 2999, 2079, 1132, 183, -697, -1565, -2447, -3340, -4241, -5120, -5983, -6822, -7612, -8400, -9195, -9938, -10661, -11398, -12108, -12786, -13466, -14115, -14719, -15289, -15816, -16301, -16795, -17294, -17769, -18202, -18600, -18997, -19375, -19695, -19963, -20226, -20507, -20793, -21072, -21356, -21612, -21813, -21994, -22181, -22383, -22585, -22767, -22921, -23060, -23198, -23344, -23491, -23614, -23711, -23785, -23853, -23948, -24048, -24128, -24198, -24265, -24345, -24427, -24492, -24566, -24636, -24682, -24714, -24747, -24758, -24745, -24745, -24763, -24756, -24720, -24671, -24609, -24521, -24401, -24271, -24138, -23994, -23836, -23670, -23492, -23289, -23075, -22838, -22549, -22235, -21925, -21586, -21205, -20787, -20339, -19867, -19366, -18835, -18285, -17705, -17085, -16447, -15802, -15137, -14459, -13766, -13035, -12282, -11506, -10716, -9899, -9075, -8283, -7495, -6704, -5903, -5063, -4207, -3321, -2390, -1490, -592};