/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0027 256 samples */
 
const int16_t AKWF_dbass_0027_256_DATA [256] = 
{228, 479, 1078, 1942, 2629, 3259, 4368, 5258, 5638, 5970, 6879, 7933, 8693, 9538, 10627, 12100, 13365, 14486, 15356, 15796, 15724, 15246, 14939, 15174, 15574, 16229, 17147, 18194, 18655, 18227, 17553, 16657, 15807, 15214, 14893, 14917, 14804, 14001, 12891, 11929, 11280, 10859, 10816, 11078, 11316, 11373, 11378, 11481, 11784, 11968, 12009, 12260, 12645, 12810, 12787, 12664, 12408, 12094, 12016, 12310, 12877, 13372, 13661, 13775, 14020, 14214, 13983, 13662, 13455, 13313, 13417, 13724, 14291, 14604, 14715, 14754, 14919, 15127, 15434, 16057, 16834, 17692, 18607, 19300, 19918, 20722, 21473, 22246, 23117, 23946, 24686, 25141, 25299, 25360, 25172, 24905, 24719, 24491, 24378, 24057, 23835, 23811, 23800, 23694, 23549, 23251, 22966, 22853, 22611, 22571, 22504, 22323, 22206, 22000, 21886, 21642, 21413, 21192, 21055, 20915, 20544, 20128, 19692, 19020, 18153, 17344, 16489, 15523, 14514, 13637, 12862, 12118, 11501, 10983, 10224, 9311, 8375, 7276, 6361, 5671, 4889, 4228, 3595, 2997, 2520, 2154, 1884, 1796, 1552, 1325, 1008, 655, 135, -339, -821, -1169, -1340, -1640, -1848, -2107, -2564, -3054, -3610, -4193, -4662, -5126, -5509, -5806, -6290, -6891, -7807, -8814, -9800, -10829, -11645, -12368, -12872, -13417, -14016, -14574, -15095, -15856, -16636, -17303, -17942, -18601, -19255, -19960, -20768, -21732, -22722, -23653, -24365, -25021, -25582, -26109, -26582, -27047, -27526, -28071, -28664, -29285, -29894, -30394, -30886, -31361, -31844, -32207, -32570, -32674, -32745, -32722, -32373, -31986, -31542, -31220, -30960, -30995, -30944, -31034, -30850, -30355, -29865, -29500, -29119, -28329, -27489, -26963, -26275, -25274, -24478, -24006, -23109, -22079, -21047, -19986, -18704, -17407, -16543, -15941, -14879, -13516, -12480, -11684, -10849, -10121, -9376, -8587, -7676, -6346, -5097, -3833, -2583, -1365, -587, -166};