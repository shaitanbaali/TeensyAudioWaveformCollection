/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0002 256 samples */
 
const int16_t AKWF_dbass_0002_256_DATA [256] = 
{563, 1736, 2777, 3705, 4608, 5490, 6323, 7073, 7750, 8353, 8991, 9779, 10565, 11357, 12158, 13018, 13882, 14810, 15768, 16750, 17715, 18639, 19406, 20185, 20899, 21542, 22101, 22695, 23306, 23962, 24627, 25402, 26105, 26795, 27279, 27653, 27962, 28193, 28423, 28667, 29025, 29425, 29774, 30138, 30649, 30987, 31306, 31660, 31967, 32241, 32519, 32661, 32691, 32767, 32639, 32358, 32097, 31554, 30975, 30471, 29943, 29603, 29329, 29253, 29149, 28980, 28632, 28382, 28247, 28037, 27659, 27152, 26516, 25711, 25125, 24701, 24338, 23957, 23596, 23037, 22720, 22390, 21846, 21423, 20790, 20267, 19848, 19560, 19416, 19132, 18709, 18264, 17778, 17262, 16903, 16519, 16160, 15633, 15108, 14571, 14051, 13691, 13217, 12587, 11947, 11542, 11370, 11297, 11254, 10835, 10269, 9637, 9178, 8676, 8040, 7327, 6479, 5686, 4816, 4231, 3985, 3694, 3324, 2961, 2677, 2412, 1989, 1251, 354, -647, -1609, -2321, -2838, -3112, -3247, -3349, -3346, -3237, -3010, -2760, -2585, -2553, -2904, -3347, -3895, -4652, -5630, -6790, -8021, -9099, -10105, -10924, -11584, -12169, -12649, -13092, -13419, -13776, -14029, -14457, -14953, -15611, -16355, -17169, -17970, -18743, -19547, -20041, -20537, -20935, -21300, -21663, -22143, -22737, -23386, -24305, -25209, -26067, -26822, -27323, -27684, -27877, -28003, -27974, -28018, -28070, -28248, -28623, -28936, -29198, -29459, -29465, -29313, -29144, -28881, -28550, -28176, -27860, -27607, -27503, -27465, -27598, -27891, -28251, -28650, -29011, -29248, -29372, -29243, -28976, -28483, -27811, -27015, -26299, -25675, -25104, -24560, -23986, -23499, -23171, -22915, -22644, -22442, -22048, -21680, -21202, -20667, -20072, -19467, -18788, -18057, -17437, -16834, -16259, -15780, -15215, -14691, -14041, -13429, -12845, -12267, -11651, -11021, -10341, -9752, -9188, -8602, -8023, -7373, -6616, -5821, -4961, -3980, -2972, -1848, -619};