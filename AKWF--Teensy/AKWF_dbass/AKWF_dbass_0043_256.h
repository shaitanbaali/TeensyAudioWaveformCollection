/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0043 256 samples */
 
const int16_t AKWF_dbass_0043_256_DATA [256] = 
{698, 1445, 2315, 2957, 3874, 4716, 5364, 5768, 6216, 6529, 6745, 7150, 7633, 7962, 8442, 8881, 9398, 10264, 11424, 12648, 13996, 15129, 16233, 17237, 18074, 18979, 19910, 20537, 21230, 21925, 22859, 23736, 24272, 24471, 24932, 25190, 25636, 26054, 26600, 27303, 28044, 29007, 29975, 30698, 31413, 31984, 32203, 32446, 32740, 32722, 32708, 32515, 32311, 31907, 31611, 31298, 31042, 30811, 30560, 30505, 30376, 30141, 29913, 29669, 29387, 28967, 28901, 28589, 28214, 27672, 27331, 26880, 26205, 25496, 24672, 23815, 23021, 22232, 21562, 21185, 20730, 20373, 20201, 20046, 19564, 19416, 19016, 18555, 18008, 17542, 16855, 16193, 15591, 14827, 14074, 13462, 12705, 11981, 11217, 10537, 9979, 9462, 8903, 8445, 7788, 7757, 7820, 7351, 6758, 5990, 5217, 4574, 4031, 3564, 2756, 1870, 1577, 1309, 1298, 1232, 797, 424, 357, 749, 991, 906, 686, 510, 782, 903, 929, 681, 315, 648, 1326, 2232, 2815, 2752, 2355, 1860, 1875, 1674, 1076, 443, -289, -369, -140, 193, -69, -670, -1008, -1507, -1474, -1740, -2486, -3955, -4797, -4900, -4877, -4989, -5575, -6617, -7721, -8669, -9515, -10666, -11896, -13067, -13818, -13674, -13542, -13497, -13642, -13927, -13727, -13202, -12679, -12781, -13250, -13775, -14059, -14359, -14912, -15933, -17061, -17843, -18005, -17745, -17540, -17279, -17164, -16885, -16892, -16889, -16939, -17316, -18000, -18366, -18436, -18402, -17992, -17902, -17870, -17762, -18250, -18712, -19380, -20596, -22040, -23542, -24606, -25168, -25370, -25352, -25215, -25031, -24445, -24134, -24108, -24039, -24102, -24245, -24081, -23992, -23563, -23309, -23090, -22763, -22303, -21670, -21220, -21129, -20879, -20593, -20177, -19372, -18306, -17313, -16023, -14676, -13072, -11418, -9737, -8364, -7257, -6585, -5794, -5119, -4692, -4413, -4087, -3874, -3304, -2093, -1096, -311};