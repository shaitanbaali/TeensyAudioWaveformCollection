/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0037 256 samples */
 
const int16_t AKWF_dbass_0037_256_DATA [256] = 
{1128, 2876, 4536, 6188, 7783, 9381, 10905, 12298, 13668, 14941, 16123, 17291, 18446, 19503, 20406, 21212, 22024, 22686, 23275, 23753, 24208, 24503, 24709, 24772, 24834, 24790, 24686, 24558, 24346, 23979, 23665, 23295, 22826, 22329, 21710, 21016, 20210, 19355, 18505, 17552, 16584, 15537, 14533, 13510, 12428, 11319, 10277, 9224, 8129, 7082, 6085, 5124, 4228, 3407, 2690, 1902, 1201, 596, -31, -560, -1021, -1433, -1736, -1898, -2057, -2063, -2006, -1949, -1717, -1442, -1050, -635, -110, 1134, 2753, 4267, 5745, 7317, 8842, 10317, 11744, 13169, 14514, 15798, 16990, 18143, 19115, 20043, 20905, 21743, 22455, 23152, 23690, 24208, 24663, 24947, 25271, 25421, 25441, 25432, 25336, 25123, 24837, 24430, 24088, 23620, 23026, 22458, 21762, 20984, 20141, 19260, 18243, 17222, 16050, 14849, 13622, 12334, 10988, 9672, 8384, 7065, 5755, 4460, 3260, 2090, 892, -237, -1217, -2168, -3083, -3867, -4693, -5410, -6124, -6810, -7348, -7811, -8308, -8583, -8862, -9118, -9147, -9212, -9184, -8976, -8833, -8554, -8140, -7682, -7106, -6486, -5679, -4808, -3872, -2937, -1951, -985, 39, 858, 1726, 2693, 3498, 4365, 5120, 5920, 6736, 7561, 8382, 9105, 9820, 10555, 11116, 11679, 12115, 12412, 12687, 12895, 12954, 12975, 12922, 12805, 12611, 12355, 12038, 11658, 11112, 10572, 9922, 9155, 8370, 7523, 6626, 5601, 4597, 3517, 2372, 1156, -9, -1226, -2567, -3966, -5350, -6819, -8320, -9771, -11271, -12790, -14238, -15671, -17094, -18447, -19868, -21236, -22534, -23732, -24939, -26068, -27067, -27980, -28786, -29614, -30312, -30976, -31509, -31982, -32321, -32574, -32710, -32696, -32568, -32363, -32082, -31609, -31019, -30317, -29529, -28645, -27649, -26443, -25173, -23850, -22304, -20804, -19244, -17506, -15798, -14004, -12293, -10585, -8887, -7180, -5513, -3856, -2242, -490};