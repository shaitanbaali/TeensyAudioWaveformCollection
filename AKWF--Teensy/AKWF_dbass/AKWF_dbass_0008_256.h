/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0008 256 samples */
 
const int16_t AKWF_dbass_0008_256_DATA [256] = 
{146, 527, 1360, 2441, 3419, 4056, 4707, 5179, 5984, 6729, 7253, 8285, 9008, 9570, 10615, 11515, 12440, 13531, 14597, 15540, 15608, 15689, 15906, 16430, 17208, 17953, 18549, 19306, 19902, 20542, 20898, 21439, 22034, 22501, 22737, 22774, 22999, 22908, 22681, 22685, 22708, 22627, 22537, 22642, 22750, 22965, 23590, 24094, 24665, 25460, 25993, 26297, 26724, 26863, 26868, 26721, 26697, 26645, 26509, 26414, 26221, 26152, 26172, 26344, 26751, 27431, 27971, 28656, 29031, 29174, 29343, 29813, 30005, 30198, 30212, 29960, 29465, 29025, 28440, 27920, 27446, 27050, 26668, 26256, 25935, 25708, 25650, 25791, 26096, 26306, 26690, 27121, 27328, 27406, 27491, 27392, 27129, 26593, 26013, 25253, 24258, 23488, 22795, 22035, 21222, 20602, 20190, 19701, 19491, 19168, 18826, 18224, 17336, 16329, 15245, 13736, 12373, 11071, 9988, 8814, 7807, 7201, 6484, 5660, 5013, 4581, 4095, 3580, 2950, 2456, 1828, 1405, 1037, 754, 209, -281, -946, -1554, -2236, -2800, -3429, -4046, -4650, -5262, -5876, -6417, -7226, -8036, -8865, -9842, -10789, -11647, -12552, -13204, -13802, -14259, -14676, -15005, -15260, -15639, -15639, -15686, -15824, -15981, -16376, -16803, -17209, -17611, -17891, -18335, -18936, -19512, -20214, -20960, -21658, -22366, -22875, -23526, -24068, -24579, -25091, -25502, -26130, -26730, -27309, -28097, -28837, -29523, -30217, -30895, -31543, -32069, -32410, -32669, -32770, -32656, -32564, -32215, -31855, -31447, -31027, -30536, -30039, -29567, -28995, -28513, -27978, -27410, -26947, -26356, -25624, -24969, -24206, -23575, -22939, -22158, -21553, -20725, -20232, -19895, -19239, -18797, -18283, -18108, -17983, -17750, -17683, -17569, -17352, -16859, -16383, -16041, -15559, -14822, -14156, -13715, -12969, -12038, -11285, -10970, -10450, -9687, -9156, -8974, -8249, -7295, -6678, -6074, -5131, -4339, -3804, -3244, -2358, -1520, -1102, -595};