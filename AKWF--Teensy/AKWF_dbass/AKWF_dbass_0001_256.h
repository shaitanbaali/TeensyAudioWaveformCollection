/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0001 256 samples */
 
const int16_t AKWF_dbass_0001_256_DATA [256] = 
{574, 1387, 2403, 3619, 4915, 6256, 7569, 8979, 10434, 11787, 13176, 14671, 16229, 17747, 19338, 20908, 22307, 23656, 25009, 26238, 27397, 28351, 29129, 29770, 30366, 30982, 31592, 32016, 32240, 32508, 32684, 32756, 32713, 32535, 32137, 31724, 31302, 30898, 30529, 30143, 29792, 29513, 29173, 28774, 28341, 27876, 27496, 27210, 27036, 26941, 26810, 26708, 26685, 26605, 26497, 26323, 26106, 25852, 25521, 25136, 24689, 24224, 23658, 23205, 22730, 22326, 21950, 21524, 21154, 20505, 19718, 18784, 17795, 16729, 15736, 14858, 14093, 13468, 12948, 12476, 12003, 11473, 11001, 10557, 10103, 9794, 9632, 9683, 9819, 10099, 10209, 10141, 9969, 9646, 9280, 8907, 8610, 8391, 8206, 8006, 7697, 7316, 6851, 6182, 5432, 4662, 3790, 2965, 1958, 895, -275, -1509, -2731, -3950, -5113, -6203, -7204, -8125, -9036, -9800, -10578, -11393, -12378, -13196, -13985, -14726, -15332, -15725, -16250, -16843, -17344, -17721, -18285, -18617, -18997, -19218, -19466, -19686, -19755, -19766, -20154, -20430, -20744, -21321, -22031, -22415, -22869, -23323, -23841, -24197, -24398, -24479, -24408, -24180, -24075, -24055, -24203, -23888, -23565, -23238, -22869, -22260, -21525, -21146, -20580, -20123, -19778, -19291, -18654, -17941, -17245, -17058, -16456, -15988, -15523, -14897, -14189, -13452, -12601, -11740, -10748, -9803, -9091, -8369, -7957, -7785, -7874, -7874, -7734, -7507, -7141, -6482, -5844, -5310, -4930, -4836, -4906, -5240, -5614, -5727, -5755, -5786, -5915, -6126, -6595, -7316, -8025, -8778, -9281, -9584, -9622, -9583, -9803, -10151, -10495, -10999, -11516, -11917, -12213, -12448, -12612, -12828, -12935, -13026, -13185, -13257, -13174, -13008, -12698, -12169, -11528, -10938, -10563, -10262, -9956, -9689, -9520, -9305, -8964, -8576, -8254, -7865, -7526, -7313, -7067, -6732, -6379, -6028, -5425, -4724, -3965, -3079, -2243, -1432, -795, -138};