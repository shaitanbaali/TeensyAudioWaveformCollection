/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0023 256 samples */
 
const int16_t AKWF_dbass_0023_256_DATA [256] = 
{1015, 2021, 2622, 3241, 3590, 4223, 4872, 5526, 6210, 6732, 7299, 8106, 8753, 9678, 10603, 11697, 12954, 14074, 15293, 16305, 16857, 17186, 16958, 16836, 16664, 16786, 17377, 18198, 19034, 19730, 19777, 19428, 18651, 17823, 17045, 16445, 16026, 15613, 14935, 14078, 13125, 12241, 11699, 11706, 11838, 11906, 11884, 11747, 11712, 11611, 11569, 11588, 11824, 11975, 12107, 12404, 12438, 12438, 12382, 12143, 12119, 12187, 12325, 12516, 12705, 12999, 13218, 13271, 13363, 13178, 12944, 12737, 12783, 13094, 13487, 13734, 13884, 13794, 13754, 13736, 14032, 14525, 15311, 16230, 17084, 18000, 18869, 19799, 20683, 21625, 22470, 23283, 23891, 24389, 24755, 24832, 24805, 24609, 24477, 24345, 24196, 24112, 24082, 24079, 23956, 23927, 23624, 23185, 22870, 22568, 22391, 22332, 22337, 22302, 22143, 22015, 21764, 21560, 21273, 20973, 20867, 20669, 20496, 20200, 19794, 19215, 18488, 17533, 16658, 15767, 14946, 14238, 13537, 12911, 12392, 11758, 11086, 10243, 9331, 8357, 7406, 6506, 5704, 4906, 4177, 3621, 3191, 2756, 2541, 2374, 2112, 1783, 1303, 842, 327, -167, -637, -1022, -1336, -1685, -1950, -2342, -2715, -3160, -3553, -3986, -4524, -4912, -5287, -5627, -6082, -6698, -7467, -8254, -9271, -10175, -10945, -11542, -12141, -12646, -13271, -13929, -14690, -15455, -16274, -17060, -17779, -18440, -19186, -19887, -20642, -21544, -22517, -23359, -24150, -24863, -25571, -26057, -26689, -27279, -27876, -28428, -29018, -29643, -30138, -30604, -31033, -31345, -31748, -32134, -32487, -32660, -32725, -32717, -32608, -32339, -31907, -31653, -31369, -31304, -31229, -31169, -31144, -30838, -30125, -29703, -29410, -28794, -28082, -27389, -26656, -25839, -24718, -24134, -23658, -22507, -21340, -20270, -19040, -17555, -16041, -15415, -14908, -13592, -12181, -11230, -10406, -9572, -8426, -7803, -7171, -5644, -4174, -3032, -2053, -677};