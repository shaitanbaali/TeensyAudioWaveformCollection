/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0029 256 samples */
 
const int16_t AKWF_dbass_0029_256_DATA [256] = 
{219, 983, 1743, 2488, 3318, 4124, 4852, 5608, 6415, 7174, 7942, 8679, 9440, 10170, 10894, 11631, 12364, 13121, 13838, 14611, 15390, 16152, 16922, 17704, 18569, 19410, 20267, 21122, 21992, 22800, 23627, 24379, 25085, 25856, 26551, 27195, 27841, 28376, 28946, 29463, 29950, 30440, 30807, 31163, 31481, 31788, 32092, 32296, 32478, 32611, 32692, 32718, 32765, 32727, 32633, 32613, 32524, 32474, 32393, 32301, 32248, 32137, 32040, 31968, 31956, 31882, 31797, 31714, 31625, 31514, 31418, 31332, 31197, 31001, 30828, 30622, 30426, 30257, 30014, 29807, 29654, 29439, 29266, 29028, 28801, 28641, 28416, 28216, 27962, 27733, 27541, 27314, 27062, 26861, 26625, 26402, 26099, 25826, 25605, 25372, 25127, 24810, 24477, 24127, 23792, 23383, 22984, 22588, 22175, 21760, 21293, 20817, 20306, 19770, 19180, 18599, 17966, 17289, 16573, 15814, 15068, 14309, 13461, 12650, 11843, 11020, 10188, 9381, 8536, 7666, 6812, 5966, 5111, 4234, 3342, 2473, 1569, 674, -241, -1163, -2028, -2919, -3850, -4730, -5669, -6560, -7451, -8372, -9240, -10099, -10929, -11713, -12431, -13122, -13789, -14424, -14985, -15506, -15991, -16481, -16886, -17273, -17608, -17965, -18278, -18549, -18783, -18956, -19162, -19333, -19495, -19582, -19699, -19810, -19880, -20014, -20102, -20228, -20388, -20495, -20653, -20756, -20915, -21055, -21129, -21203, -21335, -21417, -21401, -21467, -21455, -21454, -21370, -21274, -21273, -21230, -21139, -21106, -20967, -20885, -20785, -20714, -20609, -20543, -20493, -20422, -20330, -20261, -20186, -20063, -19974, -19854, -19743, -19682, -19548, -19455, -19334, -19242, -19116, -18990, -18834, -18636, -18495, -18305, -18099, -17845, -17539, -17221, -16889, -16505, -16066, -15605, -15168, -14677, -14175, -13731, -13160, -12583, -12034, -11476, -10811, -10219, -9552, -8857, -8195, -7497, -6784, -6084, -5362, -4632, -3889, -3194, -2496, -1773, -1036, -372};