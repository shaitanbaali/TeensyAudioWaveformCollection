/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0003 256 samples */
 
const int16_t AKWF_dbass_0003_256_DATA [256] = 
{655, 2153, 3382, 4891, 5932, 6600, 7386, 8154, 8584, 8952, 9429, 10134, 11051, 12082, 13181, 14085, 15161, 16125, 16952, 17593, 18432, 19561, 20439, 21346, 22767, 23749, 24695, 25849, 26512, 27506, 28406, 28860, 29023, 29085, 29002, 28442, 27902, 27484, 27043, 26962, 27123, 27649, 28696, 29649, 30222, 30881, 31458, 32169, 32541, 32563, 32087, 31803, 31014, 29920, 28886, 27743, 26726, 25901, 25417, 24737, 24548, 24225, 23929, 23778, 23379, 23056, 22480, 21778, 20458, 19368, 17908, 16499, 15385, 14388, 13571, 12833, 12023, 11223, 9902, 8453, 6643, 5128, 3445, 1914, 427, -1004, -1988, -2998, -3919, -4571, -5244, -5729, -5790, -5867, -6014, -6588, -7005, -7735, -8833, -10235, -11777, -13513, -15251, -17130, -18023, -18310, -19249, -20708, -22266, -23312, -24173, -24689, -25084, -25097, -26177, -27987, -28138, -27483, -26982, -27626, -29242, -30449, -30646, -30739, -30572, -30393, -30572, -31290, -30450, -29390, -27725, -26624, -26849, -26522, -25028, -23174, -20445, -17554, -15185, -12998, -12504, -12095, -10608, -9167, -8535, -8325, -7972, -7216, -6043, -4277, -1102, 1237, 2713, 3729, 5333, 7500, 8684, 8665, 8812, 8842, 7965, 7373, 8238, 9769, 9980, 9862, 10385, 11374, 12630, 12821, 13270, 13638, 13500, 13277, 13882, 15386, 16172, 16768, 17768, 18931, 20514, 21668, 22823, 24603, 26068, 26968, 27402, 27278, 26992, 26451, 25610, 24540, 23842, 23125, 22421, 22434, 23098, 23794, 24009, 24086, 23525, 22002, 19771, 16935, 14223, 11183, 8013, 5481, 3479, 2387, 1747, 865, 289, -387, -1456, -2816, -4013, -5332, -7420, -9795, -11767, -13290, -14159, -14725, -15180, -14902, -14737, -14775, -14844, -14536, -14330, -14771, -15673, -16144, -16013, -15586, -15082, -14185, -13198, -12437, -11360, -9752, -8018, -6532, -5469, -4860, -4492, -4060, -4135, -4371, -4540, -4584, -4317, -3603, -2304, -1071};