/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0065 256 samples */
 
const int16_t AKWF_dbass_0065_256_DATA [256] = 
{402, 1688, 2988, 4330, 5497, 6728, 7807, 8944, 10043, 11176, 12189, 13284, 14160, 15102, 16107, 16925, 17671, 18527, 19320, 19950, 20657, 21312, 21869, 22394, 22949, 23460, 23754, 24258, 24516, 24915, 25175, 25407, 25607, 25737, 25906, 25984, 26153, 26140, 26100, 26293, 26236, 26157, 26194, 26098, 26026, 25923, 25706, 25626, 25549, 25406, 25264, 25108, 25169, 24935, 24855, 24833, 24759, 24672, 24688, 24652, 24767, 24638, 24805, 24923, 25122, 25180, 25224, 25489, 25651, 25845, 26019, 26266, 26473, 26737, 27039, 27335, 27556, 27906, 28200, 28378, 28601, 28804, 29064, 29316, 29415, 29624, 29780, 29930, 30006, 30021, 30066, 30003, 29919, 29811, 29720, 29533, 29389, 29015, 28647, 28275, 27885, 27436, 26959, 26386, 25746, 25061, 24427, 23690, 22853, 22009, 21110, 20186, 19246, 18258, 17196, 16152, 15106, 13857, 12645, 11558, 10268, 8983, 7828, 6588, 5257, 4101, 2887, 1613, 497, -572, -1712, -2972, -4101, -5217, -6406, -7355, -8479, -9555, -10500, -11418, -12340, -13211, -14116, -14888, -15685, -16441, -17161, -17770, -18365, -18966, -19630, -19984, -20390, -20871, -21249, -21585, -21858, -22149, -22359, -22572, -22740, -22957, -23041, -23183, -23251, -23382, -23434, -23481, -23525, -23572, -23558, -23620, -23638, -23745, -23783, -23843, -23990, -24044, -24011, -24111, -24254, -24369, -24491, -24538, -24697, -24943, -25115, -25354, -25573, -25854, -26116, -26431, -26787, -27090, -27403, -27689, -28020, -28362, -28685, -28998, -29351, -29567, -29966, -30327, -30549, -30773, -31123, -31460, -31676, -31941, -32084, -32245, -32432, -32616, -32678, -32747, -32767, -32762, -32727, -32591, -32482, -32330, -32095, -31798, -31463, -31102, -30696, -30153, -29688, -29105, -28479, -27822, -27214, -26324, -25571, -24729, -23756, -22813, -21905, -20792, -19776, -18561, -17430, -16348, -15167, -13849, -12646, -11317, -9995, -8808, -7502, -6107, -4802, -3431, -2269, -830};