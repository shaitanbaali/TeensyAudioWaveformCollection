/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0005 256 samples */
 
const int16_t AKWF_dbass_0005_256_DATA [256] = 
{303, 1037, 1693, 2287, 2791, 3344, 3909, 4367, 4827, 5232, 5681, 6186, 6787, 7477, 8106, 8858, 9586, 10301, 10983, 11607, 12044, 12314, 12550, 12872, 13139, 13382, 13652, 13884, 14046, 14306, 14462, 14596, 14743, 14791, 15037, 15423, 15847, 16226, 16491, 16851, 17207, 17584, 17928, 18276, 18633, 18824, 19131, 19308, 19611, 20212, 20649, 20819, 21245, 21899, 22704, 23467, 24099, 24706, 25237, 25846, 26537, 27167, 27696, 28074, 28118, 28085, 28363, 28653, 28877, 29178, 29230, 29352, 29511, 29618, 29800, 29783, 29802, 29715, 29511, 29227, 29058, 29098, 28985, 29131, 29287, 29501, 29677, 29654, 29393, 28904, 28172, 27434, 26686, 26024, 25387, 24799, 24498, 24298, 24251, 24357, 24369, 24316, 24231, 24128, 23996, 23771, 23429, 22947, 22327, 21521, 20773, 20051, 19257, 18535, 17829, 17078, 16399, 15828, 15579, 15447, 15356, 15277, 15156, 14925, 14624, 14220, 13650, 12942, 12030, 10939, 9886, 8859, 7850, 6767, 5673, 4693, 3963, 3330, 2675, 2004, 1193, 233, -880, -1981, -3062, -4207, -5345, -6514, -7603, -8513, -9264, -9902, -10442, -11070, -11719, -12407, -13223, -14105, -15034, -15973, -16970, -17774, -18360, -18770, -19095, -19319, -19525, -19579, -19536, -19534, -19582, -19608, -19696, -19975, -20385, -20921, -21524, -22224, -22918, -23541, -24055, -24440, -24671, -24836, -24930, -25082, -25219, -25397, -25598, -25934, -26305, -26886, -27434, -27988, -28464, -28959, -29367, -29720, -30051, -30218, -30263, -30332, -30422, -30566, -30709, -31030, -31354, -31658, -31962, -32259, -32497, -32677, -32761, -32567, -32346, -31931, -31556, -31197, -30927, -30567, -30313, -29997, -29641, -29233, -28747, -28188, -27530, -26820, -26034, -25126, -24131, -22995, -21802, -20585, -19377, -18212, -17167, -16168, -15142, -14144, -13279, -12448, -11641, -10817, -9930, -9004, -8164, -7304, -6406, -5482, -4589, -3731, -2907, -2072, -1323, -629};