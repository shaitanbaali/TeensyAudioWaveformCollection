/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0050 256 samples */
 
const int16_t AKWF_dbass_0050_256_DATA [256] = 
{231, 1041, 1860, 2844, 4080, 5517, 6975, 8155, 9056, 9669, 10664, 12451, 14820, 16983, 18470, 19709, 21006, 22137, 23197, 24360, 25257, 25623, 25526, 25392, 25141, 24721, 24282, 24125, 24133, 24298, 24608, 24771, 24913, 25455, 26372, 27434, 28412, 29058, 29556, 30024, 30451, 30811, 31066, 31316, 31530, 31651, 31649, 31307, 30840, 30578, 30289, 29974, 29764, 29609, 29742, 29955, 30226, 30775, 31249, 31593, 31972, 32253, 32343, 32328, 32281, 32191, 32190, 32427, 32681, 32768, 32756, 32710, 32578, 32353, 31978, 31383, 30623, 29575, 28250, 26982, 25852, 24794, 23773, 22623, 21403, 20338, 19424, 18593, 17867, 17375, 17069, 16967, 16894, 16805, 16675, 16613, 16698, 16894, 17186, 17323, 17080, 16469, 15756, 15099, 14366, 13341, 12020, 10435, 8862, 7481, 6227, 4882, 3480, 2266, 1283, 528, -65, -526, -825, -1087, -1434, -1757, -2172, -2698, -3209, -3847, -4603, -5463, -6514, -7679, -8969, -10401, -11845, -13371, -14945, -16431, -17799, -19081, -20224, -21217, -22062, -22784, -23390, -24043, -24828, -25577, -26220, -26844, -27478, -28064, -28695, -29161, -29489, -29743, -29916, -30016, -30052, -29904, -29625, -29353, -29104, -28917, -28785, -28728, -28770, -28801, -28901, -29071, -29410, -29757, -29985, -30005, -29887, -29692, -29523, -29413, -29336, -29195, -28999, -28893, -28868, -28972, -29087, -29205, -29276, -29311, -29370, -29414, -29543, -29641, -29682, -29829, -29938, -29916, -29633, -29028, -28566, -28224, -27626, -26650, -25440, -24527, -23990, -23524, -22840, -21966, -21272, -20794, -20025, -19370, -18505, -17202, -16977, -16608, -15652, -15102, -14331, -13596, -12718, -11956, -11407, -10680, -10184, -10042, -10025, -10113, -10139, -10126, -10298, -10826, -11134, -10772, -10258, -10181, -9957, -9246, -8362, -7233, -6033, -5278, -4835, -4397, -4049, -3857, -3590, -3018, -2670, -2692, -2873, -3280, -3784, -3747, -2936, -1991, -1244, -513};