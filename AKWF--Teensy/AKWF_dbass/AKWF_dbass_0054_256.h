/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0054 256 samples */
 
const int16_t AKWF_dbass_0054_256_DATA [256] = 
{960, 2831, 4730, 6453, 7903, 8913, 9784, 10771, 11663, 12601, 13899, 15485, 17530, 19692, 21623, 23400, 25288, 26921, 28388, 29696, 30490, 31043, 31529, 31760, 31881, 31827, 31803, 31916, 31972, 32223, 32510, 32743, 32697, 32518, 32197, 31869, 31694, 31517, 31161, 30714, 30110, 29484, 28800, 28096, 27278, 26452, 25630, 24837, 24069, 23154, 22108, 21130, 20184, 19764, 19879, 20154, 20500, 20876, 20974, 20970, 20884, 20626, 20336, 20171, 20038, 19802, 19673, 19471, 19056, 18443, 17767, 16833, 15875, 14722, 13429, 12144, 10761, 9351, 7793, 5983, 3967, 1658, -817, -3257, -5376, -7250, -8707, -9746, -10342, -10499, -10557, -10442, -10194, -9939, -9643, -9172, -8581, -8011, -7248, -6454, -5689, -4669, -3589, -2719, -1825, -1557, -1383, -1269, -1283, -1266, -779, -178, 145, 558, 934, 859, 1878, 1450, 1401, 807, -504, -1147, -838, -894, -843, -2369, -3705, -4626, -6668, -8893, -10018, -10818, -10748, -11431, -11636, -11366, -11129, -10776, -10175, -9466, -9107, -8510, -7228, -7671, -7751, -7719, -8223, -8375, -8062, -8001, -7617, -6892, -6155, -6225, -5656, -5199, -4928, -4293, -3072, -1801, -871, 363, 929, 781, 1048, 1211, 1171, 1030, 755, -712, -2576, -3990, -5807, -7401, -8197, -8112, -7586, -6775, -5645, -5295, -5155, -5473, -6143, -7045, -7754, -8140, -8602, -8892, -9073, -9279, -9316, -10115, -11942, -13800, -15678, -17693, -19071, -19686, -20166, -20206, -20279, -20506, -20830, -21188, -21424, -21666, -21902, -22033, -22204, -22257, -22407, -22528, -22845, -23390, -24121, -25100, -26004, -26824, -27602, -28029, -27826, -27111, -26063, -24543, -22964, -21568, -20667, -20277, -20064, -19953, -19932, -19833, -19678, -19434, -18774, -17855, -16907, -15886, -15288, -14976, -14885, -14784, -14526, -13978, -13114, -12092, -10962, -9729, -8421, -7113, -5822, -4702, -3874, -3060, -1958, -693};