/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0011 256 samples */
 
const int16_t AKWF_dbass_0011_256_DATA [256] = 
{820, 2313, 3833, 5836, 8113, 10241, 12313, 14088, 15797, 17522, 19247, 20994, 22771, 24556, 26325, 28005, 29317, 30453, 31376, 31938, 32212, 32330, 32517, 32628, 32695, 32633, 32293, 31714, 30889, 29992, 29039, 28046, 26968, 25539, 24016, 22399, 20955, 19610, 18265, 16899, 15422, 13878, 12231, 10491, 8769, 7198, 5906, 4801, 3823, 2881, 1852, 689, -536, -1729, -2890, -3788, -4523, -5156, -5664, -6343, -7040, -7756, -8366, -8817, -9188, -9656, -10284, -11071, -11775, -12215, -12378, -12367, -12231, -12039, -12013, -12061, -12178, -12298, -12675, -13204, -13897, -14515, -15079, -15504, -15854, -16205, -16538, -16945, -17489, -18097, -18773, -19387, -19907, -20637, -21356, -21887, -22240, -22151, -21836, -21495, -21227, -21212, -21285, -21255, -21026, -20654, -19984, -19283, -18490, -17494, -16354, -14868, -13218, -11400, -9534, -7813, -6116, -4555, -2996, -1451, -86, 1053, 2053, 3000, 4096, 5440, 7007, 8665, 10311, 11814, 13091, 14292, 15348, 16418, 17459, 18351, 19196, 19840, 20417, 21116, 21822, 22478, 23021, 23344, 23466, 23274, 23054, 22801, 22414, 22056, 21593, 21096, 20474, 19669, 18849, 17950, 16948, 16012, 15102, 14195, 13251, 12245, 11269, 10065, 8973, 7868, 6849, 6075, 5305, 4599, 4035, 3555, 2768, 2043, 1465, 619, 266, -298, -1030, -1742, -2489, -3434, -4262, -4662, -4520, -4317, -4100, -3908, -3797, -3222, -2628, -1984, -773, 115, 584, 870, 1219, 1523, 2005, 2245, 2418, 2271, 2318, 2462, 2925, 3564, 3856, 4011, 3265, 2091, 870, 45, 18, 743, 884, 628, -244, -1610, -2485, -2821, -3248, -4066, -5692, -7437, -8902, -10067, -10938, -11704, -12395, -13214, -14136, -15035, -15748, -16309, -16746, -17179, -17772, -18186, -18205, -17900, -17306, -16634, -16103, -15613, -15197, -14667, -13810, -12848, -11513, -10100, -8799, -7249, -5573, -3959, -2311, -570};