/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0060 256 samples */
 
const int16_t AKWF_dbass_0060_256_DATA [256] = 
{246, 842, 1483, 2134, 2834, 3667, 4501, 5355, 6307, 7173, 7988, 8695, 9404, 10175, 10876, 11612, 12288, 12959, 13631, 14418, 15114, 15965, 16885, 17708, 18575, 19418, 20263, 21103, 21890, 22610, 23197, 23929, 24656, 25346, 26020, 26669, 27315, 27940, 28509, 28910, 29200, 29476, 29744, 30008, 30372, 30674, 30997, 31253, 31436, 31629, 31759, 31841, 31939, 32144, 32396, 32610, 32731, 32768, 32654, 32481, 32229, 31931, 31629, 31390, 31107, 30781, 30472, 29993, 29491, 29036, 28640, 28287, 27919, 27602, 27247, 26892, 26510, 25959, 25406, 24831, 24111, 23342, 22554, 21726, 20411, 19790, 19115, 18678, 18073, 17465, 16807, 16296, 15560, 14857, 14104, 13157, 11740, 10520, 9254, 8367, 7732, 6861, 5840, 4918, 3920, 2917, 2095, 1184, 136, -616, -1414, -2253, -3088, -3828, -4658, -5209, -5687, -6041, -6463, -7098, -7838, -8610, -9189, -9762, -10366, -11123, -11791, -12549, -13187, -13813, -14421, -14941, -14892, -14722, -14708, -14598, -14853, -15485, -16102, -16546, -17103, -17783, -18388, -18972, -19131, -18943, -18627, -18495, -18190, -18037, -18034, -17883, -17718, -17444, -17403, -17418, -17462, -17122, -16698, -16241, -15772, -15136, -14349, -13514, -12679, -12094, -11892, -12112, -12738, -13464, -13995, -14400, -14828, -15027, -15089, -15057, -14980, -14940, -14990, -15174, -15457, -16069, -16842, -17725, -18606, -19433, -20387, -21220, -21881, -22540, -23128, -23475, -23733, -24017, -24424, -24911, -25462, -26153, -26834, -27376, -27730, -27984, -28051, -27814, -27428, -27004, -26479, -26015, -25634, -25137, -24602, -23867, -22962, -22062, -21214, -20466, -19640, -18729, -17854, -16936, -15972, -15022, -14141, -13270, -12354, -11629, -11226, -11035, -11039, -11060, -10972, -10756, -10506, -10320, -10167, -10068, -9828, -9551, -9233, -8948, -8564, -8162, -7716, -7286, -6950, -6756, -6637, -6517, -6205, -5642, -4900, -3987, -3018, -2016, -1162, -376};