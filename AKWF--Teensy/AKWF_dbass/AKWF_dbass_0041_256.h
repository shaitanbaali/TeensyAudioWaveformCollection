/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0041 256 samples */
 
const int16_t AKWF_dbass_0041_256_DATA [256] = 
{133, 810, 1615, 2464, 3345, 4299, 5535, 6804, 8251, 9592, 10996, 12553, 13831, 14999, 16061, 16966, 17744, 18319, 18982, 19545, 20112, 20806, 21459, 22344, 23444, 24587, 25522, 26386, 27126, 27801, 28444, 29398, 30322, 31063, 31471, 31763, 31714, 31800, 31773, 31608, 31543, 31615, 31608, 31476, 31531, 31659, 32051, 32319, 32491, 32690, 32705, 32506, 32086, 31283, 30185, 29165, 27996, 26923, 25915, 24927, 24193, 23248, 22505, 21803, 21171, 20726, 20231, 19839, 19510, 19136, 18523, 18053, 17397, 17122, 16453, 15760, 15250, 14702, 14224, 13805, 13262, 12814, 12164, 11447, 10489, 9544, 8601, 7613, 6793, 6291, 5908, 5639, 5638, 5641, 5582, 5432, 5228, 5049, 4603, 4192, 3882, 3478, 3077, 2869, 2711, 2675, 2883, 2999, 3172, 2751, 2496, 2236, 1716, 1624, 1541, 1409, 1310, 1512, 1447, 980, 1062, 372, -487, -994, -1512, -2447, -3148, -3340, -3318, -3326, -3908, -4689, -4763, -4856, -5252, -5115, -4439, -4387, -4828, -5105, -5238, -5400, -5199, -4583, -4467, -3920, -3635, -3953, -4189, -4382, -4850, -5577, -5980, -6275, -6505, -6498, -6702, -6827, -7288, -7292, -7958, -8586, -8936, -9014, -8678, -8392, -7615, -7104, -6201, -5277, -5024, -4783, -4306, -4503, -5194, -5903, -6865, -7834, -8256, -8715, -8895, -8424, -7518, -6868, -6160, -5579, -5489, -5824, -6292, -6932, -7516, -8124, -8759, -9521, -9901, -10428, -11766, -13028, -14320, -15800, -17064, -17863, -18236, -18642, -18642, -18660, -18776, -19037, -19058, -19032, -19029, -18655, -18422, -18349, -18383, -18837, -19368, -20132, -20900, -21783, -22577, -23071, -23338, -23313, -22718, -21798, -20384, -19064, -17866, -17114, -16533, -16127, -15916, -15925, -15826, -15646, -15227, -14680, -13935, -13006, -12025, -11117, -10389, -9837, -9216, -8776, -8334, -7485, -6521, -5628, -4605, -3635, -2601, -1685, -1157, -465};