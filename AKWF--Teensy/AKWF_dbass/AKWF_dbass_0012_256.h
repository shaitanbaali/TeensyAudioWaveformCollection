/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0012 256 samples */
 
const int16_t AKWF_dbass_0012_256_DATA [256] = 
{237, 1194, 2279, 3560, 4961, 6468, 8053, 9546, 10961, 12372, 13796, 15229, 16812, 18379, 20004, 21620, 23239, 24790, 26299, 27654, 28847, 29727, 30377, 30914, 31329, 31751, 32199, 32521, 32737, 32748, 32679, 32508, 32360, 32064, 31689, 31244, 30757, 30274, 29715, 29316, 29034, 28818, 28542, 28138, 27698, 27290, 26904, 26601, 26400, 26371, 26331, 26352, 26371, 26368, 26293, 26174, 25933, 25528, 25081, 24531, 23872, 23262, 22638, 22057, 21534, 21163, 20827, 20533, 20181, 19711, 19047, 18175, 17155, 16048, 15009, 14129, 13394, 12831, 12454, 12211, 11969, 11663, 11349, 10932, 10541, 10305, 10284, 10546, 10974, 11522, 11923, 12094, 11960, 11585, 11186, 10684, 10252, 9991, 9737, 9401, 9079, 8652, 8049, 7237, 6303, 5294, 4322, 3249, 2168, 952, -280, -1673, -3081, -4483, -5797, -6998, -7999, -8864, -9671, -10329, -10992, -11615, -12489, -13324, -14222, -15073, -15708, -16053, -16341, -16583, -16803, -17143, -17552, -18153, -18589, -18723, -18846, -18809, -19059, -19047, -19068, -19461, -19813, -20405, -20728, -21325, -21995, -22485, -23098, -23535, -23582, -23669, -23500, -23286, -23408, -23333, -23077, -22920, -22579, -22231, -21963, -21236, -20792, -20171, -19449, -18888, -18335, -17903, -17622, -16944, -16239, -15729, -15438, -15134, -14625, -14031, -13386, -12517, -11623, -10532, -9454, -8325, -7212, -6265, -5748, -5735, -5741, -6064, -6480, -6798, -6493, -5706, -5051, -4341, -3865, -3990, -4172, -4725, -5408, -5887, -6194, -6288, -5997, -6028, -6598, -7278, -8284, -9295, -10283, -11069, -11398, -11557, -11742, -11747, -11953, -12313, -12753, -13501, -14199, -14726, -15042, -15001, -14694, -14554, -14476, -14368, -14331, -14125, -13670, -13214, -12600, -12008, -11328, -10776, -10479, -10237, -10109, -10029, -9902, -9621, -9169, -8540, -7844, -7288, -6922, -6796, -6730, -6567, -6152, -5492, -4772, -3905, -2957, -2015, -1194, -421};