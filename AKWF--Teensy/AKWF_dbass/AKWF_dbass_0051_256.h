/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0051 256 samples */
 
const int16_t AKWF_dbass_0051_256_DATA [256] = 
{91, 559, 1222, 1916, 2612, 3277, 3916, 4646, 5585, 6651, 7759, 9058, 10553, 11963, 13169, 14197, 15123, 16181, 17376, 18519, 19414, 20003, 20373, 20490, 20495, 20652, 20921, 21166, 21450, 21655, 21743, 21976, 22377, 22910, 23691, 24630, 25605, 26444, 27115, 27813, 28466, 28948, 29508, 30138, 30705, 31157, 31469, 31640, 31809, 32016, 32198, 32437, 32707, 32765, 32584, 32319, 31972, 31608, 31317, 31083, 30851, 30545, 30146, 29725, 29253, 28838, 28567, 28431, 28367, 28327, 28274, 28160, 27994, 27834, 27730, 27668, 27684, 27694, 27562, 27279, 26846, 26243, 25587, 25003, 24354, 23645, 22774, 21659, 20388, 19090, 17911, 16922, 15999, 15090, 14191, 13287, 12494, 11874, 11361, 10975, 10680, 10302, 9896, 9486, 9053, 8606, 8117, 7614, 7111, 6562, 5891, 5044, 4112, 3185, 2298, 1420, 526, -336, -1203, -2117, -3005, -3808, -4456, -4966, -5464, -5987, -6485, -7003, -7495, -7931, -8417, -8954, -9605, -10346, -11102, -11886, -12694, -13485, -14202, -14834, -15430, -15951, -16449, -16864, -17190, -17396, -17550, -17692, -17774, -17831, -17879, -17866, -17811, -17726, -17639, -17571, -17550, -17513, -17482, -17544, -17730, -18094, -18481, -19042, -19687, -20398, -21118, -21776, -22445, -23039, -23529, -24227, -25023, -25570, -26046, -26746, -27267, -27518, -27712, -27763, -27825, -27918, -28053, -27842, -27500, -26941, -26557, -26384, -26229, -26381, -26255, -25761, -25478, -25340, -25324, -25556, -25892, -26025, -25909, -25881, -26009, -25839, -25652, -25626, -25692, -25557, -25156, -24719, -24342, -23911, -23469, -23232, -22933, -22394, -21765, -21113, -20365, -19468, -18645, -18074, -17519, -17066, -16728, -16165, -15477, -14906, -14359, -13837, -13371, -12944, -12721, -12367, -11876, -11317, -10867, -10534, -10016, -9486, -9223, -8895, -8461, -7830, -7139, -6399, -5650, -5130, -4713, -4133, -3452, -2680, -1935, -1313, -751, -335, -202, -134};