/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0007 256 samples */
 
const int16_t AKWF_dbass_0007_256_DATA [256] = 
{669, 2035, 3414, 4653, 5952, 7228, 8388, 9543, 10532, 11575, 12453, 13317, 14186, 14923, 15239, 15798, 16476, 17035, 17786, 18589, 19542, 20294, 21236, 22050, 22689, 23418, 24118, 24617, 25234, 25472, 25624, 25698, 25625, 25383, 25504, 25828, 26191, 26511, 26918, 27259, 27545, 27546, 27788, 27787, 27737, 27717, 27574, 27332, 27277, 27374, 27217, 27122, 27019, 26898, 26868, 27037, 27038, 27119, 27408, 27599, 27526, 27435, 27440, 27103, 26893, 26935, 26856, 26770, 27132, 27323, 27060, 27077, 27018, 27002, 27072, 27141, 27136, 27110, 27362, 27422, 27467, 28110, 28615, 29104, 29784, 30467, 30928, 31363, 31958, 32313, 32519, 32622, 32617, 32623, 32448, 32104, 31661, 31273, 30872, 30528, 30093, 29941, 29660, 29337, 29261, 29163, 29285, 29406, 29320, 29137, 28851, 28512, 27924, 27386, 26433, 25280, 23916, 22323, 20771, 19252, 17856, 16528, 15159, 14111, 13102, 12109, 11165, 10145, 9122, 8083, 6937, 5621, 4236, 2791, 1400, -39, -1308, -2438, -3447, -4488, -5461, -6314, -7272, -8156, -9169, -10085, -11048, -11930, -12758, -13550, -14234, -14782, -15373, -15956, -16534, -17142, -17728, -18237, -18839, -19494, -20131, -20887, -21722, -22623, -23456, -24390, -25068, -25718, -26325, -26798, -27196, -27417, -27659, -27754, -27725, -27534, -27231, -27037, -26867, -26794, -26924, -27127, -27378, -27720, -28087, -28447, -28817, -29191, -29409, -29675, -29682, -29605, -29567, -29530, -29243, -29161, -29070, -28960, -29062, -29208, -29353, -29592, -29851, -30249, -30422, -30573, -30789, -30905, -30930, -30965, -31116, -31248, -31309, -31425, -31630, -31753, -31965, -32152, -32311, -32592, -32754, -32686, -32514, -32190, -31783, -31308, -30776, -30156, -29423, -28598, -27745, -26786, -25830, -24973, -24015, -22943, -21964, -21046, -19909, -18907, -17797, -16739, -15628, -14460, -13411, -12263, -11222, -10165, -9040, -7880, -6655, -5535, -4346, -3155, -1851, -521};