/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0052 256 samples */
 
const int16_t AKWF_dbass_0052_256_DATA [256] = 
{976, 2933, 5022, 7219, 9323, 11274, 13026, 14644, 16199, 17629, 18946, 20149, 21208, 22168, 23159, 24009, 24846, 25551, 26231, 27010, 27700, 28333, 28855, 29266, 29649, 29855, 30104, 30357, 30556, 30687, 30852, 31079, 31328, 31635, 31973, 32186, 32352, 32295, 32181, 32177, 32285, 32466, 32670, 32762, 32667, 32287, 31594, 30618, 29449, 28217, 26801, 25320, 23649, 21834, 19943, 17967, 15988, 13989, 12002, 10076, 8184, 6522, 4879, 3407, 2016, 778, -396, -1566, -2645, -3803, -4700, -5336, -5710, -5835, -5739, -5416, -5099, -4761, -4444, -4174, -4015, -3760, -3424, -2943, -2321, -1700, -1254, -820, -660, -539, -456, -350, -154, 121, 524, 944, 1291, 1556, 1736, 1891, 1981, 2055, 2089, 2125, 2149, 2139, 2002, 2015, 1894, 1597, 1243, 1095, 598, -85, -590, -73, 53, 579, 666, 641, 1029, 689, 807, 420, -163, -404, -582, -970, -1307, -2345, -2864, -3356, -3756, -4123, -4888, -5576, -5948, -6448, -7057, -7037, -6926, -6701, -7142, -7741, -8450, -9252, -10172, -11033, -11847, -12478, -13194, -14172, -15277, -16371, -17071, -17200, -17193, -17067, -16669, -16151, -15297, -13952, -12883, -12152, -11537, -11216, -10958, -10690, -10570, -10570, -10340, -10015, -9571, -9044, -8785, -8892, -9438, -9939, -10353, -10809, -11041, -11116, -11194, -11238, -11406, -11927, -12621, -13468, -14142, -14482, -14595, -14591, -14673, -14938, -14958, -14713, -14451, -14268, -14193, -14078, -13804, -13366, -13067, -12755, -12570, -12266, -11950, -11698, -11424, -11215, -10984, -10623, -9900, -9111, -8517, -8243, -8258, -8308, -8377, -8380, -8540, -8757, -9160, -9663, -10078, -10415, -10744, -11169, -11725, -12378, -12956, -13499, -13943, -14376, -14599, -14714, -14779, -14880, -15016, -15042, -14931, -14759, -14543, -14226, -13872, -13367, -12703, -12040, -11237, -10323, -9258, -7954, -6277, -4487, -2720, -854};