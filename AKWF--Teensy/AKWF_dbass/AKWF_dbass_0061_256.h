/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0061 256 samples */
 
const int16_t AKWF_dbass_0061_256_DATA [256] = 
{432, 1352, 2230, 3131, 3995, 4849, 5493, 5944, 6396, 6759, 7069, 7442, 7862, 8219, 8375, 8665, 8989, 9283, 9659, 10127, 10543, 10882, 11230, 11482, 11685, 11864, 12126, 12394, 12617, 13050, 13571, 14125, 14714, 15274, 15765, 16195, 16526, 16797, 16917, 16936, 16914, 16806, 16723, 16830, 16782, 16906, 17064, 17204, 17378, 17531, 18010, 18617, 18916, 19040, 19103, 19257, 19908, 20449, 20913, 21281, 21491, 21487, 21734, 21800, 22214, 22545, 22203, 21770, 21602, 21852, 22183, 22406, 22411, 22586, 22408, 22205, 22356, 22870, 23434, 23735, 23769, 24034, 24482, 25126, 25207, 24933, 24841, 24371, 24002, 23843, 23530, 23250, 22894, 21957, 21308, 20986, 20783, 20421, 19961, 19662, 19652, 19822, 19678, 19455, 19265, 19241, 18904, 18413, 17989, 17619, 17239, 16786, 16495, 16519, 16330, 15886, 15693, 15568, 15467, 15544, 15529, 15332, 14858, 13976, 12776, 11555, 10554, 9487, 8298, 7103, 6098, 5308, 4736, 4317, 4002, 3640, 3087, 2295, 1423, 457, -625, -1704, -2931, -4158, -5425, -6616, -7597, -8334, -8891, -9525, -10353, -11286, -12352, -13404, -14477, -15763, -16962, -18325, -19561, -20445, -21001, -21181, -21272, -21456, -21667, -22017, -22293, -22658, -23029, -23587, -24248, -24832, -25486, -26112, -26744, -27270, -27788, -28349, -28701, -29053, -29274, -29397, -29561, -29811, -30151, -30682, -31383, -31970, -32413, -32703, -32739, -32512, -32087, -31549, -30906, -30194, -29491, -28869, -28436, -28284, -28333, -28456, -28563, -28640, -28720, -28664, -28544, -28432, -28214, -27815, -27193, -26321, -25438, -24436, -23553, -22732, -22223, -21814, -21493, -21290, -20964, -20578, -20041, -19432, -18634, -17762, -16828, -15835, -15010, -14296, -13732, -13201, -12825, -12377, -11853, -11421, -10837, -10149, -9279, -8361, -7475, -6625, -5828, -5166, -4650, -4076, -3445, -2955, -2508, -2211, -1966, -1875, -1774, -1459, -1072, -398};