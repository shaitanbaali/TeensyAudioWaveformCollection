/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0015 256 samples */
 
const int16_t AKWF_dbass_0015_256_DATA [256] = 
{641, 1518, 1207, 1085, 1612, 2459, 2898, 3320, 4677, 5077, 5561, 6968, 7802, 8451, 8905, 8302, 7604, 8214, 9723, 10574, 11230, 12085, 12606, 13447, 14362, 14727, 14694, 14661, 14747, 15201, 15803, 16555, 17381, 18001, 18300, 18947, 19977, 20396, 19955, 19610, 19362, 18746, 18560, 18838, 18651, 17718, 16727, 16127, 16026, 16363, 16443, 15763, 15095, 15060, 15596, 16331, 16889, 17081, 17116, 17142, 17243, 17652, 18202, 18691, 19367, 20126, 21244, 22557, 23906, 25011, 25654, 26165, 27035, 28110, 28889, 29498, 30077, 30496, 30906, 31541, 32271, 32760, 32535, 31727, 30987, 30357, 29682, 28914, 28069, 27458, 27107, 26835, 26656, 26579, 26556, 26407, 26290, 26478, 26973, 27387, 27591, 27424, 26942, 26141, 25024, 23483, 21400, 18956, 16277, 13408, 10434, 7671, 5149, 2730, 636, -1052, -2309, -3182, -4030, -4608, -5046, -5681, -5992, -6323, -6872, -7814, -9112, -10454, -12106, -13727, -15187, -16666, -18070, -19261, -20357, -21177, -21564, -21747, -21881, -21979, -21963, -21892, -21845, -21647, -21438, -21382, -21285, -21216, -21077, -20965, -20914, -21088, -21583, -22153, -22686, -22947, -22924, -22714, -22272, -21548, -20693, -19741, -18599, -17481, -16643, -15779, -14845, -14025, -13441, -13008, -12740, -12509, -12402, -12418, -12461, -12520, -12600, -12675, -12498, -12217, -11683, -10941, -10217, -9515, -8945, -8575, -8415, -8352, -8495, -8871, -9324, -9845, -10279, -10690, -11293, -11899, -12459, -12876, -13202, -13552, -13924, -14197, -14314, -14316, -14207, -13999, -13641, -13312, -13224, -13362, -13664, -14120, -14716, -15475, -16168, -16792, -17333, -17453, -17601, -17919, -18273, -18434, -18363, -18209, -18200, -18047, -18354, -18310, -18123, -18820, -18935, -18624, -18505, -18957, -19833, -19631, -19981, -20556, -20418, -20267, -20440, -19564, -18228, -17228, -15551, -14252, -13174, -11338, -10060, -8767, -5929, -4538, -3201, -2311, -1559, -445};