/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0039 256 samples */
 
const int16_t AKWF_dbass_0039_256_DATA [256] = 
{230, 968, 1875, 2647, 3335, 4126, 4930, 5693, 6475, 7130, 7761, 8642, 9448, 10141, 10847, 11551, 12255, 12957, 13619, 14404, 15124, 15765, 16311, 16929, 17678, 18294, 18971, 19589, 20119, 20714, 21360, 21920, 22467, 23053, 23480, 23986, 24497, 24920, 25451, 25822, 26198, 26639, 27028, 27296, 27656, 28228, 28514, 28651, 29046, 29440, 29589, 29821, 30207, 30311, 30490, 30782, 30979, 31124, 31303, 31449, 31591, 31740, 31879, 31923, 32030, 32301, 32320, 32400, 32438, 32489, 32571, 32640, 32764, 32639, 32623, 32641, 32574, 32508, 32419, 32278, 32227, 32205, 32136, 32092, 32102, 31986, 31744, 31792, 31582, 31358, 31276, 31102, 30988, 30816, 30646, 30329, 30027, 29816, 29567, 29299, 28939, 28753, 28550, 28211, 27832, 27435, 27115, 26899, 26586, 26182, 25802, 25438, 24983, 24480, 24170, 23752, 23200, 22758, 22330, 21794, 21386, 20954, 20384, 19741, 19179, 18650, 18002, 17445, 16930, 16295, 15597, 14981, 14452, 13910, 13270, 12636, 12046, 11363, 10610, 9979, 9402, 8743, 7980, 7292, 6697, 6012, 5304, 4789, 4189, 3453, 2812, 2213, 1525, 870, 186, -433, -1119, -1784, -2375, -3066, -3716, -4332, -4953, -5530, -6048, -6625, -7322, -7941, -8351, -8891, -9483, -9948, -10441, -10969, -11375, -11922, -12408, -12761, -13120, -13552, -14050, -14326, -14625, -15093, -15479, -15706, -15962, -16252, -16574, -16894, -17082, -17276, -17481, -17574, -17848, -17952, -18181, -18337, -18349, -18507, -18658, -18809, -18803, -18798, -18834, -18818, -18780, -18744, -18710, -18651, -18540, -18490, -18376, -18108, -18024, -17771, -17543, -17344, -17069, -16772, -16446, -16117, -15817, -15570, -15264, -14792, -14330, -14032, -13585, -13163, -12719, -12292, -11852, -11375, -11081, -10676, -10199, -9752, -9206, -8617, -8145, -7647, -7248, -6701, -6101, -5564, -5039, -4572, -4038, -3421, -2883, -2341, -1798, -1319, -744, -217};