/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0034 256 samples */
 
const int16_t AKWF_dbass_0034_256_DATA [256] = 
{109, 482, 895, 1370, 1899, 2445, 2988, 3518, 4051, 4600, 5168, 5744, 6313, 6885, 7473, 8058, 8632, 9216, 9833, 10467, 11109, 11771, 12473, 13227, 14006, 14775, 15513, 16237, 16966, 17717, 18484, 19242, 19973, 20686, 21394, 22106, 22800, 23452, 24082, 24707, 25334, 25950, 26557, 27162, 27752, 28301, 28822, 29316, 29774, 30212, 30637, 31027, 31362, 31638, 31875, 32092, 32285, 32448, 32593, 32706, 32763, 32761, 32716, 32656, 32598, 32530, 32440, 32316, 32147, 31942, 31725, 31495, 31253, 30996, 30736, 30482, 30225, 29963, 29690, 29410, 29122, 28819, 28492, 28137, 27773, 27418, 27073, 26714, 26340, 25948, 25539, 25136, 24757, 24392, 24008, 23592, 23145, 22670, 22155, 21614, 21067, 20535, 20015, 19482, 18899, 18265, 17613, 16992, 16418, 15856, 15282, 14696, 14117, 13526, 12907, 12243, 11532, 10780, 9999, 9181, 8363, 7563, 6764, 5960, 5157, 4368, 3610, 2904, 2234, 1561, 851, 119, -603, -1304, -1985, -2647, -3310, -4003, -4746, -5525, -6306, -7081, -7825, -8526, -9199, -9864, -10510, -11099, -11615, -12096, -12598, -13130, -13660, -14149, -14599, -15047, -15524, -16023, -16518, -16990, -17439, -17861, -18258, -18637, -18997, -19333, -19620, -19836, -19996, -20134, -20271, -20404, -20537, -20665, -20773, -20842, -20887, -20939, -21016, -21103, -21168, -21188, -21175, -21160, -21164, -21188, -21202, -21166, -21073, -20949, -20829, -20716, -20590, -20429, -20257, -20111, -19993, -19856, -19677, -19480, -19303, -19154, -19023, -18879, -18704, -18505, -18309, -18136, -17973, -17791, -17590, -17397, -17208, -17008, -16795, -16583, -16365, -16145, -15937, -15747, -15555, -15339, -15095, -14841, -14584, -14320, -14039, -13750, -13473, -13207, -12936, -12655, -12350, -12000, -11602, -11173, -10732, -10298, -9871, -9437, -8985, -8511, -8026, -7528, -6993, -6422, -5834, -5249, -4672, -4082, -3464, -2834, -2200, -1554, -891, -223};