/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0006 256 samples */
 
const int16_t AKWF_dbass_0006_256_DATA [256] = 
{221, 739, 1324, 1710, 2075, 2436, 2732, 2952, 3258, 3626, 4048, 4465, 5121, 5802, 6363, 7038, 7625, 8080, 8540, 8897, 9177, 9410, 9595, 9850, 10015, 10362, 10774, 11059, 11455, 12054, 12495, 13224, 13898, 14528, 15065, 15793, 16650, 17240, 17881, 18707, 19499, 20179, 20842, 21475, 21876, 22277, 22795, 23014, 23408, 24105, 24717, 25252, 25977, 26771, 27420, 28205, 28799, 29176, 29784, 30315, 30584, 30979, 31462, 31878, 32142, 32296, 32633, 32774, 32684, 32686, 32694, 32567, 32427, 32248, 31922, 31457, 31230, 31006, 30659, 30512, 30489, 30317, 30241, 30107, 29881, 29661, 28994, 28445, 27785, 26927, 26098, 25310, 24761, 24397, 24153, 23907, 23779, 23835, 23837, 23968, 23965, 24018, 23933, 23753, 23433, 22995, 22572, 21804, 20941, 20363, 19558, 18688, 17970, 17343, 16710, 16296, 16103, 15839, 15605, 15538, 15539, 15358, 15066, 14605, 13972, 13147, 12142, 11024, 9940, 8827, 7880, 6807, 5889, 5056, 4336, 3669, 2962, 2198, 1215, 286, -785, -1932, -3078, -4200, -5222, -6251, -7191, -8016, -8826, -9572, -10323, -11071, -11787, -12606, -13419, -14264, -15054, -15755, -16475, -17132, -17590, -17964, -18244, -18484, -18597, -18596, -18570, -18420, -18315, -18423, -18459, -18549, -18875, -19346, -19921, -20507, -20945, -21564, -21894, -22137, -22270, -22337, -22395, -22221, -22249, -22335, -22345, -22509, -22732, -23123, -23518, -23934, -24443, -24964, -25420, -25857, -26318, -26661, -26934, -27205, -27397, -27580, -27817, -28109, -28386, -28714, -28974, -29322, -29544, -29799, -30034, -30105, -30081, -29999, -29930, -29719, -29507, -29330, -29050, -28831, -28509, -28203, -27798, -27499, -27033, -26524, -26076, -25400, -24553, -23674, -22667, -21564, -20469, -19386, -18370, -17391, -16401, -15531, -14663, -13781, -13059, -12235, -11451, -10671, -9924, -9160, -8287, -7397, -6535, -5514, -4659, -3781, -2814, -1979, -1053, -289};