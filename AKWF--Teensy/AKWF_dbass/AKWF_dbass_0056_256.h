/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0056 256 samples */
 
const int16_t AKWF_dbass_0056_256_DATA [256] = 
{846, 2110, 3303, 4493, 5639, 6566, 7170, 7784, 8632, 9471, 10261, 11059, 11969, 12843, 13605, 14308, 14885, 15365, 15810, 16268, 16674, 17243, 17906, 18803, 19715, 20610, 21578, 22393, 22897, 23206, 23496, 24067, 24873, 26067, 27262, 28564, 29757, 30727, 31467, 31995, 32315, 32622, 32726, 32597, 32359, 31998, 31612, 31017, 30330, 29404, 28297, 27259, 26265, 25294, 24560, 23942, 23271, 22681, 22048, 21435, 20617, 19824, 19013, 18536, 18255, 17991, 17883, 17656, 17405, 16925, 16610, 16438, 16358, 16496, 16482, 16689, 16930, 17104, 17118, 17013, 16445, 15713, 14724, 13618, 12612, 11425, 10270, 9256, 8488, 7801, 7205, 6490, 5587, 4410, 3148, 1709, 109, -1784, -3638, -5626, -7003, -7949, -8986, -9972, -11328, -12854, -13656, -14013, -15039, -16333, -16870, -16831, -16702, -16467, -16072, -16080, -15350, -15975, -16133, -16393, -16456, -15793, -15570, -15660, -15629, -15051, -14822, -14600, -13931, -13680, -13949, -14130, -14698, -14665, -13615, -12682, -12209, -11826, -11329, -10897, -10551, -10451, -10392, -9908, -9332, -9132, -9129, -9216, -9854, -10643, -11171, -11232, -11281, -11401, -11664, -11695, -11051, -10018, -9088, -7977, -7070, -6503, -6347, -7076, -8240, -8583, -8128, -7594, -6871, -6574, -6385, -6053, -5745, -5804, -5989, -6673, -7169, -7475, -7643, -7533, -7192, -6264, -5359, -4788, -4757, -5450, -6724, -8215, -9407, -10067, -10250, -9792, -8962, -8003, -7316, -7043, -7199, -7430, -7801, -8192, -8405, -8497, -8472, -8109, -7713, -7442, -7464, -7805, -8339, -9046, -9766, -10661, -11421, -12006, -12301, -12289, -11630, -10657, -9950, -9569, -9677, -10197, -11010, -12223, -13617, -14898, -15985, -17068, -18040, -18810, -19109, -18854, -18233, -17806, -17624, -17718, -17843, -17728, -17466, -16909, -15973, -14919, -13897, -13038, -12227, -11467, -10730, -10119, -9501, -8895, -8034, -7055, -5734, -4196, -2409, -622};