/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0033 256 samples */
 
const int16_t AKWF_dbass_0033_256_DATA [256] = 
{546, 1477, 2373, 3254, 4138, 5036, 5941, 6825, 7675, 8532, 9412, 10306, 11204, 12110, 13023, 13924, 14780, 15605, 16434, 17260, 18081, 18906, 19710, 20482, 21202, 21886, 22566, 23250, 23925, 24570, 25177, 25748, 26309, 26852, 27361, 27839, 28311, 28760, 29186, 29596, 29972, 30296, 30555, 30787, 31008, 31232, 31452, 31666, 31847, 32018, 32190, 32333, 32454, 32540, 32604, 32656, 32661, 32636, 32621, 32643, 32685, 32739, 32769, 32759, 32741, 32685, 32554, 32421, 32348, 32262, 32156, 32100, 32069, 32018, 31933, 31815, 31660, 31485, 31359, 31291, 31223, 31108, 30947, 30776, 30611, 30432, 30240, 30071, 29907, 29736, 29581, 29443, 29289, 29086, 28847, 28588, 28308, 28006, 27685, 27337, 26959, 26585, 26229, 25847, 25429, 25007, 24579, 24110, 23614, 23142, 22650, 22103, 21522, 20896, 20210, 19508, 18797, 18078, 17328, 16568, 15834, 15083, 14291, 13456, 12566, 11634, 10667, 9689, 8720, 7765, 6800, 5812, 4832, 3870, 2923, 1992, 1046, 67, -908, -1875, -2837, -3761, -4656, -5555, -6442, -7330, -8260, -9187, -10080, -10945, -11787, -12589, -13352, -14110, -14875, -15593, -16253, -16866, -17437, -18000, -18533, -19034, -19501, -19935, -20383, -20831, -21257, -21651, -22007, -22320, -22610, -22883, -23129, -23335, -23499, -23646, -23802, -23974, -24140, -24304, -24493, -24653, -24760, -24846, -24923, -24973, -25031, -25122, -25228, -25295, -25354, -25422, -25473, -25523, -25579, -25627, -25664, -25725, -25807, -25844, -25854, -25890, -25946, -25963, -25915, -25845, -25783, -25754, -25740, -25718, -25675, -25614, -25535, -25426, -25263, -25062, -24859, -24654, -24452, -24237, -24024, -23804, -23551, -23258, -22913, -22499, -22048, -21602, -21149, -20684, -20188, -19651, -19069, -18466, -17850, -17209, -16557, -15843, -15077, -14322, -13574, -12799, -11977, -11108, -10232, -9368, -8505, -7608, -6688, -5759, -4813, -3852, -2902, -1972, -997, -134};