/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0063 256 samples */
 
const int16_t AKWF_dbass_0063_256_DATA [256] = 
{785, 2163, 3157, 4270, 5343, 5934, 6528, 7339, 7997, 8767, 9572, 9960, 10778, 11242, 11557, 12210, 12500, 13083, 13528, 13309, 13411, 13894, 14472, 15172, 15769, 16768, 16972, 16871, 17219, 17606, 17996, 18389, 17955, 18240, 18037, 17452, 17870, 18227, 18281, 18503, 18343, 18058, 17976, 17891, 17930, 18219, 18568, 19048, 19436, 19858, 20506, 20932, 21420, 22309, 22926, 23695, 24319, 25317, 26064, 26418, 27003, 27553, 27688, 27792, 27821, 27971, 28144, 28446, 28773, 28835, 28632, 28621, 28708, 28585, 28467, 28541, 28539, 28524, 28735, 29077, 29438, 29914, 30263, 30376, 30480, 30727, 31029, 31332, 31618, 31818, 31930, 31709, 31363, 30809, 30003, 29214, 28517, 27609, 26610, 25652, 24990, 24554, 24244, 24169, 24127, 24201, 24427, 24633, 24635, 24588, 24649, 24667, 24375, 23929, 23237, 22419, 21503, 20660, 19786, 18902, 18091, 17233, 16391, 15803, 15295, 14759, 13987, 12987, 11843, 10595, 9147, 7741, 6291, 5036, 3973, 3005, 2133, 1261, 552, -12, -543, -1118, -1808, -2623, -3482, -4445, -5480, -6510, -7543, -8696, -9953, -11206, -12427, -13545, -14699, -15744, -16676, -17693, -18717, -19719, -20704, -21723, -22881, -23940, -24964, -25904, -26712, -27495, -28067, -28529, -28825, -28991, -29134, -29196, -29192, -29134, -29046, -28993, -29015, -29011, -29016, -29069, -29048, -29120, -29186, -29346, -29506, -29651, -29836, -29998, -30208, -30412, -30555, -30736, -30860, -31025, -31232, -31391, -31529, -31803, -31978, -32098, -32171, -32151, -32059, -31961, -31841, -31664, -31440, -31296, -31173, -31120, -31169, -31290, -31409, -31606, -31847, -32029, -32233, -32413, -32627, -32775, -32736, -32534, -32288, -31927, -31483, -31091, -30568, -30082, -29589, -29136, -28615, -28031, -27326, -26580, -25766, -24887, -24054, -23229, -22276, -21256, -20125, -18882, -17515, -16052, -14558, -13020, -11520, -9946, -8333, -6709, -5114, -3674, -2210, -666};