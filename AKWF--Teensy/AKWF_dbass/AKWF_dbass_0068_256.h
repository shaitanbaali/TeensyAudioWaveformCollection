/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0068 256 samples */
 
const int16_t AKWF_dbass_0068_256_DATA [256] = 
{748, 2278, 4069, 5268, 4808, 5291, 6801, 8798, 10994, 12866, 14162, 14531, 15447, 16816, 17844, 18895, 20389, 21719, 22479, 23430, 24166, 24278, 24925, 26368, 27599, 28854, 29645, 29677, 29552, 29590, 29577, 29670, 30251, 31429, 32342, 32784, 32447, 31330, 30084, 29043, 28292, 27568, 26737, 26602, 26712, 26756, 26836, 26967, 27131, 27582, 28127, 28522, 28762, 28430, 27694, 26719, 25829, 24754, 23464, 22251, 21273, 20522, 20078, 19699, 19048, 18272, 17749, 17001, 16109, 15631, 15346, 15112, 15221, 15708, 15995, 16090, 16181, 15746, 15131, 14593, 13801, 12936, 11997, 11030, 10583, 10490, 10442, 10434, 10557, 10973, 11589, 12130, 12476, 12940, 13357, 13568, 13706, 13694, 13497, 13009, 12467, 11764, 11019, 10425, 9637, 8740, 7974, 7522, 7262, 6886, 6441, 6047, 5783, 5511, 5158, 4524, 3852, 2839, 1333, -430, -2304, -4360, -6405, -8171, -9456, -10299, -10831, -10764, -10413, -9983, -9414, -8656, -8155, -7921, -7653, -7449, -7581, -7896, -8178, -8764, -9420, -10075, -10906, -11784, -12747, -13830, -14848, -15653, -16086, -16420, -16542, -16509, -16192, -15746, -15223, -15079, -15309, -15454, -15748, -16577, -17548, -18585, -19599, -20556, -21371, -21935, -22082, -22044, -21401, -20564, -19465, -17989, -16627, -15336, -14207, -13107, -12215, -11769, -11458, -11367, -11351, -11401, -11588, -12137, -12676, -13387, -14170, -14988, -15872, -16632, -17261, -17766, -18049, -18275, -18400, -18589, -18672, -18816, -19320, -19877, -20580, -21583, -22719, -23835, -24783, -25663, -26116, -26205, -26215, -25839, -25261, -24650, -24005, -23262, -22738, -22367, -22033, -21796, -21528, -21224, -21082, -20957, -20639, -20239, -19814, -19458, -19215, -18989, -18329, -17950, -18125, -17713, -16991, -16446, -16381, -15598, -14758, -14153, -13480, -13084, -12830, -12968, -12895, -12707, -12154, -11024, -9898, -9036, -8360, -8204, -7821, -6550, -4801, -3676, -2535, -802};