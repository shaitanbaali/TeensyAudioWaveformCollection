/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0030 256 samples */
 
const int16_t AKWF_dbass_0030_256_DATA [256] = 
{536, 1642, 2728, 3842, 4869, 5921, 6976, 8007, 8937, 9890, 10937, 11766, 12548, 13437, 14245, 14986, 15738, 16557, 17298, 17942, 18392, 19049, 19661, 20133, 20654, 21145, 21416, 21720, 21986, 22159, 22425, 22625, 22738, 22853, 22969, 22959, 22820, 22837, 22880, 22622, 22485, 22341, 22220, 22064, 21926, 21840, 21702, 21490, 21333, 21211, 21170, 21071, 21043, 20974, 21051, 21097, 21208, 21283, 21472, 21690, 21812, 22125, 22480, 22827, 23165, 23395, 23749, 24291, 24651, 25100, 25500, 25862, 26341, 26669, 27144, 27557, 28071, 28459, 28917, 29249, 29640, 30025, 30431, 30703, 31012, 31416, 31524, 31755, 32035, 32312, 32379, 32536, 32663, 32687, 32616, 32599, 32544, 32316, 32131, 31910, 31669, 31252, 30866, 30477, 29879, 29398, 28838, 28052, 27403, 26651, 25793, 25006, 24045, 23162, 22102, 21036, 19892, 18874, 17734, 16576, 15464, 14239, 13065, 11876, 10666, 9584, 8385, 7166, 6111, 5128, 3939, 2908, 2084, 926, 0, -773, -1728, -2556, -3353, -4101, -4766, -5523, -6132, -6882, -7443, -7828, -8406, -8913, -9300, -9675, -10056, -10480, -10752, -11050, -11213, -11518, -11788, -11903, -12164, -12214, -12299, -12531, -12627, -12734, -12870, -12845, -13086, -13109, -13330, -13377, -13540, -13750, -13934, -14033, -14151, -14408, -14707, -15041, -15194, -15435, -15738, -16160, -16544, -16929, -17311, -17689, -18080, -18530, -19081, -19527, -20116, -20622, -21094, -21629, -22156, -22696, -23350, -23841, -24361, -24841, -25446, -26009, -26436, -26938, -27277, -27735, -28269, -28622, -28963, -29324, -29583, -29832, -30120, -30395, -30490, -30723, -30654, -30657, -30574, -30467, -30311, -30075, -29905, -29623, -29253, -28716, -28293, -27757, -27296, -26712, -26117, -25293, -24665, -23810, -22998, -22211, -21176, -20269, -19388, -18410, -17433, -16463, -15439, -14424, -13309, -12228, -11057, -9954, -8928, -7666, -6524, -5420, -4263, -3158, -2044, -802};