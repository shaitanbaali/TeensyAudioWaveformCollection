/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0059 256 samples */
 
const int16_t AKWF_dbass_0059_256_DATA [256] = 
{544, 1440, 2246, 2969, 3638, 4261, 5049, 5796, 6399, 6865, 7188, 7646, 8102, 8498, 9003, 9762, 10682, 11737, 12979, 14249, 15499, 16837, 18186, 19134, 19979, 20796, 21688, 22813, 23948, 25052, 26307, 27351, 28352, 29363, 30150, 30830, 31489, 32095, 32475, 32734, 32742, 32564, 32392, 32217, 31994, 31898, 31694, 31654, 31506, 31404, 31099, 30757, 30277, 29809, 29382, 28697, 27932, 26978, 25987, 24843, 23723, 22645, 21689, 20773, 19942, 19139, 18258, 17465, 16697, 15953, 15127, 14256, 13190, 12149, 11215, 10531, 10019, 9601, 9328, 9164, 9098, 8819, 8312, 7770, 6905, 5714, 4869, 3976, 3189, 2551, 1581, 1139, 1115, 753, 859, 887, 403, -246, -405, -973, -1238, -1540, -2465, -3302, -3639, -3800, -3714, -4024, -4887, -5680, -6393, -7580, -9053, -10575, -12049, -13145, -12883, -12568, -12691, -12497, -12482, -11737, -10817, -10511, -10471, -9602, -9426, -8759, -7799, -7729, -7667, -7059, -6179, -5389, -4547, -4278, -4056, -3921, -4348, -4352, -4990, -5008, -4718, -4015, -3343, -2860, -2507, -2058, -1381, -1108, -852, -604, -397, -216, 240, 419, 108, -170, -678, -991, -1277, -1971, -2950, -3900, -5144, -6667, -7987, -9510, -10916, -11948, -12917, -13447, -13754, -13860, -13789, -13566, -13598, -13474, -13336, -13447, -13603, -13945, -14312, -14668, -15060, -15422, -15505, -15640, -15961, -15950, -16159, -16649, -17255, -17971, -18558, -19002, -19350, -19427, -19090, -18754, -18381, -17895, -17706, -17672, -17766, -18048, -18405, -18739, -19031, -19177, -19365, -19669, -19948, -20317, -20654, -20905, -21319, -21763, -22157, -22477, -22721, -22752, -22805, -22683, -22087, -21264, -20171, -18857, -17668, -16508, -15373, -14327, -13301, -12493, -11639, -10715, -9757, -8846, -8132, -7529, -7220, -6870, -6416, -6033, -5306, -4409, -3634, -2967, -2505, -2272, -2056, -1865, -1664, -1463, -1044, -303};