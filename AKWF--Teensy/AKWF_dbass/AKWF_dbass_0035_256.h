/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0035 256 samples */
 
const int16_t AKWF_dbass_0035_256_DATA [256] = 
{367, 946, 1505, 2081, 2672, 3287, 3930, 4569, 5194, 5816, 6450, 7109, 7794, 8490, 9191, 9885, 10585, 11303, 12029, 12747, 13447, 14136, 14838, 15572, 16333, 17118, 17904, 18670, 19417, 20158, 20911, 21670, 22404, 23102, 23786, 24464, 25128, 25759, 26361, 26931, 27468, 27984, 28493, 28977, 29402, 29762, 30097, 30465, 30883, 31314, 31692, 31983, 32209, 32388, 32516, 32604, 32674, 32735, 32766, 32767, 32757, 32743, 32714, 32634, 32503, 32352, 32200, 32050, 31892, 31721, 31539, 31353, 31161, 30966, 30761, 30521, 30226, 29888, 29528, 29160, 28812, 28500, 28222, 27957, 27668, 27345, 26995, 26602, 26153, 25678, 25211, 24777, 24360, 23927, 23449, 22931, 22402, 21896, 21389, 20848, 20281, 19699, 19115, 18533, 17959, 17398, 16849, 16292, 15719, 15118, 14486, 13822, 13152, 12497, 11868, 11252, 10644, 10037, 9426, 8801, 8162, 7508, 6814, 6090, 5365, 4673, 4019, 3370, 2689, 1986, 1280, 592, -54, -666, -1266, -1872, -2504, -3158, -3816, -4478, -5129, -5762, -6378, -6976, -7562, -8126, -8646, -9118, -9578, -10052, -10550, -11053, -11544, -12008, -12441, -12846, -13230, -13588, -13927, -14254, -14594, -14943, -15278, -15563, -15785, -15977, -16182, -16419, -16668, -16893, -17075, -17224, -17362, -17503, -17641, -17765, -17873, -17963, -18031, -18063, -18050, -18014, -17996, -18006, -18027, -18036, -18022, -17990, -17954, -17910, -17847, -17763, -17659, -17536, -17406, -17268, -17120, -16974, -16840, -16715, -16591, -16464, -16332, -16192, -16042, -15891, -15754, -15636, -15522, -15390, -15223, -15031, -14837, -14657, -14485, -14305, -14108, -13903, -13692, -13470, -13254, -13067, -12904, -12742, -12562, -12366, -12172, -11976, -11776, -11567, -11343, -11095, -10819, -10518, -10190, -9848, -9503, -9166, -8837, -8510, -8172, -7794, -7365, -6900, -6433, -5983, -5542, -5072, -4550, -3983, -3409, -2856, -2309, -1728, -1128, -476};