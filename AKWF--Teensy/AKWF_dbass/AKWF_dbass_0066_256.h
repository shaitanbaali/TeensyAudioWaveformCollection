/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0066 256 samples */
 
const int16_t AKWF_dbass_0066_256_DATA [256] = 
{785, 2216, 3602, 4965, 6367, 7758, 9070, 10369, 11743, 13107, 14444, 15776, 17088, 18446, 19874, 21124, 22465, 23750, 24916, 26008, 27069, 28110, 29022, 29852, 30555, 31166, 31716, 32107, 32426, 32632, 32709, 32677, 32554, 32226, 31918, 31405, 30847, 30081, 29339, 28507, 27581, 26554, 25437, 24294, 23032, 21725, 20322, 18913, 17513, 16035, 14638, 13189, 11698, 10197, 8805, 7360, 5962, 4606, 3225, 1959, 671, -471, -1526, -2644, -3656, -4511, -5419, -6315, -7055, -7787, -8482, -9181, -9863, -10464, -11069, -11604, -12213, -12710, -13334, -13917, -14554, -15112, -15690, -16406, -17035, -17746, -18473, -19211, -19837, -20531, -21294, -21970, -22663, -23303, -23904, -24530, -25025, -25470, -25869, -26283, -26521, -26671, -26798, -26761, -26695, -26511, -26259, -25846, -25410, -24927, -24352, -23809, -23098, -22364, -21603, -20721, -19802, -18856, -17833, -16818, -15742, -14671, -13505, -12297, -11064, -9769, -8422, -7118, -5851, -4539, -3168, -1853, -486, 845, 2227, 3678, 4991, 6342, 7660, 9025, 10431, 11726, 13189, 14531, 15813, 17137, 18316, 19451, 20639, 21653, 22591, 23497, 24358, 25083, 25689, 26211, 26686, 26954, 27159, 27236, 27172, 27126, 26977, 26698, 26201, 25623, 24997, 24323, 23539, 22610, 21633, 20674, 19563, 18454, 17277, 15964, 14766, 13434, 12147, 10848, 9520, 8219, 6892, 5564, 4293, 3032, 1863, 696, -382, -1455, -2534, -3481, -4286, -5141, -5990, -6670, -7384, -8104, -8666, -9307, -9895, -10387, -10862, -11390, -11837, -12318, -12863, -13294, -13798, -14316, -14831, -15375, -15965, -16525, -17155, -17742, -18332, -18964, -19586, -20136, -20700, -21265, -21768, -22211, -22599, -22918, -23151, -23314, -23498, -23571, -23465, -23348, -23080, -22698, -22270, -21749, -21181, -20486, -19822, -19050, -18238, -17337, -16349, -15333, -14237, -13198, -12079, -10896, -9727, -8466, -7169, -5947, -4608, -3220, -1866, -455};