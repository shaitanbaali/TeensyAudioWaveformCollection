/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0018 256 samples */
 
const int16_t AKWF_dbass_0018_256_DATA [256] = 
{427, 2141, 3894, 5808, 7666, 9525, 11366, 13162, 14844, 16325, 17710, 18971, 20181, 21340, 22580, 23870, 24966, 25952, 26734, 27374, 27938, 28242, 28458, 28681, 28756, 28761, 28761, 28606, 28364, 28145, 27900, 27703, 27435, 27128, 26731, 26187, 25472, 24740, 23950, 23171, 22403, 21754, 21172, 20686, 20249, 19742, 19126, 18354, 17379, 16313, 15227, 14196, 13248, 12442, 11764, 11115, 10483, 9807, 8952, 8133, 7274, 6439, 5644, 4745, 3810, 2700, 1417, 81, -1144, -2240, -3329, -4303, -5293, -6236, -7168, -8171, -9210, -10390, -11618, -12911, -14317, -15728, -17138, -18449, -19624, -20620, -21540, -22400, -23284, -24298, -25520, -26896, -28208, -29355, -30222, -31019, -31600, -32102, -32497, -32667, -32730, -32591, -32395, -32194, -32003, -31807, -31548, -31186, -30713, -30002, -29053, -27983, -26818, -25578, -24325, -23053, -21685, -20317, -18907, -17498, -16108, -14738, -13374, -12040, -10695, -9338, -8029, -6869, -5731, -4617, -3369, -1890, -114, 1823, 3518, 5125, 6464, 7617, 8696, 9723, 10784, 11757, 12776, 13778, 14750, 15861, 16932, 17866, 19028, 20031, 20905, 21668, 22388, 22879, 23295, 23752, 24293, 24702, 25232, 25661, 25675, 26055, 26345, 26041, 26251, 26590, 26674, 27240, 28009, 28078, 28271, 28758, 28917, 28809, 28925, 28567, 27859, 27584, 26802, 26082, 25732, 25409, 24693, 23889, 22902, 21965, 21180, 20637, 20006, 19560, 18941, 18037, 16705, 14923, 12969, 11024, 9219, 8115, 7436, 6632, 5634, 4236, 2482, 707, -804, -2138, -3533, -5122, -7080, -9282, -11543, -13511, -15199, -16654, -18105, -19628, -21206, -22701, -24126, -25391, -26705, -27900, -28987, -30097, -31313, -32106, -32494, -32711, -32731, -32582, -32467, -32426, -32355, -32191, -31760, -31147, -30185, -28934, -27576, -26256, -25173, -24148, -23122, -21825, -20531, -19216, -17818, -16368, -14737, -12775, -10764, -8762, -6676, -4720, -2984, -1222};