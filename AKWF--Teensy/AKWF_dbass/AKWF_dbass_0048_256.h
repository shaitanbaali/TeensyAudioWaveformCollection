/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0048 256 samples */
 
const int16_t AKWF_dbass_0048_256_DATA [256] = 
{284, 738, 1752, 2296, 2506, 3603, 4380, 4733, 4706, 4879, 5520, 5479, 5242, 5512, 5775, 6553, 7328, 7909, 8261, 8241, 8456, 8751, 8958, 8895, 9106, 10139, 11205, 12355, 13779, 15174, 16584, 17982, 19359, 20269, 20710, 20877, 20874, 20781, 20581, 20605, 20773, 21015, 21699, 22474, 23230, 24023, 24588, 24879, 25250, 25669, 26018, 26368, 26769, 27012, 26885, 26811, 26904, 26914, 26663, 26343, 26235, 26541, 27047, 27636, 28463, 29470, 30457, 31291, 31851, 32350, 32635, 32762, 32375, 31624, 30806, 29976, 29290, 28681, 28478, 28544, 28555, 28421, 28068, 27301, 26270, 24946, 23504, 21946, 20200, 18579, 17322, 16327, 15530, 14895, 14340, 13893, 13576, 13422, 13470, 13706, 13983, 14153, 14254, 14209, 13918, 13359, 12721, 11692, 10245, 8829, 7278, 5618, 4055, 2659, 1653, 816, 320, 172, 262, 408, 526, 613, 652, 870, 1178, 1383, 1487, 1342, 1122, 690, 178, -285, -962, -1904, -3144, -4397, -5437, -6345, -7071, -7604, -8028, -8360, -8410, -8298, -8134, -7820, -7556, -7571, -7820, -8329, -9018, -9712, -10283, -10826, -11390, -11912, -12248, -12506, -12764, -12935, -13008, -13150, -13339, -13445, -13587, -13884, -14182, -14440, -14796, -15141, -15402, -15779, -16288, -16835, -17605, -18707, -19950, -21130, -22223, -23163, -23984, -24710, -25391, -26004, -26534, -27123, -27615, -28023, -28287, -28405, -28479, -28404, -28270, -28059, -27723, -27364, -27029, -26724, -26500, -26371, -26340, -26428, -26570, -26744, -26968, -27245, -27457, -27530, -27533, -27487, -27411, -27154, -26727, -26391, -26122, -25428, -24530, -23245, -21663, -20291, -18920, -18261, -18243, -18048, -18036, -18306, -18034, -18376, -18774, -18823, -18765, -18423, -17753, -16510, -14971, -14181, -13588, -12790, -11890, -10895, -10284, -10063, -9894, -9529, -8824, -7977, -6409, -5317, -5115, -5270, -5521, -4648, -3120, -2226, -1048, -313};