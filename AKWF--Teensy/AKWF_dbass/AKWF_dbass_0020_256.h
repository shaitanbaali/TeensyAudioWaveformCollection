/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0020 256 samples */
 
const int16_t AKWF_dbass_0020_256_DATA [256] = 
{1058, 2952, 4576, 6106, 7652, 9272, 10762, 11667, 13339, 14794, 15844, 17191, 18697, 20244, 21199, 22038, 23616, 24761, 25771, 27011, 28075, 28563, 28900, 29661, 30192, 30274, 30622, 30499, 30500, 30631, 30851, 31281, 31305, 31753, 32114, 32450, 32708, 32204, 31746, 30370, 29118, 28187, 27488, 27456, 27349, 27181, 26698, 25609, 24494, 22941, 21536, 20499, 19628, 18712, 17307, 15788, 14105, 12168, 10437, 8871, 7521, 6281, 5408, 4733, 3794, 2651, 1326, 11, -1045, -2187, -3079, -3916, -4841, -5697, -6246, -6666, -6874, -6833, -6687, -6471, -6076, -5754, -5440, -5291, -5299, -5134, -4562, -3611, -2656, -2058, -1584, -1319, -1277, -1229, -1269, -1228, -1274, -1343, -1454, -1782, -2156, -2379, -2378, -2036, -1408, -628, 116, 851, 1477, 1861, 2238, 2679, 3169, 3830, 4611, 5557, 6524, 7597, 8600, 9583, 10391, 11120, 11944, 12824, 13525, 14185, 14571, 14787, 14821, 14802, 14673, 14374, 13874, 13429, 12975, 12588, 12204, 11718, 11164, 10337, 9451, 8589, 7772, 7055, 6543, 6116, 5668, 5267, 4807, 4241, 3679, 3110, 2501, 2116, 1866, 1611, 1422, 1312, 1261, 1224, 1259, 1305, 1190, 947, 519, 48, -364, -680, -887, -978, -1064, -1319, -1739, -2265, -2760, -3389, -3789, -3973, -3997, -4059, -4225, -4654, -5391, -6161, -6892, -7455, -7936, -8134, -8339, -8574, -8828, -9402, -9988, -10597, -11213, -11846, -12491, -13251, -14169, -15283, -16343, -17292, -18199, -18961, -19587, -20094, -20493, -21044, -21847, -22903, -24035, -25188, -26259, -27099, -27826, -28520, -29009, -29452, -29755, -29955, -29896, -29719, -29429, -29139, -28765, -28573, -28524, -28361, -28194, -27705, -27091, -26394, -25569, -24566, -23405, -22230, -21082, -19990, -18944, -17905, -16573, -15415, -14140, -13234, -12237, -11130, -10159, -8847, -7691, -6502, -5512, -5047, -4061, -3001, -1998, -458};