/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0025 256 samples */
 
const int16_t AKWF_dbass_0025_256_DATA [256] = 
{288, 943, 1330, 2002, 2644, 3391, 4326, 5214, 6101, 6587, 7085, 7993, 8912, 9923, 10832, 11980, 13257, 14569, 15804, 16740, 17194, 17368, 17171, 16933, 17045, 17265, 17862, 18518, 19238, 19673, 19459, 18861, 18061, 17339, 16790, 16363, 16272, 15914, 15149, 14275, 13500, 12951, 12647, 12639, 12817, 13045, 12999, 12920, 13031, 13288, 13485, 13693, 13947, 14243, 14458, 14455, 14284, 13995, 13690, 13395, 13516, 13939, 14339, 14736, 15005, 15330, 15413, 15236, 15002, 14605, 14378, 14331, 14519, 14912, 15263, 15421, 15431, 15528, 15896, 16213, 16791, 17600, 18494, 19388, 20134, 20837, 21520, 22279, 22942, 23774, 24483, 25165, 25672, 25970, 26096, 25950, 25771, 25589, 25334, 24991, 24750, 24541, 24365, 24212, 23912, 23670, 23447, 23144, 22923, 22826, 22821, 22729, 22681, 22516, 22309, 22191, 22113, 21993, 21894, 21685, 21518, 21287, 20946, 20511, 19985, 19267, 18512, 17631, 16706, 15776, 14790, 13947, 13119, 12363, 11622, 10879, 9988, 8982, 8000, 7037, 6034, 5166, 4377, 3665, 3179, 2615, 2161, 1803, 1629, 1429, 1264, 1035, 687, 241, -239, -673, -1027, -1341, -1618, -1898, -2090, -2356, -2759, -3234, -3741, -4219, -4763, -5107, -5504, -5934, -6372, -7106, -8053, -8937, -9960, -10875, -11655, -12375, -12999, -13676, -14279, -14921, -15593, -16247, -16930, -17596, -18242, -18829, -19485, -20304, -21271, -22209, -23170, -24055, -24743, -25451, -25973, -26467, -26981, -27501, -27978, -28518, -29114, -29638, -30126, -30620, -31066, -31491, -31979, -32310, -32566, -32778, -32677, -32485, -32130, -31615, -31179, -30917, -30740, -30648, -30590, -30483, -30167, -29862, -29514, -29138, -28534, -27911, -27184, -26347, -25415, -24743, -24082, -23328, -22401, -21507, -20418, -19183, -18060, -17166, -16395, -15389, -14191, -12968, -11906, -11074, -10152, -9587, -8847, -7909, -6494, -5197, -4159, -2912, -1530, -551};