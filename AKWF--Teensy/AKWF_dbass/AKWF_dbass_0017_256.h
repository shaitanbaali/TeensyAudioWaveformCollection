/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0017 256 samples */
 
const int16_t AKWF_dbass_0017_256_DATA [256] = 
{615, 1786, 3187, 4810, 6493, 8064, 9686, 11381, 13100, 14728, 16331, 17838, 19322, 20808, 22421, 23946, 25258, 26364, 27433, 28475, 29528, 30536, 31309, 31900, 32311, 32526, 32585, 32682, 32724, 32664, 32619, 32348, 31832, 31128, 30308, 29309, 28303, 27325, 26271, 25119, 23898, 22611, 21267, 19931, 18523, 16996, 15449, 14011, 12730, 11556, 10478, 9293, 8027, 6558, 5022, 3441, 2034, 795, -302, -1388, -2489, -3706, -4889, -6055, -7180, -8234, -9134, -10119, -11296, -12640, -13959, -15158, -16174, -16941, -17588, -18223, -18824, -19439, -20165, -20873, -21658, -22501, -23384, -24365, -25182, -25789, -26136, -26282, -26318, -26146, -25951, -25834, -25728, -25645, -25510, -25306, -25041, -24757, -24439, -23988, -23420, -22733, -21987, -21278, -20657, -20271, -20002, -19846, -19607, -19169, -18537, -17825, -16956, -16008, -14910, -13877, -12747, -11563, -10199, -8909, -7576, -6137, -4692, -3231, -1729, -307, 992, 2201, 3307, 4467, 5783, 7195, 8709, 10174, 11444, 12467, 13331, 14082, 14846, 15673, 16485, 17233, 17897, 18484, 18983, 19439, 19966, 20517, 20982, 21380, 21656, 21814, 21874, 21899, 21911, 21896, 21771, 21634, 21430, 21124, 20774, 20288, 19645, 18927, 18461, 18106, 17770, 17410, 16968, 16422, 15857, 15304, 14694, 14041, 13178, 12424, 12036, 11729, 11321, 10758, 9933, 8993, 8166, 7053, 5974, 5149, 4393, 3300, 2163, 925, -126, -1028, -1781, -2629, -3347, -3842, -4089, -4393, -4195, -3984, -3639, -3484, -3682, -4406, -5167, -5948, -6245, -6165, -6061, -6317, -7000, -8031, -8938, -9589, -10192, -10964, -11975, -13358, -14707, -15730, -16286, -16503, -16471, -16666, -17008, -17190, -17491, -17806, -17664, -17506, -17473, -17411, -17425, -17363, -16846, -16169, -15507, -14881, -14353, -13947, -13637, -13320, -12786, -11972, -10978, -10148, -9430, -8666, -7756, -6653, -5415, -4266, -3274, -2427, -1516, -430};