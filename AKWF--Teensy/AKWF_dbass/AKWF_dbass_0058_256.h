/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0058 256 samples */
 
const int16_t AKWF_dbass_0058_256_DATA [256] = 
{450, 117, 268, 982, 1505, 2289, 1225, 1237, 2582, 3374, 4488, 5020, 6438, 7713, 9073, 11231, 10619, 10204, 10559, 11135, 12103, 11085, 10734, 10345, 10452, 11289, 11972, 12200, 11952, 11745, 12869, 13906, 14603, 15253, 15493, 16052, 17020, 17584, 17889, 18378, 18843, 18593, 18321, 18069, 16935, 16357, 15699, 15391, 15793, 15931, 16333, 17053, 17791, 18393, 18882, 18514, 17575, 17031, 17249, 17266, 16974, 17409, 18018, 19352, 20940, 22285, 23304, 23977, 25106, 25891, 26196, 25990, 25252, 25121, 25116, 25160, 25327, 25963, 26543, 27022, 27446, 27594, 27348, 27164, 26725, 26232, 26237, 26562, 26857, 27631, 28353, 28615, 28184, 27118, 25859, 24239, 22564, 20836, 19188, 18046, 17372, 17217, 17090, 16966, 17294, 18309, 19472, 20357, 20736, 20825, 20770, 20339, 19292, 17574, 15322, 12914, 10802, 8996, 7065, 5335, 4277, 3803, 3327, 3097, 3206, 3796, 4566, 5148, 5526, 5425, 5153, 4541, 3593, 2403, 938, -550, -1750, -2864, -3751, -4411, -5030, -5660, -6233, -6633, -7024, -7568, -8049, -8392, -8446, -8125, -7972, -7851, -7824, -7734, -7722, -8177, -8785, -9447, -10060, -10922, -11608, -12127, -12450, -12820, -13375, -13883, -14326, -14976, -15810, -16645, -17380, -17935, -18702, -19441, -19934, -20000, -19611, -19068, -18321, -17635, -17078, -16807, -16857, -17352, -18235, -19241, -20185, -21213, -22454, -23803, -24973, -26069, -27391, -28758, -30167, -31450, -32272, -32620, -32672, -32755, -32544, -31873, -31023, -30224, -29485, -28869, -28440, -28116, -27990, -28065, -28044, -28000, -27836, -27542, -27258, -26932, -26739, -26796, -26690, -26578, -26364, -26074, -25725, -25253, -24699, -24057, -23333, -22702, -22253, -21938, -21447, -20860, -20203, -19384, -18538, -17681, -16903, -16201, -15345, -14573, -13703, -12675, -11631, -10639, -9675, -8434, -7359, -6427, -5294, -4276, -3893, -3491, -2862, -2076, -1133, -327};