/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0049 256 samples */
 
const int16_t AKWF_dbass_0049_256_DATA [256] = 
{1015, 2510, 3699, 4159, 3907, 3556, 3677, 4425, 6062, 8232, 10045, 11397, 12565, 13435, 13822, 14043, 14752, 15963, 17561, 19667, 22240, 24753, 26542, 26995, 25876, 24083, 22895, 22802, 23150, 22642, 20606, 17293, 13555, 10414, 8550, 8239, 9192, 11027, 13185, 14799, 15182, 13935, 10963, 6527, 1335, -3680, -7989, -10981, -12355, -13040, -13662, -14563, -16068, -18007, -20187, -22660, -25426, -27929, -29504, -29987, -29755, -29375, -29710, -30874, -31910, -32236, -31734, -30146, -27611, -24928, -22964, -21939, -20986, -19484, -17478, -15292, -13104, -10888, -8561, -6206, -4093, -2021, 112, 2303, 4719, 7429, 10585, 14130, 17558, 20332, 22288, 23599, 24375, 24616, 24438, 23693, 22330, 21004, 19638, 17716, 15775, 14277, 12738, 10424, 7735, 5289, 2604, -143, -2701, -5611, -9348, -13054, -15540, -16755, -16255, -13975, -11137, -9324, -8585, -8291, -8290, -8438, -8180, -7644, -7058, -6022, -4323, -2325, -201, 1949, 3459, 3748, 3128, 2504, 2456, 3267, 5005, 7053, 8751, 10191, 11479, 12365, 12655, 12968, 13788, 14977, 16506, 18815, 21767, 24208, 25081, 24300, 22504, 20819, 20316, 20753, 20648, 18896, 15761, 12091, 8854, 6953, 6682, 7596, 9100, 10861, 12426, 13185, 12782, 10887, 7211, 2079, -3451, -8442, -12162, -14145, -14853, -15262, -15925, -16957, -18434, -20553, -23197, -26103, -28932, -30925, -31429, -30657, -29527, -29215, -30050, -31372, -32465, -32771, -31860, -29850, -27426, -25280, -23784, -22400, -20321, -17574, -14792, -12509, -10646, -8875, -7027, -5186, -3146, -858, 1494, 3987, 6759, 9956, 13559, 17176, 20200, 22200, 23487, 24330, 24517, 24174, 23460, 22376, 20995, 19590, 17952, 15970, 14146, 12343, 10110, 7357, 4558, 2035, -42, -1824, -4072, -7239, -10838, -13980, -16295, -16823, -15272, -13007, -11175, -10131, -9469, -9019, -8654, -7951, -6945, -5995, -4828, -3271, -2345, -616};