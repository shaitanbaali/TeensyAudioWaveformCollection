/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0013 256 samples */
 
const int16_t AKWF_dbass_0013_256_DATA [256] = 
{601, 1809, 3140, 4463, 5789, 7247, 9019, 10585, 12135, 13438, 14599, 15607, 16625, 17646, 18532, 19274, 20178, 21175, 22135, 22925, 23617, 24157, 24723, 25148, 25600, 26093, 26662, 27258, 27839, 28171, 28273, 28202, 28287, 28570, 28879, 29155, 29493, 29720, 29804, 29684, 29446, 29060, 28634, 28175, 27565, 26637, 25670, 24632, 23624, 22541, 21374, 20116, 18718, 17291, 15713, 14165, 12479, 10686, 8777, 6799, 4776, 2766, 862, -889, -2572, -4198, -5640, -7192, -8724, -10231, -11573, -12979, -14201, -15468, -16706, -17947, -19241, -20413, -21394, -22336, -23235, -24252, -25318, -26406, -27523, -28627, -29578, -30481, -31151, -31748, -32149, -32523, -32719, -32765, -32649, -32447, -32294, -32046, -31633, -31136, -30391, -29597, -28588, -27651, -26659, -25744, -24901, -24013, -23099, -22206, -21353, -20509, -19680, -18849, -18006, -17084, -16091, -15078, -14205, -13393, -12523, -11569, -10619, -9442, -8226, -6975, -5723, -4540, -3322, -2204, -1055, 180, 1311, 2426, 3329, 4127, 4876, 5587, 6390, 7256, 8130, 8939, 9753, 10611, 11583, 12706, 13768, 14855, 15838, 16731, 17693, 18626, 19592, 20686, 21643, 22715, 23720, 24497, 25026, 25485, 25870, 26274, 26711, 26795, 26705, 26449, 26227, 26015, 25957, 25846, 25735, 25400, 24978, 24749, 24647, 24665, 24637, 24515, 24451, 24189, 23641, 22923, 22129, 21599, 20963, 20255, 19237, 18111, 16879, 15652, 14355, 13054, 11528, 10054, 8347, 6498, 4684, 3017, 1549, 343, -887, -2250, -3533, -5029, -6493, -7784, -9056, -10248, -11425, -12549, -13671, -14744, -15629, -16536, -17369, -18158, -18831, -19462, -19903, -20480, -20988, -21192, -21619, -21879, -22092, -22053, -21775, -21491, -21351, -21133, -20911, -20404, -20094, -19656, -19397, -18672, -17999, -17114, -16452, -15810, -15223, -14538, -13933, -13182, -12317, -11349, -10440, -9515, -8740, -7885, -6850, -5555, -4270, -2932, -1669, -504};