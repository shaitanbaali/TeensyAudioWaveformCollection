/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0010 256 samples */
 
const int16_t AKWF_dbass_0010_256_DATA [256] = 
{1777, 4311, 6442, 8440, 10552, 12922, 15421, 17918, 20489, 22807, 24535, 25999, 27155, 28587, 30184, 31498, 32188, 32400, 32545, 32646, 32671, 32361, 31876, 31119, 30184, 28911, 27427, 26202, 25212, 24457, 23506, 22208, 20435, 18500, 16454, 14228, 12144, 10131, 8393, 6900, 5602, 4173, 2630, 731, -1322, -3226, -4569, -5236, -5478, -5796, -5988, -6134, -6061, -5902, -5380, -4814, -4379, -4516, -5302, -6119, -6479, -6360, -5963, -5665, -5725, -6101, -6662, -7250, -8021, -8895, -10012, -11236, -12188, -12773, -12825, -12550, -12300, -12500, -13012, -14087, -14889, -15450, -16038, -16907, -17809, -18572, -19012, -19091, -18829, -18880, -19258, -20116, -21156, -21827, -21799, -21200, -20321, -19265, -18076, -16915, -15715, -14194, -12376, -10706, -8842, -6967, -5118, -3416, -2032, -928, -140, 419, 887, 1741, 3103, 4640, 6073, 7041, 7819, 8457, 9120, 10252, 11664, 13219, 14749, 16135, 17303, 18495, 19721, 20618, 21356, 21537, 21312, 20946, 20369, 20039, 19625, 19038, 18286, 17223, 15823, 14317, 12836, 11742, 11114, 10670, 10219, 9810, 9402, 8778, 8061, 7319, 6622, 6154, 5878, 6012, 6148, 6215, 5883, 5298, 4619, 3887, 3255, 2741, 2115, 1322, 557, 105, -267, -852, -948, -889, -876, -659, -588, 372, 1418, 2161, 3083, 3401, 3375, 3657, 3426, 3387, 3359, 3347, 3055, 2067, 1671, 1382, 1062, 463, -1375, -3080, -3716, -4331, -4497, -5407, -5630, -4672, -3817, -2315, -383, 1944, 3432, 3622, 3240, 2814, 3301, 4917, 6385, 7261, 7008, 6137, 5283, 4682, 4410, 3366, 924, -1697, -4410, -6132, -7305, -7992, -8975, -10223, -11066, -11562, -11849, -11894, -12237, -12783, -12821, -12291, -11016, -9658, -8647, -7864, -8166, -9015, -9507, -9590, -8957, -8359, -8469, -8964, -9185, -8765, -8356, -8110, -7587, -6942, -6167, -5065, -3281, -932};