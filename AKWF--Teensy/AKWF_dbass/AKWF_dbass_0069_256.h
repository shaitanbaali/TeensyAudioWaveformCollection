/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0069 256 samples */
 
const int16_t AKWF_dbass_0069_256_DATA [256] = 
{513, 1166, 3268, 5002, 5950, 6063, 6961, 8404, 9860, 10395, 11327, 13334, 14946, 15935, 16758, 18347, 19804, 20319, 21355, 23081, 24329, 24963, 26041, 27372, 28426, 28904, 29087, 29175, 29472, 30604, 30751, 30138, 30382, 31039, 32228, 32773, 32559, 32057, 31134, 29974, 28829, 27623, 26546, 26142, 26097, 26569, 27409, 27788, 27894, 28158, 28806, 29218, 29177, 29222, 29099, 28206, 27361, 26345, 24969, 23747, 23081, 22557, 22173, 21921, 21906, 21559, 20582, 19540, 18653, 18211, 17812, 17461, 17501, 17980, 18587, 18926, 18854, 18722, 18555, 17777, 16785, 15696, 14640, 13568, 12717, 12168, 11940, 11985, 12324, 12651, 12842, 13324, 14026, 14401, 14665, 15009, 15133, 15083, 14732, 14195, 13512, 12691, 11678, 10763, 9964, 9180, 8636, 8079, 7497, 7091, 6786, 6219, 5848, 5389, 4947, 4650, 4077, 3115, 1737, 236, -1527, -3725, -6107, -8023, -9564, -10732, -11330, -11436, -11373, -11073, -10458, -9586, -8889, -8486, -8091, -7879, -7801, -7637, -7637, -7874, -8316, -9060, -10043, -11083, -12204, -13534, -14631, -15627, -16400, -17011, -17303, -17421, -17397, -17135, -16622, -15952, -15683, -15830, -16071, -16552, -17310, -18290, -19430, -20648, -21690, -22426, -22993, -23046, -22585, -21772, -20393, -18758, -16944, -15265, -13910, -12814, -11902, -11272, -10772, -10599, -10772, -10970, -11157, -11746, -12461, -13108, -13845, -14828, -15894, -16823, -17649, -18319, -18743, -18999, -19068, -18984, -19006, -19161, -19604, -20387, -21424, -22687, -23856, -25008, -26153, -27100, -27596, -27741, -27668, -27273, -26521, -25866, -25217, -24530, -23925, -23523, -22992, -22693, -22687, -22416, -22093, -21989, -21885, -21808, -21627, -21196, -20876, -20768, -20451, -19918, -19687, -19324, -18889, -18376, -17806, -17475, -17281, -16583, -15732, -14913, -14527, -15098, -15033, -14353, -13642, -12937, -11865, -10710, -9756, -9658, -9132, -7978, -6926, -5728, -3899, -1348};