/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0024 256 samples */
 
const int16_t AKWF_dbass_0024_256_DATA [256] = 
{1325, 2724, 3533, 3809, 4067, 4591, 5098, 5717, 6754, 7482, 8041, 8504, 9223, 10049, 10942, 11956, 13093, 14480, 15889, 17389, 18503, 19225, 19719, 19580, 19208, 18980, 19037, 19624, 20541, 21764, 22545, 22572, 21991, 20954, 19910, 18930, 18203, 17772, 17372, 16692, 15544, 14178, 13046, 12186, 11819, 11810, 11976, 12100, 11983, 11890, 11945, 12109, 12373, 12798, 13129, 13455, 13684, 13639, 13420, 13132, 12871, 12706, 12962, 13350, 13633, 13866, 14195, 14445, 14543, 14484, 14169, 13788, 13480, 13445, 13442, 13692, 13834, 13773, 13723, 13562, 13476, 13673, 14289, 15142, 16102, 17029, 18020, 18930, 19794, 20791, 21828, 22752, 23586, 24389, 25089, 25443, 25617, 25551, 25207, 25052, 24782, 24645, 24378, 24269, 24243, 24178, 24081, 23754, 23359, 22933, 22577, 22272, 22278, 22214, 22087, 22023, 21874, 21725, 21606, 21432, 21323, 21229, 21339, 21331, 21145, 20824, 20399, 19772, 18898, 17914, 16923, 15892, 14904, 14092, 13293, 12557, 11865, 10984, 9955, 8810, 7609, 6574, 5579, 4539, 3793, 3099, 2472, 1908, 1601, 1301, 1082, 905, 571, 60, -423, -922, -1331, -1680, -1962, -2033, -2104, -2104, -2257, -2509, -2973, -3547, -4114, -4586, -5101, -5294, -5578, -5999, -6685, -7597, -8631, -9785, -10853, -11741, -12488, -13092, -13584, -14232, -14995, -15751, -16611, -17429, -18183, -18820, -19557, -20357, -21028, -21775, -22575, -23516, -24323, -25057, -25682, -26294, -26677, -27174, -27596, -28098, -28552, -29121, -29623, -30194, -30655, -31005, -31479, -31975, -32297, -32574, -32672, -32727, -32595, -32351, -31870, -31381, -31023, -30799, -30743, -30665, -30767, -30592, -30442, -29852, -29096, -28706, -28133, -27492, -26662, -25785, -24997, -23937, -22942, -22316, -21653, -20584, -19369, -18172, -16885, -15361, -14078, -13682, -13197, -12015, -10746, -9784, -8995, -7993, -6826, -6113, -4959, -3272, -1638, -400};