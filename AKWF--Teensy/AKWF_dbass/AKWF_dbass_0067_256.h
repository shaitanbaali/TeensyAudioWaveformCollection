/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0067 256 samples */
 
const int16_t AKWF_dbass_0067_256_DATA [256] = 
{636, 1492, 1884, 2183, 2905, 4052, 4728, 4665, 6372, 8129, 9185, 10112, 11375, 12427, 12664, 13016, 12843, 12753, 13050, 13379, 13764, 13664, 13104, 13330, 13915, 14280, 14306, 14935, 15394, 15311, 15132, 15056, 15271, 15834, 16717, 17218, 18403, 18930, 18665, 18867, 19164, 18518, 17878, 18236, 18890, 18976, 18888, 18864, 18459, 18144, 18208, 18378, 18814, 18590, 18278, 18035, 17748, 17958, 18544, 19041, 19195, 19302, 19687, 20000, 20446, 21178, 22049, 23097, 24107, 24628, 24787, 24903, 25377, 26113, 26601, 26906, 27005, 26989, 27091, 27205, 27087, 27161, 27638, 28296, 28760, 28566, 28100, 27448, 26744, 26004, 25035, 23700, 22271, 21223, 20716, 20447, 19955, 19449, 19216, 19384, 19671, 19952, 20208, 20484, 20623, 20705, 20470, 19652, 18339, 16986, 15786, 14209, 12328, 10269, 8272, 6629, 5177, 3969, 2878, 1962, 1466, 1485, 1571, 1409, 1081, 901, 873, 651, 6, -865, -1678, -2313, -2764, -3285, -3824, -4345, -4780, -5027, -5220, -5543, -6043, -6456, -6806, -7139, -7569, -8024, -8459, -8802, -9110, -9476, -9856, -10142, -10335, -10378, -10459, -10679, -11027, -11322, -11462, -11512, -11662, -11958, -12268, -12618, -12958, -13441, -14102, -14854, -15662, -16431, -17193, -17931, -18577, -18999, -19289, -19419, -19534, -19645, -19763, -19836, -19862, -20033, -20408, -20926, -21577, -22315, -23165, -24179, -25265, -26337, -27325, -28353, -29356, -30231, -31092, -31833, -32353, -32671, -32760, -32769, -32596, -32125, -31572, -31019, -30654, -30443, -30283, -30280, -30263, -30189, -29950, -29644, -29242, -28660, -27895, -27167, -26490, -25933, -25456, -25149, -24822, -24582, -24323, -24050, -23609, -22918, -22223, -21549, -20872, -20122, -19423, -18656, -17790, -16650, -15235, -13781, -12301, -10866, -9593, -8483, -7615, -6646, -5795, -5205, -4768, -3998, -3195, -3046, -2433, -2028, -2106, -1751, -1232, -397, -429, -200};