/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0021 256 samples */
 
const int16_t AKWF_dbass_0021_256_DATA [256] = 
{1228, 2834, 4617, 6119, 7468, 9049, 10399, 11931, 13349, 14898, 16466, 17656, 18908, 20159, 20963, 21925, 23083, 23985, 24673, 25382, 26070, 26519, 27220, 28044, 28775, 29700, 30392, 31192, 31711, 31873, 31923, 31893, 31601, 31575, 31463, 31409, 31628, 31857, 31575, 31214, 30703, 29831, 28979, 28361, 27764, 27003, 26086, 25023, 23584, 22161, 20890, 19883, 18931, 17827, 16686, 15467, 14268, 12959, 11670, 10626, 9651, 8571, 7543, 6564, 5360, 4135, 2926, 1964, 1176, 522, 94, -299, -861, -1534, -2200, -2764, -3160, -3328, -3242, -3015, -2843, -2865, -3001, -3301, -3540, -3721, -3810, -3699, -3586, -3501, -3396, -3463, -3553, -3542, -3227, -2755, -2141, -1435, -928, -431, -6, 525, 1076, 1732, 2332, 3047, 3835, 4571, 5301, 6023, 6866, 7657, 8482, 9309, 10193, 10874, 11522, 12237, 12737, 13264, 13763, 14253, 14643, 14964, 15153, 15205, 15047, 14923, 14764, 14625, 14536, 14279, 14029, 13730, 13354, 12939, 12589, 12203, 11823, 11438, 10955, 10500, 9978, 9394, 8775, 8195, 7663, 7223, 6824, 6540, 6319, 6211, 6066, 5946, 5725, 5400, 4995, 4569, 4172, 3799, 3509, 3318, 3063, 2769, 2401, 1953, 1453, 946, 393, -131, -604, -1141, -1798, -2463, -3328, -4167, -4965, -5640, -6267, -6795, -7372, -7919, -8482, -9172, -9832, -10444, -11095, -11733, -12346, -13140, -14050, -14974, -15906, -16698, -17329, -17881, -18430, -19038, -19720, -20404, -21206, -22114, -22982, -23816, -24618, -25395, -26208, -27011, -27830, -28630, -29381, -29913, -30335, -30706, -30975, -31255, -31644, -32008, -32361, -32633, -32758, -32755, -32713, -32643, -32490, -32344, -32120, -31713, -31208, -30599, -29890, -29148, -28363, -27482, -26731, -26000, -25157, -24201, -23145, -22044, -21045, -20032, -19093, -18149, -17118, -15937, -14681, -13351, -11714, -10157, -8619, -6890, -5144, -3678, -2111, -504};