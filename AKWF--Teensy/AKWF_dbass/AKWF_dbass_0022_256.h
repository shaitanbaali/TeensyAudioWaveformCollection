/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0022 256 samples */
 
const int16_t AKWF_dbass_0022_256_DATA [256] = 
{823, 2054, 3086, 4272, 5442, 6837, 8144, 9250, 10625, 11922, 12924, 13797, 14184, 15029, 15355, 15938, 16789, 17567, 18150, 18666, 19297, 19770, 20316, 20757, 21304, 22020, 23105, 24185, 25315, 25961, 26273, 26287, 25933, 25456, 24976, 24670, 24754, 25342, 25881, 26140, 26398, 26297, 25797, 25198, 24422, 23786, 23250, 22496, 21478, 20362, 19221, 18113, 17368, 16746, 16340, 15896, 15725, 15538, 15515, 15530, 15531, 15484, 15293, 15192, 14835, 14260, 13484, 12351, 11247, 10499, 9688, 9076, 8782, 8541, 8490, 8448, 8319, 7892, 7160, 6157, 5306, 4588, 4022, 3552, 3241, 2931, 2636, 2360, 2165, 2343, 2742, 3246, 4007, 4891, 5699, 6215, 6665, 7429, 8014, 8687, 9365, 9797, 10402, 10956, 11362, 11699, 12050, 12241, 12346, 12323, 12306, 12213, 11801, 11621, 11254, 10895, 10637, 10428, 10344, 10413, 10548, 11008, 11337, 11650, 11902, 12224, 12535, 12992, 13277, 13754, 14243, 14553, 14838, 14929, 14896, 14792, 14637, 14320, 13829, 13208, 12498, 12023, 11768, 11583, 11363, 11233, 11020, 10577, 9960, 9264, 8433, 7760, 7126, 6436, 6083, 5889, 5532, 5396, 5592, 5655, 5723, 5680, 5883, 6007, 6159, 6206, 5996, 5869, 5552, 5129, 4738, 4184, 3591, 3215, 2725, 2190, 1501, 1061, 515, -85, -1091, -2207, -3619, -5101, -6783, -8193, -9542, -10779, -11774, -12542, -13328, -13949, -14707, -15419, -15971, -16603, -17206, -17812, -18541, -19253, -20028, -20758, -21622, -22487, -23393, -24265, -24858, -25232, -25850, -26203, -26640, -27015, -27410, -27936, -28443, -29039, -29794, -30515, -31166, -31996, -32420, -32668, -32704, -32503, -31951, -31318, -30586, -29872, -29283, -28640, -28062, -27255, -26258, -25228, -24081, -22877, -21667, -20405, -19124, -17745, -16466, -15342, -14329, -13248, -12098, -11056, -10121, -8844, -7543, -6329, -5349, -4389, -3297, -2311, -1410, -326};