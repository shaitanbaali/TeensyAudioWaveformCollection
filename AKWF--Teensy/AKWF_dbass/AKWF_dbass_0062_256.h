/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0062 256 samples */
 
const int16_t AKWF_dbass_0062_256_DATA [256] = 
{240, 914, 1514, 2176, 2801, 3366, 3914, 4419, 4938, 5448, 5983, 6527, 7050, 7598, 8175, 8640, 9136, 9540, 10030, 10527, 10894, 11443, 11960, 12340, 12738, 13139, 13400, 13743, 14339, 14677, 15174, 15546, 16009, 16246, 16360, 17017, 17510, 17977, 18471, 18778, 19288, 19502, 19893, 20160, 20454, 20938, 21518, 22256, 22820, 23270, 23248, 23428, 23660, 23786, 23244, 23035, 22874, 22711, 22785, 23115, 23375, 23543, 23515, 23382, 23161, 22815, 22583, 22401, 22122, 21664, 21244, 21109, 21065, 20923, 20510, 20535, 20447, 20500, 20572, 20446, 20275, 19809, 19454, 18994, 18516, 18007, 17417, 17072, 16920, 16694, 16445, 16172, 15889, 15653, 15285, 14903, 14499, 14081, 13785, 13512, 13295, 13042, 12691, 12505, 12268, 11993, 11852, 12039, 12359, 12620, 12841, 12906, 12882, 12788, 12490, 11949, 11420, 10884, 10336, 10037, 9871, 9659, 9569, 9678, 9746, 9714, 9668, 9487, 9094, 8602, 7981, 7046, 6003, 5047, 4054, 3163, 2333, 1510, 781, 214, -277, -711, -1235, -1744, -2323, -3090, -4024, -5097, -6214, -7409, -8432, -9391, -10233, -10885, -11370, -11741, -11999, -12206, -12495, -12796, -13156, -13473, -13788, -14120, -14388, -14613, -14711, -14738, -14684, -14633, -14431, -14174, -13884, -13687, -13565, -13470, -13490, -13648, -13830, -14013, -14247, -14614, -14961, -15312, -15724, -16086, -16326, -16494, -16528, -16609, -16766, -17102, -17627, -18311, -19031, -19799, -20586, -21354, -22114, -22895, -23668, -24476, -25243, -25939, -26495, -26972, -27350, -27723, -28040, -28432, -28898, -29557, -30326, -31016, -31648, -32139, -32449, -32658, -32759, -32695, -32508, -32130, -31662, -31159, -30551, -29960, -29332, -28659, -28006, -27316, -26607, -25848, -24996, -24107, -23051, -21989, -20827, -19566, -18281, -16908, -15522, -14210, -12964, -11804, -10709, -9706, -8676, -7709, -6813, -5856, -4923, -3949, -3035, -2135, -1271, -489};