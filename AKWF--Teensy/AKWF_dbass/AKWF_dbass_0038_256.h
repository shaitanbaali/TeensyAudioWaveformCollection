/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0038 256 samples */
 
const int16_t AKWF_dbass_0038_256_DATA [256] = 
{425, 1826, 3224, 4463, 5621, 6951, 8152, 9241, 10465, 11677, 12897, 13987, 14991, 16068, 17221, 18276, 19392, 20531, 21464, 22370, 23240, 24059, 24888, 25814, 26705, 27492, 28130, 28670, 29155, 29700, 30291, 30765, 30974, 31323, 31879, 32300, 32334, 32314, 32497, 32605, 32584, 32682, 32770, 32642, 32432, 32249, 31944, 31674, 31443, 31004, 30382, 29861, 29322, 28530, 27584, 26734, 25830, 24894, 23921, 22890, 21814, 20572, 19172, 17819, 16498, 15162, 13851, 12550, 11114, 9421, 7618, 5992, 4377, 2723, 1081, -557, -2204, -3934, -5539, -7174, -8940, -10656, -12278, -13733, -15237, -16846, -18317, -19732, -21045, -22258, -23495, -24663, -25742, -26753, -27688, -28604, -29546, -30219, -30622, -30928, -31306, -31822, -32176, -32320, -32252, -32032, -32071, -31925, -31372, -30995, -30750, -30163, -29282, -28533, -27917, -27293, -26435, -25482, -24442, -23419, -22508, -21419, -20227, -19048, -17869, -16581, -15326, -14127, -12812, -11448, -10059, -8807, -7546, -6159, -4934, -3837, -2624, -1267, 124, 1288, 2400, 3724, 5071, 6340, 7538, 8708, 9901, 10950, 11990, 13170, 14290, 15262, 16223, 17142, 18065, 19074, 20105, 20926, 21553, 22314, 23134, 23698, 24282, 25060, 25858, 26278, 26708, 27245, 27641, 27974, 28347, 28690, 28945, 29152, 29254, 29252, 29171, 29270, 29465, 29367, 29098, 28694, 28177, 27686, 27127, 26610, 26154, 25551, 24688, 23811, 23019, 22153, 21107, 20155, 19199, 18085, 16959, 15915, 14851, 13507, 12023, 10702, 9345, 7968, 6819, 5542, 4109, 2764, 1349, -43, -1177, -2400, -3874, -5291, -6437, -7457, -8585, -9653, -10550, -11460, -12431, -13307, -14056, -14815, -15587, -16262, -16744, -17112, -17471, -17756, -17856, -17982, -17948, -17719, -17519, -17248, -16898, -16674, -16276, -15675, -15067, -14505, -13981, -13155, -12336, -11568, -10672, -9770, -8554, -7322, -6367, -5471, -4362, -3067, -1871, -765};