/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0046 256 samples */
 
const int16_t AKWF_dbass_0046_256_DATA [256] = 
{515, 1306, 2018, 2721, 3319, 4170, 4895, 5565, 6366, 6934, 7746, 8550, 9099, 10097, 10774, 11293, 12198, 12977, 13454, 14114, 14802, 15341, 16077, 16709, 17373, 17958, 18522, 18937, 19502, 20102, 20547, 21063, 21528, 21913, 22400, 22925, 23276, 23772, 24211, 24429, 24954, 25165, 25374, 25832, 26138, 26343, 26527, 26762, 27072, 27384, 27540, 27767, 28024, 28248, 28427, 28702, 28807, 28968, 29230, 29328, 29626, 29936, 30030, 30227, 30518, 30657, 30730, 30890, 31231, 31292, 31415, 31662, 31923, 32064, 32111, 32365, 32419, 32570, 32611, 32689, 32718, 32768, 32734, 32737, 32690, 32496, 32475, 32396, 32207, 32010, 31783, 31490, 31164, 30943, 30731, 30269, 29982, 29734, 29164, 28595, 28051, 27680, 27015, 26564, 25919, 25226, 24631, 24030, 23399, 22648, 22031, 21210, 20432, 19723, 19078, 18388, 17595, 16788, 15949, 15224, 14133, 13230, 12353, 11501, 10565, 9671, 8868, 7934, 7040, 5982, 5132, 4108, 3198, 2399, 1408, 392, -480, -1378, -2316, -3323, -4001, -4878, -5852, -6612, -7417, -8025, -8975, -9874, -10393, -11109, -11901, -12579, -13214, -13945, -14486, -15119, -15766, -16404, -16974, -17621, -18073, -18582, -19171, -19675, -20064, -20606, -21193, -21556, -22042, -22414, -22836, -23362, -23642, -23889, -24516, -24910, -25199, -25552, -26060, -26202, -26555, -26887, -27148, -27411, -27774, -27958, -28141, -28394, -28649, -28783, -29053, -29203, -29223, -29216, -29276, -29334, -29473, -29410, -29491, -29408, -29306, -28985, -28764, -28656, -28531, -28270, -28026, -27749, -27423, -27150, -26773, -26289, -25971, -25533, -25186, -24804, -24241, -23757, -23095, -22701, -22169, -21438, -20773, -20131, -19697, -19014, -18368, -17862, -17201, -16580, -15917, -15310, -14659, -13889, -13324, -12654, -12040, -11312, -10438, -9953, -9345, -8639, -7940, -7306, -6789, -6021, -5385, -4798, -4254, -3765, -3233, -2524, -1821, -1398, -902, -289};