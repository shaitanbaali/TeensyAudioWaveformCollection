/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0026 256 samples */
 
const int16_t AKWF_dbass_0026_256_DATA [256] = 
{387, 1672, 3017, 4349, 5563, 6689, 7707, 8575, 9569, 10548, 11674, 12813, 13971, 15224, 16496, 17765, 19018, 20150, 21313, 22427, 23383, 24308, 25289, 26476, 27593, 28721, 29664, 30369, 30996, 31440, 31798, 32185, 32473, 32693, 32759, 32639, 32350, 32077, 31842, 31440, 30992, 30417, 29627, 28885, 27984, 27049, 26145, 25238, 24433, 23641, 22837, 21991, 21336, 20636, 20013, 19391, 18899, 18360, 17796, 17291, 16816, 16450, 16086, 15841, 15674, 15610, 15652, 15796, 15900, 15975, 15918, 15703, 15365, 14975, 14614, 14380, 14243, 14164, 14213, 14318, 14482, 14547, 14650, 14710, 14754, 14725, 14595, 14497, 14398, 14268, 14136, 14003, 13698, 13247, 12642, 11994, 11314, 10759, 10244, 9872, 9516, 9185, 8790, 8394, 7965, 7519, 6965, 6326, 5724, 5042, 4311, 3484, 2672, 1807, 927, 119, -779, -1535, -2256, -2849, -3166, -3676, -4211, -4819, -5476, -5963, -6665, -7318, -8050, -8677, -9224, -9677, -10416, -11017, -11595, -12187, -12709, -13390, -14149, -14709, -15112, -15300, -15240, -15422, -15485, -15562, -15948, -16728, -17028, -17547, -17911, -18041, -18014, -17572, -17249, -17323, -17290, -17016, -16894, -16494, -16140, -15787, -14977, -14469, -14252, -14015, -13660, -13060, -12282, -11613, -10858, -10037, -9272, -8630, -7940, -7591, -7440, -7469, -8024, -8539, -8770, -8696, -8451, -8002, -7400, -6655, -6225, -6197, -6424, -6838, -7284, -7904, -8449, -8783, -8914, -9062, -9390, -10013, -10764, -11554, -12375, -13050, -13701, -14093, -14204, -14235, -14304, -14343, -14498, -14886, -15296, -15822, -16277, -16671, -17047, -17337, -17630, -17986, -18288, -18526, -18782, -18939, -18900, -18924, -18921, -18934, -18993, -18974, -18903, -18955, -18848, -18682, -18434, -17916, -17284, -16557, -15667, -14965, -14503, -14062, -13695, -13218, -12610, -11937, -11178, -10398, -9585, -8674, -7706, -6818, -5816, -4848, -3986, -3049, -2027, -853};