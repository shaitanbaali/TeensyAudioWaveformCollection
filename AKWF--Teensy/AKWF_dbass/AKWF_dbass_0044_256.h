/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0044 256 samples */
 
const int16_t AKWF_dbass_0044_256_DATA [256] = 
{263, 903, 1554, 1936, 2296, 2701, 3121, 3587, 3994, 4497, 5134, 5653, 6489, 7166, 7966, 8552, 9471, 10303, 11180, 12085, 13110, 14174, 15218, 16236, 17195, 18183, 18995, 19938, 20716, 21463, 22070, 22544, 23198, 23816, 24241, 24899, 25555, 26280, 26990, 27836, 28767, 29493, 30312, 31021, 31665, 32120, 32398, 32572, 32627, 32618, 32362, 32346, 32222, 31937, 31821, 31756, 31611, 31572, 31505, 31623, 31608, 31470, 31342, 31176, 30865, 30544, 30206, 29883, 29508, 29172, 28739, 28198, 27634, 27071, 26259, 25635, 24993, 24337, 23811, 23445, 23139, 22939, 22646, 22519, 22162, 21773, 21399, 20975, 20270, 19727, 19004, 18242, 17498, 16774, 15980, 15213, 14507, 13688, 13016, 12397, 11593, 10844, 10250, 9475, 8854, 8211, 7852, 7581, 7259, 6817, 6408, 5708, 5030, 4118, 3330, 2739, 2417, 2056, 1808, 1678, 1745, 1789, 1778, 1763, 1678, 1596, 1592, 1597, 1706, 1978, 1831, 1954, 2211, 2353, 2484, 2499, 2434, 2395, 2090, 1556, 869, 144, -580, -1090, -1613, -1760, -1997, -2128, -2431, -2470, -2550, -2874, -3437, -3842, -4153, -4559, -5042, -5428, -6033, -6675, -7603, -8647, -9519, -10240, -10929, -11642, -12343, -12566, -12649, -12816, -12854, -12981, -12582, -12629, -12704, -12614, -12792, -13309, -14090, -14751, -15430, -16044, -16706, -16972, -17138, -17093, -16676, -16703, -16640, -16675, -17017, -17349, -17699, -17948, -18224, -18528, -18682, -18635, -18490, -18516, -18783, -19190, -19913, -20767, -21665, -22318, -23005, -23694, -24130, -24107, -24183, -24161, -24126, -24094, -24121, -24133, -24195, -24207, -24300, -24342, -24072, -23892, -23674, -23054, -22495, -22019, -21585, -21117, -20590, -20109, -19703, -19079, -18358, -17321, -16278, -14985, -13873, -12508, -11451, -10355, -9475, -8904, -8449, -8071, -7735, -7481, -6980, -6561, -6077, -5312, -4328, -3502, -2585, -1768, -914, -206};