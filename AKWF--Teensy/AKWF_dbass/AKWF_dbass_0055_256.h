/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0055 256 samples */
 
const int16_t AKWF_dbass_0055_256_DATA [256] = 
{943, 2423, 3691, 5058, 6260, 7340, 8624, 9986, 11565, 13259, 14957, 16631, 18239, 19695, 21118, 22393, 23632, 24826, 25888, 26835, 27562, 28213, 28873, 29497, 30033, 30618, 31195, 31745, 32236, 32613, 32594, 32756, 32687, 32554, 32336, 31947, 31507, 30889, 30251, 29626, 28959, 28197, 27462, 26687, 26036, 25375, 24698, 24117, 23499, 22903, 22492, 22219, 22062, 21954, 21937, 21810, 21531, 21287, 20874, 20560, 20199, 19919, 19765, 19592, 19318, 18958, 18421, 17795, 16950, 16109, 15267, 14480, 13616, 12729, 11861, 10821, 9547, 8067, 6475, 4739, 2954, 1126, -610, -2087, -3384, -4444, -5345, -6196, -6921, -7601, -8281, -8827, -9208, -9482, -9586, -9502, -9217, -8745, -8059, -7246, -6463, -5657, -4817, -4302, -3919, -3374, -2742, -1947, -1501, -1172, -626, -356, -256, -136, 17, 132, 402, 19, 152, 114, -198, 54, -462, -1362, -1704, -2424, -3744, -4750, -5622, -6547, -7273, -7885, -7988, -7760, -7689, -7770, -8332, -8256, -7683, -7724, -7688, -7497, -7335, -7185, -7043, -7275, -6982, -6576, -6305, -6150, -5860, -5388, -4892, -4397, -3997, -3537, -2827, -2153, -1694, -1206, -403, 48, 441, 752, 1037, 1334, 996, 374, -459, -1195, -1843, -2462, -2785, -2934, -2878, -2855, -3130, -3374, -3728, -4331, -5035, -5641, -6119, -6358, -6619, -6959, -7241, -7642, -8360, -9392, -10557, -11782, -12780, -13612, -14440, -14946, -15343, -16058, -17224, -18477, -19536, -20388, -21097, -21605, -22123, -22321, -22361, -22622, -22984, -23179, -23526, -23951, -24507, -25271, -26062, -26685, -27212, -27437, -27289, -26738, -25963, -25358, -24767, -24302, -23905, -23631, -23335, -22979, -22646, -22318, -21931, -21466, -20653, -19662, -18804, -18098, -17551, -17178, -16860, -16484, -16024, -15383, -14659, -13925, -13203, -12426, -11669, -10836, -9888, -8995, -7860, -6662, -5315, -3796, -2261, -587};