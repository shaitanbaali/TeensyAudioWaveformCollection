/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0009 256 samples */
 
const int16_t AKWF_dbass_0009_256_DATA [256] = 
{1735, 5000, 8054, 10923, 13536, 16108, 18423, 20580, 22716, 24605, 26132, 27728, 28757, 29964, 31075, 32000, 32620, 32748, 32633, 32176, 31498, 30998, 30697, 30067, 29228, 28281, 27269, 26106, 25018, 23998, 22912, 22149, 21376, 20512, 19616, 18516, 17317, 16490, 15802, 15201, 14564, 13537, 12559, 11684, 10906, 10244, 9441, 8517, 7321, 6042, 4931, 4194, 3452, 2597, 1721, 605, -370, -1493, -2872, -4346, -5902, -7571, -8941, -10202, -11416, -12574, -13864, -15219, -16591, -18136, -19545, -20888, -22140, -23359, -24214, -24565, -24909, -25194, -25405, -25831, -25961, -25974, -25690, -24963, -24178, -22971, -21487, -19841, -17877, -15934, -14180, -12351, -10504, -8732, -7022, -5048, -3360, -2122, -749, 638, 2152, 3504, 4981, 6500, 7736, 8563, 9414, 10160, 10757, 11252, 11657, 11989, 12231, 12388, 12663, 12863, 12815, 12731, 12677, 12330, 12022, 11688, 11257, 10881, 10358, 9946, 9407, 8813, 8552, 8228, 8047, 7747, 7685, 7688, 7619, 7616, 7750, 7879, 8037, 8371, 8757, 9251, 9661, 10073, 10552, 10978, 11469, 12033, 12247, 12502, 12605, 12773, 12939, 13044, 13209, 13098, 12970, 13025, 13194, 13383, 13443, 13378, 13239, 12676, 11920, 10993, 9909, 8392, 7032, 5487, 3490, 1763, -42, -1884, -3582, -5337, -6741, -7987, -9106, -10358, -11139, -11723, -11532, -11594, -11179, -10300, -9871, -8587, -7339, -6447, -5418, -4231, -3075, -1728, -669, 529, 1780, 3325, 5306, 7223, 9067, 10391, 11419, 11700, 12223, 13282, 14423, 15888, 16331, 16554, 16809, 16732, 16593, 16379, 15689, 14360, 12924, 11713, 10423, 8898, 7149, 5649, 4080, 2401, 923, -963, -3166, -5277, -7009, -8412, -9908, -11188, -12487, -13956, -15620, -16711, -17578, -18585, -19670, -20614, -21193, -21551, -21787, -21718, -21504, -21413, -20821, -19780, -18281, -16460, -14311, -12190, -9760, -7199, -4371, -1403};