/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0016 256 samples */
 
const int16_t AKWF_dbass_0016_256_DATA [256] = 
{1419, 4103, 7626, 10999, 12215, 12416, 12527, 12967, 14737, 16455, 16632, 16334, 16599, 17250, 18285, 19592, 21908, 23576, 25490, 27780, 28669, 28530, 28398, 28714, 29173, 30490, 31458, 30815, 29816, 29947, 31082, 32512, 32732, 32532, 32033, 31594, 31530, 31264, 31211, 30972, 30554, 30390, 30356, 29409, 28080, 27222, 26951, 27423, 28368, 28770, 28334, 27774, 27373, 27707, 28275, 28164, 27305, 26092, 24784, 23756, 22725, 21258, 19564, 18315, 17803, 17378, 16494, 14957, 13911, 14298, 14891, 15064, 14740, 14220, 13697, 13198, 13040, 13766, 14859, 15794, 16276, 16416, 16147, 15169, 13936, 13052, 12525, 11966, 11218, 10492, 10322, 10911, 12329, 13959, 15393, 16712, 17790, 18530, 19099, 19541, 19636, 19446, 19400, 19416, 18798, 17668, 16157, 14306, 12539, 10920, 9375, 7942, 6618, 4980, 3525, 2448, 1709, 1098, 129, -815, -1654, -2642, -4040, -5502, -6624, -7922, -9336, -10681, -11826, -12833, -13403, -13373, -12945, -12019, -11332, -11024, -10494, -9862, -9430, -9284, -9489, -9970, -10733, -11699, -12741, -13810, -14691, -15286, -15941, -16627, -17107, -17833, -18478, -18811, -19255, -19488, -19367, -19289, -19256, -19492, -19846, -20087, -20744, -21744, -22692, -23605, -24767, -25699, -26050, -26108, -25596, -24360, -22640, -20506, -17955, -15157, -12299, -9547, -7170, -5257, -4110, -3511, -3375, -3787, -4613, -5916, -7396, -8949, -10522, -12314, -14051, -15755, -17232, -18624, -19762, -20633, -21174, -21457, -21415, -21174, -20871, -20446, -20168, -20365, -21190, -22404, -23946, -25769, -27614, -29209, -30208, -30526, -30319, -29806, -29205, -28436, -27518, -26368, -25483, -24889, -24344, -23655, -23014, -22463, -21984, -21665, -21375, -21353, -21723, -22205, -22781, -22944, -22234, -21642, -20772, -20981, -20622, -19546, -18563, -17243, -16107, -16143, -16188, -16820, -17127, -17402, -17255, -15737, -14080, -12446, -11284, -9146, -7376, -5882, -3510, -970};