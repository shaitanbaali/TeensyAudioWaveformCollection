/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0040 256 samples */
 
const int16_t AKWF_dbass_0040_256_DATA [256] = 
{162, 713, 1182, 1577, 2033, 2372, 2798, 3377, 3842, 4442, 5000, 5534, 6247, 6669, 6991, 7733, 8480, 8928, 9417, 9923, 10407, 11032, 11565, 11987, 12563, 13167, 13772, 14380, 14901, 15397, 16100, 16727, 17133, 17765, 18472, 19087, 19530, 20242, 20918, 21392, 21969, 22571, 23181, 23831, 24355, 24922, 25491, 25930, 26463, 27088, 27473, 27867, 28461, 28899, 29168, 29569, 30092, 30490, 30734, 30984, 31194, 31327, 31658, 31982, 32165, 32342, 32446, 32531, 32538, 32722, 32679, 32621, 32607, 32462, 32424, 32310, 32014, 31779, 31685, 31458, 31205, 30931, 30476, 30132, 29781, 29329, 29057, 28587, 28039, 27531, 26985, 26617, 26081, 25563, 24978, 24490, 23909, 23387, 22964, 22262, 21708, 21166, 20520, 19944, 19322, 18592, 17924, 17323, 16665, 15964, 15264, 14507, 13875, 13136, 12248, 11509, 10688, 9843, 9273, 8412, 7598, 7008, 6151, 5206, 4569, 3815, 2907, 2196, 1589, 816, 131, -494, -1327, -1931, -2567, -3307, -4073, -4795, -5481, -6098, -6741, -7473, -7993, -8604, -9271, -9939, -10514, -11032, -11548, -12027, -12716, -13301, -13853, -14303, -14734, -15257, -15744, -16124, -16427, -16811, -17271, -17652, -18017, -18438, -18696, -18821, -19165, -19482, -19824, -20118, -20315, -20562, -20862, -21013, -21083, -21315, -21392, -21641, -21749, -21699, -21910, -22085, -21992, -22075, -22150, -22163, -22080, -22254, -22415, -22256, -22257, -22268, -22359, -22425, -22474, -22504, -22468, -22558, -22703, -22509, -22430, -22438, -22431, -22473, -22469, -22462, -22463, -22340, -22420, -22278, -22094, -21892, -21644, -21475, -21314, -21044, -20750, -20592, -20244, -19943, -19566, -19258, -19090, -18570, -18173, -17886, -17250, -16665, -16314, -15925, -15462, -15024, -14494, -13752, -13286, -12810, -12248, -11832, -11212, -10436, -10077, -9460, -8643, -7938, -7350, -6861, -6269, -5523, -4850, -4172, -3708, -2843, -2205, -1602, -736, -186};