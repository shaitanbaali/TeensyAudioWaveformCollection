/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0036 256 samples */
 
const int16_t AKWF_dbass_0036_256_DATA [256] = 
{438, 1800, 3108, 4495, 5810, 7094, 8312, 9710, 11157, 12582, 14039, 15452, 16974, 18422, 19708, 21110, 22507, 23689, 24721, 25636, 26468, 27220, 27948, 28467, 29065, 29479, 29750, 29924, 30011, 30221, 30258, 30375, 30420, 30619, 30825, 30987, 31149, 31378, 31747, 32098, 32383, 32702, 32726, 32657, 32462, 32104, 31684, 31401, 30974, 30628, 30268, 29850, 29241, 28632, 27733, 26713, 25695, 24452, 23269, 21939, 20647, 19429, 18078, 16672, 15517, 14485, 13385, 12552, 11927, 11383, 10895, 10518, 10097, 9577, 9055, 8416, 7828, 7126, 6785, 6563, 6455, 6623, 6905, 7217, 7797, 8243, 8767, 9298, 9649, 9841, 10040, 10291, 10513, 10689, 10782, 10736, 10511, 9970, 9326, 8727, 8241, 7738, 7276, 6912, 6624, 6068, 5346, 4456, 3638, 3006, 2485, 1815, 1210, 827, 452, -81, -502, -1111, -2006, -2633, -3434, -4043, -4661, -4904, -5217, -5475, -5561, -5755, -6000, -6195, -6719, -7416, -7584, -8154, -8640, -8982, -9271, -9556, -9332, -9236, -9291, -9217, -9287, -9400, -9256, -8981, -8933, -8867, -8643, -8553, -8484, -8724, -8929, -9509, -9758, -10080, -10424, -10743, -10845, -11237, -11449, -11808, -11754, -11191, -10771, -10096, -9452, -8565, -7474, -6834, -6472, -6665, -7048, -7483, -7804, -8369, -8638, -8640, -8379, -7686, -7099, -6734, -6500, -6428, -6890, -7293, -7844, -8631, -9223, -9643, -10212, -10774, -11392, -12431, -13428, -14232, -15015, -15529, -15954, -16629, -17384, -17870, -18248, -18612, -18895, -19194, -19532, -19476, -19341, -19292, -19251, -19404, -19548, -19747, -19704, -19813, -19973, -20153, -19969, -19610, -19052, -18468, -17873, -17193, -16605, -16098, -15705, -15428, -15385, -15386, -15161, -15107, -14818, -14522, -14326, -14129, -13939, -13698, -13440, -13204, -12870, -12322, -11687, -11040, -10399, -9829, -9392, -8763, -8178, -7440, -6606, -5713, -4687, -3550, -2129, -751};