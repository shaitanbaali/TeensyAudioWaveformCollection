/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0032 256 samples */
 
const int16_t AKWF_dbass_0032_256_DATA [256] = 
{324, 1340, 2298, 3214, 4137, 5052, 5982, 6936, 7891, 8824, 9728, 10619, 11499, 12330, 13109, 13903, 14733, 15570, 16390, 17166, 17901, 18607, 19282, 19930, 20573, 21209, 21832, 22440, 23021, 23564, 24080, 24560, 24994, 25407, 25821, 26234, 26631, 27007, 27371, 27715, 28039, 28329, 28585, 28830, 29079, 29348, 29615, 29876, 30132, 30361, 30546, 30696, 30851, 31032, 31191, 31315, 31414, 31502, 31613, 31747, 31855, 31935, 32028, 32134, 32237, 32319, 32380, 32450, 32524, 32588, 32633, 32677, 32735, 32769, 32759, 32709, 32653, 32629, 32619, 32617, 32632, 32632, 32582, 32497, 32401, 32302, 32200, 32091, 32010, 31935, 31812, 31644, 31455, 31230, 30983, 30733, 30478, 30222, 29965, 29680, 29359, 29020, 28686, 28348, 27966, 27548, 27119, 26689, 26267, 25815, 25285, 24709, 24147, 23604, 23037, 22431, 21792, 21114, 20397, 19664, 18934, 18194, 17451, 16714, 15945, 15143, 14328, 13501, 12667, 11824, 10976, 10117, 9250, 8400, 7560, 6685, 5774, 4869, 3992, 3146, 2300, 1459, 630, -179, -978, -1782, -2573, -3338, -4095, -4827, -5510, -6158, -6795, -7432, -8049, -8683, -9324, -9926, -10483, -11019, -11530, -12012, -12464, -12859, -13209, -13543, -13861, -14147, -14404, -14651, -14898, -15145, -15398, -15641, -15828, -15963, -16082, -16185, -16283, -16367, -16427, -16477, -16514, -16540, -16598, -16683, -16761, -16828, -16875, -16895, -16903, -16921, -16941, -16953, -16949, -16917, -16872, -16840, -16825, -16805, -16773, -16726, -16691, -16692, -16691, -16667, -16636, -16609, -16589, -16573, -16538, -16505, -16484, -16456, -16421, -16384, -16349, -16285, -16191, -16079, -15955, -15837, -15719, -15583, -15419, -15231, -15027, -14824, -14623, -14413, -14153, -13829, -13473, -13128, -12780, -12420, -12070, -11713, -11325, -10896, -10420, -9901, -9366, -8812, -8232, -7641, -7045, -6408, -5733, -5046, -4334, -3592, -2831, -2077, -1329, -553};