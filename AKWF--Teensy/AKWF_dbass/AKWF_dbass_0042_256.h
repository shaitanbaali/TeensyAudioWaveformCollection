/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0042 256 samples */
 
const int16_t AKWF_dbass_0042_256_DATA [256] = 
{555, 1897, 3061, 4194, 5259, 6210, 6969, 7908, 8767, 9737, 10720, 11874, 12857, 14032, 15402, 16658, 18005, 19274, 20315, 21368, 22451, 23365, 24161, 24752, 25425, 25995, 26555, 27011, 27528, 27993, 28422, 28964, 29520, 30062, 30598, 31143, 31667, 32108, 32531, 32703, 32768, 32740, 32657, 32371, 32211, 31919, 31604, 31286, 30925, 30347, 29787, 29120, 28355, 27476, 26751, 25892, 24972, 24151, 23438, 22763, 22118, 21516, 20898, 20416, 19755, 19228, 18718, 18238, 17930, 17670, 17422, 17170, 16996, 16857, 16754, 16696, 16623, 16532, 16425, 16235, 15978, 15642, 15116, 14472, 13788, 13030, 12261, 11389, 10604, 9643, 8759, 8024, 7308, 6547, 5845, 4840, 3924, 2763, 1530, 390, -536, -1565, -2450, -3460, -4201, -5100, -6063, -6880, -7557, -8256, -8988, -9842, -10559, -11140, -11874, -12448, -12938, -13115, -12946, -12692, -12552, -12166, -11646, -11569, -11367, -11107, -10885, -10391, -9958, -9622, -9100, -8985, -8834, -8911, -9047, -9160, -9351, -9271, -9584, -9874, -9966, -9715, -9525, -9221, -8916, -8787, -8810, -8807, -9407, -10095, -10603, -11208, -11512, -11761, -11843, -11478, -11057, -10303, -9722, -9463, -9188, -9125, -9290, -9575, -9954, -10045, -10081, -10032, -9627, -9141, -8455, -7646, -7020, -6643, -6614, -6852, -7266, -7652, -8126, -8574, -8670, -8458, -7972, -7798, -7749, -7773, -7981, -8496, -9079, -9855, -10379, -10765, -11025, -10917, -10787, -10628, -10332, -10326, -10380, -10452, -10475, -10495, -10594, -10683, -10774, -10820, -10916, -11076, -11274, -11586, -11929, -12430, -13057, -13454, -13472, -13324, -12896, -12201, -11465, -10743, -10191, -9979, -10005, -10230, -10743, -11277, -11981, -12448, -12876, -13211, -13368, -13500, -13337, -13199, -13141, -13250, -13371, -13321, -13339, -13266, -13015, -12672, -12061, -11402, -10667, -9897, -9220, -8489, -7837, -7224, -6520, -5833, -4881, -3739, -2476, -1144};