/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0047 256 samples */
 
const int16_t AKWF_dbass_0047_256_DATA [256] = 
{1046, 1963, 2403, 4337, 6383, 6766, 7069, 7449, 8270, 8618, 9871, 10816, 10844, 10937, 11694, 11877, 11973, 11602, 10999, 11147, 11769, 11847, 12698, 12920, 12877, 13598, 13735, 13413, 13918, 15694, 16901, 16927, 17533, 17974, 18057, 18621, 19027, 18453, 17791, 17841, 17853, 17253, 16258, 15884, 16087, 16702, 16866, 17076, 17272, 16935, 16387, 16019, 16092, 16326, 16565, 16972, 17306, 17357, 17643, 18073, 18629, 18822, 19196, 20046, 21091, 21473, 21700, 22100, 22573, 23398, 24152, 24644, 25373, 26180, 26699, 26778, 26714, 26657, 26367, 26392, 26432, 26599, 27035, 27471, 27796, 27825, 27147, 26088, 25022, 23789, 22391, 20969, 19839, 19177, 18764, 18581, 18620, 18565, 18743, 19072, 19452, 20006, 20706, 21202, 21257, 20944, 20230, 19217, 17762, 15702, 13357, 11149, 8892, 6602, 4525, 2610, 1253, 412, 44, -7, 112, 624, 1283, 2081, 2623, 2664, 2430, 2024, 1294, 413, -622, -1724, -2682, -3247, -3569, -3925, -4374, -4876, -5520, -6247, -6973, -7610, -8176, -8476, -8537, -8519, -8409, -8372, -8410, -8314, -8177, -8235, -8227, -8327, -8528, -8892, -9284, -9525, -9628, -9679, -9849, -10101, -10479, -11165, -12050, -13083, -14252, -15339, -16327, -17293, -18214, -18884, -19228, -19192, -18987, -18705, -18356, -18179, -18174, -18383, -18855, -19543, -20289, -21004, -21715, -22478, -23511, -24615, -25789, -27090, -28395, -29741, -30956, -31948, -32605, -32778, -32610, -32264, -31769, -31068, -30378, -29763, -29391, -29279, -29345, -29443, -29468, -29488, -29404, -29046, -28451, -27696, -26902, -26204, -25583, -25152, -24877, -24681, -24572, -24447, -24317, -23994, -23458, -22746, -21928, -21006, -20153, -19405, -18639, -17888, -16909, -15709, -14309, -12872, -11532, -10297, -9236, -8364, -7690, -7088, -6545, -6109, -5823, -5469, -4599, -4266, -4172, -3722, -3356, -3302, -2811, -2160, -924, -321, -213, -253};