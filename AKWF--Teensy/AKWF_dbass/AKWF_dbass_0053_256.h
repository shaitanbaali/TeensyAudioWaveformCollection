/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0053 256 samples */
 
const int16_t AKWF_dbass_0053_256_DATA [256] = 
{946, 3088, 5159, 7113, 8887, 10682, 12444, 14110, 15711, 17151, 18384, 19595, 20679, 21717, 22747, 23592, 24424, 25161, 25814, 26379, 26994, 27691, 28326, 28939, 29388, 29716, 29982, 30199, 30410, 30666, 30874, 31177, 31518, 31804, 31991, 32078, 32126, 32176, 32266, 32413, 32581, 32685, 32752, 32644, 32329, 31866, 31137, 30238, 29103, 27727, 26208, 24584, 22792, 20931, 19070, 17146, 15219, 13292, 11291, 9487, 7834, 6266, 4871, 3538, 2214, 943, -414, -1692, -2800, -3716, -4452, -4956, -5278, -5414, -5398, -5260, -5000, -4773, -4524, -4296, -4074, -3842, -3530, -3093, -2687, -2204, -1699, -1290, -1002, -780, -607, -395, 25, 443, 850, 1233, 1445, 1697, 1896, 2000, 2089, 2123, 2213, 2298, 2339, 2445, 2387, 2211, 2192, 2127, 1667, 1036, 699, 400, 288, 381, 485, 836, 1141, 985, 1224, 1325, 783, 583, 287, -126, -516, -973, -1293, -1710, -2072, -2805, -3768, -4062, -4924, -5562, -5833, -6050, -6094, -5921, -6182, -6498, -7032, -7762, -8721, -9376, -9831, -10644, -11522, -12555, -13519, -14649, -15673, -16510, -16863, -16951, -17165, -17037, -16636, -15878, -14903, -13781, -12801, -11959, -11507, -11435, -11411, -11262, -11042, -10825, -10380, -9900, -9511, -9348, -9529, -9937, -10297, -10770, -11173, -11268, -11291, -11267, -11242, -11302, -11685, -12266, -12917, -13573, -13927, -14081, -14263, -14450, -14432, -14328, -14327, -14280, -14231, -14218, -14278, -14129, -13764, -13358, -12916, -12645, -12271, -11902, -11642, -11436, -11257, -10989, -10573, -10010, -9430, -8814, -8314, -8138, -7994, -7867, -7868, -8096, -8404, -8885, -9408, -9877, -10273, -10564, -10774, -11149, -11830, -12522, -13112, -13629, -14027, -14247, -14412, -14497, -14656, -14796, -14804, -14655, -14526, -14442, -14364, -14228, -13959, -13516, -12915, -12143, -11218, -10185, -9020, -7695, -6260, -4726, -3094, -1072};