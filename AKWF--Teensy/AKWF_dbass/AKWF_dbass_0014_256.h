/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0014 256 samples */
 
const int16_t AKWF_dbass_0014_256_DATA [256] = 
{882, 2122, 3362, 4733, 6077, 7120, 7653, 7954, 8091, 7908, 8012, 8387, 8670, 9153, 9893, 10223, 10192, 10386, 11370, 13116, 14625, 15559, 16309, 16887, 17667, 19034, 19961, 20075, 20344, 20535, 20873, 21289, 21644, 22292, 22944, 23326, 23768, 24339, 25107, 25770, 25935, 26026, 25882, 25720, 26086, 26520, 26323, 25523, 24777, 24282, 24233, 24058, 23751, 23549, 23008, 22335, 22011, 21817, 21578, 21614, 21962, 22184, 22151, 22295, 22615, 22874, 22878, 22633, 22295, 22075, 22148, 22511, 22883, 22893, 22269, 21335, 20491, 19758, 19173, 18382, 17525, 16683, 15970, 15668, 15655, 15534, 15432, 15464, 15716, 16070, 16632, 17526, 18409, 18940, 19526, 20063, 20437, 20619, 20307, 19609, 18811, 17929, 16829, 15894, 14802, 13748, 12768, 11814, 10929, 10236, 9736, 9393, 9246, 9494, 9770, 9799, 9790, 9653, 9338, 8860, 8096, 7124, 5879, 4335, 2835, 1164, -638, -2439, -4183, -5846, -7302, -8452, -9397, -10359, -11444, -12343, -12977, -13713, -14630, -15568, -16517, -17559, -18515, -19321, -20161, -21015, -21775, -22405, -23078, -23732, -24456, -25289, -26039, -26891, -27643, -28065, -28342, -28604, -28885, -29262, -29666, -30054, -30467, -30850, -31263, -31759, -32218, -32577, -32623, -32613, -32744, -32724, -32468, -32174, -31726, -31235, -30624, -29731, -28639, -27347, -26012, -24773, -23514, -22328, -21276, -20412, -19777, -19354, -19114, -18753, -18294, -17849, -17408, -16819, -16097, -15366, -14523, -13631, -12919, -12355, -11933, -11693, -11546, -11408, -11351, -11203, -10939, -10687, -10327, -9966, -9485, -8912, -8504, -8691, -8650, -8492, -8466, -8588, -8733, -9002, -9889, -10416, -10309, -9819, -9216, -9416, -10176, -10786, -10582, -9612, -9484, -9910, -10674, -11405, -10885, -10356, -9819, -9758, -10297, -10856, -10333, -8812, -7731, -7067, -7095, -7617, -7331, -6891, -6515, -6215, -6555, -6738, -5969, -4853, -2969, -698};