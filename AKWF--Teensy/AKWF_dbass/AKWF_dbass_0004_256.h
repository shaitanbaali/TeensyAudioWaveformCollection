/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0004 256 samples */
 
const int16_t AKWF_dbass_0004_256_DATA [256] = 
{508, 1390, 2254, 3150, 4024, 4857, 5667, 6444, 7194, 7876, 8570, 9252, 9887, 10658, 11450, 12267, 13086, 13942, 14779, 15619, 16483, 17286, 18066, 18795, 19557, 20345, 21171, 21981, 22742, 23504, 24207, 24875, 25503, 26110, 26675, 27254, 27829, 28418, 29012, 29648, 30210, 30729, 31196, 31571, 31849, 32041, 32266, 32454, 32607, 32664, 32757, 32693, 32676, 32590, 32458, 32308, 32220, 32247, 32217, 32264, 32041, 31691, 31430, 31436, 31337, 30780, 30516, 30468, 30081, 29579, 29234, 28835, 28384, 27737, 27261, 26882, 26529, 26065, 25387, 24847, 24434, 23757, 23156, 22681, 22203, 21661, 20927, 20372, 20124, 19703, 19073, 18360, 18237, 18240, 17836, 17170, 16799, 16435, 16122, 15673, 15196, 14845, 14283, 13709, 13283, 12784, 12268, 11776, 11274, 10587, 9890, 9433, 8968, 8319, 7914, 7161, 6175, 5426, 5013, 4558, 3843, 3253, 2889, 2415, 1715, 901, -53, -989, -1978, -2908, -3859, -4741, -5356, -5886, -6408, -6890, -7203, -7323, -7502, -7842, -8239, -8691, -9278, -9964, -10798, -11759, -12795, -13799, -14655, -15392, -16159, -16963, -17517, -17672, -17677, -17664, -17658, -17572, -17398, -17206, -17228, -17421, -17714, -18143, -18645, -19113, -19527, -20019, -20604, -21134, -21617, -21991, -22235, -22517, -22967, -23509, -24049, -24495, -24940, -25349, -25756, -26240, -26561, -26798, -26887, -26909, -26971, -27159, -27437, -27706, -28048, -28536, -29057, -29493, -29853, -30103, -30342, -30596, -30759, -30843, -30957, -31024, -31005, -30989, -30938, -30885, -30802, -30687, -30597, -30435, -30091, -29628, -29015, -28283, -27465, -26576, -25710, -24916, -24129, -23387, -22792, -22302, -21858, -21479, -21092, -20683, -20249, -19756, -19165, -18381, -17564, -16764, -15936, -15111, -14264, -13437, -12673, -11965, -11313, -10739, -10128, -9519, -8822, -8040, -7246, -6495, -5766, -5052, -4416, -3829, -3255, -2683, -2129, -1544, -915, -307};