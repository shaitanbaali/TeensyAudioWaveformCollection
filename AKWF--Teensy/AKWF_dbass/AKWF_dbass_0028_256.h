/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0028 256 samples */
 
const int16_t AKWF_dbass_0028_256_DATA [256] = 
{907, 2122, 3197, 4386, 5251, 5573, 5454, 5542, 6153, 7068, 8018, 8746, 9613, 10016, 10259, 10912, 12170, 13244, 14351, 15707, 17301, 18982, 20320, 21071, 21210, 20763, 19682, 18788, 18687, 19210, 20104, 21161, 22111, 22378, 21792, 20362, 18510, 17227, 16730, 16545, 16388, 16101, 15405, 14168, 12588, 11418, 10768, 10656, 11161, 11760, 12205, 12417, 12801, 13276, 13698, 13969, 14389, 14976, 15218, 15280, 15122, 14613, 13925, 13362, 13198, 13692, 14515, 15242, 15588, 15685, 15547, 15008, 14357, 13799, 13621, 13832, 14231, 14607, 14827, 14824, 14777, 14891, 15098, 15589, 16252, 17205, 18312, 19383, 20146, 20748, 21247, 21987, 22729, 23589, 24435, 25001, 25382, 25468, 25355, 24987, 24463, 24197, 23856, 23566, 23228, 23015, 22704, 22518, 22294, 22099, 21740, 21271, 21044, 21014, 21064, 21207, 21244, 21051, 20856, 20825, 20744, 20635, 20418, 20192, 19747, 19368, 18932, 18459, 17887, 17259, 16477, 15481, 14390, 13383, 12381, 11572, 10931, 10181, 9340, 8467, 7534, 6317, 5198, 4350, 3548, 2929, 2358, 1783, 1287, 781, 411, 149, 51, -30, -213, -587, -1056, -1508, -2176, -2649, -3037, -3216, -3273, -3391, -3220, -3515, -4064, -4811, -5672, -6317, -6985, -7436, -7682, -8002, -8634, -9805, -11230, -12493, -13749, -14749, -15484, -15935, -16428, -16907, -17349, -17779, -18329, -19055, -19566, -20131, -20660, -21173, -21805, -22823, -23976, -25109, -26019, -26763, -27200, -27598, -27731, -27878, -28030, -28313, -28739, -29241, -29853, -30434, -30770, -31148, -31579, -31986, -32380, -32587, -32757, -32705, -32371, -31789, -30989, -30286, -29668, -29268, -29208, -29021, -28976, -28884, -28674, -27604, -26905, -26430, -25859, -24871, -23675, -22858, -22180, -21182, -19802, -18664, -18282, -16736, -14911, -14221, -13324, -11610, -10565, -10567, -10267, -8953, -7865, -7477, -6528, -5071, -4302, -3837, -2483, -648};