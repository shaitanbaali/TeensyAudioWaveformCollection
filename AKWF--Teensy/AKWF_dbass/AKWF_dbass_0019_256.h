/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0019 256 samples */
 
const int16_t AKWF_dbass_0019_256_DATA [256] = 
{729, 1908, 2943, 4176, 5683, 7337, 8810, 10224, 11857, 13379, 14873, 16482, 17915, 19048, 20081, 21399, 22554, 23685, 24750, 25658, 26548, 27386, 28154, 28977, 29738, 29942, 30050, 30143, 30292, 30393, 30638, 30961, 30997, 30871, 30967, 30844, 30844, 31069, 31306, 31686, 32140, 32562, 32802, 32300, 31615, 31074, 30613, 30002, 29795, 29584, 28821, 27728, 26496, 25064, 23427, 21735, 20468, 18755, 16739, 14652, 12548, 10143, 7840, 6179, 4613, 3029, 1644, 207, -1194, -2616, -3836, -4869, -6017, -7285, -8582, -9879, -11427, -12842, -13865, -14970, -16031, -16906, -17942, -19316, -20769, -22237, -23703, -25103, -26192, -26906, -27586, -28428, -29213, -29706, -30113, -30441, -30477, -30383, -30167, -29813, -29148, -28389, -27427, -26098, -24436, -22619, -20735, -18822, -16915, -15088, -13170, -11157, -9157, -7188, -5225, -3275, -1421, 275, 1878, 3255, 4464, 5631, 7165, 8803, 10511, 12191, 13755, 15119, 16492, 17795, 19070, 20304, 21473, 22778, 23965, 25038, 25947, 26657, 27252, 27799, 28509, 29203, 29798, 30134, 30314, 30268, 29893, 29443, 28937, 28346, 27613, 26790, 25946, 25107, 24122, 23254, 22378, 21427, 20378, 19291, 17950, 16523, 15143, 13908, 12827, 12030, 11382, 10642, 9886, 9088, 8103, 7207, 6338, 5593, 5007, 4488, 3927, 3179, 2163, 1130, 131, -703, -1396, -2062, -2786, -3546, -4287, -5150, -6104, -7076, -8036, -9030, -10241, -11448, -12782, -14113, -15338, -16389, -17311, -18100, -18737, -19484, -20307, -21217, -22138, -23027, -23828, -24578, -25230, -25921, -26692, -27414, -28034, -28516, -28896, -29118, -29269, -29465, -29678, -29991, -30448, -30889, -31127, -31241, -31231, -31017, -30694, -30242, -29690, -29063, -28339, -27466, -26571, -25557, -24521, -23439, -22390, -21308, -20118, -18945, -17769, -16616, -15567, -14544, -13566, -12447, -11250, -9828, -8321, -6877, -5386, -4075, -2876, -2079, -1442, -501};