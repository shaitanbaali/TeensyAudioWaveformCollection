/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_dbass_0057 256 samples */
 
const int16_t AKWF_dbass_0057_256_DATA [256] = 
{911, 2351, 3607, 4842, 6244, 7775, 9597, 11325, 12955, 14760, 16522, 18245, 20400, 22485, 24471, 26235, 27773, 29270, 30575, 31458, 32087, 32492, 32695, 32722, 32720, 32746, 32752, 32660, 32713, 32735, 32685, 32659, 32477, 31978, 31594, 31273, 30867, 30456, 29960, 29557, 29291, 29505, 30033, 30687, 31259, 31642, 31852, 31784, 31621, 31463, 31185, 30594, 29486, 27908, 25868, 23864, 21848, 19827, 17956, 16462, 15125, 13910, 12902, 11959, 11235, 10593, 9990, 9352, 8760, 8394, 8103, 7960, 7741, 7387, 6857, 6136, 5008, 3474, 1816, -117, -2136, -3959, -5482, -6784, -7829, -8827, -9792, -10901, -11859, -12746, -13664, -14329, -14769, -15087, -15132, -14865, -14817, -14732, -14818, -15026, -15659, -15867, -16073, -15882, -15329, -14437, -12866, -12291, -10766, -9141, -7660, -6037, -4144, -4278, -4803, -3804, -2864, -2417, -1878, -2171, -2499, -1412, -516, -515, 156, -83, 1089, 2683, 2424, 531, -1898, -3895, -4578, -3958, -2657, -2251, -1757, -415, -49, -677, -1592, -2204, -2653, -2990, -4141, -5626, -6963, -7471, -7566, -7616, -7625, -7843, -7257, -6927, -7098, -7891, -8417, -8421, -7531, -5555, -4018, -3386, -2318, -365, 1560, 3252, 4624, 6113, 6914, 6920, 6174, 4395, 2396, 1216, 572, -12, -356, -212, 114, 420, 592, 333, -309, -1225, -2605, -4456, -6592, -8754, -10827, -12724, -14285, -15592, -16948, -18601, -20694, -23075, -25571, -27853, -29684, -30750, -31069, -31026, -30476, -29635, -29031, -28805, -28690, -28455, -28084, -27317, -26300, -25651, -25406, -25399, -25383, -25273, -25060, -24550, -23685, -22622, -21392, -19914, -18233, -16541, -15057, -13616, -12057, -10285, -8355, -6560, -5500, -5187, -5581, -6457, -7777, -9349, -10690, -11892, -12729, -13313, -13698, -13673, -13010, -11815, -10352, -9088, -7941, -7306, -6973, -6689, -6388, -5950, -4904, -3632, -2124, -514};