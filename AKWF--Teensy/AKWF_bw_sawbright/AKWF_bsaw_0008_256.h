/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0008 256 samples */
 
const int16_t AKWF_bsaw_0008_256_DATA [256] = 
{19928, 29962, 20079, 20547, 20706, 18613, 16260, 14878, 14322, 14129, 13996, 13783, 13516, 13255, 13034, 12853, 12701, 12569, 12454, 12352, 12265, 12193, 12132, 12076, 12028, 11982, 11937, 11891, 11844, 11792, 11737, 11678, 11614, 11544, 11472, 11393, 11309, 11223, 11133, 11039, 10941, 10840, 10738, 10634, 10529, 10419, 10310, 10200, 10088, 9977, 9863, 9750, 9636, 9522, 9406, 9292, 9175, 9058, 8941, 8823, 8706, 8587, 8467, 8348, 8228, 8107, 7986, 7865, 7743, 7621, 7497, 7373, 7249, 7125, 7001, 6874, 6749, 6623, 6496, 6369, 6242, 6114, 5987, 5859, 5730, 5601, 5473, 5344, 5215, 5085, 4954, 4825, 4696, 4565, 4434, 4304, 4171, 4040, 3910, 3778, 3647, 3516, 3384, 3252, 3120, 2988, 2855, 2723, 2590, 2458, 2326, 2193, 2060, 1928, 1794, 1662, 1530, 1395, 1264, 1131, 997, 864, 731, 599, 465, 332, 197, 65, -66, -198, -333, -466, -600, -732, -865, -998, -1132, -1265, -1396, -1531, -1663, -1795, -1929, -2061, -2194, -2327, -2459, -2591, -2724, -2856, -2989, -3121, -3253, -3385, -3517, -3648, -3779, -3911, -4041, -4172, -4304, -4435, -4565, -4697, -4826, -4955, -5086, -5216, -5345, -5474, -5602, -5731, -5860, -5987, -6115, -6243, -6370, -6497, -6624, -6750, -6874, -7001, -7126, -7250, -7374, -7497, -7622, -7744, -7865, -7987, -8108, -8229, -8349, -8467, -8587, -8706, -8824, -8942, -9059, -9175, -9292, -9407, -9522, -9637, -9750, -9864, -9977, -10089, -10201, -10311, -10420, -10529, -10635, -10739, -10841, -10941, -11039, -11134, -11223, -11310, -11393, -11472, -11545, -11615, -11678, -11737, -11792, -11845, -11892, -11938, -11983, -12028, -12077, -12132, -12194, -12266, -12353, -12454, -12570, -12701, -12853, -13035, -13256, -13517, -13783, -13996, -14130, -14322, -14879, -16261, -18613, -20706, -20547, -20079, -29962, -19928};