/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0009 256 samples */
 
const int16_t AKWF_bsaw_0009_256_DATA [256] = 
{18729, 32334, 24550, 22954, 21224, 17531, 13674, 11124, 9999, 9821, 10079, 10404, 10646, 10781, 10831, 10813, 10748, 10657, 10552, 10454, 10367, 10302, 10252, 10214, 10185, 10160, 10134, 10105, 10069, 10027, 9980, 9928, 9868, 9804, 9736, 9664, 9587, 9509, 9427, 9342, 9256, 9166, 9077, 8986, 8893, 8800, 8707, 8611, 8515, 8420, 8324, 8228, 8130, 8034, 7937, 7838, 7740, 7642, 7543, 7444, 7343, 7242, 7143, 7041, 6939, 6837, 6735, 6632, 6528, 6425, 6320, 6216, 6111, 6005, 5900, 5795, 5687, 5580, 5474, 5368, 5259, 5152, 5044, 4936, 4828, 4719, 4611, 4502, 4392, 4284, 4173, 4065, 3955, 3844, 3734, 3624, 3513, 3404, 3293, 3183, 3072, 2960, 2849, 2738, 2627, 2516, 2405, 2293, 2181, 2070, 1958, 1847, 1735, 1623, 1511, 1399, 1288, 1175, 1063, 950, 839, 728, 615, 503, 391, 280, 167, 54, -55, -168, -281, -392, -504, -616, -729, -840, -951, -1064, -1176, -1289, -1400, -1512, -1624, -1736, -1847, -1959, -2071, -2182, -2294, -2406, -2517, -2628, -2739, -2850, -2961, -3073, -3183, -3294, -3405, -3514, -3625, -3735, -3845, -3955, -4066, -4174, -4285, -4393, -4503, -4612, -4720, -4829, -4937, -5045, -5153, -5260, -5369, -5475, -5581, -5688, -5796, -5901, -6005, -6112, -6217, -6321, -6426, -6529, -6633, -6736, -6837, -6939, -7042, -7144, -7243, -7344, -7445, -7543, -7642, -7741, -7839, -7937, -8035, -8131, -8228, -8325, -8421, -8516, -8611, -8708, -8801, -8894, -8987, -9078, -9167, -9256, -9342, -9427, -9510, -9588, -9664, -9737, -9805, -9869, -9928, -9981, -10028, -10069, -10105, -10135, -10161, -10186, -10214, -10253, -10302, -10368, -10454, -10553, -10657, -10749, -10814, -10831, -10782, -10647, -10405, -10080, -9821, -9999, -11125, -13674, -17531, -21224, -22955, -24550, -32334, -18729};