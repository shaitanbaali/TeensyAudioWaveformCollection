/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0005 256 samples */
 
const int16_t AKWF_bsaw_0005_256_DATA [256] = 
{22254, 31257, 26012, 25534, 25059, 24430, 23503, 22378, 21019, 19515, 17966, 16415, 14921, 13528, 12266, 11157, 10222, 9461, 8876, 8461, 8202, 8083, 8086, 8191, 8377, 8621, 8905, 9207, 9515, 9813, 10085, 10326, 10528, 10686, 10797, 10860, 10878, 10854, 10791, 10692, 10563, 10411, 10241, 10056, 9863, 9666, 9469, 9276, 9089, 8911, 8742, 8585, 8438, 8302, 8177, 8062, 7953, 7854, 7762, 7672, 7586, 7502, 7419, 7336, 7251, 7165, 7076, 6985, 6892, 6793, 6691, 6587, 6479, 6369, 6257, 6142, 6024, 5907, 5788, 5669, 5550, 5429, 5309, 5189, 5070, 4951, 4834, 4716, 4600, 4484, 4367, 4251, 4138, 4022, 3907, 3793, 3678, 3564, 3451, 3335, 3219, 3104, 2990, 2874, 2758, 2640, 2525, 2409, 2290, 2174, 2057, 1938, 1821, 1703, 1586, 1469, 1350, 1232, 1116, 998, 880, 762, 646, 529, 411, 293, 175, 58, -59, -176, -294, -412, -530, -647, -763, -881, -999, -1117, -1233, -1351, -1470, -1587, -1704, -1822, -1939, -2058, -2175, -2291, -2409, -2526, -2641, -2759, -2875, -2991, -3105, -3220, -3336, -3451, -3565, -3679, -3794, -3908, -4023, -4138, -4252, -4368, -4485, -4601, -4717, -4835, -4952, -5071, -5190, -5310, -5430, -5550, -5670, -5789, -5908, -6025, -6143, -6258, -6369, -6480, -6588, -6692, -6794, -6892, -6986, -7077, -7166, -7252, -7337, -7419, -7503, -7587, -7673, -7762, -7855, -7953, -8062, -8178, -8302, -8438, -8585, -8743, -8912, -9090, -9276, -9470, -9667, -9863, -10057, -10242, -10411, -10563, -10693, -10791, -10855, -10879, -10861, -10797, -10687, -10529, -10327, -10086, -9814, -9516, -9208, -8905, -8622, -8378, -8192, -8087, -8084, -8203, -8462, -8877, -9462, -10222, -11158, -12266, -13529, -14922, -16416, -17966, -19515, -21019, -22379, -23503, -24430, -25059, -25534, -26012, -31257, -22254};