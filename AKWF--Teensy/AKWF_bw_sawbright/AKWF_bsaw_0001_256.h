/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0001 256 samples */
 
const int16_t AKWF_bsaw_0001_256_DATA [256] = 
{23898, 32168, 29817, 30062, 29738, 29206, 28436, 27551, 26490, 25336, 24152, 22968, 21822, 20748, 19758, 18874, 18104, 17448, 16909, 16480, 16153, 15919, 15762, 15675, 15644, 15653, 15693, 15752, 15821, 15890, 15953, 16004, 16039, 16056, 16050, 16023, 15972, 15900, 15809, 15698, 15572, 15430, 15278, 15115, 14943, 14766, 14584, 14399, 14216, 14031, 13846, 13665, 13485, 13307, 13133, 12957, 12788, 12620, 12452, 12286, 12121, 11957, 11793, 11630, 11465, 11301, 11136, 10970, 10803, 10636, 10466, 10297, 10126, 9953, 9779, 9606, 9431, 9254, 9076, 8899, 8721, 8542, 8362, 8181, 8001, 7821, 7640, 7459, 7278, 7096, 6915, 6733, 6549, 6367, 6185, 6003, 5819, 5636, 5453, 5271, 5087, 4904, 4719, 4537, 4352, 4168, 3984, 3799, 3614, 3430, 3245, 3060, 2875, 2690, 2505, 2319, 2133, 1947, 1764, 1577, 1390, 1205, 1019, 834, 650, 463, 278, 93, -94, -279, -464, -651, -835, -1020, -1206, -1391, -1578, -1765, -1948, -2134, -2319, -2506, -2690, -2875, -3061, -3246, -3431, -3615, -3800, -3985, -4168, -4353, -4538, -4720, -4905, -5088, -5271, -5454, -5637, -5820, -6004, -6186, -6368, -6550, -6733, -6916, -7097, -7278, -7460, -7641, -7822, -8001, -8182, -8363, -8543, -8722, -8900, -9077, -9254, -9432, -9607, -9779, -9954, -10127, -10298, -10467, -10637, -10804, -10971, -11137, -11301, -11465, -11630, -11794, -11958, -12122, -12287, -12453, -12620, -12788, -12958, -13133, -13308, -13485, -13665, -13846, -14032, -14217, -14400, -14585, -14766, -14944, -15115, -15278, -15430, -15572, -15699, -15809, -15901, -15972, -16023, -16051, -16056, -16039, -16005, -15954, -15891, -15822, -15752, -15694, -15653, -15645, -15675, -15763, -15919, -16154, -16481, -16909, -17448, -18105, -18874, -19759, -20748, -21822, -22968, -24152, -25336, -26491, -27552, -28436, -29206, -29738, -30063, -29817, -32168, -23899};