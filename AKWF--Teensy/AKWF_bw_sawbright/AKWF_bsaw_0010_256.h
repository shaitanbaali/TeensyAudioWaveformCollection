/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0010 256 samples */
 
const int16_t AKWF_bsaw_0010_256_DATA [256] = 
{24645, 33515, 32240, 31467, 29970, 28293, 26600, 25047, 23582, 22253, 21074, 20033, 19121, 18332, 17654, 17077, 16596, 16195, 15865, 15600, 15387, 15218, 15087, 14983, 14901, 14834, 14777, 14724, 14673, 14620, 14562, 14501, 14430, 14352, 14267, 14174, 14071, 13964, 13848, 13726, 13601, 13468, 13334, 13196, 13055, 12911, 12766, 12620, 12474, 12326, 12179, 12029, 11882, 11734, 11585, 11437, 11289, 11141, 10992, 10844, 10696, 10546, 10396, 10247, 10097, 9947, 9795, 9644, 9493, 9342, 9189, 9035, 8882, 8727, 8572, 8419, 8262, 8107, 7950, 7794, 7637, 7480, 7323, 7166, 7006, 6848, 6690, 6532, 6373, 6213, 6054, 5895, 5735, 5575, 5415, 5254, 5095, 4933, 4774, 4613, 4451, 4291, 4130, 3969, 3807, 3646, 3485, 3323, 3161, 2999, 2837, 2675, 2514, 2351, 2189, 2027, 1865, 1702, 1541, 1378, 1216, 1054, 893, 730, 568, 406, 242, 81, -82, -243, -407, -569, -731, -894, -1055, -1217, -1379, -1542, -1703, -1866, -2028, -2190, -2352, -2515, -2676, -2838, -3000, -3162, -3324, -3486, -3646, -3808, -3970, -4130, -4291, -4451, -4614, -4775, -4934, -5096, -5254, -5416, -5576, -5736, -5895, -6055, -6213, -6373, -6533, -6691, -6849, -7007, -7167, -7324, -7480, -7637, -7794, -7950, -8108, -8263, -8420, -8573, -8727, -8882, -9036, -9189, -9342, -9494, -9645, -9796, -9947, -10098, -10247, -10397, -10547, -10697, -10845, -10993, -11142, -11290, -11438, -11586, -11735, -11882, -12030, -12180, -12326, -12475, -12621, -12767, -12912, -13055, -13197, -13335, -13469, -13601, -13727, -13848, -13964, -14071, -14174, -14268, -14353, -14431, -14502, -14562, -14621, -14674, -14725, -14778, -14835, -14902, -14983, -15088, -15219, -15387, -15601, -15865, -16195, -16597, -17078, -17654, -18332, -19121, -20033, -21075, -22253, -23583, -25048, -26600, -28293, -29970, -31467, -32240, -33515, -24645};