/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0003 256 samples */
 
const int16_t AKWF_bsaw_0003_256_DATA [256] = 
{23142, 30301, 23662, 22556, 21745, 21075, 20335, 19577, 18716, 17808, 16910, 16038, 15215, 14461, 13783, 13191, 12691, 12277, 11948, 11698, 11520, 11404, 11339, 11318, 11329, 11365, 11413, 11471, 11533, 11587, 11632, 11666, 11685, 11687, 11674, 11643, 11595, 11534, 11456, 11366, 11265, 11153, 11037, 10913, 10783, 10651, 10518, 10383, 10249, 10115, 9983, 9852, 9724, 9597, 9470, 9348, 9225, 9105, 8986, 8866, 8749, 8631, 8514, 8395, 8278, 8159, 8040, 7920, 7800, 7678, 7556, 7432, 7308, 7183, 7058, 6931, 6805, 6677, 6549, 6420, 6290, 6161, 6033, 5902, 5771, 5641, 5511, 5380, 5248, 5119, 4987, 4855, 4724, 4592, 4461, 4329, 4196, 4065, 3934, 3801, 3668, 3536, 3405, 3271, 3139, 3005, 2874, 2739, 2607, 2474, 2341, 2207, 2073, 1941, 1806, 1672, 1538, 1403, 1270, 1136, 1003, 869, 734, 600, 468, 335, 199, 66, -67, -200, -336, -469, -601, -735, -870, -1004, -1137, -1271, -1404, -1539, -1673, -1807, -1942, -2074, -2208, -2342, -2475, -2608, -2740, -2875, -3006, -3140, -3272, -3406, -3537, -3669, -3802, -3935, -4066, -4197, -4330, -4462, -4593, -4725, -4856, -4988, -5119, -5249, -5381, -5512, -5642, -5772, -5903, -6033, -6162, -6291, -6421, -6550, -6678, -6805, -6932, -7059, -7184, -7309, -7433, -7557, -7679, -7801, -7920, -8040, -8159, -8278, -8396, -8515, -8632, -8750, -8867, -8987, -9105, -9226, -9348, -9471, -9597, -9725, -9853, -9983, -10116, -10250, -10384, -10519, -10652, -10783, -10913, -11037, -11154, -11266, -11367, -11456, -11534, -11596, -11643, -11674, -11688, -11685, -11667, -11633, -11588, -11533, -11472, -11414, -11365, -11330, -11318, -11339, -11405, -11520, -11699, -11949, -12278, -12691, -13192, -13783, -14462, -15216, -16039, -16911, -17809, -18717, -19577, -20336, -21076, -21746, -22556, -23662, -30301, -23142};