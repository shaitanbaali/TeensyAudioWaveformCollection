/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0006 256 samples */
 
const int16_t AKWF_bsaw_0006_256_DATA [256] = 
{22859, 32049, 29049, 29316, 29092, 28582, 27716, 26611, 25235, 23688, 22064, 20419, 18812, 17297, 15902, 14660, 13591, 12700, 11991, 11460, 11092, 10876, 10793, 10820, 10940, 11127, 11365, 11630, 11907, 12182, 12439, 12670, 12867, 13021, 13133, 13199, 13220, 13200, 13140, 13042, 12914, 12761, 12587, 12398, 12196, 11988, 11778, 11565, 11360, 11160, 10967, 10782, 10607, 10443, 10287, 10140, 10000, 9868, 9742, 9622, 9504, 9387, 9273, 9160, 9045, 8930, 8813, 8692, 8571, 8446, 8318, 8189, 8055, 7919, 7782, 7641, 7499, 7356, 7211, 7065, 6920, 6773, 6626, 6480, 6333, 6185, 6040, 5894, 5748, 5604, 5459, 5314, 5170, 5027, 4882, 4739, 4596, 4451, 4306, 4163, 4019, 3875, 3730, 3586, 3440, 3294, 3150, 3005, 2858, 2713, 2566, 2419, 2273, 2126, 1979, 1833, 1686, 1539, 1392, 1246, 1099, 951, 806, 660, 513, 366, 219, 72, -73, -220, -367, -514, -661, -807, -952, -1100, -1247, -1393, -1540, -1687, -1834, -1980, -2127, -2274, -2420, -2567, -2714, -2859, -3006, -3151, -3295, -3441, -3587, -3731, -3876, -4020, -4164, -4307, -4452, -4596, -4740, -4883, -5027, -5171, -5314, -5460, -5605, -5749, -5895, -6041, -6186, -6334, -6481, -6627, -6773, -6921, -7066, -7211, -7357, -7499, -7642, -7783, -7920, -8055, -8189, -8319, -8447, -8572, -8693, -8813, -8931, -9046, -9160, -9274, -9387, -9504, -9623, -9743, -9869, -10001, -10140, -10288, -10444, -10608, -10782, -10968, -11160, -11361, -11566, -11778, -11989, -12196, -12399, -12588, -12761, -12915, -13043, -13140, -13200, -13221, -13199, -13134, -13022, -12867, -12670, -12440, -12183, -11908, -11631, -11365, -11128, -10941, -10821, -10794, -10877, -11093, -11460, -11991, -12701, -13592, -14660, -15902, -17297, -18813, -20419, -22065, -23688, -25235, -26611, -27716, -28582, -29092, -29316, -29050, -32049, -22860};