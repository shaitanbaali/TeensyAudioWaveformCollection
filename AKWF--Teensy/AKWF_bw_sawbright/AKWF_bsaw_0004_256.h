/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0004 256 samples */
 
const int16_t AKWF_bsaw_0004_256_DATA [256] = 
{23028, 30037, 22732, 21466, 20648, 19994, 19276, 18546, 17715, 16843, 15985, 15154, 14375, 13662, 13025, 12471, 12005, 11621, 11317, 11089, 10928, 10824, 10771, 10757, 10773, 10810, 10861, 10918, 10975, 11028, 11070, 11103, 11119, 11121, 11106, 11075, 11027, 10967, 10892, 10805, 10708, 10602, 10488, 10369, 10246, 10121, 9994, 9866, 9737, 9610, 9484, 9360, 9239, 9118, 8998, 8881, 8766, 8651, 8538, 8425, 8313, 8202, 8090, 7979, 7866, 7754, 7640, 7525, 7413, 7297, 7180, 7062, 6944, 6826, 6707, 6587, 6465, 6344, 6223, 6100, 5977, 5854, 5732, 5608, 5483, 5360, 5236, 5111, 4986, 4862, 4739, 4614, 4489, 4363, 4239, 4113, 3987, 3863, 3738, 3612, 3485, 3360, 3234, 3109, 2982, 2855, 2729, 2603, 2476, 2351, 2224, 2096, 1969, 1843, 1715, 1588, 1462, 1335, 1206, 1080, 953, 826, 698, 571, 444, 317, 189, 62, -63, -190, -318, -445, -572, -699, -827, -954, -1081, -1207, -1336, -1463, -1589, -1716, -1844, -1970, -2097, -2225, -2351, -2477, -2604, -2730, -2856, -2983, -3110, -3235, -3361, -3486, -3613, -3739, -3864, -3988, -4114, -4240, -4364, -4489, -4615, -4740, -4863, -4987, -5112, -5237, -5360, -5484, -5609, -5733, -5855, -5978, -6101, -6224, -6344, -6466, -6587, -6708, -6826, -6945, -7063, -7180, -7297, -7414, -7526, -7641, -7754, -7866, -7980, -8091, -8202, -8314, -8425, -8539, -8651, -8767, -8882, -8999, -9119, -9240, -9361, -9485, -9611, -9737, -9867, -9994, -10121, -10247, -10369, -10489, -10603, -10709, -10805, -10893, -10968, -11028, -11075, -11107, -11122, -11120, -11104, -11071, -11028, -10976, -10919, -10862, -10810, -10773, -10757, -10771, -10825, -10928, -11090, -11318, -11621, -12006, -12472, -13026, -13663, -14375, -15155, -15985, -16843, -17716, -18546, -19277, -19994, -20648, -21467, -22732, -30037, -23028};