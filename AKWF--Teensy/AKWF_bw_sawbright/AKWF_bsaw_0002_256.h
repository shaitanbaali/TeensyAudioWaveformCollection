/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0002 256 samples */
 
const int16_t AKWF_bsaw_0002_256_DATA [256] = 
{23695, 31644, 28154, 27985, 27458, 26845, 26058, 25195, 24183, 23095, 21990, 20896, 19844, 18863, 17966, 17169, 16481, 15899, 15422, 15050, 14769, 14571, 14445, 14379, 14361, 14380, 14425, 14484, 14550, 14616, 14674, 14721, 14752, 14763, 14755, 14727, 14676, 14607, 14520, 14415, 14295, 14161, 14019, 13868, 13708, 13543, 13378, 13207, 13038, 12868, 12700, 12533, 12368, 12205, 12046, 11886, 11730, 11575, 11424, 11272, 11120, 10969, 10820, 10669, 10520, 10369, 10218, 10066, 9913, 9758, 9602, 9447, 9289, 9132, 8972, 8812, 8650, 8490, 8327, 8163, 8000, 7835, 7671, 7505, 7339, 7173, 7008, 6841, 6675, 6508, 6342, 6176, 6010, 5841, 5674, 5506, 5338, 5170, 5003, 4834, 4666, 4498, 4329, 4160, 3992, 3823, 3654, 3484, 3315, 3146, 2977, 2807, 2637, 2468, 2297, 2127, 1957, 1786, 1617, 1447, 1277, 1107, 936, 766, 596, 425, 254, 85, -86, -255, -426, -597, -767, -937, -1108, -1278, -1448, -1618, -1787, -1958, -2128, -2298, -2469, -2638, -2808, -2978, -3147, -3316, -3485, -3655, -3824, -3993, -4161, -4330, -4499, -4667, -4835, -5004, -5171, -5339, -5506, -5674, -5842, -6010, -6177, -6343, -6509, -6676, -6842, -7009, -7174, -7339, -7506, -7672, -7836, -8000, -8164, -8328, -8491, -8651, -8813, -8972, -9132, -9290, -9448, -9603, -9759, -9913, -10066, -10219, -10370, -10520, -10670, -10820, -10970, -11121, -11272, -11424, -11576, -11731, -11887, -12046, -12206, -12369, -12534, -12700, -12869, -13039, -13208, -13378, -13544, -13709, -13868, -14020, -14162, -14295, -14416, -14520, -14608, -14677, -14727, -14755, -14763, -14752, -14722, -14675, -14617, -14550, -14485, -14425, -14380, -14361, -14379, -14445, -14572, -14770, -15050, -15423, -15899, -16482, -17169, -17966, -18864, -19844, -20897, -21990, -23096, -24183, -25195, -26058, -26845, -27458, -27985, -28155, -31644, -23696};