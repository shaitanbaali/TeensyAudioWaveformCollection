/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bsaw_0007 256 samples */
 
const int16_t AKWF_bsaw_0007_256_DATA [256] = 
{21427, 33335, 29477, 26170, 23728, 22958, 22833, 22343, 21043, 19245, 17444, 15906, 14637, 13522, 12472, 11496, 10646, 9970, 9476, 9148, 8953, 8868, 8879, 8972, 9133, 9342, 9584, 9834, 10085, 10321, 10536, 10722, 10871, 10983, 11055, 11087, 11081, 11040, 10966, 10864, 10739, 10594, 10435, 10265, 10087, 9907, 9729, 9553, 9381, 9217, 9059, 8910, 8770, 8638, 8514, 8396, 8287, 8182, 8080, 7984, 7889, 7795, 7702, 7609, 7515, 7419, 7321, 7221, 7120, 7014, 6907, 6797, 6685, 6571, 6455, 6338, 6220, 6099, 5978, 5858, 5736, 5614, 5493, 5370, 5249, 5127, 5006, 4885, 4766, 4645, 4526, 4406, 4286, 4168, 4048, 3929, 3810, 3691, 3571, 3452, 3333, 3215, 3093, 2973, 2854, 2732, 2611, 2490, 2369, 2249, 2128, 2006, 1884, 1763, 1642, 1519, 1398, 1276, 1153, 1032, 911, 789, 667, 547, 426, 304, 181, 60, -61, -182, -305, -427, -548, -668, -790, -912, -1033, -1154, -1277, -1399, -1520, -1643, -1763, -1884, -2006, -2129, -2249, -2370, -2491, -2612, -2733, -2855, -2974, -3094, -3216, -3334, -3453, -3572, -3692, -3811, -3930, -4048, -4169, -4287, -4406, -4526, -4645, -4766, -4886, -5007, -5128, -5250, -5370, -5494, -5614, -5737, -5858, -5979, -6099, -6220, -6339, -6456, -6571, -6686, -6798, -6908, -7015, -7120, -7222, -7322, -7419, -7515, -7610, -7702, -7796, -7890, -7984, -8081, -8183, -8288, -8397, -8515, -8639, -8770, -8911, -9059, -9218, -9382, -9554, -9730, -9908, -10088, -10266, -10435, -10594, -10740, -10865, -10967, -11041, -11082, -11088, -11055, -10984, -10872, -10722, -10537, -10322, -10086, -9835, -9584, -9343, -9134, -8973, -8879, -8869, -8953, -9149, -9476, -9970, -10647, -11496, -12473, -13523, -14638, -15907, -17445, -19245, -21043, -22344, -22833, -22958, -23729, -26170, -29477, -33335, -21427};