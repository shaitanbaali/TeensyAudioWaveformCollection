/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0075 256 samples */
 
const int16_t AKWF_eorgan_0075_256_DATA [256] = 
{1849, 6649, 11115, 15290, 19097, 22494, 25445, 27910, 29880, 31344, 32293, 32737, 32684, 32160, 31194, 29828, 28136, 26246, 24258, 22234, 20214, 18253, 16428, 14797, 13397, 12245, 11355, 10737, 10388, 10297, 10445, 10804, 11326, 11907, 12479, 13006, 13454, 13801, 14026, 14114, 14049, 13816, 13426, 12851, 12026, 10981, 9727, 8290, 6728, 5154, 3652, 2258, 999, -95, -1008, -1732, -2255, -2576, -2694, -2613, -2345, -1899, -1297, -568, 252, 1072, 1840, 2529, 3110, 3572, 3903, 4093, 4143, 4050, 3822, 3464, 2991, 2421, 1780, 1101, 433, -103, -438, -548, -425, -11, 579, 1289, 2137, 3097, 4157, 5293, 6483, 7703, 8915, 10083, 11158, 12028, 12626, 12920, 12884, 12504, 11774, 10702, 9292, 7566, 5555, 3301, 889, -1621, -4192, -6764, -9255, -11535, -13506, -15121, -16348, -17154, -17521, -17443, -16916, -15946, -14542, -12728, -10536, -7995, -5170, -2113, 1106, 4219, 7120, 9756, 12057, 13989, 15521, 16622, 17285, 17499, 17265, 16589, 15486, 13985, 12113, 9917, 7472, 4906, 2323, -217, -2672, -4988, -7086, -8909, -10422, -11604, -12445, -12935, -13078, -12885, -12378, -11589, -10562, -9410, -8200, -6970, -5761, -4597, -3502, -2502, -1608, -847, -202, 285, 489, 456, 190, -286, -924, -1609, -2266, -2861, -3370, -3767, -4039, -4177, -4174, -4029, -3744, -3325, -2783, -2128, -1386, -581, 247, 1010, 1652, 2147, 2472, 2611, 2555, 2297, 1835, 1172, 317, -724, -1934, -3288, -4762, -6319, -7898, -9385, -10700, -11813, -12710, -13354, -13799, -14083, -14197, -14154, -13967, -13653, -13229, -12718, -12150, -11561, -10998, -10568, -10338, -10336, -10588, -11106, -11895, -12947, -14254, -15798, -17546, -19456, -21442, -23448, -25433, -27340, -29088, -30548, -31625, -32273, -32458, -32154, -31348, -30028, -28201, -25875, -23059, -19789, -16095, -12020, -7634, -2890};