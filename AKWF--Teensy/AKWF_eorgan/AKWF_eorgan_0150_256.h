/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0150 256 samples */
 
const int16_t AKWF_eorgan_0150_256_DATA [256] = 
{461, 1903, 3495, 5250, 7144, 9167, 11300, 13491, 15700, 17885, 20004, 22032, 23941, 25698, 27291, 28701, 29910, 30914, 31702, 32273, 32627, 32766, 32697, 32428, 31972, 31344, 30558, 29635, 28599, 27470, 26277, 25044, 23794, 22558, 21352, 20200, 19124, 18136, 17253, 16486, 15841, 15323, 14932, 14665, 14516, 14476, 14531, 14666, 14866, 15115, 15392, 15675, 15947, 16190, 16383, 16508, 16550, 16495, 16329, 16043, 15628, 15081, 14400, 13586, 12640, 11574, 10395, 9114, 7752, 6323, 4848, 3356, 1869, 414, -970, -2268, -3453, -4497, -5387, -6107, -6640, -6979, -7116, -7048, -6774, -6298, -5628, -4776, -3765, -2614, -1343, 20, 1446, 2896, 4329, 5718, 7037, 8252, 9345, 10297, 11087, 11704, 12137, 12376, 12418, 12260, 11906, 11356, 10620, 9709, 8631, 7404, 6048, 4577, 3019, 1400, -260, -1932, -3589, -5214, -6778, -8260, -9647, -10916, -12057, -13062, -13922, -14633, -15201, -15627, -15920, -16091, -16155, -16126, -16020, -15858, -15660, -15447, -15238, -15055, -14915, -14839, -14842, -14937, -15137, -15452, -15886, -16438, -17111, -17896, -18785, -19769, -20827, -21946, -23106, -24285, -25458, -26603, -27692, -28702, -29613, -30400, -31047, -31538, -31857, -31993, -31937, -31683, -31228, -30569, -29714, -28662, -27425, -26016, -24442, -22726, -20885, -18934, -16914, -14868, -12814, -10795, -8839, -6971, -5226, -3629, -2195, -947, 105, 955, 1596, 2027, 2254, 2281, 2116, 1773, 1270, 624, -139, -989, -1903, -2850, -3801, -4733, -5622, -6443, -7181, -7815, -8335, -8729, -8990, -9111, -9094, -8937, -8648, -8232, -7701, -7067, -6343, -5546, -4694, -3803, -2900, -1999, -1121, -287, 483, 1176, 1773, 2262, 2633, 2877, 2992, 2978, 2836, 2573, 2199, 1728, 1172, 552, -110, -798, -1484, -2142, -2751, -3285, -3722, -4044, -4232, -4269, -4143, -3843, -3359, -2687, -1828, -748};