/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0080 256 samples */
 
const int16_t AKWF_eorgan_0080_256_DATA [256] = 
{2294, 8151, 13487, 18250, 22279, 25497, 27873, 29432, 30263, 30494, 30275, 29776, 29172, 28605, 28196, 28009, 28060, 28329, 28776, 29350, 29998, 30674, 31300, 31830, 32248, 32550, 32728, 32762, 32631, 32322, 31819, 31105, 30168, 29034, 27715, 26225, 24600, 22889, 21160, 19518, 18063, 16879, 16036, 15530, 15299, 15314, 15502, 15778, 16049, 16219, 16206, 15947, 15412, 14603, 13594, 12493, 11411, 10461, 9741, 9321, 9236, 9485, 10029, 10799, 11702, 12582, 13339, 13889, 14180, 14199, 13966, 13539, 13001, 12467, 12045, 11842, 11949, 12391, 13147, 14154, 15333, 16590, 17822, 18931, 19832, 20510, 20826, 20732, 20289, 19559, 18632, 17615, 16582, 15583, 14659, 13826, 13090, 12479, 11988, 11597, 11288, 11046, 10848, 10685, 10528, 10377, 10228, 10039, 9735, 9274, 8596, 7650, 6395, 4797, 2863, 642, -1771, -4234, -6575, -8622, -10213, -11200, -11482, -11002, -9762, -7812, -5280, -2324, 851, 3914, 6625, 8809, 10319, 11082, 11074, 10334, 8947, 7045, 4789, 2344, -110, -2419, -4475, -6206, -7589, -8650, -9426, -9963, -10321, -10542, -10698, -10848, -10999, -11155, -11330, -11541, -11813, -12158, -12595, -13144, -13818, -14595, -15465, -16418, -17422, -18433, -19388, -20187, -20732, -20953, -20771, -20207, -19398, -18359, -17164, -15907, -14690, -13608, -12750, -12188, -11948, -12037, -12381, -12876, -13415, -13883, -14184, -14252, -14052, -13584, -12890, -12040, -11127, -10303, -9673, -9318, -9289, -9600, -10228, -11115, -12176, -13295, -14358, -15261, -15908, -16268, -16362, -16249, -15998, -15705, -15464, -15366, -15490, -15871, -16576, -17631, -18981, -20552, -22255, -23973, -25628, -27166, -28542, -29736, -30739, -31520, -32080, -32439, -32614, -32615, -32465, -32179, -31770, -31250, -30621, -29920, -29222, -28578, -28040, -27661, -27488, -27548, -27839, -28321, -28892, -29412, -29721, -29639, -29014, -27706, -25605, -22672, -18912, -14384, -9225, -3473};