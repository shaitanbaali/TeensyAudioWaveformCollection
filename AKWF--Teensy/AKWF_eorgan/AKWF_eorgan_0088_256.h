/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0088 256 samples */
 
const int16_t AKWF_eorgan_0088_256_DATA [256] = 
{1233, 3962, 6568, 9103, 11544, 13885, 16118, 18223, 20203, 22048, 23749, 25309, 26722, 27982, 29094, 30054, 30864, 31527, 32045, 32421, 32658, 32764, 32741, 32597, 32339, 31973, 31506, 30946, 30302, 29578, 28789, 27937, 27037, 26117, 25190, 24262, 23341, 22432, 21535, 20660, 19804, 18969, 18162, 17375, 16609, 15868, 15146, 14442, 13760, 13090, 12437, 11800, 11172, 10555, 9949, 9349, 8756, 8169, 7584, 7003, 6422, 5840, 5255, 4665, 4074, 3502, 2954, 2423, 1910, 1410, 923, 446, -23, -485, -946, -1404, -1865, -2328, -2800, -3280, -3773, -4281, -4809, -5356, -5930, -6523, -7146, -7809, -8504, -9231, -9994, -10788, -11610, -12459, -13329, -14215, -15107, -15979, -16816, -17614, -18360, -19050, -19676, -20230, -20707, -21096, -21396, -21596, -21694, -21683, -21557, -21313, -20949, -20460, -19845, -19105, -18235, -17239, -16119, -14873, -13510, -12034, -10446, -8758, -6979, -5108, -3168, -1163, 886, 2897, 4845, 6725, 8516, 10220, 11825, 13317, 14699, 15963, 17103, 18120, 19011, 19772, 20406, 20915, 21300, 21562, 21706, 21733, 21651, 21465, 21178, 20799, 20332, 19786, 19167, 18482, 17739, 16943, 16105, 15231, 14332, 13435, 12554, 11692, 10854, 10046, 9269, 8526, 7817, 7139, 6501, 5896, 5310, 4751, 4213, 3694, 3193, 2703, 2225, 1755, 1287, 823, 359, -109, -583, -1062, -1553, -2055, -2569, -3102, -3652, -4223, -4810, -5393, -5970, -6545, -7116, -7688, -8263, -8839, -9421, -10010, -10606, -11210, -11826, -12452, -13092, -13748, -14416, -15105, -15812, -16539, -17288, -18059, -18850, -19669, -20507, -21366, -22246, -23141, -24046, -24960, -25875, -26783, -27678, -28528, -29319, -30045, -30693, -31260, -31735, -32110, -32380, -32537, -32574, -32485, -32265, -31908, -31411, -30768, -29980, -29041, -27951, -26714, -25324, -23786, -22107, -20282, -18320, -16235, -14019, -11692, -9263, -6740, -4143, -1420};