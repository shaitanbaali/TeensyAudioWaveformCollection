/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0049 256 samples */
 
const int16_t AKWF_eorgan_0049_256_DATA [256] = 
{1018, 3432, 5977, 8527, 10987, 13250, 14944, 16021, 17390, 19287, 21432, 23649, 25782, 27737, 29466, 30871, 31685, 31803, 31282, 30242, 28773, 27030, 25248, 23568, 21984, 20401, 18614, 16342, 13713, 11161, 8628, 6057, 3559, 1338, -311, -1407, -2555, -3518, -4155, -4480, -4576, -4642, -4654, -4302, -3720, -3138, -2634, -2279, -2232, -2517, -3046, -3747, -4600, -5437, -5994, -6114, -5777, -5087, -4255, -3553, -2980, -2307, -1670, -1221, -971, -871, -860, -899, -963, -1036, -1102, -1156, -1212, -1282, -1376, -1541, -1820, -2206, -2626, -3112, -3839, -4858, -6078, -7357, -8610, -9664, -10348, -10564, -10352, -9887, -9422, -9277, -9385, -9433, -9551, -9874, -10378, -10964, -11515, -11924, -12127, -12109, -11900, -11568, -11226, -11097, -11117, -10903, -10583, -10392, -10387, -10633, -11323, -12479, -13965, -15580, -17084, -18155, -18528, -18037, -16691, -14615, -12073, -9459, -6798, -3844, -1411, 213, 2621, 5299, 8005, 10656, 13170, 15448, 17178, 18214, 19414, 21152, 23163, 25253, 27270, 29107, 30709, 31993, 32691, 32692, 32054, 30896, 29312, 27446, 25509, 23650, 21927, 20226, 18337, 16010, 13282, 10598, 7988, 5347, 2820, 635, -884, -2207, -3632, -4761, -5543, -5983, -6162, -6298, -6389, -6090, -5505, -4897, -4385, -4001, -3919, -4204, -4758, -5476, -6328, -7156, -7706, -7797, -7379, -6583, -5629, -4780, -4051, -3223, -2429, -1821, -1421, -1199, -1095, -1057, -1044, -1033, -1008, -975, -936, -902, -883, -898, -969, -1112, -1315, -1587, -2086, -2896, -3940, -5074, -6199, -7194, -7877, -8130, -7971, -7560, -7126, -6979, -7125, -7229, -7381, -7730, -8267, -8902, -9520, -10020, -10337, -10442, -10358, -10149, -9925, -9906, -10053, -10004, -9826, -9762, -9882, -10236, -11033, -12314, -13931, -15702, -17378, -18662, -19271, -19016, -17866, -15978, -13607, -11101, -8529, -5707, -2947, -773};