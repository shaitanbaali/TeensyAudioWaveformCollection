/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0143 256 samples */
 
const int16_t AKWF_eorgan_0143_256_DATA [256] = 
{1045, 3186, 5223, 7201, 9103, 10930, 12678, 14338, 15913, 17403, 18801, 20116, 21346, 22490, 23557, 24547, 25459, 26303, 27077, 27786, 28436, 29026, 29561, 30044, 30477, 30862, 31202, 31498, 31752, 31965, 32137, 32272, 32370, 32429, 32453, 32441, 32394, 32312, 32197, 32050, 31874, 31665, 31429, 31167, 30878, 30566, 30232, 29878, 29505, 29114, 28707, 28287, 27851, 27404, 26945, 26475, 25997, 25513, 25020, 24520, 24017, 23507, 22993, 22476, 21953, 21429, 20900, 20369, 19836, 19300, 18763, 18227, 17690, 17153, 16619, 16087, 15558, 15034, 14513, 13996, 13487, 12979, 12478, 11981, 11486, 10996, 10507, 10018, 9529, 9039, 8546, 8048, 7547, 7039, 6526, 6006, 5479, 4947, 4411, 3872, 3333, 2796, 2264, 1743, 1233, 741, 273, -167, -574, -941, -1267, -1545, -1776, -1954, -2080, -2152, -2170, -2134, -2046, -1908, -1726, -1506, -1249, -965, -659, -337, -7, 322, 644, 950, 1235, 1494, 1721, 1911, 2061, 2169, 2232, 2249, 2220, 2146, 2027, 1866, 1664, 1422, 1148, 841, 504, 143, -239, -640, -1055, -1481, -1915, -2355, -2801, -3249, -3699, -4152, -4604, -5059, -5514, -5970, -6429, -6892, -7358, -7828, -8303, -8782, -9267, -9757, -10252, -10753, -11259, -11768, -12282, -12800, -13320, -13843, -14369, -14897, -15429, -15963, -16498, -17036, -17574, -18112, -18653, -19192, -19731, -20272, -20812, -21350, -21888, -22425, -22961, -23494, -24024, -24551, -25074, -25590, -26099, -26600, -27090, -27569, -28035, -28484, -28918, -29334, -29729, -30105, -30458, -30788, -31096, -31378, -31636, -31869, -32075, -32256, -32410, -32538, -32638, -32710, -32754, -32768, -32751, -32701, -32616, -32495, -32334, -32130, -31879, -31579, -31226, -30814, -30340, -29798, -29183, -28495, -27725, -26869, -25930, -24894, -23765, -22541, -21216, -19793, -18272, -16655, -14951, -13164, -11294, -9356, -7356, -5302, -3211, -1042};