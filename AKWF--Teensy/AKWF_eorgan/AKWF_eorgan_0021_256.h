/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0021 256 samples */
 
const int16_t AKWF_eorgan_0021_256_DATA [256] = 
{509, 1398, 2331, 3300, 4293, 5387, 6514, 7645, 8808, 10000, 11230, 12480, 13728, 15005, 16264, 17506, 18737, 19924, 21086, 22211, 23305, 24341, 25320, 26250, 27122, 27939, 28694, 29393, 30037, 30611, 31120, 31555, 31930, 32234, 32476, 32643, 32740, 32769, 32734, 32617, 32443, 32200, 31887, 31515, 31076, 30587, 30034, 29423, 28766, 28055, 27295, 26500, 25655, 24770, 23858, 22903, 21919, 20901, 19845, 18793, 17711, 16616, 15500, 14365, 13248, 12111, 10993, 9857, 8748, 7642, 6552, 5478, 4419, 3388, 2368, 1381, 373, -581, -1538, -2458, -3373, -4278, -5163, -6044, -6921, -7768, -8620, -9466, -10300, -11118, -11949, -12761, -13555, -14354, -15148, -15938, -16721, -17488, -18242, -19005, -19739, -20476, -21194, -21898, -22581, -23249, -23894, -24514, -25100, -25663, -26184, -26677, -27113, -27526, -27872, -28180, -28436, -28630, -28770, -28843, -28864, -28819, -28723, -28544, -28288, -27968, -27602, -27161, -26663, -26106, -25470, -24784, -24055, -23212, -22314, -21393, -20423, -19406, -18335, -17225, -16097, -14922, -13750, -12575, -11392, -10236, -9087, -7956, -6837, -5759, -4717, -3709, -2738, -1803, -912, -59, 757, 1523, 2241, 2902, 3524, 4091, 4615, 5080, 5494, 5855, 6171, 6420, 6628, 6786, 6887, 6946, 6955, 6928, 6851, 6732, 6581, 6391, 6166, 5917, 5632, 5321, 4992, 4632, 4253, 3849, 3417, 2992, 2546, 2094, 1624, 1140, 681, 204, -250, -717, -1154, -1585, -1993, -2384, -2753, -3091, -3413, -3698, -3998, -4247, -4489, -4693, -4892, -5076, -5238, -5396, -5549, -5671, -5800, -5921, -6031, -6127, -6235, -6328, -6404, -6487, -6568, -6649, -6726, -6792, -6852, -6926, -6981, -7043, -7095, -7147, -7185, -7221, -7245, -7258, -7245, -7226, -7174, -7108, -6998, -6873, -6696, -6493, -6247, -5951, -5614, -5223, -4790, -4307, -3783, -3192, -2539, -1838, -1108, -301};