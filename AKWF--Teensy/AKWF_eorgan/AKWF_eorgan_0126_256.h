/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0126 256 samples */
 
const int16_t AKWF_eorgan_0126_256_DATA [256] = 
{444, 1358, 2429, 3675, 5089, 6669, 8407, 10277, 12261, 14328, 16431, 18543, 20625, 22629, 24531, 26293, 27881, 29277, 30458, 31402, 32105, 32557, 32756, 32711, 32429, 31927, 31224, 30347, 29317, 28159, 26901, 25566, 24173, 22749, 21311, 19867, 18439, 17031, 15645, 14290, 12958, 11643, 10344, 9044, 7734, 6410, 5053, 3655, 2214, 716, -837, -2445, -4111, -5826, -7578, -9363, -11154, -12932, -14680, -16368, -17969, -19467, -20830, -22043, -23089, -23950, -24618, -25086, -25352, -25418, -25291, -24988, -24526, -23929, -23228, -22453, -21636, -20812, -20007, -19250, -18570, -17984, -17514, -17174, -16971, -16913, -16996, -17220, -17570, -18029, -18581, -19204, -19871, -20561, -21247, -21910, -22529, -23083, -23558, -23941, -24223, -24395, -24459, -24416, -24270, -24028, -23706, -23314, -22865, -22377, -21862, -21334, -20807, -20288, -19787, -19308, -18852, -18418, -18003, -17598, -17188, -16759, -16291, -15764, -15159, -14454, -13633, -12679, -11576, -10319, -8901, -7313, -5566, -3662, -1610, 564, 2845, 5206, 7602, 10012, 12397, 14715, 16943, 19047, 20991, 22761, 24331, 25682, 26811, 27705, 28364, 28792, 28998, 28998, 28809, 28455, 27958, 27339, 26625, 25840, 25000, 24129, 23242, 22352, 21471, 20606, 19759, 18935, 18127, 17329, 16536, 15733, 14912, 14061, 13167, 12223, 11221, 10153, 9015, 7812, 6538, 5203, 3821, 2396, 952, -489, -1910, -3281, -4575, -5774, -6848, -7778, -8550, -9144, -9552, -9767, -9786, -9612, -9251, -8718, -8033, -7217, -6305, -5324, -4306, -3287, -2292, -1353, -497, 256, 889, 1382, 1731, 1928, 1972, 1867, 1625, 1262, 795, 247, -357, -1000, -1654, -2298, -2912, -3477, -3979, -4405, -4746, -4996, -5154, -5221, -5204, -5109, -4949, -4736, -4485, -4211, -3926, -3643, -3376, -3132, -2917, -2738, -2594, -2483, -2400, -2335, -2272, -2198, -2088, -1923, -1680, -1342, -888, -279};