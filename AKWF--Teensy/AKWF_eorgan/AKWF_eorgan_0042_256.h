/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0042 256 samples */
 
const int16_t AKWF_eorgan_0042_256_DATA [256] = 
{1068, 2879, 4413, 5673, 6830, 7773, 8473, 8888, 8882, 8703, 12383, 16536, 19395, 21258, 22138, 22126, 21344, 19929, 18005, 15717, 13190, 10590, 7950, 4935, 5189, -10411, -28765, -22475, -19451, -15841, -12459, -9355, -5811, -2250, 1135, 4150, 6631, 8538, 9836, 10085, 12859, -6636, -16303, -8604, -5027, -1558, 990, 2626, 3450, 3579, 3127, 2198, 736, -547, -1712, -3167, -1293, -15402, -31784, -23647, -19163, -14214, -9595, -5578, -2056, 820, 3089, 4735, 5788, 6323, 6376, 6000, 5363, 4049, -1602, -7539, -12188, -15859, -18469, -20023, -20583, -20280, -19235, -17620, -15576, -13723, -11957, -9982, -4806, -15371, -28900, -18146, -11110, -4031, 2153, 7351, 11899, 15696, 18583, 20597, 21760, 22147, 21865, 20549, 21807, 901, -10204, -4438, -1952, 776, 3196, 5235, 6834, 8010, 8761, 9037, 8815, 8806, 9245, 9234, 12261, -791, -16434, -7818, -3032, 1731, 5801, 9315, 12672, 15044, 16275, 16591, 15891, 14384, 12286, 9815, 6980, 4199, 5654, 7926, 9362, 10240, 10553, 10362, 9742, 8787, 7563, 6152, 4633, 3104, 1583, -329, 976, -13622, -31057, -23996, -20334, -16175, -12335, -8999, -6103, -3656, -1749, -365, 560, 1122, 1345, 827, 3098, -16617, -26694, -20527, -17084, -13260, -9410, -5695, -2269, 723, 3164, 5002, 6048, 6896, 7457, 7294, 10035, -3706, -20079, -12160, -8205, -4036, -333, 2645, 5075, 6821, 7991, 8595, 8698, 8380, 7686, 6688, 5545, 3780, -1827, -6916, -10340, -12454, -13449, -13509, -12813, -11537, -9825, -7776, -5523, -2757, 264, 2026, 6605, -5631, -21453, -13351, -9192, -5015, -1523, 1289, 3867, 6088, 7843, 9146, 10018, 10462, 10548, 9858, 11948, -7982, -18031, -11147, -7555, -3763, -350, 2613, 5038, 6927, 8255, 9003, 9176, 8793, 8241, 6885, 8300, -6334, -23396, -15960, -12028, -7900, -4186, -888};