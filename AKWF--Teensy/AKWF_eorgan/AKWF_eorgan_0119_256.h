/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0119 256 samples */
 
const int16_t AKWF_eorgan_0119_256_DATA [256] = 
{1257, 3976, 6535, 8997, 11344, 13580, 15698, 17689, 19559, 21305, 22920, 24412, 25778, 27013, 28128, 29117, 29982, 30728, 31354, 31862, 32255, 32536, 32705, 32767, 32724, 32581, 32338, 32001, 31575, 31061, 30467, 29796, 29054, 28258, 27415, 26530, 25610, 24658, 23680, 22682, 21663, 20629, 19589, 18541, 17493, 16452, 15415, 14387, 13371, 12364, 11369, 10391, 9421, 8465, 7522, 6588, 5664, 4750, 3838, 2931, 2026, 1114, 200, -722, -1639, -2502, -3306, -4058, -4758, -5415, -6030, -6608, -7155, -7671, -8162, -8632, -9084, -9519, -9943, -10357, -10764, -11167, -11566, -11963, -12364, -12754, -13150, -13568, -13991, -14421, -14859, -15303, -15749, -16195, -16637, -17074, -17499, -17896, -18260, -18585, -18867, -19104, -19291, -19423, -19499, -19516, -19470, -19358, -19179, -18930, -18608, -18212, -17740, -17189, -16560, -15849, -15056, -14179, -13222, -12178, -11051, -9842, -8549, -7176, -5724, -4192, -2590, -916, 805, 2481, 4086, 5622, 7078, 8457, 9758, 10973, 12107, 13158, 14123, 15006, 15808, 16526, 17163, 17722, 18200, 18604, 18933, 19191, 19376, 19494, 19547, 19535, 19465, 19336, 19153, 18921, 18640, 18317, 17955, 17557, 17130, 16688, 16239, 15786, 15333, 14881, 14434, 13994, 13562, 13135, 12724, 12328, 11920, 11512, 11103, 10691, 10277, 9855, 9422, 8980, 8520, 8044, 7547, 7023, 6473, 5892, 5272, 4614, 3913, 3161, 2357, 1495, 584, -330, -1234, -2134, -3027, -3921, -4819, -5719, -6628, -7548, -8474, -9415, -10370, -11334, -12315, -13306, -14307, -15323, -16346, -17374, -18410, -19448, -20478, -21504, -22515, -23507, -24481, -25429, -26345, -27228, -28069, -28866, -29610, -30287, -30889, -31411, -31845, -32192, -32445, -32600, -32654, -32604, -32447, -32179, -31799, -31305, -30692, -29960, -29110, -28133, -27034, -25813, -24459, -22981, -21378, -19646, -17788, -15809, -13701, -11477, -9137, -6684, -4131, -1420};