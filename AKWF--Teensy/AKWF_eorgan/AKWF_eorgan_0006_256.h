/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0006 256 samples */
 
const int16_t AKWF_eorgan_0006_256_DATA [256] = 
{406, 1179, 1936, 2700, 3456, 4206, 4948, 5679, 6402, 7116, 7820, 8515, 9202, 9876, 10544, 11203, 11849, 12489, 13119, 13739, 14352, 14955, 15549, 16139, 16720, 17294, 17864, 18427, 18983, 19535, 20079, 20618, 21151, 21678, 22199, 22713, 23219, 23718, 24211, 24694, 25168, 25634, 26088, 26532, 26965, 27385, 27792, 28188, 28567, 28933, 29283, 29616, 29933, 30233, 30514, 30777, 31021, 31245, 31449, 31630, 31790, 31930, 32046, 32139, 32210, 32257, 32280, 32280, 32259, 32224, 32187, 32159, 32150, 32166, 32207, 32271, 32350, 32435, 32515, 32576, 32606, 32596, 32537, 32427, 32261, 32041, 31769, 31446, 31079, 30673, 30230, 29759, 29261, 28736, 28192, 27628, 27041, 26435, 25808, 25158, 24489, 23793, 23075, 22335, 21570, 20778, 19966, 19130, 18272, 17397, 16503, 15593, 14673, 13741, 12801, 11858, 10909, 9963, 9020, 8078, 7143, 6216, 5295, 4385, 3484, 2592, 1712, 843, -17, -881, -1755, -2626, -3488, -4343, -5190, -6026, -6854, -7672, -8477, -9273, -10059, -10831, -11594, -12345, -13084, -13812, -14528, -15231, -15925, -16609, -17278, -17941, -18594, -19236, -19869, -20493, -21106, -21710, -22305, -22887, -23460, -24022, -24572, -25111, -25636, -26149, -26648, -27132, -27602, -28056, -28492, -28913, -29315, -29697, -30060, -30403, -30724, -31025, -31305, -31559, -31791, -31999, -32183, -32343, -32479, -32588, -32672, -32731, -32762, -32767, -32747, -32701, -32629, -32532, -32410, -32263, -32092, -31898, -31682, -31451, -31222, -31007, -30820, -30671, -30561, -30489, -30448, -30426, -30408, -30382, -30333, -30248, -30115, -29930, -29689, -29390, -29035, -28632, -28182, -27695, -27176, -26628, -26060, -25474, -24871, -24257, -23629, -22986, -22331, -21660, -20972, -20269, -19547, -18806, -18047, -17268, -16469, -15655, -14824, -13977, -13121, -12252, -11376, -10498, -9614, -8732, -7854, -6980, -6114, -5258, -4411, -3575, -2751, -1940, -1145, -347};