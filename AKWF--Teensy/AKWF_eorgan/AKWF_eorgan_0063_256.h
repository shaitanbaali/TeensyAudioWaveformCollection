/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0063 256 samples */
 
const int16_t AKWF_eorgan_0063_256_DATA [256] = 
{1208, 4183, 6992, 9617, 11981, 14024, 15701, 16970, 17816, 18231, 18228, 17836, 17094, 16061, 14800, 13380, 11890, 10400, 8995, 7753, 6737, 6013, 5623, 5603, 5972, 6731, 7869, 9358, 11152, 13203, 15437, 17787, 20174, 22512, 24727, 26749, 28494, 29916, 30971, 31618, 31840, 31639, 31031, 30040, 28711, 27105, 25280, 23318, 21302, 19301, 17403, 15687, 14215, 13050, 12241, 11816, 11796, 12184, 12964, 14106, 15567, 17293, 19213, 21252, 23335, 25374, 27289, 29009, 30455, 31571, 32312, 32640, 32537, 32000, 31043, 29695, 27998, 26008, 23790, 21418, 18977, 16541, 14194, 12020, 10075, 8427, 7128, 6204, 5678, 5558, 5827, 6459, 7408, 8627, 10049, 11595, 13196, 14765, 16227, 17508, 18536, 19257, 19622, 19601, 19174, 18342, 17122, 15536, 13630, 11469, 9104, 6621, 4104, 1619, -743, -2904, -4807, -6384, -7588, -8388, -8768, -8722, -8270, -7439, -6275, -4830, -3177, -1391, 455, 2271, 3973, 5494, 6753, 7696, 8273, 8448, 8204, 7534, 6457, 4996, 3189, 1105, -1202, -3656, -6170, -8675, -11083, -13310, -15306, -16997, -18335, -19291, -19845, -19989, -19742, -19127, -18187, -16974, -15559, -14011, -12406, -10828, -9356, -8058, -7010, -6267, -5873, -5862, -6250, -7042, -8216, -9751, -11598, -13698, -15993, -18399, -20836, -23232, -25500, -27557, -29345, -30802, -31875, -32539, -32769, -32566, -31943, -30932, -29574, -27922, -26051, -24037, -21946, -19873, -17899, -16091, -14532, -13273, -12363, -11840, -11720, -12007, -12686, -13733, -15105, -16738, -18579, -20543, -22554, -24534, -26400, -28070, -29487, -30580, -31304, -31626, -31529, -31008, -30070, -28749, -27090, -25140, -22971, -20652, -18261, -15883, -13595, -11468, -9577, -7978, -6714, -5824, -5322, -5212, -5478, -6094, -7014, -8181, -9538, -10999, -12492, -13936, -15250, -16355, -17192, -17696, -17819, -17535, -16823, -15685, -14132, -12197, -9927, -7375, -4619, -1669};