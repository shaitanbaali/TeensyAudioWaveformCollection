/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0140 256 samples */
 
const int16_t AKWF_eorgan_0140_256_DATA [256] = 
{641, 2464, 4317, 6226, 8170, 10141, 12123, 14095, 16048, 17963, 19818, 21606, 23306, 24901, 26382, 27734, 28940, 29997, 30893, 31618, 32171, 32546, 32740, 32754, 32589, 32249, 31735, 31056, 30219, 29227, 28097, 26835, 25450, 23960, 22372, 20697, 18957, 17160, 15318, 13453, 11571, 9685, 7817, 5969, 4156, 2394, 684, -962, -2533, -4031, -5446, -6771, -8011, -9160, -10215, -11183, -12060, -12848, -13554, -14175, -14717, -15185, -15582, -15912, -16180, -16388, -16543, -16649, -16710, -16731, -16716, -16670, -16596, -16500, -16386, -16257, -16116, -15968, -15816, -15663, -15513, -15366, -15226, -15096, -14977, -14870, -14779, -14703, -14646, -14607, -14589, -14591, -14616, -14663, -14733, -14825, -14940, -15076, -15232, -15407, -15595, -15794, -16000, -16205, -16407, -16598, -16771, -16919, -17034, -17109, -17137, -17109, -17020, -16861, -16627, -16312, -15910, -15418, -14832, -14149, -13368, -12488, -11507, -10430, -9258, -7991, -6636, -5201, -3685, -2102, -459, 1239, 2972, 4735, 6515, 8292, 10060, 11803, 13499, 15143, 16718, 18206, 19602, 20891, 22059, 23102, 24012, 24778, 25400, 25873, 26194, 26365, 26387, 26261, 25993, 25589, 25053, 24393, 23620, 22741, 21765, 20705, 19571, 18372, 17125, 15839, 14526, 13201, 11873, 10552, 9255, 7986, 6756, 5577, 4453, 3389, 2394, 1469, 617, -157, -858, -1483, -2032, -2513, -2924, -3270, -3556, -3784, -3962, -4092, -4181, -4234, -4256, -4251, -4225, -4181, -4126, -4063, -3997, -3932, -3872, -3820, -3781, -3755, -3747, -3759, -3793, -3851, -3933, -4042, -4178, -4341, -4532, -4752, -4998, -5273, -5574, -5901, -6254, -6631, -7030, -7451, -7890, -8347, -8820, -9305, -9799, -10299, -10797, -11290, -11773, -12237, -12678, -13087, -13455, -13776, -14043, -14245, -14376, -14429, -14396, -14271, -14047, -13720, -13284, -12737, -12076, -11298, -10404, -9395, -8269, -7033, -5689, -4242, -2701, -1033};