/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0133 256 samples */
 
const int16_t AKWF_eorgan_0133_256_DATA [256] = 
{272, 890, 1635, 2536, 3600, 4840, 6258, 7840, 9582, 11462, 13446, 15511, 17617, 19715, 21774, 23749, 25594, 27283, 28778, 30053, 31094, 31885, 32423, 32712, 32759, 32579, 32191, 31617, 30880, 30004, 29013, 27931, 26772, 25562, 24309, 23025, 21723, 20404, 19072, 17735, 16389, 15035, 13679, 12315, 10946, 9577, 8203, 6828, 5457, 4086, 2718, 1359, 1, -1352, -2700, -4047, -5391, -6728, -8066, -9395, -10715, -12021, -13305, -14561, -15783, -16955, -18074, -19128, -20110, -21011, -21831, -22561, -23204, -23761, -24234, -24633, -24963, -25232, -25453, -25633, -25781, -25905, -26012, -26105, -26189, -26262, -26323, -26368, -26395, -26397, -26368, -26304, -26201, -26053, -25858, -25614, -25322, -24983, -24598, -24172, -23706, -23206, -22672, -22112, -21525, -20914, -20284, -19637, -18973, -18299, -17617, -16932, -16251, -15578, -14919, -14287, -13682, -13114, -12588, -12104, -11664, -11264, -10896, -10550, -10212, -9862, -9480, -9043, -8526, -7908, -7163, -6273, -5227, -4012, -2622, -1070, 641, 2494, 4453, 6498, 8593, 10690, 12759, 14758, 16643, 18389, 19960, 21329, 22488, 23420, 24123, 24603, 24868, 24934, 24819, 24547, 24144, 23629, 23030, 22370, 21664, 20934, 20191, 19445, 18708, 17982, 17267, 16572, 15890, 15223, 14572, 13932, 13302, 12685, 12076, 11477, 10887, 10304, 9727, 9158, 8589, 8021, 7452, 6875, 6290, 5694, 5085, 4465, 3834, 3194, 2550, 1910, 1275, 657, 64, -500, -1025, -1506, -1941, -2324, -2657, -2943, -3186, -3391, -3568, -3724, -3867, -4010, -4157, -4318, -4497, -4698, -4921, -5165, -5429, -5707, -5992, -6278, -6559, -6825, -7071, -7291, -7478, -7630, -7746, -7823, -7861, -7862, -7826, -7755, -7651, -7514, -7345, -7146, -6918, -6660, -6375, -6066, -5733, -5380, -5014, -4638, -4259, -3884, -3519, -3169, -2841, -2535, -2252, -1991, -1741, -1495, -1238, -954, -624, -210};