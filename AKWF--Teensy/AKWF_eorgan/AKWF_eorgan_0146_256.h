/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0146 256 samples */
 
const int16_t AKWF_eorgan_0146_256_DATA [256] = 
{255, 1064, 2206, 3701, 5544, 7717, 10178, 12849, 15641, 18450, 21166, 23715, 26014, 28000, 29647, 30936, 31864, 32456, 32735, 32736, 32490, 32031, 31385, 30573, 29617, 28538, 27347, 26073, 24746, 23401, 22087, 20858, 19764, 18864, 18198, 17794, 17666, 17801, 18169, 18715, 19376, 20075, 20737, 21290, 21676, 21850, 21791, 21487, 20950, 20203, 19278, 18216, 17045, 15805, 14525, 13219, 11912, 10617, 9345, 8117, 6958, 5893, 4968, 4224, 3704, 3450, 3497, 3861, 4537, 5504, 6720, 8117, 9622, 11150, 12614, 13943, 15072, 15948, 16549, 16864, 16897, 16669, 16212, 15559, 14741, 13790, 12734, 11586, 10369, 9093, 7767, 6413, 5054, 3713, 2433, 1256, 220, -623, -1241, -1619, -1747, -1644, -1346, -912, -405, 94, 510, 777, 833, 640, 173, -571, -1573, -2811, -4244, -5825, -7519, -9277, -11060, -12847, -14603, -16301, -17929, -19456, -20857, -22103, -23150, -23961, -24493, -24707, -24574, -24078, -23225, -22033, -20546, -18839, -16992, -15102, -13274, -11585, -10114, -8919, -8030, -7470, -7233, -7302, -7653, -8247, -9056, -10043, -11180, -12448, -13815, -15261, -16767, -18301, -19831, -21323, -22724, -23987, -25063, -25896, -26454, -26707, -26647, -26281, -25642, -24783, -23764, -22663, -21558, -20523, -19617, -18892, -18373, -18070, -17973, -18060, -18299, -18653, -19090, -19574, -20081, -20592, -21092, -21564, -22002, -22388, -22700, -22916, -22999, -22912, -22612, -22065, -21238, -20113, -18691, -16985, -15032, -12895, -10639, -8348, -6117, -4016, -2117, -484, 858, 1896, 2629, 3084, 3289, 3282, 3100, 2775, 2338, 1808, 1206, 547, -156, -882, -1605, -2302, -2929, -3444, -3804, -3966, -3896, -3574, -2994, -2169, -1135, 56, 1339, 2636, 3867, 4963, 5863, 6522, 6921, 7054, 6938, 6606, 6098, 5463, 4740, 3976, 3205, 2452, 1743, 1097, 530, 63, -278, -468, -471, -229};