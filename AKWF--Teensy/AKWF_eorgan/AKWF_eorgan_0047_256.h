/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0047 256 samples */
 
const int16_t AKWF_eorgan_0047_256_DATA [256] = 
{841, 2721, 5077, 7314, 9476, 11544, 13509, 15388, 17176, 18869, 20461, 21950, 23345, 24648, 25778, 27300, 26277, 23801, 25121, 25871, 26588, 27190, 27659, 28083, 28454, 28735, 28922, 29025, 29058, 29028, 28873, 29050, 26927, 23347, 23491, 23114, 22703, 22142, 21551, 20924, 20305, 19670, 18969, 18171, 17320, 16483, 15573, 15116, 12373, 8020, 7713, 7052, 6425, 5792, 5159, 4521, 3879, 3236, 2589, 1939, 1297, 646, -8, -672, -1329, -2542, -4145, -5599, -6942, -8182, -9338, -10411, -11422, -12366, -13231, -14014, -14721, -15342, -15949, -16041, -18091, -22001, -21905, -22136, -22311, -22450, -22554, -22549, -22454, -22296, -22093, -21844, -21553, -21223, -20902, -20206, -21180, -24274, -23465, -22809, -22113, -21394, -20661, -19925, -19169, -18406, -17649, -16923, -16173, -15371, -14600, -13527, -13957, -17044, -15925, -14849, -13795, -12744, -11715, -10707, -9732, -8785, -7937, -7120, -6283, -5426, -4519, -3639, -2855, -1584, 197, 1892, 3572, 5220, 6827, 8385, 9885, 11334, 12730, 14068, 15351, 16575, 17673, 19094, 18748, 15784, 16964, 17889, 18745, 19516, 20175, 20808, 21424, 22026, 22608, 23158, 23663, 24110, 24457, 25043, 24157, 20541, 21160, 21436, 21729, 22041, 22257, 22386, 22383, 22265, 22083, 21814, 21530, 21254, 20897, 20832, 19232, 14887, 14683, 14397, 14038, 13645, 13204, 12720, 12191, 11625, 11017, 10374, 9693, 8978, 8236, 7458, 6664, 5279, 3451, 1715, 0, -1695, -3349, -4941, -6463, -7924, -9331, -10684, -11990, -13249, -14524, -15331, -18254, -23044, -23614, -24400, -25076, -25714, -26345, -26894, -27333, -27677, -27924, -28078, -28142, -28128, -28091, -27605, -29053, -32214, -31245, -30738, -30097, -29408, -28667, -27888, -27070, -26221, -25353, -24479, -23559, -22547, -21524, -19983, -20536, -22747, -20973, -19484, -17940, -16382, -14798, -13194, -11576, -9959, -8256, -6558, -4922, -3356, -1903, -460};