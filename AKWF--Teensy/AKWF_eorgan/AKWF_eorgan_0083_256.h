/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0083 256 samples */
 
const int16_t AKWF_eorgan_0083_256_DATA [256] = 
{2309, 8480, 14034, 18991, 23237, 26716, 29403, 31285, 32395, 32769, 32460, 31527, 30034, 28070, 25739, 23127, 20355, 17706, 15346, 13307, 11602, 10248, 9266, 8663, 8440, 8577, 9045, 9797, 10788, 11994, 13368, 14863, 16393, 17702, 18660, 19248, 19460, 19323, 18881, 18216, 17413, 16528, 15611, 14665, 13651, 12582, 11445, 10232, 8979, 7907, 7112, 6555, 6192, 5972, 5874, 5898, 6051, 6357, 6841, 7529, 8440, 9590, 10969, 12570, 14329, 15987, 17425, 18632, 19595, 20324, 20840, 21162, 21319, 21335, 21224, 20988, 20613, 20064, 19289, 18241, 16948, 15629, 14385, 13201, 12061, 10982, 9919, 8858, 7850, 6935, 6186, 5698, 5523, 5697, 6221, 7084, 8215, 9362, 10381, 11226, 11847, 12214, 12288, 12033, 11398, 10364, 8928, 7088, 4866, 2284, -654, -3919, -7411, -10853, -14061, -16961, -19458, -21446, -22856, -23627, -23705, -23041, -21603, -19387, -16410, -12705, -8374, -3521, 1669, 6666, 11185, 15115, 18341, 20819, 22520, 23438, 23604, 23054, 21844, 20031, 17682, 14888, 11749, 8354, 4825, 1446, -1619, -4335, -6693, -8673, -10253, -11429, -12198, -12579, -12605, -12321, -11771, -10983, -10002, -8875, -7689, -6702, -6044, -5735, -5779, -6152, -6812, -7676, -8659, -9711, -10775, -11852, -12986, -14162, -15396, -16695, -18024, -19162, -20015, -20622, -21028, -21285, -21414, -21417, -21285, -20997, -20526, -19848, -18945, -17799, -16419, -14818, -13055, -11391, -9945, -8726, -7749, -7001, -6465, -6118, -5932, -5882, -5955, -6146, -6470, -6962, -7673, -8648, -9859, -11084, -12226, -13296, -14308, -15249, -16159, -17048, -17870, -18580, -19105, -19352, -19263, -18808, -17979, -16790, -15308, -13788, -12372, -11105, -10037, -9198, -8624, -8355, -8438, -8896, -9730, -10939, -12502, -14402, -16633, -19160, -21892, -24546, -26942, -29007, -30642, -31746, -32250, -32093, -31220, -29588, -27159, -23937, -19935, -15198, -9828, -3791};