/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0136 256 samples */
 
const int16_t AKWF_eorgan_0136_256_DATA [256] = 
{716, 3006, 5332, 7719, 10130, 12545, 14936, 17266, 19518, 21665, 23673, 25530, 27209, 28688, 29959, 31004, 31810, 32375, 32694, 32765, 32592, 32181, 31543, 30686, 29629, 28389, 26980, 25426, 23750, 21969, 20111, 18199, 16248, 14289, 12338, 10409, 8530, 6707, 4953, 3287, 1710, 227, -1151, -2430, -3610, -4689, -5680, -6586, -7412, -8172, -8875, -9526, -10142, -10728, -11294, -11851, -12404, -12959, -13522, -14094, -14677, -15272, -15875, -16482, -17091, -17690, -18274, -18835, -19359, -19839, -20264, -20621, -20902, -21097, -21196, -21193, -21081, -20856, -20515, -20057, -19487, -18804, -18015, -17130, -16155, -15103, -13988, -12820, -11621, -10405, -9186, -7988, -6825, -5710, -4664, -3700, -2827, -2061, -1408, -874, -466, -184, -27, 7, -74, -263, -550, -921, -1362, -1855, -2386, -2935, -3482, -4010, -4499, -4931, -5291, -5562, -5728, -5782, -5711, -5508, -5169, -4694, -4083, -3339, -2471, -1487, -398, 778, 2030, 3338, 4679, 6036, 7389, 8711, 9987, 11197, 12316, 13333, 14229, 14988, 15602, 16060, 16356, 16488, 16453, 16255, 15899, 15393, 14748, 13975, 13092, 12113, 11056, 9944, 8795, 7626, 6462, 5323, 4222, 3183, 2220, 1344, 573, -86, -627, -1043, -1333, -1497, -1538, -1460, -1269, -980, -602, -148, 362, 920, 1505, 2101, 2694, 3267, 3803, 4292, 4719, 5074, 5349, 5536, 5631, 5630, 5534, 5343, 5061, 4695, 4251, 3737, 3166, 2547, 1890, 1212, 520, -169, -845, -1498, -2119, -2697, -3226, -3701, -4118, -4475, -4771, -5008, -5190, -5323, -5411, -5464, -5490, -5499, -5502, -5511, -5534, -5582, -5666, -5792, -5969, -6201, -6491, -6843, -7255, -7726, -8250, -8821, -9430, -10066, -10715, -11366, -12000, -12600, -13151, -13634, -14028, -14321, -14493, -14528, -14410, -14130, -13677, -13040, -12218, -11208, -10006, -8619, -7057, -5326, -3446, -1377};