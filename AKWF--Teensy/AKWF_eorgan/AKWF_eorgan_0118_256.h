/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0118 256 samples */
 
const int16_t AKWF_eorgan_0118_256_DATA [256] = 
{1310, 4262, 7033, 9695, 12224, 14619, 16875, 18977, 20931, 22733, 24378, 25870, 27211, 28396, 29432, 30322, 31066, 31670, 32137, 32472, 32681, 32767, 32735, 32592, 32344, 31996, 31549, 31014, 30392, 29687, 28907, 28054, 27130, 26151, 25118, 24032, 22902, 21726, 20509, 19254, 17958, 16626, 15264, 13884, 12511, 11158, 9819, 8500, 7203, 5925, 4668, 3436, 2223, 1036, -127, -1260, -2356, -3414, -4438, -5422, -6368, -7278, -8145, -8970, -9748, -10451, -11074, -11618, -12080, -12460, -12757, -12973, -13109, -13163, -13138, -13036, -12860, -12611, -12291, -11907, -11464, -10963, -10412, -9818, -9190, -8494, -7812, -7194, -6611, -6077, -5593, -5167, -4799, -4489, -4241, -4054, -3922, -3841, -3803, -3803, -3839, -3903, -3990, -4096, -4213, -4335, -4458, -4572, -4673, -4754, -4810, -4838, -4833, -4791, -4710, -4590, -4427, -4224, -3977, -3690, -3365, -3003, -2606, -2180, -1728, -1253, -761, -258, 253, 755, 1245, 1721, 2174, 2604, 3005, 3371, 3702, 3997, 4249, 4460, 4629, 4756, 4843, 4890, 4900, 4876, 4822, 4743, 4642, 4526, 4400, 4272, 4149, 4035, 3937, 3862, 3814, 3799, 3823, 3887, 4001, 4170, 4399, 4688, 5037, 5447, 5912, 6430, 6997, 7602, 8263, 8964, 9596, 10190, 10746, 11251, 11702, 12093, 12421, 12680, 12867, 12980, 13016, 12973, 12849, 12645, 12359, 11990, 11541, 11009, 10396, 9704, 8938, 8122, 7267, 6369, 5435, 4461, 3447, 2400, 1314, 191, -961, -2139, -3342, -4563, -5810, -7078, -8364, -9673, -11000, -12343, -13706, -15078, -16434, -17763, -19054, -20307, -21524, -22696, -23823, -24908, -25941, -26919, -27844, -28701, -29485, -30195, -30824, -31369, -31823, -32183, -32443, -32598, -32644, -32574, -32383, -32067, -31620, -31035, -30314, -29447, -28432, -27273, -25956, -24486, -22867, -21088, -19157, -17078, -14844, -12470, -9959, -7315, -4557, -1624};