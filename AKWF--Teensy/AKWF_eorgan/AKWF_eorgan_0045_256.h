/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0045 256 samples */
 
const int16_t AKWF_eorgan_0045_256_DATA [256] = 
{478, 2189, 3917, 5564, 7903, 6323, 3435, 6029, 7905, 9795, 11597, 13305, 14919, 16464, 18034, 19453, 20622, 21576, 22435, 23211, 23855, 24277, 25379, 26921, 28221, 29370, 30346, 31157, 31796, 32274, 32589, 32746, 32754, 32624, 32353, 31836, 31942, 27901, 22840, 22866, 22054, 21245, 20315, 19262, 18200, 17094, 15904, 14678, 13434, 12162, 10853, 9423, 8571, 4740, -1910, -2316, -3576, -4809, -5955, -6936, -7852, -8801, -9758, -10681, -11590, -12399, -13060, -13738, -13606, -17242, -21920, -21118, -20927, -20593, -20209, -19768, -19282, -18769, -18224, -17654, -17067, -16461, -15841, -15226, -14617, -14026, -14303, -14965, -15358, -15611, -15758, -15820, -15779, -15630, -15381, -15036, -14605, -14093, -13491, -12836, -11308, -14056, -17733, -16076, -15126, -14023, -12962, -11981, -10944, -9867, -8768, -7661, -6568, -5471, -4386, -3411, -1857, -3328, -7508, -5538, -4379, -3136, -1929, -781, 315, 1363, 2343, 3253, 4055, 4832, 5605, 6181, 7484, 4511, 750, 2434, 3251, 4122, 4916, 5620, 6244, 6768, 7101, 7396, 7771, 8181, 8495, 8706, 8859, 8929, 9847, 11325, 12659, 13936, 15144, 16267, 17304, 18256, 19114, 19873, 20540, 21114, 21595, 21856, 22817, 19347, 15197, 16190, 16251, 16330, 16281, 16103, 15927, 15785, 15657, 15502, 15294, 15040, 14759, 14371, 14545, 11670, 6253, 6828, 6697, 6758, 6676, 6397, 6032, 5662, 5272, 4806, 4204, 3573, 2976, 2249, 2306, -1973, -6940, -6424, -6754, -6976, -7206, -7456, -7709, -7973, -8248, -8527, -8808, -9087, -9368, -9656, -9948, -10257, -11439, -13008, -14412, -15743, -16953, -18031, -18990, -19853, -20620, -21281, -21845, -22326, -22716, -23243, -22919, -26694, -30763, -29607, -29262, -28714, -28086, -27394, -26527, -25522, -24397, -23165, -21839, -20430, -18950, -17491, -15393, -16285, -19524, -16893, -14959, -12914, -10875, -8851, -6871, -4928, -3032, -1175};