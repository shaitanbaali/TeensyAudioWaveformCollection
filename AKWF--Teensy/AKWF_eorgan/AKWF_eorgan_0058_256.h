/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0058 256 samples */
 
const int16_t AKWF_eorgan_0058_256_DATA [256] = 
{1410, 4890, 8244, 11511, 14642, 17609, 20376, 22907, 25184, 27185, 28887, 30288, 31375, 32146, 32609, 32768, 32638, 32235, 31580, 30699, 29614, 28359, 26965, 25459, 23878, 22254, 20611, 18988, 17408, 15893, 14472, 13158, 11966, 10912, 9999, 9231, 8609, 8130, 7782, 7560, 7448, 7425, 7495, 7631, 7779, 7946, 8110, 8252, 8352, 8396, 8370, 8262, 8063, 7768, 7376, 6885, 6301, 5631, 4884, 4075, 3219, 2329, 1429, 538, -326, -1140, -1885, -2542, -3092, -3521, -3813, -3958, -3950, -3784, -3459, -2975, -2341, -1569, -666, 347, 1448, 2623, 3845, 5085, 6317, 7566, 8731, 9784, 10731, 11541, 12199, 12682, 12977, 13075, 12965, 12646, 12119, 11389, 10466, 9361, 8097, 6690, 5162, 3548, 1869, 158, -1550, -3230, -4848, -6367, -7769, -9022, -10098, -10982, -11654, -12101, -12315, -12291, -12028, -11532, -10813, -9885, -8762, -7471, -6036, -4481, -2842, -1145, 600, 2306, 3964, 5547, 7019, 8354, 9526, 10510, 11291, 11850, 12178, 12270, 12122, 11740, 11129, 10300, 9275, 8068, 6704, 5212, 3615, 1946, 242, -1477, -3172, -4810, -6371, -7816, -9127, -10284, -11262, -12051, -12639, -13020, -13189, -13152, -12912, -12481, -11871, -11101, -10187, -9161, -8014, -6777, -5548, -4302, -3067, -1872, -742, 304, 1245, 2060, 2740, 3272, 3648, 3864, 3921, 3822, 3572, 3183, 2668, 2040, 1319, 522, -332, -1219, -2122, -3020, -3891, -4720, -5491, -6188, -6803, -7326, -7752, -8079, -8310, -8447, -8500, -8478, -8394, -8264, -8105, -7937, -7780, -7629, -7537, -7531, -7609, -7791, -8094, -8525, -9094, -9808, -10667, -11668, -12807, -14071, -15447, -16921, -18466, -20063, -21686, -23299, -24877, -26391, -27801, -29082, -30201, -31124, -31831, -32293, -32487, -32396, -32008, -31313, -30303, -28980, -27354, -25426, -23219, -20752, -18041, -15124, -12033, -8797, -5464, -1995};