/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0015 256 samples */
 
const int16_t AKWF_eorgan_0015_256_DATA [256] = 
{847, 2110, 3327, 4521, 5689, 6830, 7946, 9031, 10090, 11120, 12118, 13089, 14030, 14939, 15818, 16668, 17486, 18275, 19032, 19758, 20457, 21124, 21761, 22370, 22949, 23500, 24022, 24518, 24984, 25427, 25842, 26230, 26595, 26936, 27253, 27547, 27819, 28070, 28301, 28511, 28702, 28875, 29031, 29169, 29293, 29400, 29493, 29572, 29638, 29693, 29735, 29766, 29787, 29799, 29802, 29796, 29783, 29761, 29734, 29700, 29659, 29614, 29563, 29507, 29447, 29382, 29313, 29239, 29163, 29081, 28997, 28909, 28816, 28719, 28619, 28515, 28405, 28291, 28172, 28047, 27918, 27781, 27638, 27488, 27330, 27165, 26990, 26807, 26615, 26411, 26196, 25970, 25732, 25481, 25216, 24936, 24641, 24331, 24004, 23661, 23299, 22920, 22520, 22101, 21662, 21200, 20719, 20214, 19686, 19138, 18563, 17963, 17342, 16693, 16019, 15322, 14597, 13845, 13070, 12266, 11436, 10582, 9699, 8790, 7857, 6896, 5912, 4902, 3865, 2807, 1724, 615, -511, -1661, -2834, -4025, -5237, -6469, -7703, -8911, -10086, -11227, -12338, -13415, -14458, -15470, -16448, -17391, -18303, -19183, -20027, -20841, -21622, -22370, -23088, -23773, -24427, -25053, -25648, -26212, -26748, -27256, -27737, -28191, -28618, -29019, -29396, -29748, -30076, -30383, -30665, -30928, -31170, -31391, -31593, -31778, -31944, -32092, -32224, -32340, -32441, -32528, -32599, -32658, -32704, -32737, -32758, -32767, -32765, -32752, -32729, -32696, -32653, -32599, -32537, -32464, -32383, -32292, -32193, -32084, -31966, -31838, -31702, -31556, -31399, -31233, -31057, -30870, -30673, -30463, -30243, -30011, -29766, -29508, -29237, -28952, -28653, -28339, -28009, -27663, -27301, -26921, -26524, -26109, -25674, -25220, -24747, -24252, -23735, -23198, -22638, -22055, -21450, -20818, -20166, -19486, -18781, -18053, -17297, -16514, -15707, -14872, -14010, -13123, -12206, -11263, -10295, -9297, -8273, -7224, -6145, -5041, -3912, -2757, -1580, -352};