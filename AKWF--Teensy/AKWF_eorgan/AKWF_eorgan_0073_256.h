/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0073 256 samples */
 
const int16_t AKWF_eorgan_0073_256_DATA [256] = 
{1187, 3865, 6430, 8934, 11357, 13689, 15920, 18033, 20029, 21899, 23630, 25225, 26676, 27974, 29124, 30118, 30955, 31635, 32156, 32517, 32721, 32767, 32657, 32394, 31981, 31423, 30721, 29885, 28920, 27832, 26634, 25330, 23935, 22491, 21012, 19507, 17992, 16472, 14955, 13457, 11978, 10527, 9118, 7755, 6463, 5252, 4120, 3076, 2126, 1269, 510, -147, -706, -1160, -1511, -1761, -1909, -1957, -1909, -1768, -1537, -1222, -831, -369, 155, 711, 1285, 1872, 2463, 3052, 3633, 4199, 4748, 5275, 5775, 6246, 6683, 7083, 7445, 7766, 8041, 8271, 8451, 8580, 8654, 8702, 8671, 8543, 8340, 8059, 7701, 7270, 6769, 6201, 5573, 4891, 4163, 3427, 2697, 1978, 1280, 606, -38, -644, -1213, -1740, -2217, -2648, -3029, -3357, -3630, -3850, -4015, -4122, -4175, -4172, -4113, -4001, -3836, -3618, -3352, -3039, -2681, -2282, -1847, -1378, -883, -365, 165, 686, 1186, 1661, 2104, 2512, 2879, 3202, 3478, 3707, 3883, 4007, 4077, 4092, 4051, 3954, 3802, 3594, 3331, 3015, 2646, 2225, 1757, 1241, 680, 82, -554, -1222, -1915, -2631, -3359, -4095, -4827, -5521, -6161, -6743, -7259, -7705, -8080, -8377, -8597, -8742, -8790, -8756, -8695, -8579, -8411, -8193, -7929, -7619, -7268, -6877, -6449, -5986, -5493, -4973, -4431, -3868, -3289, -2702, -2113, -1524, -946, -386, 149, 628, 1038, 1372, 1625, 1790, 1862, 1838, 1716, 1493, 1168, 741, 210, -420, -1152, -1983, -2907, -3925, -5032, -6220, -7489, -8831, -10223, -11658, -13123, -14609, -16115, -17626, -19133, -20632, -22108, -23551, -24951, -26265, -27478, -28582, -29564, -30418, -31140, -31720, -32155, -32441, -32575, -32553, -32374, -32039, -31543, -30888, -30078, -29108, -27984, -26711, -25285, -23713, -22005, -20157, -18182, -16088, -13874, -11560, -9153, -6660, -4104, -1436};