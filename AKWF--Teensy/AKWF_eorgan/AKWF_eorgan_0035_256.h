/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0035 256 samples */
 
const int16_t AKWF_eorgan_0035_256_DATA [256] = 
{772, 1652, 2227, 2776, 3284, 3703, 4042, 4316, 4534, 4708, 4844, 4956, 5052, 5142, 5238, 5348, 5481, 5648, 5852, 6102, 6405, 6765, 7178, 7630, 8105, 8598, 9088, 9610, 10232, 10990, 11893, 12943, 14068, 15172, 16218, 17182, 18019, 18719, 19269, 19643, 19832, 19842, 19685, 19380, 18948, 18418, 17812, 17169, 16513, 15870, 15267, 14717, 14233, 13825, 13503, 13265, 13120, 13069, 13112, 13248, 13476, 13795, 14201, 14691, 15258, 15889, 16579, 17314, 18088, 18889, 19706, 20527, 21344, 22149, 22939, 23707, 24443, 25138, 25785, 26383, 26915, 27376, 27752, 28034, 28216, 28287, 28243, 28079, 27795, 27390, 26869, 26239, 25511, 24698, 23812, 22864, 21873, 20857, 19830, 18813, 17813, 16848, 15927, 15064, 14268, 13546, 12901, 12336, 11858, 11469, 11168, 10949, 10811, 10747, 10749, 10808, 10913, 11058, 11231, 11423, 11618, 11803, 11970, 12106, 12199, 12237, 12208, 12102, 11911, 11626, 11239, 10752, 10155, 9453, 8653, 7764, 6798, 5765, 4681, 3564, 2433, 1316, 231, -812, -1788, -2691, -3503, -4218, -4835, -5357, -5783, -6118, -6371, -6548, -6655, -6704, -6699, -6646, -6555, -6439, -6312, -6199, -6123, -6105, -6172, -6336, -6579, -6890, -7274, -7725, -8280, -9028, -9991, -11161, -12537, -14054, -15650, -17303, -18973, -20624, -22235, -23766, -25212, -26544, -27749, -28814, -29751, -30552, -31220, -31759, -32175, -32474, -32667, -32757, -32759, -32677, -32521, -32292, -31995, -31637, -31215, -30733, -30196, -29601, -28956, -28269, -27543, -26793, -26031, -25264, -24512, -23791, -23110, -22489, -21938, -21469, -21090, -20807, -20621, -20530, -20530, -20616, -20775, -20995, -21260, -21557, -21868, -22178, -22468, -22720, -22923, -23061, -23121, -23093, -22968, -22737, -22395, -21936, -21359, -20667, -19859, -18934, -17906, -16787, -15582, -14316, -12988, -11619, -10229, -8828, -7427, -6051, -4748, -3477, -2060, -494};