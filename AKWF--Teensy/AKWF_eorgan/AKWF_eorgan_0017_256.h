/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0017 256 samples */
 
const int16_t AKWF_eorgan_0017_256_DATA [256] = 
{700, 2108, 3717, 5093, 6541, 7976, 9393, 10785, 12154, 13499, 14813, 16098, 17353, 18568, 19749, 20890, 21988, 23043, 24053, 25011, 25922, 26782, 27587, 28339, 29035, 29673, 30255, 30777, 31239, 31644, 31986, 32266, 32491, 32630, 32741, 32769, 32740, 32652, 32505, 32298, 32033, 31709, 31332, 30898, 30410, 29872, 29283, 28645, 27960, 27229, 26456, 25642, 24789, 23898, 22974, 22017, 21032, 20020, 18981, 17922, 16844, 15747, 14639, 13519, 12389, 11256, 10118, 8978, 7843, 6712, 5587, 4475, 3374, 2288, 1222, 175, -849, -1848, -2821, -3765, -4676, -5556, -6401, -7206, -7975, -8703, -9389, -10033, -10634, -11187, -11697, -12157, -12569, -12935, -13251, -13536, -13738, -13919, -14042, -14113, -14139, -14114, -14043, -13925, -13759, -13549, -13294, -12995, -12655, -12274, -11853, -11395, -10902, -10374, -9813, -9223, -8604, -7958, -7290, -6598, -5887, -5160, -4417, -3664, -2901, -2132, -1344, -677, 289, 1168, 1784, 2630, 3384, 4127, 4861, 5581, 6288, 6978, 7643, 8286, 8904, 9493, 10051, 10579, 11071, 11529, 11951, 12332, 12675, 12976, 13234, 13449, 13619, 13744, 13822, 13852, 13836, 13770, 13657, 13493, 13277, 13038, 12714, 12366, 11967, 11518, 11022, 10482, 9898, 9269, 8599, 7887, 7135, 6347, 5519, 4656, 3764, 2837, 1882, 902, -106, -1135, -2183, -3252, -4337, -5430, -6539, -7654, -8773, -9898, -11020, -12140, -13257, -14363, -15459, -16544, -17611, -18660, -19689, -20692, -21671, -22622, -23540, -24425, -25275, -26086, -26858, -27587, -28272, -28911, -29504, -30045, -30537, -30975, -31360, -31690, -31963, -32180, -32338, -32437, -32477, -32457, -32378, -32219, -32034, -31759, -31434, -31049, -30603, -30099, -29534, -28914, -28236, -27502, -26716, -25875, -24983, -24043, -23053, -22016, -20939, -19814, -18651, -17452, -16214, -14944, -13645, -12313, -10958, -9580, -8178, -6760, -5328, -3881, -2424, -915};