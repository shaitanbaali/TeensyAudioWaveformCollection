/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0064 256 samples */
 
const int16_t AKWF_eorgan_0064_256_DATA [256] = 
{950, 2946, 4852, 6680, 8385, 9953, 11356, 12571, 13593, 14424, 15059, 15511, 15803, 15951, 15983, 15933, 15830, 15706, 15599, 15542, 15565, 15688, 15929, 16314, 16841, 17514, 18333, 19281, 20340, 21490, 22700, 23946, 25193, 26406, 27548, 28600, 29517, 30287, 30890, 31308, 31539, 31579, 31440, 31126, 30668, 30080, 29396, 28647, 27872, 27095, 26360, 25696, 25129, 24691, 24399, 24266, 24297, 24493, 24849, 25353, 25986, 26723, 27534, 28381, 29238, 30064, 30825, 31490, 32024, 32404, 32606, 32619, 32431, 32042, 31458, 30689, 29753, 28680, 27490, 26216, 24898, 23565, 22254, 21000, 19832, 18775, 17853, 17080, 16468, 16015, 15717, 15569, 15548, 15637, 15806, 16026, 16266, 16491, 16673, 16776, 16776, 16649, 16371, 15937, 15335, 14566, 13641, 12570, 11373, 10074, 8702, 7283, 5867, 4473, 3141, 1907, 791, -175, -972, -1588, -2018, -2259, -2320, -2215, -1960, -1584, -1115, -590, -34, 502, 994, 1404, 1700, 1853, 1848, 1666, 1296, 739, -2, -917, -1985, -3182, -4488, -5865, -7278, -8699, -10087, -11407, -12640, -13755, -14721, -15538, -16193, -16673, -16996, -17166, -17199, -17121, -16959, -16738, -16491, -16253, -16058, -15933, -15912, -16010, -16249, -16643, -17198, -17911, -18777, -19783, -20909, -22126, -23410, -24728, -26042, -27324, -28534, -29635, -30607, -31418, -32048, -32488, -32727, -32764, -32607, -32270, -31771, -31132, -30382, -29563, -28696, -27829, -26991, -26215, -25535, -24973, -24553, -24293, -24195, -24263, -24496, -24878, -25393, -26016, -26720, -27474, -28242, -28990, -29686, -30292, -30785, -31134, -31317, -31321, -31143, -30769, -30211, -29480, -28592, -27568, -26441, -25234, -23983, -22723, -21484, -20298, -19195, -18200, -17325, -16594, -16009, -15569, -15271, -15101, -15042, -15069, -15152, -15261, -15366, -15429, -15419, -15302, -15054, -14648, -14063, -13294, -12324, -11165, -9816, -8299, -6633, -4836, -2951, -969};