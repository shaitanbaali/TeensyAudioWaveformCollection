/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0115 256 samples */
 
const int16_t AKWF_eorgan_0115_256_DATA [256] = 
{2551, 7685, 11904, 15487, 18510, 21062, 23214, 25021, 26541, 27817, 28882, 29767, 30499, 31092, 31566, 31932, 32201, 32379, 32473, 32485, 32417, 32268, 32038, 31725, 31323, 30826, 30226, 29516, 28686, 27721, 26615, 25352, 23932, 22438, 20913, 19373, 17845, 16345, 14897, 13523, 12236, 11055, 10000, 9080, 8300, 7678, 7217, 6920, 6788, 6822, 7022, 7383, 7903, 8576, 9393, 10349, 11430, 12622, 13917, 15291, 16728, 18213, 19719, 21231, 22716, 24074, 25287, 26370, 27330, 28181, 28935, 29597, 30178, 30687, 31129, 31510, 31834, 32104, 32324, 32495, 32617, 32690, 32714, 32685, 32600, 32463, 32260, 31974, 31609, 31152, 30590, 29911, 29100, 28136, 27005, 25679, 24146, 22475, 20695, 18808, 16831, 14770, 12634, 10452, 8230, 5990, 3764, 1563, -568, -2478, -4128, -5542, -6729, -7712, -8493, -9084, -9492, -9717, -9763, -9625, -9307, -8803, -8105, -7212, -6116, -4811, -3299, -1573, 348, 2171, 3768, 5156, 6330, 7296, 8061, 8629, 9007, 9199, 9206, 9031, 8672, 8128, 7391, 6454, 5311, 3944, 2341, 480, -1596, -3748, -5932, -8137, -10331, -12490, -14609, -16659, -18629, -20514, -22295, -23969, -25521, -26877, -28035, -29021, -29853, -30550, -31129, -31601, -31980, -32277, -32494, -32638, -32731, -32768, -32752, -32687, -32572, -32409, -32197, -31935, -31619, -31248, -30817, -30319, -29750, -29103, -28367, -27534, -26594, -25532, -24344, -23014, -21543, -20026, -18513, -17014, -15560, -14164, -12845, -11625, -10513, -9523, -8668, -7958, -7398, -6995, -6754, -6679, -6768, -7022, -7444, -8026, -8765, -9651, -10671, -11823, -13084, -14436, -15869, -17358, -18879, -20421, -21952, -23457, -24906, -26206, -27347, -28344, -29203, -29940, -30563, -31082, -31504, -31836, -32081, -32244, -32327, -32329, -32248, -32082, -31825, -31471, -31010, -30431, -29717, -28847, -27803, -26549, -25054, -23277, -21159, -18649, -15673, -12145, -7988, -2930};