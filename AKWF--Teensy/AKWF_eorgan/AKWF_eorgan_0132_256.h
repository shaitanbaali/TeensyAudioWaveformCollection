/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0132 256 samples */
 
const int16_t AKWF_eorgan_0132_256_DATA [256] = 
{992, 2922, 4861, 6842, 8841, 10851, 12853, 14823, 16755, 18631, 20432, 22151, 23774, 25283, 26678, 27946, 29074, 30064, 30906, 31593, 32127, 32500, 32714, 32766, 32658, 32389, 31961, 31379, 30643, 29758, 28730, 27563, 26262, 24838, 23296, 21641, 19892, 18053, 16136, 14163, 12136, 10071, 7988, 5888, 3787, 1703, -364, -2397, -4381, -6314, -8183, -9974, -11687, -13310, -14833, -16259, -17576, -18780, -19874, -20849, -21704, -22441, -23059, -23557, -23938, -24203, -24356, -24400, -24341, -24185, -23938, -23612, -23210, -22742, -22217, -21640, -21020, -20364, -19679, -18969, -18245, -17506, -16762, -16019, -15276, -14541, -13818, -13108, -12417, -11748, -11103, -10488, -9907, -9362, -8857, -8393, -7970, -7592, -7256, -6961, -6704, -6480, -6285, -6114, -5959, -5815, -5677, -5538, -5394, -5241, -5073, -4887, -4681, -4449, -4192, -3907, -3592, -3246, -2869, -2459, -2018, -1546, -1042, -508, 52, 641, 1254, 1889, 2546, 3219, 3906, 4604, 5305, 6007, 6704, 7388, 8056, 8701, 9315, 9897, 10441, 10942, 11397, 11804, 12158, 12458, 12702, 12889, 13018, 13088, 13098, 13050, 12943, 12780, 12560, 12286, 11961, 11585, 11163, 10695, 10187, 9644, 9068, 8462, 7838, 7200, 6553, 5910, 5274, 4657, 4063, 3497, 2967, 2478, 2033, 1633, 1280, 974, 714, 500, 331, 204, 119, 74, 67, 94, 155, 246, 365, 509, 673, 857, 1056, 1265, 1482, 1702, 1918, 2126, 2319, 2489, 2630, 2736, 2803, 2825, 2796, 2715, 2577, 2379, 2121, 1802, 1418, 975, 468, -96, -718, -1398, -2127, -2904, -3724, -4579, -5464, -6372, -7295, -8228, -9163, -10089, -11002, -11895, -12754, -13573, -14342, -15048, -15685, -16243, -16711, -17085, -17358, -17522, -17576, -17513, -17331, -17029, -16605, -16060, -15391, -14601, -13695, -12670, -11533, -10288, -8937, -7488, -5948, -4320, -2618, -804};