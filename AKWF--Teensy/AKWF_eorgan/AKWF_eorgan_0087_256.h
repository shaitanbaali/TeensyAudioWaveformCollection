/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0087 256 samples */
 
const int16_t AKWF_eorgan_0087_256_DATA [256] = 
{1240, 4053, 6748, 9382, 11920, 14357, 16681, 18869, 20920, 22826, 24569, 26153, 27573, 28817, 29893, 30797, 31525, 32085, 32475, 32703, 32770, 32683, 32448, 32074, 31570, 30943, 30200, 29355, 28416, 27390, 26297, 25141, 23937, 22727, 21527, 20345, 19193, 18073, 16994, 15964, 14980, 14046, 13170, 12347, 11576, 10859, 10195, 9582, 9022, 8510, 8047, 7633, 7263, 6938, 6656, 6417, 6219, 6060, 5939, 5853, 5801, 5779, 5784, 5815, 5864, 5919, 5973, 6020, 6056, 6081, 6090, 6078, 6045, 5988, 5903, 5790, 5643, 5462, 5241, 4980, 4675, 4322, 3918, 3461, 2946, 2381, 1752, 1048, 280, -553, -1455, -2418, -3437, -4516, -5640, -6803, -7996, -9179, -10337, -11461, -12535, -13555, -14510, -15389, -16185, -16889, -17492, -17988, -18370, -18629, -18762, -18763, -18630, -18358, -17946, -17395, -16701, -15868, -14902, -13800, -12573, -11227, -9763, -8199, -6543, -4801, -2995, -1134, 763, 2632, 4449, 6205, 7877, 9461, 10944, 12313, 13567, 14695, 15687, 16547, 17268, 17847, 18287, 18585, 18744, 18767, 18658, 18422, 18062, 17584, 16997, 16309, 15526, 14659, 13711, 12698, 11628, 10506, 9349, 8162, 6960, 5781, 4642, 3547, 2507, 1525, 603, -249, -1037, -1760, -2411, -2991, -3523, -3995, -4413, -4780, -5097, -5369, -5599, -5790, -5946, -6067, -6157, -6220, -6259, -6275, -6270, -6249, -6216, -6170, -6118, -6063, -6008, -5969, -5953, -5962, -6002, -6076, -6185, -6330, -6514, -6738, -7004, -7313, -7667, -8065, -8511, -9005, -9547, -10139, -10785, -11481, -12231, -13034, -13886, -14797, -15760, -16768, -17826, -18923, -20055, -21219, -22404, -23599, -24795, -25949, -27043, -28072, -29016, -29870, -30623, -31264, -31783, -32175, -32429, -32537, -32495, -32293, -31929, -31397, -30697, -29823, -28777, -27562, -26173, -24618, -22903, -21026, -19001, -16838, -14538, -12120, -9598, -6981, -4294, -1490};