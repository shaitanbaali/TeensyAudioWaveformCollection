/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0110 256 samples */
 
const int16_t AKWF_eorgan_0110_256_DATA [256] = 
{1274, 3813, 6244, 8606, 10870, 13019, 15041, 16916, 18642, 20213, 21620, 22871, 23970, 24921, 25737, 26431, 27014, 27511, 27938, 28308, 28638, 28942, 29227, 29509, 29792, 30078, 30374, 30677, 30984, 31293, 31596, 31883, 32144, 32373, 32558, 32690, 32760, 32758, 32685, 32533, 32303, 31995, 31618, 31173, 30668, 30118, 29531, 28924, 28313, 27712, 27140, 26614, 26143, 25737, 25405, 25151, 24979, 24888, 24877, 24938, 25062, 25241, 25460, 25708, 25965, 26213, 26436, 26616, 26741, 26798, 26779, 26677, 26485, 26203, 25832, 25375, 24836, 24227, 23556, 22836, 22081, 21305, 20526, 19759, 19010, 18295, 17620, 16978, 16383, 15834, 15327, 14859, 14427, 14019, 13627, 13243, 12851, 12443, 12008, 11537, 11021, 10454, 9828, 9148, 8410, 7619, 6784, 5909, 5007, 4094, 3178, 2280, 1417, 605, -135, -788, -1348, -1800, -2138, -2359, -2463, -2453, -2334, -2115, -1811, -1435, -1007, -543, -60, 417, 863, 1264, 1597, 1849, 2005, 2053, 1989, 1809, 1510, 1097, 572, -50, -763, -1551, -2399, -3288, -4197, -5110, -6016, -6898, -7744, -8549, -9303, -9998, -10638, -11220, -11749, -12230, -12672, -13082, -13472, -13853, -14235, -14631, -15048, -15497, -15984, -16512, -17086, -17706, -18363, -19056, -19788, -20543, -21312, -22082, -22837, -23563, -24243, -24864, -25419, -25895, -26287, -26590, -26803, -26925, -26963, -26921, -26809, -26637, -26420, -26171, -25907, -25646, -25407, -25205, -25052, -24962, -24940, -24996, -25133, -25352, -25649, -26024, -26467, -26966, -27514, -28097, -28695, -29296, -29879, -30430, -30939, -31392, -31778, -32095, -32337, -32499, -32583, -32591, -32527, -32398, -32212, -31979, -31707, -31407, -31089, -30761, -30431, -30104, -29785, -29473, -29166, -28863, -28557, -28236, -27893, -27514, -27085, -26589, -26011, -25331, -24534, -23605, -22532, -21309, -19932, -18394, -16698, -14854, -12858, -10732, -8488, -6142, -3719, -1185};