/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0007 256 samples */
 
const int16_t AKWF_eorgan_0007_256_DATA [256] = 
{293, 1077, 1846, 2616, 3383, 4148, 4911, 5668, 6424, 7178, 7925, 8670, 9412, 10147, 10878, 11606, 12327, 13043, 13753, 14456, 15154, 15844, 16526, 17202, 17871, 18530, 19181, 19822, 20452, 21075, 21684, 22283, 22869, 23443, 24005, 24552, 25087, 25606, 26111, 26599, 27072, 27530, 27969, 28392, 28798, 29184, 29552, 29902, 30232, 30545, 30836, 31107, 31358, 31590, 31801, 31993, 32163, 32312, 32440, 32547, 32634, 32699, 32742, 32765, 32767, 32749, 32710, 32650, 32571, 32472, 32352, 32214, 32057, 31881, 31687, 31473, 31240, 30991, 30723, 30440, 30147, 29842, 29532, 29216, 28894, 28564, 28224, 27871, 27505, 27122, 26719, 26293, 25847, 25376, 24882, 24366, 23827, 23269, 22692, 22096, 21485, 20861, 20220, 19568, 18901, 18223, 17534, 16830, 16114, 15389, 14651, 13901, 13140, 12367, 11585, 10794, 9991, 9181, 8364, 7538, 6707, 5872, 5031, 4189, 3345, 2497, 1653, 809, -36, -876, -1719, -2562, -3399, -4232, -5061, -5882, -6699, -7509, -8311, -9107, -9894, -10671, -11441, -12203, -12952, -13692, -14421, -15137, -15844, -16538, -17220, -17890, -18548, -19192, -19825, -20443, -21047, -21640, -22217, -22781, -23331, -23866, -24388, -24895, -25388, -25866, -26330, -26778, -27210, -27628, -28030, -28416, -28787, -29140, -29477, -29797, -30100, -30387, -30657, -30908, -31142, -31358, -31555, -31735, -31897, -32038, -32161, -32268, -32357, -32437, -32505, -32567, -32620, -32663, -32699, -32723, -32731, -32722, -32692, -32638, -32559, -32453, -32318, -32156, -31965, -31747, -31502, -31231, -30937, -30618, -30278, -29919, -29538, -29138, -28718, -28279, -27821, -27345, -26846, -26331, -25798, -25244, -24674, -24087, -23481, -22859, -22221, -21568, -20901, -20221, -19528, -18825, -18110, -17386, -16653, -15913, -15164, -14412, -13652, -12889, -12122, -11350, -10575, -9801, -9023, -8244, -7466, -6685, -5904, -5126, -4346, -3568, -2791, -2015, -1243, -456};