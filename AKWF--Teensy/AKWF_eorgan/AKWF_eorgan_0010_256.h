/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0010 256 samples */
 
const int16_t AKWF_eorgan_0010_256_DATA [256] = 
{483, 1255, 2024, 2817, 3612, 4405, 5194, 5971, 6737, 7490, 8226, 8945, 9646, 10325, 10984, 11623, 12239, 12835, 13409, 13962, 14495, 15009, 15502, 15977, 16433, 16871, 17292, 17696, 18082, 18454, 18810, 19151, 19479, 19793, 20095, 20386, 20665, 20935, 21197, 21449, 21694, 21932, 22163, 22390, 22612, 22838, 23079, 23349, 23655, 24009, 24413, 24864, 25361, 25893, 26449, 27019, 27589, 28147, 28686, 29196, 29671, 30110, 30510, 30872, 31200, 31491, 31750, 31978, 32178, 32350, 32493, 32609, 32695, 32749, 32768, 32752, 32697, 32601, 32462, 32280, 32052, 31778, 31455, 31088, 30673, 30212, 29709, 29161, 28574, 27950, 27290, 26600, 25881, 25135, 24366, 23579, 22773, 21954, 21123, 20281, 19433, 18578, 17717, 16856, 15993, 15129, 14270, 13412, 12557, 11711, 10869, 10037, 9215, 8402, 7600, 6811, 6033, 5268, 4519, 3780, 3054, 2343, 1642, 955, 277, -419, -1125, -1828, -2530, -3226, -3919, -4611, -5299, -5986, -6672, -7359, -8046, -8734, -9420, -10110, -10801, -11492, -12185, -12879, -13573, -14269, -14964, -15659, -16354, -17049, -17738, -18426, -19109, -19784, -20455, -21116, -21766, -22407, -23033, -23644, -24242, -24819, -25378, -25917, -26433, -26926, -27394, -27834, -28245, -28628, -28979, -29301, -29591, -29847, -30072, -30263, -30419, -30544, -30635, -30693, -30719, -30712, -30675, -30607, -30511, -30384, -30230, -30050, -29846, -29618, -29369, -29100, -28811, -28508, -28187, -27853, -27507, -27151, -26783, -26409, -26030, -25641, -25250, -24854, -24454, -24053, -23649, -23245, -22843, -22440, -22039, -21639, -21238, -20839, -20443, -20047, -19652, -19264, -18894, -18556, -18257, -18000, -17785, -17607, -17456, -17321, -17186, -17037, -16861, -16646, -16382, -16067, -15695, -15270, -14794, -14272, -13709, -13114, -12492, -11849, -11188, -10515, -9831, -9140, -8438, -7730, -7016, -6292, -5561, -4824, -4077, -3324, -2567, -1805, -1042, -262};