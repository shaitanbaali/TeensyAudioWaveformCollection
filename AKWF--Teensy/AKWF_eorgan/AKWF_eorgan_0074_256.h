/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0074 256 samples */
 
const int16_t AKWF_eorgan_0074_256_DATA [256] = 
{1501, 5164, 8631, 11955, 15095, 18032, 20741, 23195, 25391, 27315, 28951, 30300, 31357, 32117, 32587, 32766, 32663, 32285, 31648, 30771, 29669, 28369, 26938, 25434, 23888, 22321, 20751, 19202, 17691, 16225, 14826, 13504, 12269, 11159, 10186, 9355, 8670, 8133, 7740, 7487, 7364, 7357, 7468, 7658, 7835, 8002, 8143, 8241, 8286, 8269, 8184, 8026, 7789, 7475, 7083, 6612, 6064, 5443, 4751, 3999, 3191, 2338, 1454, 554, -340, -1178, -1927, -2575, -3108, -3514, -3788, -3922, -3914, -3762, -3468, -3030, -2453, -1744, -904, 54, 1118, 2282, 3526, 4828, 6167, 7572, 8891, 10052, 11066, 11903, 12554, 13003, 13243, 13271, 13084, 12684, 12078, 11297, 10353, 9256, 8020, 6655, 5174, 3602, 1948, 240, -1494, -3216, -4846, -6347, -7706, -8901, -9913, -10734, -11354, -11765, -11964, -11949, -11719, -11277, -10629, -9781, -8739, -7519, -6136, -4605, -2955, -1205, 631, 2404, 4084, 5653, 7079, 8345, 9440, 10343, 11049, 11549, 11838, 11914, 11774, 11423, 10861, 10093, 9134, 7987, 6671, 5206, 3607, 1903, 162, -1561, -3235, -4836, -6351, -7753, -9030, -10172, -11163, -11994, -12654, -13113, -13360, -13392, -13210, -12818, -12222, -11433, -10464, -9340, -8050, -6650, -5301, -3981, -2716, -1524, -427, 567, 1444, 2194, 2812, 3294, 3633, 3828, 3879, 3787, 3555, 3188, 2692, 2075, 1354, 540, -345, -1249, -2141, -3009, -3834, -4608, -5322, -5968, -6542, -7040, -7459, -7800, -8062, -8246, -8355, -8394, -8369, -8286, -8158, -7998, -7822, -7622, -7481, -7452, -7533, -7740, -8084, -8571, -9203, -9981, -10903, -11963, -13151, -14434, -15795, -17225, -18706, -20228, -21776, -23326, -24863, -26364, -27800, -29129, -30274, -31201, -31893, -32331, -32498, -32385, -31985, -31295, -30309, -29030, -27464, -25609, -23479, -21088, -18438, -15558, -12466, -9185, -5752, -2116};