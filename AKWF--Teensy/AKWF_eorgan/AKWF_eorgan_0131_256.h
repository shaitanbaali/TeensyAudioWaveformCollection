/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0131 256 samples */
 
const int16_t AKWF_eorgan_0131_256_DATA [256] = 
{300, 1353, 2410, 3495, 4599, 5721, 6860, 8009, 9167, 10331, 11494, 12657, 13815, 14962, 16098, 17217, 18310, 19376, 20408, 21395, 22339, 23228, 24058, 24827, 25528, 26158, 26715, 27193, 27593, 27910, 28143, 28292, 28356, 28333, 28224, 28029, 27748, 27384, 26934, 26403, 25793, 25103, 24339, 23500, 22588, 21613, 20570, 19466, 18307, 17091, 15824, 14514, 13158, 11766, 10341, 8882, 7400, 5898, 4375, 2840, 1299, -249, -1796, -3339, -4876, -6399, -7907, -9400, -10867, -12308, -13723, -15102, -16449, -17760, -19026, -20253, -21437, -22571, -23657, -24695, -25677, -26604, -27474, -28280, -29026, -29706, -30319, -30866, -31344, -31752, -32092, -32362, -32563, -32696, -32760, -32757, -32690, -32558, -32363, -32107, -31791, -31417, -30987, -30505, -29971, -29386, -28759, -28084, -27367, -26612, -25818, -24989, -24129, -23235, -22313, -21367, -20393, -19397, -18383, -17347, -16296, -15232, -14152, -13062, -11965, -10857, -9747, -8632, -7514, -6398, -5283, -4169, -3064, -1964, -872, 208, 1276, 2333, 3371, 4394, 5398, 6379, 7341, 8278, 9187, 10070, 10925, 11746, 12535, 13289, 14004, 14684, 15323, 15919, 16476, 16991, 17460, 17887, 18269, 18607, 18900, 19149, 19352, 19512, 19627, 19699, 19729, 19716, 19661, 19567, 19434, 19262, 19052, 18807, 18527, 18214, 17869, 17492, 17086, 16653, 16193, 15707, 15199, 14667, 14114, 13542, 12951, 12343, 11720, 11080, 10427, 9761, 9082, 8392, 7693, 6983, 6266, 5542, 4810, 4075, 3334, 2589, 1845, 1098, 351, -392, -1135, -1874, -2606, -3330, -4042, -4740, -5423, -6086, -6727, -7347, -7939, -8504, -9042, -9548, -10021, -10463, -10869, -11239, -11573, -11869, -12127, -12345, -12523, -12660, -12755, -12806, -12815, -12781, -12701, -12576, -12406, -12190, -11928, -11619, -11265, -10864, -10416, -9925, -9386, -8802, -8175, -7503, -6788, -6033, -5235, -4399, -3526, -2617, -1676, -681};