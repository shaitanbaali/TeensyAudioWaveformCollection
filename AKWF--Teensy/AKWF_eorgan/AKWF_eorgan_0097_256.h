/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0097 256 samples */
 
const int16_t AKWF_eorgan_0097_256_DATA [256] = 
{1451, 5219, 8798, 12239, 15488, 18515, 21295, 23791, 25995, 27894, 29472, 30739, 31690, 32334, 32690, 32767, 32588, 32174, 31551, 30743, 29763, 28635, 27377, 25998, 24514, 22938, 21269, 19522, 17697, 15788, 13804, 11744, 9611, 7456, 5298, 3126, 958, -1218, -3395, -5556, -7701, -9823, -11893, -13900, -15824, -17627, -19299, -20810, -22126, -23230, -24091, -24683, -24994, -25009, -24716, -24108, -23189, -21965, -20445, -18648, -16603, -14326, -11862, -9242, -6512, -3776, -1091, 1509, 3979, 6296, 8436, 10366, 12078, 13561, 14805, 15812, 16586, 17135, 17469, 17605, 17565, 17366, 17029, 16577, 16024, 15409, 14721, 13942, 13111, 12232, 11298, 10324, 9301, 8226, 7101, 5915, 4674, 3421, 2171, 914, -349, -1623, -2909, -4198, -5489, -6778, -8047, -9289, -10488, -11616, -12661, -13599, -14402, -15050, -15513, -15778, -15820, -15632, -15204, -14525, -13602, -12442, -11049, -9447, -7653, -5690, -3596, -1404, 845, 3056, 5175, 7178, 9016, 10673, 12125, 13347, 14333, 15075, 15569, 15819, 15832, 15623, 15204, 14596, 13826, 12912, 11884, 10768, 9573, 8331, 7058, 5760, 4457, 3158, 1859, 575, -698, -1964, -3220, -4472, -5719, -6917, -8048, -9127, -10151, -11126, -12056, -12937, -13765, -14544, -15245, -15861, -16425, -16891, -17249, -17476, -17555, -17461, -17175, -16682, -15966, -15020, -13841, -12418, -10766, -8898, -6811, -4541, -2112, 457, 3120, 5843, 8581, 11229, 13734, 16060, 18165, 20025, 21618, 22914, 23911, 24595, 24964, 25027, 24784, 24258, 23458, 22406, 21131, 19657, 18013, 16232, 14324, 12323, 10257, 8136, 5984, 3814, 1631, -552, -2727, -4902, -7065, -9219, -11360, -13431, -15422, -17337, -19168, -20920, -22590, -24170, -25660, -27046, -28316, -29459, -30461, -31297, -31952, -32405, -32633, -32611, -32319, -31739, -30859, -29667, -28165, -26344, -24213, -21787, -19073, -16104, -12910, -9511, -5963, -2221};