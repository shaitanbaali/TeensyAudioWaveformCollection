/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0138 256 samples */
 
const int16_t AKWF_eorgan_0138_256_DATA [256] = 
{1113, 3608, 6092, 8587, 11048, 13443, 15737, 17889, 19874, 21661, 23221, 24541, 25606, 26405, 26941, 27216, 27240, 27027, 26599, 25979, 25190, 24266, 23234, 22120, 20958, 19777, 18594, 17437, 16324, 15263, 14269, 13345, 12489, 11703, 10978, 10304, 9672, 9067, 8475, 7885, 7281, 6652, 5991, 5290, 4547, 3769, 2954, 2116, 1268, 421, -400, -1177, -1892, -2517, -3033, -3421, -3661, -3737, -3640, -3362, -2904, -2270, -1472, -523, 557, 1740, 3001, 4311, 5631, 6931, 8178, 9335, 10376, 11273, 12000, 12543, 12888, 13027, 12962, 12696, 12241, 11610, 10824, 9909, 8886, 7787, 6642, 5477, 4324, 3209, 2151, 1177, 301, -465, -1113, -1639, -2045, -2334, -2514, -2597, -2597, -2528, -2406, -2247, -2066, -1877, -1691, -1516, -1356, -1212, -1082, -956, -826, -679, -498, -265, 40, 436, 942, 1578, 2357, 3291, 4395, 5665, 7099, 8691, 10421, 12273, 14224, 16238, 18285, 20334, 22336, 24259, 26067, 27715, 29178, 30421, 31417, 32150, 32603, 32770, 32651, 32249, 31577, 30649, 29487, 28122, 26574, 24880, 23074, 21180, 19236, 17274, 15312, 13382, 11504, 9686, 7946, 6290, 4716, 3227, 1815, 471, -811, -2051, -3259, -4448, -5632, -6825, -8031, -9262, -10518, -11795, -13093, -14402, -15707, -16997, -18254, -19453, -20579, -21608, -22517, -23291, -23908, -24355, -24621, -24700, -24591, -24300, -23837, -23218, -22460, -21592, -20638, -19629, -18601, -17585, -16612, -15719, -14931, -14276, -13779, -13455, -13315, -13365, -13604, -14031, -14628, -15384, -16278, -17282, -18374, -19522, -20693, -21865, -23003, -24081, -25077, -25968, -26737, -27374, -27869, -28218, -28424, -28490, -28425, -28240, -27951, -27572, -27119, -26611, -26062, -25487, -24901, -24310, -23720, -23136, -22551, -21963, -21365, -20741, -20078, -19362, -18571, -17689, -16699, -15582, -14326, -12922, -11354, -9626, -7743, -5708, -3544, -1210};