/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0056 256 samples */
 
const int16_t AKWF_eorgan_0056_256_DATA [256] = 
{944, 2899, 4805, 6699, 8567, 10407, 12212, 13969, 15679, 17336, 18927, 20454, 21909, 23284, 24583, 25795, 26916, 27946, 28882, 29719, 30458, 31097, 31630, 32063, 32392, 32618, 32742, 32766, 32689, 32515, 32246, 31885, 31434, 30898, 30280, 29584, 28816, 27979, 27078, 26121, 25110, 24049, 22953, 21817, 20650, 19464, 18257, 17038, 15816, 14592, 13373, 12168, 10976, 9809, 8669, 7559, 6487, 5457, 4470, 3533, 2648, 1817, 1044, 332, -317, -904, -1425, -1882, -2272, -2596, -2855, -3048, -3176, -3242, -3247, -3193, -3083, -2919, -2703, -2439, -2132, -1784, -1398, -979, -535, -30, 478, 983, 1504, 2029, 2558, 3084, 3604, 4115, 4611, 5088, 5544, 5975, 6375, 6745, 7079, 7376, 7632, 7846, 8016, 8142, 8221, 8253, 8236, 8172, 8060, 7900, 7694, 7442, 7145, 6806, 6426, 6007, 5553, 5065, 4546, 4000, 3429, 2837, 2229, 1606, 973, 335, -306, -945, -1579, -2205, -2816, -3412, -3988, -4540, -5064, -5560, -6021, -6448, -6837, -7184, -7490, -7752, -7968, -8138, -8261, -8337, -8363, -8341, -8274, -8158, -7997, -7794, -7547, -7259, -6934, -6573, -6180, -5757, -5306, -4835, -4345, -3837, -3320, -2797, -2269, -1744, -1224, -717, -207, 302, 750, 1173, 1566, 1920, 2235, 2508, 2733, 2908, 3029, 3094, 3103, 3049, 2934, 2755, 2511, 2202, 1827, 1385, 879, 308, -326, -1023, -1779, -2595, -3464, -4388, -5360, -6376, -7435, -8532, -9658, -10814, -11995, -13189, -14399, -15615, -16828, -18041, -19242, -20423, -21585, -22717, -23813, -24871, -25882, -26840, -27742, -28582, -29352, -30052, -30675, -31216, -31673, -32042, -32318, -32500, -32585, -32571, -32457, -32240, -31922, -31499, -30975, -30349, -29620, -28794, -27868, -26847, -25736, -24534, -23246, -21880, -20432, -18913, -17330, -15681, -13977, -12225, -10424, -8588, -6723, -4831, -2929, -973};