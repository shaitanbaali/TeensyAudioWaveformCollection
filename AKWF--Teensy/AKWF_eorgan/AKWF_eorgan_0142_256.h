/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0142 256 samples */
 
const int16_t AKWF_eorgan_0142_256_DATA [256] = 
{2020, 5052, 7849, 10474, 12915, 15174, 17256, 19154, 20887, 22458, 23871, 25141, 26271, 27268, 28143, 28902, 29547, 30090, 30534, 30880, 31135, 31299, 31370, 31352, 31247, 31054, 30772, 30405, 29956, 29426, 28828, 28172, 27468, 26734, 25980, 25221, 24474, 23748, 23056, 22406, 21801, 21242, 20731, 20266, 19843, 19465, 19126, 18828, 18576, 18371, 18218, 18124, 18090, 18124, 18225, 18391, 18614, 18889, 19210, 19565, 19948, 20349, 20760, 21176, 21597, 22017, 22441, 22867, 23294, 23725, 24156, 24582, 24999, 25399, 25771, 26108, 26400, 26628, 26787, 26870, 26871, 26786, 26617, 26363, 26026, 25610, 25119, 24558, 23937, 23261, 22530, 21754, 20934, 20070, 19171, 18237, 17269, 16274, 15250, 14200, 13127, 12029, 10904, 9756, 8580, 7380, 6160, 4927, 3688, 2465, 1269, 129, -923, -1856, -2646, -3268, -3710, -3957, -4002, -3853, -3525, -3035, -2406, -1671, -863, -14, 831, 1638, 2379, 3028, 3571, 3995, 4294, 4467, 4515, 4440, 4248, 3945, 3538, 3034, 2440, 1767, 1017, 202, -668, -1582, -2531, -3508, -4511, -5538, -6583, -7650, -8732, -9827, -10942, -12068, -13202, -14344, -15480, -16599, -17695, -18745, -19746, -20687, -21554, -22340, -23043, -23656, -24183, -24629, -24996, -25290, -25522, -25694, -25813, -25882, -25901, -25872, -25792, -25661, -25476, -25237, -24943, -24599, -24214, -23795, -23350, -22888, -22420, -21955, -21500, -21062, -20642, -20246, -19870, -19514, -19180, -18865, -18571, -18302, -18062, -17858, -17698, -17591, -17547, -17575, -17683, -17875, -18152, -18515, -18958, -19473, -20058, -20700, -21390, -22118, -22869, -23633, -24405, -25173, -25928, -26670, -27386, -28072, -28728, -29340, -29910, -30434, -30909, -31334, -31707, -32027, -32294, -32507, -32660, -32749, -32763, -32692, -32520, -32229, -31799, -31207, -30432, -29456, -28254, -26815, -25131, -23195, -21027, -18639, -16041, -13267, -10349, -7316, -4218, -1017};