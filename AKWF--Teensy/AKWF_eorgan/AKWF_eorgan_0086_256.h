/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0086 256 samples */
 
const int16_t AKWF_eorgan_0086_256_DATA [256] = 
{1040, 2896, 4691, 6461, 8196, 9894, 11553, 13160, 14718, 16225, 17671, 19060, 20387, 21647, 22842, 23970, 25026, 26014, 26931, 27775, 28550, 29255, 29888, 30455, 30954, 31385, 31755, 32063, 32311, 32501, 32638, 32726, 32764, 32762, 32720, 32643, 32536, 32400, 32238, 32052, 31848, 31629, 31396, 31150, 30896, 30637, 30373, 30107, 29839, 29570, 29306, 29042, 28780, 28524, 28271, 28021, 27773, 27531, 27289, 27050, 26812, 26572, 26332, 26090, 25844, 25596, 25348, 25096, 24841, 24577, 24307, 24028, 23738, 23434, 23120, 22791, 22446, 22087, 21709, 21315, 20905, 20474, 20027, 19562, 19079, 18582, 18069, 17534, 16987, 16423, 15845, 15256, 14658, 14049, 13436, 12820, 12198, 11580, 10967, 10359, 9761, 9174, 8597, 8036, 7487, 6958, 6447, 5954, 5479, 5028, 4596, 4185, 3795, 3427, 3079, 2753, 2443, 2151, 1879, 1622, 1378, 1147, 926, 712, 507, 302, 100, -103, -305, -504, -700, -897, -1096, -1301, -1514, -1738, -1971, -2220, -2484, -2764, -3063, -3380, -3718, -4076, -4455, -4856, -5277, -5719, -6184, -6667, -7168, -7690, -8229, -8782, -9350, -9930, -10522, -11123, -11730, -12342, -12958, -13571, -14181, -14786, -15380, -15967, -16543, -17105, -17651, -18186, -18700, -19194, -19676, -20140, -20588, -21018, -21427, -21820, -22197, -22556, -22899, -23226, -23539, -23839, -24127, -24402, -24668, -24928, -25179, -25425, -25667, -25909, -26148, -26382, -26614, -26844, -27072, -27301, -27532, -27763, -27999, -28237, -28479, -28725, -28973, -29224, -29478, -29734, -29988, -30242, -30494, -30743, -30986, -31219, -31442, -31652, -31846, -32021, -32174, -32303, -32404, -32473, -32508, -32505, -32461, -32370, -32229, -32035, -31785, -31476, -31106, -30674, -30173, -29607, -28975, -28271, -27496, -26654, -25738, -24751, -23696, -22569, -21375, -20116, -18790, -17401, -15955, -14449, -12889, -11282, -9622, -7922, -6186, -4412, -2615, -755};