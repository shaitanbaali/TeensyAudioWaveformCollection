/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0084 256 samples */
 
const int16_t AKWF_eorgan_0084_256_DATA [256] = 
{2283, 8415, 13925, 18842, 23060, 26530, 29228, 31144, 32311, 32760, 32541, 31704, 30309, 28431, 26162, 23574, 20773, 18010, 15428, 13061, 10922, 9033, 7475, 6312, 5549, 5175, 5165, 5477, 6074, 6928, 7998, 9242, 10582, 11793, 12761, 13469, 13913, 14121, 14132, 14017, 13853, 13682, 13554, 13433, 13189, 12832, 12348, 11723, 10990, 10346, 9877, 9549, 9325, 9162, 9042, 8962, 8931, 8965, 9086, 9317, 9672, 10164, 10792, 11551, 12400, 13189, 13850, 14372, 14750, 14996, 15124, 15153, 15104, 14999, 14847, 14651, 14398, 14056, 13583, 12940, 12150, 11411, 10810, 10331, 9957, 9709, 9468, 9161, 8836, 8523, 8284, 8203, 8327, 8689, 9293, 10129, 11137, 12093, 12870, 13427, 13717, 13712, 13376, 12678, 11573, 10047, 8105, 5779, 3164, 298, -2815, -6145, -9601, -12943, -16008, -18731, -21033, -22820, -24031, -24614, -24517, -23696, -22122, -19790, -16714, -12923, -8512, -3572, 1727, 6811, 11409, 15420, 18738, 21324, 23152, 24217, 24550, 24185, 23169, 21557, 19406, 16795, 13812, 10533, 7066, 3657, 453, -2512, -5227, -7667, -9752, -11423, -12668, -13499, -13946, -14045, -13839, -13354, -12630, -11711, -10676, -9748, -9045, -8582, -8365, -8365, -8548, -8838, -9161, -9478, -9737, -9973, -10323, -10775, -11345, -12046, -12845, -13547, -14068, -14440, -14702, -14898, -15046, -15149, -15200, -15180, -15070, -14849, -14501, -14011, -13384, -12625, -11772, -10977, -10310, -9776, -9385, -9124, -8977, -8927, -8950, -9026, -9144, -9300, -9510, -9800, -10216, -10794, -11512, -12168, -12679, -13058, -13320, -13445, -13551, -13707, -13866, -14000, -14041, -13909, -13553, -12941, -12068, -10943, -9626, -8341, -7213, -6284, -5600, -5188, -5083, -5319, -5938, -6953, -8364, -10134, -12167, -14432, -16919, -19598, -22383, -25029, -27377, -29364, -30906, -31912, -32325, -32087, -31150, -29475, -27027, -23806, -19826, -15124, -9797, -3801};