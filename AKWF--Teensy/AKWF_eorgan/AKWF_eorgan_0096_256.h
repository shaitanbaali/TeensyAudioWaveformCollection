/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0096 256 samples */
 
const int16_t AKWF_eorgan_0096_256_DATA [256] = 
{1056, 3050, 4963, 6832, 8636, 10369, 12022, 13582, 15047, 16411, 17669, 18825, 19876, 20820, 21666, 22415, 23072, 23644, 24136, 24554, 24906, 25196, 25428, 25611, 25746, 25835, 25887, 25897, 25871, 25809, 25713, 25582, 25418, 25230, 25019, 24785, 24532, 24260, 23971, 23669, 23355, 23037, 22716, 22401, 22098, 21816, 21562, 21342, 21165, 21036, 20966, 20960, 21021, 21155, 21363, 21647, 22006, 22434, 22934, 23496, 24113, 24778, 25481, 26212, 26960, 27699, 28421, 29113, 29763, 30364, 30906, 31382, 31787, 32119, 32374, 32550, 32648, 32670, 32619, 32498, 32311, 32064, 31764, 31414, 31017, 30590, 30125, 29618, 29084, 28521, 27928, 27308, 26664, 25990, 25291, 24562, 23803, 23020, 22216, 21388, 20537, 19664, 18764, 17845, 16902, 15943, 14972, 13990, 13003, 12019, 11042, 10079, 9137, 8222, 7341, 6502, 5704, 4956, 4256, 3609, 3012, 2464, 1960, 1497, 1070, 668, 285, -87, -456, -820, -1190, -1577, -1986, -2429, -2912, -3436, -4010, -4633, -5308, -6033, -6807, -7626, -8486, -9384, -10308, -11258, -12224, -13197, -14177, -15153, -16117, -17072, -18011, -18926, -19825, -20696, -21544, -22368, -23169, -23945, -24700, -25425, -26120, -26787, -27425, -28037, -28623, -29181, -29710, -30210, -30673, -31095, -31488, -31836, -32139, -32388, -32580, -32707, -32765, -32753, -32665, -32500, -32257, -31936, -31541, -31075, -30540, -29946, -29302, -28610, -27889, -27146, -26389, -25645, -24926, -24242, -23603, -23018, -22494, -22038, -21653, -21342, -21107, -20947, -20859, -20842, -20889, -20995, -21154, -21356, -21597, -21867, -22159, -22465, -22776, -23090, -23400, -23698, -23983, -24252, -24500, -24729, -24936, -25120, -25279, -25406, -25498, -25554, -25574, -25559, -25503, -25407, -25266, -25082, -24845, -24553, -24201, -23785, -23297, -22729, -22081, -21340, -20506, -19574, -18537, -17397, -16152, -14801, -13351, -11806, -10163, -8442, -6644, -4781, -2871, -877};