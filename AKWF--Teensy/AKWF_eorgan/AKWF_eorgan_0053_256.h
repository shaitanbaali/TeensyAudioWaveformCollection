/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0053 256 samples */
 
const int16_t AKWF_eorgan_0053_256_DATA [256] = 
{2063, 5175, 8155, 10889, 13429, 15864, 18158, 20274, 22202, 23950, 25359, 26330, 27023, 27582, 28079, 28559, 29065, 29677, 30360, 31109, 31842, 32339, 32670, 32768, 32663, 32460, 32141, 31814, 31508, 31195, 30913, 30718, 30630, 30533, 30345, 29903, 29214, 28510, 27985, 27577, 27139, 26811, 26512, 25949, 25106, 23934, 22525, 21034, 19609, 18261, 16888, 15545, 14299, 13025, 11691, 10358, 9083, 7952, 7007, 6341, 5983, 5851, 5884, 6069, 6398, 6760, 7061, 7239, 7249, 7151, 7028, 6853, 6566, 6203, 5691, 4961, 4066, 3138, 2287, 1472, 717, 181, -58, -28, 167, 323, 408, 361, 167, -124, -549, -1034, -1497, -2005, -2547, -3055, -3533, -3941, -4310, -4661, -4923, -4963, -4657, -4209, -3811, -3333, -2842, -2499, -2309, -2260, -2256, -2209, -2029, -1702, -1275, -685, 121, 1012, 1933, 2914, 3941, 5055, 6231, 7488, 8880, 10398, 12000, 13676, 15360, 16952, 18366, 19539, 20466, 21196, 21780, 22131, 22168, 21918, 21325, 20358, 19098, 17729, 16375, 15032, 13757, 12678, 11800, 11053, 10316, 9492, 8632, 7697, 6714, 5743, 4749, 3783, 2929, 2121, 1336, 638, 3, -570, -1143, -1769, -2402, -2905, -3134, -3296, -3592, -3861, -4140, -4620, -5283, -6088, -6938, -7768, -8509, -9195, -9911, -10582, -11109, -11562, -11984, -12322, -12553, -12639, -12585, -12385, -11986, -11398, -10655, -9755, -8749, -7760, -6923, -6342, -6034, -5905, -5891, -6019, -6336, -6818, -7530, -8548, -9879, -11408, -13017, -14702, -16378, -17859, -19098, -20171, -21166, -22200, -23247, -24331, -25401, -26395, -27347, -28218, -28933, -29587, -30221, -30733, -31116, -31325, -31412, -31451, -31415, -31171, -30565, -29790, -29032, -28137, -27177, -26337, -25598, -24980, -24429, -23894, -23330, -22668, -21970, -21124, -20028, -18836, -17603, -16427, -15221, -13888, -12435, -10747, -8732, -6380, -3764, -863};