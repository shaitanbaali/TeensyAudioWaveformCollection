/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0137 256 samples */
 
const int16_t AKWF_eorgan_0137_256_DATA [256] = 
{734, 2539, 4397, 6328, 8305, 10319, 12352, 14377, 16383, 18348, 20249, 22072, 23800, 25409, 26890, 28229, 29408, 30423, 31263, 31919, 32392, 32676, 32769, 32673, 32392, 31930, 31288, 30478, 29504, 28374, 27100, 25692, 24154, 22506, 20757, 18920, 17023, 15074, 13088, 11097, 9108, 7143, 5230, 3376, 1605, -60, -1614, -3038, -4317, -5444, -6411, -7206, -7830, -8277, -8545, -8636, -8553, -8300, -7878, -7297, -6564, -5683, -4667, -3525, -2264, -901, 554, 2088, 3676, 5305, 6961, 8616, 10256, 11863, 13409, 14881, 16260, 17523, 18661, 19657, 20496, 21170, 21670, 21987, 22120, 22064, 21820, 21388, 20769, 19972, 18997, 17855, 16553, 15096, 13500, 11773, 9921, 7965, 5912, 3778, 1590, -643, -2904, -5166, -7416, -9635, -11792, -13880, -15878, -17761, -19523, -21146, -22613, -23919, -25053, -26006, -26778, -27362, -27758, -27966, -27989, -27831, -27495, -26989, -26319, -25491, -24518, -23408, -22168, -20815, -19358, -17811, -16199, -14531, -12824, -11106, -9386, -7687, -6032, -4433, -2912, -1489, -174, 1018, 2070, 2978, 3729, 4317, 4740, 4992, 5072, 4982, 4723, 4300, 3715, 2978, 2095, 1070, -83, -1355, -2742, -4224, -5795, -7438, -9131, -10863, -12617, -14368, -16105, -17806, -19447, -21016, -22494, -23859, -25103, -26209, -27162, -27956, -28582, -29031, -29301, -29391, -29295, -29017, -28561, -27929, -27125, -26158, -25036, -23761, -22350, -20810, -19146, -17379, -15516, -13570, -11568, -9517, -7433, -5345, -3261, -1201, 807, 2756, 4626, 6394, 8054, 9589, 10981, 12230, 13322, 14248, 15010, 15600, 16017, 16266, 16343, 16255, 16005, 15600, 15045, 14346, 13516, 12561, 11489, 10315, 9048, 7702, 6301, 4853, 3376, 1893, 419, -1029, -2425, -3758, -5009, -6158, -7194, -8102, -8867, -9484, -9941, -10231, -10355, -10305, -10083, -9688, -9126, -8398, -7509, -6468, -5281, -3957, -2508, -904};