/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0141 256 samples */
 
const int16_t AKWF_eorgan_0141_256_DATA [256] = 
{1473, 5745, 9395, 12499, 15054, 17097, 18698, 19929, 20871, 21562, 22034, 22346, 22539, 22647, 22673, 22596, 22425, 22211, 22000, 21801, 21624, 21489, 21414, 21415, 21491, 21605, 21701, 21743, 21686, 21486, 21102, 20511, 19720, 18796, 17813, 16818, 15839, 14925, 14137, 13531, 13129, 12897, 12775, 12711, 12633, 12453, 12109, 11563, 10789, 9814, 8700, 7501, 6273, 5105, 4091, 3310, 2828, 2613, 2604, 2771, 3053, 3378, 3656, 3805, 3757, 3515, 3107, 2560, 1945, 1332, 790, 388, 190, 209, 431, 857, 1462, 2203, 2998, 3727, 4327, 4794, 5141, 5374, 5506, 5561, 5576, 5596, 5662, 5775, 5926, 6121, 6355, 6612, 6864, 7076, 7218, 7312, 7400, 7484, 7538, 7555, 7540, 7484, 7362, 7098, 6608, 5829, 4713, 3235, 1373, -847, -3339, -5975, -8589, -11036, -13180, -14868, -15959, -16337, -15925, -14787, -13018, -10689, -7906, -4804, -1569, 1593, 4459, 6907, 8885, 10350, 11299, 11771, 11827, 11551, 11014, 10259, 9329, 8276, 7155, 6003, 4822, 3597, 2345, 1113, -36, -1083, -2018, -2815, -3451, -3915, -4205, -4365, -4449, -4503, -4572, -4705, -4947, -5324, -5823, -6381, -6915, -7375, -7753, -7996, -8047, -7859, -7417, -6761, -5960, -5074, -4184, -3390, -2761, -2345, -2178, -2232, -2449, -2781, -3165, -3523, -3767, -3817, -3622, -3218, -2661, -1994, -1269, -568, 19, 402, 515, 356, -44, -657, -1412, -2234, -3056, -3807, -4427, -4903, -5242, -5447, -5539, -5552, -5569, -5693, -5981, -6437, -7041, -7776, -8623, -9551, -10513, -11461, -12347, -13162, -13913, -14586, -15180, -15708, -16191, -16657, -17134, -17592, -17990, -18325, -18614, -18865, -19070, -19234, -19380, -19579, -19907, -20422, -21162, -22144, -23377, -24832, -26451, -28130, -29726, -31107, -32149, -32710, -32656, -31874, -30282, -27936, -24915, -21285, -17136, -12600, -7859, -3004};