/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0149 256 samples */
 
const int16_t AKWF_eorgan_0149_256_DATA [256] = 
{794, 2795, 4671, 6440, 8069, 9537, 10819, 11899, 12764, 13410, 13831, 14029, 14013, 13795, 13387, 12816, 12102, 11272, 10359, 9397, 8414, 7447, 6531, 5689, 4952, 4346, 3889, 3602, 3500, 3592, 3886, 4386, 5093, 5998, 7096, 8376, 9818, 11405, 13118, 14923, 16789, 18671, 20528, 22329, 24041, 25630, 27075, 28351, 29434, 30316, 30983, 31425, 31639, 31628, 31394, 30945, 30294, 29459, 28453, 27303, 26036, 24675, 23259, 21822, 20388, 19001, 17686, 16473, 15394, 14467, 13714, 13151, 12789, 12633, 12687, 12946, 13402, 14041, 14846, 15796, 16865, 18031, 19262, 20518, 21770, 22982, 24124, 25169, 26088, 26859, 27462, 27881, 28100, 28113, 27912, 27494, 26861, 26020, 24978, 23747, 22346, 20791, 19104, 17318, 15454, 13546, 11634, 9741, 7902, 6154, 4515, 3018, 1687, 535, -418, -1163, -1695, -2013, -2120, -2026, -1745, -1296, -695, 27, 848, 1740, 2659, 3574, 4456, 5272, 5995, 6598, 7060, 7361, 7485, 7418, 7152, 6680, 6002, 5119, 4036, 2766, 1318, -288, -2029, -3889, -5836, -7834, -9860, -11873, -13835, -15718, -17484, -19101, -20553, -21814, -22867, -23704, -24317, -24701, -24859, -24797, -24522, -24047, -23392, -22578, -21624, -20556, -19411, -18228, -17045, -15892, -14801, -13805, -12925, -12188, -11616, -11223, -11022, -11023, -11231, -11644, -12262, -13078, -14080, -15245, -16557, -17981, -19489, -21051, -22629, -24186, -25697, -27120, -28433, -29611, -30626, -31462, -32103, -32534, -32748, -32742, -32514, -32065, -31403, -30542, -29489, -28266, -26896, -25394, -23788, -22120, -20415, -18710, -17041, -15431, -13916, -12525, -11275, -10194, -9298, -8598, -8103, -7818, -7740, -7864, -8176, -8665, -9306, -10081, -10962, -11918, -12921, -13936, -14928, -15870, -16733, -17485, -18105, -18571, -18864, -18972, -18879, -18582, -18075, -17358, -16435, -15311, -14001, -12519, -10878, -9104, -7218, -5247, -3234, -1167};