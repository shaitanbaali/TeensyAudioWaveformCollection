/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0082 256 samples */
 
const int16_t AKWF_eorgan_0082_256_DATA [256] = 
{1894, 6413, 10620, 14520, 18019, 21072, 23657, 25770, 27454, 28759, 29745, 30485, 31040, 31466, 31811, 32101, 32346, 32545, 32688, 32761, 32754, 32659, 32476, 32211, 31875, 31478, 31029, 30532, 29982, 29367, 28674, 27883, 26975, 25978, 24891, 23709, 22444, 21118, 19767, 18447, 17206, 16097, 15172, 14453, 13932, 13618, 13484, 13495, 13605, 13767, 13937, 14075, 14161, 14188, 14166, 14127, 14110, 14160, 14319, 14619, 15078, 15700, 16465, 17347, 18302, 19236, 20100, 20858, 21488, 21986, 22365, 22647, 22874, 23086, 23327, 23628, 24005, 24457, 24967, 25495, 25995, 26418, 26712, 26834, 26748, 26464, 25941, 25179, 24235, 23145, 21960, 20735, 19506, 18296, 17122, 15980, 14864, 13799, 12774, 11764, 10753, 9727, 8673, 7599, 6504, 5398, 4298, 3204, 2120, 1046, -31, -1126, -2243, -3394, -4568, -5742, -6880, -7923, -8807, -9462, -9823, -9825, -9426, -8605, -7371, -5757, -3834, -1687, 579, 2780, 4795, 6530, 7904, 8873, 9420, 9552, 9307, 8742, 7924, 6921, 5799, 4623, 3431, 2258, 1119, 6, -1086, -2168, -3255, -4351, -5452, -6563, -7664, -8748, -9810, -10840, -11852, -12856, -13865, -14904, -15991, -17103, -18243, -19419, -20620, -21831, -23017, -24126, -25112, -25931, -26522, -26876, -27029, -26969, -26721, -26328, -25839, -25301, -24766, -24276, -23852, -23506, -23229, -22993, -22758, -22484, -22127, -21657, -21062, -20335, -19494, -18571, -17607, -16696, -15889, -15219, -14708, -14359, -14160, -14086, -14094, -14140, -14181, -14183, -14127, -14011, -13851, -13684, -13550, -13495, -13570, -13811, -14250, -14890, -15738, -16782, -17976, -19269, -20613, -21950, -23236, -24449, -25567, -26590, -27524, -28338, -29043, -29663, -30213, -30702, -31142, -31528, -31855, -32116, -32296, -32387, -32388, -32306, -32149, -31930, -31662, -31348, -30984, -30554, -30013, -29310, -28386, -27169, -25597, -23616, -21173, -18265, -14900, -11115, -6994, -2525};