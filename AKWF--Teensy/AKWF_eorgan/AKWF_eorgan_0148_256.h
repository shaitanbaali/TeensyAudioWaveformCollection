/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0148 256 samples */
 
const int16_t AKWF_eorgan_0148_256_DATA [256] = 
{1143, 3187, 5433, 7890, 10494, 13178, 15864, 18471, 20944, 23228, 25276, 27072, 28604, 29864, 30873, 31644, 32196, 32555, 32737, 32761, 32642, 32392, 32020, 31540, 30966, 30317, 29613, 28887, 28170, 27495, 26895, 26400, 26023, 25776, 25652, 25630, 25683, 25768, 25840, 25853, 25766, 25541, 25153, 24584, 23833, 22908, 21823, 20599, 19270, 17850, 16369, 14851, 13304, 11746, 10192, 8645, 7126, 5652, 4242, 2927, 1739, 707, -133, -761, -1162, -1332, -1285, -1046, -657, -165, 371, 899, 1367, 1730, 1958, 2029, 1937, 1687, 1292, 770, 147, -556, -1318, -2120, -2951, -3800, -4656, -5514, -6360, -7175, -7948, -8655, -9269, -9764, -10113, -10294, -10294, -10113, -9760, -9260, -8654, -7991, -7321, -6702, -6180, -5794, -5575, -5539, -5688, -6012, -6493, -7105, -7817, -8599, -9423, -10259, -11096, -11912, -12693, -13430, -14107, -14707, -15211, -15593, -15828, -15886, -15743, -15380, -14784, -13959, -12917, -11685, -10312, -8853, -7369, -5927, -4582, -3382, -2368, -1558, -963, -585, -409, -418, -590, -902, -1334, -1863, -2479, -3167, -3914, -4709, -5534, -6367, -7184, -7950, -8632, -9197, -9609, -9840, -9876, -9706, -9339, -8794, -8106, -7322, -6493, -5676, -4918, -4263, -3745, -3381, -3178, -3131, -3224, -3440, -3759, -4159, -4619, -5122, -5655, -6206, -6766, -7330, -7885, -8416, -8906, -9330, -9661, -9872, -9936, -9833, -9547, -9080, -8442, -7657, -6764, -5812, -4852, -3945, -3142, -2486, -2014, -1744, -1683, -1823, -2150, -2638, -3260, -3990, -4804, -5677, -6597, -7547, -8514, -9490, -10459, -11401, -12298, -13122, -13841, -14430, -14859, -15105, -15156, -15007, -14666, -14154, -13505, -12758, -11959, -11162, -10405, -9729, -9162, -8715, -8393, -8187, -8075, -8036, -8041, -8063, -8079, -8067, -8011, -7897, -7718, -7458, -7111, -6662, -6089, -5377, -4498, -3425, -2143, -581};