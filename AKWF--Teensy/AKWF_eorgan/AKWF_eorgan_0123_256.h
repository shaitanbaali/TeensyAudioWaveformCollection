/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0123 256 samples */
 
const int16_t AKWF_eorgan_0123_256_DATA [256] = 
{2217, 8147, 13431, 18023, 21767, 24600, 26526, 27593, 27920, 27659, 26983, 26044, 24990, 23948, 23014, 22235, 21627, 21193, 20909, 20741, 20666, 20680, 20791, 21029, 21441, 22080, 22974, 24123, 25484, 27007, 28586, 30104, 31419, 32349, 32758, 32572, 31754, 30317, 28320, 25891, 23171, 20323, 17513, 14859, 12469, 10396, 8623, 7108, 5776, 4550, 3353, 2095, 721, -776, -2355, -3936, -5405, -6628, -7496, -7923, -7867, -7332, -6369, -5072, -3565, -2035, -632, 535, 1386, 1903, 2110, 2080, 1914, 1747, 1695, 1850, 2261, 2920, 3791, 4781, 5793, 6746, 7547, 8120, 8421, 8506, 8338, 7954, 7531, 7222, 7186, 7565, 8439, 9842, 11735, 14044, 16639, 19314, 21908, 24294, 26358, 28038, 29294, 30115, 30522, 30560, 30283, 29726, 28902, 27813, 26438, 24746, 22707, 20307, 17550, 14471, 11133, 7667, 4228, 975, -1877, -4119, -5627, -6317, -6186, -5285, -3745, -1743, 470, 2586, 4328, 5489, 5920, 5536, 4326, 2347, -300, -3423, -6804, -10272, -13662, -16837, -19710, -22231, -24387, -26189, -27656, -28824, -29724, -30355, -30712, -30769, -30476, -29784, -28659, -27102, -25144, -22834, -20275, -17586, -14913, -12462, -10387, -8781, -7704, -7144, -7039, -7267, -7672, -8096, -8365, -8378, -8197, -7740, -7034, -6145, -5160, -4159, -3237, -2494, -1986, -1734, -1710, -1838, -2008, -2093, -1973, -1568, -834, 227, 1554, 3046, 4575, 5948, 7026, 7704, 7912, 7633, 6889, 5754, 4329, 2744, 1126, -435, -1875, -3186, -4407, -5617, -6896, -8327, -9985, -11925, -14181, -16723, -19457, -22276, -25029, -27550, -29695, -31319, -32343, -32738, -32518, -31749, -30536, -29063, -27479, -25911, -24471, -23226, -22224, -21482, -20977, -20667, -20500, -20434, -20459, -20570, -20787, -21139, -21657, -22343, -23195, -24176, -25212, -26180, -26945, -27351, -27233, -26430, -24804, -22284, -18848, -14532, -9465, -3681};