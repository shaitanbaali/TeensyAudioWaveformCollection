/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0070 256 samples */
 
const int16_t AKWF_eorgan_0070_256_DATA [256] = 
{238, 1125, 1992, 2856, 3713, 4565, 5412, 6251, 7084, 7908, 8724, 9533, 10333, 11121, 11902, 12672, 13431, 14180, 14918, 15643, 16359, 17061, 17751, 18428, 19094, 19744, 20382, 21005, 21614, 22210, 22791, 23356, 23908, 24444, 24965, 25471, 25959, 26432, 26891, 27333, 27756, 28165, 28556, 28932, 29290, 29630, 29954, 30261, 30550, 30822, 31076, 31313, 31532, 31735, 31918, 32084, 32233, 32362, 32474, 32568, 32644, 32703, 32742, 32764, 32768, 32754, 32722, 32671, 32603, 32516, 32412, 32290, 32149, 31990, 31815, 31621, 31409, 31179, 30933, 30669, 30387, 30087, 29771, 29437, 29086, 28718, 28334, 27932, 27516, 27082, 26629, 26163, 25681, 25182, 24668, 24139, 23593, 23034, 22460, 21870, 21267, 20650, 20017, 19373, 18713, 18041, 17358, 16660, 15950, 15229, 14496, 13751, 12998, 12232, 11455, 10671, 9874, 9070, 8258, 7436, 6607, 5771, 4927, 4077, 3223, 2360, 1493, 623, -251, -1122, -1991, -2857, -3714, -4566, -5413, -6251, -7085, -7909, -8725, -9533, -10333, -11121, -11902, -12673, -13431, -14180, -14918, -15644, -16360, -17062, -17751, -18428, -19094, -19744, -20382, -21006, -21614, -22211, -22791, -23357, -23909, -24445, -24965, -25471, -25960, -26432, -26891, -27333, -27756, -28165, -28556, -28932, -29290, -29631, -29954, -30261, -30551, -30822, -31076, -31313, -31532, -31735, -31918, -32084, -32233, -32362, -32474, -32568, -32644, -32703, -32742, -32764, -32768, -32754, -32722, -32671, -32603, -32516, -32412, -32290, -32149, -31990, -31815, -31621, -31409, -31179, -30933, -30669, -30387, -30087, -29771, -29437, -29087, -28718, -28335, -27932, -27516, -27082, -26629, -26163, -25682, -25183, -24669, -24139, -23593, -23034, -22460, -21870, -21267, -20650, -20018, -19374, -18713, -18042, -17358, -16660, -15951, -15229, -14497, -13752, -12998, -12232, -11455, -10672, -9875, -9071, -8258, -7437, -6608, -5772, -4928, -4078, -3224, -2362, -1498, -611};