/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0012 256 samples */
 
const int16_t AKWF_eorgan_0012_256_DATA [256] = 
{535, 1849, 3122, 4368, 5585, 6780, 7940, 9040, 10096, 11116, 12102, 13071, 13996, 14867, 15713, 16521, 17301, 18053, 18762, 19425, 20077, 20694, 21297, 21902, 22508, 23104, 23704, 24299, 24871, 25433, 25980, 26498, 27000, 27477, 27944, 28372, 28781, 29183, 29550, 29903, 30244, 30561, 30847, 31110, 31363, 31592, 31799, 31999, 32171, 32324, 32447, 32558, 32647, 32704, 32745, 32766, 32761, 32732, 32681, 32627, 32549, 32447, 32321, 32168, 31994, 31804, 31592, 31366, 31110, 30834, 30543, 30229, 29893, 29540, 29172, 28801, 28397, 27987, 27552, 27099, 26632, 26159, 25665, 25153, 24631, 24099, 23558, 23011, 22453, 21881, 21291, 20709, 20107, 19494, 18876, 18235, 17575, 16915, 16240, 15534, 14837, 14115, 13405, 12673, 11926, 11177, 10418, 9659, 8901, 8128, 7342, 6579, 5847, 5086, 4361, 3658, 2960, 2287, 1618, 952, 327, -283, -880, -1454, -2002, -2532, -3053, -3536, -4030, -4487, -4920, -5358, -5768, -6177, -6555, -6942, -7365, -7809, -8250, -8698, -9179, -9659, -10125, -10587, -11050, -11507, -11974, -12418, -12864, -13298, -13731, -14172, -14620, -15059, -15489, -15906, -16327, -16754, -17181, -17603, -18027, -18452, -18856, -19256, -19675, -20086, -20500, -20901, -21288, -21687, -22077, -22470, -22860, -23242, -23617, -23985, -24356, -24715, -25073, -25417, -25749, -26075, -26418, -26733, -27042, -27341, -27636, -27912, -28176, -28446, -28697, -28928, -29150, -29372, -29560, -29740, -29911, -30069, -30219, -30342, -30443, -30534, -30603, -30662, -30698, -30705, -30720, -30699, -30643, -30573, -30499, -30373, -30235, -30068, -29875, -29653, -29408, -29149, -28839, -28512, -28161, -27761, -27333, -26885, -26407, -25883, -25341, -24769, -24159, -23539, -22885, -22204, -21493, -20767, -20003, -19215, -18437, -17642, -16839, -16027, -15222, -14427, -13645, -12845, -12039, -11226, -10386, -9542, -8691, -7799, -6813, -5731, -4564, -3344, -2068, -747};