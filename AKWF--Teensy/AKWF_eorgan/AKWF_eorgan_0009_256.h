/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0009 256 samples */
 
const int16_t AKWF_eorgan_0009_256_DATA [256] = 
{193, 875, 1541, 2216, 2888, 3554, 4214, 4867, 5515, 6157, 6793, 7426, 8054, 8678, 9299, 9918, 10531, 11145, 11757, 12365, 12974, 13583, 14189, 14797, 15403, 16007, 16613, 17217, 17819, 18421, 19018, 19612, 20203, 20788, 21367, 21942, 22505, 23063, 23612, 24149, 24675, 25191, 25691, 26179, 26652, 27108, 27548, 27970, 28373, 28759, 29122, 29466, 29788, 30089, 30367, 30622, 30855, 31063, 31249, 31409, 31546, 31657, 31745, 31808, 31846, 31861, 31852, 31820, 31765, 31687, 31588, 31466, 31325, 31163, 30982, 30781, 30565, 30341, 30123, 29926, 29756, 29621, 29520, 29451, 29406, 29373, 29340, 29292, 29216, 29103, 28942, 28730, 28464, 28143, 27771, 27352, 26889, 26390, 25860, 25301, 24719, 24115, 23492, 22851, 22192, 21514, 20816, 20097, 19355, 18591, 17803, 16989, 16154, 15293, 14408, 13506, 12581, 11638, 10683, 9712, 8734, 7751, 6762, 5774, 4791, 3810, 2839, 1880, 929, -4, -938, -1889, -2832, -3766, -4688, -5593, -6485, -7360, -8217, -9058, -9882, -10686, -11472, -12240, -12985, -13714, -14421, -15106, -15773, -16419, -17045, -17652, -18241, -18811, -19366, -19904, -20426, -20934, -21428, -21908, -22378, -22834, -23280, -23716, -24142, -24559, -24967, -25366, -25756, -26137, -26508, -26871, -27222, -27563, -27893, -28210, -28516, -28808, -29087, -29351, -29600, -29832, -30047, -30244, -30423, -30582, -30721, -30839, -30935, -31008, -31056, -31081, -31082, -31070, -31063, -31075, -31120, -31207, -31338, -31509, -31711, -31933, -32157, -32368, -32546, -32679, -32754, -32763, -32702, -32568, -32368, -32104, -31781, -31409, -30995, -30543, -30060, -29549, -29016, -28460, -27884, -27288, -26669, -26031, -25368, -24685, -23979, -23247, -22495, -21719, -20920, -20104, -19268, -18418, -17556, -16682, -15799, -14915, -14027, -13141, -12263, -11388, -10522, -9668, -8825, -7996, -7182, -6381, -5594, -4825, -4066, -3323, -2595, -1877, -1174, -470};