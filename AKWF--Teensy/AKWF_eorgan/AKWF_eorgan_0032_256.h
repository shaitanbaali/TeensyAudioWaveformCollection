/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0032 256 samples */
 
const int16_t AKWF_eorgan_0032_256_DATA [256] = 
{1473, 6576, 11740, 16784, 21447, 25507, 28758, 31070, 32401, 32780, 32313, 31142, 29447, 27446, 25346, 23336, 21559, 20108, 19034, 18340, 17977, 17867, 17914, 18010, 18059, 17976, 17705, 17213, 16494, 15563, 14457, 13217, 11896, 10555, 9241, 7995, 6866, 5873, 5033, 4358, 3848, 3499, 3302, 3243, 3282, 3096, 2204, 846, -220, -660, -778, -1000, -1442, -2028, -2711, -3556, -4610, -5756, -6754, -7381, -7544, -7210, -6340, -4916, -2982, -699, 1725, 4065, 6108, 7660, 8558, 8698, 8058, 6701, 4754, 2376, -232, -2848, -5275, -7328, -8865, -9818, -10153, -9896, -9116, -7918, -6425, -4771, -3088, -1525, -280, 432, 528, 116, -559, -1253, -1798, -2124, -2270, -2336, -2431, -2627, -2925, -3274, -3602, -3855, -4000, -4027, -3972, -4177, -5134, -6613, -7848, -8462, -8695, -8929, -9240, -9505, -9678, -9837, -10048, -10209, -10089, -9473, -8261, -6421, -3932, -793, 2927, 7030, 11255, 15348, 19056, 22153, 24448, 25817, 26220, 25690, 24337, 22311, 19796, 17006, 14150, 11422, 8973, 6897, 5251, 4039, 3210, 2693, 2390, 2198, 2022, 1782, 1419, 898, 211, -627, -1577, -2600, -3647, -4659, -5594, -6411, -7068, -7547, -7832, -7918, -7807, -7501, -7020, -6379, -5617, -5068, -5212, -5815, -6125, -5810, -5192, -4713, -4519, -4561, -4812, -5347, -6216, -7290, -8299, -8991, -9237, -8973, -8140, -6700, -4689, -2265, 352, 2930, 5238, 7063, 8219, 8578, 8100, 6837, 4908, 2469, -271, -3088, -5773, -8127, -10002, -11318, -12037, -12177, -11800, -11010, -9928, -8685, -7413, -6268, -5452, -5177, -5529, -6398, -7541, -8712, -9741, -10552, -11173, -11695, -12217, -12806, -13461, -14120, -14707, -15160, -15441, -15539, -15497, -15658, -16513, -17837, -18867, -19222, -19146, -19027, -18939, -18759, -18443, -18065, -17687, -17212, -16410, -15069, -13091, -10449, -7132, -3023};