/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0092 256 samples */
 
const int16_t AKWF_eorgan_0092_256_DATA [256] = 
{1188, 3479, 5692, 7872, 9996, 12058, 14054, 15963, 17784, 19510, 21132, 22649, 24058, 25347, 26528, 27595, 28546, 29390, 30123, 30753, 31286, 31724, 32074, 32346, 32545, 32677, 32750, 32769, 32745, 32682, 32583, 32459, 32311, 32150, 31977, 31796, 31611, 31422, 31232, 31041, 30850, 30658, 30466, 30273, 30075, 29871, 29662, 29447, 29221, 28985, 28737, 28479, 28207, 27925, 27628, 27321, 27004, 26678, 26344, 26005, 25664, 25323, 24985, 24653, 24333, 24024, 23734, 23462, 23214, 22988, 22788, 22615, 22466, 22345, 22247, 22173, 22119, 22086, 22067, 22061, 22060, 22062, 22062, 22054, 22029, 22002, 21944, 21836, 21695, 21505, 21269, 20982, 20642, 20247, 19796, 19291, 18731, 18124, 17469, 16768, 16033, 15262, 14461, 13639, 12798, 11949, 11096, 10246, 9405, 8584, 7784, 7013, 6278, 5574, 4912, 4294, 3721, 3191, 2706, 2264, 1864, 1503, 1177, 880, 609, 357, 119, -112, -336, -559, -791, -1034, -1293, -1577, -1890, -2233, -2617, -3041, -3508, -4020, -4577, -5177, -5820, -6505, -7227, -7987, -8772, -9581, -10411, -11254, -12099, -12947, -13784, -14605, -15407, -16180, -16922, -17627, -18288, -18903, -19470, -19983, -20441, -20847, -21195, -21488, -21733, -21927, -22074, -22184, -22247, -22269, -22289, -22293, -22289, -22280, -22271, -22266, -22274, -22295, -22334, -22395, -22477, -22584, -22718, -22876, -23061, -23273, -23507, -23765, -24043, -24338, -24649, -24971, -25299, -25632, -25964, -26295, -26623, -26945, -27256, -27558, -27847, -28126, -28392, -28644, -28885, -29114, -29330, -29538, -29737, -29930, -30120, -30299, -30475, -30656, -30833, -31007, -31182, -31355, -31525, -31690, -31848, -31996, -32129, -32242, -32329, -32383, -32399, -32373, -32295, -32162, -31962, -31694, -31346, -30913, -30389, -29770, -29047, -28216, -27277, -26226, -25062, -23784, -22392, -20892, -19285, -17574, -15767, -13871, -11886, -9830, -7713, -5539, -3328, -1040};