/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0065 256 samples */
 
const int16_t AKWF_eorgan_0065_256_DATA [256] = 
{1703, 5799, 9674, 13329, 16671, 19634, 22171, 24244, 25848, 26997, 27717, 28054, 28068, 27818, 27384, 26832, 26225, 25629, 25087, 24646, 24325, 24147, 24107, 24202, 24423, 24740, 25143, 25608, 26114, 26639, 27173, 27706, 28226, 28732, 29225, 29703, 30164, 30609, 31035, 31435, 31800, 32125, 32401, 32618, 32736, 32768, 32704, 32543, 32289, 31944, 31530, 31059, 30557, 30051, 29562, 29110, 28721, 28406, 28180, 28035, 27975, 27984, 28044, 28131, 28225, 28288, 28298, 28224, 28057, 27777, 27375, 26854, 26218, 25484, 24676, 23805, 22899, 21985, 21092, 20230, 19425, 18677, 17996, 17388, 16837, 16356, 15913, 15492, 15088, 14695, 14297, 13893, 13479, 13054, 12615, 12169, 11709, 11235, 10747, 10230, 9675, 9072, 8388, 7614, 6728, 5706, 4543, 3223, 1743, 128, -1615, -3446, -5310, -7158, -8927, -10539, -11929, -13028, -13770, -14110, -14012, -13452, -12435, -10982, -9139, -6957, -4518, -1917, 770, 3407, 5907, 8185, 10148, 11734, 12901, 13608, 13854, 13652, 13027, 12030, 10715, 9155, 7416, 5568, 3689, 1824, 32, -1644, -3184, -4566, -5789, -6863, -7795, -8604, -9312, -9935, -10499, -11018, -11507, -11974, -12432, -12874, -13310, -13731, -14145, -14549, -14942, -15335, -15731, -16145, -16576, -17036, -17564, -18148, -18801, -19521, -20298, -21134, -22008, -22906, -23805, -24674, -25491, -26239, -26894, -27437, -27861, -28167, -28358, -28443, -28443, -28383, -28281, -28176, -28094, -28056, -28081, -28185, -28375, -28651, -29008, -29430, -29899, -30391, -30887, -31358, -31779, -32136, -32403, -32580, -32661, -32643, -32531, -32320, -32044, -31719, -31345, -30935, -30499, -30045, -29573, -29087, -28587, -28074, -27546, -27011, -26469, -25928, -25407, -24912, -24476, -24113, -23843, -23687, -23660, -23768, -24018, -24394, -24880, -25439, -26019, -26570, -27031, -27325, -27385, -27145, -26542, -25525, -24063, -22139, -19747, -16918, -13694, -10131, -6321, -2260};