/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0060 256 samples */
 
const int16_t AKWF_eorgan_0060_256_DATA [256] = 
{2003, 7699, 13038, 17985, 22372, 26082, 29021, 31119, 32366, 32772, 32391, 31304, 29621, 27477, 25007, 22366, 19708, 17158, 14844, 12873, 11309, 10200, 9563, 9384, 9623, 10204, 11054, 12092, 13203, 14291, 15256, 16016, 16506, 16675, 16500, 15980, 15131, 13997, 12629, 11104, 9492, 7871, 6341, 4959, 3759, 2809, 2129, 1728, 1594, 1700, 2002, 2430, 2947, 3483, 3965, 4342, 4558, 4582, 4392, 3986, 3378, 2594, 1683, 698, -303, -1252, -2087, -2752, -3198, -3391, -3311, -2959, -2350, -1512, -497, 641, 1832, 2996, 4096, 5053, 5809, 6331, 6592, 6589, 6329, 5886, 5253, 4482, 3671, 2888, 2207, 1696, 1410, 1394, 1669, 2237, 3081, 4154, 5396, 6728, 8052, 9274, 10274, 10968, 11275, 11112, 10434, 9210, 7448, 5188, 2483, -571, -3849, -7233, -10568, -13694, -16477, -18769, -20446, -21415, -21609, -20993, -19568, -17377, -14498, -11027, -7117, -2915, 1418, 5682, 9715, 13361, 16461, 18907, 20609, 21508, 21593, 20884, 19436, 17334, 14693, 11655, 8353, 4945, 1593, -1580, -4442, -6887, -8850, -10278, -11156, -11501, -11350, -10780, -9867, -8691, -7372, -6006, -4697, -3530, -2573, -1880, -1478, -1375, -1556, -1984, -2611, -3366, -4182, -4989, -5683, -6212, -6574, -6688, -6538, -6121, -5457, -4573, -3521, -2378, -1179, -3, 1075, 1999, 2713, 3178, 3374, 3295, 2951, 2371, 1598, 685, -307, -1313, -2271, -3122, -3817, -4321, -4612, -4688, -4560, -4259, -3827, -3316, -2796, -2337, -1976, -1789, -1821, -2111, -2672, -3507, -4601, -5894, -7360, -8943, -10550, -12101, -13527, -14748, -15702, -16348, -16654, -16615, -16245, -15587, -14697, -13650, -12544, -11469, -10543, -9848, -9463, -9472, -9919, -10834, -12209, -14007, -16174, -18615, -21209, -23838, -26349, -28590, -30425, -31710, -32328, -32189, -31228, -29419, -26762, -23311, -19147, -14379, -9163, -3530};