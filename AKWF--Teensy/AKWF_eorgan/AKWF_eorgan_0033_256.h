/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0033 256 samples */
 
const int16_t AKWF_eorgan_0033_256_DATA [256] = 
{5177, 17900, 25652, 29419, 30917, 31785, 32341, 32640, 32759, 32744, 32631, 32442, 32195, 31904, 31577, 31224, 30853, 30461, 30058, 29645, 29223, 28794, 28361, 27923, 27481, 27038, 26591, 26143, 25695, 25244, 24794, 24343, 23890, 23438, 22986, 22533, 22081, 21627, 21174, 20722, 20269, 19815, 19363, 18910, 18457, 18006, 17553, 17100, 16649, 16196, 15744, 15294, 14841, 14389, 13938, 13486, 13033, 12583, 12132, 11680, 11229, 10778, 10328, 9877, 9426, 8975, 8525, 8074, 7622, 7173, 6721, 6272, 5820, 5367, 4918, 4467, 4015, 3565, 3114, 2662, 2212, 1761, 1310, 858, 407, -44, -494, -946, -1398, -1849, -2302, -2753, -3205, -3657, -4109, -4561, -5015, -5467, -5919, -6372, -6825, -7278, -7732, -8184, -8638, -9092, -9545, -9999, -10452, -10905, -11357, -11808, -12258, -12705, -13148, -13584, -14012, -14424, -14813, -15170, -15474, -15702, -15811, -15740, -15365, -14758, -12604, -5133, 3273, 11375, 14575, 15197, 15662, 15780, 15703, 15498, 15207, 14860, 14476, 14068, 13644, 13209, 12767, 12321, 11872, 11421, 10968, 10516, 10062, 9609, 9156, 8702, 8248, 7796, 7342, 6889, 6436, 5982, 5530, 5078, 4625, 4173, 3721, 3268, 2817, 2365, 1912, 1461, 1009, 557, 107, -344, -796, -1247, -1698, -2149, -2599, -3051, -3503, -3952, -4404, -4855, -5305, -5756, -6209, -6658, -7109, -7560, -8011, -8462, -8912, -9363, -9815, -10265, -10715, -11167, -11618, -12069, -12520, -12971, -13422, -13874, -14325, -14778, -15230, -15681, -16133, -16585, -17037, -17489, -17942, -18394, -18847, -19300, -19752, -20205, -20658, -21110, -21563, -22016, -22469, -22922, -23374, -23826, -24279, -24730, -25180, -25631, -26079, -26527, -26973, -27417, -27859, -28297, -28730, -29159, -29580, -29994, -30397, -30788, -31162, -31515, -31842, -32135, -32385, -32578, -32698, -32721, -32617, -32338, -31815, -30994, -29585, -25834, -19127, -7064};