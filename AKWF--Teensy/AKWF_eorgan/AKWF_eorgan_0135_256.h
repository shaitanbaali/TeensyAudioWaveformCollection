/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0135 256 samples */
 
const int16_t AKWF_eorgan_0135_256_DATA [256] = 
{2996, 7892, 12790, 17526, 21853, 25584, 28577, 30753, 32117, 32721, 32671, 32104, 31169, 30011, 28749, 27476, 26249, 25086, 23980, 22913, 21842, 20746, 19609, 18427, 17223, 16033, 14891, 13838, 12899, 12078, 11362, 10710, 10059, 9345, 8495, 7454, 6191, 4696, 3002, 1179, -693, -2510, -4164, -5576, -6682, -7459, -7929, -8152, -8220, -8249, -8356, -8649, -9204, -10060, -11204, -12588, -14111, -15647, -17069, -18244, -19072, -19490, -19484, -19089, -18386, -17493, -16543, -15669, -14988, -14580, -14482, -14681, -15117, -15696, -16295, -16792, -17071, -17046, -16667, -15933, -14887, -13602, -12185, -10751, -9408, -8246, -7327, -6669, -6259, -6048, -5964, -5926, -5853, -5681, -5367, -4899, -4288, -3575, -2810, -2049, -1345, -736, -238, 149, 450, 692, 909, 1124, 1341, 1546, 1698, 1734, 1581, 1164, 426, -664, -2101, -3826, -5728, -7665, -9450, -10886, -11791, -12002, -11407, -9961, -7692, -4700, -1142, 2751, 6745, 10596, 14059, 16954, 19148, 20569, 21222, 21166, 20513, 19399, 17981, 16407, 14795, 13245, 11817, 10525, 9369, 8327, 7361, 6448, 5571, 4727, 3939, 3238, 2659, 2237, 1998, 1943, 2053, 2281, 2568, 2838, 3017, 3045, 2882, 2520, 1982, 1327, 640, 17, -446, -671, -601, -220, 444, 1329, 2331, 3335, 4217, 4863, 5194, 5168, 4787, 4104, 3214, 2237, 1301, 534, 36, -130, 46, 528, 1238, 2056, 2851, 3492, 3862, 3882, 3520, 2790, 1754, 513, -809, -2086, -3197, -4049, -4592, -4814, -4756, -4489, -4110, -3730, -3448, -3355, -3500, -3900, -4534, -5346, -6263, -7194, -8054, -8778, -9314, -9645, -9782, -9759, -9622, -9427, -9222, -9042, -8904, -8801, -8711, -8606, -8451, -8223, -7917, -7550, -7162, -6821, -6600, -6575, -6809, -7336, -8151, -9201, -10380, -11550, -12526, -13121, -13153, -12467, -10959, -8588, -5396, -1374};