/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0055 256 samples */
 
const int16_t AKWF_eorgan_0055_256_DATA [256] = 
{1024, 3136, 5194, 7235, 9245, 11219, 13149, 15020, 16831, 18575, 20237, 21820, 23315, 24709, 26009, 27203, 28286, 29258, 30114, 30852, 31472, 31970, 32346, 32602, 32738, 32755, 32654, 32437, 32112, 31676, 31138, 30503, 29770, 28953, 28052, 27077, 26035, 24932, 23773, 22571, 21329, 20056, 18767, 17462, 16149, 14844, 13549, 12272, 11025, 9811, 8639, 7520, 6456, 5454, 4524, 3666, 2890, 2198, 1595, 1084, 669, 352, 135, 19, 5, 93, 282, 572, 960, 1445, 2022, 2688, 3441, 4276, 5184, 6164, 7210, 8310, 9464, 10664, 11896, 13161, 14447, 15745, 17044, 18399, 19713, 20977, 22219, 23420, 24581, 25687, 26733, 27714, 28620, 29444, 30185, 30830, 31377, 31824, 32162, 32391, 32504, 32501, 32378, 32138, 31776, 31291, 30686, 29963, 29121, 28162, 27093, 25913, 24627, 23243, 21761, 20189, 18537, 16803, 15000, 13136, 11213, 9246, 7239, 5197, 3137, 1064, -1017, -3092, -5155, -7200, -9211, -11186, -13117, -14989, -16802, -18547, -20211, -21796, -23293, -24689, -25991, -27188, -28272, -29248, -30107, -30847, -31469, -31971, -32349, -32608, -32746, -32764, -32667, -32454, -32130, -31697, -31161, -30527, -29797, -28982, -28084, -27109, -26068, -24965, -23808, -22607, -21365, -20099, -18780, -17420, -16115, -14809, -13513, -12238, -10991, -9778, -8609, -7492, -6429, -5430, -4500, -3646, -2871, -2181, -1580, -1073, -661, -346, -132, -18, -8, -98, -290, -583, -973, -1459, -2040, -2708, -3463, -4300, -5210, -6193, -7240, -8342, -9497, -10699, -11931, -13197, -14483, -15781, -17086, -18385, -19671, -20942, -22183, -23385, -24547, -25655, -26701, -27684, -28591, -29418, -30160, -30807, -31356, -31805, -32147, -32377, -32493, -32493, -32373, -32134, -31775, -31294, -30691, -29971, -29130, -28175, -27109, -25930, -24647, -23266, -21786, -20215, -18565, -16834, -15031, -13170, -11247, -9281, -7276, -5238, -3183, -1072};