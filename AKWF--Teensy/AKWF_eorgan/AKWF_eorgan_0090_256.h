/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0090 256 samples */
 
const int16_t AKWF_eorgan_0090_256_DATA [256] = 
{1296, 4132, 6821, 9420, 11910, 14285, 16535, 18647, 20622, 22456, 24139, 25675, 27063, 28293, 29376, 30306, 31084, 31713, 32194, 32528, 32719, 32769, 32680, 32457, 32105, 31627, 31026, 30311, 29489, 28561, 27544, 26441, 25270, 24098, 22950, 21831, 20753, 19717, 18728, 17792, 16905, 16071, 15294, 14568, 13893, 13272, 12700, 12177, 11705, 11279, 10900, 10569, 10282, 10043, 9849, 9701, 9598, 9541, 9528, 9559, 9630, 9741, 9886, 10063, 10265, 10461, 10638, 10791, 10915, 11008, 11066, 11089, 11073, 11019, 10925, 10789, 10612, 10392, 10125, 9812, 9451, 9036, 8567, 8045, 7459, 6819, 6115, 5333, 4482, 3563, 2569, 1506, 378, -818, -2070, -3376, -4720, -6036, -7300, -8506, -9641, -10702, -11685, -12579, -13384, -14094, -14703, -15211, -15613, -15904, -16083, -16148, -16096, -15924, -15632, -15218, -14680, -14020, -13236, -12329, -11303, -10159, -8898, -7529, -6059, -4488, -2834, -1104, 684, 2428, 4095, 5682, 7171, 8561, 9842, 11008, 12058, 12989, 13795, 14480, 15042, 15480, 15797, 15991, 16067, 16024, 15867, 15597, 15216, 14728, 14138, 13445, 12657, 11779, 10810, 9763, 8640, 7444, 6190, 4880, 3533, 2214, 945, -266, -1412, -2492, -3504, -4442, -5309, -6108, -6833, -7488, -8087, -8625, -9107, -9534, -9909, -10234, -10513, -10745, -10933, -11079, -11182, -11247, -11273, -11259, -11209, -11126, -11010, -10864, -10693, -10502, -10296, -10104, -9943, -9816, -9728, -9680, -9675, -9714, -9798, -9927, -10102, -10324, -10591, -10903, -11263, -11670, -12122, -12623, -13175, -13776, -14430, -15134, -15889, -16701, -17565, -18479, -19448, -20461, -21519, -22619, -23749, -24905, -26070, -27178, -28202, -29138, -29971, -30698, -31312, -31804, -32173, -32413, -32519, -32488, -32318, -32003, -31543, -30936, -30181, -29273, -28214, -27006, -25642, -24128, -22468, -20657, -18702, -16612, -14382, -12026, -9553, -6967, -4290, -1467};