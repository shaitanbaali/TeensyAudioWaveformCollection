/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0019 256 samples */
 
const int16_t AKWF_eorgan_0019_256_DATA [256] = 
{956, 3232, 5666, 7890, 10149, 12346, 14463, 16479, 18399, 20217, 21919, 23507, 24974, 26312, 27527, 28619, 29584, 30426, 31145, 31735, 32197, 32527, 32718, 32769, 32669, 32429, 32263, 32025, 31570, 30928, 30181, 29389, 28570, 27689, 26784, 25808, 24812, 23814, 22827, 21866, 20930, 20022, 19152, 18323, 17539, 16806, 16115, 15472, 14874, 14321, 13813, 13353, 12942, 12585, 12287, 12055, 11898, 11804, 11563, 11324, 11231, 11256, 11320, 11367, 11375, 11369, 11362, 11347, 11307, 11221, 11075, 10863, 10584, 10238, 9822, 9333, 8770, 8138, 7437, 6672, 5850, 4971, 4038, 3058, 2024, 940, -194, -1387, -2641, -3941, -5077, -6190, -7424, -8751, -10083, -11379, -12578, -13744, -14858, -15922, -16914, -17813, -18604, -19276, -19830, -20262, -20568, -20745, -20792, -20708, -20499, -20166, -19716, -19149, -18470, -17681, -16780, -15770, -14650, -13415, -12062, -10609, -9263, -7889, -6344, -4658, -2905, -1269, 605, 2391, 3944, 5698, 7338, 8920, 10429, 11848, 13178, 14412, 15537, 16552, 17453, 18233, 18895, 19441, 19867, 20178, 20373, 20449, 20405, 20238, 19943, 19516, 18946, 18251, 17636, 16961, 16079, 15020, 13867, 12679, 11468, 10250, 8957, 7647, 6322, 5002, 3706, 2448, 1227, 48, -1080, -2157, -3177, -4135, -5036, -5878, -6661, -7390, -8059, -8668, -9216, -9697, -10106, -10438, -10682, -10849, -11152, -11441, -11570, -11571, -11517, -11471, -11452, -11433, -11404, -11369, -11348, -11362, -11424, -11538, -11709, -11935, -12218, -12563, -12970, -13435, -13958, -14532, -15152, -15818, -16525, -17270, -18057, -18883, -19750, -20663, -21627, -22626, -23450, -24242, -25144, -26127, -27108, -28009, -28864, -29623, -30338, -30996, -31570, -32041, -32393, -32618, -32715, -32682, -32515, -32210, -31765, -31184, -30468, -29620, -28649, -27553, -26337, -25005, -23554, -21987, -20306, -18503, -16575, -14543, -12612, -10646, -8504, -6217, -3872, -1467};