/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0120 256 samples */
 
const int16_t AKWF_eorgan_0120_256_DATA [256] = 
{1644, 5523, 9031, 12276, 15247, 17952, 20401, 22591, 24542, 26263, 27757, 29041, 30121, 31003, 31701, 32219, 32562, 32739, 32754, 32612, 32317, 31871, 31282, 30551, 29684, 28679, 27531, 26245, 24818, 23244, 21530, 19669, 17685, 15722, 13835, 12023, 10302, 8666, 7119, 5663, 4289, 2993, 1779, 641, -424, -1400, -2297, -3117, -3863, -4544, -5158, -5702, -6180, -6587, -6919, -7174, -7345, -7425, -7411, -7296, -7072, -6736, -6286, -5714, -5035, -4364, -3742, -3165, -2631, -2137, -1678, -1250, -848, -464, -96, 259, 604, 939, 1265, 1580, 1878, 2158, 2409, 2626, 2792, 2927, 2969, 2871, 2645, 2275, 1748, 1053, 181, -876, -2102, -3498, -5029, -6533, -7957, -9304, -10564, -11742, -12837, -13844, -14766, -15602, -16345, -16997, -17547, -17987, -18317, -18532, -18625, -18593, -18428, -18126, -17678, -17081, -16327, -15406, -14318, -13053, -11601, -9966, -8139, -6115, -3905, -1501, 1055, 3496, 5742, 7803, 9668, 11343, 12831, 14133, 15259, 16214, 17001, 17632, 18110, 18442, 18635, 18694, 18627, 18436, 18128, 17708, 17179, 16546, 15816, 14994, 14085, 13090, 12007, 10840, 9589, 8252, 6838, 5342, 3794, 2355, 1086, -16, -934, -1673, -2242, -2649, -2910, -3039, -3035, -2912, -2759, -2557, -2315, -2044, -1753, -1445, -1124, -794, -454, -104, 256, 634, 1030, 1448, 1898, 2380, 2900, 3466, 4074, 4731, 5417, 6020, 6500, 6864, 7114, 7255, 7293, 7235, 7084, 6849, 6535, 6145, 5683, 5155, 4558, 3894, 3164, 2361, 1484, 529, -513, -1630, -2819, -4090, -5436, -6865, -8384, -9989, -11682, -13465, -15325, -17262, -19243, -21125, -22859, -24454, -25903, -27209, -28377, -29404, -30293, -31046, -31657, -32128, -32451, -32620, -32634, -32488, -32176, -31692, -31029, -30183, -29140, -27896, -26443, -24766, -22859, -20716, -18315, -15659, -12738, -9543, -6082, -2257};