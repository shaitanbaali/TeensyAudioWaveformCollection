/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0104 256 samples */
 
const int16_t AKWF_eorgan_0104_256_DATA [256] = 
{1033, 3281, 5405, 7449, 9396, 11240, 12975, 14588, 16082, 17453, 18694, 19807, 20792, 21642, 22362, 22950, 23405, 23728, 23917, 23974, 23899, 23692, 23355, 22888, 22296, 21579, 20741, 19788, 18728, 17564, 16310, 14974, 13578, 12210, 10902, 9663, 8508, 7440, 6467, 5596, 4829, 4170, 3622, 3184, 2859, 2649, 2553, 2572, 2705, 2954, 3317, 3794, 4386, 5092, 5908, 6837, 7874, 9014, 10259, 11600, 13028, 14544, 16129, 17780, 19471, 21116, 22681, 24159, 25534, 26805, 27961, 28996, 29909, 30695, 31353, 31879, 32274, 32535, 32666, 32662, 32524, 32253, 31848, 31311, 30640, 29837, 28905, 27841, 26651, 25339, 23901, 22351, 20694, 18931, 17079, 15146, 13151, 11185, 9280, 7442, 5690, 4026, 2453, 986, -378, -1635, -2778, -3811, -4731, -5535, -6224, -6800, -7257, -7600, -7828, -7938, -7934, -7814, -7583, -7236, -6781, -6218, -5548, -4782, -3923, -2976, -1954, -865, 272, 1376, 2418, 3386, 4267, 5059, 5754, 6342, 6826, 7201, 7462, 7611, 7644, 7562, 7366, 7051, 6624, 6080, 5420, 4645, 3755, 2751, 1638, 409, -927, -2365, -3909, -5548, -7278, -9093, -10977, -12925, -14917, -16860, -18723, -20501, -22174, -23742, -25197, -26530, -27740, -28825, -29779, -30604, -31297, -31856, -32283, -32576, -32736, -32763, -32656, -32415, -32043, -31537, -30902, -30136, -29245, -28230, -27091, -25840, -24481, -23016, -21463, -19829, -18134, -16466, -14861, -13322, -11869, -10504, -9232, -8064, -6998, -6040, -5195, -4459, -3838, -3330, -2937, -2658, -2494, -2445, -2511, -2692, -2986, -3392, -3911, -4542, -5282, -6124, -7071, -8112, -9244, -10460, -11747, -13098, -14490, -15836, -17101, -18279, -19357, -20326, -21184, -21920, -22533, -23021, -23379, -23608, -23705, -23672, -23505, -23204, -22773, -22207, -21510, -20683, -19721, -18629, -17410, -16062, -14589, -12997, -11282, -9457, -7528, -5500, -3389, -1153};