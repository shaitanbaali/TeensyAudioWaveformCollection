/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0095 256 samples */
 
const int16_t AKWF_eorgan_0095_256_DATA [256] = 
{1291, 3894, 6374, 8782, 11096, 13310, 15416, 17395, 19253, 20980, 22569, 24027, 25350, 26538, 27600, 28537, 29353, 30060, 30663, 31169, 31589, 31929, 32197, 32406, 32561, 32669, 32736, 32765, 32764, 32731, 32674, 32592, 32487, 32363, 32221, 32064, 31886, 31689, 31468, 31226, 30957, 30660, 30338, 29986, 29599, 29180, 28728, 28244, 27727, 27180, 26604, 26002, 25371, 24716, 24037, 23333, 22607, 21858, 21085, 20289, 19470, 18624, 17754, 16856, 15939, 15045, 14184, 13350, 12545, 11767, 11013, 10286, 9581, 8898, 8239, 7600, 6984, 6391, 5819, 5268, 4741, 4234, 3749, 3285, 2838, 2416, 2006, 1597, 1196, 797, 396, -8, -419, -840, -1274, -1721, -2184, -2659, -3143, -3638, -4140, -4649, -5160, -5669, -6174, -6665, -7136, -7579, -7986, -8346, -8653, -8897, -9071, -9166, -9176, -9094, -8916, -8641, -8264, -7784, -7206, -6531, -5760, -4904, -3969, -2960, -1893, -776, 378, 1505, 2582, 3604, 4556, 5431, 6221, 6918, 7520, 8023, 8423, 8722, 8922, 9025, 9035, 8959, 8802, 8572, 8277, 7926, 7526, 7087, 6618, 6127, 5622, 5109, 4593, 4080, 3572, 3071, 2580, 2100, 1631, 1177, 738, 312, -102, -509, -912, -1312, -1713, -2121, -2531, -2948, -3391, -3851, -4332, -4836, -5359, -5907, -6476, -7066, -7681, -8317, -8973, -9655, -10359, -11083, -11836, -12611, -13413, -14245, -15103, -15992, -16904, -17795, -18659, -19498, -20308, -21096, -21861, -22601, -23319, -24015, -24685, -25333, -25958, -26552, -27122, -27664, -28173, -28653, -29102, -29516, -29899, -30247, -30561, -30852, -31115, -31350, -31562, -31751, -31917, -32066, -32195, -32307, -32401, -32471, -32518, -32537, -32530, -32490, -32413, -32297, -32135, -31922, -31650, -31309, -30891, -30390, -29794, -29095, -28290, -27366, -26320, -25148, -23841, -22402, -20830, -19121, -17281, -15316, -13225, -11023, -8719, -6317, -3842, -1243};