/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0041 256 samples */
 
const int16_t AKWF_eorgan_0041_256_DATA [256] = 
{346, 1354, 2557, 3996, 5095, 5403, 5492, 5870, 6708, 7760, 8888, 9999, 11011, 11875, 12575, 13090, 13418, 13560, 13520, 13315, 12958, 12458, 11834, 11098, 10277, 9377, 8409, 7385, 6314, 5200, 4062, 2895, 1712, 522, -669, -1824, -3090, -7883, -14102, -15628, -15052, -16851, -20855, -21663, -19755, -18123, -16621, -17544, -23409, -26551, -24541, -22178, -20822, -19269, -17223, -14919, -12539, -10159, -11078, -15546, -16316, -13254, -9834, -6757, -3874, -1104, 1536, 4042, 6048, 6977, 7727, 8826, 10054, 11205, 12191, 12947, 13277, 13452, 14067, 12571, 4279, -2403, -448, 3068, 5492, 7288, 8744, 9761, 10343, 10982, 10337, 9245, 7181, 3170, 2023, 3941, 5582, 6384, 7398, 8716, 10084, 11474, 12322, 12105, 11894, 12089, 12447, 12788, 13037, 13133, 13267, 11551, 5588, 1697, 2374, 3687, 4398, 4778, 5004, 5110, 5102, 4990, 1569, -5782, -9312, -8478, -7215, -6336, -5607, -4923, -4286, -3678, -3437, -4157, -4923, -5191, -5169, -5042, -4886, -4737, -4622, -4614, -4288, -8335, -22583, -32883, -29970, -24929, -21190, -18092, -15175, -12350, -9575, -7550, -8317, -9681, -9458, -8130, -6329, -4350, -2305, -311, 1549, 3257, 4635, 2594, -1428, -1145, 1618, 3866, 5470, 6690, 7413, 7953, 8820, 7980, 3731, 410, 1374, 3176, 4450, 5374, 5907, 6427, 7181, 7773, 7544, 7072, 6970, 7117, 7345, 7570, 7731, 8013, 6919, 2208, -444, -115, 646, 1362, 1905, 2381, 2804, 3189, 3388, 2709, 1876, -489, -9671, -17312, -15535, -11921, -9221, -7021, -4977, -3036, -1208, 121, -262, -1149, -1130, -437, 508, 1509, 2458, 3294, 3860, 4252, 4684, 2844, -944, -1409, 526, 1983, 2864, 3322, 3830, 4443, 5164, 4030, -417, -3777, -2985, -1291, 25, 622, -2516, -6065, -4988, -2306, -3221, -8214, -9733, -6963, -3816, -1209};