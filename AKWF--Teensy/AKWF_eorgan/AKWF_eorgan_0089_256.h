/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0089 256 samples */
 
const int16_t AKWF_eorgan_0089_256_DATA [256] = 
{1300, 4286, 7112, 9838, 12441, 14915, 17251, 19431, 21458, 23326, 25024, 26560, 27925, 29117, 30141, 30996, 31680, 32197, 32548, 32734, 32761, 32630, 32343, 31907, 31327, 30607, 29751, 28768, 27665, 26447, 25130, 23719, 22234, 20753, 19304, 17892, 16532, 15226, 13977, 12794, 11674, 10618, 9631, 8707, 7847, 7053, 6320, 5648, 5038, 4486, 3992, 3558, 3179, 2859, 2595, 2388, 2238, 2143, 2105, 2120, 2187, 2302, 2462, 2662, 2895, 3127, 3339, 3528, 3689, 3816, 3910, 3965, 3982, 3958, 3893, 3784, 3630, 3432, 3184, 2888, 2540, 2136, 1675, 1153, 566, -79, -795, -1596, -2470, -3421, -4451, -5557, -6735, -7984, -9296, -10663, -12069, -13439, -14744, -15977, -17126, -18184, -19147, -20003, -20752, -21388, -21903, -22297, -22563, -22699, -22701, -22566, -22293, -21878, -21320, -20618, -19768, -18773, -17633, -16346, -14917, -13351, -11644, -9811, -7857, -5785, -3612, -1348, 981, 3260, 5446, 7537, 9511, 11365, 13095, 14685, 16138, 17451, 18616, 19637, 20513, 21241, 21825, 22265, 22563, 22721, 22743, 22630, 22385, 22012, 21515, 20898, 20168, 19327, 18379, 17334, 16197, 14974, 13677, 12314, 10901, 9516, 8187, 6916, 5716, 4588, 3535, 2562, 1664, 842, 103, -562, -1169, -1708, -2187, -2608, -2973, -3285, -3547, -3760, -3928, -4051, -4130, -4166, -4163, -4120, -4039, -3923, -3774, -3595, -3390, -3167, -2931, -2716, -2540, -2406, -2322, -2289, -2309, -2385, -2515, -2702, -2946, -3247, -3606, -4021, -4493, -5025, -5613, -6264, -6975, -7747, -8585, -9485, -10448, -11482, -12579, -13738, -14964, -16248, -17586, -18977, -20408, -21872, -23352, -24771, -26099, -27328, -28444, -29444, -30317, -31056, -31657, -32114, -32422, -32578, -32576, -32414, -32090, -31599, -30945, -30117, -29120, -27957, -26619, -25113, -23442, -21602, -19601, -17447, -15135, -12685, -10102, -7393, -4582, -1613};