/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0113 256 samples */
 
const int16_t AKWF_eorgan_0113_256_DATA [256] = 
{1389, 3595, 5621, 7531, 9318, 10993, 12555, 14009, 15364, 16621, 17784, 18862, 19857, 20771, 21615, 22388, 23092, 23739, 24325, 24859, 25342, 25774, 26164, 26513, 26824, 27100, 27341, 27552, 27737, 27896, 28035, 28153, 28253, 28343, 28420, 28492, 28559, 28619, 28681, 28742, 28804, 28871, 28942, 29017, 29100, 29190, 29288, 29395, 29509, 29633, 29765, 29904, 30051, 30204, 30363, 30527, 30695, 30865, 31037, 31210, 31380, 31547, 31709, 31865, 32014, 32152, 32278, 32391, 32489, 32570, 32635, 32681, 32707, 32714, 32700, 32662, 32602, 32520, 32412, 32280, 32121, 31935, 31723, 31483, 31215, 30917, 30588, 30231, 29844, 29425, 28975, 28494, 27983, 27440, 26867, 26264, 25632, 24974, 24293, 23585, 22861, 22114, 21348, 20571, 19776, 18970, 18155, 17330, 16498, 15663, 14823, 13983, 13142, 12299, 11456, 10616, 9775, 8934, 8092, 7248, 6399, 5544, 4680, 3804, 2911, 1994, 1055, 85, -893, -1835, -2747, -3637, -4501, -5349, -6186, -7011, -7831, -8648, -9461, -10274, -11088, -11900, -12715, -13532, -14350, -15167, -15982, -16794, -17605, -18408, -19203, -19992, -20768, -21532, -22282, -23012, -23727, -24421, -25091, -25741, -26365, -26960, -27526, -28064, -28572, -29047, -29495, -29909, -30294, -30652, -30977, -31274, -31541, -31779, -31992, -32177, -32334, -32467, -32574, -32657, -32717, -32754, -32767, -32761, -32733, -32688, -32621, -32538, -32440, -32326, -32197, -32057, -31904, -31744, -31577, -31405, -31230, -31053, -30875, -30699, -30524, -30351, -30185, -30025, -29869, -29721, -29582, -29450, -29327, -29211, -29102, -29003, -28913, -28827, -28749, -28674, -28602, -28535, -28464, -28395, -28321, -28244, -28159, -28064, -27956, -27834, -27689, -27524, -27335, -27118, -26871, -26593, -26276, -25922, -25528, -25088, -24599, -24060, -23466, -22813, -22098, -21317, -20464, -19539, -18532, -17442, -16265, -14990, -13619, -12147, -10560, -8864, -7050, -5114, -3056, -819};