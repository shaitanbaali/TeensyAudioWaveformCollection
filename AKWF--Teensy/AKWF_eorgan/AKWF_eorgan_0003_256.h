/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0003 256 samples */
 
const int16_t AKWF_eorgan_0003_256_DATA [256] = 
{162, 713, 1242, 1770, 2290, 2807, 3324, 3850, 4395, 4965, 5578, 6258, 7021, 7869, 8811, 9849, 10978, 12200, 13512, 14902, 16341, 17808, 19280, 20734, 22135, 23454, 24692, 25753, 26609, 27518, 28268, 28794, 29190, 29457, 29591, 29629, 29602, 29534, 29449, 29358, 29272, 29220, 29208, 29269, 29412, 29622, 29903, 30241, 30619, 31029, 31450, 31859, 32238, 32558, 32757, 32658, 32480, 32275, 32039, 31698, 31009, 30123, 29092, 27915, 26606, 25189, 23688, 22100, 20463, 18792, 17112, 15449, 13821, 12231, 10713, 9274, 7921, 6670, 5491, 4392, 3362, 2368, 1396, 457, -452, -1291, -2065, -2799, -3500, -4190, -4885, -5593, -6326, -7076, -7801, -8505, -9189, -9860, -10534, -11206, -11885, -12581, -13293, -14003, -14694, -15364, -16012, -16645, -17264, -17865, -18444, -18991, -19513, -20018, -20502, -20963, -21395, -21787, -22136, -22449, -22720, -22958, -23178, -23399, -23630, -23872, -24126, -24401, -24688, -24977, -25255, -25520, -25767, -25995, -26188, -26334, -26416, -26425, -26337, -26130, -25790, -25309, -24684, -23916, -23005, -21955, -20768, -19464, -18073, -16619, -15130, -13634, -12167, -10767, -9441, -8282, -7328, -6326, -5488, -4889, -4438, -4152, -4033, -4074, -4235, -4478, -4776, -5092, -5403, -5681, -5884, -5996, -6000, -5906, -5720, -5445, -5090, -4666, -4181, -3657, -3123, -2596, -2098, -1663, -1321, -1082, -935, -874, -887, -965, -1103, -1293, -1527, -1791, -2076, -2369, -2652, -2907, -3128, -3305, -3439, -3526, -3557, -3523, -3418, -3248, -3014, -2722, -2383, -2033, -1701, -1393, -1090, -796, -510, -265, -74, 56, 116, 97, -5, -173, -378, -600, -853, -1143, -1479, -1857, -2278, -2744, -3251, -3768, -4269, -4739, -5174, -5579, -5951, -6270, -6517, -6681, -6761, -6756, -6670, -6511, -6272, -5955, -5571, -5118, -4601, -4026, -3412, -2791, -2168, -1555, -963, -377};