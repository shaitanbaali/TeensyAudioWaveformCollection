/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0117 256 samples */
 
const int16_t AKWF_eorgan_0117_256_DATA [256] = 
{1468, 5023, 8302, 11395, 14276, 16948, 19410, 21648, 23674, 25489, 27089, 28486, 29679, 30670, 31467, 32072, 32487, 32718, 32764, 32628, 32313, 31822, 31156, 30313, 29299, 28115, 26756, 25231, 23541, 21683, 19670, 17504, 15205, 12886, 10590, 8324, 6107, 3942, 1834, -198, -2141, -3975, -5694, -7293, -8750, -10059, -11227, -12255, -13142, -13893, -14509, -14986, -15328, -15533, -15600, -15526, -15310, -14951, -14445, -13791, -12992, -12042, -10948, -9709, -8345, -6959, -5595, -4249, -2935, -1653, -403, 803, 1963, 3074, 4133, 5147, 6114, 7029, 7897, 8714, 9473, 10175, 10811, 11377, 11860, 12295, 12605, 12738, 12723, 12549, 12209, 11703, 11027, 10180, 9167, 7990, 6670, 5321, 3987, 2674, 1399, 166, -1012, -2118, -3152, -4107, -4980, -5770, -6474, -7085, -7607, -8035, -8365, -8597, -8729, -8758, -8682, -8499, -8209, -7808, -7297, -6678, -5949, -5114, -4175, -3136, -2010, -797, 477, 1708, 2854, 3916, 4878, 5739, 6494, 7138, 7675, 8102, 8418, 8628, 8729, 8725, 8619, 8409, 8102, 7697, 7196, 6605, 5921, 5150, 4294, 3355, 2338, 1247, 81, -1142, -2411, -3718, -5050, -6399, -7738, -8952, -10001, -10886, -11600, -12143, -12519, -12729, -12777, -12676, -12409, -11988, -11521, -10975, -10353, -9666, -8921, -8116, -7259, -6356, -5399, -4396, -3347, -2247, -1098, 98, 1340, 2615, 3921, 5260, 6620, 8002, 9379, 10648, 11772, 12753, 13583, 14266, 14802, 15191, 15436, 15538, 15499, 15323, 15008, 14558, 13972, 13248, 12391, 11393, 10254, 8977, 7552, 5984, 4294, 2488, 575, -1434, -3521, -5665, -7863, -10114, -12396, -14702, -17008, -19199, -21237, -23122, -24840, -26395, -27782, -28997, -30043, -30916, -31615, -32139, -32488, -32657, -32645, -32452, -32073, -31504, -30746, -29793, -28640, -27285, -25725, -23952, -21968, -19773, -17355, -14725, -11884, -8833, -5590, -2078};