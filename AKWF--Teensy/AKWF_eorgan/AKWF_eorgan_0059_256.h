/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0059 256 samples */
 
const int16_t AKWF_eorgan_0059_256_DATA [256] = 
{1735, 6312, 10669, 14823, 18677, 22163, 25219, 27785, 29834, 31346, 32310, 32742, 32663, 32115, 31145, 29813, 28192, 26347, 24357, 22303, 20248, 18266, 16419, 14754, 13316, 12136, 11226, 10596, 10242, 10139, 10264, 10578, 11040, 11602, 12210, 12818, 13370, 13825, 14143, 14287, 14235, 13967, 13495, 12815, 11910, 10830, 9597, 8249, 6831, 5379, 3943, 2569, 1292, 155, -809, -1582, -2143, -2483, -2605, -2518, -2239, -1790, -1206, -521, 229, 1001, 1758, 2462, 3078, 3578, 3944, 4155, 4209, 4107, 3860, 3486, 3008, 2461, 1877, 1297, 759, 302, -36, -224, -242, -23, 382, 967, 1753, 2714, 3827, 5051, 6343, 7660, 8938, 10128, 11176, 12023, 12621, 12933, 12920, 12560, 11837, 10759, 9328, 7574, 5539, 3262, 804, -1759, -4368, -6943, -9396, -11664, -13669, -15341, -16630, -17486, -17876, -17781, -17196, -16131, -14609, -12675, -10380, -7781, -4965, -2002, 1044, 4033, 6903, 9578, 11972, 14023, 15676, 16882, 17615, 17859, 17614, 16895, 15731, 14167, 12253, 10051, 7643, 5091, 2477, -113, -2618, -4964, -7084, -8937, -10474, -11667, -12505, -12977, -13098, -12884, -12370, -11593, -10600, -9446, -8184, -6868, -5558, -4302, -3142, -2126, -1276, -622, -147, 142, 187, 57, -234, -654, -1167, -1737, -2322, -2885, -3388, -3798, -4087, -4238, -4236, -4075, -3759, -3302, -2723, -2045, -1304, -535, 224, 932, 1550, 2042, 2375, 2524, 2467, 2194, 1701, 991, 85, -1002, -2240, -3588, -5011, -6464, -7897, -9273, -10547, -11678, -12642, -13386, -13926, -14261, -14377, -14290, -14020, -13601, -13069, -12466, -11846, -11256, -10747, -10370, -10169, -10183, -10443, -10970, -11775, -12853, -14195, -15775, -17548, -19474, -21494, -23533, -25532, -27410, -29088, -30498, -31570, -32238, -32450, -32166, -31356, -30001, -28106, -25689, -22769, -19405, -15654, -11580, -7277, -2727};