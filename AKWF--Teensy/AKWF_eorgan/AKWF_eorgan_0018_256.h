/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0018 256 samples */
 
const int16_t AKWF_eorgan_0018_256_DATA [256] = 
{892, 2877, 5038, 6974, 8962, 10905, 12791, 14607, 16362, 18055, 19678, 21230, 22705, 24091, 25395, 26608, 27722, 28738, 29648, 30443, 31121, 31675, 32098, 32390, 32540, 32562, 32692, 32771, 32644, 32345, 31956, 31543, 31119, 30639, 30136, 29552, 28933, 28289, 27629, 26956, 26266, 25558, 24838, 24109, 23373, 22639, 21906, 21179, 20463, 19760, 19077, 18423, 17801, 17217, 16679, 16189, 15761, 15377, 14806, 14209, 13743, 13373, 13022, 12627, 12178, 11699, 11211, 10721, 10219, 9686, 9118, 8520, 7892, 7240, 6566, 5867, 5143, 4395, 3620, 2820, 1999, 1149, 269, -637, -1581, -2558, -3572, -4629, -5730, -6857, -7778, -8648, -9619, -10661, -11683, -12644, -13479, -14268, -14997, -15676, -16292, -16828, -17276, -17635, -17911, -18103, -18212, -18235, -18172, -18019, -17777, -17448, -17028, -16516, -15911, -15212, -14413, -13515, -12517, -11416, -10208, -8914, -7767, -6615, -5305, -3874, -2397, -1068, 505, 1968, 3172, 4598, 5916, 7192, 8419, 9588, 10703, 11764, 12761, 13692, 14554, 15336, 16040, 16661, 17191, 17631, 17973, 18211, 18340, 18356, 18252, 18026, 17667, 17196, 16839, 16444, 15854, 15103, 14275, 13432, 12583, 11737, 10815, 9869, 8892, 7900, 6904, 5910, 4911, 3909, 2908, 1909, 919, -56, -1018, -1961, -2879, -3771, -4628, -5443, -6214, -6933, -7592, -8189, -8712, -9175, -9813, -10464, -10970, -11367, -11731, -12126, -12563, -13017, -13463, -13900, -14337, -14790, -15266, -15760, -16270, -16791, -17321, -17864, -18420, -18987, -19568, -20160, -20764, -21383, -22019, -22671, -23346, -24045, -24768, -25521, -26308, -27108, -27692, -28213, -28824, -29495, -30136, -30667, -31130, -31479, -31776, -32014, -32176, -32249, -32222, -32096, -31876, -31564, -31160, -30662, -30065, -29373, -28582, -27694, -26709, -25624, -24438, -23150, -21755, -20254, -18648, -16930, -15099, -13178, -11395, -9602, -7647, -5563, -3442, -1290};