/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0100 256 samples */
 
const int16_t AKWF_eorgan_0100_256_DATA [256] = 
{2268, 8377, 13746, 18242, 21669, 23962, 25159, 25389, 24865, 23857, 22613, 21321, 20130, 19099, 18219, 17437, 16681, 15913, 15088, 14169, 13147, 12062, 10955, 9881, 8946, 8271, 7945, 8011, 8482, 9345, 10559, 12066, 13774, 15491, 17086, 18495, 19656, 20542, 21139, 21459, 21553, 21515, 21434, 21358, 21253, 21149, 21033, 20859, 20555, 20076, 19349, 18292, 16868, 15109, 13129, 11098, 9250, 7865, 7187, 7394, 8581, 10745, 13759, 17411, 21392, 25188, 28424, 30858, 32322, 32776, 32274, 30967, 29076, 26880, 24639, 22538, 20727, 19265, 18133, 17270, 16591, 16044, 15564, 15091, 14592, 14095, 13582, 13060, 12618, 12354, 12332, 12581, 13094, 13846, 14787, 15855, 16952, 17883, 18524, 18813, 18702, 18171, 17221, 15890, 14238, 12388, 10455, 8510, 6590, 4750, 2990, 1289, -395, -2102, -3888, -5820, -7934, -10190, -12474, -14615, -16388, -17520, -17775, -16991, -15092, -12099, -8162, -3519, 1505, 6331, 10551, 13906, 16201, 17375, 17465, 16606, 15009, 12942, 10659, 8343, 6144, 4126, 2273, 535, -1156, -2842, -4565, -6366, -8254, -10183, -12114, -13997, -15722, -17165, -18244, -18908, -19148, -18981, -18440, -17588, -16515, -15415, -14415, -13584, -12981, -12633, -12554, -12732, -13117, -13616, -14135, -14631, -15136, -15619, -16095, -16611, -17235, -18012, -19020, -20336, -21999, -23977, -26157, -28367, -30374, -31897, -32694, -32583, -31474, -29367, -26388, -22752, -18769, -14947, -11666, -9167, -7617, -7058, -7434, -8594, -10317, -12326, -14361, -16233, -17795, -18990, -19832, -20387, -20738, -20936, -21047, -21133, -21224, -21292, -21357, -21410, -21364, -21122, -20615, -19820, -18742, -17404, -15856, -14166, -12425, -10831, -9507, -8515, -7906, -7697, -7887, -8442, -9295, -10330, -11430, -12522, -13568, -14520, -15371, -16146, -16888, -17631, -18437, -19375, -20472, -21699, -22936, -24013, -24705, -24742, -23885, -21975, -18937, -14798, -9709, -3773};