/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0105 256 samples */
 
const int16_t AKWF_eorgan_0105_256_DATA [256] = 
{1371, 4290, 7043, 9690, 12212, 14605, 16864, 18975, 20943, 22764, 24429, 25946, 27311, 28519, 29578, 30483, 31235, 31838, 32290, 32591, 32746, 32754, 32615, 32334, 31913, 31355, 30663, 29844, 28905, 27849, 26690, 25436, 24106, 22780, 21488, 20236, 19040, 17902, 16830, 15830, 14904, 14056, 13290, 12603, 12000, 11482, 11048, 10698, 10435, 10257, 10165, 10157, 10234, 10397, 10643, 10973, 11383, 11871, 12437, 13073, 13775, 14539, 15353, 16213, 17097, 17930, 18681, 19344, 19910, 20373, 20731, 20978, 21110, 21130, 21037, 20830, 20509, 20079, 19538, 18887, 18134, 17275, 16314, 15258, 14103, 12854, 11519, 10096, 8606, 7057, 5441, 3771, 2052, 284, -1515, -3344, -5182, -6952, -8624, -10191, -11640, -12968, -14173, -15244, -16183, -16984, -17649, -18176, -18564, -18814, -18926, -18899, -18736, -18437, -18004, -17437, -16735, -15905, -14947, -13860, -12653, -11329, -9887, -8340, -6693, -4951, -3129, -1236, 707, 2614, 4452, 6212, 7879, 9448, 10913, 12261, 13493, 14604, 15586, 16442, 17170, 17763, 18222, 18548, 18736, 18788, 18702, 18479, 18116, 17614, 16976, 16197, 15283, 14236, 13055, 11747, 10319, 8770, 7115, 5361, 3524, 1685, -127, -1908, -3641, -5329, -6962, -8530, -10039, -11480, -12832, -14097, -15269, -16343, -17322, -18200, -18971, -19638, -20198, -20648, -20986, -21211, -21322, -21320, -21204, -20974, -20634, -20184, -19634, -18982, -18241, -17418, -16531, -15654, -14823, -14039, -13315, -12657, -12068, -11556, -11121, -10766, -10495, -10307, -10204, -10185, -10253, -10406, -10643, -10966, -11374, -11868, -12445, -13105, -13848, -14672, -15574, -16550, -17600, -18715, -19891, -21125, -22400, -23711, -25038, -26302, -27472, -28542, -29496, -30332, -31040, -31616, -32056, -32358, -32514, -32527, -32392, -32110, -31678, -31095, -30361, -29475, -28436, -27246, -25900, -24402, -22754, -20951, -18999, -16904, -14661, -12281, -9771, -7135, -4391, -1478};