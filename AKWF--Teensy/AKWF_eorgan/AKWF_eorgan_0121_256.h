/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0121 256 samples */
 
const int16_t AKWF_eorgan_0121_256_DATA [256] = 
{1670, 5723, 9402, 12809, 15927, 18760, 21312, 23579, 25578, 27315, 28792, 30025, 31020, 31782, 32325, 32652, 32770, 32688, 32409, 31941, 31283, 30444, 29432, 28250, 26905, 25394, 23713, 21870, 19859, 17676, 15332, 12821, 10179, 7623, 5237, 3021, 995, -840, -2465, -3879, -5105, -6156, -7039, -7771, -8383, -8874, -9257, -9540, -9727, -9822, -9824, -9733, -9547, -9261, -8869, -8362, -7730, -6967, -6058, -4997, -3772, -2371, -793, 970, 2862, 4671, 6331, 7858, 9249, 10515, 11667, 12710, 13654, 14510, 15282, 15979, 16605, 17162, 17652, 18076, 18429, 18707, 18905, 19012, 19015, 18923, 18693, 18284, 17702, 16930, 15947, 14744, 13308, 11622, 9686, 7486, 5054, 2605, 218, -2081, -4248, -6286, -8199, -9976, -11628, -13149, -14537, -15788, -16892, -17839, -18631, -19260, -19718, -20000, -20103, -20016, -19732, -19246, -18550, -17635, -16495, -15126, -13516, -11667, -9578, -7240, -4671, -1867, 1125, 3985, 6607, 8999, 11145, 13052, 14720, 16144, 17339, 18308, 19055, 19592, 19924, 20057, 20000, 19760, 19342, 18752, 17998, 17085, 16015, 14793, 13433, 11936, 10308, 8553, 6662, 4646, 2500, 220, -2158, -4600, -7060, -9322, -11316, -13059, -14550, -15805, -16836, -17653, -18275, -18720, -18990, -19103, -19120, -19031, -18850, -18584, -18242, -17829, -17348, -16802, -16186, -15500, -14740, -13898, -12967, -11943, -10810, -9565, -8198, -6697, -5063, -3284, -1391, 409, 2027, 3467, 4727, 5821, 6760, 7551, 8208, 8740, 9154, 9460, 9665, 9775, 9790, 9714, 9547, 9285, 8923, 8457, 7873, 7170, 6328, 5318, 4137, 2773, 1201, -581, -2557, -4724, -7064, -9575, -12207, -14743, -17112, -19321, -21357, -23227, -24934, -26471, -27845, -29057, -30099, -30971, -31665, -32171, -32488, -32612, -32537, -32254, -31759, -31044, -30100, -28919, -27496, -25817, -23876, -21667, -19175, -16402, -13345, -9998, -6376, -2382};