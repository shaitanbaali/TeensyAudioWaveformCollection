/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0005 256 samples */
 
const int16_t AKWF_eorgan_0005_256_DATA [256] = 
{204, 958, 1712, 2484, 3261, 4041, 4823, 5602, 6379, 7152, 7918, 8674, 9421, 10155, 10875, 11579, 12264, 12933, 13583, 14210, 14819, 15407, 15974, 16522, 17049, 17556, 18045, 18513, 18964, 19398, 19813, 20211, 20594, 20961, 21313, 21651, 21974, 22283, 22580, 22872, 23169, 23477, 23804, 24156, 24538, 24945, 25377, 25830, 26295, 26768, 27239, 27700, 28149, 28580, 28989, 29376, 29739, 30079, 30396, 30693, 30971, 31231, 31473, 31697, 31905, 32093, 32261, 32410, 32534, 32635, 32709, 32754, 32768, 32750, 32698, 32611, 32487, 32324, 32126, 31889, 31614, 31304, 30958, 30577, 30163, 29716, 29240, 28734, 28200, 27641, 27055, 26448, 25821, 25172, 24504, 23821, 23119, 22403, 21675, 20932, 20181, 19418, 18647, 17868, 17084, 16292, 15499, 14700, 13901, 13103, 12302, 11503, 10707, 9913, 9122, 8336, 7553, 6774, 6003, 5233, 4471, 3714, 2960, 2213, 1470, 731, -5, -759, -1528, -2298, -3070, -3844, -4615, -5388, -6162, -6934, -7709, -8483, -9254, -10026, -10797, -11564, -12332, -13096, -13853, -14609, -15360, -16105, -16844, -17575, -18299, -19015, -19720, -20413, -21097, -21766, -22421, -23061, -23683, -24288, -24876, -25442, -25987, -26513, -27013, -27491, -27945, -28372, -28775, -29151, -29498, -29819, -30112, -30376, -30613, -30820, -31000, -31151, -31276, -31371, -31440, -31482, -31500, -31489, -31455, -31396, -31314, -31209, -31080, -30932, -30763, -30575, -30368, -30144, -29904, -29650, -29381, -29097, -28802, -28496, -28178, -27851, -27515, -27168, -26813, -26450, -26078, -25700, -25314, -24923, -24526, -24124, -23714, -23299, -22881, -22456, -22026, -21592, -21150, -20704, -20253, -19796, -19333, -18865, -18396, -17934, -17486, -17058, -16651, -16266, -15897, -15541, -15185, -14820, -14438, -14028, -13586, -13107, -12586, -12024, -11424, -10788, -10123, -9433, -8721, -7994, -7260, -6515, -5768, -5020, -4269, -3518, -2770, -2023, -1278, -520};