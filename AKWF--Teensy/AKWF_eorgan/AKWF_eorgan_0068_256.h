/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0068 256 samples */
 
const int16_t AKWF_eorgan_0068_256_DATA [256] = 
{1249, 4025, 6715, 9360, 11932, 14416, 16793, 19037, 21144, 23097, 24881, 26494, 27925, 29166, 30223, 31092, 31773, 32272, 32597, 32751, 32749, 32599, 32312, 31901, 31379, 30763, 30059, 29288, 28461, 27586, 26682, 25755, 24815, 23873, 22937, 22010, 21099, 20207, 19337, 18493, 17671, 16871, 16103, 15357, 14621, 13905, 13202, 12510, 11832, 11162, 10501, 9848, 9204, 8571, 7952, 7348, 6765, 6206, 5677, 5186, 4738, 4340, 4000, 3726, 3522, 3398, 3359, 3410, 3556, 3801, 4147, 4594, 5143, 5792, 6535, 7372, 8292, 9287, 10350, 11471, 12633, 13828, 15041, 16256, 17456, 18684, 19844, 20920, 21931, 22857, 23690, 24416, 25027, 25517, 25876, 26104, 26196, 26152, 25973, 25663, 25226, 24670, 23999, 23229, 22363, 21418, 20406, 19334, 18218, 17075, 15910, 14737, 13570, 12415, 11284, 10185, 9121, 8099, 7125, 6195, 5313, 4480, 3686, 2934, 2216, 1525, 855, 201, -437, -1089, -1752, -2435, -3140, -3879, -4657, -5474, -6337, -7248, -8203, -9205, -10251, -11331, -12446, -13588, -14742, -15906, -17066, -18206, -19323, -20398, -21418, -22375, -23254, -24041, -24731, -25310, -25771, -26108, -26314, -26386, -26322, -26124, -25791, -25328, -24741, -24037, -23224, -22315, -21316, -20250, -19095, -17869, -16668, -15447, -14224, -13015, -11837, -10697, -9609, -8590, -7642, -6777, -6003, -5323, -4744, -4265, -3889, -3615, -3441, -3363, -3377, -3479, -3662, -3918, -4242, -4627, -5063, -5545, -6066, -6620, -7198, -7800, -8416, -9047, -9689, -10339, -10998, -11665, -12338, -13024, -13720, -14429, -15155, -15888, -16643, -17429, -18235, -19063, -19915, -20790, -21681, -22592, -23512, -24437, -25364, -26278, -27173, -28040, -28864, -29634, -30340, -30964, -31494, -31920, -32224, -32396, -32424, -32296, -32004, -31538, -30894, -30063, -29045, -27843, -26451, -24878, -23132, -21214, -19141, -16927, -14577, -12118, -9565, -6934, -4253, -1483};