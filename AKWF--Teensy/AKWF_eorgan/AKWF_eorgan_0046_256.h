/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0046 256 samples */
 
const int16_t AKWF_eorgan_0046_256_DATA [256] = 
{1991, 5771, 9198, 12513, 15413, 17692, 19534, 22171, 25404, 27984, 29996, 31441, 32321, 32903, 32037, 26730, 25987, 24962, 23534, 21867, 19912, 17989, 14910, 7880, 5308, 3000, 791, -1444, -3827, -5414, -9021, -14712, -14832, -15224, -15392, -15419, -15324, -15121, -14807, -15720, -17195, -18013, -18472, -18539, -18274, -17424, -16904, -20794, -19412, -17668, -15929, -13997, -12027, -9697, -8948, -11204, -8778, -6335, -4042, -1900, -38, 2158, 2218, -647, 1595, 3458, 5047, 6204, 7217, 8276, 8888, 10605, 13347, 15701, 17777, 19560, 21005, 22302, 22632, 18045, 18394, 18584, 18449, 18349, 18073, 17949, 16038, 11156, 10951, 10727, 9972, 9041, 7815, 6990, 3673, -2014, -2305, -3200, -4078, -4997, -5949, -6918, -7844, -10064, -13076, -15621, -17770, -19573, -21084, -22110, -23823, -29165, -28997, -28468, -27594, -26192, -24451, -22141, -20693, -22440, -19440, -16030, -12702, -9383, -6307, -2525, -1497, -2429, 2166, 5730, 9188, 12522, 15415, 17686, 19526, 22155, 25407, 27987, 29996, 31435, 32316, 32899, 32047, 26732, 25989, 24966, 23542, 21865, 19910, 17974, 14993, 7921, 5306, 2992, 783, -1440, -3828, -5368, -9224, -14859, -14792, -15226, -15387, -15416, -15319, -15120, -14804, -15711, -17187, -18008, -18471, -18535, -18275, -17423, -16928, -20790, -19417, -17677, -15937, -14007, -12025, -9715, -8837, -11161, -8801, -6334, -4046, -1910, -59, 2175, 2064, -765, 1617, 3439, 5039, 6200, 7216, 8273, 8884, 10591, 13333, 15698, 17782, 19561, 20995, 22297, 22617, 18051, 18400, 18587, 18455, 18356, 18080, 17950, 16073, 11174, 10952, 10734, 9976, 9049, 7829, 6980, 3763, -1952, -2324, -3195, -4078, -4998, -5944, -6922, -7844, -10054, -13066, -15619, -17775, -19577, -21078, -22111, -23792, -29158, -28999, -28468, -27598, -26200, -24454, -22138, -20691, -22452, -19448, -16043, -12695, -9371, -6305, -2553, -1481, -2350};