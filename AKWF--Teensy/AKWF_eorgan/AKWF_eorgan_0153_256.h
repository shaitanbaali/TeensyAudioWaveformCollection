/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0153 256 samples */
 
const int16_t AKWF_eorgan_0153_256_DATA [256] = 
{1162, 2987, 4871, 6836, 8863, 10931, 13012, 15071, 17092, 19051, 20923, 22699, 24361, 25891, 27287, 28535, 29626, 30560, 31331, 31935, 32375, 32651, 32765, 32721, 32525, 32183, 31701, 31088, 30355, 29509, 28563, 27529, 26415, 25238, 24007, 22734, 21437, 20125, 18811, 17515, 16242, 15005, 13818, 12685, 11615, 10619, 9694, 8850, 8089, 7409, 6809, 6293, 5854, 5492, 5205, 4985, 4832, 4740, 4703, 4718, 4778, 4880, 5018, 5187, 5382, 5599, 5833, 6080, 6336, 6594, 6849, 7097, 7333, 7550, 7747, 7918, 8061, 8171, 8245, 8279, 8270, 8216, 8111, 7954, 7740, 7465, 7129, 6726, 6255, 5714, 5098, 4407, 3640, 2794, 1871, 871, -207, -1354, -2572, -3855, -5192, -6579, -8001, -9439, -10881, -12314, -13717, -15082, -16393, -17633, -18798, -19872, -20841, -21701, -22439, -23048, -23522, -23855, -24040, -24076, -23960, -23692, -23270, -22698, -21980, -21117, -20120, -18995, -17748, -16396, -14945, -13409, -11808, -10158, -8485, -6819, -5175, -3576, -2045, -593, 763, 2008, 3134, 4132, 4988, 5703, 6270, 6684, 6948, 7060, 7021, 6836, 6508, 6043, 5447, 4730, 3902, 2968, 1943, 837, -337, -1566, -2839, -4144, -5460, -6772, -8063, -9313, -10513, -11650, -12710, -13690, -14583, -15380, -16084, -16689, -17193, -17601, -17912, -18129, -18255, -18292, -18245, -18117, -17914, -17640, -17298, -16896, -16436, -15923, -15364, -14761, -14119, -13443, -12739, -12007, -11255, -10487, -9709, -8928, -8145, -7367, -6602, -5850, -5117, -4408, -3727, -3077, -2466, -1894, -1367, -892, -468, -102, 199, 437, 607, 706, 731, 681, 553, 350, 71, -282, -707, -1198, -1749, -2356, -3007, -3697, -4413, -5141, -5872, -6595, -7294, -7961, -8581, -9144, -9641, -10059, -10387, -10618, -10743, -10752, -10640, -10401, -10030, -9522, -8875, -8090, -7161, -6095, -4894, -3559, -2102, -488};