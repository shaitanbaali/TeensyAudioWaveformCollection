/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0072 256 samples */
 
const int16_t AKWF_eorgan_0072_256_DATA [256] = 
{1013, 3099, 5111, 7091, 9026, 10914, 12750, 14521, 16231, 17874, 19441, 20935, 22350, 23679, 24929, 26090, 27160, 28143, 29033, 29829, 30532, 31140, 31650, 32066, 32386, 32609, 32736, 32768, 32707, 32549, 32301, 31962, 31532, 31017, 30417, 29733, 28972, 28135, 27225, 26249, 25209, 24109, 22958, 21765, 20554, 19337, 18112, 16886, 15668, 14456, 13258, 12079, 10918, 9781, 8673, 7593, 6548, 5539, 4565, 3634, 2746, 1901, 1103, 355, -342, -977, -1547, -2051, -2488, -2857, -3157, -3388, -3552, -3648, -3676, -3637, -3534, -3366, -3137, -2848, -2504, -2105, -1656, -1160, -625, -16, 596, 1186, 1778, 2361, 2933, 3489, 4027, 4544, 5036, 5499, 5933, 6336, 6704, 7038, 7335, 7593, 7812, 7992, 8129, 8227, 8282, 8294, 8264, 8192, 8076, 7918, 7718, 7475, 7192, 6868, 6504, 6102, 5663, 5188, 4678, 4138, 3566, 2968, 2345, 1699, 1036, 359, -329, -1009, -1675, -2325, -2952, -3556, -4133, -4679, -5196, -5678, -6125, -6536, -6908, -7239, -7532, -7783, -7991, -8159, -8283, -8365, -8404, -8400, -8355, -8266, -8137, -7966, -7756, -7505, -7217, -6891, -6530, -6135, -5706, -5250, -4765, -4253, -3720, -3168, -2599, -2018, -1429, -839, -228, 387, 927, 1430, 1887, 2295, 2649, 2948, 3187, 3366, 3481, 3532, 3517, 3434, 3283, 3065, 2778, 2423, 2000, 1510, 954, 333, -350, -1084, -1867, -2698, -3572, -4490, -5450, -6446, -7478, -8545, -9639, -10763, -11914, -13082, -14270, -15472, -16680, -17897, -19114, -20324, -21528, -22716, -23866, -24968, -26011, -26988, -27902, -28743, -29508, -30197, -30803, -31325, -31761, -32107, -32363, -32527, -32598, -32574, -32455, -32241, -31930, -31522, -31021, -30422, -29728, -28942, -28060, -27087, -26025, -24872, -23633, -22310, -20903, -19418, -17859, -16223, -14520, -12754, -10925, -9043, -7112, -5136, -3127, -1044};