/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0114 256 samples */
 
const int16_t AKWF_eorgan_0114_256_DATA [256] = 
{1703, 4887, 7705, 10263, 12565, 14636, 16494, 18148, 19624, 20934, 22088, 23106, 23998, 24768, 25432, 25995, 26465, 26847, 27144, 27363, 27507, 27577, 27576, 27507, 27370, 27164, 26893, 26558, 26159, 25698, 25176, 24595, 23967, 23322, 22677, 22041, 21426, 20837, 20282, 19773, 19316, 18919, 18589, 18325, 18139, 18029, 17999, 18053, 18186, 18402, 18696, 19064, 19505, 20013, 20581, 21204, 21875, 22584, 23324, 24087, 24864, 25650, 26432, 27204, 27956, 28659, 29304, 29891, 30419, 30890, 31307, 31664, 31969, 32220, 32419, 32566, 32664, 32710, 32707, 32652, 32546, 32387, 32172, 31902, 31574, 31182, 30725, 30197, 29597, 28917, 28154, 27302, 26358, 25315, 24170, 22921, 21564, 20141, 18661, 17133, 15574, 13989, 12389, 10798, 9217, 7665, 6160, 4709, 3328, 2033, 830, -265, -1214, -2013, -2669, -3185, -3574, -3838, -3983, -4014, -3936, -3753, -3473, -3099, -2640, -2105, -1503, -842, -137, 557, 1194, 1766, 2263, 2675, 2993, 3212, 3328, 3333, 3222, 2994, 2641, 2156, 1535, 770, -143, -1187, -2340, -3588, -4923, -6331, -7796, -9310, -10857, -12420, -13993, -15555, -17097, -18610, -20079, -21494, -22849, -24105, -25255, -26306, -27256, -28114, -28888, -29575, -30183, -30718, -31182, -31581, -31916, -32193, -32415, -32581, -32693, -32756, -32766, -32727, -32638, -32499, -32307, -32064, -31768, -31419, -31011, -30549, -30030, -29451, -28813, -28119, -27371, -26597, -25813, -25022, -24236, -23461, -22708, -21985, -21297, -20656, -20067, -19537, -19073, -18680, -18361, -18121, -17961, -17882, -17885, -17969, -18134, -18373, -18683, -19062, -19502, -19994, -20534, -21113, -21720, -22351, -22992, -23636, -24271, -24859, -25390, -25865, -26275, -26621, -26902, -27117, -27264, -27343, -27352, -27290, -27153, -26942, -26650, -26274, -25813, -25253, -24594, -23828, -22942, -21929, -20779, -19473, -18000, -16348, -14494, -12424, -10121, -7561, -4739, -1548};