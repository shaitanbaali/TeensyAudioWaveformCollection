/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0025 256 samples */
 
const int16_t AKWF_eorgan_0025_256_DATA [256] = 
{1189, 3421, 5627, 7804, 9930, 12021, 14059, 16024, 17916, 19724, 21424, 23038, 24546, 25935, 27209, 28355, 29372, 30263, 31020, 31640, 32127, 32474, 32689, 32769, 32718, 32537, 32233, 31810, 31268, 30615, 29860, 29005, 28062, 27032, 25925, 24746, 23509, 22219, 20886, 19510, 18103, 16675, 15232, 13790, 12339, 10899, 9468, 8062, 6682, 5322, 4001, 2723, 1482, 297, -845, -1940, -2980, -3966, -4896, -5771, -6593, -7362, -8076, -8739, -9349, -9913, -10431, -10907, -11341, -11735, -12093, -12418, -12716, -12987, -13232, -13453, -13659, -13847, -14019, -14179, -14328, -14468, -14601, -14726, -14845, -14958, -15064, -15166, -15261, -15349, -15429, -15502, -15561, -15611, -15648, -15668, -15673, -15658, -15621, -15560, -15476, -15364, -15223, -15050, -14845, -14604, -14329, -14020, -13670, -13282, -12853, -12387, -11884, -11342, -10760, -10144, -9490, -8800, -8087, -7338, -6561, -5759, -4934, -4092, -3238, -2364, -1483, -596, 294, 1177, 2059, 2937, 3800, 4648, 5481, 6285, 7071, 7831, 8559, 9260, 9922, 10550, 11145, 11701, 12218, 12699, 13136, 13537, 13902, 14226, 14512, 14764, 14982, 15165, 15317, 15439, 15532, 15600, 15646, 15668, 15671, 15655, 15624, 15579, 15522, 15453, 15375, 15290, 15198, 15099, 14993, 14882, 14765, 14643, 14513, 14376, 14231, 14075, 13906, 13724, 13526, 13309, 13072, 12812, 12526, 12210, 11861, 11479, 11060, 10601, 10099, 9551, 8954, 8309, 7615, 6866, 6063, 5205, 4291, 3330, 2308, 1231, 107, -1070, -2289, -3551, -4860, -6206, -7579, -8984, -10401, -11836, -13286, -14738, -16183, -17615, -19024, -20411, -21764, -23073, -24330, -25524, -26656, -27713, -28691, -29578, -30367, -31053, -31634, -32100, -32448, -32671, -32766, -32732, -32564, -32261, -31822, -31250, -30543, -29697, -28722, -27618, -26383, -25042, -23575, -21998, -20320, -18543, -16683, -14752, -12736, -10662, -8538, -6376, -4243, -1724};