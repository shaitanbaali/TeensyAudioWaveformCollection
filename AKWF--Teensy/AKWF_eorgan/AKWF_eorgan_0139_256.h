/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0139 256 samples */
 
const int16_t AKWF_eorgan_0139_256_DATA [256] = 
{1812, 5758, 9385, 12703, 15627, 18105, 20100, 21574, 22529, 22970, 22911, 22380, 21417, 20072, 18391, 16440, 14295, 12019, 9690, 7385, 5167, 3112, 1282, -280, -1533, -2457, -3041, -3280, -3190, -2796, -2132, -1236, -146, 1091, 2435, 3839, 5258, 6656, 7998, 9240, 10356, 11313, 12076, 12620, 12924, 12975, 12776, 12341, 11707, 10920, 10041, 9147, 8314, 7624, 7154, 6961, 7080, 7523, 8293, 9365, 10695, 12224, 13881, 15592, 17288, 18898, 20362, 21634, 22673, 23451, 23956, 24182, 24139, 23844, 23319, 22591, 21695, 20666, 19535, 18347, 17146, 15971, 14863, 13861, 12993, 12295, 11788, 11483, 11381, 11468, 11729, 12139, 12661, 13254, 13872, 14468, 15004, 15440, 15743, 15882, 15838, 15599, 15155, 14506, 13652, 12599, 11360, 9938, 8351, 6634, 4811, 2935, 1069, -721, -2351, -3733, -4784, -5418, -5561, -5165, -4214, -2719, -697, 1791, 4666, 7838, 11188, 14604, 17980, 21194, 24155, 26778, 28982, 30715, 31937, 32618, 32751, 32347, 31421, 29998, 28118, 25838, 23201, 20276, 17141, 13858, 10510, 7180, 3923, 822, -2054, -4671, -6978, -8952, -10586, -11870, -12818, -13458, -13817, -13932, -13845, -13594, -13225, -12782, -12306, -11836, -11406, -11056, -10814, -10711, -10782, -11054, -11544, -12263, -13212, -14374, -15712, -17182, -18718, -20245, -21690, -22965, -23995, -24725, -25119, -25161, -24851, -24214, -23293, -22147, -20849, -19469, -18078, -16750, -15539, -14494, -13659, -13058, -12704, -12605, -12749, -13120, -13697, -14453, -15352, -16360, -17448, -18570, -19681, -20745, -21721, -22570, -23263, -23765, -24058, -24129, -23979, -23622, -23072, -22356, -21513, -20581, -19611, -18648, -17729, -16899, -16189, -15628, -15240, -15037, -15026, -15213, -15595, -16165, -16916, -17842, -18924, -20132, -21438, -22793, -24133, -25393, -26488, -27333, -27842, -27931, -27528, -26580, -25075, -23020, -20430, -17368, -13910, -10149, -6203, -2094};