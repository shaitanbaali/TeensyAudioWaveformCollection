/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0111 256 samples */
 
const int16_t AKWF_eorgan_0111_256_DATA [256] = 
{1104, 3134, 5093, 7023, 8911, 10752, 12546, 14277, 15946, 17552, 19085, 20545, 21928, 23229, 24450, 25590, 26641, 27609, 28489, 29282, 29991, 30616, 31152, 31611, 31989, 32286, 32511, 32664, 32748, 32768, 32731, 32636, 32492, 32307, 32090, 31843, 31571, 31282, 30976, 30660, 30336, 30008, 29682, 29359, 29041, 28733, 28438, 28155, 27888, 27636, 27402, 27187, 26988, 26809, 26650, 26507, 26380, 26268, 26172, 26086, 26011, 25944, 25881, 25819, 25758, 25693, 25624, 25544, 25452, 25346, 25222, 25078, 24911, 24718, 24499, 24251, 23974, 23666, 23324, 22952, 22545, 22102, 21626, 21119, 20577, 20007, 19406, 18769, 18105, 17414, 16697, 15959, 15204, 14431, 13645, 12852, 12051, 11256, 10470, 9696, 8937, 8199, 7480, 6789, 6123, 5489, 4886, 4318, 3781, 3281, 2819, 2392, 2005, 1652, 1337, 1058, 812, 600, 420, 270, 145, 47, -30, -88, -133, -165, -190, -213, -232, -247, -266, -290, -325, -374, -442, -529, -641, -781, -947, -1146, -1379, -1644, -1946, -2286, -2661, -3072, -3521, -4007, -4529, -5088, -5677, -6300, -6954, -7634, -8342, -9071, -9820, -10588, -11367, -12156, -12950, -13741, -14524, -15295, -16051, -16788, -17506, -18196, -18862, -19501, -20107, -20677, -21222, -21732, -22210, -22654, -23064, -23441, -23785, -24095, -24375, -24623, -24842, -25036, -25203, -25345, -25469, -25573, -25661, -25736, -25802, -25860, -25914, -25967, -26021, -26078, -26141, -26215, -26299, -26397, -26509, -26639, -26785, -26948, -27130, -27329, -27548, -27785, -28037, -28304, -28584, -28877, -29180, -29490, -29802, -30116, -30429, -30731, -31026, -31307, -31569, -31807, -32016, -32195, -32334, -32425, -32462, -32439, -32355, -32203, -31979, -31683, -31308, -30853, -30319, -29698, -28993, -28205, -27328, -26365, -25318, -24185, -22967, -21670, -20289, -18833, -17305, -15702, -14034, -12306, -10514, -8671, -6784, -4853, -2891, -859};