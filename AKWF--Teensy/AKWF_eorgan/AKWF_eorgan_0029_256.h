/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0029 256 samples */
 
const int16_t AKWF_eorgan_0029_256_DATA [256] = 
{2040, 4949, 6669, 8064, 9292, 10440, 11495, 12672, 14672, 16212, 17369, 18397, 19339, 20226, 20995, 22060, 23207, 22359, 22264, 22605, 23079, 23620, 24190, 24776, 25368, 25960, 26545, 27110, 27644, 28154, 28502, 29566, 31544, 31700, 31178, 31533, 31772, 31859, 31728, 31501, 31225, 30921, 30602, 30265, 29914, 29534, 29201, 28444, 26602, 24151, 22744, 21867, 21171, 20554, 20035, 19243, 17490, 15625, 13898, 13159, 14415, 14743, 14728, 15874, 16623, 16258, 15787, 15212, 14574, 13858, 13247, 12120, 4161, -1778, -3741, -4732, -5285, -5689, -6073, -6356, -7159, -9166, -10318, -11012, -11549, -12003, -12411, -12798, -13171, -13533, -13883, -14211, -14509, -14751, -15014, -15261, -14063, -14193, -14962, -14771, -14643, -14512, -14369, -14208, -14023, -13814, -13578, -13320, -13044, -12652, -12120, -11568, -10784, -11822, -12412, -11773, -11525, -11308, -10791, -8803, -5921, -4927, -3950, -3727, -4969, -5262, -4561, -1697, 2577, 4943, 6325, 7365, 8224, 8996, 9670, 10463, 12073, 13222, 13988, 14624, 15175, 15637, 16165, 16265, 10519, 6621, 6372, 6602, 7010, 7463, 7919, 8367, 8804, 9226, 9630, 10007, 10348, 10662, 10813, 11682, 13463, 13428, 12715, 12881, 12935, 12840, 12529, 12125, 11674, 11198, 10705, 10198, 9677, 9126, 8623, 7695, 5686, 3065, 1491, 450, -406, -1176, -1841, -2770, -4650, -6626, -8454, -9279, -8096, -7825, -7883, -6767, -6034, -6403, -6868, -7425, -8035, -8716, -9284, -10362, -18267, -24151, -26009, -26822, -27194, -27412, -27605, -27695, -28300, -30104, -31049, -31534, -31856, -32090, -32274, -32434, -32576, -32703, -32763, -32761, -32725, -32621, -32614, -30970, -28728, -28591, -28990, -28441, -27954, -27463, -26958, -26435, -25887, -25314, -24717, -24097, -23460, -22680, -21938, -19888, -17825, -18089, -17638, -16829, -15906, -14950, -13851, -13532, -12852, -11412, -10178, -9668, -10579, -9872, -8934, -4590};