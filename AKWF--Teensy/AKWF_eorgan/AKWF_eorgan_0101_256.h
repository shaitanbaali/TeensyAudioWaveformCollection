/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0101 256 samples */
 
const int16_t AKWF_eorgan_0101_256_DATA [256] = 
{1943, 6874, 11403, 15532, 19149, 22191, 24618, 26406, 27569, 28133, 28140, 27645, 26710, 25402, 23786, 21930, 19927, 17935, 16063, 14359, 12846, 11557, 10514, 9728, 9222, 9000, 9075, 9452, 10128, 11096, 12331, 13804, 15457, 17141, 18771, 20308, 21709, 22954, 24023, 24894, 25556, 25991, 26190, 26138, 25772, 25103, 24128, 22865, 21365, 19769, 18182, 16659, 15252, 14027, 13047, 12369, 12047, 12121, 12622, 13556, 14914, 16662, 18732, 21049, 23499, 25854, 27973, 29772, 31172, 32137, 32646, 32701, 32321, 31545, 30426, 29018, 27384, 25589, 23689, 21742, 19826, 18083, 16601, 15399, 14478, 13851, 13478, 13316, 13366, 13608, 14027, 14609, 15333, 16177, 17106, 18081, 19042, 19841, 20394, 20667, 20632, 20280, 19602, 18606, 17299, 15690, 13800, 11637, 9223, 6593, 3762, 778, -2280, -5261, -8043, -10555, -12740, -14526, -15848, -16652, -16889, -16527, -15549, -13963, -11803, -9119, -6007, -2576, 1054, 4571, 7801, 10639, 12977, 14756, 15933, 16493, 16446, 15814, 14649, 12997, 10924, 8503, 5789, 2854, -204, -3232, -6119, -8818, -11306, -13549, -15523, -17221, -18621, -19707, -20481, -20929, -21057, -20873, -20397, -19664, -18729, -17738, -16781, -15897, -15124, -14485, -14005, -13694, -13573, -13658, -13953, -14480, -15298, -16395, -17777, -19425, -21284, -23218, -25121, -26937, -28614, -30087, -31291, -32172, -32674, -32754, -32386, -31563, -30293, -28610, -26580, -24283, -21828, -19443, -17275, -15402, -13905, -12819, -12167, -11949, -12139, -12703, -13586, -14740, -16095, -17586, -19160, -20760, -22305, -23653, -24720, -25483, -25944, -26086, -25954, -25586, -24987, -24174, -23158, -21960, -20597, -19092, -17481, -15802, -14112, -12564, -11242, -10176, -9397, -8916, -8736, -8853, -9261, -9950, -10900, -12098, -13528, -15156, -16960, -18898, -20893, -22788, -24463, -25852, -26893, -27515, -27656, -27259, -26276, -24678, -22444, -19589, -16143, -12162, -7747, -2891};