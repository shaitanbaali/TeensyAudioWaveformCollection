/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0099 256 samples */
 
const int16_t AKWF_eorgan_0099_256_DATA [256] = 
{2003, 7102, 11743, 15901, 19455, 22349, 24567, 26125, 27088, 27538, 27562, 27231, 26606, 25729, 24617, 23280, 21736, 20069, 18327, 16521, 14670, 12828, 11075, 9507, 8232, 7361, 6988, 7179, 7960, 9318, 11187, 13468, 16012, 18551, 20894, 22926, 24551, 25729, 26456, 26760, 26704, 26370, 25846, 25195, 24427, 23585, 22673, 21681, 20610, 19528, 18463, 17401, 16347, 15333, 14408, 13641, 13121, 12941, 13189, 13914, 15136, 16837, 18948, 21369, 23952, 26429, 28615, 30399, 31697, 32476, 32742, 32534, 31927, 31013, 29890, 28629, 27293, 25920, 24519, 23089, 21634, 20219, 18873, 17580, 16332, 15163, 14094, 13160, 12452, 12052, 12031, 12431, 13258, 14490, 16048, 17823, 19663, 21300, 22547, 23292, 23454, 23005, 21954, 20358, 18297, 15881, 13229, 10429, 7577, 4738, 1937, -807, -3465, -5959, -8241, -10308, -12155, -13741, -15015, -15910, -16344, -16229, -15496, -14108, -12068, -9413, -6243, -2684, 1098, 4758, 8075, 10918, 13170, 14778, 15724, 16033, 15762, 14996, 13825, 12317, 10534, 8522, 6293, 3858, 1239, -1484, -4259, -7078, -9922, -12736, -15435, -17932, -20115, -21870, -23107, -23756, -23793, -23233, -22138, -20608, -18794, -16965, -15307, -13939, -12954, -12393, -12264, -12533, -13137, -14000, -15030, -16163, -17392, -18668, -19995, -21378, -22816, -24244, -25631, -26989, -28318, -29585, -30739, -31712, -32416, -32751, -32640, -32027, -30895, -29258, -27188, -24786, -22199, -19693, -17457, -15597, -14201, -13299, -12890, -12927, -13343, -14041, -14927, -15925, -16976, -18041, -19110, -20186, -21264, -22277, -23199, -24048, -24826, -25502, -26056, -26451, -26599, -26417, -25832, -24805, -23326, -21420, -19168, -16675, -14095, -11697, -9666, -8113, -7124, -6723, -6900, -7603, -8746, -10224, -11920, -13739, -15589, -17406, -19164, -20842, -22418, -23806, -24962, -25886, -26565, -26966, -27037, -26709, -25901, -24530, -22517, -19837, -16488, -12512, -8013, -3005};