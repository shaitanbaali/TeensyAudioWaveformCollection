/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0057 256 samples */
 
const int16_t AKWF_eorgan_0057_256_DATA [256] = 
{1107, 3624, 6069, 8485, 10849, 13150, 15377, 17508, 19539, 21457, 23245, 24904, 26418, 27778, 28986, 30031, 30907, 31618, 32157, 32526, 32727, 32761, 32632, 32345, 31906, 31321, 30597, 29744, 28774, 27692, 26514, 25249, 23907, 22506, 21054, 19562, 18049, 16523, 14994, 13483, 11992, 10534, 9127, 7772, 6481, 5267, 4130, 3081, 2125, 1266, 507, -146, -696, -1141, -1479, -1715, -1849, -1887, -1829, -1685, -1457, -1152, -779, -344, 146, 679, 1250, 1851, 2468, 3098, 3730, 4353, 4962, 5549, 6104, 6623, 7097, 7522, 7892, 8204, 8452, 8634, 8749, 8795, 8767, 8699, 8551, 8319, 8028, 7674, 7263, 6801, 6291, 5739, 5151, 4535, 3894, 3239, 2575, 1908, 1246, 596, -37, -643, -1222, -1762, -2260, -2712, -3115, -3461, -3751, -3982, -4152, -4260, -4306, -4290, -4214, -4078, -3888, -3644, -3350, -3013, -2635, -2222, -1781, -1315, -834, -341, 154, 648, 1132, 1601, 2048, 2467, 2854, 3200, 3502, 3758, 3960, 4107, 4196, 4224, 4192, 4096, 3940, 3721, 3442, 3107, 2716, 2274, 1785, 1252, 682, 81, -548, -1195, -1856, -2524, -3190, -3849, -4494, -5117, -5712, -6273, -6793, -7268, -7691, -8058, -8364, -8610, -8774, -8859, -8901, -8871, -8772, -8605, -8372, -8073, -7717, -7304, -6839, -6330, -5783, -5202, -4597, -3976, -3343, -2713, -2092, -1486, -906, -362, 139, 587, 977, 1299, 1547, 1713, 1793, 1779, 1670, 1460, 1148, 732, 209, -417, -1148, -1981, -2909, -3933, -5045, -6236, -7504, -8838, -10226, -11667, -13142, -14641, -16159, -17679, -19185, -20674, -22126, -23530, -24877, -26148, -27336, -28431, -29416, -30284, -31027, -31633, -32094, -32406, -32559, -32552, -32379, -32037, -31525, -30844, -29995, -28979, -27800, -26465, -24976, -23343, -21578, -19681, -17669, -15556, -13344, -11055, -8702, -6294, -3854, -1341};