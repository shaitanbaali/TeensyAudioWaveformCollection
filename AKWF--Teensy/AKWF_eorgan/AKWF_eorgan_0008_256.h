/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0008 256 samples */
 
const int16_t AKWF_eorgan_0008_256_DATA [256] = 
{375, 934, 1476, 2026, 2572, 3112, 3644, 4168, 4686, 5200, 5709, 6215, 6721, 7224, 7730, 8238, 8748, 9262, 9781, 10304, 10834, 11370, 11911, 12459, 13014, 13574, 14143, 14715, 15292, 15876, 16460, 17048, 17637, 18226, 18814, 19400, 19983, 20559, 21131, 21694, 22250, 22795, 23326, 23846, 24352, 24840, 25312, 25766, 26200, 26613, 27005, 27374, 27720, 28042, 28338, 28610, 28855, 29074, 29268, 29434, 29575, 29689, 29776, 29836, 29871, 29881, 29866, 29827, 29764, 29679, 29573, 29445, 29297, 29130, 28944, 28743, 28523, 28290, 28041, 27779, 27504, 27216, 26923, 26642, 26387, 26173, 26010, 25902, 25844, 25829, 25845, 25873, 25897, 25900, 25866, 25783, 25643, 25441, 25177, 24850, 24467, 24033, 23555, 23038, 22491, 21915, 21319, 20701, 20063, 19408, 18732, 18035, 17319, 16577, 15810, 15019, 14200, 13354, 12484, 11586, 10665, 9724, 8759, 7782, 6791, 5789, 4782, 3774, 2766, 1766, 776, -205, -1207, -2236, -3264, -4280, -5282, -6268, -7232, -8175, -9097, -9991, -10862, -11706, -12520, -13307, -14065, -14791, -15488, -16152, -16784, -17386, -17956, -18493, -19002, -19481, -19931, -20353, -20749, -21121, -21469, -21794, -22101, -22389, -22660, -22917, -23161, -23393, -23615, -23828, -24033, -24231, -24422, -24609, -24789, -24965, -25136, -25301, -25462, -25616, -25766, -25909, -26045, -26174, -26296, -26407, -26509, -26602, -26681, -26751, -26820, -26916, -27057, -27259, -27538, -27895, -28325, -28817, -29357, -29918, -30477, -31012, -31497, -31919, -32262, -32519, -32685, -32762, -32753, -32665, -32507, -32287, -32010, -31687, -31323, -30920, -30483, -30011, -29503, -28961, -28385, -27770, -27117, -26427, -25696, -24930, -24127, -23288, -22420, -21523, -20600, -19660, -18704, -17737, -16769, -15798, -14831, -13875, -12930, -12000, -11091, -10202, -9335, -8494, -7674, -6880, -6113, -5366, -4645, -3947, -3270, -2614, -1980, -1363, -766, -174};