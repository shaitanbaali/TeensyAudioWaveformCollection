/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0014 256 samples */
 
const int16_t AKWF_eorgan_0014_256_DATA [256] = 
{376, 1081, 1771, 2461, 3148, 3834, 4516, 5196, 5875, 6552, 7223, 7892, 8557, 9217, 9876, 10532, 11179, 11823, 12461, 13093, 13719, 14342, 14956, 15564, 16166, 16759, 17344, 17920, 18488, 19048, 19600, 20141, 20671, 21193, 21703, 22202, 22689, 23165, 23629, 24080, 24519, 24946, 25359, 25758, 26143, 26513, 26868, 27211, 27536, 27847, 28143, 28421, 28683, 28931, 29161, 29374, 29569, 29748, 29908, 30052, 30177, 30286, 30376, 30445, 30499, 30534, 30549, 30547, 30526, 30487, 30429, 30353, 30256, 30140, 30009, 29859, 29688, 29499, 29292, 29069, 28827, 28565, 28287, 27990, 27677, 27346, 26998, 26633, 26252, 25856, 25442, 25013, 24568, 24108, 23633, 23145, 22640, 22124, 21595, 21050, 20495, 19926, 19345, 18754, 18150, 17535, 16913, 16280, 15637, 14987, 14325, 13656, 12982, 12301, 11611, 10918, 10216, 9512, 8804, 8089, 7373, 6653, 5930, 5207, 4482, 3754, 3026, 2300, 1573, 849, 126, -596, -1316, -2032, -2747, -3454, -4157, -4865, -5576, -6289, -7004, -7715, -8430, -9150, -9866, -10583, -11301, -12014, -12729, -13442, -14151, -14859, -15561, -16257, -16951, -17638, -18317, -18990, -19653, -20308, -20956, -21591, -22214, -22826, -23424, -24011, -24585, -25141, -25683, -26209, -26718, -27211, -27687, -28142, -28579, -28998, -29394, -29772, -30130, -30465, -30780, -31072, -31340, -31588, -31812, -32013, -32191, -32347, -32476, -32582, -32664, -32723, -32757, -32767, -32756, -32719, -32655, -32569, -32460, -32327, -32171, -31991, -31787, -31561, -31313, -31043, -30750, -30434, -30098, -29742, -29363, -28967, -28547, -28109, -27657, -27182, -26689, -26178, -25649, -25108, -24551, -23978, -23388, -22786, -22170, -21541, -20901, -20250, -19588, -18916, -18233, -17543, -16845, -16139, -15428, -14712, -13990, -13265, -12535, -11801, -11070, -10333, -9598, -8865, -8131, -7401, -6673, -5947, -5228, -4515, -3804, -3103, -2404, -1704, -1006, -298};