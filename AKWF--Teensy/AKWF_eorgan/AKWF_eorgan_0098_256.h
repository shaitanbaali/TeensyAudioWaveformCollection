/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0098 256 samples */
 
const int16_t AKWF_eorgan_0098_256_DATA [256] = 
{1392, 4852, 8148, 11332, 14359, 17208, 19854, 22267, 24444, 26370, 28033, 29438, 30586, 31478, 32129, 32546, 32745, 32745, 32565, 32219, 31722, 31090, 30333, 29465, 28495, 27432, 26276, 25033, 23712, 22305, 20817, 19247, 17601, 15919, 14207, 12468, 10710, 8926, 7121, 5307, 3483, 1666, -131, -1900, -3616, -5256, -6809, -8249, -9555, -10706, -11681, -12457, -13027, -13373, -13491, -13370, -13017, -12433, -11624, -10608, -9399, -8015, -6487, -4840, -3106, -1365, 340, 1987, 3539, 4981, 6292, 7448, 8446, 9275, 9928, 10411, 10722, 10870, 10868, 10722, 10452, 10073, 9602, 9055, 8443, 7800, 7113, 6369, 5600, 4803, 3980, 3139, 2273, 1379, 461, -490, -1471, -2448, -3411, -4365, -5313, -6255, -7194, -8122, -9041, -9946, -10824, -11668, -12466, -13201, -13859, -14425, -14877, -15196, -15364, -15367, -15190, -14825, -14263, -13503, -12545, -11398, -10064, -8558, -6903, -5111, -3216, -1241, 782, 2772, 4687, 6509, 8203, 9746, 11127, 12325, 13331, 14142, 14751, 15163, 15385, 15426, 15293, 15006, 14579, 14032, 13387, 12659, 11865, 11020, 10138, 9227, 8299, 7362, 6414, 5462, 4507, 3546, 2579, 1601, 615, -343, -1268, -2165, -3029, -3873, -4694, -5487, -6258, -7001, -7697, -8340, -8958, -9515, -10004, -10404, -10702, -10879, -10921, -10814, -10546, -10109, -9504, -8724, -7772, -6659, -5391, -3985, -2463, -840, 851, 2582, 4323, 5995, 7554, 8979, 10235, 11304, 12169, 12811, 13226, 13407, 13352, 13064, 12550, 11825, 10899, 9789, 8523, 7110, 5580, 3956, 2253, 493, -1303, -3122, -4948, -6765, -8576, -10366, -12129, -13874, -15586, -17269, -18921, -20498, -21991, -23405, -24731, -25974, -27133, -28201, -29176, -30049, -30812, -31459, -31972, -32340, -32546, -32577, -32415, -32041, -31441, -30600, -29510, -28161, -26558, -24692, -22573, -20216, -17621, -14821, -11835, -8683, -5413, -1973};