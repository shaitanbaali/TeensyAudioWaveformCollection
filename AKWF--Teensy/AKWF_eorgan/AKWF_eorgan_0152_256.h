/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0152 256 samples */
 
const int16_t AKWF_eorgan_0152_256_DATA [256] = 
{344, 1481, 2626, 3804, 5006, 6232, 7481, 8743, 10020, 11309, 12599, 13894, 15184, 16457, 17714, 18945, 20141, 21304, 22428, 23503, 24532, 25510, 26431, 27298, 28103, 28848, 29532, 30150, 30703, 31191, 31612, 31968, 32258, 32482, 32641, 32736, 32768, 32738, 32647, 32499, 32293, 32033, 31721, 31358, 30946, 30491, 29992, 29452, 28877, 28265, 27621, 26949, 26248, 25523, 24777, 24009, 23225, 22427, 21614, 20790, 19958, 19115, 18269, 17418, 16562, 15705, 14846, 13985, 13126, 12267, 11408, 10552, 9697, 8841, 7991, 7139, 6290, 5444, 4598, 3755, 2917, 2077, 1240, 407, -424, -1255, -2081, -2906, -3729, -4546, -5362, -6172, -6974, -7773, -8562, -9340, -10107, -10858, -11593, -12311, -13006, -13681, -14332, -14954, -15549, -16114, -16645, -17141, -17602, -18022, -18403, -18742, -19035, -19284, -19485, -19639, -19745, -19799, -19804, -19758, -19661, -19514, -19314, -19066, -18768, -18422, -18028, -17589, -17104, -16579, -16013, -15410, -14772, -14102, -13401, -12677, -11929, -11161, -10381, -9587, -8787, -7988, -7191, -6402, -5631, -4874, -4141, -3433, -2753, -2105, -1493, -917, -381, 112, 564, 969, 1327, 1640, 1904, 2120, 2288, 2409, 2480, 2505, 2484, 2417, 2306, 2153, 1959, 1726, 1456, 1151, 813, 446, 51, -369, -811, -1273, -1753, -2246, -2752, -3268, -3789, -4317, -4846, -5374, -5900, -6422, -6934, -7438, -7930, -8408, -8873, -9322, -9756, -10174, -10574, -10956, -11323, -11671, -12002, -12316, -12614, -12896, -13161, -13410, -13645, -13864, -14068, -14258, -14434, -14596, -14746, -14883, -15007, -15118, -15218, -15305, -15379, -15441, -15490, -15525, -15546, -15552, -15542, -15515, -15470, -15406, -15323, -15217, -15088, -14936, -14757, -14551, -14317, -14051, -13753, -13423, -13058, -12657, -12218, -11740, -11223, -10666, -10067, -9425, -8745, -8018, -7250, -6441, -5588, -4694, -3761, -2789, -1780, -711};