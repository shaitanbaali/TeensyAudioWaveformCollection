/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0076 256 samples */
 
const int16_t AKWF_eorgan_0076_256_DATA [256] = 
{2133, 8087, 13514, 18425, 22703, 26276, 29095, 31118, 32341, 32769, 32428, 31366, 29655, 27432, 24919, 22266, 19600, 17077, 14818, 12890, 11336, 10194, 9514, 9318, 9586, 10258, 11224, 12307, 13399, 14437, 15358, 16113, 16647, 16865, 16714, 16186, 15287, 14049, 12521, 10855, 9213, 7659, 6265, 5037, 3945, 3027, 2291, 1753, 1432, 1397, 1664, 2165, 2778, 3359, 3845, 4201, 4393, 4404, 4226, 3857, 3303, 2576, 1705, 722, -315, -1287, -2107, -2739, -3149, -3323, -3250, -2933, -2376, -1595, -618, 521, 1764, 3009, 4110, 4962, 5551, 5938, 6154, 6204, 6092, 5874, 5468, 4855, 4102, 3253, 2427, 1802, 1451, 1409, 1687, 2279, 3154, 4215, 5396, 6650, 7913, 9124, 10196, 10986, 11333, 11163, 10445, 9183, 7427, 5215, 2583, -405, -3651, -7010, -10333, -13497, -16302, -18554, -20170, -21091, -21278, -20715, -19402, -17364, -14641, -11282, -7393, -3075, 1504, 5939, 9991, 13551, 16502, 18786, 20355, 21178, 21250, 20576, 19194, 17146, 14510, 11428, 8117, 4732, 1404, -1712, -4497, -6879, -8818, -10272, -11193, -11558, -11389, -10743, -9735, -8539, -7266, -5977, -4740, -3605, -2628, -1907, -1495, -1405, -1634, -2153, -2914, -3775, -4573, -5253, -5736, -6027, -6213, -6241, -6105, -5799, -5306, -4558, -3547, -2344, -1069, 124, 1177, 2047, 2703, 3124, 3301, 3230, 2917, 2374, 1627, 711, -320, -1342, -2273, -3073, -3711, -4170, -4437, -4516, -4408, -4129, -3705, -3168, -2573, -2019, -1652, -1571, -1785, -2235, -2881, -3715, -4726, -5876, -7193, -8683, -10281, -11937, -13533, -14881, -15906, -16572, -16863, -16781, -16357, -15683, -14825, -13828, -12756, -11666, -10647, -9838, -9402, -9411, -9897, -10856, -12238, -14005, -16120, -18523, -21118, -23753, -26288, -28601, -30489, -31764, -32344, -32173, -31215, -29459, -26903, -23581, -19536, -14830, -9570, -3733};