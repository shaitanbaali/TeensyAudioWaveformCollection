/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0129 256 samples */
 
const int16_t AKWF_eorgan_0129_256_DATA [256] = 
{1541, 3868, 6207, 8582, 10962, 13325, 15645, 17887, 20039, 22075, 23968, 25709, 27280, 28664, 29858, 30850, 31635, 32215, 32587, 32756, 32727, 32508, 32106, 31529, 30790, 29899, 28863, 27697, 26412, 25011, 23512, 21920, 20240, 18489, 16671, 14794, 12877, 10923, 8938, 6941, 4929, 2915, 912, -1078, -3045, -4974, -6863, -8699, -10463, -12156, -13758, -15256, -16643, -17905, -19027, -20005, -20827, -21486, -21977, -22295, -22441, -22414, -22217, -21858, -21343, -20686, -19901, -19005, -18021, -16967, -15862, -14732, -13592, -12460, -11357, -10295, -9287, -8349, -7484, -6700, -6005, -5396, -4876, -4442, -4091, -3817, -3616, -3480, -3405, -3383, -3408, -3475, -3578, -3713, -3874, -4060, -4266, -4489, -4725, -4971, -5220, -5470, -5718, -5961, -6197, -6422, -6635, -6832, -7009, -7165, -7294, -7391, -7451, -7468, -7433, -7341, -7181, -6950, -6638, -6238, -5745, -5155, -4464, -3673, -2781, -1788, -703, 469, 1722, 3039, 4406, 5808, 7219, 8626, 10009, 11344, 12616, 13810, 14905, 15892, 16760, 17497, 18100, 18565, 18888, 19072, 19119, 19035, 18824, 18496, 18061, 17527, 16904, 16204, 15433, 14603, 13724, 12801, 11845, 10860, 9850, 8827, 7793, 6753, 5718, 4690, 3674, 2676, 1697, 741, -185, -1082, -1946, -2771, -3557, -4298, -4988, -5625, -6201, -6706, -7138, -7487, -7749, -7918, -7988, -7956, -7819, -7576, -7230, -6782, -6238, -5606, -4892, -4114, -3284, -2419, -1541, -668, 180, 983, 1727, 2393, 2965, 3433, 3787, 4015, 4117, 4089, 3929, 3639, 3226, 2697, 2057, 1318, 493, -410, -1376, -2392, -3449, -4531, -5627, -6731, -7827, -8909, -9972, -11002, -11995, -12943, -13834, -14667, -15433, -16125, -16742, -17279, -17730, -18094, -18366, -18542, -18619, -18592, -18457, -18206, -17837, -17345, -16720, -15961, -15064, -14022, -12836, -11506, -10027, -8408, -6653, -4768, -2768, -611};