/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0022 256 samples */
 
const int16_t AKWF_eorgan_0022_256_DATA [256] = 
{508, 1309, 2164, 2998, 3950, 4978, 6022, 7098, 8205, 9421, 10454, 11870, 12920, 14267, 15487, 16736, 17974, 19202, 20409, 21587, 22731, 23838, 24896, 25905, 26859, 27750, 28579, 29341, 30028, 30643, 31181, 31637, 32013, 32305, 32500, 32694, 32732, 32665, 32544, 32357, 32094, 31753, 31317, 30837, 30257, 29641, 28957, 28223, 27440, 26610, 25742, 24845, 23917, 22966, 22001, 21017, 20027, 19032, 18035, 17040, 16052, 15069, 14099, 13145, 12207, 11289, 10403, 9455, 8600, 7790, 6973, 6166, 5376, 4609, 3874, 3158, 2456, 1769, 1090, 421, -238, -895, -1550, -2205, -2868, -3536, -4212, -4900, -5601, -6312, -7040, -7782, -8537, -9312, -10099, -10902, -11722, -12554, -13412, -14199, -15063, -15958, -16828, -17681, -18541, -19373, -20235, -21061, -21883, -22673, -23437, -24171, -24867, -25525, -26136, -26696, -27203, -27651, -28034, -28355, -28608, -28789, -28900, -28936, -28897, -28784, -28594, -28328, -27985, -27567, -27066, -26571, -25941, -25221, -24464, -23664, -22826, -21886, -20871, -20040, -18802, -17838, -16714, -15600, -14477, -13343, -12212, -11090, -9980, -8889, -7827, -6792, -5792, -4834, -3916, -3048, -2231, -1466, -760, -113, 472, 993, 1440, 1903, 2233, 2474, 2684, 2843, 2947, 2986, 2976, 2883, 2774, 2600, 2396, 2153, 1877, 1573, 1246, 904, 547, 183, -183, -550, -913, -1269, -1615, -1944, -2257, -2552, -2823, -3070, -3291, -3484, -3635, -3840, -3945, -3996, -4050, -4086, -4100, -4085, -4035, -3962, -3870, -3763, -3643, -3511, -3370, -3224, -3075, -2928, -2787, -2653, -2529, -2419, -2322, -2242, -2179, -2134, -2110, -2105, -2122, -2159, -2218, -2297, -2408, -2456, -2589, -2760, -2915, -3065, -3209, -3387, -3536, -3715, -3871, -4017, -4145, -4253, -4338, -4394, -4417, -4402, -4345, -4244, -4091, -3891, -3635, -3323, -2954, -2526, -2038, -1491, -884, -201};