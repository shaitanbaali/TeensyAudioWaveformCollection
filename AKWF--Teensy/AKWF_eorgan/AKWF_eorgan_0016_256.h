/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0016 256 samples */
 
const int16_t AKWF_eorgan_0016_256_DATA [256] = 
{523, 2278, 4013, 5700, 7331, 8907, 10428, 11888, 13291, 14638, 15920, 17146, 18313, 19417, 20464, 21451, 22378, 23249, 24060, 24813, 25511, 26154, 26741, 27275, 27757, 28187, 28569, 28903, 29189, 29432, 29631, 29788, 29907, 29987, 30030, 30041, 30019, 29967, 29887, 29781, 29652, 29500, 29328, 29138, 28933, 28715, 28483, 28242, 27993, 27738, 27478, 27217, 26954, 26692, 26433, 26177, 25927, 25684, 25448, 25222, 25005, 24801, 24609, 24430, 24264, 24114, 23978, 23857, 23753, 23664, 23591, 23534, 23494, 23469, 23458, 23464, 23484, 23517, 23563, 23622, 23692, 23772, 23862, 23959, 24063, 24173, 24287, 24403, 24520, 24636, 24750, 24859, 24962, 25058, 25144, 25218, 25279, 25325, 25353, 25362, 25349, 25313, 25252, 25164, 25047, 24898, 24717, 24501, 24248, 23959, 23629, 23257, 22845, 22386, 21882, 21331, 20732, 20083, 19386, 18635, 17833, 16981, 16073, 15111, 14098, 13027, 11904, 10727, 9493, 8209, 6870, 5476, 4033, 2538, 991, -601, -2246, -3938, -5672, -7414, -9097, -10710, -12262, -13750, -15171, -16532, -17828, -19058, -20230, -21339, -22385, -23374, -24303, -25172, -25986, -26743, -27447, -28099, -28699, -29249, -29753, -30208, -30621, -30989, -31317, -31606, -31859, -32075, -32259, -32410, -32532, -32627, -32696, -32741, -32764, -32767, -32752, -32720, -32674, -32613, -32542, -32460, -32370, -32273, -32171, -32064, -31953, -31840, -31727, -31612, -31500, -31388, -31279, -31172, -31069, -30969, -30874, -30782, -30695, -30611, -30532, -30457, -30385, -30316, -30251, -30187, -30124, -30062, -30001, -29937, -29870, -29803, -29730, -29650, -29564, -29469, -29365, -29249, -29121, -28978, -28820, -28643, -28448, -28232, -27992, -27729, -27440, -27121, -26775, -26398, -25987, -25542, -25060, -24541, -23984, -23384, -22742, -22058, -21328, -20550, -19728, -18855, -17933, -16961, -15937, -14860, -13732, -12548, -11312, -10022, -8674, -7274, -5821, -4312, -2753, -1105};