/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0091 256 samples */
 
const int16_t AKWF_eorgan_0091_256_DATA [256] = 
{1434, 4729, 7817, 10761, 13538, 16145, 18572, 20806, 22853, 24710, 26368, 27836, 29112, 30193, 31085, 31788, 32301, 32628, 32766, 32722, 32493, 32079, 31483, 30704, 29748, 28615, 27302, 25821, 24175, 22364, 20410, 18314, 16113, 13972, 11951, 10051, 8291, 6669, 5188, 3855, 2663, 1611, 703, -70, -711, -1221, -1603, -1860, -1992, -2000, -1884, -1644, -1277, -783, -159, 600, 1494, 2525, 3700, 5016, 6470, 8067, 9795, 11651, 13606, 15500, 17279, 18941, 20473, 21877, 23154, 24296, 25310, 26196, 26952, 27587, 28096, 28481, 28745, 28884, 28897, 28782, 28537, 28157, 27635, 26978, 26168, 25191, 24056, 22754, 21279, 19636, 17824, 15841, 13700, 11404, 8988, 6613, 4338, 2166, 117, -1809, -3610, -5274, -6807, -8203, -9458, -10576, -11555, -12389, -13082, -13629, -14029, -14282, -14384, -14333, -14125, -13759, -13235, -12545, -11695, -10682, -9502, -8165, -6674, -5030, -3251, -1342, 663, 2601, 4411, 6088, 7615, 8989, 10206, 11257, 12148, 12876, 13439, 13843, 14088, 14177, 14112, 13895, 13530, 13017, 12359, 11559, 10613, 9529, 8306, 6941, 5440, 3807, 2035, 137, -1884, -4029, -6281, -8634, -11055, -13381, -15552, -17569, -19414, -21091, -22600, -23935, -25104, -26112, -26953, -27637, -28185, -28591, -28860, -28998, -29008, -28891, -28649, -28284, -27796, -27184, -26448, -25583, -24593, -23474, -22220, -20838, -19327, -17687, -15929, -14054, -12093, -10205, -8447, -6817, -5329, -3979, -2771, -1706, -778, 13, 668, 1195, 1593, 1864, 2010, 2033, 1933, 1708, 1359, 882, 274, -464, -1336, -2349, -3504, -4799, -6240, -7824, -9546, -11409, -13396, -15504, -17697, -19812, -21788, -23622, -25293, -26802, -28142, -29306, -30291, -31101, -31727, -32173, -32434, -32513, -32406, -32114, -31634, -30967, -30111, -29065, -27826, -26396, -24774, -22955, -20946, -18748, -16356, -13785, -11041, -8127, -5069, -1799};