/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0011 256 samples */
 
const int16_t AKWF_eorgan_0011_256_DATA [256] = 
{442, 1364, 2268, 3177, 4084, 4989, 5895, 6796, 7697, 8601, 9498, 10389, 11273, 12147, 13018, 13882, 14735, 15583, 16419, 17241, 18049, 18844, 19622, 20389, 21139, 21869, 22583, 23277, 23954, 24612, 25246, 25855, 26442, 27007, 27549, 28070, 28562, 29025, 29467, 29878, 30265, 30626, 30961, 31268, 31544, 31789, 32006, 32199, 32366, 32505, 32613, 32689, 32741, 32766, 32764, 32735, 32677, 32592, 32482, 32347, 32189, 32005, 31798, 31567, 31308, 31031, 30734, 30413, 30075, 29717, 29337, 28941, 28523, 28093, 27648, 27186, 26711, 26223, 25720, 25203, 24677, 24142, 23594, 23041, 22476, 21901, 21322, 20737, 20148, 19557, 18955, 18350, 17741, 17132, 16521, 15909, 15294, 14681, 14068, 13454, 12844, 12231, 11619, 11013, 10407, 9805, 9208, 8611, 8018, 7430, 6845, 6261, 5686, 5114, 4546, 3985, 3425, 2872, 2320, 1774, 1238, 706, 176, -351, -874, -1391, -1898, -2402, -2906, -3405, -3899, -4389, -4874, -5355, -5837, -6313, -6786, -7258, -7726, -8191, -8654, -9115, -9577, -10033, -10486, -10942, -11393, -11844, -12292, -12738, -13179, -13621, -14065, -14506, -14947, -15383, -15819, -16259, -16694, -17124, -17556, -17989, -18417, -18845, -19268, -19689, -20113, -20528, -20941, -21350, -21753, -22157, -22556, -22946, -23331, -23715, -24089, -24456, -24817, -25166, -25511, -25847, -26170, -26487, -26794, -27085, -27366, -27635, -27891, -28137, -28367, -28577, -28775, -28960, -29127, -29277, -29408, -29521, -29617, -29690, -29745, -29781, -29797, -29791, -29763, -29712, -29639, -29543, -29423, -29282, -29118, -28926, -28712, -28477, -28214, -27928, -27617, -27281, -26917, -26535, -26130, -25700, -25244, -24763, -24258, -23731, -23186, -22617, -22027, -21414, -20779, -20130, -19458, -18766, -18057, -17330, -16589, -15833, -15062, -14271, -13474, -12661, -11835, -11002, -10159, -9306, -8448, -7580, -6708, -5827, -4939, -4049, -3157, -2258, -1359, -437};