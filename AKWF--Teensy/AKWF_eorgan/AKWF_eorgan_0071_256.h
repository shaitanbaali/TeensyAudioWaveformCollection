/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0071 256 samples */
 
const int16_t AKWF_eorgan_0071_256_DATA [256] = 
{1096, 3338, 5499, 7621, 9689, 11701, 13649, 15520, 17317, 19032, 20656, 22193, 23636, 24975, 26219, 27359, 28391, 29318, 30136, 30842, 31441, 31928, 32301, 32565, 32718, 32759, 32690, 32513, 32229, 31837, 31345, 30750, 30057, 29270, 28393, 27428, 26382, 25259, 24064, 22807, 21491, 20122, 18715, 17284, 15866, 14477, 13119, 11799, 10529, 9308, 8145, 7049, 6016, 5057, 4174, 3368, 2645, 2004, 1449, 983, 605, 318, 121, 17, 4, 83, 255, 518, 870, 1312, 1842, 2458, 3159, 3942, 4802, 5741, 6752, 7828, 8972, 10176, 11428, 12732, 14078, 15455, 16855, 18337, 19775, 21138, 22458, 23717, 24916, 26044, 27095, 28068, 28952, 29747, 30449, 31053, 31555, 31958, 32253, 32442, 32521, 32492, 32349, 32099, 31737, 31262, 30676, 29981, 29176, 28260, 27240, 26112, 24880, 23551, 22120, 20594, 18980, 17275, 15488, 13625, 11684, 9680, 7618, 5498, 3336, 1137, -1088, -3291, -5458, -7585, -9654, -11667, -13616, -15489, -17288, -19005, -20632, -22170, -23615, -24957, -26202, -27345, -28379, -29308, -30129, -30838, -31438, -31928, -32305, -32570, -32725, -32768, -32703, -32527, -32246, -31857, -31365, -30774, -30082, -29299, -28422, -27458, -26414, -25293, -24100, -22845, -21528, -20167, -18728, -17240, -15829, -14440, -13082, -11765, -10496, -9276, -8116, -7021, -5991, -5033, -4152, -3349, -2626, -1989, -1436, -972, -597, -312, -119, -16, -7, -89, -262, -527, -880, -1326, -1858, -2477, -3179, -3965, -4828, -5768, -6781, -7860, -9005, -10210, -11464, -12769, -14115, -15492, -16900, -18323, -19731, -21101, -22420, -23681, -24882, -26012, -27063, -28038, -28925, -29721, -30426, -31032, -31537, -31940, -32238, -32428, -32510, -32484, -32345, -32096, -31735, -31264, -30680, -29988, -29184, -28272, -27255, -26129, -24900, -23572, -22144, -20620, -19008, -17304, -15518, -13658, -11718, -9716, -7656, -5540, -3385, -1145};