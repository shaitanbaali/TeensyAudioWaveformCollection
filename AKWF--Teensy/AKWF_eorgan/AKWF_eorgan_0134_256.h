/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0134 256 samples */
 
const int16_t AKWF_eorgan_0134_256_DATA [256] = 
{795, 3457, 6157, 8899, 11615, 14258, 16773, 19099, 21205, 23057, 24619, 25886, 26849, 27509, 27886, 27997, 27870, 27536, 27029, 26386, 25638, 24819, 23958, 23076, 22197, 21335, 20497, 19693, 18926, 18195, 17501, 16840, 16206, 15600, 15017, 14451, 13903, 13369, 12844, 12329, 11817, 11307, 10796, 10275, 9741, 9189, 8613, 8009, 7378, 6714, 6020, 5304, 4565, 3816, 3067, 2325, 1606, 922, 280, -304, -826, -1283, -1668, -1985, -2237, -2433, -2582, -2693, -2778, -2851, -2921, -2997, -3089, -3199, -3330, -3480, -3645, -3820, -3996, -4164, -4313, -4434, -4519, -4559, -4549, -4486, -4367, -4192, -3965, -3689, -3365, -3000, -2602, -2169, -1709, -1226, -723, -207, 319, 852, 1383, 1906, 2413, 2894, 3338, 3735, 4073, 4344, 4540, 4656, 4690, 4646, 4536, 4371, 4173, 3969, 3786, 3659, 3624, 3714, 3965, 4404, 5057, 5938, 7056, 8410, 9985, 11760, 13706, 15776, 17925, 20105, 22250, 24314, 26244, 27981, 29493, 30743, 31701, 32359, 32708, 32754, 32510, 31998, 31246, 30284, 29149, 27877, 26498, 25046, 23556, 22043, 20532, 19040, 17574, 16144, 14754, 13400, 12086, 10811, 9563, 8351, 7164, 5999, 4858, 3736, 2628, 1537, 456, -618, -1684, -2754, -3829, -4912, -6012, -7131, -8267, -9429, -10609, -11801, -13007, -14213, -15406, -16583, -17725, -18818, -19860, -20832, -21728, -22546, -23280, -23933, -24509, -25013, -25457, -25851, -26204, -26531, -26841, -27143, -27446, -27753, -28063, -28379, -28697, -29008, -29304, -29577, -29817, -30014, -30158, -30242, -30262, -30211, -30090, -29899, -29639, -29314, -28927, -28483, -27988, -27445, -26860, -26238, -25579, -24892, -24180, -23447, -22702, -21949, -21199, -20461, -19744, -19061, -18424, -17839, -17316, -16863, -16475, -16153, -15887, -15661, -15455, -15247, -15003, -14693, -14281, -13730, -13011, -12094, -10951, -9570, -7946, -6077, -3984, -1626};