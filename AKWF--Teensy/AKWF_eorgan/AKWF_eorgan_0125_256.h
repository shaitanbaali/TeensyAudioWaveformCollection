/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0125 256 samples */
 
const int16_t AKWF_eorgan_0125_256_DATA [256] = 
{1286, 5328, 9055, 12469, 15482, 18052, 20149, 21752, 22872, 23520, 23710, 23473, 22836, 21841, 20523, 18928, 17102, 15091, 12954, 10763, 8581, 6495, 4589, 2936, 1612, 674, 157, 71, 396, 1082, 2053, 3228, 4514, 5819, 7066, 8190, 9141, 9889, 10419, 10728, 10825, 10721, 10429, 9965, 9350, 8612, 7768, 6840, 5861, 4849, 3840, 2875, 1996, 1263, 730, 453, 480, 847, 1579, 2665, 4069, 5739, 7586, 9522, 11457, 13295, 14961, 16399, 17556, 18418, 18977, 19241, 19230, 18972, 18495, 17825, 16996, 16046, 14997, 13886, 12743, 11587, 10455, 9383, 8407, 7574, 6937, 6534, 6408, 6587, 7077, 7865, 8908, 10136, 11467, 12800, 14041, 15099, 15897, 16377, 16500, 16251, 15638, 14683, 13425, 11902, 10171, 8272, 6264, 4209, 2147, 139, -1764, -3525, -5086, -6390, -7388, -8017, -8214, -7932, -7126, -5775, -3870, -1442, 1448, 4713, 8226, 11863, 15503, 19000, 22250, 25164, 27652, 29673, 31197, 32206, 32708, 32716, 32244, 31321, 29976, 28254, 26189, 23826, 21216, 18402, 15448, 12428, 9399, 6457, 3687, 1156, -1049, -2875, -4289, -5272, -5845, -6061, -5986, -5708, -5317, -4897, -4532, -4284, -4198, -4306, -4623, -5145, -5867, -6778, -7859, -9097, -10467, -11945, -13510, -15138, -16797, -18469, -20117, -21696, -23167, -24470, -25547, -26349, -26818, -26920, -26638, -25975, -24967, -23669, -22166, -20549, -18908, -17337, -15910, -14691, -13724, -13028, -12610, -12461, -12559, -12883, -13402, -14091, -14914, -15838, -16834, -17873, -18924, -19963, -20960, -21876, -22677, -23315, -23743, -23916, -23795, -23356, -22587, -21509, -20161, -18610, -16951, -15272, -13675, -12252, -11079, -10216, -9701, -9550, -9755, -10295, -11137, -12237, -13539, -15007, -16580, -18201, -19824, -21394, -22858, -24180, -25301, -26169, -26729, -26919, -26685, -25971, -24736, -22961, -20629, -17778, -14467, -10782, -6848, -2694};