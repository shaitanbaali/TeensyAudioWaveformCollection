/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0043 256 samples */
 
const int16_t AKWF_eorgan_0043_256_DATA [256] = 
{286, 795, 1719, 2356, 2939, 3579, 4159, 4723, 5073, 5876, 9380, 13031, 16110, 18735, 20853, 22461, 23571, 24208, 24396, 24177, 23567, 22632, 21411, 19805, 18963, 2109, -4401, -3109, -3344, -3413, -3636, -3898, -3678, -3249, -2726, -2055, -1344, -630, 67, 392, 2707, -9568, -16037, -11183, -8816, -6626, -4485, -2797, -1499, -589, -55, 92, -134, -373, -624, -1066, -527, -15293, -20384, -16961, -15179, -13188, -11331, -9608, -7991, -6500, -5190, -4049, -3043, -2210, -1532, -1036, -603, -1092, -4331, -7665, -10418, -12798, -14809, -16407, -17581, -18360, -18774, -18837, -18572, -18227, -18029, -17100, -15065, -28902, -31097, -25855, -21875, -17585, -13410, -9331, -5139, -1035, 2858, 6523, 9857, 12845, 15467, 17364, 20947, 9657, 3827, 8567, 10865, 13106, 14985, 16475, 17581, 18322, 18705, 18705, 18289, 18030, 17920, 17624, 18268, 3175, -1139, 2361, 4238, 6167, 7946, 9540, 11251, 12761, 13466, 14094, 14296, 14076, 13492, 12600, 11272, 10301, 11922, 13665, 14888, 15721, 16170, 16262, 16004, 15449, 14633, 13594, 12366, 10986, 9484, 7812, 6921, -10530, -15672, -13985, -13623, -13032, -12523, -12033, -11530, -11004, -10459, -9993, -9563, -9180, -8827, -8826, -6790, -19241, -26067, -22463, -20638, -18263, -16109, -13855, -11625, -9445, -7381, -5518, -3886, -2218, -574, 881, 3021, -11115, -13535, -8903, -5949, -3011, -399, 1889, 3884, 5566, 6901, 7894, 8616, 9040, 9193, 9061, 8814, 7498, 3625, 128, -2751, -5064, -6828, -8128, -8967, -9416, -9505, -9271, -8762, -7793, -6260, -5243, -3410, -18232, -20288, -16160, -13483, -10779, -8372, -6160, -3868, -1661, 428, 2358, 4113, 5674, 7048, 7886, 10650, -1343, -7767, -3312, -1150, 1145, 3208, 5028, 6588, 7883, 8904, 9613, 9976, 10165, 10151, 9952, 10320, -5967, -9476, -6437, -4865, -3241, -1749, -448};