/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0013 256 samples */
 
const int16_t AKWF_eorgan_0013_256_DATA [256] = 
{527, 1305, 2046, 2797, 3525, 4241, 4961, 5668, 6372, 7072, 7752, 8438, 9085, 9740, 10406, 11053, 11697, 12339, 12991, 13627, 14253, 14878, 15485, 16087, 16678, 17270, 17834, 18382, 18924, 19449, 19971, 20477, 20975, 21461, 21926, 22379, 22812, 23252, 23660, 24063, 24455, 24816, 25176, 25522, 25863, 26161, 26458, 26747, 27009, 27272, 27519, 27747, 27948, 28146, 28324, 28478, 28625, 28762, 28870, 28965, 29057, 29132, 29191, 29237, 29251, 29266, 29252, 29225, 29196, 29144, 29069, 28991, 28893, 28774, 28645, 28506, 28356, 28173, 27982, 27786, 27566, 27325, 27075, 26830, 26564, 26270, 25971, 25649, 25311, 24973, 24619, 24252, 23878, 23484, 23073, 22661, 22228, 21778, 21321, 20859, 20381, 19892, 19393, 18874, 18336, 17800, 17269, 16705, 16135, 15567, 14992, 14401, 13794, 13186, 12556, 11927, 11302, 10651, 10005, 9356, 8690, 8019, 7360, 6677, 5986, 5303, 4604, 3902, 3206, 2498, 1804, 1089, 372, -333, -1049, -1763, -2480, -3204, -3925, -4636, -5347, -6058, -6767, -7490, -8209, -8920, -9646, -10384, -11115, -11850, -12584, -13302, -14016, -14733, -15450, -16154, -16841, -17543, -18237, -18900, -19555, -20214, -20854, -21480, -22101, -22709, -23299, -23873, -24458, -25028, -25574, -26125, -26645, -27160, -27634, -28106, -28542, -28980, -29366, -29749, -30108, -30444, -30763, -31059, -31329, -31584, -31806, -32002, -32189, -32336, -32466, -32582, -32659, -32715, -32743, -32753, -32760, -32712, -32663, -32573, -32489, -32364, -32221, -32076, -31881, -31678, -31447, -31180, -30906, -30618, -30299, -29972, -29608, -29237, -28825, -28425, -27983, -27539, -27063, -26567, -26049, -25506, -24942, -24365, -23780, -23194, -22591, -21953, -21311, -20648, -19947, -19258, -18539, -17801, -17078, -16331, -15567, -14787, -14012, -13225, -12418, -11616, -10819, -9998, -9190, -8369, -7541, -6726, -5894, -5088, -4258, -3445, -2651, -1856, -1058, -266};