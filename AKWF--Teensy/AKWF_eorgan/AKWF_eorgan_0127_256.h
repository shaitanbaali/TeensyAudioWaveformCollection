/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0127 256 samples */
 
const int16_t AKWF_eorgan_0127_256_DATA [256] = 
{2516, 7212, 11364, 14953, 17885, 20138, 21727, 22705, 23152, 23151, 22782, 22113, 21199, 20087, 18802, 17369, 15815, 14151, 12410, 10632, 8855, 7143, 5563, 4168, 3017, 2161, 1627, 1426, 1550, 1958, 2600, 3415, 4334, 5291, 6226, 7092, 7853, 8496, 9018, 9423, 9718, 9915, 10016, 10024, 9925, 9705, 9331, 8773, 8006, 7008, 5795, 4409, 2920, 1446, 123, -910, -1509, -1559, -982, 239, 2058, 4368, 7001, 9775, 12503, 14993, 17103, 18733, 19824, 20379, 20443, 20091, 19418, 18519, 17485, 16386, 15281, 14210, 13191, 12237, 11356, 10541, 9795, 9124, 8540, 8071, 7743, 7586, 7623, 7870, 8333, 8998, 9830, 10776, 11771, 12741, 13617, 14325, 14814, 15040, 14981, 14638, 14026, 13177, 12128, 10920, 9596, 8182, 6703, 5178, 3600, 1970, 287, -1451, -3210, -4933, -6539, -7906, -8898, -9376, -9203, -8280, -6538, -3985, -698, 3194, 7477, 11938, 16353, 20487, 24166, 27256, 29662, 31366, 32386, 32772, 32604, 31964, 30938, 29586, 27968, 26133, 24104, 21909, 19576, 17116, 14562, 11960, 9344, 6783, 4344, 2079, 54, -1682, -3104, -4192, -4958, -5443, -5690, -5763, -5727, -5648, -5585, -5585, -5679, -5881, -6194, -6612, -7126, -7725, -8402, -9158, -10003, -10951, -12033, -13282, -14720, -16365, -18206, -20196, -22266, -24299, -26157, -27702, -28789, -29301, -29161, -28350, -26918, -24971, -22671, -20207, -17764, -15530, -13652, -12230, -11320, -10922, -10989, -11447, -12202, -13159, -14226, -15335, -16427, -17462, -18422, -19295, -20076, -20769, -21373, -21883, -22284, -22554, -22665, -22587, -22298, -21784, -21038, -20077, -18934, -17662, -16332, -15014, -13778, -12699, -11831, -11217, -10881, -10821, -11022, -11454, -12082, -12863, -13758, -14738, -15780, -16867, -18004, -19193, -20435, -21730, -23049, -24331, -25498, -26428, -26985, -27030, -26427, -25076, -22909, -19933, -16221, -11910, -7205, -2216};