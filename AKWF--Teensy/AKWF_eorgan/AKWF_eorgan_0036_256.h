/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0036 256 samples */
 
const int16_t AKWF_eorgan_0036_256_DATA [256] = 
{558, 2311, 4176, 6051, 7927, 9794, 10852, 9417, 5860, 2309, 666, 1279, 3221, 5596, 7927, 10079, 12074, 13354, 12533, 9907, 7242, 6283, 7407, 9690, 12230, 14545, 16233, 17242, 17924, 18582, 19333, 20163, 21012, 21802, 22481, 22935, 23040, 23032, 21915, 16277, 4379, -7540, -13636, -14019, -11335, -7585, -3885, -564, 2356, 5018, 7519, 9900, 12179, 14347, 16347, 18140, 19668, 20682, 20727, 20066, 18537, 15297, 11073, 7731, 6645, 7569, 9401, 11360, 13082, 14485, 15140, 14449, 12600, 10586, 9851, 10739, 12230, 13326, 14788, 16467, 17716, 18556, 19273, 20080, 21046, 22145, 23290, 24407, 25487, 25780, 23559, 19053, 14383, 11700, 11411, 12506, 14050, 15526, 16780, 17821, 18681, 19437, 18950, 14628, 6595, -1475, -5701, -6020, -4184, -1879, -56, 1248, 2328, 3395, 4522, 5705, 6912, 8094, 9230, 10286, 11250, 11992, 12024, 11157, 9013, 4889, -323, -4640, -6559, -6218, -4807, -3188, -1733, -471, -49, -1725, -5114, -8415, -9872, -9216, -7813, -8013, -10276, -13117, -14918, -15688, -17168, -19431, -20996, -21023, -20157, -18474, -16228, -13935, -12063, -10732, -9643, -8525, -7270, -5910, -4769, -4048, -3538, -2965, -2292, -1825, -1683, -1614, -1403, -989, -404, 281, 1019, 1761, 2480, 3153, 3772, 4335, 4837, 5270, 5634, 5923, 6138, 6279, 6348, 6338, 6264, 6073, 4809, 1573, -2758, -6690, -10147, -13798, -17147, -19103, -19244, -18257, -17511, -18471, -20466, -21817, -22527, -21988, -20589, -19078, -17758, -16771, -16107, -15835, -17021, -20290, -24498, -27351, -27807, -26638, -24839, -23023, -21649, -20782, -20073, -19229, -18159, -16882, -15459, -13971, -12451, -10935, -9509, -8437, -9108, -14006, -22320, -29628, -32723, -32042, -29348, -25981, -22650, -19588, -16802, -14175, -11745, -10727, -11890, -13920, -14980, -14073, -11636, -8682, -6331, -5012, -4213, -3368, -2247, -768};