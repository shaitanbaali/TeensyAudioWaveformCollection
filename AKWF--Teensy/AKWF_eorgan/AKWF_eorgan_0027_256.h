/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0027 256 samples */
 
const int16_t AKWF_eorgan_0027_256_DATA [256] = 
{717, 1807, 2878, 3958, 5045, 6144, 7257, 8378, 9511, 10655, 11800, 12947, 14093, 15228, 16352, 17463, 18551, 19622, 20673, 21696, 22692, 23655, 24573, 25444, 26255, 27001, 27679, 28283, 28814, 29274, 29665, 29991, 30259, 30471, 30632, 30749, 30821, 30855, 30855, 30824, 30764, 30676, 30565, 30430, 30275, 30101, 29909, 29701, 29477, 29239, 28988, 28727, 28454, 27914, 28794, 24076, -24894, -30107, -29097, -29585, -29814, -30025, -30218, -30395, -30555, -30695, -30813, -30907, -30977, -31020, -31031, -31010, -30954, -30858, -30720, -30535, -30297, -30004, -29648, -29226, -28735, -28168, -27524, -26805, -26007, -25139, -24207, -23216, -22177, -21100, -19984, -18844, -17680, -16492, -15289, -14073, -12843, -11611, -10377, -9145, -7921, -6706, -5499, -4307, -3123, -1947, -781, 379, 1538, 2692, 3847, 5001, 6150, 7297, 8438, 9567, 10686, 11761, 12945, 13636, 8173, 8221, 9418, 10305, 11194, 12045, 12853, 13618, 14342, 15023, 15663, 16267, 16832, 17365, 17868, 18342, 18793, 19225, 19642, 19850, 21317, 11415, 6187, 7722, 7961, 8424, 8905, 9404, 9921, 10447, 10975, 11497, 12002, 12480, 12927, 13338, 13711, 14046, 14347, 14614, 14855, 15072, 15270, 15454, 15628, 15796, 15966, 16138, 16318, 16512, 16719, 16944, 17194, 17469, 17769, 18099, 18456, 18839, 19250, 19678, 20124, 20386, 21700, 18909, -17035, -20378, -18996, -18788, -18420, -18076, -17760, -17473, -17213, -16976, -16760, -16561, -16374, -16200, -16030, -15863, -15693, -15518, -15331, -15129, -14906, -14660, -14384, -14074, -13729, -13343, -12915, -12448, -11945, -11409, -10853, -10280, -9704, -9133, -8572, -8026, -7496, -6981, -6478, -5988, -5704, -4103, -9262, -19051, -17442, -17079, -16502, -15890, -15245, -14564, -13848, -13091, -12295, -11461, -10587, -9677, -8734, -7755, -6750, -5723, -4674, -3637, -2459, -1743, -7148, -7008, -5688, -4644, -3563, -2485, -1414, -324};