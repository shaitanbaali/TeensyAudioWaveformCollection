/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0040 256 samples */
 
const int16_t AKWF_eorgan_0040_256_DATA [256] = 
{603, 2206, 3241, 4513, 6067, 7335, 7805, 8143, 8708, 9139, 9710, 10663, 11727, 12790, 13795, 14691, 15445, 16040, 16467, 16721, 16804, 16724, 16492, 16118, 15612, 14993, 14267, 13445, 12544, 11571, 10531, 9441, 8304, 7131, 5910, 4783, 2720, -3346, -9643, -11232, -11731, -15475, -18442, -18655, -17215, -15900, -14872, -16436, -21827, -25109, -24047, -21797, -20293, -19567, -18530, -16977, -15093, -13249, -15152, -20136, -21395, -18832, -15602, -12580, -9740, -6993, -4326, -1792, 606, 2482, 3356, 4045, 5049, 6209, 7351, 8360, 9133, 9528, 9997, 6887, -2892, -8209, -5666, -1726, 1358, 3737, 5752, 7502, 8917, 9771, 10266, 9564, 5831, 689, -166, 1972, 4169, 5890, 7184, 7955, 8998, 10370, 11825, 12764, 12809, 12864, 13293, 13921, 14558, 15144, 15558, 12682, 6712, 4028, 5224, 6988, 8224, 9076, 9721, 10207, 10590, 10645, 6740, -462, -3898, -3367, -2162, -1214, -441, 266, 937, 1546, 2107, 2209, 1371, 445, -37, -219, -280, -305, -375, -384, -861, -9773, -24857, -32936, -29853, -24800, -20984, -17965, -15257, -12684, -10286, -8056, -6728, -7584, -8992, -9228, -8430, -7132, -5617, -4058, -2571, -1187, -613, -3234, -6518, -5750, -2984, -664, 969, 1981, 2985, 4208, 5293, 3749, 114, -2260, -1582, -14, 1234, 2083, 2733, 3623, 4584, 5563, 6250, 6092, 5706, 5662, 5872, 6173, 6488, 6808, 4432, -185, -1813, -1222, -348, 505, 1226, 1859, 2438, 2959, 3416, 3650, 2794, -2102, -12947, -19457, -17362, -13714, -10807, -8450, -6289, -4205, -2241, -377, 850, 391, -509, -592, 14, 943, 1978, 2997, 3910, 4765, 4769, 1270, -2738, -2488, -145, 1837, 3259, 4347, 5180, 5670, 5977, 4685, 8, -3242, -2566, -935, 596, 19, -4457, -7255, -5516, -2760, -4331, -9164, -10353, -7793, -4647, -1754};