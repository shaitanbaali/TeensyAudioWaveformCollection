/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0067 256 samples */
 
const int16_t AKWF_eorgan_0067_256_DATA [256] = 
{983, 2862, 4694, 6515, 8313, 10084, 11825, 13521, 15173, 16777, 18321, 19807, 21229, 22575, 23853, 25055, 26172, 27209, 28160, 29023, 29799, 30484, 31077, 31582, 31996, 32319, 32555, 32703, 32766, 32745, 32646, 32468, 32216, 31896, 31509, 31061, 30557, 30000, 29396, 28751, 28068, 27354, 26619, 25860, 25087, 24308, 23524, 22744, 21973, 21214, 20473, 19759, 19070, 18414, 17798, 17221, 16689, 16205, 15772, 15394, 15071, 14806, 14600, 14454, 14370, 14346, 14384, 14481, 14638, 14853, 15125, 15450, 15825, 16251, 16720, 17231, 17781, 18362, 18974, 19611, 20266, 20936, 21616, 22300, 22980, 23693, 24374, 25016, 25641, 26232, 26792, 27312, 27787, 28215, 28590, 28905, 29159, 29348, 29466, 29513, 29485, 29379, 29192, 28925, 28573, 28140, 27624, 27021, 26335, 25568, 24718, 23787, 22781, 21697, 20541, 19317, 18025, 16672, 15262, 13797, 12285, 10731, 9135, 7509, 5857, 4180, 2490, 793, -911, -2610, -4301, -5980, -7635, -9265, -10867, -12426, -13944, -15415, -16832, -18194, -19494, -20725, -21892, -22985, -24002, -24942, -25802, -26579, -27276, -27887, -28413, -28857, -29217, -29492, -29687, -29801, -29838, -29798, -29684, -29502, -29251, -28939, -28569, -28142, -27667, -27148, -26586, -25990, -25363, -24717, -24029, -23310, -22623, -21930, -21241, -20559, -19893, -19242, -18616, -18020, -17455, -16927, -16440, -15997, -15601, -15258, -14967, -14732, -14556, -14436, -14378, -14380, -14444, -14568, -14754, -14999, -15300, -15659, -16073, -16537, -17050, -17609, -18208, -18847, -19520, -20220, -20946, -21694, -22451, -23221, -23994, -24765, -25531, -26281, -27011, -27721, -28400, -29042, -29645, -30202, -30706, -31157, -31546, -31871, -32126, -32308, -32414, -32440, -32385, -32245, -32018, -31704, -31299, -30804, -30219, -29545, -28778, -27926, -26985, -25957, -24849, -23659, -22390, -21052, -19639, -18161, -16625, -15028, -13380, -11691, -9955, -8188, -6393, -4573, -2744, -866};