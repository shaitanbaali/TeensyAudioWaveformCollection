/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0085 256 samples */
 
const int16_t AKWF_eorgan_0085_256_DATA [256] = 
{2166, 7671, 12701, 17294, 21360, 24851, 27732, 29966, 31552, 32484, 32767, 32419, 31463, 29945, 27919, 25456, 22687, 19914, 17328, 15002, 12985, 11321, 10063, 9238, 8860, 8925, 9431, 10365, 11704, 13427, 15489, 17842, 20391, 22847, 25055, 26983, 28586, 29861, 30804, 31415, 31706, 31681, 31355, 30716, 29723, 28403, 26771, 24863, 22764, 20735, 18926, 17360, 16052, 15011, 14230, 13701, 13420, 13382, 13588, 14036, 14727, 15659, 16817, 18183, 19697, 21122, 22340, 23334, 24083, 24586, 24842, 24850, 24609, 24115, 23366, 22351, 21064, 19508, 17693, 15639, 13430, 11325, 9474, 7908, 6643, 5720, 5093, 4739, 4679, 4911, 5441, 6277, 7415, 8851, 10551, 12480, 14549, 16466, 18075, 19329, 20175, 20591, 20548, 20037, 19045, 17571, 15625, 13223, 10415, 7252, 3767, 36, -3809, -7478, -10768, -13607, -15938, -17709, -18886, -19452, -19396, -18717, -17420, -15526, -13069, -10081, -6646, -2836, 1226, 5139, 8708, 11854, 14492, 16576, 18074, 18954, 19215, 18850, 17871, 16289, 14130, 11447, 8287, 4725, 897, -2901, -6477, -9754, -12688, -15229, -17325, -18955, -20100, -20761, -20950, -20672, -19952, -18814, -17303, -15468, -13402, -11399, -9609, -8072, -6829, -5886, -5250, -4918, -4881, -5138, -5670, -6493, -7657, -9127, -10894, -12922, -15127, -17249, -19139, -20775, -22144, -23239, -24063, -24629, -24940, -25001, -24814, -24380, -23700, -22773, -21617, -20249, -18729, -17296, -16065, -15055, -14286, -13758, -13472, -13430, -13630, -14076, -14771, -15724, -16941, -18416, -20140, -22091, -24184, -26160, -27867, -29272, -30359, -31089, -31501, -31614, -31413, -30894, -30049, -28873, -27367, -25533, -23406, -21019, -18459, -16019, -13853, -12005, -10532, -9454, -8797, -8574, -8791, -9455, -10555, -12073, -13957, -16164, -18651, -21350, -24130, -26692, -28843, -30509, -31632, -32163, -32067, -31331, -29942, -27904, -25216, -21909, -18015, -13574, -8672, -3261};