/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0107 256 samples */
 
const int16_t AKWF_eorgan_0107_256_DATA [256] = 
{2242, 7563, 12247, 16239, 19463, 21986, 23970, 25610, 27091, 28509, 29866, 31089, 32050, 32627, 32759, 32463, 31850, 31121, 30470, 30040, 29905, 30063, 30407, 30798, 31120, 31285, 31268, 31098, 30845, 30582, 30357, 30179, 30027, 29854, 29623, 29330, 29004, 28707, 28506, 28446, 28512, 28627, 28679, 28522, 28002, 27073, 25764, 24187, 22511, 20932, 19596, 18551, 17750, 17088, 16429, 15663, 14759, 13777, 12864, 12223, 12045, 12440, 13399, 14792, 16380, 17795, 18752, 19079, 18718, 17741, 16314, 14652, 12930, 11252, 9630, 8001, 6311, 4467, 2381, 68, -2364, -4736, -6861, -8602, -9906, -10784, -11354, -11781, -12185, -12666, -13263, -13952, -14674, -15365, -15980, -16514, -16993, -17465, -17967, -18504, -19041, -19516, -19855, -20007, -19980, -19842, -19700, -19689, -19946, -20512, -21345, -22328, -23284, -24008, -24348, -24255, -23764, -22984, -22050, -21065, -20068, -19001, -17714, -16017, -13727, -10732, -7060, -2848, 1651, 5997, 9881, 13127, 15653, 17529, 18915, 20003, 20972, 21916, 22833, 23648, 24228, 24448, 24246, 23632, 22720, 21703, 20776, 20078, 19682, 19581, 19671, 19807, 19870, 19775, 19490, 19047, 18512, 17954, 17423, 16926, 16440, 15916, 15317, 14633, 13898, 13167, 12508, 11965, 11520, 11094, 10577, 9817, 8660, 7061, 5045, 2722, 264, -2138, -4339, -6288, -8043, -9680, -11256, -12867, -14535, -16191, -17692, -18827, -19405, -19311, -18550, -17257, -15667, -14146, -12982, -12347, -12302, -12778, -13610, -14588, -15540, -16366, -17061, -17709, -18441, -19377, -20594, -22080, -23726, -25351, -26764, -27833, -28499, -28772, -28769, -28652, -28545, -28539, -28675, -28929, -29237, -29535, -29778, -29958, -30099, -30249, -30443, -30682, -30933, -31130, -31196, -31083, -30795, -30394, -29992, -29717, -29707, -29998, -30549, -31236, -31885, -32284, -32280, -31821, -30940, -29742, -28357, -26889, -25367, -23737, -21839, -19483, -16482, -12727, -8242, -3038};