/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0124 256 samples */
 
const int16_t AKWF_eorgan_0124_256_DATA [256] = 
{2515, 9471, 15605, 20915, 25265, 28606, 30939, 32298, 32774, 32477, 31535, 30067, 28201, 26070, 23814, 21529, 19305, 17274, 15517, 14055, 12894, 12059, 11568, 11441, 11702, 12368, 13414, 14784, 16403, 18200, 20072, 21899, 23541, 24760, 25409, 25423, 24781, 23496, 21631, 19322, 16724, 13981, 11237, 8593, 6135, 3919, 1944, 195, -1340, -2618, -3657, -4536, -5343, -6127, -6894, -7609, -8207, -8605, -8725, -8509, -7924, -6963, -5662, -4078, -2303, -530, 1112, 2540, 3704, 4599, 5250, 5703, 6035, 6331, 6659, 7065, 7563, 8105, 8623, 9023, 9249, 9338, 9278, 9019, 8541, 7902, 7080, 6100, 5126, 4289, 3753, 3692, 4194, 5297, 6979, 9166, 11728, 14403, 17004, 19418, 21531, 23278, 24601, 25441, 25777, 25609, 24961, 23849, 22283, 20276, 17819, 14918, 11606, 7994, 4189, 276, -3565, -7104, -10199, -12736, -14576, -15600, -15728, -14912, -13155, -10506, -7090, -3072, 1288, 5474, 9133, 12080, 14168, 15328, 15537, 14826, 13261, 10954, 8035, 4627, 862, -3063, -6932, -10628, -14065, -17121, -19730, -21888, -23604, -24867, -25666, -25996, -25825, -25143, -23966, -22338, -20323, -17977, -15401, -12707, -10045, -7681, -5788, -4454, -3726, -3583, -3961, -4711, -5661, -6667, -7570, -8288, -8864, -9220, -9369, -9347, -9186, -8846, -8357, -7805, -7269, -6808, -6434, -6112, -5781, -5358, -4765, -3943, -2860, -1510, 71, 1812, 3603, 5252, 6640, 7703, 8396, 8710, 8672, 8332, 7760, 7041, 6253, 5440, 4618, 3748, 2761, 1567, 118, -1546, -3417, -5521, -7875, -10431, -13117, -15848, -18486, -20891, -22916, -24403, -25268, -25480, -25044, -24014, -22493, -20713, -18847, -17011, -15319, -13851, -12676, -11864, -11446, -11425, -11775, -12472, -13499, -14832, -16464, -18375, -20515, -22757, -24995, -27150, -29098, -30693, -31811, -32329, -32120, -31068, -29069, -26072, -22060, -17062, -11190, -4429};