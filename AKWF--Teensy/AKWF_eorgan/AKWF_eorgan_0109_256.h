/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0109 256 samples */
 
const int16_t AKWF_eorgan_0109_256_DATA [256] = 
{1408, 4341, 7110, 9741, 12184, 14416, 16419, 18178, 19705, 21016, 22131, 23086, 23919, 24665, 25363, 26041, 26720, 27415, 28130, 28861, 29595, 30314, 30989, 31589, 32091, 32465, 32695, 32768, 32677, 32424, 32024, 31496, 30868, 30183, 29477, 28781, 28127, 27539, 27034, 26627, 26321, 26112, 25993, 25948, 25940, 25952, 25965, 25957, 25911, 25817, 25666, 25460, 25199, 24896, 24565, 24223, 23885, 23566, 23278, 23028, 22820, 22653, 22525, 22425, 22348, 22277, 22198, 22104, 21988, 21850, 21690, 21513, 21330, 21150, 20989, 20862, 20782, 20758, 20798, 20894, 21042, 21228, 21434, 21638, 21813, 21951, 22002, 21922, 21716, 21368, 20875, 20248, 19498, 18645, 17717, 16739, 15746, 14778, 13865, 13026, 12281, 11629, 11066, 10585, 10163, 9777, 9402, 9008, 8561, 8044, 7438, 6736, 5944, 5066, 4126, 3153, 2177, 1240, 383, -358, -955, -1384, -1636, -1708, -1614, -1374, -1019, -590, -120, 335, 732, 1028, 1188, 1187, 1009, 651, 121, -564, -1378, -2286, -3247, -4220, -5173, -6073, -6894, -7628, -8265, -8811, -9279, -9685, -10059, -10434, -10835, -11285, -11811, -12421, -13124, -13921, -14799, -15739, -16717, -17691, -18627, -19498, -20274, -20935, -21466, -21854, -22101, -22215, -22200, -22076, -21909, -21706, -21491, -21289, -21120, -20998, -20931, -20927, -20981, -21087, -21231, -21399, -21576, -21750, -21910, -22050, -22169, -22264, -22342, -22412, -22480, -22565, -22678, -22827, -23016, -23247, -23519, -23824, -24153, -24491, -24823, -25134, -25404, -25624, -25787, -25894, -25947, -25958, -25940, -25915, -25903, -25920, -25997, -26160, -26418, -26777, -27236, -27783, -28402, -29073, -29764, -30445, -31082, -31631, -32061, -32348, -32476, -32439, -32240, -31889, -31402, -30806, -30127, -29389, -28626, -27862, -27108, -26373, -25657, -24948, -24230, -23476, -22647, -21713, -20633, -19370, -17896, -16198, -14258, -12087, -9696, -7109, -4369, -1452};