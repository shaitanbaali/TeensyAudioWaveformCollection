/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0024 256 samples */
 
const int16_t AKWF_eorgan_0024_256_DATA [256] = 
{678, 2321, 3883, 5401, 6894, 8418, 9937, 11446, 12940, 14423, 15872, 17278, 18645, 19951, 21193, 22381, 23513, 24577, 25574, 26511, 27379, 28180, 28919, 29581, 30184, 30730, 31203, 31610, 31953, 32231, 32454, 32623, 32727, 32768, 32759, 32692, 32573, 32402, 32185, 31915, 31599, 31237, 30849, 30412, 29954, 29512, 29093, 28703, 28357, 28055, 27803, 27586, 27377, 27195, 27001, 26799, 26554, 26261, 25926, 25539, 25100, 24615, 24076, 23494, 22877, 22236, 21561, 20866, 20146, 19403, 18654, 17880, 17072, 16227, 15333, 14407, 13460, 12477, 11468, 10423, 9373, 8295, 7198, 6092, 4957, 3804, 2646, 1502, 376, -720, -1794, -2836, -3842, -4804, -5714, -6575, -7381, -8121, -8815, -9441, -10014, -10529, -10982, -11357, -11664, -11917, -12096, -12204, -12253, -12231, -12128, -11942, -11709, -11425, -11062, -10623, -10118, -9562, -8949, -8283, -7571, -6833, -6130, -5455, -4778, -4091, -3414, -2737, -2047, -1397, -770, -156, 449, 1039, 1595, 2144, 2682, 3219, 3732, 4215, 4671, 5083, 5445, 5771, 6056, 6291, 6473, 6612, 6696, 6728, 6711, 6632, 6507, 6340, 6111, 5832, 5506, 5129, 4715, 4267, 3771, 3234, 2671, 2073, 1451, 803, 137, -550, -1252, -1966, -2671, -3398, -4131, -4851, -5565, -6281, -6988, -7692, -8377, -9056, -9738, -10392, -11039, -11665, -12287, -12903, -13500, -14087, -14663, -15225, -15786, -16341, -16888, -17423, -17959, -18487, -19018, -19548, -20065, -20587, -21120, -21667, -22241, -22817, -23385, -23959, -24525, -25093, -25634, -26168, -26686, -27179, -27667, -28141, -28593, -28999, -29365, -29680, -29949, -30174, -30359, -30517, -30669, -30829, -31003, -31180, -31378, -31561, -31727, -31852, -31907, -31854, -31686, -31398, -30963, -30376, -29650, -28780, -27760, -26607, -25368, -24049, -22639, -21151, -19599, -18010, -16380, -14711, -13016, -11310, -9584, -7847, -6111, -4378, -2675, -960};