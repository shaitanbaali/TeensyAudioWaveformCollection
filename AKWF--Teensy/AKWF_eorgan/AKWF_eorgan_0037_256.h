/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0037 256 samples */
 
const int16_t AKWF_eorgan_0037_256_DATA [256] = 
{1099, 5154, 8217, 10907, 14233, 17475, 20371, 23138, 25807, 28524, 31074, 32661, 32187, 29146, 23936, 17550, 11364, 6673, 4202, 3766, 4902, 7123, 9767, 12047, 13357, 13449, 12442, 10796, 9137, 8040, 7823, 8412, 9289, 9721, 9168, 7518, 4987, 1857, -1210, -3649, -5876, -7834, -8585, -7841, -5777, -3115, -673, 2165, 5657, 8996, 12152, 15246, 18238, 20919, 22819, 23569, 23089, 21633, 19692, 17928, 16981, 17156, 17845, 17542, 14981, 9978, 3048, -4363, -10321, -15561, -20721, -23885, -24814, -24078, -22078, -19665, -17545, -16128, -15418, -15131, -14808, -13933, -12174, -9559, -6514, -3761, -642, 3458, 7124, 9284, 9861, 9107, 7723, 6387, 5714, 5857, 6234, 5841, 3892, 346, -3854, -7483, -10683, -13856, -15657, -15612, -14324, -12338, -10393, -9017, -8444, -8657, -9456, -10688, -12408, -14599, -16985, -19369, -21780, -24145, -26120, -27352, -27682, -27004, -25222, -22287, -18376, -13758, -8855, -4128, -109, 2698, 4932, 7523, 10137, 12572, 15052, 17561, 19840, 21015, 20032, 16603, 11359, 5589, 964, -1809, -3441, -3596, -2183, -441, 1122, 2646, 3602, 3514, 2625, 1389, 350, -157, -139, 254, 780, 975, 490, -502, -2158, -5041, -8897, -12824, -16112, -18167, -18661, -17396, -14486, -10518, -6269, -2391, 725, 2882, 4849, 7368, 10093, 12543, 14320, 15025, 14622, 13398, 11888, 10693, 10363, 11048, 12000, 11780, 9367, 5018, 72, -5479, -12578, -19488, -24240, -26621, -26849, -25299, -22657, -19720, -17186, -15445, -14446, -13849, -13129, -11730, -9333, -5970, -1927, 2182, 5492, 8365, 11300, 13187, 13443, 12636, 11335, 10214, 9786, 10060, 10435, 9998, 8153, 5322, 2303, -1177, -4989, -7636, -8478, -7699, -5725, -3301, -1101, 385, 1009, 870, 215, -850, -2401, -4377, -6518, -8677, -10882, -13048, -14789, -15788, -15897, -15033, -13090, -10100, -6125, -1838};