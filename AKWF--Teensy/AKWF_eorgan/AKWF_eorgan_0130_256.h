/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0130 256 samples */
 
const int16_t AKWF_eorgan_0130_256_DATA [256] = 
{461, 1428, 2422, 3466, 4555, 5692, 6877, 8104, 9376, 10689, 12034, 13411, 14815, 16231, 17659, 19082, 20485, 21861, 23193, 24465, 25673, 26800, 27834, 28772, 29599, 30311, 30903, 31369, 31708, 31916, 31996, 31945, 31768, 31468, 31047, 30512, 29869, 29123, 28279, 27348, 26333, 25241, 24082, 22859, 21579, 20252, 18876, 17460, 16013, 14532, 13024, 11499, 9949, 8385, 6812, 5225, 3632, 2039, 441, -1152, -2740, -4322, -5888, -7439, -8974, -10482, -11962, -13414, -14828, -16205, -17541, -18829, -20070, -21262, -22398, -23483, -24513, -25483, -26398, -27253, -28046, -28780, -29451, -30057, -30602, -31084, -31503, -31863, -32160, -32397, -32577, -32697, -32759, -32763, -32712, -32604, -32440, -32221, -31947, -31618, -31237, -30804, -30320, -29789, -29211, -28589, -27928, -27226, -26490, -25723, -24926, -24104, -23261, -22398, -21517, -20625, -19719, -18805, -17885, -16955, -16021, -15084, -14136, -13184, -12225, -11253, -10271, -9277, -8263, -7232, -6181, -5104, -4007, -2882, -1729, -554, 647, 1874, 3117, 4379, 5656, 6937, 8222, 9502, 10764, 12007, 13219, 14388, 15513, 16582, 17585, 18522, 19383, 20161, 20856, 21465, 21982, 22411, 22750, 23000, 23164, 23244, 23245, 23171, 23026, 22817, 22548, 22224, 21853, 21436, 20983, 20495, 19978, 19435, 18870, 18285, 17684, 17069, 16440, 15801, 15150, 14490, 13820, 13141, 12452, 11757, 11051, 10336, 9615, 8884, 8147, 7405, 6657, 5908, 5156, 4405, 3656, 2912, 2172, 1443, 721, 9, -690, -1378, -2053, -2713, -3360, -3992, -4604, -5201, -5779, -6334, -6871, -7386, -7877, -8349, -8796, -9220, -9621, -9996, -10345, -10668, -10962, -11225, -11458, -11656, -11819, -11946, -12035, -12084, -12093, -12061, -11988, -11873, -11718, -11521, -11285, -11010, -10697, -10347, -9963, -9545, -9093, -8612, -8097, -7555, -6984, -6382, -5751, -5093, -4401, -3678, -2924, -2133, -1308, -424};