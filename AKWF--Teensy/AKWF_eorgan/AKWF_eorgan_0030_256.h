/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0030 256 samples */
 
const int16_t AKWF_eorgan_0030_256_DATA [256] = 
{1344, 4510, 7771, 11037, 13984, 16294, 17830, 18634, 18878, 18786, 18499, 18116, 17704, 17299, 16892, 16433, 15838, 15013, 13885, 12433, 10694, 8778, 6843, 5126, 3750, 2509, 1367, 389, -369, -875, -1112, -1084, -807, -316, 352, 1157, 2043, 2898, 3692, 4736, 6045, 7531, 9130, 10787, 12470, 14095, 15547, 16668, 17191, 16969, 16136, 15033, 13968, 13106, 12510, 12215, 12256, 12660, 13437, 14570, 16021, 17725, 19483, 21118, 22903, 24906, 27057, 29212, 31058, 32282, 32759, 32600, 32025, 31229, 30334, 29380, 28363, 27259, 26008, 24551, 22824, 20756, 18318, 15531, 12456, 9243, 6091, 3361, 970, -1562, -4178, -6750, -9190, -11444, -13470, -15256, -16811, -18141, -19266, -20208, -20979, -21597, -22071, -22404, -22604, -22678, -22640, -22520, -22362, -22223, -22166, -22288, -22797, -23801, -25145, -26502, -27608, -28348, -28712, -28707, -28330, -27572, -26432, -24932, -23108, -21020, -18868, -16826, -14618, -12179, -9576, -6953, -4626, -2903, -1913, -1606, -1803, -2273, -2872, -3499, -4089, -4608, -5072, -5537, -6092, -6842, -7866, -9189, -10787, -12552, -14330, -15890, -17109, -18200, -19198, -20038, -20669, -21054, -21177, -21043, -20671, -20089, -19335, -18453, -17496, -16575, -15720, -14620, -13259, -11727, -10088, -8394, -6678, -5024, -3547, -2403, -1861, -2067, -2887, -3977, -5034, -5893, -6517, -6886, -6940, -6647, -5997, -5004, -3698, -2137, -509, 1020, 2734, 4709, 6882, 9115, 11096, 12513, 13240, 13384, 13159, 12758, 12293, 11800, 11273, 10675, 9947, 9023, 7834, 6307, 4406, 2150, -405, -3115, -5799, -8139, -10097, -12101, -14140, -16098, -17893, -19476, -20810, -21887, -22716, -23309, -23687, -23871, -23880, -23728, -23428, -22988, -22413, -21712, -20905, -20022, -19108, -18226, -17442, -16858, -16689, -17050, -17798, -18655, -19351, -19579, -19360, -18737, -17715, -16296, -14482, -12304, -9801, -7041, -4228, -1463};