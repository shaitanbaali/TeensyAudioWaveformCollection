/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0039 256 samples */
 
const int16_t AKWF_eorgan_0039_256_DATA [256] = 
{1880, 4696, 6819, 9827, 13119, 16211, 19056, 21699, 24288, 26859, 29024, 29373, 26511, 20222, 12056, 4748, 286, -1370, -1401, -671, 445, 1640, 2362, 2039, 659, -1053, -2146, -2098, -684, 2237, 6285, 10390, 12444, 10987, 6726, 1596, -2296, -4177, -4966, -5856, -7147, -8138, -8033, -6493, -4429, -2190, 907, 4051, 6619, 8369, 9329, 9779, 10068, 9901, 8435, 5796, 2726, 39, -1394, -1360, -180, 1740, 3867, 4424, 989, -5489, -13040, -22821, -30393, -32863, -30993, -26088, -19763, -13314, -8087, -5213, -4531, -5079, -5972, -6187, -5249, -3640, -2048, -929, -57, 1181, 2727, 4512, 5861, 5501, 3002, -168, -2537, -4342, -4608, -3549, -3164, -4843, -8679, -13637, -17656, -19040, -17680, -14403, -10207, -5833, -1945, 804, 2036, 2024, 1261, 411, 256, 928, 1557, 1063, -921, -4530, -9564, -14570, -18268, -20206, -20076, -18067, -14828, -10952, -6904, -2892, 932, 4436, 7240, 9310, 11960, 14805, 17475, 20073, 22659, 25279, 27329, 27245, 23738, 17090, 9365, 3545, 947, -82, 109, 985, 1799, 2488, 2964, 2593, 1675, 608, -267, 87, 1439, 3712, 7440, 11155, 12573, 10565, 6253, 1858, -594, -1994, -3325, -4802, -6345, -7296, -6828, -4780, -1839, 747, 3089, 5942, 8369, 10047, 11007, 11535, 11919, 11668, 10057, 7417, 4530, 2249, 1258, 1613, 2999, 5084, 7172, 7200, 3111, -3320, -11443, -21369, -27722, -29202, -26552, -21226, -14723, -8416, -3595, -1206, -814, -1440, -2201, -2136, -1035, 517, 1755, 2707, 3969, 5437, 7207, 9119, 10279, 9366, 6322, 2596, 38, -1206, -1224, -389, -393, -2211, -6012, -10643, -13938, -14516, -12540, -8956, -4768, -803, 2108, 3735, 4676, 4440, 3489, 2781, 2753, 3349, 3737, 2916, 1291, -1758, -6623, -11384, -14904, -16646, -16312, -14211, -11022, -7367, -3496, -386};