/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0094 256 samples */
 
const int16_t AKWF_eorgan_0094_256_DATA [256] = 
{1204, 3562, 5822, 8031, 10167, 12223, 14189, 16051, 17809, 19455, 20985, 22400, 23699, 24881, 25952, 26916, 27774, 28539, 29214, 29805, 30323, 30773, 31160, 31495, 31782, 32025, 32229, 32397, 32532, 32637, 32711, 32755, 32768, 32755, 32711, 32639, 32532, 32393, 32221, 32013, 31768, 31488, 31173, 30824, 30439, 30024, 29578, 29108, 28615, 28102, 27574, 27037, 26490, 25938, 25384, 24829, 24274, 23722, 23169, 22620, 22071, 21519, 20965, 20404, 19839, 19284, 18741, 18203, 17673, 17146, 16621, 16095, 15569, 15042, 14516, 13986, 13459, 12934, 12413, 11897, 11390, 10892, 10407, 9936, 9476, 9039, 8614, 8191, 7779, 7377, 6976, 6579, 6181, 5780, 5372, 4955, 4526, 4085, 3631, 3164, 2684, 2190, 1683, 1169, 647, 124, -394, -904, -1397, -1863, -2300, -2698, -3048, -3344, -3581, -3750, -3851, -3879, -3832, -3709, -3513, -3247, -2913, -2519, -2072, -1580, -1051, -498, 73, 635, 1172, 1678, 2142, 2552, 2906, 3193, 3411, 3557, 3626, 3619, 3539, 3390, 3172, 2890, 2555, 2170, 1744, 1284, 796, 289, -227, -752, -1275, -1794, -2305, -2803, -3289, -3759, -4217, -4661, -5094, -5513, -5922, -6324, -6721, -7116, -7513, -7913, -8321, -8738, -9161, -9591, -10044, -10510, -10990, -11484, -11987, -12500, -13019, -13541, -14069, -14597, -15124, -15652, -16177, -16702, -17227, -17753, -18282, -18815, -19355, -19905, -20464, -21016, -21561, -22103, -22642, -23181, -23720, -24261, -24803, -25346, -25888, -26428, -26964, -27491, -28010, -28515, -29000, -29465, -29905, -30315, -30696, -31041, -31352, -31629, -31869, -32072, -32240, -32373, -32471, -32537, -32571, -32577, -32552, -32498, -32413, -32297, -32151, -31972, -31757, -31506, -31210, -30869, -30476, -30023, -29504, -28913, -28242, -27483, -26632, -25678, -24618, -23450, -22165, -20765, -19251, -17620, -15875, -14028, -12074, -10029, -7901, -5698, -3440, -1083};