/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0066 256 samples */
 
const int16_t AKWF_eorgan_0066_256_DATA [256] = 
{1826, 6200, 10356, 14308, 17965, 21269, 24170, 26628, 28641, 30216, 31370, 32146, 32591, 32762, 32721, 32527, 32241, 31914, 31589, 31303, 31077, 30930, 30860, 30863, 30932, 31047, 31195, 31360, 31523, 31671, 31795, 31888, 31946, 31970, 31962, 31926, 31863, 31777, 31669, 31536, 31375, 31178, 30949, 30674, 30326, 29916, 29438, 28891, 28284, 27621, 26917, 26192, 25463, 24756, 24093, 23492, 22972, 22547, 22224, 22002, 21878, 21839, 21867, 21941, 22038, 22121, 22174, 22168, 22085, 21910, 21634, 21256, 20780, 20215, 19580, 18890, 18165, 17428, 16700, 15995, 15330, 14708, 14136, 13616, 13138, 12720, 12320, 11921, 11533, 11141, 10739, 10323, 9891, 9442, 8978, 8501, 8013, 7512, 6997, 6462, 5898, 5292, 4624, 3884, 3051, 2111, 1055, -129, -1439, -2861, -4377, -5956, -7550, -9116, -10591, -11911, -13020, -13852, -14354, -14481, -14203, -13504, -12385, -10868, -8994, -6813, -4402, -1838, 804, 3397, 5867, 8134, 10114, 11753, 13005, 13839, 14250, 14246, 13855, 13115, 12077, 10806, 9357, 7796, 6190, 4581, 3024, 1552, 187, -1049, -2157, -3144, -4016, -4788, -5479, -6100, -6674, -7214, -7729, -8228, -8714, -9189, -9653, -10103, -10537, -10956, -11362, -11754, -12141, -12535, -12928, -13334, -13798, -14300, -14851, -15451, -16096, -16782, -17495, -18221, -18942, -19635, -20278, -20856, -21350, -21748, -22046, -22243, -22344, -22363, -22317, -22231, -22126, -22034, -21981, -21988, -22075, -22258, -22540, -22927, -23411, -23981, -24620, -25307, -26024, -26745, -27447, -28115, -28729, -29282, -29768, -30184, -30536, -30810, -31036, -31227, -31380, -31501, -31598, -31674, -31726, -31755, -31758, -31730, -31669, -31574, -31445, -31288, -31113, -30930, -30757, -30608, -30499, -30449, -30466, -30559, -30731, -30967, -31250, -31550, -31822, -32022, -32090, -31969, -31596, -30913, -29870, -28420, -26539, -24218, -21449, -18270, -14720, -10853, -6756, -2413};