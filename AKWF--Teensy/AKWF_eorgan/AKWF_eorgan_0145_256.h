/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0145 256 samples */
 
const int16_t AKWF_eorgan_0145_256_DATA [256] = 
{1171, 3336, 5944, 8944, 12206, 15592, 18957, 22148, 25053, 27572, 29621, 31166, 32190, 32701, 32737, 32348, 31600, 30560, 29304, 27905, 26421, 24918, 23447, 22047, 20764, 19633, 18679, 17936, 17419, 17142, 17109, 17309, 17719, 18295, 18987, 19732, 20455, 21088, 21564, 21825, 21831, 21562, 21017, 20215, 19194, 18012, 16720, 15384, 14066, 12807, 11646, 10606, 9689, 8899, 8220, 7632, 7125, 6687, 6313, 6013, 5798, 5689, 5706, 5868, 6185, 6653, 7266, 7996, 8803, 9647, 10480, 11256, 11938, 12499, 12922, 13205, 13352, 13380, 13307, 13151, 12927, 12637, 12284, 11857, 11334, 10700, 9936, 9024, 7964, 6764, 5442, 4043, 2615, 1219, -77, -1211, -2133, -2805, -3208, -3351, -3257, -2973, -2559, -2081, -1603, -1192, -906, -786, -869, -1178, -1725, -2515, -3542, -4804, -6288, -7971, -9840, -11854, -13960, -16113, -18236, -20255, -22096, -23669, -24895, -25704, -26034, -25846, -25127, -23891, -22183, -20078, -17699, -15175, -12646, -10260, -8128, -6355, -5016, -4156, -3792, -3912, -4485, -5461, -6768, -8343, -10104, -11967, -13870, -15740, -17523, -19180, -20664, -21947, -23003, -23805, -24336, -24588, -24555, -24250, -23694, -22928, -22001, -20976, -19929, -18932, -18055, -17362, -16893, -16673, -16703, -16960, -17407, -17988, -18646, -19320, -19954, -20508, -20947, -21255, -21428, -21470, -21399, -21228, -20978, -20659, -20274, -19819, -19283, -18647, -17894, -17005, -15967, -14784, -13465, -12029, -10517, -8969, -7430, -5954, -4572, -3317, -2212, -1256, -445, 234, 803, 1281, 1680, 2010, 2268, 2443, 2519, 2476, 2297, 1968, 1488, 871, 142, -656, -1468, -2236, -2890, -3372, -3631, -3632, -3358, -2812, -2020, -1020, 130, 1360, 2612, 3816, 4910, 5852, 6602, 7137, 7445, 7521, 7371, 7002, 6432, 5680, 4770, 3738, 2625, 1480, 364, -650, -1493, -2078, -2332, -2184, -1578, -423};