/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0122 256 samples */
 
const int16_t AKWF_eorgan_0122_256_DATA [256] = 
{2247, 8004, 13182, 17801, 21760, 25029, 27612, 29544, 30913, 31816, 32357, 32639, 32751, 32767, 32749, 32722, 32695, 32668, 32628, 32552, 32429, 32256, 32040, 31801, 31573, 31392, 31277, 31238, 31257, 31303, 31324, 31254, 31014, 30527, 29721, 28547, 26990, 25058, 22790, 20274, 17603, 14889, 12248, 9760, 7503, 5520, 3800, 2321, 1038, -101, -1144, -2143, -3138, -4137, -5116, -6029, -6802, -7353, -7613, -7530, -7080, -6272, -5144, -3761, -2215, -661, 784, 2032, 3024, 3746, 4210, 4460, 4558, 4588, 4627, 4729, 4927, 5214, 5566, 5923, 6221, 6406, 6421, 6215, 5755, 5084, 4178, 3054, 1840, 639, -435, -1277, -1821, -2043, -1951, -1588, -1019, -338, 365, 1003, 1505, 1832, 1955, 1870, 1598, 1172, 632, 7, -692, -1455, -2295, -3231, -4279, -5442, -6714, -8067, -9450, -10779, -11959, -12889, -13457, -13553, -13097, -12035, -10363, -8106, -5353, -2218, 1120, 4348, 7249, 9693, 11574, 12848, 13510, 13595, 13173, 12347, 11230, 9926, 8534, 7144, 5820, 4597, 3492, 2500, 1617, 818, 87, -573, -1151, -1627, -1964, -2119, -2074, -1818, -1374, -776, -84, 620, 1247, 1706, 1913, 1816, 1397, 664, -333, -1496, -2717, -3886, -4883, -5638, -6195, -6499, -6568, -6443, -6181, -5838, -5473, -5151, -4910, -4764, -4695, -4656, -4579, -4382, -3990, -3357, -2457, -1292, 91, 1615, 3178, 4622, 5836, 6751, 7313, 7506, 7343, 6865, 6138, 5240, 4255, 3235, 2217, 1201, 165, -943, -2171, -3573, -5195, -7071, -9221, -11618, -14194, -16875, -19553, -22118, -24472, -26517, -28197, -29496, -30417, -30997, -31303, -31406, -31387, -31321, -31266, -31257, -31317, -31451, -31637, -31849, -32046, -32205, -32316, -32374, -32392, -32385, -32375, -32364, -32348, -32311, -32202, -31954, -31482, -30687, -29465, -27716, -25339, -22291, -18548, -14127, -9110, -3469};