/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0001 256 samples */
 
const int16_t AKWF_eorgan_0001_256_DATA [256] = 
{318, 1132, 1911, 2701, 3495, 4280, 5052, 5804, 6541, 7263, 7964, 8650, 9318, 9967, 10600, 11216, 11812, 12392, 12954, 13498, 14025, 14534, 15026, 15504, 15965, 16411, 16843, 17260, 17665, 18059, 18441, 18813, 19176, 19530, 19878, 20219, 20554, 20884, 21210, 21533, 21851, 22167, 22478, 22787, 23092, 23393, 23693, 23987, 24276, 24560, 24839, 25112, 25378, 25637, 25887, 26129, 26360, 26581, 26791, 26988, 27184, 27393, 27627, 27901, 28221, 28588, 28998, 29444, 29911, 30385, 30850, 31286, 31682, 32025, 32306, 32522, 32670, 32750, 32766, 32725, 32628, 32482, 32292, 32064, 31799, 31500, 31169, 30804, 30407, 29978, 29513, 29013, 28478, 27904, 27294, 26647, 25961, 25242, 24488, 23699, 22884, 22041, 21172, 20286, 19382, 18464, 17539, 16606, 15670, 14737, 13806, 12881, 11965, 11056, 10159, 9276, 8405, 7548, 6706, 5878, 5065, 4269, 3486, 2719, 1968, 1229, 507, -222, -966, -1705, -2435, -3157, -3869, -4571, -5265, -5950, -6626, -7298, -7960, -8619, -9273, -9922, -10570, -11216, -11858, -12502, -13145, -13786, -14430, -15074, -15716, -16362, -17008, -17652, -18296, -18939, -19578, -20215, -20847, -21472, -22091, -22701, -23300, -23890, -24465, -25026, -25572, -26099, -26607, -27096, -27561, -28002, -28419, -28808, -29169, -29502, -29803, -30074, -30314, -30520, -30693, -30834, -30940, -31013, -31053, -31059, -31032, -30974, -30883, -30761, -30610, -30431, -30224, -29992, -29734, -29453, -29152, -28831, -28490, -28135, -27764, -27380, -26985, -26578, -26163, -25743, -25314, -24882, -24469, -24091, -23767, -23509, -23323, -23207, -23152, -23143, -23164, -23192, -23208, -23193, -23131, -23012, -22831, -22583, -22270, -21899, -21475, -21005, -20497, -19962, -19402, -18825, -18233, -17625, -17008, -16375, -15727, -15066, -14385, -13685, -12967, -12226, -11462, -10681, -9877, -9056, -8220, -7369, -6507, -5641, -4769, -3898, -3033, -2174, -1328, -479};