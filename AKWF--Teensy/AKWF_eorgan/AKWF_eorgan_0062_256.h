/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0062 256 samples */
 
const int16_t AKWF_eorgan_0062_256_DATA [256] = 
{2833, 11281, 18752, 24925, 29415, 32038, 32795, 31877, 29622, 26468, 22907, 19382, 16278, 13871, 12277, 11490, 11387, 11752, 12336, 12902, 13250, 13287, 12965, 12347, 11583, 10836, 10286, 10086, 10298, 10908, 11819, 12856, 13801, 14422, 14519, 13961, 12708, 10832, 8503, 5983, 3566, 1555, 236, -230, 170, 1396, 3251, 5437, 7593, 9365, 10430, 10551, 9652, 7778, 5120, 1979, -1248, -4156, -6379, -7624, -7739, -6721, -4728, -2040, 979, 3869, 6248, 7792, 8290, 7688, 6084, 3722, 941, -1855, -4264, -5950, -6679, -6353, -4997, -2812, -95, 2808, 5520, 7710, 9138, 9723, 9404, 8297, 6666, 4793, 2977, 1497, 554, 254, 594, 1473, 2710, 4078, 5344, 6317, 6860, 6931, 6557, 5871, 5040, 4232, 3617, 3282, 3218, 3361, 3543, 3537, 3095, 1984, 45, -2770, -6396, -10606, -15047, -19299, -22867, -25285, -26174, -25273, -22507, -17976, -11999, -5025, 2403, 9599, 15999, 21105, 24531, 26109, 25845, 23936, 20722, 16646, 12204, 7840, 3945, 800, -1482, -2901, -3579, -3728, -3597, -3423, -3403, -3631, -4153, -4907, -5743, -6499, -6997, -7083, -6701, -5860, -4664, -3291, -1960, -907, -335, -378, -1077, -2369, -4086, -5970, -7729, -9070, -9699, -9460, -8366, -6450, -3908, -1048, 1767, 4181, 5866, 6579, 6242, 4897, 2733, 45, -2773, -5315, -7219, -8194, -8091, -6907, -4799, -2050, 975, 3819, 6096, 7486, 7778, 6919, 5009, 2294, -885, -4125, -7015, -9220, -10502, -10759, -10015, -8465, -6400, -4166, -2134, -631, 106, -10, -1017, -2794, -5082, -7591, -10021, -12088, -13584, -14404, -14543, -14101, -13256, -12232, -11255, -10519, -10156, -10206, -10640, -11326, -12092, -12772, -13198, -13277, -13022, -12496, -11869, -11369, -11247, -11732, -12992, -15076, -17918, -21297, -24863, -28199, -30814, -32246, -32116, -30175, -26347, -20751, -13705, -5479};