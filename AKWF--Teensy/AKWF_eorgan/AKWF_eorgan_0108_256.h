/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0108 256 samples */
 
const int16_t AKWF_eorgan_0108_256_DATA [256] = 
{1406, 4247, 6938, 9510, 11917, 14140, 16161, 17968, 19566, 20968, 22188, 23254, 24195, 25035, 25810, 26539, 27241, 27932, 28614, 29288, 29947, 30578, 31162, 31682, 32118, 32451, 32671, 32767, 32737, 32583, 32319, 31958, 31525, 31055, 30576, 30114, 29693, 29331, 29044, 28843, 28731, 28704, 28755, 28872, 29022, 29190, 29361, 29516, 29638, 29718, 29750, 29726, 29650, 29528, 29367, 29178, 28974, 28762, 28553, 28353, 28164, 27988, 27824, 27667, 27514, 27352, 27179, 26985, 26774, 26540, 26288, 26022, 25748, 25478, 25220, 24983, 24779, 24611, 24483, 24389, 24322, 24273, 24224, 24159, 24054, 23902, 23669, 23324, 22867, 22289, 21587, 20772, 19853, 18846, 17775, 16662, 15531, 14420, 13353, 12346, 11414, 10559, 9780, 9072, 8418, 7806, 7215, 6625, 6014, 5373, 4688, 3956, 3183, 2375, 1552, 737, -48, -768, -1394, -1900, -2262, -2468, -2512, -2393, -2127, -1730, -1237, -679, -85, 498, 1029, 1474, 1799, 1982, 2006, 1864, 1562, 1112, 531, -157, -917, -1722, -2546, -3361, -4148, -4895, -5597, -6252, -6872, -7466, -8051, -8653, -9287, -9967, -10717, -11536, -12434, -13409, -14446, -15535, -16651, -17762, -18840, -19861, -20801, -21644, -22375, -22986, -23475, -23849, -24112, -24279, -24391, -24459, -24503, -24543, -24593, -24668, -24776, -24920, -25104, -25321, -25563, -25821, -26086, -26345, -26594, -26827, -27039, -27229, -27401, -27559, -27706, -27853, -28007, -28171, -28347, -28537, -28736, -28940, -29141, -29329, -29493, -29621, -29705, -29739, -29718, -29644, -29524, -29368, -29190, -29007, -28837, -28692, -28601, -28588, -28657, -28814, -29058, -29381, -29769, -30206, -30668, -31130, -31565, -31935, -32218, -32393, -32446, -32372, -32172, -31853, -31423, -30905, -30314, -29665, -28984, -28284, -27571, -26851, -26122, -25372, -24584, -23741, -22809, -21761, -20573, -19211, -17658, -15903, -13932, -11759, -9394, -6857, -4188, -1357};