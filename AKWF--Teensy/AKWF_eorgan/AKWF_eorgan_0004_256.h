/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0004 256 samples */
 
const int16_t AKWF_eorgan_0004_256_DATA [256] = 
{465, 1252, 2028, 2833, 3650, 4465, 5275, 6074, 6862, 7634, 8387, 9120, 9832, 10519, 11184, 11823, 12436, 13023, 13586, 14123, 14637, 15127, 15593, 16037, 16461, 16864, 17248, 17611, 17956, 18285, 18597, 18893, 19174, 19441, 19695, 19938, 20170, 20393, 20609, 20814, 21015, 21211, 21400, 21587, 21773, 21966, 22184, 22437, 22737, 23092, 23506, 23975, 24496, 25057, 25647, 26252, 26859, 27455, 28030, 28576, 29087, 29562, 29997, 30394, 30756, 31084, 31381, 31649, 31889, 32102, 32289, 32448, 32577, 32674, 32739, 32767, 32756, 32703, 32606, 32461, 32271, 32032, 31744, 31407, 31021, 30587, 30110, 29586, 29022, 28418, 27777, 27105, 26404, 25673, 24920, 24148, 23356, 22549, 21731, 20902, 20066, 19222, 18374, 17524, 16671, 15818, 14968, 14118, 13273, 12436, 11603, 10776, 9962, 9155, 8357, 7575, 6801, 6040, 5294, 4558, 3837, 3128, 2429, 1741, 1066, 392, -304, -1011, -1720, -2428, -3136, -3843, -4551, -5260, -5971, -6681, -7397, -8116, -8835, -9560, -10288, -11019, -11754, -12491, -13230, -13972, -14716, -15458, -16202, -16945, -17685, -18424, -19158, -19885, -20607, -21319, -22018, -22708, -23381, -24038, -24680, -25298, -25897, -26473, -27021, -27544, -28038, -28501, -28935, -29334, -29699, -30028, -30323, -30580, -30802, -30986, -31134, -31244, -31317, -31355, -31357, -31325, -31258, -31160, -31030, -30870, -30681, -30464, -30222, -29956, -29668, -29360, -29031, -28689, -28330, -27957, -27574, -27181, -26780, -26373, -25960, -25543, -25123, -24703, -24280, -23857, -23434, -23012, -22592, -22174, -21759, -21348, -20938, -20532, -20129, -19728, -19331, -18935, -18547, -18186, -17862, -17585, -17362, -17191, -17066, -16976, -16904, -16833, -16746, -16626, -16457, -16231, -15940, -15582, -15157, -14672, -14129, -13542, -12913, -12254, -11573, -10872, -10157, -9435, -8702, -7964, -7222, -6473, -5719, -4959, -4193, -3422, -2647, -1867, -1088, -293};