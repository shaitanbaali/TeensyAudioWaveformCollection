/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0038 256 samples */
 
const int16_t AKWF_eorgan_0038_256_DATA [256] = 
{559, 1975, 3554, 5164, 6474, 7596, 8709, 9959, 11474, 13115, 14728, 16295, 17794, 19259, 20712, 22108, 23417, 24666, 25850, 26949, 27976, 28918, 29768, 30523, 31178, 31728, 32167, 32488, 32694, 32771, 32750, 32620, 32379, 32046, 31624, 31121, 30544, 29902, 29201, 28449, 27653, 26809, 25927, 25005, 24044, 23052, 22029, 20971, 19892, 18790, 17671, 16553, 15426, 14308, 13209, 12132, 11088, 10086, 9108, 8163, 7239, 6323, 5413, 4487, 3532, 2547, 1525, 470, -603, -1700, -2791, -3848, -4834, -5707, -6447, -7065, -7669, -8321, -9061, -9891, -10717, -11516, -12308, -13094, -13909, -14746, -15600, -16478, -17384, -18318, -19283, -20267, -21260, -22257, -23232, -24179, -25085, -25928, -26697, -27381, -27969, -28465, -28857, -29147, -29339, -29435, -29438, -29357, -29194, -28956, -28641, -28250, -27783, -27236, -26607, -25889, -25080, -24170, -23151, -22015, -20761, -19393, -17916, -16326, -14649, -12889, -11095, -9264, -7423, -5608, -3836, -2128, -522, 985, 2365, 3552, 4519, 5359, 6169, 7095, 8201, 9355, 10486, 11570, 12613, 13647, 14668, 15635, 16539, 17390, 18184, 18908, 19553, 20109, 20567, 20930, 21191, 21350, 21409, 21372, 21246, 21038, 20754, 20401, 19988, 19523, 19008, 18454, 17862, 17236, 16580, 15894, 15175, 14431, 13660, 12865, 12060, 11237, 10404, 9570, 8742, 7927, 7128, 6353, 5608, 4892, 4207, 3539, 2887, 2240, 1593, 943, 284, -388, -1056, -1705, -2305, -2828, -3331, -3867, -4485, -5215, -5973, -6701, -7397, -8048, -8681, -9303, -9897, -10476, -11054, -11641, -12249, -12884, -13549, -14261, -15011, -15802, -16635, -17492, -18368, -19254, -20130, -20977, -21780, -22515, -23177, -23750, -24222, -24588, -24849, -24997, -25038, -24976, -24815, -24561, -24219, -23795, -23292, -22708, -22050, -21308, -20482, -19570, -18563, -17458, -16255, -14929, -13491, -11942, -10279, -8536, -6718, -4842, -2888, -960};