/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0069 256 samples */
 
const int16_t AKWF_eorgan_0069_256_DATA [256] = 
{1167, 3702, 6161, 8586, 10953, 13249, 15460, 17565, 19561, 21435, 23172, 24773, 26230, 27533, 28690, 29694, 30546, 31253, 31816, 32242, 32538, 32711, 32768, 32721, 32578, 32348, 32040, 31667, 31235, 30751, 30228, 29669, 29081, 28472, 27843, 27199, 26543, 25875, 25197, 24509, 23810, 23096, 22376, 21640, 20878, 20098, 19295, 18467, 17617, 16739, 15837, 14911, 13961, 12994, 12010, 11013, 10012, 9012, 8018, 7041, 6087, 5163, 4282, 3451, 2678, 1974, 1345, 798, 340, -20, -281, -440, -493, -440, -282, -20, 340, 794, 1337, 1960, 2650, 3403, 4205, 5043, 5905, 6823, 7720, 8577, 9415, 10211, 10962, 11652, 12271, 12817, 13277, 13648, 13928, 14110, 14197, 14189, 14087, 13896, 13618, 13264, 12833, 12340, 11792, 11195, 10559, 9897, 9213, 8519, 7824, 7133, 6455, 5797, 5162, 4554, 3977, 3433, 2922, 2443, 1994, 1574, 1178, 802, 440, 91, -247, -594, -951, -1322, -1709, -2120, -2558, -3024, -3524, -4056, -4619, -5214, -5838, -6485, -7153, -7837, -8526, -9217, -9900, -10563, -11203, -11807, -12365, -12871, -13315, -13687, -13985, -14197, -14321, -14352, -14289, -14130, -13875, -13527, -13089, -12565, -11964, -11291, -10556, -9769, -8940, -8086, -7192, -6271, -5405, -4558, -3743, -2976, -2266, -1622, -1056, -577, -190, 99, 286, 368, 344, 215, -17, -352, -783, -1307, -1915, -2600, -3356, -4172, -5041, -5954, -6899, -7871, -8861, -9859, -10860, -11857, -12841, -13811, -14763, -15690, -16596, -17475, -18325, -19152, -19954, -20730, -21488, -22217, -22930, -23635, -24324, -25000, -25667, -26321, -26963, -27595, -28210, -28806, -29383, -29930, -30444, -30921, -31348, -31720, -32027, -32260, -32408, -32464, -32417, -32260, -31981, -31576, -31034, -30352, -29525, -28549, -27422, -26146, -24719, -23147, -21438, -19591, -17620, -15538, -13347, -11070, -8718, -6303, -3852, -1321};