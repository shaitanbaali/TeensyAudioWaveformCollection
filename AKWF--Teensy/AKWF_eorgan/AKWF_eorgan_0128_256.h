/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0128 256 samples */
 
const int16_t AKWF_eorgan_0128_256_DATA [256] = 
{472, 1374, 2364, 3454, 4634, 5904, 7255, 8675, 10161, 11700, 13278, 14889, 16509, 18117, 19703, 21248, 22733, 24153, 25493, 26738, 27884, 28922, 29842, 30642, 31318, 31864, 32282, 32571, 32731, 32765, 32679, 32473, 32155, 31733, 31212, 30598, 29905, 29138, 28306, 27422, 26491, 25524, 24535, 23526, 22511, 21500, 20497, 19511, 18553, 17621, 16725, 15872, 15059, 14294, 13579, 12913, 12297, 11734, 11218, 10754, 10339, 9969, 9644, 9360, 9117, 8909, 8736, 8594, 8481, 8395, 8334, 8296, 8278, 8277, 8294, 8325, 8369, 8425, 8490, 8561, 8639, 8719, 8801, 8881, 8958, 9030, 9090, 9140, 9175, 9191, 9183, 9149, 9086, 8988, 8852, 8675, 8453, 8183, 7859, 7476, 7034, 6530, 5961, 5330, 4636, 3879, 3062, 2188, 1261, 287, -730, -1782, -2861, -3963, -5080, -6196, -7313, -8414, -9490, -10538, -11543, -12498, -13397, -14230, -14990, -15675, -16276, -16791, -17221, -17563, -17816, -17984, -18070, -18077, -18010, -17877, -17683, -17437, -17147, -16822, -16470, -16106, -15738, -15373, -15024, -14699, -14407, -14156, -13953, -13804, -13715, -13690, -13732, -13843, -14024, -14275, -14591, -14973, -15415, -15909, -16453, -17035, -17650, -18289, -18941, -19601, -20257, -20898, -21520, -22113, -22665, -23174, -23631, -24027, -24359, -24624, -24815, -24931, -24971, -24933, -24818, -24624, -24355, -24014, -23608, -23140, -22614, -22035, -21407, -20734, -20024, -19280, -18506, -17711, -16897, -16066, -15227, -14382, -13533, -12685, -11841, -11003, -10176, -9358, -8555, -7770, -7000, -6251, -5526, -4820, -4141, -3488, -2863, -2268, -1705, -1173, -677, -220, 200, 578, 913, 1204, 1447, 1641, 1788, 1884, 1929, 1925, 1870, 1770, 1621, 1432, 1199, 931, 631, 304, -43, -402, -768, -1133, -1488, -1827, -2138, -2413, -2648, -2830, -2952, -3008, -2988, -2888, -2701, -2421, -2044, -1569, -992, -293};