/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0151 256 samples */
 
const int16_t AKWF_eorgan_0151_256_DATA [256] = 
{501, 1342, 2206, 3106, 4041, 5009, 6011, 7038, 8093, 9173, 10271, 11388, 12521, 13661, 14810, 15963, 17109, 18251, 19377, 20482, 21563, 22613, 23626, 24604, 25536, 26422, 27260, 28043, 28772, 29444, 30056, 30608, 31099, 31526, 31891, 32191, 32428, 32603, 32715, 32765, 32755, 32687, 32562, 32382, 32150, 31867, 31536, 31160, 30744, 30287, 29795, 29272, 28718, 28136, 27535, 26911, 26270, 25617, 24950, 24277, 23597, 22913, 22228, 21544, 20860, 20183, 19510, 18840, 18181, 17529, 16883, 16246, 15618, 14995, 14382, 13775, 13174, 12577, 11983, 11393, 10805, 10216, 9624, 9031, 8432, 7829, 7219, 6599, 5970, 5332, 4682, 4019, 3345, 2656, 1956, 1242, 512, -227, -977, -1742, -2514, -3296, -4086, -4879, -5675, -6474, -7269, -8064, -8851, -9626, -10391, -11142, -11870, -12580, -13264, -13916, -14539, -15127, -15676, -16187, -16655, -17078, -17456, -17786, -18069, -18302, -18485, -18617, -18700, -18732, -18714, -18648, -18535, -18376, -18172, -17926, -17642, -17319, -16962, -16574, -16158, -15717, -15254, -14774, -14282, -13778, -13272, -12766, -12261, -11766, -11283, -10815, -10364, -9937, -9535, -9161, -8817, -8506, -8231, -7992, -7789, -7626, -7502, -7418, -7375, -7371, -7407, -7481, -7593, -7740, -7922, -8138, -8383, -8656, -8955, -9278, -9618, -9978, -10349, -10730, -11117, -11506, -11893, -12278, -12655, -13020, -13373, -13712, -14031, -14330, -14608, -14860, -15089, -15291, -15465, -15611, -15729, -15817, -15879, -15911, -15915, -15892, -15843, -15770, -15673, -15555, -15415, -15256, -15082, -14890, -14686, -14471, -14245, -14013, -13774, -13531, -13286, -13040, -12794, -12549, -12308, -12069, -11836, -11605, -11380, -11161, -10945, -10734, -10526, -10321, -10118, -9917, -9713, -9507, -9298, -9082, -8857, -8623, -8376, -8114, -7837, -7538, -7221, -6879, -6510, -6113, -5688, -5229, -4738, -4214, -3651, -3053, -2418, -1745, -1035, -268};