/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0051 256 samples */
 
const int16_t AKWF_eorgan_0051_256_DATA [256] = 
{781, 2234, 3801, 5603, 7684, 10007, 12508, 15091, 17665, 20171, 22499, 24589, 26395, 27902, 29151, 30199, 31047, 31714, 32204, 32534, 32726, 32770, 32736, 32571, 32274, 31843, 31253, 30497, 29585, 28560, 27463, 26284, 24991, 23585, 22090, 20546, 19006, 17470, 15964, 14501, 13070, 11668, 10279, 8883, 7479, 6106, 4799, 3601, 2542, 1618, 826, 203, -218, -555, -879, -1164, -1422, -1668, -1919, -2176, -2433, -2677, -2901, -3123, -3363, -3637, -3927, -4209, -4461, -4680, -4859, -5010, -5151, -5309, -5511, -5783, -6151, -6601, -7100, -7604, -8092, -8552, -8983, -9378, -9727, -10030, -10299, -10546, -10790, -11066, -11452, -11991, -12674, -13408, -14097, -14776, -15504, -16329, -17203, -18062, -18851, -19566, -20204, -20772, -21284, -21745, -22165, -22558, -22914, -23197, -23356, -23332, -23082, -22592, -21857, -20865, -19613, -18089, -16294, -14271, -12101, -9883, -7681, -5530, -3464, -1643, -320, 897, 2273, 3609, 4994, 6578, 8401, 10427, 12602, 14845, 17090, 19246, 21223, 22971, 24460, 25668, 26642, 27412, 28003, 28430, 28698, 28823, 28827, 28720, 28509, 28187, 27748, 27175, 26438, 25511, 24469, 23395, 22378, 21378, 20305, 19128, 17866, 16572, 15281, 14029, 12818, 11663, 10548, 9462, 8390, 7309, 6213, 5137, 4122, 3200, 2391, 1681, 1076, 577, 183, -105, -280, -384, -474, -572, -691, -831, -985, -1141, -1299, -1473, -1690, -1946, -2234, -2538, -2839, -3127, -3401, -3668, -3953, -4274, -4657, -5140, -5740, -6443, -7210, -8007, -8807, -9615, -10420, -11203, -11966, -12710, -13448, -14226, -15098, -16107, -17272, -18545, -19846, -21061, -22108, -22996, -23827, -24645, -25481, -26296, -27062, -27768, -28396, -28939, -29404, -29795, -30113, -30375, -30575, -30685, -30642, -30389, -29901, -29169, -28184, -26927, -25380, -23534, -21401, -19031, -16493, -13880, -11240, -8637, -6134, -3731, -1761, -430};