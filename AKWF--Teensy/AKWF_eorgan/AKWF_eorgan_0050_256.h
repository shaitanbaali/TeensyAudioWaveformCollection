/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0050 256 samples */
 
const int16_t AKWF_eorgan_0050_256_DATA [256] = 
{959, 3334, 6038, 8938, 11919, 14664, 16774, 18416, 20204, 22228, 24338, 26412, 28351, 30041, 31335, 32190, 32653, 32771, 32603, 32213, 31674, 31005, 30181, 29113, 27666, 25691, 23243, 20561, 17716, 14690, 11572, 8521, 5665, 3172, 1115, -308, -1228, -2204, -3150, -4068, -4940, -5505, -5722, -5746, -5674, -5643, -5797, -6185, -6763, -7451, -8115, -8604, -8858, -8911, -8785, -8501, -8109, -7734, -7383, -6901, -6294, -5708, -5258, -4946, -4707, -4498, -4282, -4045, -3790, -3522, -3253, -3005, -2791, -2628, -2520, -2466, -2457, -2511, -2728, -3128, -3656, -4273, -4902, -5434, -5778, -5894, -5817, -5637, -5487, -5531, -5755, -5986, -6223, -6545, -6967, -7443, -7910, -8303, -8574, -8703, -8704, -8612, -8506, -8533, -8705, -8769, -8683, -8609, -8620, -8826, -9379, -10306, -11522, -12931, -14344, -15554, -16401, -16766, -16611, -15970, -14963, -13744, -12298, -10493, -8338, -6055, -3844, -1907, -447, 1275, 3502, 5950, 8446, 10803, 12696, 14174, 15793, 17751, 19833, 21946, 23998, 25847, 27331, 28392, 29059, 29375, 29392, 29207, 28902, 28498, 27939, 27120, 25926, 24221, 22024, 19606, 17021, 14250, 11390, 8562, 5915, 3585, 1660, 203, -701, -1361, -2045, -2742, -3389, -3774, -3833, -3717, -3526, -3355, -3344, -3552, -3949, -4469, -4992, -5359, -5517, -5493, -5294, -4942, -4525, -4182, -3900, -3528, -3074, -2656, -2365, -2212, -2143, -2109, -2082, -2049, -2010, -1968, -1923, -1893, -1901, -1955, -2065, -2231, -2447, -2744, -3235, -3971, -4926, -6002, -7052, -7938, -8593, -8985, -9133, -9134, -9123, -9273, -9619, -9975, -10292, -10678, -11150, -11663, -12155, -12559, -12819, -12911, -12843, -12665, -12449, -12370, -12429, -12348, -12098, -11839, -11661, -11662, -11989, -12697, -13702, -14868, -16037, -17013, -17629, -17759, -17361, -16471, -15193, -13705, -12018, -9959, -7602, -5141, -2828, -862};