/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0112 256 samples */
 
const int16_t AKWF_eorgan_0112_256_DATA [256] = 
{859, 2272, 3633, 4975, 6288, 7571, 8823, 10035, 11209, 12342, 13430, 14473, 15471, 16416, 17315, 18165, 18962, 19710, 20406, 21051, 21650, 22199, 22698, 23154, 23567, 23934, 24262, 24552, 24808, 25031, 25224, 25392, 25536, 25662, 25774, 25877, 25972, 26061, 26151, 26238, 26330, 26428, 26530, 26644, 26766, 26899, 27046, 27206, 27379, 27566, 27768, 27981, 28210, 28449, 28699, 28961, 29231, 29505, 29785, 30069, 30351, 30633, 30908, 31176, 31432, 31672, 31895, 32092, 32266, 32411, 32526, 32609, 32657, 32669, 32643, 32577, 32469, 32320, 32129, 31895, 31617, 31295, 30931, 30525, 30077, 29587, 29060, 28492, 27889, 27252, 26580, 25880, 25152, 24397, 23622, 22829, 22016, 21194, 20366, 19531, 18696, 17863, 17029, 16206, 15388, 14580, 13784, 13000, 12228, 11475, 10736, 10011, 9304, 8614, 7938, 7279, 6634, 6001, 5383, 4773, 4173, 3582, 2994, 2410, 1828, 1240, 650, 52, -548, -1139, -1722, -2301, -2874, -3448, -4025, -4606, -5193, -5790, -6397, -7015, -7648, -8293, -8954, -9632, -10325, -11035, -11760, -12500, -13258, -14030, -14810, -15608, -16414, -17226, -18048, -18870, -19695, -20521, -21341, -22154, -22959, -23748, -24518, -25268, -25990, -26688, -27356, -27991, -28593, -29159, -29686, -30175, -30623, -31029, -31393, -31715, -31992, -32227, -32418, -32567, -32675, -32741, -32767, -32754, -32706, -32621, -32502, -32356, -32178, -31975, -31750, -31505, -31243, -30967, -30685, -30396, -30104, -29811, -29521, -29236, -28954, -28683, -28420, -28168, -27928, -27701, -27488, -27289, -27102, -26929, -26770, -26624, -26489, -26362, -26247, -26139, -26035, -25936, -25837, -25737, -25633, -25521, -25401, -25267, -25116, -24942, -24743, -24515, -24255, -23961, -23630, -23259, -22844, -22388, -21885, -21335, -20736, -20089, -19392, -18643, -17845, -16994, -16095, -15148, -14149, -13104, -12015, -10882, -9705, -8491, -7236, -5950, -4634, -3287, -1920, -504};