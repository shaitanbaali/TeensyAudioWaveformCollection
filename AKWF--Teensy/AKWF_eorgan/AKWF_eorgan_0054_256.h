/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0054 256 samples */
 
const int16_t AKWF_eorgan_0054_256_DATA [256] = 
{219, 1036, 1837, 2640, 3440, 4239, 5036, 5828, 6618, 7404, 8184, 8961, 9732, 10496, 11255, 12008, 12752, 13490, 14218, 14938, 15650, 16352, 17042, 17725, 18398, 19056, 19706, 20342, 20966, 21578, 22176, 22762, 23333, 23890, 24433, 24963, 25476, 25974, 26458, 26925, 27373, 27808, 28225, 28626, 29008, 29373, 29721, 30051, 30362, 30656, 30931, 31187, 31425, 31645, 31842, 32022, 32185, 32326, 32448, 32551, 32634, 32697, 32740, 32764, 32768, 32753, 32717, 32664, 32589, 32494, 32380, 32248, 32094, 31921, 31732, 31522, 31290, 31043, 30776, 30490, 30186, 29864, 29523, 29166, 28791, 28398, 27988, 27560, 27118, 26660, 26181, 25690, 25184, 24661, 24124, 23572, 23007, 22428, 21835, 21229, 20609, 19979, 19334, 18681, 18013, 17334, 16649, 15950, 15243, 14527, 13802, 13067, 12327, 11577, 10820, 10060, 9291, 8516, 7738, 6954, 6166, 5374, 4579, 3781, 2982, 2175, 1385, 494, -152, -1043, -1833, -2641, -3441, -4240, -5037, -5829, -6619, -7405, -8185, -8962, -9733, -10497, -11255, -12009, -12752, -13490, -14219, -14939, -15650, -16353, -17043, -17725, -18398, -19056, -19707, -20342, -20966, -21578, -22177, -22762, -23334, -23890, -24433, -24964, -25476, -25974, -26458, -26925, -27373, -27808, -28225, -28626, -29008, -29373, -29721, -30052, -30362, -30656, -30931, -31187, -31425, -31645, -31842, -32022, -32185, -32326, -32448, -32551, -32634, -32697, -32740, -32764, -32768, -32753, -32717, -32664, -32589, -32494, -32380, -32248, -32094, -31921, -31732, -31522, -31290, -31043, -30776, -30490, -30186, -29864, -29523, -29166, -28791, -28398, -27988, -27560, -27118, -26660, -26182, -25690, -25185, -24661, -24124, -23573, -23008, -22429, -21835, -21229, -20609, -19980, -19335, -18681, -18014, -17334, -16649, -15951, -15243, -14527, -13802, -13068, -12327, -11577, -10821, -10060, -9291, -8517, -7739, -6954, -6166, -5375, -4580, -3782, -2983, -2181, -1380, -562};