/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0116 256 samples */
 
const int16_t AKWF_eorgan_0116_256_DATA [256] = 
{2420, 7761, 12125, 15814, 18911, 21512, 23696, 25518, 27045, 28319, 29375, 30247, 30960, 31532, 31984, 32325, 32564, 32709, 32767, 32737, 32621, 32417, 32122, 31731, 31237, 30632, 29901, 29032, 28011, 26813, 25426, 23821, 21986, 20005, 17915, 15726, 13464, 11144, 8783, 6414, 4049, 1706, -567, -2622, -4406, -5946, -7273, -8406, -9357, -10146, -10780, -11267, -11612, -11816, -11881, -11804, -11581, -11208, -10673, -9971, -9092, -8019, -6749, -5264, -3574, -1831, -98, 1555, 3045, 4388, 5594, 6664, 7616, 8456, 9188, 9822, 10360, 10806, 11161, 11426, 11596, 11669, 11639, 11500, 11235, 10864, 10337, 9608, 8690, 7551, 6165, 4511, 2557, 253, -2283, -4872, -7441, -9809, -11933, -13835, -15521, -17011, -18322, -19460, -20444, -21285, -21988, -22567, -23023, -23361, -23584, -23693, -23689, -23569, -23327, -22958, -22451, -21796, -20980, -19983, -18788, -17371, -15696, -13740, -11467, -8829, -5797, -2302, 1581, 5175, 8288, 11003, 13342, 15357, 17086, 18551, 19788, 20825, 21674, 22359, 22895, 23291, 23559, 23704, 23731, 23644, 23443, 23128, 22695, 22142, 21463, 20648, 19692, 18583, 17304, 15849, 14199, 12335, 10251, 7925, 5373, 2766, 195, -2182, -4211, -5932, -7377, -8567, -9535, -10306, -10881, -11280, -11574, -11742, -11799, -11750, -11605, -11364, -11033, -10611, -10097, -9488, -8783, -7973, -7053, -6015, -4846, -3542, -2094, -483, 1242, 2992, 4716, 6260, 7584, 8706, 9632, 10377, 10952, 11363, 11622, 11733, 11700, 11527, 11215, 10761, 10160, 9405, 8492, 7400, 6119, 4630, 2903, 912, -1315, -3633, -5978, -8331, -10683, -12999, -15261, -17457, -19559, -21557, -23424, -25074, -26501, -27734, -28787, -29684, -30441, -31070, -31584, -31994, -32306, -32528, -32660, -32705, -32664, -32535, -32312, -31989, -31557, -31006, -30316, -29471, -28447, -27211, -25728, -23957, -21835, -19306, -16294, -12708, -8460, -3266};