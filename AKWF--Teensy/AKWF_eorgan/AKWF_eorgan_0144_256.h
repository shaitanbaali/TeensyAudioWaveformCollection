/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0144 256 samples */
 
const int16_t AKWF_eorgan_0144_256_DATA [256] = 
{403, 1847, 3761, 5727, 7540, 9334, 11266, 13227, 15082, 16877, 18624, 20322, 21843, 23247, 24575, 25779, 26800, 27717, 28520, 29247, 29779, 30243, 30672, 30944, 31165, 31259, 31256, 31176, 30972, 30708, 30352, 29875, 29346, 28736, 28082, 27365, 26610, 25835, 25032, 24184, 23321, 22450, 21548, 20630, 19717, 18851, 17940, 17055, 16246, 15582, 14971, 14452, 14157, 14097, 14149, 14373, 14861, 15563, 16377, 17303, 18451, 19850, 21160, 22132, 22919, 24030, 25483, 26955, 28170, 29246, 30278, 31226, 31916, 32375, 32657, 32752, 32544, 32114, 31458, 30606, 29466, 28106, 26567, 24909, 23077, 21158, 19165, 17139, 15097, 13097, 11118, 9222, 7395, 5623, 3973, 2437, 957, -398, -1665, -2825, -3893, -4861, -5738, -6533, -7248, -7834, -8350, -8766, -9082, -9257, -9390, -9419, -9327, -9147, -8898, -8581, -8153, -7589, -7018, -6431, -5730, -4916, -4146, -3422, -2566, -1527, -675, -210, 79, 627, 1617, 2599, 3366, 4052, 4819, 5574, 6189, 6733, 7232, 7697, 8015, 8254, 8453, 8569, 8541, 8432, 8229, 7963, 7502, 6971, 6401, 5662, 4874, 3961, 2956, 1894, 732, -462, -1712, -3049, -4403, -5804, -7222, -8682, -10157, -11639, -13136, -14666, -16197, -17721, -19253, -20779, -22267, -23673, -25090, -26443, -27679, -28738, -29713, -30568, -31175, -31528, -31753, -31790, -31543, -31062, -30445, -29689, -28677, -27376, -26126, -25171, -24361, -23191, -21641, -20044, -18678, -17431, -16207, -15053, -14138, -13433, -12885, -12495, -12377, -12446, -12700, -13110, -13768, -14607, -15589, -16665, -17888, -19182, -20537, -21912, -23293, -24624, -25918, -27109, -28209, -29223, -30081, -30793, -31409, -31868, -32210, -32418, -32521, -32515, -32412, -32232, -31975, -31589, -31133, -30572, -29894, -29051, -28134, -27073, -25857, -24508, -23058, -21519, -19853, -18057, -16277, -14513, -12685, -10803, -9023, -7350, -5594, -3696, -2011, -691};