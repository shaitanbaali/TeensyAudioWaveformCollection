/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0147 256 samples */
 
const int16_t AKWF_eorgan_0147_256_DATA [256] = 
{995, 2860, 5012, 7451, 10118, 12933, 15803, 18621, 21313, 23802, 26019, 27935, 29523, 30774, 31703, 32327, 32672, 32770, 32646, 32326, 31831, 31180, 30388, 29469, 28443, 27333, 26165, 24982, 23825, 22737, 21771, 20967, 20356, 19955, 19767, 19771, 19931, 20196, 20507, 20796, 21000, 21067, 20952, 20627, 20079, 19314, 18346, 17203, 15924, 14536, 13078, 11582, 10065, 8549, 7055, 5590, 4176, 2836, 1588, 473, -475, -1222, -1724, -1951, -1878, -1497, -816, 136, 1305, 2630, 4038, 5449, 6792, 8006, 9035, 9853, 10439, 10793, 10927, 10864, 10632, 10260, 9778, 9209, 8569, 7876, 7140, 6365, 5570, 4771, 3985, 3235, 2555, 1978, 1542, 1278, 1205, 1332, 1650, 2134, 2738, 3407, 4077, 4680, 5152, 5438, 5497, 5303, 4842, 4126, 3169, 2003, 668, -805, -2376, -4007, -5681, -7369, -9045, -10700, -12305, -13834, -15265, -16557, -17674, -18581, -19236, -19609, -19682, -19446, -18915, -18116, -17099, -15928, -14683, -13446, -12292, -11289, -10495, -9944, -9660, -9647, -9893, -10378, -11071, -11944, -12962, -14091, -15313, -16601, -17930, -19292, -20658, -22006, -23308, -24523, -25611, -26530, -27235, -27691, -27869, -27754, -27350, -26673, -25762, -24666, -23447, -22180, -20925, -19743, -18688, -17789, -17065, -16519, -16132, -15883, -15751, -15708, -15727, -15785, -15867, -15959, -16050, -16133, -16196, -16226, -16202, -16099, -15881, -15517, -14970, -14210, -13214, -11977, -10504, -8819, -6972, -5015, -3021, -1074, 754, 2399, 3801, 4931, 5771, 6316, 6585, 6600, 6393, 5995, 5441, 4758, 3969, 3096, 2157, 1162, 133, -908, -1940, -2923, -3819, -4587, -5187, -5582, -5750, -5676, -5366, -4838, -4133, -3302, -2405, -1515, -690, 10, 541, 879, 1016, 954, 719, 344, -133, -676, -1246, -1808, -2341, -2820, -3230, -3557, -3783, -3891, -3859, -3659, -3258, -2623, -1724, -487};