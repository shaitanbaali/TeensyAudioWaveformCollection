/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0020 256 samples */
 
const int16_t AKWF_eorgan_0020_256_DATA [256] = 
{905, 3365, 5693, 7930, 10012, 11986, 13857, 15590, 17222, 18736, 20126, 21437, 22718, 23964, 25156, 26266, 27278, 28198, 29017, 29748, 30421, 31042, 31589, 32034, 32369, 32594, 32729, 32767, 32707, 32554, 32336, 32032, 31655, 31222, 30727, 30177, 29578, 28945, 28278, 27567, 26816, 26029, 25202, 24352, 23483, 22591, 21694, 20786, 19870, 18924, 17915, 16904, 15917, 14980, 14086, 13195, 12362, 11579, 10866, 10192, 9561, 8973, 8425, 7912, 7425, 6982, 6567, 6184, 5749, 5255, 4711, 4152, 3598, 3028, 2465, 1890, 1272, 644, -5, -699, -1427, -2174, -2956, -3772, -4576, -5364, -6159, -6991, -7867, -8770, -9673, -10596, -11520, -12446, -13358, -14252, -15105, -15914, -16676, -17391, -18026, -18594, -19089, -19516, -19854, -20119, -20292, -20372, -20364, -20254, -20033, -19687, -19228, -18665, -18045, -17348, -16510, -15520, -14441, -13305, -12140, -10975, -9762, -8492, -7185, -5711, -3973, -2062, -91, 1828, 3663, 5397, 6974, 8444, 9812, 11045, 12183, 13205, 14109, 14940, 15746, 16526, 17256, 17912, 18478, 18958, 19343, 19648, 19903, 20113, 20257, 20305, 20252, 20098, 19859, 19534, 19122, 18623, 18070, 17442, 16749, 16012, 15223, 14391, 13520, 12627, 11712, 10765, 9790, 8791, 7765, 6730, 5684, 4629, 3572, 2508, 1434, 325, -851, -2036, -3202, -4318, -5389, -6451, -7446, -8376, -9220, -10006, -10729, -11389, -11989, -12534, -13034, -13472, -13867, -14214, -14597, -15029, -15497, -15968, -16422, -16878, -17314, -17747, -18211, -18670, -19134, -19628, -20143, -20658, -21193, -21748, -22273, -22768, -23257, -23767, -24309, -24867, -25418, -25990, -26567, -27151, -27728, -28293, -28820, -29305, -29737, -30114, -30400, -30603, -30714, -30740, -30658, -30483, -30200, -29810, -29319, -28719, -27998, -27148, -26184, -25114, -23989, -22786, -21443, -19952, -18373, -16739, -15077, -13418, -11712, -9950, -8155, -6188, -3955, -1498};