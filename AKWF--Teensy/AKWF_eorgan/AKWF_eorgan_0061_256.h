/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0061 256 samples */
 
const int16_t AKWF_eorgan_0061_256_DATA [256] = 
{2333, 9138, 15394, 20977, 25633, 29192, 31549, 32662, 32585, 31431, 29381, 26648, 23483, 20156, 16903, 13952, 11496, 9654, 8502, 8053, 8258, 9038, 10229, 11671, 13197, 14625, 15815, 16657, 17054, 16969, 16410, 15423, 14089, 12524, 10849, 9191, 7675, 6399, 5435, 4827, 4577, 4651, 5011, 5567, 6168, 6746, 7201, 7445, 7419, 7089, 6453, 5528, 4390, 3116, 1797, 526, -596, -1490, -2097, -2380, -2333, -1981, -1376, -590, 307, 1182, 1958, 2561, 2925, 3018, 2835, 2397, 1756, 984, 174, -581, -1193, -1583, -1666, -1422, -845, 39, 1174, 2473, 3837, 5207, 6401, 7317, 7912, 8129, 7959, 7423, 6581, 5517, 4345, 3187, 2168, 1405, 986, 976, 1388, 2205, 3344, 4707, 6161, 7530, 8646, 9342, 9444, 8859, 7515, 5403, 2584, -844, -4710, -8791, -12860, -16645, -19882, -22347, -23835, -24202, -23375, -21352, -18208, -14078, -9192, -3799, 1836, 7340, 12440, 16871, 20384, 22820, 24077, 24126, 23019, 20873, 17876, 14242, 10226, 6105, 2112, -1518, -4589, -6986, -8626, -9494, -9643, -9148, -8171, -6876, -5427, -4009, -2763, -1799, -1217, -1055, -1308, -1934, -2852, -3954, -5117, -6220, -7144, -7792, -8096, -8021, -7565, -6769, -5667, -4354, -3008, -1687, -496, 474, 1156, 1517, 1546, 1257, 724, 21, -769, -1553, -2235, -2737, -3001, -2993, -2712, -2180, -1452, -601, 302, 1127, 1795, 2231, 2375, 2192, 1680, 862, -207, -1454, -2782, -4096, -5303, -6319, -7059, -7498, -7622, -7456, -7054, -6493, -5870, -5254, -4800, -4605, -4717, -5183, -6013, -7178, -8616, -10239, -11927, -13553, -14993, -16126, -16855, -17121, -16902, -16215, -15142, -13778, -12255, -10750, -9428, -8457, -8012, -8187, -9053, -10620, -12831, -15590, -18725, -22019, -25246, -28137, -30434, -31914, -32377, -31685, -29763, -26621, -22336, -17058, -11016, -4321};