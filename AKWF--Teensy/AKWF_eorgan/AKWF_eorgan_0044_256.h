/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0044 256 samples */
 
const int16_t AKWF_eorgan_0044_256_DATA [256] = 
{1051, 2842, 4631, 1512, 1475, 3847, 5711, 7573, 9360, 11066, 12695, 14308, 15912, 17337, 18525, 19560, 20509, 21390, 22083, 22894, 24496, 26018, 27373, 28585, 29636, 30521, 31260, 31847, 32288, 32584, 32741, 32763, 32634, 32499, 31810, 26231, 24930, 24656, 24049, 23373, 22560, 21673, 20763, 19768, 18699, 17591, 16462, 15286, 14060, 12798, 11577, 5103, 2630, 1854, 568, -696, -1867, -2901, -3925, -4983, -6054, -7126, -8160, -9057, -9875, -10573, -11178, -16588, -18479, -18158, -18202, -18131, -18013, -17851, -17657, -17420, -17149, -16850, -16528, -16180, -15817, -15455, -15046, -14978, -15729, -16347, -16784, -17096, -17311, -17430, -17454, -17376, -17195, -16923, -16565, -16130, -15602, -14804, -14267, -18599, -19107, -17948, -17013, -16012, -15063, -14121, -13118, -12072, -11009, -9934, -8852, -7777, -6704, -5689, -4300, -8722, -8756, -7106, -5904, -4671, -3476, -2319, -1207, -146, 862, 1791, 2641, 3511, 4318, 5134, 5724, 1257, 882, 2209, 3106, 3989, 4802, 5547, 6219, 6751, 7125, 7512, 7972, 8425, 8781, 9048, 9196, 9593, 10925, 12266, 13533, 14740, 15870, 16921, 17893, 18786, 19595, 20316, 20950, 21501, 21946, 22359, 22598, 17907, 16623, 17196, 17296, 17357, 17287, 17148, 17028, 16925, 16823, 16678, 16481, 16244, 15979, 15616, 15686, 9811, 8457, 8734, 8642, 8602, 8418, 8069, 7657, 7238, 6793, 6254, 5621, 5003, 4376, 3802, 3045, -2620, -4528, -4495, -4848, -5160, -5489, -5837, -6185, -6549, -6925, -7299, -7678, -8058, -8435, -8827, -9179, -9878, -11413, -12878, -14246, -15541, -16716, -17769, -18726, -19593, -20365, -21057, -21659, -22173, -22652, -23072, -23568, -28741, -29800, -29219, -28928, -28533, -28081, -27514, -26776, -25923, -24960, -23902, -22749, -21512, -20221, -18876, -17295, -20976, -20515, -18359, -16592, -14737, -12885, -11044, -9212, -7414, -5660, -3960, -2335, -621};