/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0079 256 samples */
 
const int16_t AKWF_eorgan_0079_256_DATA [256] = 
{2451, 9127, 15182, 20531, 24979, 28427, 30839, 32247, 32761, 32540, 31774, 30673, 29455, 28300, 27359, 26708, 26370, 26321, 26508, 26871, 27339, 27857, 28328, 28694, 28935, 29045, 29014, 28820, 28434, 27839, 27017, 25943, 24605, 23038, 21252, 19264, 17123, 14887, 12639, 10515, 8636, 7105, 6011, 5346, 5030, 5021, 5234, 5560, 5882, 6078, 6049, 5714, 5036, 4015, 2749, 1368, 10, -1180, -2082, -2609, -2717, -2407, -1728, -766, 362, 1464, 2412, 3104, 3473, 3502, 3220, 2694, 2033, 1377, 862, 621, 770, 1336, 2298, 3576, 5067, 6660, 8224, 9636, 10794, 11673, 12110, 12048, 11562, 10728, 9662, 8496, 7321, 6204, 5192, 4307, 3559, 2981, 2565, 2290, 2129, 2068, 2078, 2142, 2231, 2342, 2469, 2563, 2528, 2311, 1838, 1045, -117, -1691, -3670, -5992, -8541, -11132, -13558, -15602, -17060, -17750, -17545, -16374, -14239, -11205, -7429, -3114, 1482, 5929, 9925, 13248, 15715, 17236, 17782, 17396, 16188, 14323, 11999, 9425, 6826, 4388, 2253, 510, -816, -1755, -2353, -2668, -2773, -2723, -2611, -2500, -2405, -2336, -2301, -2327, -2444, -2665, -3015, -3520, -4195, -5011, -5956, -7020, -8161, -9323, -10427, -11348, -11964, -12189, -11921, -11187, -10149, -8827, -7313, -5723, -4187, -2821, -1738, -1023, -714, -816, -1238, -1848, -2514, -3092, -3465, -3546, -3294, -2709, -1843, -782, 356, 1381, 2164, 2604, 2633, 2239, 1446, 330, -1002, -2409, -3749, -4889, -5712, -6176, -6310, -6187, -5896, -5552, -5277, -5185, -5371, -5883, -6809, -8180, -9931, -11970, -14186, -16435, -18615, -20666, -22525, -24170, -25593, -26751, -27649, -28310, -28753, -28997, -29065, -28975, -28750, -28401, -27928, -27380, -26855, -26409, -26110, -26027, -26214, -26710, -27510, -28561, -29739, -30869, -31751, -32162, -31908, -30816, -28753, -25663, -21554, -16502, -10673, -4129};