/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0026 256 samples */
 
const int16_t AKWF_eorgan_0026_256_DATA [256] = 
{1495, 6898, 11677, 15766, 19137, 21869, 24065, 25816, 27221, 28350, 29254, 29987, 30583, 31065, 31460, 31783, 32046, 32259, 32431, 32563, 32664, 32731, 32764, 32762, 32717, 32619, 32450, 32180, 31767, 31155, 30294, 29177, 27896, 26628, 25501, 24534, 23672, 22820, 21890, 20807, 19508, 17979, 16278, 14516, 12839, 11365, 10123, 9101, 8257, 7535, 6888, 6276, 5663, 5019, 4315, 3520, 2609, 1560, 349, -1022, -2535, -4140, -5751, -7304, -8807, -10324, -11897, -13486, -15002, -16380, -17585, -18600, -19439, -20113, -20639, -21028, -21288, -21420, -21416, -21259, -20923, -20370, -19565, -18488, -17160, -15676, -14184, -12832, -11727, -10906, -10362, -10083, -10067, -10331, -10896, -11743, -12756, -13740, -14546, -15127, -15513, -15759, -15907, -15989, -16023, -16023, -15995, -15944, -15869, -15773, -15652, -15506, -15329, -15117, -14863, -14561, -14197, -13759, -13237, -12606, -11852, -10952, -9882, -8628, -7175, -5505, -3622, -1549, 628, 2759, 4729, 6491, 8034, 9372, 10519, 11487, 12301, 12982, 13548, 14020, 14414, 14740, 15014, 15243, 15434, 15593, 15724, 15830, 15915, 15975, 16014, 16026, 16008, 15948, 15831, 15631, 15310, 14818, 14110, 13189, 12163, 11225, 10533, 10142, 10042, 10210, 10640, 11341, 12327, 13582, 15030, 16538, 17948, 19138, 20058, 20715, 21138, 21368, 21436, 21360, 21154, 20820, 20355, 19745, 18977, 18039, 16915, 15609, 14146, 12576, 10988, 9447, 7946, 6422, 4831, 3211, 1652, 215, -1065, -2181, -3149, -3989, -4728, -5395, -6018, -6625, -7254, -7938, -8723, -9663, -10807, -12182, -13784, -15525, -17269, -18883, -20281, -21451, -22439, -23313, -24161, -25073, -26128, -27345, -28643, -29847, -30822, -31536, -32024, -32349, -32557, -32682, -32748, -32768, -32750, -32697, -32610, -32491, -32337, -32142, -31902, -31606, -31244, -30800, -30256, -29586, -28760, -27732, -26454, -24860, -22863, -20374, -17288, -13511, -9021, -3797};