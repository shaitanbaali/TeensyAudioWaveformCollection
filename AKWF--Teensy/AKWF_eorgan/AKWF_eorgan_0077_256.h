/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0077 256 samples */
 
const int16_t AKWF_eorgan_0077_256_DATA [256] = 
{2480, 9569, 15874, 21359, 25854, 29267, 31540, 32647, 32617, 31510, 29442, 26634, 23421, 20069, 16846, 13939, 11486, 9629, 8458, 7991, 8197, 9030, 10265, 11687, 13181, 14624, 15875, 16764, 17195, 17136, 16584, 15570, 14177, 12599, 10972, 9375, 7876, 6534, 5406, 4611, 4270, 4373, 4906, 5699, 6420, 6981, 7317, 7388, 7187, 6771, 6169, 5368, 4321, 3006, 1607, 323, -763, -1601, -2159, -2415, -2372, -2038, -1445, -633, 331, 1241, 2003, 2570, 2902, 2988, 2822, 2415, 1792, 999, 103, -753, -1342, -1615, -1629, -1424, -987, -260, 765, 2054, 3542, 5194, 6673, 7725, 8314, 8405, 8066, 7439, 6589, 5570, 4446, 3288, 2198, 1369, 924, 908, 1327, 2161, 3340, 4728, 6151, 7483, 8618, 9381, 9511, 8925, 7578, 5473, 2673, -693, -4480, -8537, -12617, -16448, -19713, -22131, -23556, -23904, -23137, -21257, -18304, -14344, -9522, -4007, 1945, 7655, 12744, 17031, 20350, 22617, 23781, 23823, 22769, 20685, 17693, 14009, 9975, 5860, 1929, -1627, -4667, -7053, -8691, -9561, -9695, -9140, -8119, -6847, -5440, -4021, -2732, -1743, -1151, -988, -1259, -1936, -2935, -4067, -5193, -6243, -7147, -7850, -8299, -8377, -7971, -7092, -5747, -4124, -2598, -1246, -138, 682, 1204, 1482, 1541, 1364, 904, 135, -761, -1588, -2264, -2738, -2980, -2972, -2714, -2217, -1512, -643, 327, 1191, 1856, 2272, 2404, 2237, 1769, 1010, -11, -1250, -2637, -4027, -5193, -6079, -6745, -7225, -7502, -7517, -7257, -6752, -6062, -5237, -4568, -4294, -4456, -5082, -6103, -7374, -8821, -10395, -12023, -13634, -15124, -16297, -17027, -17273, -17022, -16297, -15164, -13761, -12258, -10784, -9443, -8411, -7948, -8140, -9028, -10613, -12832, -15558, -18646, -21946, -25213, -28176, -30522, -31970, -32378, -31667, -29797, -26777, -22650, -17496, -11464, -4565};