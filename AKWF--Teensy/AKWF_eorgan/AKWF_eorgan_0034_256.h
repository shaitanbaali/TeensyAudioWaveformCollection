/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0034 256 samples */
 
const int16_t AKWF_eorgan_0034_256_DATA [256] = 
{1902, 5357, 8758, 12074, 15211, 18161, 20918, 23433, 25679, 27635, 29286, 30630, 31651, 32339, 32703, 32747, 32479, 31912, 31059, 29927, 28523, 26887, 25050, 23024, 20835, 18514, 16094, 13489, 10598, 7779, 5198, 2605, 107, -1840, -3300, -4351, -4900, -4949, -4617, -4016, -3198, -2195, -1070, 110, 1294, 2432, 3491, 4431, 5216, 5828, 6246, 6465, 6480, 6285, 5885, 5294, 4533, 3617, 2556, 1383, 126, -1192, -2538, -3888, -5213, -6479, -7659, -8729, -9659, -10329, -10658, -10861, -10964, -10787, -10323, -9809, -9149, -8145, -6893, -5552, -4129, -2550, -819, 1010, 2910, 4868, 6870, 8902, 10936, 12949, 14927, 16840, 18670, 20408, 22029, 23510, 24834, 25985, 26938, 27446, 27354, 26711, 25585, 24056, 22190, 20065, 17765, 15352, 12898, 10474, 8124, 5897, 3846, 2001, 399, -958, -2076, -2942, -3554, -3961, -4451, -4906, -4856, -4183, -3249, -2544, -1890, -925, 330, 1644, 2917, 4192, 5471, 6702, 7830, 8824, 9679, 10370, 10865, 11150, 11218, 11064, 10681, 10068, 9234, 8182, 6929, 5512, 3950, 2258, 458, -1419, -3334, -5255, -7173, -8926, -10357, -11778, -13283, -14589, -15667, -16422, -16551, -16055, -15137, -13924, -12425, -10661, -8707, -6653, -4564, -2477, -442, 1482, 3263, 4867, 6261, 7427, 8344, 8993, 9369, 9477, 9321, 8903, 8231, 7328, 6216, 4920, 3462, 1863, 161, -1617, -3448, -5296, -7137, -8952, -10708, -12487, -14334, -15991, -17407, -18742, -19980, -20881, -21533, -22138, -22607, -22795, -22719, -22471, -22079, -21527, -20812, -19972, -19033, -18011, -16935, -15828, -14702, -13584, -12497, -11456, -10484, -9590, -8778, -8060, -7478, -7265, -7558, -8315, -9470, -10942, -12657, -14536, -16501, -18490, -20437, -22270, -23942, -25394, -26578, -27471, -28038, -28235, -28036, -27434, -26429, -24984, -22836, -20139, -17400, -14803, -12047, -8703, -5038, -1410};