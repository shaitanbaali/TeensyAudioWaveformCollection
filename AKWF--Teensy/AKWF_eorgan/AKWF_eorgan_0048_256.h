/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0048 256 samples */
 
const int16_t AKWF_eorgan_0048_256_DATA [256] = 
{1424, 3816, 5998, 7958, 10253, 12729, 15078, 17156, 18947, 20395, 21472, 22172, 22489, 22436, 22040, 21308, 20144, 18722, 17677, 17015, 16667, 16640, 16911, 17457, 18241, 19214, 20325, 21518, 22751, 24056, 25339, 26524, 27647, 28680, 29618, 30439, 31142, 31775, 32269, 32587, 32762, 32647, 32214, 31515, 30567, 29296, 27720, 25897, 23871, 21698, 19486, 17229, 15033, 13015, 11261, 9859, 8824, 8153, 7885, 8019, 8534, 9326, 10296, 11342, 12329, 13098, 13275, 12973, 12920, 13008, 12953, 12628, 12043, 11216, 10194, 8991, 7605, 6130, 4638, 3211, 1914, 771, -113, -682, -1239, -1772, -2204, -2511, -2679, -2712, -2630, -2453, -2193, -1908, -1636, -1392, -1209, -1158, -1128, -973, -770, -595, -452, -247, 2, 199, 328, 311, 72, -312, -737, -1448, -2474, -3734, -5167, -6670, -8196, -9591, -10730, -11535, -11929, -11873, -11346, -10331, -8911, -7210, -5401, -3594, -1971, -802, -179, 360, 1136, 2063, 2931, 3595, 4010, 4194, 4094, 3750, 3171, 2409, 1546, 623, -191, -837, -1659, -2611, -3599, -4536, -5440, -6246, -6948, -7559, -8067, -8461, -8759, -8997, -9143, -9253, -9314, -9351, -9390, -9412, -9461, -9504, -9559, -9628, -9698, -9946, -10379, -10951, -11721, -12676, -13793, -15081, -16557, -18135, -19748, -21370, -22917, -24255, -25315, -26024, -26298, -26117, -25459, -24284, -22671, -20725, -18582, -16378, -14277, -12461, -11204, -10466, -9566, -8531, -7672, -7062, -6710, -6601, -6723, -7047, -7589, -8329, -9204, -10154, -11133, -12063, -12890, -13610, -14191, -14600, -14809, -14827, -14704, -14443, -14025, -13510, -12962, -12380, -11789, -11239, -10820, -10621, -10470, -10131, -9710, -9252, -8813, -8390, -7942, -7607, -7484, -7544, -7751, -8136, -8734, -9494, -10361, -11348, -12402, -13396, -14251, -14930, -15326, -15306, -14791, -13802, -12329, -10361, -7967, -5364, -2783, -532};