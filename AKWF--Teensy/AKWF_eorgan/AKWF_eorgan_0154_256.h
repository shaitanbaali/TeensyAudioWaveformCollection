/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0154 256 samples */
 
const int16_t AKWF_eorgan_0154_256_DATA [256] = 
{782, 2614, 4763, 6942, 8626, 10188, 11512, 12544, 13244, 13857, 14811, 15810, 16900, 17874, 19106, 20074, 20968, 22315, 23329, 24127, 24999, 25617, 25987, 26298, 26630, 27070, 27336, 27224, 26754, 26157, 25575, 25044, 24785, 25072, 25235, 25725, 26494, 27271, 28058, 28880, 29868, 30493, 30496, 30131, 29749, 29334, 28952, 28622, 28160, 27598, 27157, 26498, 25691, 24999, 24613, 24125, 23279, 22890, 22942, 23154, 23459, 24066, 24852, 25338, 26097, 26836, 27378, 27360, 27059, 26762, 25753, 24297, 22733, 21061, 19690, 18357, 17238, 16285, 15704, 15343, 15330, 15664, 15908, 16065, 16269, 16443, 16507, 16541, 16506, 16425, 15913, 14892, 13425, 11635, 9607, 7600, 5942, 4672, 3440, 2568, 1992, 1791, 1972, 2485, 3171, 3623, 3717, 3898, 4146, 4290, 4862, 5572, 6151, 6418, 6491, 6413, 5964, 5235, 4518, 3764, 2664, 1453, 537, -69, -437, -611, -559, -390, 123, 589, 1401, 2239, 2584, 2814, 2806, 2518, 1907, 1212, 873, 589, 403, 120, 104, -157, -473, -328, -496, -858, -1133, -1638, -2370, -3143, -3873, -4469, -5219, -6323, -7761, -9298, -10799, -12222, -13349, -13906, -14557, -14854, -14844, -14800, -14725, -14579, -14241, -14244, -14834, -15768, -16692, -17620, -18485, -19273, -20164, -21131, -21943, -22948, -24075, -25057, -25705, -26429, -27481, -28049, -28149, -28064, -27854, -27319, -26578, -26109, -25339, -24566, -23965, -23893, -24076, -24225, -25062, -26320, -27658, -29077, -30170, -31197, -31984, -32578, -32768, -32717, -32291, -31490, -30753, -30076, -29324, -28577, -27912, -27249, -26630, -26034, -25840, -26127, -26835, -27840, -29058, -30232, -31027, -31414, -31736, -31675, -31292, -30514, -29330, -27791, -26054, -24531, -23348, -22057, -20678, -19384, -17644, -15749, -13969, -12483, -11174, -10007, -9193, -8646, -8078, -7535, -7330, -7225, -6817, -6098, -5135, -3969, -2581, -1036};