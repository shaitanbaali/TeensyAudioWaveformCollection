/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0078 256 samples */
 
const int16_t AKWF_eorgan_0078_256_DATA [256] = 
{3002, 11739, 19175, 25169, 29488, 32030, 32793, 31880, 29561, 26415, 22912, 19400, 16273, 13787, 12141, 11386, 11395, 11789, 12287, 12754, 13090, 13236, 13038, 12412, 11510, 10735, 10311, 10234, 10491, 11064, 11897, 12899, 13896, 14547, 14621, 14041, 12792, 10919, 8523, 5844, 3236, 1212, 126, -42, 484, 1632, 3292, 5302, 7401, 9134, 10161, 10319, 9491, 7642, 4998, 1859, -1440, -4332, -6436, -7577, -7680, -6742, -4846, -2149, 1037, 3998, 6290, 7721, 8174, 7626, 6124, 3804, 936, -1918, -4335, -6032, -6723, -6351, -5017, -2881, -189, 2604, 5143, 7241, 8767, 9674, 9702, 8732, 6990, 4961, 3060, 1574, 642, 323, 625, 1493, 2771, 4117, 5288, 6178, 6711, 6857, 6604, 5951, 4983, 4101, 3572, 3377, 3355, 3437, 3533, 3525, 3211, 2203, 270, -2593, -6239, -10425, -14801, -18993, -22605, -25044, -25919, -25076, -22477, -18171, -12349, -5283, 2537, 9955, 16264, 21150, 24376, 25855, 25588, 23684, 20416, 16363, 12001, 7677, 3787, 592, -1712, -3068, -3606, -3703, -3639, -3544, -3526, -3639, -4035, -4800, -5783, -6581, -6969, -6953, -6547, -5767, -4673, -3359, -1995, -930, -393, -463, -1159, -2439, -4204, -6219, -8132, -9433, -9768, -9164, -7891, -6009, -3632, -924, 1846, 4223, 5864, 6601, 6317, 4975, 2798, 84, -2833, -5388, -7198, -8094, -7999, -6909, -4909, -2158, 1034, 3952, 6153, 7444, 7711, 6928, 5146, 2500, -739, -4008, -6879, -9074, -10300, -10497, -9768, -8267, -6239, -4135, -2307, -937, -153, -14, -737, -2429, -4869, -7564, -10099, -12181, -13669, -14503, -14669, -14221, -13314, -12288, -11383, -10707, -10331, -10284, -10580, -11219, -12113, -12862, -13200, -13145, -12858, -12410, -11888, -11414, -11189, -11601, -12883, -15046, -17937, -21316, -24840, -28131, -30799, -32254, -32103, -30202, -26513, -21103, -14161, -5767};