/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0102 256 samples */
 
const int16_t AKWF_eorgan_0102_256_DATA [256] = 
{1495, 4887, 8082, 11111, 13927, 16500, 18804, 20810, 22513, 23908, 24990, 25771, 26264, 26490, 26477, 26257, 25874, 25395, 24872, 24343, 23837, 23383, 23003, 22714, 22527, 22443, 22466, 22591, 22806, 23095, 23440, 23810, 24181, 24516, 24780, 24948, 24997, 24910, 24673, 24283, 23733, 23030, 22185, 21208, 20121, 18952, 17728, 16485, 15274, 14152, 13179, 12388, 11805, 11459, 11365, 11533, 11968, 12663, 13615, 14804, 16206, 17795, 19528, 21368, 23259, 25097, 26815, 28374, 29729, 30853, 31720, 32308, 32610, 32621, 32341, 31781, 30952, 29882, 28596, 27127, 25524, 23848, 22156, 20488, 18869, 17333, 15903, 14590, 13411, 12371, 11465, 10696, 10050, 9510, 9059, 8670, 8313, 7954, 7560, 7102, 6562, 5919, 5159, 4280, 3276, 2152, 919, -412, -1823, -3281, -4764, -6234, -7644, -8933, -10046, -10948, -11615, -12019, -12145, -11983, -11534, -10800, -9789, -8521, -7022, -5316, -3450, -1463, 589, 2603, 4509, 6266, 7829, 9167, 10256, 11073, 11605, 11851, 11806, 11480, 10885, 10047, 8987, 7740, 6353, 4886, 3395, 1917, 479, -888, -2160, -3327, -4378, -5301, -6104, -6787, -7363, -7846, -8259, -8626, -8978, -9348, -9770, -10270, -10871, -11590, -12441, -13426, -14549, -15808, -17187, -18679, -20260, -21898, -23572, -25243, -26859, -28361, -29692, -30816, -31708, -32339, -32692, -32758, -32533, -32018, -31222, -30163, -28865, -27352, -25668, -23851, -21954, -20084, -18308, -16662, -15195, -13934, -12901, -12121, -11601, -11347, -11357, -11623, -12132, -12858, -13778, -14856, -16045, -17284, -18517, -19704, -20819, -21833, -22718, -23465, -24060, -24497, -24778, -24905, -24893, -24752, -24506, -24183, -23809, -23419, -23048, -22721, -22462, -22289, -22212, -22241, -22374, -22612, -22941, -23351, -23821, -24321, -24829, -25302, -25698, -25952, -26011, -25840, -25412, -24700, -23692, -22375, -20747, -18817, -16584, -14076, -11316, -8331, -5171, -1799};