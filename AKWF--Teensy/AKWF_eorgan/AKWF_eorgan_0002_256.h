/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0002 256 samples */
 
const int16_t AKWF_eorgan_0002_256_DATA [256] = 
{194, 908, 1586, 2238, 2874, 3584, 4340, 5097, 5852, 6594, 7318, 8021, 8700, 9349, 9969, 10558, 11109, 11626, 12108, 12554, 12965, 13343, 13687, 13998, 14279, 14531, 14755, 14953, 15125, 15274, 15400, 15505, 15593, 15662, 15715, 15756, 15783, 15801, 15809, 15811, 15809, 15804, 15798, 15802, 15839, 15933, 16109, 16382, 16765, 17261, 17864, 18562, 19338, 20169, 21031, 21907, 22772, 23613, 24420, 25185, 25902, 26576, 27206, 27796, 28353, 28880, 29378, 29852, 30300, 30723, 31119, 31482, 31810, 32099, 32342, 32535, 32673, 32751, 32765, 32714, 32594, 32405, 32145, 31815, 31416, 30951, 30423, 29835, 29190, 28494, 27749, 26963, 26140, 25283, 24399, 23491, 22562, 21619, 20664, 19697, 18726, 17753, 16777, 15806, 14838, 13876, 12928, 11989, 11065, 10160, 9273, 8407, 7566, 6748, 5957, 5195, 4459, 3754, 3079, 2430, 1812, 1216, 548, -171, -884, -1583, -2262, -2921, -3561, -4182, -4788, -5380, -5959, -6529, -7093, -7650, -8206, -8762, -9319, -9882, -10451, -11026, -11611, -12208, -12814, -13435, -14070, -14716, -15380, -16058, -16748, -17453, -18170, -18896, -19632, -20375, -21120, -21868, -22615, -23357, -24091, -24813, -25519, -26208, -26871, -27507, -28113, -28683, -29213, -29702, -30142, -30535, -30876, -31162, -31392, -31565, -31677, -31730, -31723, -31656, -31530, -31346, -31105, -30809, -30460, -30062, -29615, -29125, -28595, -28027, -27427, -26799, -26146, -25473, -24785, -24084, -23376, -22663, -21948, -21238, -20534, -19837, -19154, -18482, -17824, -17186, -16565, -15964, -15386, -14829, -14295, -13785, -13297, -12831, -12392, -11971, -11573, -11197, -10841, -10504, -10201, -9958, -9802, -9749, -9811, -9984, -10260, -10619, -11032, -11470, -11900, -12287, -12603, -12824, -12931, -12917, -12778, -12520, -12152, -11691, -11153, -10553, -9909, -9233, -8535, -7824, -7105, -6379, -5651, -4921, -4185, -3449, -2711, -1975, -1243, -503};