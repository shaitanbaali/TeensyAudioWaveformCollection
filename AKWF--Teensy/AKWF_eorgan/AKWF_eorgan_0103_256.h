/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0103 256 samples */
 
const int16_t AKWF_eorgan_0103_256_DATA [256] = 
{1696, 5514, 9110, 12523, 15701, 18613, 21233, 23527, 25495, 27128, 28422, 29389, 30046, 30409, 30513, 30390, 30087, 29674, 29206, 28721, 28253, 27832, 27480, 27214, 27047, 26983, 27023, 27162, 27390, 27690, 28040, 28412, 28778, 29100, 29341, 29478, 29483, 29340, 29034, 28562, 27918, 27108, 26141, 25032, 23804, 22484, 21100, 19695, 18313, 17023, 15883, 14931, 14190, 13695, 13457, 13491, 13798, 14375, 15217, 16302, 17608, 19105, 20750, 22505, 24309, 26052, 27669, 29118, 30348, 31334, 32049, 32473, 32595, 32410, 31924, 31142, 30081, 28770, 27232, 25508, 23648, 21714, 19769, 17856, 16001, 14239, 12597, 11085, 9723, 8517, 7462, 6561, 5800, 5164, 4631, 4177, 3768, 3371, 2949, 2477, 1930, 1289, 540, -319, -1297, -2388, -3580, -4861, -6214, -7602, -9004, -10382, -11685, -12850, -13822, -14563, -15048, -15250, -15154, -14750, -14037, -13019, -11707, -10121, -8290, -6239, -4019, -1668, 751, 3128, 5390, 7495, 9393, 11052, 12447, 13548, 14349, 14841, 15021, 14899, 14490, 13816, 12898, 11777, 10496, 9120, 7709, 6298, 4916, 3598, 2365, 1229, 202, -705, -1500, -2182, -2766, -3266, -3706, -4112, -4512, -4947, -5448, -6044, -6757, -7605, -8601, -9748, -11052, -12505, -14095, -15808, -17622, -19504, -21429, -23356, -25230, -26988, -28572, -29940, -31068, -31923, -32487, -32752, -32710, -32364, -31722, -30804, -29631, -28233, -26652, -24929, -23119, -21336, -19644, -18088, -16714, -15552, -14625, -13960, -13562, -13438, -13588, -14002, -14665, -15550, -16634, -17879, -19237, -20640, -22032, -23371, -24631, -25778, -26785, -27643, -28336, -28857, -29209, -29395, -29428, -29322, -29100, -28790, -28420, -28029, -27650, -27312, -27039, -26848, -26751, -26759, -26868, -27080, -27379, -27755, -28184, -28639, -29090, -29498, -29815, -29972, -29917, -29610, -29021, -28126, -26910, -25357, -23468, -21252, -18706, -15860, -12741, -9375, -5815, -2017};