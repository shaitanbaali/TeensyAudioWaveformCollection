/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0081 256 samples */
 
const int16_t AKWF_eorgan_0081_256_DATA [256] = 
{2429, 8818, 14626, 19801, 24171, 27651, 30202, 31838, 32640, 32728, 32245, 31353, 30222, 29000, 27807, 26722, 25783, 25009, 24392, 23907, 23519, 23203, 22925, 22666, 22427, 22208, 22010, 21813, 21595, 21341, 21029, 20629, 20118, 19505, 18781, 17948, 17025, 16049, 15074, 14187, 13478, 13013, 12855, 12978, 13272, 13710, 14228, 14749, 15196, 15515, 15648, 15545, 15191, 14592, 13827, 13002, 12219, 11591, 11209, 11136, 11404, 12008, 12906, 14023, 15263, 16453, 17481, 18265, 18746, 18909, 18771, 18383, 17825, 17205, 16628, 16199, 16008, 16090, 16433, 16991, 17706, 18524, 19368, 20156, 20814, 21326, 21551, 21431, 21018, 20360, 19540, 18648, 17748, 16878, 16064, 15311, 14611, 13971, 13374, 12787, 12187, 11552, 10860, 10103, 9256, 8326, 7321, 6222, 4997, 3630, 2079, 315, -1670, -3875, -6262, -8768, -11294, -13694, -15801, -17449, -18483, -18768, -18210, -16766, -14447, -11314, -7511, -3208, 1378, 5807, 9810, 13201, 15817, 17575, 18443, 18442, 17652, 16195, 14222, 11889, 9375, 6829, 4368, 2074, -8, -1866, -3503, -4941, -6222, -7365, -8402, -9358, -10231, -11016, -11721, -12359, -12957, -13531, -14106, -14710, -15369, -16079, -16845, -17672, -18543, -19424, -20263, -20974, -21473, -21698, -21582, -21155, -20559, -19811, -18979, -18143, -17380, -16752, -16319, -16131, -16206, -16540, -17058, -17657, -18232, -18674, -18893, -18828, -18446, -17754, -16795, -15644, -14395, -13225, -12243, -11532, -11150, -11111, -11396, -11956, -12707, -13542, -14351, -15031, -15487, -15683, -15628, -15369, -14955, -14442, -13901, -13414, -13048, -12830, -12872, -13226, -13845, -14671, -15624, -16608, -17555, -18427, -19193, -19850, -20399, -20832, -21165, -21429, -21648, -21839, -22024, -22215, -22426, -22659, -22903, -23174, -23505, -23917, -24448, -25127, -25967, -26963, -28080, -29261, -30401, -31359, -31972, -32073, -31512, -30158, -27912, -24744, -20664, -15746, -10133, -3862};