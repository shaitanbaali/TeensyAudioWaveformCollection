/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0023 256 samples */
 
const int16_t AKWF_eorgan_0023_256_DATA [256] = 
{741, 3011, 5149, 7166, 9057, 10823, 12460, 13963, 15341, 16593, 17716, 18722, 19611, 20387, 21062, 21639, 22123, 22525, 22853, 23112, 23316, 23471, 23584, 23665, 23723, 23764, 23797, 23826, 23862, 23908, 23971, 24052, 24156, 24287, 24445, 24632, 24846, 25088, 25356, 25646, 25955, 26279, 26611, 26947, 27280, 27602, 27906, 28185, 28428, 28630, 28780, 28869, 28891, 28837, 28698, 28466, 28135, 27699, 27152, 26488, 25706, 24799, 23769, 22610, 21323, 19914, 18380, 16726, 14959, 13081, 11222, 9501, 7902, 6429, 5087, 3864, 2758, 1770, 888, 110, -571, -1166, -1678, -2117, -2491, -2807, -3074, -3300, -3494, -3660, -3808, -3943, -4074, -4204, -4337, -4478, -4631, -4797, -4979, -5177, -5390, -5618, -5859, -6109, -6368, -6627, -6884, -7134, -7370, -7584, -7774, -7927, -8038, -8098, -8102, -8042, -7908, -7695, -7398, -7005, -6515, -5923, -5220, -4406, -3479, -2432, -1271, 6, 1408, 2878, 4260, 5521, 6656, 7666, 8552, 9309, 9942, 10449, 10829, 11090, 11237, 11276, 11210, 11047, 10797, 10468, 10065, 9602, 9083, 8519, 7920, 7294, 6649, 5997, 5342, 4691, 4057, 3439, 2847, 2286, 1755, 1264, 813, 402, 32, -298, -588, -840, -1060, -1248, -1411, -1555, -1686, -1808, -1930, -2061, -2206, -2375, -2577, -2817, -3106, -3452, -3858, -4338, -4895, -5533, -6264, -7089, -8008, -9030, -10155, -11381, -12716, -14148, -15685, -17318, -19038, -20849, -22619, -24227, -25690, -27003, -28165, -29186, -30066, -30807, -31420, -31908, -32279, -32541, -32699, -32766, -32745, -32648, -32485, -32259, -31981, -31659, -31301, -30915, -30506, -30079, -29640, -29195, -28745, -28294, -27846, -27400, -26958, -26518, -26079, -25640, -25197, -24748, -24288, -23811, -23313, -22787, -22227, -21626, -20981, -20278, -19515, -18687, -17782, -16797, -15725, -14557, -13296, -11932, -10458, -8877, -7184, -5373, -3450, -1364};