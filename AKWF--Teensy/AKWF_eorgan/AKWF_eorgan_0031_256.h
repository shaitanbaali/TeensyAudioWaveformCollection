/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0031 256 samples */
 
const int16_t AKWF_eorgan_0031_256_DATA [256] = 
{2340, 6975, 11217, 15027, 18264, 20933, 23099, 24838, 26241, 27376, 28300, 29060, 29690, 30215, 30659, 31035, 31355, 31631, 31869, 32073, 32253, 32408, 32542, 32660, 32759, 32367, 31283, 29727, 28040, 26487, 25244, 23721, 21462, 19020, 16698, 14736, 13207, 12070, 11252, 10682, 10291, 10028, 9854, 9740, 9666, 9621, 9592, 9575, 9559, 9580, 9244, 8456, 7609, 6670, 5651, 4661, 3776, 3491, 4008, 5093, 6389, 7642, 8538, 8817, 9568, 10740, 11854, 12677, 13210, 13514, 13651, 13676, 13632, 13551, 13454, 13354, 13258, 13172, 13098, 13034, 12980, 12936, 12899, 12870, 12846, 12827, 12809, 12796, 12780, 12291, 11119, 9488, 7735, 6124, 4830, 3262, 964, -1511, -3867, -5848, -7438, -9089, -10346, -11418, -12281, -13014, -13706, -14374, -15017, -15627, -16202, -16737, -17225, -17707, -17791, -17384, -16883, -16261, -15526, -14795, -14136, -13103, -11484, -9499, -7461, -5623, -4896, -2925, 28, 3025, 5953, 8446, 10352, 11708, 12612, 13168, 13474, 13605, 13616, 13552, 13440, 13300, 13148, 12992, 12838, 12691, 12552, 12421, 12301, 12190, 12088, 11996, 11908, 11350, 10116, 8431, 6627, 4972, 3637, 2031, -298, -2804, -5184, -7196, -8770, -9948, -10802, -11403, -11821, -12109, -12307, -12440, -12530, -12592, -12634, -12664, -12689, -12678, -13022, -13818, -14672, -15617, -16641, -17637, -18526, -18814, -18301, -17218, -15926, -14674, -13781, -13503, -12754, -11584, -10471, -9649, -9117, -8815, -8679, -8655, -8698, -8780, -8877, -8977, -9073, -9159, -9234, -9299, -9353, -9399, -9434, -9464, -9488, -9507, -9525, -9538, -9553, -10043, -11215, -12846, -14599, -16210, -17504, -19072, -21369, -23847, -26196, -28193, -29709, -30374, -30789, -30889, -30838, -30657, -30335, -29915, -29435, -28934, -28429, -27939, -27470, -27058, -26318, -25159, -23966, -22711, -21400, -20145, -19008, -17541, -15527, -13179, -10807, -8730, -6089, -2275};