/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0093 256 samples */
 
const int16_t AKWF_eorgan_0093_256_DATA [256] = 
{959, 2716, 4414, 6092, 7736, 9349, 10927, 12461, 13954, 15401, 16796, 18143, 19437, 20674, 21856, 22979, 24041, 25044, 25985, 26863, 27679, 28435, 29124, 29753, 30321, 30825, 31269, 31653, 31978, 32245, 32454, 32610, 32712, 32761, 32761, 32712, 32617, 32476, 32294, 32070, 31807, 31507, 31172, 30803, 30403, 29977, 29522, 29045, 28545, 28020, 27476, 26917, 26336, 25741, 25131, 24507, 23870, 23223, 22564, 21894, 21219, 20533, 19842, 19145, 18444, 17757, 17085, 16427, 15788, 15163, 14556, 13968, 13394, 12836, 12297, 11773, 11265, 10774, 10296, 9835, 9389, 8955, 8534, 8128, 7731, 7354, 6986, 6621, 6267, 5920, 5581, 5252, 4930, 4615, 4309, 4012, 3721, 3439, 3167, 2903, 2648, 2403, 2168, 1944, 1728, 1525, 1333, 1151, 982, 823, 677, 543, 422, 311, 213, 125, 50, -12, -65, -107, -138, -161, -175, -179, -178, -171, -157, -139, -116, -96, -80, -68, -64, -66, -77, -97, -125, -163, -213, -272, -343, -426, -521, -628, -747, -876, -1019, -1174, -1342, -1518, -1707, -1908, -2120, -2340, -2573, -2815, -3066, -3326, -3597, -3877, -4164, -4459, -4762, -5075, -5394, -5721, -6058, -6401, -6752, -7116, -7482, -7855, -8249, -8651, -9069, -9499, -9941, -10400, -10872, -11358, -11862, -12381, -12915, -13467, -14036, -14619, -15221, -15839, -16472, -17124, -17789, -18470, -19163, -19852, -20536, -21213, -21882, -22542, -23193, -23833, -24460, -25077, -25679, -26266, -26837, -27390, -27925, -28441, -28935, -29405, -29851, -30271, -30663, -31025, -31354, -31650, -31908, -32126, -32304, -32440, -32531, -32577, -32574, -32521, -32416, -32259, -32046, -31777, -31452, -31066, -30621, -30116, -29548, -28919, -28229, -27475, -26657, -25781, -24838, -23835, -22774, -21651, -20469, -19234, -17939, -16593, -15196, -13748, -12255, -10720, -9142, -7527, -5881, -4203, -2501, -744};