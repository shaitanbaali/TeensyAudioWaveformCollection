/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0052 256 samples */
 
const int16_t AKWF_eorgan_0052_256_DATA [256] = 
{787, 3079, 5272, 7398, 9431, 11362, 13179, 14869, 16435, 17874, 19182, 20366, 21431, 22377, 23218, 23955, 24597, 25154, 25636, 26049, 26407, 26719, 26996, 27247, 27480, 27700, 27915, 28127, 28341, 28562, 28788, 29024, 29273, 29536, 29812, 30105, 30412, 30736, 31074, 31413, 31739, 32037, 32294, 32501, 32651, 32741, 32769, 32737, 32645, 32496, 32295, 32044, 31747, 31409, 31033, 30622, 30183, 29718, 29230, 28723, 28202, 27667, 27123, 26573, 26017, 25460, 24904, 24348, 23798, 23253, 22714, 22185, 21665, 21154, 20656, 20168, 19692, 19230, 18780, 18343, 17918, 17506, 17105, 16716, 16331, 15949, 15568, 15181, 14788, 14387, 13975, 13554, 13123, 12677, 12216, 11742, 11251, 10744, 10217, 9668, 9099, 8505, 7890, 7265, 6643, 6036, 5458, 4915, 4413, 3954, 3538, 3162, 2827, 2525, 2254, 2013, 1791, 1588, 1400, 1221, 1047, 877, 705, 529, 348, 157, -43, -257, -486, -730, -991, -1269, -1565, -1881, -2217, -2571, -2944, -3337, -3748, -4179, -4627, -5092, -5575, -6073, -6585, -7114, -7653, -8201, -8756, -9313, -9865, -10412, -10949, -11472, -11985, -12482, -12961, -13423, -13864, -14285, -14684, -15057, -15404, -15724, -16013, -16272, -16501, -16708, -16909, -17119, -17346, -17599, -17885, -18203, -18555, -18938, -19349, -19788, -20247, -20723, -21213, -21712, -22215, -22718, -23218, -23712, -24197, -24669, -25124, -25565, -25985, -26383, -26759, -27111, -27438, -27739, -28014, -28260, -28479, -28670, -28831, -28966, -29072, -29149, -29200, -29222, -29217, -29185, -29126, -29040, -28931, -28798, -28647, -28479, -28301, -28113, -27919, -27720, -27516, -27310, -27103, -26893, -26682, -26472, -26264, -26060, -25858, -25662, -25472, -25290, -25113, -24935, -24738, -24509, -24238, -23916, -23539, -23106, -22614, -22066, -21467, -20816, -20119, -19385, -18611, -17804, -16974, -16118, -15069, -13685, -12030, -10162, -8126, -5971, -3743, -1430};