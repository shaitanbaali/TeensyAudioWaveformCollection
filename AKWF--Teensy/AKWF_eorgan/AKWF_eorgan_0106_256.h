/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eorgan_0106 256 samples */
 
const int16_t AKWF_eorgan_0106_256_DATA [256] = 
{1444, 4466, 7289, 9979, 12521, 14916, 17161, 19244, 21175, 22953, 24573, 26041, 27360, 28527, 29548, 30425, 31156, 31750, 32206, 32525, 32712, 32768, 32696, 32499, 32181, 31743, 31190, 30527, 29763, 28898, 27944, 26909, 25807, 24702, 23618, 22560, 21542, 20563, 19629, 18747, 17916, 17138, 16419, 15755, 15147, 14597, 14103, 13666, 13284, 12957, 12683, 12462, 12292, 12173, 12101, 12077, 12095, 12155, 12254, 12385, 12545, 12727, 12925, 13132, 13331, 13462, 13502, 13443, 13281, 13011, 12632, 12141, 11535, 10820, 9997, 9078, 8131, 7173, 6194, 5196, 4179, 3137, 2070, 980, -140, -1290, -2467, -3679, -4919, -6187, -7489, -8815, -10162, -11533, -12914, -14303, -15685, -16998, -18218, -19342, -20360, -21267, -22060, -22733, -23288, -23718, -24023, -24202, -24254, -24179, -23975, -23642, -23182, -22591, -21870, -21023, -20043, -18938, -17706, -16344, -14862, -13259, -11534, -9698, -7755, -5708, -3571, -1350, 931, 3167, 5319, 7384, 9345, 11201, 12946, 14568, 16074, 17458, 18710, 19839, 20840, 21708, 22451, 23063, 23546, 23899, 24125, 24220, 24189, 24031, 23747, 23336, 22801, 22146, 21371, 20481, 19480, 18370, 17162, 15861, 14480, 13083, 11691, 10309, 8947, 7608, 6290, 5006, 3749, 2521, 1327, 161, -977, -2084, -3169, -4228, -5262, -6276, -7271, -8246, -9211, -10143, -10981, -11707, -12325, -12828, -13220, -13502, -13674, -13742, -13711, -13587, -13384, -13165, -12954, -12756, -12580, -12430, -12315, -12236, -12198, -12203, -12256, -12355, -12505, -12706, -12960, -13268, -13630, -14048, -14522, -15053, -15641, -16286, -16986, -17744, -18557, -19421, -20338, -21300, -22303, -23347, -24418, -25512, -26612, -27656, -28619, -29495, -30273, -30948, -31516, -31968, -32303, -32515, -32603, -32562, -32391, -32088, -31647, -31069, -30352, -29490, -28483, -27331, -26027, -24571, -22964, -21199, -19279, -17208, -14972, -12587, -10053, -7369, -4551, -1530};