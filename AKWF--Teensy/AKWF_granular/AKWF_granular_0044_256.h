/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0044 256 samples */
 
const int16_t AKWF_granular_0044_256_DATA [256] = 
{305, 866, 1455, 2063, 2680, 3296, 3903, 4497, 5074, 5635, 6171, 6681, 7161, 7608, 7740, 9600, 1749, -11118, -10057, -11118, -11851, -12579, -13287, -13948, -14561, -15102, -15556, -15892, -16091, -16118, -15934, -15496, -14752, -13643, -12129, -10148, -7693, -4783, -1512, 1998, 5617, 9171, 12528, 15626, 18401, 20873, 23045, 24934, 26570, 27977, 29184, 30216, 31089, 31809, 32412, 32569, 32279, 31894, 31386, 30760, 29990, 28742, 29621, -11278, -32470, -30449, -31643, -32146, -32491, -32697, -32767, -32701, -32491, -32105, -31531, -30728, -29651, -28270, -26506, -24307, -21625, -18418, -14630, -10241, -5547, -805, 3790, 8030, 11800, 14985, 17580, 19600, 21103, 22161, 22847, 23215, 23322, 23210, 22925, 22491, 21940, 21296, 20577, 19809, 19005, 18177, 17348, 16491, 15811, 15518, -11953, -15755, -14175, -13933, -13469, -12979, -12443, -11870, -11254, -10591, -9885, -9133, -8330, -7487, -6605, -5684, -4753, -3808, -2875, -1989, -1181, -493, 39, 394, 557, 538, 343, 46, -9, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -4, 12, -209, -550, -731, -751, -594, -215, 13, -4, -3};