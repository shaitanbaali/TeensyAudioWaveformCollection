/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0007 256 samples */
 
const int16_t AKWF_granular_0007_256_DATA [256] = 
{734, 2798, 4875, 6932, 8893, 10745, 12462, 14027, 15448, 16733, 17878, 18912, 19834, 20652, 21369, 22002, 22548, 23014, 23405, 23723, 23977, 24172, 24314, 24157, 25449, 20225, -23848, -28062, -27958, -29053, -29902, -30693, -31427, -32084, -32575, -32516, -32203, -31726, -31037, -30110, -28901, -27369, -25491, -23181, -20418, -17186, -13462, -9327, -4857, -180, 4503, 9001, 13185, 16915, 20190, 22987, 25328, 27248, 28796, 30022, 30967, 31669, 32160, 32475, 32645, 32688, 32626, 32470, 32242, 31931, 31540, 31069, 30472, 29278, 31524, -7561, -33385, -30079, -31443, -31941, -32324, -32590, -32739, -32765, -32653, -32395, -31970, -31355, -30526, -29439, -28059, -26335, -24217, -21655, -18626, -15111, -11157, -6801, -2190, 2514, 7113, 11435, 15368, 18849, 21847, 24381, 26476, 28173, 29538, 30596, 31388, 31985, 32080, 31715, 31251, 30678, 30021, 29316, 28538, 27705, 26813, 25866, 24239, 26063, 9506, -23259, -22429, -22668, -22673, -22471, -22168, -21761, -21262, -20668, -19983, -19206, -18339, -17377, -16314, -15143, -13845, -12424, -10865, -9173, -7374, -5487, -3546, -1633, 188, 1842, 3259, 4422, 5311, 5932, 6315, 6491, 6493, 6350, 6090, 5740, 5319, 4844, 4329, 3787, 3230, 2662, 2092, 1527, 978, 369, -21, 5, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -6, 18, -118, -652, -1191, -1746, -2311, -2882, -3459, -4036, -4602, -5152, -5675, -6160, -6593, -6954, -7226, -7383, -7401, -7249, -6888, -6290, -5423, -4275, -2840, -1105};