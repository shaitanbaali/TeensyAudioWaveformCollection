/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0042 256 samples */
 
const int16_t AKWF_granular_0042_256_DATA [256] = 
{290, 1630, 3371, 4990, 6614, 8211, 9797, 11354, 12882, 14378, 15831, 17243, 18617, 19938, 21211, 22428, 23582, 24683, 25720, 26693, 27599, 28432, 29200, 29896, 30516, 31065, 31535, 31931, 32250, 32496, 32661, 32750, 32765, 32703, 32565, 32354, 32068, 31714, 31288, 30791, 30226, 29595, 28901, 28148, 27330, 26455, 25524, 24538, 23508, 22425, 21295, 20122, 18904, 17653, 16373, 15046, 13696, 12319, 10913, 9497, 8057, 6597, 5126, 3647, 2157, 673, -819, -2310, -3796, -5266, -6737, -8187, -9623, -11044, -12435, -13798, -15144, -16453, -17731, -18972, -20164, -21322, -22435, -23498, -24516, -25477, -26377, -27228, -28014, -28740, -29404, -29997, -30524, -30982, -31366, -31678, -31918, -32079, -32164, -32172, -32104, -31956, -31731, -31428, -31044, -30581, -30045, -29424, -28729, -27955, -27106, -26183, -25189, -24130, -23007, -21817, -20564, -19257, -17898, -16492, -15034, -13539, -11998, -10434, -8839, -7212, -5568, -3909, -2234, -568, 1110, 2789, 4456, 6113, 7744, 9355, 10947, 12507, 14027, 15511, 16947, 18338, 19679, 20967, 22193, 23358, 24460, 25495, 26461, 27360, 28180, 28921, 29590, 30179, 30692, 31122, 31471, 31738, 31926, 32030, 32055, 31998, 31861, 31646, 31354, 30983, 30537, 30020, 29432, 28769, 28040, 27246, 26386, 25473, 24496, 23460, 22373, 21239, 20056, 18825, 17551, 16240, 14893, 13521, 12113, 10678, 9217, 7736, 6246, 4742, 3222, 1697, 166, -1364, -2881, -4405, -5916, -7416, -8901, -10363, -11799, -13219, -14608, -15964, -17289, -18567, -19810, -21010, -22163, -23268, -24318, -25310, -26250, -27131, -27947, -28702, -29385, -29999, -30549, -31024, -31423, -31750, -31997, -32167, -32259, -32272, -32206, -32058, -31830, -31520, -31129, -30664, -30118, -29490, -28791, -28014, -27160, -26244, -25252, -24191, -23068, -21879, -20634, -19341, -17985, -16581, -15131, -13635, -12115, -10556, -8961, -7343, -5701, -4058, -2377, -662};