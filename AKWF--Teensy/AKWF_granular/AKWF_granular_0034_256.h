/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0034 256 samples */
 
const int16_t AKWF_granular_0034_256_DATA [256] = 
{315, 2430, 3832, 3437, 4778, 3467, 2552, 4193, 3798, 5285, 10278, 11088, 8967, 11103, 11878, 8554, 9101, 15273, 11890, 10732, 16826, 15112, 11357, 18768, 17265, 12317, 15198, 16616, 12642, 14319, 18799, 18172, 15409, 19185, 19027, 15144, 14799, 20410, 16357, 19384, 26473, 25866, 21660, 24385, 22101, 18857, 23401, 26907, 27510, 27016, 30067, 27646, 26979, 31099, 30903, 28464, 29845, 28777, 27774, 27891, 26268, 25329, 28622, 28836, 31227, 30462, 25844, 23198, 18754, 19282, 19033, 19932, 23263, 20360, 16941, 21237, 19176, 14490, 20403, 12354, 7479, 12150, 13899, 11377, 19981, 20940, 13819, 13457, 14269, 6622, 7544, 11408, 8103, 7299, 14456, 9173, 6880, 7776, 4826, 1374, 5098, 1852, -986, 847, -1749, -1520, 811, -2843, -2875, -2833, -8791, -7618, -5378, -9649, -7957, -6899, -10119, -7837, -5272, -9603, -10015, -10554, -13285, -14418, -12638, -14522, -14748, -12228, -13890, -12733, -11892, -14128, -17175, -17220, -18751, -18314, -14333, -16232, -14965, -14394, -15384, -16025, -14697, -17822, -19049, -17527, -19092, -17454, -16279, -17366, -18263, -17888, -17953, -18364, -18078, -19346, -20640, -19893, -18702, -17700, -16513, -17595, -18247, -18760, -18684, -17763, -16132, -17294, -18129, -17365, -16763, -16678, -15426, -16233, -17684, -17680, -16748, -16555, -16540, -15868, -18148, -19234, -16012, -15012, -14662, -12240, -13997, -15656, -14806, -15034, -15155, -14677, -14604, -14091, -13016, -11405, -10222, -10953, -9975, -10180, -10311, -10285, -11352, -12110, -10805, -10062, -9061, -4904, -6663, -6904, -5912, -7642, -8741, -7274, -8063, -8864, -6976, -5394, -4742, -4203, -4196, -5525, -9035, -7956, -9207, -10278, -9823, -8101, -7905, -6008, -4728, -4391, -5334, -6648, -6606, -7209, -7472, -4775, -3236, -2913, -747, 210, -237, -1017, -403, -1744, -2635, -1568, -246, 310, -795, -569, -872, -2193, -2464, -1108};