/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0038 256 samples */
 
const int16_t AKWF_granular_0038_256_DATA [256] = 
{180, 1134, 2749, 4356, 5312, 6881, 8388, 10155, 11714, 12602, 14530, 16020, 17329, 19070, 20536, 21817, 23375, 24411, 25660, 27262, 28065, 29451, 30838, 31484, 32394, 32766, 32360, 32244, 32008, 31433, 30987, 29874, 28960, 28165, 26207, 24651, 22932, 20645, 18784, 16567, 14363, 12209, 9745, 7706, 5725, 3769, 1738, 135, -1697, -3718, -5004, -6540, -8055, -8995, -9833, -10644, -11474, -12362, -13193, -13945, -14605, -14807, -15110, -15776, -15861, -16034, -16660, -16777, -17100, -17481, -17311, -17337, -17467, -17119, -16935, -16504, -15866, -15107, -14219, -13587, -12638, -11604, -10761, -9781, -8449, -7283, -6138, -4673, -3584, -2857, -1849, -970, -192, 603, 1251, 1926, 2602, 3082, 3443, 3591, 3776, 4091, 4088, 4066, 4176, 4012, 3915, 3974, 3785, 3534, 3247, 2855, 2452, 2038, 1351, 833, 471, -113, -530, -990, -1537, -2023, -2590, -3219, -3895, -4406, -5005, -5547, -6110, -6543, -6966, -7355, -7708, -8091, -8316, -8263, -8439, -8539, -8263, -7934, -7946, -7660, -7297, -7212, -6988, -6644, -6591, -6368, -6161, -5985, -5868, -6059, -6146, -6253, -6864, -7137, -7498, -7991, -8427, -8921, -9224, -9282, -9549, -9794, -9927, -9898, -9889, -9964, -9929, -9680, -9400, -8857, -8220, -7817, -7126, -6067, -5227, -4247, -3021, -1730, -468, 806, 2119, 3326, 4245, 5205, 6117, 6956, 7783, 8125, 8443, 8876, 9105, 9313, 9429, 9332, 9410, 9446, 9277, 9115, 8921, 8714, 8586, 8113, 7653, 7075, 6378, 5706, 4870, 4028, 3104, 2298, 1175, 420, -456, -1398, -2166, -2822, -3450, -3799, -4081, -4721, -4931, -4876, -5362, -5507, -6035, -6355, -6464, -6735, -6936, -7310, -7340, -7294, -7489, -7584, -8120, -8313, -8354, -8902, -9112, -9336, -9540, -9204, -9146, -9273, -8811, -8339, -8078, -7245, -6528, -5920, -4382, -3415, -2392, -614};