/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0039 256 samples */
 
const int16_t AKWF_granular_0039_256_DATA [256] = 
{1467, 3641, 4371, 4649, 4574, 4769, 6597, 8906, 11110, 13115, 14232, 14056, 13769, 14194, 15029, 16649, 17153, 17352, 16843, 16147, 15468, 15272, 15599, 15663, 15687, 15341, 14839, 14639, 14831, 14905, 15099, 14709, 13530, 11771, 10311, 9462, 9053, 8902, 8705, 8342, 7331, 5703, 4153, 3406, 2718, 828, 607, 2491, 3401, 3303, 2908, 3202, 3848, 4891, 5739, 6879, 8300, 9624, 9614, 9317, 9451, 10499, 12202, 12910, 12758, 12845, 13942, 15188, 16880, 18720, 21418, 23711, 24951, 25488, 26181, 27252, 28882, 30356, 31141, 31795, 32134, 32165, 31591, 31762, 32392, 32708, 32672, 31605, 30399, 29832, 29321, 28603, 27070, 25900, 24392, 22803, 21085, 20145, 20045, 19546, 17292, 15223, 13627, 12589, 11283, 9852, 9095, 9231, 8513, 6737, 3773, 1610, 1500, 669, -493, -2374, -4486, -5200, -5693, -6117, -6722, -7139, -7021, -6474, -7081, -8377, -9338, -10126, -9312, -7453, -6025, -5241, -4967, -5178, -5933, -7026, -8072, -8565, -8237, -6862, -6147, -6659, -8342, -10425, -11543, -11296, -10718, -10881, -11393, -11953, -12733, -13265, -12964, -12000, -10394, -9088, -8678, -8870, -9409, -9362, -8452, -6664, -4402, -3205, -3232, -5827, -7601, -4949, -5308, -5373, -4301, -3964, -4466, -5210, -5768, -5801, -5367, -5364, -7090, -9592, -8596, -8281, -8248, -7509, -6011, -5038, -5040, -5538, -5662, -5746, -5438, -4240, -3152, -2655, -2923, -2615, -2207, -2364, -1774, -1597, -749, 464, 550, -662, -1070, -521, 28, -272, -1051, -1294, -810, -99, -312, -1889, -2697, -2121, -1629, -2833, -5343, -6818, -6555, -6699, -6723, -7128, -7126, -6746, -6732, -6788, -7072, -7311, -6849, -6066, -4865, -2648, -2390, -3909, -5304, -6113, -5822, -5627, -5711, -5244, -3572, -2043, -2302, -3858, -4791, -4475, -2757, -2127, -2787, -3512, -3340, -3213, -2426, -675};