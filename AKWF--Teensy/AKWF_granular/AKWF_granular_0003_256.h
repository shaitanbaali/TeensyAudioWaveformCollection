/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0003 256 samples */
 
const int16_t AKWF_granular_0003_256_DATA [256] = 
{1002, 2293, 3590, 4887, 6182, 7464, 8726, 9967, 11183, 12362, 13504, 14604, 15671, 16692, 17672, 18613, 19505, 20358, 21175, 21950, 22687, 23388, 24050, 24681, 25279, 25845, 26382, 26888, 27365, 27816, 28241, 28640, 29018, 29370, 29702, 30013, 30303, 30573, 30823, 31054, 31270, 31468, 31646, 31811, 31959, 32090, 32209, 32310, 32399, 32474, 32541, 32582, 32638, 32401, 31947, 31515, 31065, 30610, 30147, 29687, 29268, 27952, 31760, 10181, -32101, -28443, -29044, -29028, -28990, -28947, -28895, -28830, -28746, -28655, -28549, -28435, -28305, -28162, -28001, -27831, -27648, -27444, -27228, -26998, -26751, -26486, -26207, -25906, -25587, -25252, -24894, -24518, -24125, -23701, -23259, -22794, -22299, -21789, -21248, -20677, -20078, -19452, -18794, -18110, -17390, -16636, -15850, -15031, -14180, -13298, -12380, -11428, -10449, -9441, -8415, -7365, -6295, -5215, -4130, -3046, -1973, -912, 130, 1142, 2126, 3009, 3812, 4597, 5358, 6086, 6783, 7451, 8090, 8701, 9284, 9837, 10362, 10862, 11340, 11791, 12220, 12624, 13007, 13368, 13707, 14028, 14324, 14603, 14864, 15109, 15331, 15537, 15728, 15903, 16065, 16212, 16342, 16460, 16568, 16661, 16742, 16814, 16875, 16926, 16966, 16999, 17023, 17038, 17047, 17046, 17038, 17024, 17005, 16977, 16942, 16901, 16859, 16812, 16757, 16696, 16632, 16565, 16493, 16418, 16272, 16554, 13276, 11477, 12213, 12468, 12788, 13111, 13433, 13752, 14013, 14274, 15266, -9678, -17554, -16140, -16796, -17136, -17474, -17812, -18141, -18465, -18786, -19109, -19424, -19732, -20031, -20323, -20611, -20891, -21159, -21417, -21664, -21896, -22118, -22323, -22512, -22685, -22836, -22968, -23075, -23156, -23215, -23243, -23242, -23204, -23129, -23016, -22862, -22663, -22414, -22112, -21753, -21338, -20856, -20307, -19689, -18993, -18215, -17366, -16422, -15394, -14280, -13069, -11779, -10408, -8942, -7404, -5797, -4122, -2423, -567};