/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0043 256 samples */
 
const int16_t AKWF_granular_0043_256_DATA [256] = 
{3427, 9097, 14288, 18779, 22293, 24668, 25860, 25940, 25038, 23352, 21107, 18529, 15786, 13067, 10480, 8140, 6093, 4352, 2946, 1843, 1033, 504, 194, 46, 2, -1, -26, -135, -391, -851, -1571, -2603, -3981, -5751, -7928, -10517, -13471, -16724, -20167, -23643, -26922, -29735, -31774, -32732, -32342, -30396, -26792, -21588, -15038, -7414, 579, 8220, 15063, 20678, 24769, 27292, 28272, 27881, 26377, 24069, 21263, 18200, 15132, 12221, 9569, 7274, 5332, 3750, 2513, 1583, 919, 475, 205, 63, 8, -1, -2, -30, -112, -274, -529, -893, -1375, -1967, -2671, -3465, -4318, -5207, -6078, -6875, -7535, -7994, -8185, -8068, -7619, -6840, -5771, -4502, -3123, -1753, -519, 483, 1185, 1553, 1613, 1400, 1003, 443, -14, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, 1, -8, -344, -667, -727, -488, -58, -10, -80, -198, -410, -745, -1232, -1902, -2795, -3920, -5300, -6931, -8767, -10782, -12866, -14880, -16664, -18001, -18675, -18492, -17282, -14959, -11530, -7171, -1931};