/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0019 256 samples */
 
const int16_t AKWF_granular_0019_256_DATA [256] = 
{26, 117, 275, 498, 788, 1143, 1549, 1997, 2478, 2990, 3534, 4113, 4727, 5369, 6025, 6683, 7341, 7999, 8668, 9349, 10044, 10741, 11428, 12104, 12768, 13422, 14076, 14729, 15378, 16029, 16667, 17282, 17877, 18453, 19023, 19604, 20181, 20740, 21273, 21769, 22254, 22744, 23237, 23716, 24163, 24570, 24960, 25360, 25775, 26182, 26529, 26808, 27056, 27344, 27722, 28156, 27989, 30660, 16464, -23594, -24695, -24476, -27575, -31095, -31759, -30759, -27600, -24890, -23830, -24810, -27144, -29206, -29989, -29194, -27585, -26329, -26270, -27487, -29309, -30788, -31289, -30834, -30003, -29518, -29806, -30772, -31911, -32657, -32707, -32177, -31461, -30979, -30919, -31148, -31338, -31163, -30489, -29432, -28257, -27190, -26322, -25536, -24616, -23393, -21804, -19955, -18037, -16176, -14410, -12673, -10806, -8746, -6504, -4159, -1859, 322, 2387, 4372, 6341, 8347, 10345, 12298, 14126, 15787, 17291, 18682, 20012, 21311, 22564, 23731, 24798, 25442, 25795, 26074, 26285, 26447, 26553, 26585, 26533, 26397, 26193, 25945, 25670, 25371, 25044, 24679, 24272, 23826, 23348, 22853, 22350, 21834, 21310, 20765, 20199, 19620, 19032, 18440, 17846, 17245, 16641, 16036, 15426, 14818, 14203, 13588, 12975, 12372, 11776, 11185, 10592, 9985, 9290, 9357, -49, -7780, -5543, -6036, -6105, -6323, -5782, -4920, -3963, -3199, -2784, -2552, -2338, -1988, -1505, -972, -459, -24, 5, -3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};