/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0035 256 samples */
 
const int16_t AKWF_granular_0035_256_DATA [256] = 
{1047, 595, 1171, 5121, 6572, 8090, 12394, 12338, 10135, 12861, 8691, 7510, 8259, 4641, 2907, 8166, 8418, 7977, 13952, 12469, 6666, 7467, 6305, 577, 4608, 8906, 4479, 7672, 14267, 11505, 14042, 18143, 12423, 13901, 17948, 13380, 14221, 22123, 19135, 22758, 29955, 28079, 24294, 30759, 24275, 20850, 26393, 27996, 22156, 27065, 27343, 22973, 27174, 29883, 25945, 24479, 22929, 19582, 18272, 21818, 18446, 20857, 22360, 18916, 18004, 21530, 18374, 14759, 14097, 14202, 9537, 16399, 19300, 20168, 19039, 20642, 19697, 16401, 15852, 18070, 15990, 14839, 19551, 24090, 22750, 24307, 26277, 22367, 16558, 21252, 18680, 13166, 16176, 20335, 14750, 21146, 23881, 16658, 16577, 15422, 9349, 10112, 11034, 4201, 6617, 6754, 3152, 7968, 9656, 3686, 4076, 3865, -5894, -6567, -2157, -9902, -7343, -5457, -7395, -7243, -2399, -1699, -4680, -3150, -6070, -9363, -9579, -4921, -6615, -4510, 1309, 1155, 1798, 3129, 43, -4959, -3081, -5194, -8376, -4877, -3127, -6189, -3384, -4284, -7064, -6532, -11535, -14074, -13330, -15458, -17502, -14889, -17801, -19786, -18079, -16254, -19716, -17369, -18280, -21639, -24088, -19131, -21312, -17992, -17510, -16822, -15585, -13107, -13075, -11943, -10638, -13304, -11026, -7869, -10276, -8706, -5996, -10799, -11343, -8879, -13145, -14087, -11093, -13026, -14557, -12339, -15781, -16718, -17293, -17600, -20764, -17886, -20406, -21183, -20545, -22004, -21735, -18088, -17405, -16243, -15472, -18282, -18995, -18371, -19977, -17829, -15939, -18829, -14953, -12995, -14108, -11318, -10591, -17034, -16082, -16430, -19949, -16935, -14543, -16591, -14386, -12652, -15726, -13176, -11000, -12216, -8702, -7519, -11026, -9219, -10631, -13092, -9989, -10907, -12526, -8545, -9204, -11986, -9759, -10326, -15932, -14289, -13322, -18039, -12838, -11074, -13612, -10732, -10029, -12372, -8597, -5663, -5809, -410, -610, -2398};