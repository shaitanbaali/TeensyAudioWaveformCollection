/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0030 256 samples */
 
const int16_t AKWF_granular_0030_256_DATA [256] = 
{1101, 5853, 8987, 6726, 5608, 6946, 7125, 7084, 7876, 9044, 10939, 12144, 13668, 15828, 17761, 21863, 25067, 25817, 26672, 28150, 28143, 27699, 27632, 25540, 24013, 23500, 21516, 19468, 19045, 18590, 16835, 15256, 14899, 15684, 14464, 11014, 8171, 4555, 1671, 2157, 1541, -1977, -4546, -6196, -9081, -12090, -13541, -12419, -11592, -12042, -13008, -14700, -16954, -17233, -16635, -18242, -19590, -20549, -21731, -24043, -27801, -30431, -30884, -31476, -30979, -30493, -30992, -29020, -24417, -20444, -18751, -17983, -15999, -13239, -9624, -6851, -6135, -6154, -5246, -4845, -4406, -3744, -3859, -2357, 964, 1899, 2769, 5721, 8193, 11254, 14488, 15260, 15827, 18498, 19683, 20247, 21453, 20281, 18906, 20549, 20204, 19714, 22765, 22845, 21950, 25147, 26762, 25727, 26650, 24643, 20773, 20925, 20706, 18364, 17581, 15232, 11699, 10281, 7533, 4507, 4672, 6342, 7268, 9230, 8357, 5392, 6478, 7402, 4930, 4385, 4150, 1387, -1201, -4188, -9541, -14206, -15412, -16460, -18188, -19374, -19544, -20108, -20738, -19093, -17703, -17805, -16709, -15677, -16479, -16132, -14662, -15463, -16711, -15316, -15525, -18346, -18761, -17211, -17398, -16329, -13010, -13629, -15338, -12902, -10185, -11232, -10995, -7536, -7420, -8453, -5937, -4640, -4838, -2512, 813, 2283, 5020, 9548, 15772, 19797, 20093, 20291, 20996, 20712, 22971, 26176, 24559, 22103, 21618, 19823, 17179, 15999, 16358, 18423, 20523, 21550, 22155, 22754, 24696, 27298, 27993, 27471, 27878, 28040, 26946, 24317, 20272, 16679, 13850, 11239, 8514, 6534, 4692, 2741, -369, -3303, -2849, -2054, -3248, -4751, -8249, -12277, -13219, -12946, -14673, -16664, -16835, -17718, -21556, -24070, -24057, -24194, -23515, -21560, -22929, -26338, -26265, -26193, -28864, -29727, -28681, -28829, -29087, -29659, -31959, -32539, -30576, -27436, -23235, -19564, -16886, -11046, -7812, -8507, -5980, -1412};