/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0005 256 samples */
 
const int16_t AKWF_granular_0005_256_DATA [256] = 
{419, 1247, 2053, 2858, 3664, 4464, 5257, 6044, 6816, 7586, 8345, 9093, 9833, 10557, 11269, 11969, 12654, 13328, 13987, 14627, 15255, 15867, 16465, 17048, 17612, 18160, 18695, 19215, 19720, 20207, 20676, 21132, 21573, 21999, 22410, 22805, 23190, 23558, 23915, 24253, 24582, 24896, 25200, 25489, 25765, 26032, 26285, 26532, 26760, 26985, 27192, 27398, 27583, 27775, 27942, 28108, 28262, 28410, 28550, 28675, 28803, 28912, 29027, 29116, 29224, 29298, 29391, 29453, 29529, 29585, 29644, 29695, 29735, 29784, 29806, 29850, 29856, 29897, 29890, 29919, 29908, 29925, 29909, 29911, 29899, 29878, 29870, 29831, 29830, 29774, 29771, 29703, 29697, 29624, 29605, 29536, 29503, 29441, 29380, 29332, 29248, 29218, 29108, 29090, 28965, 28949, 28813, 28791, 28659, 28620, 28504, 28432, 28350, 28230, 28194, 28006, 28046, 27762, 27922, 27324, 28248, 26611, 16067, 11770, 13273, 12865, 13164, 12998, 13297, 13115, 13435, 13252, 13306, 13589, 15402, -11773, -30588, -27864, -27853, -28376, -28194, -28494, -28412, -28637, -28602, -28785, -28788, -28918, -28992, -29210, -29359, -29511, -29689, -29811, -30000, -30104, -30303, -30400, -30593, -30686, -30864, -30970, -31125, -31240, -31375, -31504, -31613, -31750, -31840, -31981, -32058, -32195, -32264, -32387, -32457, -32563, -32631, -32738, -32712, -32566, -32456, -32310, -32196, -32036, -31912, -31742, -31604, -31427, -31276, -31095, -30924, -30738, -30547, -30359, -30147, -29951, -29726, -29519, -29280, -29059, -28806, -28566, -28308, -28051, -27778, -27512, -27187, -26864, -26653, -26405, -26159, -25887, -25614, -25321, -25026, -24706, -24381, -24040, -23686, -23321, -22936, -22539, -22124, -21700, -21253, -20801, -20324, -19836, -19328, -18807, -18270, -17716, -17144, -16555, -15953, -15333, -14701, -14052, -13384, -12703, -12008, -11302, -10584, -9849, -9101, -8346, -7585, -6806, -6020, -5230, -4430, -3631, -2822, -2012, -1199, -371};