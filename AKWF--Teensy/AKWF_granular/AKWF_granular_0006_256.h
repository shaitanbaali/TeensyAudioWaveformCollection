/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0006 256 samples */
 
const int16_t AKWF_granular_0006_256_DATA [256] = 
{412, 2163, 3989, 5764, 7512, 9212, 10865, 12465, 14001, 15473, 16872, 18197, 19456, 20638, 21752, 22795, 23767, 24673, 25517, 26297, 27021, 27689, 28295, 28856, 29372, 29839, 30264, 30647, 30988, 31300, 31574, 31814, 32022, 32217, 32275, 32176, 32066, 31932, 31774, 31595, 31399, 31184, 30950, 30703, 30441, 30165, 29881, 29585, 29274, 28953, 28627, 28293, 27952, 27604, 27246, 26884, 26517, 26151, 25777, 25397, 25017, 24626, 24232, 23833, 23341, 23171, 23036, -15617, -25889, -23622, -24289, -24473, -24616, -24758, -24898, -25024, -25148, -25266, -25373, -25471, -25559, -25635, -25705, -25760, -25807, -25842, -25860, -25868, -25861, -25840, -25803, -25749, -25675, -25582, -25471, -25339, -25182, -25006, -24804, -24574, -24316, -24027, -23709, -23357, -22968, -22542, -22077, -21569, -21019, -20425, -19781, -19083, -18335, -17531, -16677, -15764, -14793, -13762, -12675, -11532, -10340, -9093, -7794, -6457, -5082, -3686, -2261, -824, 621, 2061, 3482, 4886, 6267, 7609, 8912, 10159, 11367, 12519, 13613, 14651, 15630, 16550, 17417, 18226, 18983, 19685, 20333, 20939, 21496, 22009, 22480, 22910, 23304, 23660, 23984, 24277, 24540, 24773, 24980, 25161, 25320, 25455, 25568, 25661, 25737, 25796, 25836, 25859, 25868, 25862, 25844, 25812, 25769, 25713, 25645, 25570, 25482, 25384, 25278, 25165, 25043, 24914, 24775, 24636, 24402, 24385, 24441, 24468, 24491, 24499, 24506, 24529, 23641, 28126, 3539, -29500, -25563, -26749, -27116, -27499, -27868, -28236, -28597, -28955, -29305, -29644, -29975, -30300, -30612, -30915, -31208, -31488, -31754, -32004, -32240, -32456, -32669, -32755, -32685, -32611, -32510, -32384, -32236, -32059, -31851, -31616, -31348, -31045, -30709, -30331, -29915, -29454, -28947, -28397, -27794, -27136, -26422, -25656, -24827, -23926, -22966, -21935, -20831, -19667, -18422, -17106, -15718, -14256, -12730, -11153, -9501, -7806, -6065, -4285, -2505, -632};