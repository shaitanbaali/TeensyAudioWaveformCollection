/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0021 256 samples */
 
const int16_t AKWF_granular_0021_256_DATA [256] = 
{2150, 7388, 12864, 18308, 23294, 27536, 30671, 32445, 32709, 31408, 28567, 24318, 18874, 12566, 5706, -1380, -8255, -14612, -20111, -24451, -27506, -29122, -29261, -27969, -25371, -21669, -17051, -11837, -6322, -791, 4406, 9060, 12950, 15870, 17712, 18431, 18032, 16581, 14196, 11059, 7346, 3311, -834, -4885, -8615, -11831, -14402, -16202, -17193, -17348, -16694, -15219, -12944, -9960, -6426, -2550, 1409, 5198, 8638, 11483, 13583, 14829, 15163, 14612, 13276, 11258, 8682, 5702, 2515, -757, -3921, -6822, -9343, -11368, -12829, -13699, -13960, -13637, -12781, -11474, -9798, -7858, -5761, -3625, -1552, 365, 2057, 3458, 4515, 5211, 5538, 5509, 5153, 4508, 3630, 2581, 1416, 210, -1079, -2731, -4917, -7653, -10905, -14472, -18137, -21605, -24585, -26902, -28256, -28466, -27446, -25208, -21814, -17408, -12212, -6504, -583, 5251, 10714, 15523, 19422, 22233, 23837, 24200, 23325, 21296, 18261, 14428, 10015, 5268, 468, -4136, -8297, -11790, -14499, -16277, -17071, -16870, -15732, -13749, -11046, -7812, -4225, -487, 3158, 6581, 9589, 12031, 13817, 14872, 15170, 14751, 13517, 11236, 7799, 3336, -1987, -7865, -13887, -19646, -24742, -28772, -31495, -32663, -32159, -30002, -26264, -21119, -15114, -7410, 3894, 10957, 17426, 22948, 27244, 30122, 31466, 31272, 29594, 26575, 22411, 17384, 11822, 5956, 177, -5218, -9986, -13859, -16697, -18396, -18900, -18235, -16487, -13820, -10380, -6398, -2124, 2215, 6360, 10254, 13973, 17529, 20885, 23969, 26625, 28737, 30142, 30705, 30322, 28955, 26586, 23278, 19128, 14318, 9074, 3552, -1930, -7130, -11825, -15759, -18788, -20780, -21645, -21362, -19988, -17550, -14183, -10184, -5785, -1216, 3254, 7413, 11076, 14054, 16212, 17481, 17827, 17274, 15883, 13761, 11053, 7928, 4560, 1126, -2194, -5225, -7827, -9881, -11327, -12106, -12212, -11674, -10561, -8748, -6027, -2248};