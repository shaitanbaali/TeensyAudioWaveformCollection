/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0033 256 samples */
 
const int16_t AKWF_granular_0033_256_DATA [256] = 
{1783, 5018, 8110, 11131, 14032, 16795, 19376, 21774, 23963, 25927, 27647, 29118, 30337, 31306, 32026, 32503, 32740, 32754, 32562, 32172, 31602, 30871, 30003, 29010, 27909, 26724, 25466, 24156, 22821, 21453, 20081, 18715, 17359, 16034, 14748, 13492, 12290, 11138, 10042, 9013, 8040, 7128, 6281, 5499, 4781, 4123, 3526, 2986, 2504, 2079, 1703, 1376, 1094, 854, 654, 489, 356, 250, 171, 110, 68, 37, 16, 2, -13, -31, -56, -90, -140, -209, -298, -411, -555, -730, -939, -1188, -1480, -1812, -2194, -2625, -3106, -3642, -4229, -4873, -5578, -6342, -7160, -8036, -8965, -9950, -10988, -12074, -13203, -14368, -15564, -16790, -18033, -19276, -20512, -21743, -22940, -24093, -25194, -26213, -27147, -27978, -28684, -29254, -29669, -29912, -29975, -29839, -29499, -28941, -28165, -27167, -25937, -24487, -22823, -20949, -18895, -16652, -14247, -11709, -9060, -6330, -3545, -724, 2098, 4886, 7616, 10247, 12774, 15164, 17399, 19449, 21302, 22948, 24382, 25596, 26584, 27348, 27891, 28224, 28352, 28288, 28042, 27622, 27101, 26442, 25664, 24778, 23810, 22764, 21659, 20515, 19341, 18154, 16965, 15780, 14609, 13465, 12353, 11282, 10264, 9311, 8401, 7541, 6733, 5976, 5270, 4616, 4013, 3461, 2963, 2510, 2106, 1745, 1427, 1153, 916, 713, 544, 405, 293, 206, 139, 90, 56, 31, 15, 4, -6, -21, -42, -71, -116, -177, -259, -367, -500, -664, -864, -1101, -1379, -1701, -2067, -2487, -2956, -3484, -4067, -4706, -5405, -6169, -6993, -7880, -8829, -9830, -10898, -12018, -13192, -14412, -15669, -16957, -18278, -19610, -20946, -22280, -23580, -24849, -26071, -27222, -28288, -29248, -30078, -30776, -31312, -31668, -31831, -31786, -31517, -31013, -30267, -29274, -28026, -26537, -24797, -22817, -20612, -18215, -15612, -12843, -9938, -6925, -3788, -816};