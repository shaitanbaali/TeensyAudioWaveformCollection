/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0041 256 samples */
 
const int16_t AKWF_granular_0041_256_DATA [256] = 
{301, 1201, 2133, 3151, 4221, 5318, 6388, 7362, 8194, 8855, 9348, 9725, 10074, 10506, 11168, 11917, 12949, 14507, 16539, 18990, 21728, 24549, 27233, 29562, 31316, 32343, 32516, 31767, 30106, 27542, 24177, 20117, 15481, 10448, 5183, -201, -5461, -10418, -14877, -18600, -21456, -23282, -23967, -23485, -21880, -19285, -15864, -11902, -7697, -3536, 229, 3377, 5923, 7490, 7998, 7493, 6071, 3851, 999, -2305, -5898, -9603, -13279, -16804, -20040, -22858, -25149, -26813, -27787, -28014, -27483, -26234, -24365, -22004, -19322, -16508, -13749, -11218, -9030, -7221, -5804, -4701, -3803, -2966, -2015, -833, 619, 2390, 4440, 6718, 9098, 11441, 13603, 15456, 16912, 17917, 18441, 18500, 18125, 17371, 16278, 14899, 13290, 11499, 9596, 7660, 5785, 4100, 2747, 1877, 1617, 2068, 3287, 5271, 7941, 11121, 14621, 18203, 21572, 24472, 26670, 27968, 28269, 27506, 25702, 22915, 19283, 14963, 10067, 4825, -604, -6007, -11260, -16153, -20525, -24189, -27012, -28887, -29747, -29572, -28416, -26397, -23716, -20561, -17223, -13945, -10977, -8526, -6726, -5629, -5259, -5464, -6121, -7143, -8395, -9739, -11066, -12302, -13380, -14268, -14949, -15387, -15558, -15426, -14963, -14136, -12938, -11390, -9531, -7454, -5285, -3117, -1092, 683, 2160, 3317, 4207, 4930, 5623, 6440, 7538, 9027, 10989, 13432, 16292, 19412, 22663, 25852, 28414, 30360, 31618, 32066, 31662, 30400, 28326, 25514, 22108, 18190, 13901, 9420, 4888, 486, -3563, -7140, -10012, -12003, -12988, -12870, -11629, -9304, -6039, -2051, 2408, 6979, 11388, 15291, 18400, 20491, 21426, 21147, 19561, 16684, 12926, 8466, 3542, -1680, -6975, -12166, -17060, -21497, -25341, -28486, -30815, -32255, -32769, -32388, -31169, -29241, -26766, -23968, -21056, -18226, -15684, -13561, -11917, -10762, -10014, -9554, -9236, -8895, -8391, -7615, -6502, -5050, -3306, -1296};