/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0023 256 samples */
 
const int16_t AKWF_granular_0023_256_DATA [256] = 
{2884, 6596, 9798, 13013, 15981, 18699, 21261, 23596, 25722, 27651, 29330, 30820, 31883, 32416, 32878, 31212, 28319, 26606, 25074, 23722, 22506, 21361, 20297, 19289, 18317, 17402, 16514, 15660, 14841, 14039, 13263, 12511, 11777, 11066, 10371, 9687, 9025, 8374, 7741, 7121, 6512, 5915, 5330, 4756, 4197, 3646, 3104, 2574, 2053, 1543, 1040, 549, 65, -405, -870, -1328, -1779, -2220, -2654, -3078, -3496, -3907, -4309, -4706, -5092, -5471, -5846, -6195, -6471, -6729, -6972, -7200, -7414, -7612, -7795, -7965, -8120, -8265, -8386, -8543, -8785, -9015, -9241, -9461, -9676, -9887, -10089, -10287, -10480, -10666, -10850, -11028, -11197, -11364, -11524, -11678, -11830, -11975, -12113, -12248, -12376, -12500, -12618, -12731, -12839, -12941, -13038, -13130, -13217, -13301, -13377, -13446, -13514, -13574, -13630, -13683, -13724, -13767, -13804, -13828, -13859, -13877, -13887, -13911, -13789, -14311, -10466, -2748, 1955, 5712, 8752, 11802, 14471, 16883, 19052, 20934, 22609, 24049, 25243, 26232, 26978, 27451, 27957, 26896, 24313, 22761, 21454, 20287, 19227, 18248, 17329, 16459, 15637, 14844, 14086, 13353, 12650, 11966, 11301, 10658, 10028, 9417, 8826, 8242, 7676, 7120, 6575, 6048, 5528, 5016, 4518, 4028, 3548, 3080, 2617, 2163, 1719, 1281, 856, 435, 23, -380, -777, -1169, -1550, -1927, -2298, -2660, -3017, -3366, -3709, -4046, -4376, -4700, -5017, -5329, -5635, -5933, -6227, -6515, -6796, -7072, -7341, -7605, -7865, -8116, -8364, -8604, -8841, -9070, -9295, -9514, -9727, -9936, -10139, -10336, -10526, -10711, -10894, -11071, -11239, -11403, -11562, -11716, -11865, -12010, -12146, -12281, -12406, -12527, -12649, -12757, -12865, -12969, -13057, -13155, -13240, -13316, -13398, -13462, -13526, -13597, -13638, -13694, -13742, -13766, -13818, -13836, -13851, -13900, -13877, -13890, -13873, -14116, -8488, -1295};