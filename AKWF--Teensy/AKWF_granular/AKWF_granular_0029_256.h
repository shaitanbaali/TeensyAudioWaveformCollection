/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0029 256 samples */
 
const int16_t AKWF_granular_0029_256_DATA [256] = 
{2145, 5432, 7163, 6649, 5451, 6432, 9445, 12536, 12721, 9301, 8433, 9654, 10012, 10312, 12598, 16168, 20189, 22256, 21351, 21529, 25809, 30453, 32719, 31941, 28857, 27355, 29303, 28427, 28058, 28172, 27907, 26407, 24290, 21764, 21385, 21074, 20206, 20088, 16787, 11771, 9704, 5162, -192, -1400, -2297, -5152, -5815, -6659, -8841, -6238, -4693, -7698, -9056, -10227, -11466, -7728, -7091, -12400, -14023, -13547, -15355, -15727, -16366, -18909, -16830, -12897, -12165, -12360, -8880, -2970, 1078, 4037, 6144, 7345, 8629, 10537, 10203, 10888, 13350, 13935, 11867, 9693, 9151, 10070, 10571, 8957, 7571, 7316, 7693, 6569, 4719, 5353, 6751, 5825, 2599, 198, -641, -2191, -1496, -2131, -6123, -7240, -6640, -9678, -11935, -9942, -8318, -9194, -10909, -12364, -13944, -13899, -12021, -11916, -14207, -12107, -7170, -5044, -5353, -8379, -10619, -9043, -3966, -1593, -2141, -2699, -2332, -643, -30, -2690, -2002, 3248, 6557, 6805, 5088, 2677, 4771, 8259, 7850, 6932, 7402, 7415, 7812, 6851, 3949, 3413, 4733, 3500, 1414, 1372, 1483, 1294, 45, -3566, -4731, -3115, -3114, -5129, -6432, -8159, -7259, -5884, -6620, -7631, -8912, -9919, -10673, -12198, -12505, -11662, -13934, -16285, -15678, -17891, -17431, -14651, -17102, -18494, -16488, -17145, -18322, -16665, -17671, -18609, -14966, -11902, -10640, -8819, -9848, -11426, -11035, -9104, -5588, -1693, -837, 98, 2235, 2348, 3643, 7557, 10296, 14436, 19423, 20489, 19941, 23448, 27871, 31300, 32745, 31003, 28222, 27079, 26270, 25676, 24934, 22959, 21531, 19322, 14663, 11694, 11076, 8781, 5350, 1715, -2588, -4518, -7418, -12015, -15818, -19328, -23029, -23186, -22651, -26217, -27282, -25406, -27215, -27211, -23501, -22493, -24496, -24848, -24124, -25286, -24979, -23711, -22893, -22526, -22288, -19890, -19880, -20183, -15144, -9466, -6784, -2558};