/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0004 256 samples */
 
const int16_t AKWF_granular_0004_256_DATA [256] = 
{399, 1089, 2002, 1792, 1725, 2956, 3992, 5072, 6146, 7266, 8339, 9252, 10174, 11074, 11972, 12792, 13482, 14142, 14773, 15361, 15811, 16203, 16572, 16921, 17248, 17561, 17862, 18154, 18440, 18728, 19013, 19303, 19598, 19903, 20218, 20545, 20884, 21238, 21610, 21748, 23313, 17775, 8281, 9979, 10484, 11168, 11849, 12529, 13198, 13863, 14521, 15169, 15804, 16429, 17033, 17632, 18218, 18786, 19344, 19891, 20430, 20958, 21480, 21997, 22512, 23014, 23520, 24028, 24540, 25056, 25573, 26091, 26621, 27167, 27714, 28263, 28838, 29062, 31404, 24455, 3814, 5541, 6381, 7204, 8071, 8931, 9774, 10621, 11462, 12289, 13104, 13899, 14677, 15446, 16194, 16912, 17642, 18325, 18898, 19470, 20020, 20580, 21017, 21246, 21481, 21707, 21922, 22070, 22203, 22346, 22494, 22648, 22807, 22975, 23160, 23006, 24849, 18831, -13842, -14913, -13764, -13384, -12820, -12238, -11638, -11028, -10396, -9757, -9100, -8432, -7753, -7065, -6368, -5665, -4952, -4236, -3513, -2786, -2054, -1318, -590, 134, 861, 1589, 2310, 3025, 3730, 4422, 5113, 5790, 6452, 7090, 7734, 7930, 10593, 2540, -25260, -24322, -23913, -23664, -23347, -23039, -22736, -22428, -22109, -21792, -21477, -21153, -20823, -20481, -20134, -19780, -19413, -19034, -18643, -18241, -17832, -17407, -16967, -16528, -16075, -15616, -15138, -14696, -14235, -13609, -12993, -12370, -11769, -11076, -10187, -9494, -7821, -9956, -28079, -28637, -27465, -26875, -26171, -25476, -24786, -24097, -23407, -22715, -22020, -21322, -20618, -19902, -19176, -18438, -17687, -16927, -16148, -15354, -14547, -13721, -12885, -12044, -11183, -10315, -9442, -8561, -7689, -6817, -5946, -5091, -4245, -3418, -2617, -1865, -959, -554, -8174, -9353, -8497, -8182, -7794, -7428, -7079, -6730, -6394, -6064, -5738, -5410, -5075, -4732, -4380, -4009, -3620, -3213, -2777, -2315, -1826, -1307, -759, -166};