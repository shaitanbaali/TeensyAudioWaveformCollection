/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0001 256 samples */
 
const int16_t AKWF_granular_0001_256_DATA [256] = 
{938, 2225, 3460, 4706, 5934, 7147, 8342, 9508, 10649, 11772, 12860, 13918, 14948, 15935, 16898, 17825, 18713, 19573, 20395, 21172, 21940, 22573, 23096, 23605, 24077, 24518, 24936, 25325, 25684, 26018, 26330, 26617, 26883, 27127, 27352, 27559, 27748, 27919, 28077, 28219, 28352, 28471, 28576, 28675, 28764, 28848, 28922, 28992, 29058, 29117, 29184, 29240, 29296, 29357, 29415, 29480, 29545, 29615, 29696, 29654, 29588, 29534, 29486, 29452, 29417, 29406, 29397, 29390, 29411, 29426, 29462, 29505, 29548, 29616, 29675, 29751, 29842, 29915, 30021, 30112, 30206, 30322, 30407, 30526, 30628, 30717, 30847, 30924, 31028, 31140, 31189, 31312, 31420, 30895, 33258, 25722, -14215, -17530, -15666, -15740, -15349, -15040, -14668, -14337, -14004, -13649, -13331, -12985, -12646, -12324, -11979, -11657, -11322, -10986, -10668, -10331, -10007, -9679, -9344, -9021, -8684, -8359, -8034, -7690, -7368, -7033, -6693, -6370, -6023, -5689, -5348, -4998, -4667, -4310, -3964, -3616, -3249, -2903, -2534, -2170, -1808, -1421, -1058, -667, -279, 97, 513, 898, 1306, 1732, 2127, 2578, 2994, 3423, 3892, 4309, 4801, 5260, 5704, 6235, 6669, 7188, 7716, 8157, 8770, 9227, 9755, 10035, 11876, 8566, -24069, -29537, -27290, -27433, -27181, -26717, -26452, -26126, -25718, -25460, -25081, -24749, -24461, -24090, -23820, -23502, -23192, -22951, -22642, -22414, -22175, -21930, -21751, -21534, -21364, -21213, -21047, -20940, -20809, -20710, -20634, -20542, -20497, -20436, -20391, -20370, -20330, -20322, -20307, -20293, -20299, -20284, -20284, -20278, -20265, -20263, -20239, -20216, -20188, -20139, -20092, -20026, -19948, -19852, -19740, -19612, -19459, -19289, -19095, -18873, -18630, -18355, -18052, -17718, -17352, -16952, -16513, -16048, -15516, -14870, -14197, -13487, -12748, -11972, -11159, -10321, -9446, -8542, -7604, -6641, -5651, -4638, -3605, -2548, -1482, -367};