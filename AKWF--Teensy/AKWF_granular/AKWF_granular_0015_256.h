/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0015 256 samples */
 
const int16_t AKWF_granular_0015_256_DATA [256] = 
{403, 882, 1099, 1126, 1065, 1029, 1078, 1189, 1352, 1552, 1686, 1662, 1627, 1682, 1646, 2000, 3803, 5381, 2936, -795, -2648, -3335, -2337, -212, 1785, 3211, 4397, 5412, 5993, 4926, 1690, -483, 740, 4442, 6791, 5725, 3525, 1945, 1279, 571, -205, 328, -62, -7096, -22218, -21320, -11705, -7146, -4265, -2108, -161, 1742, 3223, 3931, 10141, 10375, 5605, 5927, 8914, 11583, 10730, 7683, 4777, 3108, 2147, 1375, 2245, 3192, 1643, -812, -2663, -4456, -6934, -5962, -587, 2260, 2191, 1537, 802, 107, -610, -1315, -1681, -1435, -954, -872, -1325, -1968, -2317, -2448, -2774, -3036, -2619, -3550, -11287, -29508, -29033, -15361, -8151, -4061, -1417, 454, 1689, 2273, 2337, 2166, 1992, 1952, 2020, 2139, 2285, 2375, 2276, 2081, 1991, 1886, 1841, 2542, 3509, 2676, 679, -465, -1007, -914, 24, 1099, 1767, 2097, 2250, 2260, 2028, 1329, 629, 650, 1377, 2430, 3388, 3657, 3352, 3512, 3829, 3191, 3405, 3782, -1757, -11073, -9468, -5193, -3195, -1963, -1072, -272, 557, 1386, 1635, 3768, 6585, 4260, 3366, 3585, 3172, 2506, 1706, 929, 427, 169, -29, -24, 182, 89, -251, -528, -714, -952, -999, -513, -65, 23, -5, -51, -98, -142, -187, -212, -187, -124, -85, -85, -96, -97, -81, -63, -44, -11, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, 10, 16, -28, -105, -186, -304, -426, -317, -77, 14, 3, -37, -91, -155, -242, -333, -366, -306, -235, -253, -358, -479, -547, -601, -723, -751, -713, -1403, -5117, -10211, -8065, -4317, -2398, -1157, -265};