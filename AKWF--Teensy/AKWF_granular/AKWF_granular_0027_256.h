/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0027 256 samples */
 
const int16_t AKWF_granular_0027_256_DATA [256] = 
{132, 1180, 1037, 1990, 3502, 3621, 3277, 4992, 5924, 5584, 6291, 7637, 7027, 7726, 9542, 10995, 11934, 13241, 15361, 15092, 16731, 18544, 20129, 20681, 22384, 23047, 23713, 24778, 27440, 27307, 27774, 27788, 27541, 27520, 29385, 30286, 30939, 31745, 31851, 30778, 30824, 30129, 29471, 29556, 30194, 29707, 29166, 29137, 27562, 25115, 23416, 21817, 19795, 18854, 19001, 17611, 15359, 13579, 11445, 8403, 6352, 5069, 2892, 1037, -65, -1746, -4183, -6171, -8456, -11185, -13120, -14807, -16455, -17576, -18908, -20635, -22362, -23921, -25776, -26889, -27663, -28639, -29811, -30348, -30889, -31763, -32099, -32112, -32479, -32715, -32103, -31543, -31156, -30322, -29459, -28993, -28083, -26559, -25202, -23737, -21839, -20457, -19402, -17846, -16398, -15188, -13476, -11827, -10594, -9128, -7583, -6488, -5674, -4731, -4040, -3531, -2536, -1389, -661, -23, 332, 334, -70, -233, -229, -402, -658, -820, -1168, -1599, -2052, -2766, -3473, -4131, -4885, -5333, -5377, -5569, -5980, -6073, -6571, -7364, -7540, -7505, -7904, -7883, -7772, -7846, -7858, -7591, -7031, -6844, -6621, -6032, -5617, -5386, -4653, -3865, -3540, -3145, -2640, -2481, -2135, -1534, -1210, -872, -353, -131, 108, 686, 970, 1266, 1834, 2275, 2273, 2669, 3158, 3329, 3439, 4146, 4603, 4443, 4928, 5785, 5384, 5902, 6912, 6716, 6509, 7237, 7226, 6783, 7375, 7591, 7110, 7357, 7166, 6526, 6251, 6320, 5546, 5592, 5508, 4585, 4081, 3588, 2443, 1479, 1256, 319, -282, -278, -705, -1159, -1816, -2410, -3751, -4354, -4848, -4830, -4833, -4586, -4548, -4515, -4815, -4971, -5267, -5560, -5549, -5091, -4642, -4057, -3580, -3693, -3611, -3633, -3630, -3419, -2735, -2406, -2417, -1585, -1297, -1816, -1286, -1166, -1563, -1438, -1129, -1406, -1816, -1500, -1950, -1334, -1134, -1246};