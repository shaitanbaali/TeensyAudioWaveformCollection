/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0020 256 samples */
 
const int16_t AKWF_granular_0020_256_DATA [256] = 
{7613, 19569, 28522, 32669, 31092, 24067, 12964, -1, -12399, -21918, -26977, -26768, -21819, -13359, -3177, 6802, 14839, 19595, 20403, 17476, 11721, 4366, -3075, -9278, -13217, -14398, -12867, -9158, -4144, 1145, 5710, 8775, 9952, 9179, 6767, 3325, -441, -3834, -6267, -7381, -7106, -5637, -3341, -720, 1713, 3528, 4454, 4400, 3471, 1906, 54, -1721, -3104, -3890, -3986, -3439, -2409, -1135, 129, 1161, 1789, 1937, 1624, 957, 84, -807, -1553, -2028, -2168, -1974, -1510, -882, -217, 366, 759, 1084, 1723, 2736, 3864, 4781, 4708, 2238, -2914, -9717, -16414, -21279, -22890, -20663, -14902, -6721, 2337, 10606, 16558, 19260, 18413, 14466, 8310, 1285, -5258, -10166, -12658, -12487, -9916, -5619, -508, 4349, 8112, 10313, 10666, 9261, 6502, 2998, -526, -3492, -5377, -5935, -5169, -3344, -864, 1782, 4099, 5699, 6358, 6037, 4876, 3152, 1223, -545, -1853, -2505, -2447, -1743, -580, 793, 2105, 3133, 3706, 3756, 3320, 2504, 1485, 461, -390, -939, -1113, -920, -433, 231, 935, 1535, 1934, 2067, 1925, 1551, 1021, 440, -92, -494, -711, -726, -561, -268, 80, 420, 1525, 4463, 9034, 14215, 18526, 20621, 19660, 15554, 8886, 826, -7180, -13701, -17619, -18386, -16039, -11091, -4489, 2420, 8314, 12168, 13400, 11910, 8148, 3000, -2537, -7388, -10683, -11909, -10997, -8253, -4313, 3, 3851, 6553, 7676, 7129, 5117, 2120, -1226, -4274, -6480, -7493, -7192, -5726, -3443, -837, 1615, 3455, 4393, 4316, 3321, 1657, -321, -2214, -3679, -4463, -4468, -3740, -2460, -896, 647, 1889, 2627, 2775, 2339, 1452, 311, -839, -1796, -2388, -2523, -2205, -1518, -618, 331, 1151, 1701, 1909, 1760, 1313, 670, -35, -640, -1222, -2870, -6287, -10983, -15753, -19040, -18782, -13676, -3935};