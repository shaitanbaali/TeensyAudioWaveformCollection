/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0017 256 samples */
 
const int16_t AKWF_granular_0017_256_DATA [256] = 
{139, 551, 954, 1355, 1758, 2159, 2559, 2962, 3363, 3765, 4165, 4566, 4963, 5363, 5762, 6161, 6559, 6956, 7353, 7749, 8146, 8544, 8935, 9334, 9724, 10125, 10512, 10916, 11297, 11700, 12084, 12481, 12874, 13258, 13662, 14027, 14454, 14796, 15248, 15556, 15528, 18550, 7049, -19611, -17046, -17907, -18328, -18730, -19097, -19530, -19871, -20311, -20647, -21084, -21431, -21849, -22211, -22607, -22989, -23369, -23767, -24124, -24539, -24879, -25307, -25644, -26064, -26407, -26815, -27172, -27566, -27945, -28307, -28690, -28669, -28721, -28625, -28712, -28590, -28677, -28560, -28638, -28595, -28488, -27977, -31734, 1223, 32424, 27686, 27884, 27734, 27101, 26876, 26339, 26033, 25558, 25172, 24762, 24330, 23967, 23497, 23151, 22664, 22330, 21848, 21510, 21038, 20667, 20237, 19817, 19446, 18669, 19991, -6242, -19588, -16613, -16748, -16315, -15944, -15537, -15150, -14750, -14359, -13955, -13572, -13155, -12787, -12354, -11998, -11562, -11209, -10775, -10410, -9991, -9607, -9234, -8778, -8470, -8022, -7334, 5406, 7639, 6523, 6345, 5855, 5510, 5074, 4691, 4278, 3874, 3476, 3068, 2672, 2264, 1866, 1461, 1060, 670, 223, -26, 6, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};