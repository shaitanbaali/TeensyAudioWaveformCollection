/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0040 256 samples */
 
const int16_t AKWF_granular_0040_256_DATA [256] = 
{1936, 8081, 13796, 18936, 23267, 26638, 28956, 30233, 30511, 29899, 28542, 26609, 24258, 21650, 18923, 16204, 13608, 11163, 8946, 6989, 5287, 3851, 2687, 1772, 1090, 607, 291, 109, 24, 0, 0, -16, -86, -245, -530, -976, -1615, -2479, -3586, -4968, -6639, -8602, -10848, -13352, -16076, -18960, -21909, -24807, -27496, -29804, -31572, -32595, -32701, -31744, -29653, -26354, -21830, -16366, -10184, -3581, 3070, 9544, 15473, 20606, 24738, 27758, 29649, 30437, 30222, 29153, 27411, 25166, 22596, 19863, 17108, 14440, 11936, 9648, 7614, 5849, 4361, 3140, 2160, 1405, 847, 461, 215, 77, 16, 0, 0, -17, -80, -216, -451, -810, -1317, -1988, -2834, -3881, -5123, -6559, -8189, -9963, -11870, -13857, -15841, -17744, -19456, -20853, -21841, -22288, -22096, -21188, -19547, -17171, -14118, -10516, -6548, -2391, 1750, 5638, 9096, 11957, 14107, 15530, 16219, 16240, 15699, 14730, 13486, 12098, 10713, 9436, 8344, 7494, 6894, 6531, 6375, 6373, 6471, 6609, 6740, 6819, 6817, 6719, 6518, 6220, 5831, 5365, 4837, 4258, 3642, 2987, 2305, 1595, 853, 83, -723, -1574, -2468, -3402, -4376, -5377, -6400, -7414, -8399, -9309, -10111, -10763, -11215, -11431, -11381, -11055, -10456, -9616, -8593, -7454, -6302, -5230, -4327, -3681, -3349, -3352, -3671, -4255, -5013, -5824, -6551, -7053, -7200, -6890, -6051, -4671, -2761, -480, 2442, 5847, 9133, 12159, 14769, 16856, 18349, 19219, 19483, 19189, 18426, 17274, 15839, 14216, 12496, 10767, 9082, 7482, 6019, 4707, 3565, 2607, 1819, 1204, 757, 453, 224, 89, 22, 0, 0, -9, -53, -160, -359, -679, -1143, -1782, -2617, -3673, -4967, -6503, -8279, -10303, -12528, -14924, -17415, -19897, -22263, -24384, -26084, -27206, -27585, -27087, -25600, -23077, -19534, -15056, -9831, -3949};