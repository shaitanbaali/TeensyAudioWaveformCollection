/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0026 256 samples */
 
const int16_t AKWF_granular_0026_256_DATA [256] = 
{465, 1435, 2370, 3285, 4175, 5040, 5889, 6705, 7496, 8263, 8998, 9707, 10383, 11033, 11649, 12231, 12779, 13299, 13780, 14227, 14638, 15012, 15352, 15648, 15915, 16132, 16310, 16437, 17082, 17551, 17266, 16344, 15545, 15442, 15336, 15160, 14959, 14720, 14443, 14127, 13777, 13391, 12974, 12518, 12027, 11505, 10947, 10359, 9744, 9095, 8410, 7699, 6960, 6199, 5406, 4584, 3737, 2868, 1972, 1062, 130, -827, -1799, -2789, -3790, -4803, -5832, -6880, -7916, -8816, -9694, -10575, -11454, -12330, -13197, -14053, -14899, -15741, -16574, -17391, -18198, -18991, -19770, -20526, -21253, -21944, -22598, -23217, -23801, -24348, -24855, -25315, -25741, -26118, -26452, -26736, -26978, -27167, -27308, -27402, -27442, -27430, -27369, -27258, -27093, -26877, -26608, -26293, -25929, -25515, -25052, -24541, -23989, -23398, -22759, -22079, -21361, -20606, -19824, -19009, -18158, -17283, -16380, -15451, -14513, -13552, -12574, -11587, -10592, -9596, -8598, -7603, -6614, -5631, -4658, -3716, -2786, -1879, -1002, -159, 650, 1420, 2151, 2839, 3478, 4070, 4609, 5097, 5533, 5913, 6236, 6496, 6703, 6851, 6939, 6969, 6940, 6852, 6708, 6507, 6249, 5936, 5568, 5145, 4671, 4148, 3575, 2959, 2295, 1587, 840, 55, -766, -1617, -2502, -3414, -4350, -5308, -6282, -7271, -8277, -9289, -10311, -11334, -12353, -13374, -14391, -15397, -16396, -17382, -18350, -19300, -20234, -21146, -22026, -22894, -23728, -24534, -25313, -26054, -26764, -27444, -28084, -28686, -29249, -29774, -30260, -30699, -31099, -31455, -31763, -32029, -32248, -32403, -32691, -32693, -32476, -32273, -32023, -31738, -31416, -31065, -30682, -30265, -29814, -29338, -28833, -28295, -27752, -27123, -26228, -25299, -24365, -23408, -22425, -21433, -20425, -19403, -18372, -17327, -16270, -15206, -14138, -13072, -12002, -10922, -9849, -8774, -7710, -6647, -5594, -4548, -3512, -2491, -1491, -479};