/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0012 256 samples */
 
const int16_t AKWF_granular_0012_256_DATA [256] = 
{2048, 5165, 8316, 11505, 14668, 17763, 20711, 23488, 26035, 28304, 30273, 31633, 32384, 32743, 32681, 32206, 31330, 30078, 28459, 26513, 24263, 21749, 19026, 16120, 13066, 9930, 6745, 3556, 441, -2610, -5528, -8273, -10829, -13133, -15178, -16947, -18412, -19561, -20379, -20883, -21033, -20904, -20445, -19648, -18586, -24902, -27093, -25063, -24539, -24565, -24693, -24460, -23798, -22830, -21616, -20127, -18363, -16297, -13935, -11286, -8406, -5283, -1992, 1412, 4895, 8367, 11778, 15110, 18265, 21212, 23906, 26279, 28327, 30018, 31315, 32207, 32685, 32743, 32389, 31629, 30482, 28963, 27117, 24960, 22518, 19845, 16982, 13964, 10863, 7689, 4498, 1343, -1733, -4689, -7483, -10093, -12484, -14609, -16454, -18010, -19256, -20172, -20766, -21032, -20965, -20612, -20020, -18499, -22431, -27485, -25349, -24150, -23716, -23558, -23116, -22288, -21154, -19812, -18269, -16518, -14574, -12421, -10086, -7602, -5011, -2359, 310, 2957, 5534, 7986, 10281, 12372, 14248, 15875, 17234, 18310, 19097, 19593, 19805, 19741, 19411, 18837, 18041, 17041, 15869, 14546, 13118, 11601, 10022, 8418, 6817, 5239, 3725, 2275, 917, -327, -1449, -2435, -3282, -3986, -4545, -4959, -5234, -5377, -5398, -5309, -5120, -4847, -4504, -4126, -3594, -3632, -4412, -3924, -3381, -3025, -2711, -2381, -2014, -1636, -1263, -904, -575, -283, -31, 6, -3, 0, 0, 0, 0, 0, 0, 53, 202, 444, 770, 1180, 1659, 2198, 2778, 3387, 4007, 4619, 5206, 5749, 6227, 6628, 6936, 7137, 7219, 7174, 6997, 6682, 6231, 5645, 4928, 4098, 3153, 2112, 991, -191, -1414, -2654, -3906, -5129, -6308, -7423, -8441, -9359, -10147, -10799, -11284, -11608, -11753, -11745, -11313, -12010, -16374, -16720, -15998, -16158, -16553, -16925, -16991, -16774, -16339, -15672, -14777, -13624, -12183, -10453, -8434, -6142, -3608, -805};