/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0022 256 samples */
 
const int16_t AKWF_granular_0022_256_DATA [256] = 
{406, 1462, 2723, 3923, 5128, 6328, 7515, 8690, 9858, 11012, 12148, 13269, 14365, 15446, 16506, 17543, 18553, 19534, 20490, 21417, 22316, 23183, 24016, 24813, 25581, 26310, 27007, 27666, 28286, 28868, 29416, 29922, 30392, 30825, 31211, 31539, 31825, 32074, 32282, 32453, 32588, 32684, 32744, 32768, 32760, 32717, 32639, 32531, 32391, 32222, 32025, 31798, 31544, 31263, 30959, 30633, 30282, 29910, 29518, 29107, 28680, 28236, 27774, 27299, 26809, 26309, 25800, 25280, 24749, 24210, 23664, 23115, 22562, 22002, 21441, 20877, 20311, 19749, 19185, 18621, 18062, 17503, 16949, 16402, 15855, 15315, 14782, 14252, 13734, 13224, 12718, 12221, 11734, 11255, 10785, 10323, 9871, 9429, 8997, 8574, 8161, 7756, 7361, 6978, 6605, 6239, 5882, 5535, 5196, 4868, 4547, 4234, 3927, 3629, 3337, 3052, 2773, 2500, 2232, 1970, 1713, 1459, 1207, 959, 713, 469, 228, -11, -251, -493, -734, -976, -1220, -1467, -1715, -1967, -2223, -2483, -2749, -3017, -3292, -3571, -3859, -4154, -4455, -4762, -5079, -5400, -5734, -6076, -6426, -6786, -7153, -7529, -7916, -8314, -8720, -9138, -9562, -9998, -10446, -10901, -11365, -11839, -12321, -12814, -13317, -13827, -14343, -14868, -15400, -15941, -16489, -17040, -17590, -18142, -18698, -19255, -19814, -20376, -20934, -21494, -22052, -22607, -23159, -23704, -24244, -24778, -25305, -25821, -26331, -26824, -27309, -27779, -28235, -28674, -29097, -29501, -29886, -30251, -30594, -30912, -31209, -31478, -31723, -31939, -32127, -32285, -32413, -32508, -32573, -32602, -32599, -32560, -32485, -32376, -32228, -32045, -31823, -31563, -31265, -30927, -30550, -30137, -29685, -29193, -28665, -28094, -27490, -26849, -26168, -25452, -24700, -23911, -23095, -22246, -21365, -20456, -19515, -18547, -17560, -16538, -15493, -14428, -13347, -12239, -11116, -9974, -8816, -7652, -6475, -5285, -4087, -2888, -1677, -437};