/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0031 256 samples */
 
const int16_t AKWF_granular_0031_256_DATA [256] = 
{2440, 5061, 7004, 10602, 14425, 19990, 22353, 22334, 21047, 18899, 15318, 14312, 11895, 10097, 8871, 8024, 7136, 10436, 16091, 23176, 27321, 31122, 31261, 32035, 32895, 30585, 25265, 20313, 13652, 8146, 3870, 19, -1910, -1242, -244, 4395, 11164, 20205, 25668, 28488, 28472, 29421, 29256, 29115, 24782, 18859, 12386, 4861, -1117, -3824, -4785, -3601, -896, 2137, 8079, 16120, 20509, 22597, 22590, 21296, 20038, 18530, 13413, 7941, 1620, -5786, -10679, -12731, -11550, -8466, -5971, -3596, -1136, 2151, 6811, 9701, 10766, 9173, 5444, 253, -3527, -8941, -13702, -18713, -21622, -22379, -20441, -17070, -13229, -9772, -6933, -4994, -3043, -1411, -1424, -4302, -9282, -15943, -20981, -24979, -27450, -29126, -29324, -28640, -26073, -21962, -17047, -12440, -8203, -5888, -4432, -4093, -4710, -7557, -11347, -16526, -21021, -24094, -25015, -24890, -23646, -21940, -19561, -16277, -12093, -7911, -5115, -3942, -4342, -6397, -8566, -11604, -14788, -17684, -20206, -22102, -21822, -19963, -17131, -13437, -9427, -5480, -1337, 2401, 4713, 5407, 4566, 2400, -203, -3036, -5820, -8123, -9964, -10591, -9670, -7919, -4944, -1828, 1210, 4001, 5325, 5448, 4655, 2687, 175, -2880, -6347, -9020, -11090, -12015, -12098, -10780, -8384, -4716, -1254, 1968, 4167, 6101, 7202, 7246, 6531, 5123, 3020, 824, -1428, -3404, -3479, -2643, -1688, -413, 967, 2258, 3443, 4038, 3621, 3756, 3487, 2435, 1022, -531, -2681, -4247, -5473, -5865, -5221, -4005, -3029, -2132, -973, 590, 1918, 2959, 3432, 2919, 2269, 1864, 217, -1250, -2735, -4104, -4497, -3691, -3535, -2258, -1207, -1067, -569, -322, -239, 360, 160, -1188, -1949, -4195, -4908, -4038, -2072, -715, 2506, 3690, 6037, 7917, 10283, 10928, 11737, 11031, 9104, 6567, 5273, 2791, 302, -874, -3234, -3464, -2458, 98};