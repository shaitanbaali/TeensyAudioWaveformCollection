/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0037 256 samples */
 
const int16_t AKWF_granular_0037_256_DATA [256] = 
{7365, 13927, 24913, 32012, 31039, 25736, 16410, 4792, -7542, -14891, -18331, -19875, -16974, -12961, -9299, -4882, -1022, 2144, 6931, 12023, 14073, 14265, 12803, 5997, -4539, -13875, -21246, -25770, -25978, -21943, -16292, -10278, -5193, -2719, -72, 3824, 6662, 10206, 13527, 13754, 9930, 4085, -3923, -13055, -19218, -21303, -20584, -17393, -11655, -6088, -1519, 1429, 2713, 4889, 6956, 7998, 10097, 14326, 16041, 16186, 14653, 7731, 1996, -3033, -7953, -9770, -8180, -4454, -3087, -950, -119, -1017, 647, 1087, 1865, 6808, 15564, 22167, 23533, 21362, 15741, 6796, -3268, -10100, -13673, -13744, -11707, -9577, -6818, -2083, 3583, 9656, 17656, 23550, 26800, 25208, 18225, 8652, -3594, -13905, -21968, -25171, -23273, -19533, -14150, -8643, -3478, -452, 2433, 5992, 8348, 9754, 8973, 5605, 5, -7194, -15559, -22457, -24989, -23517, -20136, -14546, -7937, -2856, 394, 2466, 3964, 5461, 7899, 11036, 15068, 15934, 12214, 6234, -2354, -10303, -16951, -20255, -18020, -14207, -8669, -3035, 1402, 3301, 2978, 4449, 6514, 7756, 8834, 12501, 15801, 15977, 13364, 7160, 2896, -1636, -6358, -7528, -5439, -1766, -1373, -1362, -739, -1175, -1443, 1191, 10658, 22552, 29513, 28715, 25018, 17455, 4317, -6871, -13066, -14501, -13438, -11912, -9901, -5998, -1065, 1929, 5996, 13261, 20255, 21815, 19940, 15534, 5869, -5939, -17308, -24202, -26403, -25191, -20750, -14348, -6774, -1956, -34, 2564, 5916, 7574, 8597, 9262, 6881, 1292, -6255, -14062, -20417, -23497, -23593, -20881, -14882, -8227, -3616, -442, 2142, 3266, 3899, 5070, 7415, 11028, 15280, 18099, 13762, 7655, 2184, -7041, -13488, -14888, -12169, -8917, -5260, -514, -136, -706, -1207, -1139, 1311, 4611, 7773, 11340, 17595, 21319, 16893, 11747, 7272, -1010, -7431, -8839, -7473, -6310, -5183, -4411, -5039, -728};