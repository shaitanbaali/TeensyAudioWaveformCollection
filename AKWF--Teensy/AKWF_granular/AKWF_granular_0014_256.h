/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0014 256 samples */
 
const int16_t AKWF_granular_0014_256_DATA [256] = 
{1101, 3987, 6458, 8684, 10695, 12491, 14123, 15588, 16908, 18118, 19208, 20208, 21119, 21945, 22706, 23427, 23700, 23850, 24143, 24456, 24808, 25187, 25587, 26000, 26427, 26857, 27298, 27741, 28183, 28621, 29114, 29522, 29857, 30204, 30461, 30621, 30781, 30930, 31066, 31194, 31313, 31425, 31530, 31625, 31716, 31799, 31879, 31952, 32021, 32087, 32145, 32200, 32252, 32302, 32349, 32390, 32431, 32468, 32501, 32533, 32564, 32592, 32620, 32642, 32667, 32689, 32708, 32729, 32742, 32769, 32731, 32584, 32449, 32310, 32201, 32114, 32041, 31990, 31944, 31915, 31895, 31873, 31873, 31867, 31867, 31794, 32121, 30999, 24216, 18843, 14340, 10317, 6821, 3776, 1127, -1190, -3217, -4993, -6537, -7888, -9064, -10089, -10989, -11763, -12433, -13013, -13506, -13930, -14288, -14583, -14829, -15024, -15176, -15294, -15371, -15421, -15438, -15431, -15403, -15348, -15276, -15185, -15078, -14957, -14819, -14669, -14508, -14335, -14155, -13963, -13762, -13555, -13339, -13120, -12892, -12659, -12421, -12175, -11930, -11679, -11421, -11164, -10898, -10635, -10368, -10092, -9823, -9544, -9267, -8992, -8705, -8425, -8140, -7850, -7573, -7274, -6988, -6745, -6223, -7563, -10325, -12227, -14070, -15679, -17125, -18417, -19577, -20627, -21568, -22424, -23195, -23891, -24537, -25111, -25648, -26140, -26574, -26971, -27414, -27631, -24704, -21833, -19725, -17810, -16182, -14817, -13650, -12662, -11846, -11146, -10572, -10103, -9711, -9412, -9169, -8989, -8865, -8779, -8740, -8734, -8759, -8817, -8892, -8995, -9117, -9254, -9412, -9580, -9761, -9957, -10158, -10373, -10594, -10824, -11060, -11300, -11550, -11803, -12061, -12324, -12586, -12858, -13131, -13404, -13686, -13964, -14246, -14534, -14818, -15108, -15396, -15685, -15979, -16271, -16569, -16865, -17158, -17458, -17751, -18052, -18355, -18646, -18953, -19249, -19549, -19858, -20150, -20456, -20766, -20956, -21700, -19910, -13812, -9489, -5501, -1917};