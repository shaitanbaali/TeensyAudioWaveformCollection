/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0018 256 samples */
 
const int16_t AKWF_granular_0018_256_DATA [256] = 
{1185, 2944, 4620, 6298, 7991, 9706, 11399, 13018, 14533, 15919, 17194, 18392, 19541, 20657, 21752, 22797, 23780, 24697, 25330, 25665, 25936, 26147, 26316, 26451, 26545, 26587, 26570, 26489, 26352, 26170, 25957, 25725, 25476, 25210, 24917, 24595, 24242, 23864, 23461, 23043, 22616, 22183, 21744, 21292, 20830, 20353, 19864, 19367, 18865, 18355, 17849, 17339, 16833, 16316, 15800, 15275, 14755, 14227, 13713, 13191, 12679, 12163, 11656, 11144, 10641, 10133, 9613, 9132, 8715, -2387, -7820, -5487, -6014, -5968, -6375, -6150, -5738, -4919, -4119, -3402, -2951, -2678, -2511, -2312, -2012, -1612, -1162, -724, -285, 3, -2, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 9, 63, 165, 313, 509, 754, 1047, 1381, 1747, 2138, 2553, 2991, 3452, 3939, 4451, 4986, 5539, 6100, 6658, 7220, 7778, 8343, 8917, 9503, 10091, 10685, 11275, 11854, 12424, 12984, 13536, 14096, 14651, 15213, 15765, 16311, 16839, 17365, 17865, 18370, 18856, 19352, 19828, 20321, 20775, 21247, 21671, 22112, 22511, 22937, 23319, 23730, 24097, 24489, 24831, 25192, 25508, 25836, 26134, 26438, 26725, 27000, 27288, 27514, 27787, 27942, 28231, 27832, 31132, -1106, -29382, -22743, -24564, -26765, -29852, -31694, -31940, -30159, -27565, -25045, -23846, -24145, -25817, -27866, -29495, -29990, -29382, -28035, -26758, -26130, -26510, -27706, -29265, -30575, -31227, -31134, -30530, -29860, -29528, -29775, -30519, -31500, -32333, -32752, -32646, -32166, -31548, -31078, -30893, -31003, -31223, -31347, -31171, -30633, -29785, -28788, -27805, -26962, -26245, -25579, -24824, -23857, -22624, -21167, -19557, -17922, -16339, -14833, -13350, -11825, -10175, -8378, -6459, -4475, -2497, -567};