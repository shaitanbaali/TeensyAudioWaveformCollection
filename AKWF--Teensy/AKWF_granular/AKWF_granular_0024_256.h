/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0024 256 samples */
 
const int16_t AKWF_granular_0024_256_DATA [256] = 
{1054, 4999, 8905, 12746, 16457, 19968, 23182, 26017, 28413, 30295, 31624, 32361, 32721, 32756, 32717, 32677, 32621, 32551, 32464, 32359, 32233, 32088, 31921, 31731, 31519, 31281, 31018, 30730, 30416, 30073, 29707, 29310, 28886, 28433, 27952, 27442, 26906, 26339, 25743, 25120, 24467, 23790, 23083, 22347, 21584, 20795, 19984, 19146, 18283, 17394, 16482, 15549, 14599, 13622, 12628, 11614, 10582, 9537, 8476, 7397, 6306, 5202, 4096, 2972, 1838, 700, -442, -1587, -2709, -3802, -4868, -5900, -6902, -7866, -8800, -9699, -10564, -11390, -12172, -12925, -13814, -14729, -15621, -16498, -17357, -18200, -19024, -19829, -20614, -21372, -22107, -22823, -23511, -24176, -24812, -25417, -25997, -26548, -27067, -27559, -28017, -28441, -28835, -29196, -29524, -29816, -30073, -30297, -30485, -30638, -30756, -30837, -30881, -30892, -30852, -30671, -30254, -29541, -28492, -27073, -25276, -23113, -20580, -17704, -14527, -11087, -7446, -3689, 163, 4013, 7799, 11448, 14866, 17992, 20794, 23178, 25112, 26554, 27467, 27829, 27835, 27816, 27794, 27760, 27715, 27657, 27584, 27495, 27391, 27269, 27130, 26969, 26788, 26588, 26364, 26121, 25853, 25564, 25250, 24913, 24551, 24168, 23757, 23321, 22863, 22380, 21871, 21338, 20779, 20197, 19597, 18968, 18315, 17642, 16945, 16225, 15491, 14729, 13947, 13151, 12333, 11501, 10650, 9780, 8898, 8001, 7090, 6173, 5239, 4294, 3341, 2380, 1413, 442, -534, -1517, -2501, -3488, -4469, -5451, -6433, -7413, -8385, -9350, -10307, -11257, -12198, -13129, -14045, -14945, -15837, -16709, -17567, -18408, -19224, -20022, -20801, -21555, -22288, -22992, -23675, -24332, -24961, -25564, -26136, -26676, -27190, -27673, -28124, -28541, -28927, -29279, -29598, -29882, -30132, -30345, -30526, -30670, -30779, -30852, -30887, -30890, -30826, -30593, -30108, -29312, -28177, -26672, -24782, -22521, -19895, -16938, -13711, -10224, -6556, -2682};