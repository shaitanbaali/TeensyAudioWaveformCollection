/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0009 256 samples */
 
const int16_t AKWF_granular_0009_256_DATA [256] = 
{1546, 4137, 6712, 9294, 11883, 14444, 16956, 19386, 21714, 23922, 25987, 27911, 29525, 30668, 31568, 32227, 32628, 32772, 32658, 32288, 31664, 30787, 29670, 28318, 26741, 24964, 22978, 20814, 18489, 16009, 13412, 10723, 7924, 5073, 2181, -737, -3621, -6494, -9324, -12072, -14729, -17272, -19658, -21913, -23991, -25873, -27560, -29022, -30252, -31253, -32007, -32505, -32747, -32732, -32461, -31933, -31150, -30131, -28867, -27374, -25671, -23757, -21663, -19409, -16982, -14430, -11763, -8995, -6180, -3303, -393, 2513, 5403, 8253, 11016, 13717, 16307, 18762, 21076, 23212, 25168, 26934, 28487, 29809, 30901, 31745, 32341, 32684, 32768, 32595, 32165, 31481, 30551, 29376, 27969, 26343, 24517, 22491, 20290, 17922, 15416, 12796, 10075, 7268, 4403, 1501, -1386, -4293, -7162, -9968, -12702, -15325, -17828, -20200, -22413, -24444, -26286, -27912, -29324, -30509, -31449, -32139, -32599, -32609, -32128, -31415, -30463, -29289, -27912, -26339, -24592, -22687, -20652, -18510, -16271, -13957, -11592, -9199, -6800, -4428, -2075, 217, 2446, 4586, 6612, 8521, 10307, 11941, 13425, 14749, 15894, 16876, 17680, 18304, 18751, 19022, 19120, 19055, 18829, 18447, 17930, 17277, 16500, 15612, 14632, 13570, 12438, 11249, 10019, 8757, 7485, 6221, 4960, 3729, 2532, 1383, 298, -719, -1666, -2529, -3308, -3992, -4578, -5072, -5467, -5754, -5884, -5851, -5664, -5329, -4861, -4268, -3560, -2765, -1886, -945, 38, 1043, 2058, 3048, 4016, 4925, 5764, 6517, 7156, 7686, 8068, 8153, 8142, 8034, 7822, 7507, 7081, 6548, 5910, 5161, 4310, 3360, 2311, 1182, -21, -1303, -2642, -4029, -5456, -6891, -8343, -9793, -11219, -12612, -13953, -15218, -16415, -17515, -18500, -19364, -20089, -20667, -21088, -21342, -21418, -21310, -21016, -20528, -19848, -18974, -17907, -16656, -15223, -13611, -11828, -9896, -7820, -5629, -3321, -860};