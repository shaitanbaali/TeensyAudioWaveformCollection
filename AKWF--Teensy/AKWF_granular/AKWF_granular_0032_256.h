/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0032 256 samples */
 
const int16_t AKWF_granular_0032_256_DATA [256] = 
{873, 2746, 3736, 4851, 6819, 8616, 11097, 14773, 18126, 19494, 20751, 22613, 24792, 27657, 30474, 32372, 32802, 32569, 32249, 32020, 31866, 31920, 31895, 30590, 29279, 27326, 24723, 22295, 20543, 19580, 18619, 16576, 14243, 12165, 9884, 8257, 7507, 6589, 5616, 4408, 1915, -179, -2180, -4084, -4444, -5273, -7482, -9288, -10959, -13620, -14909, -16360, -18352, -19658, -21910, -24118, -25391, -27679, -29863, -29783, -30797, -31837, -30651, -30563, -31559, -30002, -28482, -29013, -27985, -26655, -26151, -23897, -21002, -19644, -18289, -17423, -16962, -15310, -13877, -12802, -10097, -8505, -7514, -5236, -2962, -438, 4062, 8644, 12337, 16015, 18238, 18832, 20420, 23219, 25979, 27986, 28819, 28261, 28355, 28693, 28185, 27760, 28040, 28336, 28509, 28380, 27071, 25933, 26299, 27016, 26575, 26197, 26084, 25055, 23748, 22252, 20326, 18949, 18309, 17197, 15677, 13721, 11179, 8978, 7005, 5018, 3251, 897, -2511, -6992, -11076, -13873, -16198, -18460, -21014, -23298, -25895, -28464, -29959, -30476, -31437, -31018, -30010, -30557, -30903, -30541, -30656, -29969, -28631, -27639, -26451, -26266, -27542, -26850, -25333, -25142, -23509, -21861, -22269, -21897, -19278, -17321, -14856, -10287, -5656, -2360, 252, 1204, 1742, 4064, 7686, 11349, 12829, 12640, 12951, 13783, 14134, 15159, 16654, 18259, 20175, 21728, 21822, 21780, 23270, 25859, 27436, 28482, 29368, 29570, 29495, 29816, 29425, 29256, 30455, 31199, 30809, 29967, 27969, 25679, 24025, 22658, 21696, 20681, 17726, 14020, 10602, 6078, 2656, 1292, -814, -3948, -6793, -10297, -13086, -14976, -15833, -16305, -17304, -18543, -19847, -21667, -23507, -23649, -22504, -21767, -21716, -22011, -23796, -25839, -25787, -24813, -24255, -23839, -24009, -25038, -26400, -27136, -26645, -24291, -21339, -19206, -17737, -17200, -17614, -17059, -15346, -13432, -10828, -7739, -6066, -6751, -6803, -5260, -3280, -1205};