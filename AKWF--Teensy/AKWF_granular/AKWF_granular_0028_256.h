/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0028 256 samples */
 
const int16_t AKWF_granular_0028_256_DATA [256] = 
{307, 413, 3313, 9561, 7628, 5164, 9683, 5945, 1190, 1565, 2766, 6307, 10696, 13232, 16779, 23514, 22726, 18518, 25977, 24695, 22421, 18977, 9838, 8277, 1650, -8604, -11248, -16275, -18692, -20563, -25530, -30887, -31104, -32147, -29498, -22825, -21930, -16752, -10873, -11339, -11816, -11269, -5294, 3033, 10040, 8989, 8890, 11598, 9582, 11073, 10842, 10788, 7895, 2443, -6546, -14377, -15860, -16363, -13920, -12809, -11717, -14320, -17040, -17711, -21298, -18107, -14846, -18406, -20760, -18306, -15517, -9086, -7975, -2125, 4640, 8073, 9242, 5173, 3116, 6078, 6417, 9276, 10445, 9959, 7190, 5812, 9884, 12750, 16734, 17695, 19202, 19553, 18444, 14114, 15294, 13757, 12044, 10445, 4395, -2154, -14935, -23520, -26975, -25519, -21621, -16925, -13962, -8512, -7545, -3124, 5975, 8930, 8205, 2577, -171, -1770, -3287, 764, 1311, 4169, 7430, 8081, 17587, 18152, 11381, 7235, 5190, 2103, -2027, -6837, -16833, -18228, -20134, -22834, -15254, -14603, -16058, -13153, -13250, -8194, -5712, -9111, -11193, -11403, -9978, -5657, -2133, 1653, 3331, 7499, 12877, 12924, 12326, 8270, 2506, 2881, 2372, -942, 665, -672, -1604, 7275, 7565, 9531, 9619, 7126, 10101, 13337, 13293, 6605, 4359, -497, -2052, -1001, -866, 811, 4564, 7299, 4459, 4682, 3695, 1034, 705, -119, -6262, -6845, -9458, -10770, -6065, -3355, 483, 3963, 6815, 12451, 16526, 20403, 18004, 12673, 13146, 11283, 8933, 6258, 1457, -1371, -3920, -5041, -6192, 499, -1514, -13656, -17281, -16325, -8941, -14780, -24660, -23132, -13483, -4097, -4482, -7087, -477, 7043, 7949, 8675, 8968, 6278, 3339, 1952, -654, 2170, 6473, 4216, 7528, 10358, 6001, 8963, 11765, 13240, 13121, 6838, 4927, 7788, 6939, 9317, 6935, 6833, 6601, 3240, -647, -4465, -4594, -6530, -9072, -3269, -823, -299};