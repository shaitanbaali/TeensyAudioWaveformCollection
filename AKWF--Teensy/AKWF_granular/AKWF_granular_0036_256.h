/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0036 256 samples */
 
const int16_t AKWF_granular_0036_256_DATA [256] = 
{2457, 3030, 4457, 8625, 18180, 25325, 26894, 29818, 31880, 30075, 27400, 25287, 22371, 19046, 14661, 7435, 580, -3738, -8633, -12691, -12485, -11171, -10995, -9798, -8616, -8409, -7222, -4772, -2827, -502, 1818, 1046, -1337, -2663, -5437, -9213, -10538, -11630, -13961, -15083, -15731, -17301, -17539, -15883, -13692, -10296, -6190, -4031, -2595, -648, 510, 1368, 3634, 5896, 7772, 9836, 10734, 9735, 9028, 8237, 6590, 4931, 3575, 1714, -1420, -5429, -9228, -12172, -14120, -14854, -14623, -12827, -10255, -8704, -7708, -6423, -5385, -3765, -2380, 518, 7482, 12207, 11067, 9308, 7702, 4107, 750, -286, -55, 376, -136, -2606, -4863, -4700, -3932, -782, 7309, 17465, 23797, 25719, 26011, 24990, 23623, 22949, 22083, 21507, 20343, 15924, 9104, 3260, -880, -4017, -5142, -4334, -3612, -3784, -5411, -8419, -10386, -9972, -8795, -7862, -5505, -4482, -6629, -8534, -9363, -9836, -9193, -6799, -4258, -1953, -470, -898, -1769, -1956, -2291, -2935, -3040, -4348, -7489, -10810, -14157, -16287, -15858, -14609, -13760, -12497, -10949, -9146, -6668, -4468, -2668, -695, 1365, 2219, 1596, 1136, 760, -120, -422, 1171, 3067, 4399, 5573, 7255, 8216, 8442, 9497, 14443, 23000, 27336, 26021, 24923, 22095, 15817, 9884, 5908, 3281, 1127, -2583, -8636, -13251, -15243, -16942, -16809, -12685, -7289, -3340, -1225, -493, 392, 3012, 4708, 4763, 5252, 5306, 2545, -1442, -4208, -5730, -5670, -4607, -3159, -1091, 1207, 2078, 2042, 3751, 7831, 11630, 13600, 14364, 13099, 9839, 5940, 1455, -2063, -3864, -5767, -8573, -10773, -11829, -12844, -13447, -12807, -11075, -8188, -5859, -5523, -6097, -5839, -5821, -6111, -5591, -5116, -5505, -6728, -8222, -8876, -8109, -6953, -6534, -5656, -3993, -3433, -3819, -1700, 2036, 2658, 2158, 3023, 3065, 2748, 2654, 1476};