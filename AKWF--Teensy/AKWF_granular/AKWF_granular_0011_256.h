/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0011 256 samples */
 
const int16_t AKWF_granular_0011_256_DATA [256] = 
{2909, 7844, 11593, 13731, 14171, 13183, 11244, 8870, 6478, 4353, 2660, 1420, 619, 189, 22, 0, -25, -207, -703, -1671, -3242, -5533, -8551, -12184, -16077, -19611, -21940, -22146, -19462, -13682, -5375, 4088, 13170, 20231, 24323, 25274, 23594, 20178, 15932, 11666, 7878, 4831, 2625, 1181, 381, 58, -1, -25, -257, -949, -2334, -4615, -7972, -12389, -17727, -23552, -28802, -32144, -32463, -28781, -20827, -9390, 3685, 16105, 25753, 31350, 32731, 30566, 26094, 20594, 15036, 10153, 6249, 3410, 1568, 532, 93, 1, -14, -208, -810, -2038, -4051, -6939, -10716, -15148, -19844, -24101, -26925, -27292, -24407, -18134, -9067, 1343, 11218, 18903, 23392, 24531, 22924, 19518, 15330, 11153, 7517, 4625, 2538, 1181, 419, 84, 2, -5, -101, -438, -1146, -2318, -4025, -6246, -8889, -11691, -14234, -15970, -16308, -14772, -11236, -6106, -146, 5568, 10046, 12699, 13445, 12603, 10735, 8415, 6108, 4098, 2524, 1390, 656, 240, 53, 2, 0, -32, -158, -425, -868, -1488, -2277, -3175, -4080, -4843, -5286, -5242, -4618, -3440, -1888, -258, 1129, 2066, 2457, 2372, 1972, 1441, 927, 509, 223, 54, -3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -3, 21, 261, 674, 1095, 1407, 1540, 1493, 1306, 1035, 743, 470, 254, 107, 29, 2, 2, 512, 1396, 2238, 2876, 3194, 3171, 2869, 2380, 1818, 1269, 795, 430, 189, 53, 3, -1, -17, -106, -346, -814, -1585, -2714, -4231, -6057, -8045, -9868, -11066, -11131, -9682, -6593, -2034};