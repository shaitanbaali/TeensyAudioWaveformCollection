/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0016 256 samples */
 
const int16_t AKWF_granular_0016_256_DATA [256] = 
{29521, 28165, 28104, 27786, 27510, 27239, 26965, 26703, 26415, 26144, 25868, 25585, 25316, 25032, 24751, 24475, 24196, 23919, 23642, 23357, 23081, 22800, 22526, 22246, 21965, 21686, 21406, 21129, 20855, 20571, 20294, 20018, 19736, 19467, 19181, 18906, 18176, 20456, 7634, -19634, -16738, -16986, -16705, -16439, -16171, -15905, -15637, -15369, -15102, -14833, -14565, -14297, -14026, -13758, -13489, -13220, -12951, -12681, -12411, -12144, -11875, -11608, -11336, -11069, -10801, -10532, -10266, -9997, -9725, -9459, -9191, -8927, -8660, -8386, -8129, -7583, -8728, -969, 8380, 6785, 6752, 6480, 6214, 5934, 5664, 5391, 5118, 4844, 4569, 4294, 4022, 3749, 3475, 3202, 2927, 2656, 2381, 2110, 1836, 1564, 1291, 1018, 744, 484, 158, -19, 4, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, -3, 13, 246, 529, 799, 1072, 1344, 1618, 1892, 2165, 2437, 2708, 2982, 3254, 3527, 3798, 4071, 4343, 4613, 4886, 5156, 5427, 5697, 5969, 6239, 6509, 6779, 7048, 7318, 7587, 7857, 8126, 8395, 8661, 8931, 9200, 9467, 9736, 10002, 10269, 10538, 10805, 11072, 11337, 11605, 11871, 12138, 12405, 12670, 12933, 13201, 13465, 13731, 13997, 14258, 14524, 14791, 15051, 15321, 15581, 15825, 15735, 18213, -6611, -18974, -16672, -17430, -17692, -17960, -18234, -18498, -18766, -19028, -19295, -19561, -19827, -20089, -20355, -20615, -20880, -21142, -21406, -21667, -21926, -22189, -22452, -22711, -22972, -23231, -23491, -23754, -24011, -24271, -24528, -24788, -25047, -25306, -25564, -25823, -26077, -26338, -26596, -26851, -27110, -27363, -27623, -27876, -28144, -28285, -28264, -28254, -28250, -28234, -28227, -28216, -28208, -28200, -28192, -28175, -28168, -28154, -28157, -28143, -28114, -27728, -29790, -20095};