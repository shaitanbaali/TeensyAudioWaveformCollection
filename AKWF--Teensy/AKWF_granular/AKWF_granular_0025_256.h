/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0025 256 samples */
 
const int16_t AKWF_granular_0025_256_DATA [256] = 
{469, 1627, 2663, 3628, 4530, 5386, 6199, 6966, 7698, 8391, 9054, 9688, 10291, 10864, 11409, 11922, 12414, 12879, 13320, 13735, 14118, 14476, 14813, 15128, 15417, 15683, 15913, 16124, 16313, 16476, 16623, 16739, 16823, 16838, 16814, 17461, -19946, -24936, -20339, -18460, -16486, -14696, -13028, -11451, -9963, -8556, -7218, -5962, -4752, -3598, -2499, -1449, -453, 488, 1376, 2200, 2960, 3660, 4300, 4884, 5412, 5888, 6314, 6687, 7014, 7292, 7525, 7715, 7862, 7969, 8037, 8065, 8056, 7994, 8002, 7212, 5883, 5043, 4305, 3656, 3078, 2550, 2066, 1624, 1239, 908, 624, 388, 193, 40, -76, -158, -208, -227, -217, -179, -114, -26, 86, 220, 375, 545, 736, 941, 1161, 1395, 1640, 1896, 2160, 2431, 2709, 2993, 3279, 3568, 3855, 4136, 4404, 4557, 5644, -8700, -12085, -10166, -9529, -8792, -8080, -7387, -6708, -6037, -5374, -4725, -4073, -3425, -2783, -2144, -1511, -887, -268, 346, 950, 1544, 2132, 2705, 3264, 3821, 4337, 4786, 5222, 5636, 6031, 6405, 6755, 7083, 7384, 7657, 7906, 8121, 8290, 8532, 8044, 6729, 5921, 5203, 4549, 3938, 3362, 2809, 2277, 1763, 1262, 775, 301, -159, -608, -1046, -1464, -1857, -2231, -2586, -2920, -3238, -3538, -3818, -4080, -4326, -4554, -4762, -4955, -5129, -5286, -5425, -5547, -5652, -5741, -5810, -5863, -5899, -5918, -5919, -5916, -5915, -5913, -5910, -5908, -5906, -5904, -5902, -5900, -5897, -5896, -5893, -5891, -5888, -5886, -5884, -5881, -5878, -5877, -5875, -5872, -5869, -5868, -5865, -5862, -5860, -5858, -5857, -5853, -5851, -5849, -5847, -5845, -5842, -5838, -5837, -5834, -5833, -5830, -5828, -5826, -5822, -5821, -5819, -5817, -5814, -5811, -5809, -5807, -5805, -5803, -5800, -5796, -5765, -5915, -4398, -2189, -764};