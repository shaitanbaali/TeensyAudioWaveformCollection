/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0002 256 samples */
 
const int16_t AKWF_granular_0002_256_DATA [256] = 
{276, 1334, 2545, 3884, 5348, 6929, 8595, 10327, 12106, 13900, 15673, 17408, 19070, 20663, 22161, 23575, 24715, 25587, 26230, 27723, 24504, 17779, 19484, 20377, 21332, 22253, 23166, 23985, 24308, 24540, 24790, 25048, 25330, 25642, 25983, 26366, 26784, 27229, 27770, 28085, 28274, 28493, 28706, 28915, 29124, 29300, 29468, 29620, 29426, 31348, 22902, -12737, -11569, -10903, -10328, -9707, -9077, -8458, -7843, -7221, -6600, -5984, -5362, -4732, -4101, -3463, -2822, -2168, -1507, -837, -148, 550, 1264, 2000, 2756, 3535, 4330, 5149, 5935, 6898, 8016, -22011, -29424, -27203, -27030, -26492, -25929, -25344, -24765, -24189, -23625, -23096, -22609, -22170, -21785, -21455, -21180, -20952, -20764, -20609, -20472, -20338, -20213, -19890, -19380, -18840, -18238, -17555, -16775, -15972, -14516, -16409, -18167, -16802, -15738, -14191, -12507, -10754, -8943, -7090, -5248, -3436, -1676, -13, 1537, 2885, 4329, 5750, 6981, 8056, 8983, 9771, 10432, 10986, 11448, 11832, 12157, 12439, 12693, 12939, 13189, 13460, 13760, 14111, 14521, 14998, 15549, 16176, 16886, 17663, 18506, 19402, 20329, 21276, 22232, 23172, 24080, 24949, 25769, 26533, 27236, 27875, 28044, 30808, 19802, 1377, 4267, 4867, 5746, 6578, 7394, 8183, 8941, 9667, 10375, 11065, 11727, 12377, 13009, 13626, 14227, 14813, 15389, 15953, 16508, 17049, 17574, 18099, 18611, 19102, 19711, 20436, 20857, 23022, 17493, -27021, -29565, -28470, -28439, -28203, -27996, -27689, -26916, -26113, -25344, -24609, -23896, -23211, -22558, -21927, -21316, -20713, -20160, -19428, -18586, -17716, -16802, -15840, -14824, -13755, -12627, -11430, -10201, -8781, -7519, -23166, -25798, -23873, -22846, -21606, -20272, -18905, -17500, -16083, -14682, -13308, -11990, -10747, -9594, -8546, -7614, -6777, -6049, -5422, -4878, -4410, -4004, -3642, -3308, -2989, -2667, -2323, -1943, -1511, -1013, -418};