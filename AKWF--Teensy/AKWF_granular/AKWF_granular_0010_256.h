/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0010 256 samples */
 
const int16_t AKWF_granular_0010_256_DATA [256] = 
{800, 2434, 4033, 5624, 7200, 8754, 10298, 11812, 13298, 14756, 16165, 17547, 18887, 20178, 21423, 22614, 23743, 24829, 25849, 26806, 27699, 28529, 29250, 29813, 30302, 30711, 31040, 31296, 31471, 31569, 31588, 31532, 31397, 31188, 30905, 30550, 30123, 29628, 29062, 28434, 27737, 26979, 26170, 25297, 24369, 23395, 22367, 21296, 20189, 19035, 17846, 16626, 15372, 14101, 12805, 11483, 10149, 8805, 7446, 6091, 4730, 3366, 2010, 660, -672, -1989, -3294, -4581, -5838, -7072, -8271, -9442, -10578, -11680, -12739, -13753, -14722, -15649, -16531, -17360, -18133, -18859, -19531, -20147, -20708, -21210, -21653, -22041, -22370, -22641, -22852, -23004, -23099, -23135, -23115, -23038, -22905, -22717, -22475, -22180, -21833, -21439, -20998, -20508, -19971, -19393, -18775, -18116, -17424, -16695, -15931, -15140, -14321, -13480, -12613, -11727, -10820, -9875, -8999, -8114, -7202, -6278, -5333, -4378, -3419, -2445, -1466, -483, 505, 1504, 2518, 3540, 4562, 5588, 6607, 7628, 8644, 9649, 10643, 11621, 12582, 13524, 14444, 15341, 16210, 17044, 17849, 18618, 19351, 20047, 20696, 21299, 21860, 22372, 22837, 23247, 23604, 23907, 24154, 24344, 24475, 24549, 24560, 24509, 24401, 24227, 23993, 23700, 23341, 22921, 22442, 21901, 21298, 20644, 19927, 19151, 18324, 17437, 16507, 15525, 14490, 13410, 12292, 11132, 9928, 8691, 7417, 6113, 4791, 3437, 2060, 670, -739, -2156, -3577, -5010, -6440, -7870, -9297, -10700, -12098, -13484, -14842, -16181, -17488, -18756, -20001, -21207, -22366, -23485, -24551, -25567, -26532, -27439, -28285, -29071, -29785, -30440, -31025, -31536, -31975, -32336, -32631, -32767, -32757, -32679, -32520, -32284, -31968, -31576, -31107, -30567, -29951, -29261, -28501, -27672, -26777, -25824, -24799, -23715, -22579, -21384, -20142, -18853, -17512, -16129, -14711, -13251, -11773, -10258, -8716, -7153, -5573, -3988, -2396, -758};