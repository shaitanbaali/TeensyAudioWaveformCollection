/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0013 256 samples */
 
const int16_t AKWF_granular_0013_256_DATA [256] = 
{588, 1914, 3257, 4635, 6030, 7420, 8787, 10107, 11358, 12534, 13604, 14560, 15381, 16053, 16595, 16778, 19007, 20910, 20686, 20591, 20624, 20663, 20575, 20240, 19656, 18848, 17834, 16623, 15214, 13614, 11812, 9826, 7665, 5352, 2914, 371, -2254, -4928, -7617, -10283, -12883, -15414, -17818, -20077, -22157, -24020, -25644, -27044, -28020, -28485, -28664, -28517, -28043, -30976, -32500, -31012, -29967, -29084, -28242, -27227, -25910, -24313, -22508, -20513, -18344, -16022, -13563, -10971, -8262, -5463, -2600, 292, 3168, 6033, 8826, 11528, 14105, 16513, 18736, 20764, 22551, 24095, 25374, 26369, 27087, 27564, 27447, 28782, 32552, 32374, 31420, 30905, 30417, 29870, 29032, 27860, 26403, 24712, 22807, 20699, 18416, 15935, 13292, 10512, 7607, 4631, 1605, -1454, -4497, -7479, -10383, -13150, -15775, -18220, -20461, -22449, -24197, -25673, -26861, -27753, -28343, -28625, -28672, -28012, -29497, -32527, -31596, -30316, -29418, -28565, -27649, -26447, -24963, -23226, -21292, -19190, -16924, -14519, -11980, -9307, -6536, -3700, -813, 2068, 4943, 7772, 10516, 13138, 15612, 17910, 20014, 21899, 23538, 24917, 26022, 26849, 27404, 27585, 27745, 31456, 32580, 31108, 30153, 29299, 28474, 27456, 26133, 24566, 22801, 20886, 18837, 16659, 14376, 12015, 9581, 7125, 4649, 2186, -227, -2561, -4793, -6899, -8859, -10654, -12261, -13669, -14864, -15847, -16611, -17156, -17484, -17597, -17508, -17243, -16711, -16387, -17969, -17849, -16642, -15773, -14964, -14185, -13321, -12335, -11252, -10118, -8942, -7742, -6541, -5331, -4126, -2947, -1797, -696, 337, 1308, 2197, 2996, 3693, 4291, 4777, 5098, 5239, 5208, 5014, 4669, 4186, 3582, 2888, 2061, 1633, 1279, 319, -596, -1420, -2189, -2855, -3712, -5251, -5991, -6408, -6884, -7305, -7689, -7811, -7677, -7453, -7115, -6674, -6128, -5471, -4711, -3840, -2865, -1794, -611};