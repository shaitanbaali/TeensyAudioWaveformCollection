/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_granular_0008 256 samples */
 
const int16_t AKWF_granular_0008_256_DATA [256] = 
{1973, 5320, 8522, 11438, 13996, 16199, 18066, 19626, 20921, 21975, 22824, 23481, 23965, 24291, 23851, 27271, -14395, -30428, -28679, -30582, -31761, -32618, -32443, -31688, -30429, -28507, -25738, -21935, -16963, -10786, -3682, 3727, 10829, 16987, 21958, 25759, 28521, 30437, 31698, 32423, 32733, 32702, 32415, 31907, 31218, 29471, 33702, -9563, -35143, -30921, -32361, -32689, -32745, -32489, -31819, -30635, -28801, -26160, -22516, -17698, -11687, -4676, 2776, 9911, 16229, 21361, 25307, 28207, 30224, 31586, 32169, 31677, 30793, 29653, 28357, 26904, 24651, 27061, -1518, -26593, -22184, -22465, -21828, -21011, -19972, -18738, -17253, -15485, -13414, -11015, -8284, -5316, -2241, 653, 3082, 4862, 5959, 6457, 6483, 6161, 5596, 4873, 4040, 3158, 2248, 1354, 404, -38, 10, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -8, 24, -501, -1410, -2298, -3222, -4140, -5026, -5854, -6569, -7113, -7402, -7326, -6767, -5582, -3687, -1027};