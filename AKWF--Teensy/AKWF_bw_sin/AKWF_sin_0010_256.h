/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0010 256 samples */
 
const int16_t AKWF_sin_0010_256_DATA [256] = 
{737, 1808, 2858, 3908, 4954, 6000, 7043, 8079, 9111, 10139, 11145, 12121, 13068, 13981, 14869, 15727, 16554, 17357, 18132, 18878, 19601, 20297, 20968, 21617, 22241, 22840, 23418, 23973, 24507, 25020, 25513, 25985, 26438, 26872, 27287, 27683, 28062, 28424, 28770, 29098, 29410, 29707, 29987, 30253, 30505, 30741, 30964, 31172, 31366, 31548, 31715, 31870, 32013, 32142, 32259, 32363, 32456, 32536, 32605, 32661, 32706, 32738, 32759, 32768, 32765, 32752, 32726, 32688, 32638, 32577, 32504, 32418, 32320, 32210, 32089, 31954, 31806, 31646, 31472, 31284, 31085, 30870, 30642, 30399, 30142, 29869, 29582, 29278, 28960, 28625, 28272, 27903, 27516, 27112, 26688, 26247, 25786, 25305, 24804, 24281, 23739, 23175, 22587, 21978, 21343, 20685, 20003, 19296, 18562, 17805, 17018, 16204, 15365, 14494, 13594, 12668, 11709, 10718, 9702, 8672, 7637, 6599, 5554, 4507, 3460, 2407, 1354, 302, -752, -1805, -2857, -3909, -4955, -6001, -7044, -8080, -9112, -10139, -11145, -12122, -13068, -13982, -14869, -15727, -16555, -17358, -18132, -18879, -19601, -20298, -20969, -21617, -22241, -22841, -23418, -23973, -24507, -25021, -25513, -25985, -26438, -26872, -27287, -27683, -28063, -28424, -28770, -29098, -29410, -29707, -29988, -30254, -30505, -30741, -30964, -31172, -31366, -31548, -31715, -31871, -32013, -32142, -32259, -32363, -32456, -32536, -32605, -32661, -32706, -32738, -32759, -32768, -32765, -32752, -32726, -32688, -32638, -32577, -32504, -32418, -32320, -32210, -32089, -31954, -31806, -31646, -31472, -31284, -31085, -30870, -30642, -30399, -30142, -29869, -29583, -29278, -28960, -28625, -28272, -27903, -27516, -27112, -26689, -26247, -25786, -25305, -24804, -24282, -23739, -23175, -22587, -21978, -21344, -20685, -20003, -19297, -18563, -17806, -17018, -16205, -15365, -14495, -13595, -12669, -11709, -10719, -9703, -8672, -7638, -6600, -5555, -4508, -3461, -2409, -1360, -288};