/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0007 256 samples */
 
const int16_t AKWF_sin_0007_256_DATA [256] = 
{672, 1648, 2603, 3561, 4514, 5467, 6417, 7361, 8301, 9238, 10167, 11092, 12010, 12919, 13822, 14707, 15563, 16395, 17198, 17975, 18728, 19455, 20157, 20837, 21492, 22123, 22733, 23319, 23884, 24428, 24950, 25453, 25935, 26398, 26841, 27266, 27672, 28060, 28432, 28784, 29121, 29441, 29744, 30031, 30303, 30559, 30800, 31027, 31239, 31435, 31618, 31787, 31942, 32083, 32210, 32326, 32426, 32514, 32589, 32649, 32698, 32733, 32756, 32767, 32764, 32748, 32720, 32679, 32625, 32558, 32477, 32385, 32278, 32157, 32025, 31878, 31717, 31542, 31353, 31150, 30932, 30699, 30452, 30189, 29911, 29617, 29306, 28979, 28636, 28276, 27896, 27501, 27087, 26654, 26203, 25732, 25240, 24730, 24199, 23646, 23071, 22476, 21856, 21216, 20550, 19860, 19148, 18411, 17646, 16859, 16044, 15200, 14333, 13438, 12531, 11620, 10698, 9771, 8839, 7901, 6958, 6013, 5060, 4108, 3152, 2193, 1234, 275, -686, -1645, -2603, -3562, -4515, -5467, -6418, -7362, -8302, -9239, -10168, -11093, -12011, -12919, -13822, -14708, -15563, -16395, -17199, -17976, -18729, -19456, -20157, -20837, -21493, -22124, -22733, -23319, -23884, -24429, -24950, -25453, -25936, -26398, -26841, -27266, -27672, -28060, -28432, -28785, -29121, -29441, -29744, -30031, -30303, -30559, -30800, -31027, -31239, -31435, -31618, -31787, -31942, -32083, -32210, -32326, -32426, -32514, -32589, -32649, -32698, -32733, -32756, -32767, -32764, -32748, -32720, -32679, -32625, -32558, -32477, -32385, -32278, -32157, -32025, -31878, -31717, -31542, -31353, -31150, -30932, -30699, -30452, -30189, -29911, -29617, -29307, -28979, -28636, -28276, -27897, -27501, -27087, -26654, -26203, -25732, -25240, -24730, -24199, -23646, -23071, -22476, -21857, -21216, -20550, -19861, -19148, -18411, -17647, -16859, -16044, -15201, -14334, -13439, -12532, -11621, -10699, -9772, -8840, -7902, -6959, -6014, -5061, -4108, -3153, -2196, -1239, -263};