/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0001 256 samples */
 
const int16_t AKWF_sin_0001_256_DATA [256] = 
{492, 1309, 2109, 2910, 3708, 4505, 5300, 6090, 6878, 7662, 8440, 9213, 9983, 10744, 11499, 12249, 12989, 13722, 14449, 15165, 15873, 16572, 17258, 17936, 18604, 19259, 19903, 20536, 21155, 21762, 22356, 22936, 23504, 24056, 24593, 25117, 25626, 26119, 26597, 27058, 27502, 27931, 28342, 28737, 29115, 29474, 29816, 30141, 30447, 30735, 31004, 31254, 31486, 31700, 31893, 32068, 32224, 32360, 32476, 32574, 32652, 32709, 32748, 32766, 32765, 32744, 32704, 32644, 32564, 32465, 32346, 32208, 32050, 31873, 31677, 31462, 31227, 30976, 30704, 30413, 30106, 29780, 29435, 29074, 28695, 28298, 27885, 27454, 27008, 26545, 26066, 25571, 25061, 24535, 23996, 23443, 22873, 22292, 21697, 21087, 20467, 19833, 19187, 18531, 17863, 17183, 16495, 15796, 15086, 14370, 13643, 12908, 12167, 11417, 10660, 9898, 9129, 8354, 7576, 6792, 6004, 5213, 4417, 3620, 2822, 2019, 1217, 415, -389, -1191, -1993, -2795, -3594, -4391, -5187, -5977, -6765, -7550, -8328, -9103, -9873, -10634, -11392, -12142, -12884, -13619, -14346, -15062, -15773, -16472, -17160, -17840, -18509, -19165, -19812, -20446, -21066, -21676, -22272, -22854, -23424, -23978, -24518, -25044, -25554, -26049, -26529, -26992, -27440, -27871, -28284, -28681, -29062, -29423, -29769, -30096, -30404, -30695, -30967, -31219, -31454, -31670, -31866, -32044, -32202, -32342, -32461, -32561, -32641, -32702, -32743, -32764, -32766, -32748, -32711, -32653, -32576, -32480, -32364, -32229, -32074, -31899, -31707, -31494, -31262, -31013, -30744, -30456, -30151, -29827, -29486, -29127, -28750, -28355, -27944, -27517, -27072, -26612, -26134, -25643, -25136, -24611, -24075, -23522, -22955, -22376, -21783, -21175, -20556, -19925, -19280, -18625, -17959, -17281, -16595, -15896, -15188, -14473, -13747, -13014, -12274, -11524, -10768, -10008, -9240, -8465, -7689, -6905, -6117, -5327, -4532, -3735, -2936, -2136, -1337, -520};