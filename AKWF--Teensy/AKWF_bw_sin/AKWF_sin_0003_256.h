/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0003 256 samples */
 
const int16_t AKWF_sin_0003_256_DATA [256] = 
{141, 809, 1535, 2250, 2966, 3690, 4415, 5141, 5866, 6595, 7325, 8057, 8792, 9522, 10253, 10988, 11719, 12452, 13183, 13906, 14631, 15354, 16072, 16787, 17495, 18192, 18888, 19574, 20250, 20918, 21569, 22208, 22837, 23448, 24041, 24613, 25160, 25692, 26203, 26691, 27156, 27597, 28016, 28416, 28795, 29152, 29491, 29809, 30110, 30395, 30662, 30914, 31148, 31366, 31570, 31760, 31932, 32088, 32232, 32358, 32469, 32563, 32638, 32698, 32739, 32763, 32768, 32752, 32716, 32660, 32584, 32487, 32367, 32226, 32063, 31877, 31666, 31435, 31179, 30903, 30602, 30277, 29930, 29560, 29169, 28757, 28320, 27863, 27385, 26887, 26371, 25834, 25279, 24705, 24115, 23510, 22890, 22254, 21605, 20941, 20266, 19583, 18887, 18183, 17469, 16747, 16020, 15288, 14549, 13807, 13061, 12315, 11565, 10813, 10060, 9308, 8557, 7810, 7062, 6315, 5572, 4830, 4097, 3369, 2652, 1951, 1235, 516, -199, -917, -1634, -2352, -3073, -3792, -4518, -5243, -5972, -6703, -7431, -8160, -8895, -9627, -10361, -11095, -11823, -12555, -13285, -14012, -14738, -15458, -16172, -16887, -17595, -18295, -18989, -19670, -20344, -21009, -21662, -22300, -22923, -23532, -24122, -24691, -25240, -25765, -26273, -26756, -27218, -27659, -28074, -28469, -28845, -29200, -29536, -29853, -30150, -30432, -30697, -30946, -31179, -31396, -31597, -31784, -31955, -32110, -32250, -32375, -32482, -32573, -32648, -32704, -32743, -32764, -32766, -32747, -32709, -32650, -32570, -32470, -32347, -32202, -32036, -31846, -31635, -31399, -31141, -30860, -30555, -30228, -29879, -29506, -29110, -28693, -28258, -27796, -27315, -26815, -26293, -25756, -25199, -24621, -24030, -23422, -22797, -22163, -21512, -20846, -20170, -19482, -18786, -18082, -17367, -16643, -15916, -15181, -14445, -13702, -12955, -12206, -11455, -10705, -9954, -9202, -8449, -7700, -6953, -6211, -5468, -4727, -3991, -3262, -2551, -1853, -1136, -402};