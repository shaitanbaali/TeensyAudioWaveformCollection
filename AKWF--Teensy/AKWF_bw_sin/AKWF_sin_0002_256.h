/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0002 256 samples */
 
const int16_t AKWF_sin_0002_256_DATA [256] = 
{550, 1383, 2202, 3027, 3854, 4675, 5504, 6330, 7157, 7983, 8803, 9620, 10439, 11249, 12056, 12858, 13646, 14432, 15211, 15977, 16735, 17482, 18211, 18935, 19644, 20337, 21018, 21679, 22324, 22956, 23568, 24161, 24736, 25292, 25830, 26348, 26844, 27319, 27775, 28210, 28624, 29018, 29389, 29739, 30070, 30379, 30668, 30938, 31185, 31416, 31626, 31816, 31987, 32142, 32277, 32395, 32497, 32582, 32650, 32702, 32739, 32761, 32767, 32758, 32736, 32699, 32648, 32582, 32503, 32408, 32299, 32175, 32037, 31882, 31711, 31524, 31320, 31095, 30850, 30583, 30293, 29982, 29647, 29291, 28911, 28510, 28090, 27648, 27184, 26703, 26201, 25686, 25153, 24602, 24035, 23456, 22861, 22259, 21638, 21007, 20368, 19715, 19056, 18387, 17707, 17018, 16325, 15621, 14913, 14197, 13472, 12741, 12004, 11261, 10513, 9759, 8997, 8230, 7458, 6684, 5901, 5114, 4320, 3521, 2722, 1918, 1106, 293, -525, -1344, -2161, -2988, -3813, -4641, -5466, -6290, -7118, -7944, -8765, -9586, -10399, -11210, -12017, -12818, -13612, -14396, -15173, -15940, -16699, -17447, -18181, -18900, -19610, -20304, -20985, -21650, -22296, -22924, -23538, -24134, -24711, -25268, -25803, -26323, -26821, -27298, -27755, -28190, -28603, -28999, -29372, -29724, -30056, -30364, -30654, -30925, -31175, -31405, -31616, -31806, -31979, -32135, -32272, -32391, -32492, -32578, -32646, -32700, -32737, -32760, -32767, -32760, -32738, -32700, -32650, -32586, -32506, -32413, -32304, -32182, -32044, -31890, -31720, -31533, -31328, -31106, -30862, -30596, -30307, -29996, -29662, -29309, -28929, -28529, -28110, -27666, -27206, -26728, -26227, -25709, -25176, -24625, -24064, -23484, -22890, -22285, -21666, -21037, -20398, -19746, -19085, -18416, -17737, -17052, -16358, -15656, -14944, -14231, -13507, -12776, -12040, -11296, -10547, -9796, -9034, -8266, -7496, -6716, -5937, -5151, -4357, -3560, -2759, -1952, -1153, -309};