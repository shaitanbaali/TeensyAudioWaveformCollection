/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0012 256 samples */
 
const int16_t AKWF_sin_0012_256_DATA [256] = 
{422, 1291, 2142, 2997, 3852, 4699, 5548, 6389, 7224, 8056, 8880, 9698, 10510, 11310, 12105, 12888, 13659, 14425, 15178, 15916, 16647, 17362, 18064, 18754, 19430, 20090, 20737, 21368, 21985, 22584, 23170, 23737, 24291, 24827, 25345, 25847, 26331, 26797, 27250, 27682, 28095, 28494, 28873, 29234, 29580, 29906, 30214, 30506, 30780, 31038, 31274, 31494, 31698, 31882, 32050, 32200, 32331, 32445, 32542, 32622, 32684, 32729, 32757, 32768, 32761, 32740, 32702, 32645, 32569, 32476, 32367, 32240, 32096, 31935, 31758, 31564, 31352, 31123, 30875, 30613, 30332, 30034, 29721, 29389, 29040, 28676, 28294, 27892, 27476, 27044, 26594, 26128, 25645, 25144, 24628, 24098, 23549, 22986, 22407, 21812, 21202, 20578, 19939, 19286, 18616, 17935, 17241, 16534, 15813, 15081, 14337, 13583, 12817, 12041, 11255, 10461, 9657, 8845, 8026, 7200, 6370, 5532, 4688, 3844, 2996, 2139, 1286, 430, -429, -1285, -2137, -2993, -3845, -4692, -5541, -6382, -7217, -8049, -8873, -9691, -10503, -11303, -12097, -12881, -13652, -14417, -15169, -15909, -16639, -17354, -18056, -18746, -19422, -20082, -20729, -21361, -21977, -22577, -23161, -23729, -24283, -24819, -25338, -25840, -26323, -26790, -27243, -27674, -28087, -28487, -28865, -29227, -29573, -29899, -30206, -30499, -30771, -31029, -31266, -31487, -31689, -31874, -32041, -32193, -32323, -32437, -32535, -32615, -32676, -32721, -32749, -32762, -32755, -32732, -32695, -32637, -32561, -32469, -32358, -32232, -32088, -31927, -31750, -31555, -31344, -31114, -30867, -30604, -30325, -30027, -29713, -29382, -29033, -28668, -28286, -27884, -27468, -27037, -26586, -26119, -25637, -25136, -24621, -24090, -23541, -22978, -22400, -21804, -21194, -20570, -19932, -19279, -18609, -17927, -17233, -16526, -15806, -15074, -14331, -13575, -12810, -12034, -11247, -10454, -9650, -8837, -8019, -7192, -6361, -5524, -4680, -3836, -2989, -2135, -1283, -413};