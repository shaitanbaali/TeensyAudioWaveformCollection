/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0005 256 samples */
 
const int16_t AKWF_sin_0005_256_DATA [256] = 
{438, 1238, 2017, 2788, 3559, 4328, 5095, 5863, 6629, 7398, 8169, 8934, 9698, 10458, 11212, 11962, 12700, 13431, 14151, 14857, 15553, 16237, 16904, 17559, 18201, 18828, 19442, 20043, 20630, 21207, 21766, 22316, 22858, 23381, 23894, 24397, 24888, 25363, 25828, 26279, 26718, 27144, 27554, 27950, 28333, 28702, 29053, 29391, 29714, 30022, 30314, 30589, 30850, 31095, 31321, 31534, 31734, 31911, 32073, 32221, 32350, 32463, 32559, 32636, 32696, 32737, 32760, 32768, 32751, 32716, 32665, 32590, 32498, 32384, 32248, 32094, 31915, 31715, 31492, 31250, 30982, 30694, 30379, 30042, 29684, 29297, 28888, 28451, 27993, 27513, 26997, 26457, 25897, 25313, 24693, 24048, 23377, 22684, 21960, 21203, 20427, 19629, 18969, 18544, 18111, 17589, 17078, 16563, 16000, 15392, 14737, 14033, 13280, 12489, 11664, 10806, 9918, 9022, 8120, 7212, 6308, 5413, 4532, 3664, 2811, 1973, 1152, 346, -450, -1235, -2017, -2789, -3560, -4329, -5096, -5864, -6630, -7399, -8169, -8935, -9698, -10459, -11213, -11962, -12701, -13431, -14152, -14857, -15553, -16238, -16904, -17559, -18201, -18828, -19443, -20044, -20631, -21208, -21767, -22316, -22858, -23382, -23895, -24397, -24888, -25363, -25828, -26279, -26718, -27144, -27554, -27950, -28333, -28702, -29053, -29391, -29715, -30022, -30314, -30589, -30850, -31095, -31321, -31534, -31734, -31911, -32073, -32221, -32350, -32463, -32559, -32636, -32696, -32737, -32760, -32768, -32751, -32716, -32665, -32590, -32498, -32384, -32247, -32094, -31915, -31715, -31492, -31250, -30982, -30694, -30379, -30043, -29684, -29297, -28889, -28451, -27993, -27513, -26997, -26457, -25898, -25313, -24694, -24048, -23377, -22685, -21960, -21204, -20428, -19629, -18970, -18545, -18111, -17590, -17079, -16563, -16001, -15393, -14737, -14033, -13280, -12490, -11664, -10806, -9919, -9023, -8120, -7212, -6309, -5414, -4533, -3665, -2812, -1976, -1156, -337};