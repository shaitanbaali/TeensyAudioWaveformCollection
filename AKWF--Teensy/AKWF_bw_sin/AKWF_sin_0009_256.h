/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0009 256 samples */
 
const int16_t AKWF_sin_0009_256_DATA [256] = 
{222, 1050, 1860, 2672, 3482, 4289, 5097, 5898, 6697, 7493, 8283, 9068, 9849, 10622, 11390, 12151, 12904, 13650, 14389, 15116, 15837, 16547, 17246, 17937, 18617, 19283, 19940, 20584, 21216, 21836, 22441, 23033, 23613, 24176, 24725, 25261, 25780, 26284, 26773, 27245, 27700, 28140, 28562, 28966, 29354, 29719, 30058, 30376, 30669, 30941, 31192, 31421, 31631, 31822, 31994, 32148, 32284, 32402, 32503, 32589, 32657, 32709, 32745, 32764, 32767, 32755, 32726, 32681, 32620, 32542, 32447, 32337, 32208, 32062, 31898, 31715, 31513, 31292, 31051, 30788, 30504, 30196, 29867, 29513, 29134, 28736, 28322, 27889, 27441, 26977, 26495, 25997, 25485, 24956, 24412, 23855, 23282, 22696, 22096, 21482, 20855, 20216, 19565, 18903, 18229, 17542, 16847, 16141, 15425, 14701, 13966, 13223, 12474, 11715, 10950, 10180, 9402, 8618, 7831, 7037, 6240, 5440, 4633, 3827, 3018, 2205, 1393, 580, -234, -1047, -1860, -2673, -3483, -4290, -5097, -5899, -6698, -7493, -8283, -9069, -9850, -10622, -11391, -12152, -12904, -13651, -14389, -15117, -15837, -16547, -17246, -17937, -18617, -19283, -19941, -20584, -21216, -21836, -22441, -23034, -23613, -24177, -24726, -25262, -25780, -26284, -26774, -27245, -27700, -28140, -28562, -28966, -29354, -29719, -30058, -30376, -30669, -30941, -31192, -31421, -31631, -31822, -31994, -32148, -32284, -32402, -32503, -32589, -32657, -32709, -32745, -32764, -32767, -32755, -32726, -32681, -32620, -32542, -32447, -32337, -32208, -32062, -31898, -31715, -31513, -31292, -31051, -30788, -30504, -30197, -29867, -29513, -29134, -28736, -28323, -27889, -27442, -26977, -26495, -25997, -25485, -24956, -24413, -23856, -23282, -22696, -22096, -21482, -20856, -20217, -19565, -18903, -18229, -17542, -16847, -16141, -15425, -14701, -13967, -13224, -12474, -11716, -10951, -10181, -9402, -8619, -7831, -7037, -6241, -5440, -4634, -3827, -3019, -2208, -1398, -570};