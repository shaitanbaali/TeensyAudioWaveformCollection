/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0004 256 samples */
 
const int16_t AKWF_sin_0004_256_DATA [256] = 
{551, 1191, 2467, 3145, 4032, 4914, 5787, 6644, 7490, 8327, 9155, 9975, 10788, 11589, 12383, 13166, 13940, 14702, 15453, 16190, 16916, 17630, 18327, 19013, 19685, 20339, 20984, 21611, 22223, 22822, 23404, 23971, 24535, 25018, 25573, 26053, 26526, 26988, 27433, 27858, 28265, 28655, 29027, 29383, 29722, 30041, 30344, 30631, 30897, 31147, 31379, 31592, 31789, 31968, 32127, 32270, 32395, 32500, 32590, 32661, 32713, 32749, 32766, 32766, 32750, 32715, 32661, 32591, 32505, 32400, 32278, 32140, 31984, 31811, 31621, 31413, 31191, 30951, 30695, 30420, 30131, 29826, 29502, 29165, 28811, 28440, 28056, 27655, 27237, 26806, 26359, 25897, 25422, 24929, 24425, 23858, 23363, 22781, 22209, 21626, 21025, 20412, 19782, 19141, 18485, 17817, 17139, 16448, 15742, 15028, 14302, 13563, 12816, 12056, 11286, 10507, 9718, 8920, 8114, 7297, 6474, 5644, 4802, 3955, 3099, 2228, 1393, 232, -518, -1201, -2463, -3146, -4033, -4915, -5788, -6645, -7491, -8328, -9156, -9976, -10789, -11589, -12383, -13167, -13940, -14703, -15454, -16191, -16916, -17630, -18328, -19014, -19685, -20340, -20984, -21611, -22223, -22822, -23404, -23972, -24535, -25018, -25574, -26053, -26526, -26989, -27433, -27858, -28265, -28655, -29027, -29383, -29722, -30041, -30344, -30631, -30897, -31147, -31379, -31592, -31789, -31968, -32127, -32270, -32395, -32500, -32590, -32661, -32713, -32749, -32766, -32766, -32750, -32715, -32661, -32591, -32505, -32400, -32278, -32140, -31984, -31811, -31621, -31413, -31191, -30951, -30695, -30420, -30131, -29826, -29502, -29165, -28811, -28441, -28056, -27655, -27237, -26806, -26359, -25897, -25422, -24929, -24425, -23858, -23364, -22781, -22210, -21626, -21025, -20412, -19783, -19141, -18486, -17818, -17139, -16448, -15743, -15029, -14302, -13563, -12816, -12056, -11287, -10508, -9719, -8920, -8115, -7298, -6475, -5644, -4803, -3956, -3100, -2234, -1358, -403};