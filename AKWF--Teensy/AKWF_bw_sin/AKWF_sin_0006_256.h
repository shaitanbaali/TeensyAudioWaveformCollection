/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0006 256 samples */
 
const int16_t AKWF_sin_0006_256_DATA [256] = 
{344, 1224, 2090, 2965, 3842, 4722, 5607, 6489, 7372, 8255, 9132, 10011, 10883, 11749, 12611, 13465, 14308, 15143, 15969, 16782, 17585, 18374, 19147, 19907, 20650, 21376, 22086, 22775, 23445, 24097, 24726, 25335, 25923, 26487, 27028, 27546, 28040, 28511, 28956, 29376, 29774, 30145, 30490, 30811, 31107, 31378, 31623, 31845, 32042, 32213, 32361, 32486, 32587, 32665, 32722, 32756, 32767, 32759, 32731, 32683, 32616, 32530, 32426, 32305, 32167, 32013, 31844, 31660, 31462, 31250, 31025, 30788, 30539, 30276, 30004, 29721, 29427, 29123, 28809, 28486, 28153, 27812, 27460, 27101, 26733, 26354, 25969, 25573, 25169, 24756, 24332, 23900, 23459, 23006, 22545, 22072, 21588, 21094, 20589, 20072, 19544, 19003, 18449, 17884, 17307, 16714, 16112, 15493, 14861, 14219, 13561, 12889, 12204, 11506, 10795, 10071, 9332, 8583, 7822, 7046, 6260, 5465, 4656, 3838, 3012, 2175, 1330, 479, -380, -1244, -2114, -2989, -3867, -4748, -5632, -6513, -7396, -8280, -9158, -10035, -10908, -11773, -12635, -13490, -14333, -15167, -15992, -16804, -17606, -18396, -19168, -19929, -20671, -21396, -22105, -22794, -23464, -24115, -24744, -25351, -25938, -26502, -27042, -27560, -28053, -28523, -28968, -29388, -29784, -30155, -30499, -30820, -31116, -31384, -31630, -31850, -32046, -32217, -32364, -32488, -32589, -32667, -32723, -32756, -32768, -32760, -32730, -32681, -32613, -32527, -32424, -32301, -32163, -32009, -31840, -31655, -31457, -31245, -31019, -30781, -30531, -30269, -29997, -29713, -29418, -29114, -28800, -28477, -28144, -27802, -27451, -27091, -26723, -26345, -25959, -25562, -25158, -24745, -24321, -23889, -23447, -22994, -22532, -22059, -21575, -21082, -20575, -20058, -19530, -18989, -18434, -17870, -17290, -16699, -16095, -15477, -14845, -14202, -13542, -12871, -12186, -11488, -10776, -10051, -9313, -8563, -7802, -7026, -6240, -5444, -4634, -3817, -2990, -2153, -1313, -445};