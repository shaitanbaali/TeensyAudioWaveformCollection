/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0008 256 samples */
 
const int16_t AKWF_sin_0008_256_DATA [256] = 
{617, 1514, 2391, 3272, 4148, 5022, 5896, 6763, 7627, 8488, 9342, 10191, 11035, 11869, 12698, 13521, 14333, 15138, 15934, 16719, 17495, 18260, 19013, 19758, 20488, 21205, 21900, 22566, 23202, 23812, 24396, 24954, 25488, 25998, 26483, 26947, 27388, 27809, 28210, 28589, 28949, 29290, 29613, 29918, 30205, 30475, 30728, 30966, 31186, 31392, 31582, 31757, 31918, 32063, 32195, 32314, 32418, 32507, 32584, 32648, 32697, 32734, 32758, 32767, 32765, 32749, 32720, 32678, 32622, 32553, 32471, 32375, 32265, 32141, 32003, 31851, 31684, 31503, 31306, 31094, 30867, 30622, 30362, 30085, 29790, 29477, 29147, 28798, 28429, 28042, 27632, 27203, 26752, 26279, 25783, 25263, 24719, 24150, 23555, 22933, 22285, 21608, 20901, 20178, 19442, 18693, 17935, 17165, 16385, 15596, 14796, 13987, 13171, 12346, 11513, 10676, 9829, 8978, 8121, 7259, 6393, 5524, 4649, 3774, 2896, 2014, 1134, 253, -630, -1511, -2391, -3273, -4148, -5023, -5897, -6764, -7627, -8489, -9342, -10192, -11035, -11870, -12699, -13521, -14333, -15139, -15935, -16719, -17495, -18260, -19013, -19758, -20489, -21206, -21901, -22566, -23202, -23812, -24396, -24954, -25488, -25998, -26483, -26947, -27389, -27809, -28210, -28589, -28949, -29291, -29613, -29918, -30205, -30475, -30728, -30966, -31186, -31392, -31582, -31757, -31918, -32063, -32195, -32314, -32418, -32507, -32584, -32648, -32697, -32734, -32758, -32767, -32765, -32749, -32720, -32678, -32622, -32553, -32471, -32375, -32265, -32141, -32003, -31851, -31684, -31503, -31306, -31094, -30867, -30622, -30362, -30085, -29790, -29477, -29147, -28798, -28429, -28042, -27632, -27203, -26752, -26279, -25783, -25264, -24719, -24150, -23556, -22934, -22285, -21608, -20901, -20179, -19442, -18693, -17935, -17166, -16385, -15596, -14796, -13987, -13172, -12346, -11514, -10677, -9830, -8978, -8122, -7260, -6394, -5525, -4650, -3775, -2897, -2017, -1139, -242};