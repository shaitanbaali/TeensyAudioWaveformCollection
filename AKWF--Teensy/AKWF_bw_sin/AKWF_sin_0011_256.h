/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin_0011 256 samples */
 
const int16_t AKWF_sin_0011_256_DATA [256] = 
{483, 1397, 2291, 3182, 4065, 4948, 5828, 6702, 7570, 8434, 9288, 10134, 10972, 11799, 12616, 13421, 14213, 14991, 15752, 16501, 17240, 17964, 18671, 19367, 20047, 20708, 21357, 21988, 22601, 23198, 23778, 24334, 24875, 25401, 25911, 26401, 26876, 27334, 27773, 28194, 28600, 28987, 29354, 29707, 30040, 30351, 30651, 30932, 31194, 31441, 31674, 31886, 32082, 32257, 32393, 32492, 32566, 32620, 32660, 32689, 32712, 32728, 32739, 32748, 32755, 32759, 32763, 32765, 32764, 32736, 32681, 32594, 32481, 32350, 32198, 32021, 31829, 31621, 31388, 31138, 30875, 30592, 30288, 29971, 29636, 29282, 28912, 28525, 28117, 27692, 27250, 26791, 26311, 25815, 25304, 24772, 24221, 23656, 23077, 22477, 21864, 21234, 20582, 19917, 19236, 18537, 17823, 17096, 16353, 15596, 14824, 14043, 13253, 12448, 11633, 10807, 9968, 9120, 8266, 7399, 6527, 5651, 4766, 3877, 2986, 2096, 1206, 312, -583, -1479, -2374, -3269, -4158, -5045, -5928, -6803, -7674, -8539, -9390, -10231, -11063, -11886, -12701, -13503, -14294, -15075, -15841, -16592, -17334, -18059, -18766, -19463, -20139, -20794, -21438, -22067, -22677, -23272, -23852, -24413, -24957, -25484, -25996, -26487, -26960, -27419, -27855, -28271, -28674, -29059, -29424, -29775, -30110, -30424, -30723, -31007, -31270, -31516, -31749, -31962, -32154, -32317, -32435, -32524, -32589, -32637, -32673, -32699, -32719, -32733, -32743, -32751, -32757, -32761, -32764, -32766, -32768, -32756, -32713, -32638, -32533, -32406, -32259, -32086, -31894, -31687, -31459, -31210, -30948, -30668, -30365, -30047, -29714, -29360, -28987, -28599, -28194, -27767, -27324, -26868, -26391, -25896, -25388, -24859, -24309, -23745, -23165, -22563, -21946, -21316, -20664, -19996, -19316, -18621, -17912, -17187, -16448, -15694, -14924, -14142, -13350, -12540, -11722, -10896, -10054, -9204, -8350, -7490, -6623, -5750, -4869, -3981, -3092, -2199, -1306, -391};