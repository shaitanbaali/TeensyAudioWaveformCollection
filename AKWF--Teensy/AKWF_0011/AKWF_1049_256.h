/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1049 256 samples */
 
const int16_t AKWF_1049_256_DATA [256] = 
{2236, 2584, 2928, 3269, 3612, 3955, 4299, 4640, 4983, 5326, 5667, 6008, 6351, 6692, 7034, 7375, 7715, 8057, 8398, 8738, 9078, 9420, 9758, 10100, 10441, 10779, 11119, 11458, 11798, 12138, 12477, 12816, 13156, 13495, 13835, 14172, 14512, 14851, 15189, 15527, 15865, 16204, 16541, 16880, 17218, 17555, 17893, 18231, 18568, 18905, 19242, 19579, 19918, 20254, 20590, 20927, 21264, 21600, 21937, 22273, 22609, 22946, 23282, 23617, 23953, 24289, 24624, 24960, 25294, 25631, 25966, 26300, 26635, 26972, 27305, 27640, 27975, 28308, 28643, 28978, 29312, 29646, 29981, 30315, 30650, 30984, 31316, 31629, 32094, 29802, 28472, 27896, 27158, 26441, 25725, 25010, 24293, 23577, 22862, 22146, 21431, 20716, 20000, 19285, 18571, 17855, 17142, 16427, 15712, 14999, 14284, 13569, 12858, 12142, 11429, 10717, 10003, 9290, 8579, 7866, 7153, 6442, 5729, 5017, 4307, 3594, 2883, 2173, 1462, 751, 42, -669, -1378, -2087, -2798, -3508, -4217, -4926, -5634, -6344, -7053, -7760, -8468, -9177, -9884, -10592, -11299, -12006, -12714, -13421, -14126, -14833, -15540, -16245, -16952, -17658, -18362, -19069, -19773, -20477, -21183, -21889, -22592, -23297, -24000, -24703, -25408, -26111, -26813, -27518, -28267, -28703, -31516, -32695, -32046, -31756, -31409, -31060, -30712, -30364, -30016, -29667, -29320, -28970, -28621, -28273, -27925, -27576, -27227, -26879, -26530, -26182, -25833, -25485, -25137, -24788, -24441, -24092, -23743, -23396, -23048, -22700, -22352, -22004, -21656, -21309, -20961, -20614, -20267, -19920, -19572, -19225, -18878, -18531, -18185, -17837, -17491, -17144, -16797, -16451, -16105, -15758, -15413, -15066, -14719, -14374, -14029, -13682, -13337, -12991, -12646, -12301, -11955, -11611, -11266, -10920, -10575, -10231, -9886, -9541, -9198, -8853, -8508, -8164, -7819, -7476, -7133, -6787, -6443, -6101, -5756, -5413, -5069, -4726, -4384, -4035};