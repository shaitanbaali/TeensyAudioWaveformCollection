/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1044 256 samples */
 
const int16_t AKWF_1044_256_DATA [256] = 
{11913, 11815, 11718, 11621, 11524, 11426, 11328, 11230, 11132, 11033, 10934, 10836, 10736, 10637, 10538, 10439, 10338, 10239, 10139, 10041, 9940, 9840, 9741, 9641, 9541, 9440, 9341, 9240, 9140, 9041, 8940, 8841, 8740, 8640, 8542, 8439, 8341, 8240, 8141, 8041, 7940, 7842, 7740, 7642, 7541, 7442, 7342, 7242, 7142, 7043, 6943, 6843, 6743, 6644, 6544, 6444, 6344, 6246, 6145, 6046, 5947, 5847, 5748, 5648, 5549, 5450, 5350, 5251, 5151, 5052, 4953, 4854, 4755, 4655, 4556, 4458, 4359, 4260, 4160, 4062, 3963, 3864, 3764, 3666, 3567, 3468, 3369, 3270, 3171, 3073, 2974, 2875, 2777, 2678, 2580, 2481, 2383, 2284, 2185, 2087, 1988, 1891, 1582, 2605, -3817, -11056, -10013, -10323, -10419, -10515, -10612, -10706, -10803, -10899, -10994, -11088, -11183, -11278, -11372, -11467, -11562, -11656, -11751, -11846, -11941, -12036, -12128, -12222, -12317, -12412, -12504, -12599, -12694, -12786, -12880, -12975, -13068, -13162, -13254, -13349, -13443, -13535, -13630, -13723, -13816, -13770, -14615, -10902, -4735, -5319, -4990, -4803, -4616, -4429, -4243, -4056, -3870, -3684, -3497, -3311, -3125, -2940, -2754, -2569, -2383, -2197, -2012, -1826, -1640, -1455, -1270, -1086, -900, -715, -530, -345, -160, 24, 209, 392, 578, 762, 947, 1131, 1317, 1499, 1684, 1869, 2052, 2237, 2421, 2604, 2789, 2973, 3156, 3339, 3524, 3709, 3892, 4075, 4258, 4441, 4624, 4810, 4994, 5176, 5360, 5543, 5726, 5910, 6093, 6276, 6457, 6640, 6823, 7006, 7189, 7372, 7555, 7736, 7919, 8103, 8286, 8467, 8649, 8833, 8900, 9660, 3861, -2215, -6050, -10446, -13900, -21591, -30151, -24230, -22993, -21849, -20637, -19443, -18254, -17059, -15865, -14675, -13480, -12288, -11097, -9901, -8710, -7517, -6323, -5131, -3940, -2748, -1560, -348};