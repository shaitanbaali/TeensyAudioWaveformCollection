/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1065 256 samples */
 
const int16_t AKWF_1065_256_DATA [256] = 
{32094, 32186, 32287, 32393, 32498, 32593, 32672, 32730, 32762, 32767, 32745, 32701, 32638, 32561, 32463, 32356, 32241, 32118, 31987, 31847, 31699, 31542, 31378, 31204, 31023, 30833, 30634, 30428, 30213, 29989, 29758, 29520, 29272, 29017, 28753, 28482, 28203, 27916, 27622, 27322, 27013, 26698, 26376, 26047, 25712, 25372, 25023, 24670, 24311, 23945, 23576, 23200, 22819, 22435, 22047, 21652, 21255, 20854, 20449, 20041, 19631, 19217, 18801, 18384, 17964, 17543, 17120, 16696, 16272, 15847, 15422, 14998, 14574, 14150, 13728, 13307, 12888, 12471, 12055, 11643, 11233, 10826, 10423, 10024, 9628, 9237, 8851, 8469, 8093, 7723, 7358, 6998, 6646, 6299, 5960, 5629, 5303, 4986, 4677, 4376, 4083, 3798, 3522, 3256, 2999, 2751, 2512, 2284, 2065, 1857, 1659, 1471, 1294, 1128, 973, 829, 696, 574, 465, 365, 279, 203, 139, 88, 47, -301, 1373, -7105, -32009, -31913, -31814, -31875, -31857, -31834, -31805, -31770, -31727, -31677, -31621, -31555, -31483, -31403, -31314, -31218, -31113, -31000, -30877, -30748, -30609, -30462, -30307, -30142, -29969, -29788, -29598, -29400, -29193, -28978, -28754, -28523, -28283, -28036, -27780, -27516, -27245, -26966, -26679, -26386, -26086, -25777, -25464, -25142, -24814, -24481, -24141, -23794, -23444, -23087, -22725, -22359, -21986, -21610, -21230, -20846, -20457, -20065, -19670, -19272, -18871, -18468, -18063, -17656, -17247, -16837, -16425, -16013, -15601, -15189, -14776, -14364, -13952, -13542, -13134, -12725, -12319, -11917, -11515, -11116, -10721, -10329, -9940, -9556, -9175, -8799, -8428, -8061, -7700, -7345, -6995, -6651, -6313, -5981, -5657, -5340, -5030, -4727, -4432, -4145, -3866, -3595, -3333, -3081, -2836, -2600, -2374, -2158, -1950, -1753, -1566, -1389, -1221, -1064, -918, -782, -657, -542, -438, -345, -263, -192, -132, -83, -46, -19, -4, 0};