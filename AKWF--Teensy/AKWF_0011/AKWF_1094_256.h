/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1094 256 samples */
 
const int16_t AKWF_1094_256_DATA [256] = 
{499, 508, 511, 532, 756, 1448, 1476, 1565, 1909, 4417, 6381, 6570, 6610, 6635, 6726, 7226, 10082, 10950, 11193, 11509, 11919, 14903, 15477, 15459, 15447, 15896, 16090, 16038, 16112, 17064, 19685, 19677, 20041, 20114, 20140, 19913, 21062, 23532, 23297, 23341, 23341, 23387, 23359, 24933, 25320, 24752, 25041, 25133, 25220, 25006, 26731, 27704, 27556, 27663, 27657, 27679, 27671, 29434, 29948, 29840, 29882, 29894, 29859, 30020, 31479, 32309, 21056, 16844, 17749, 17628, 17690, 17722, 17580, 18646, 19366, 19225, 19345, 19450, 19451, 19459, 19578, 19633, 19615, 19837, 20930, 21122, 21194, 21345, 21376, 21437, 21608, 22401, 22784, 22677, 23328, 23839, 23791, 23831, 23851, 23989, 24366, 24347, 24372, 24496, 24978, 25834, 25938, 25949, 25959, 25916, 26344, 26701, 26836, 26909, 27431, 27950, 28459, 28400, 28420, 28383, 28548, 29189, 29191, 29149, 29758, 30047, 29948, 30242, 31163, 30370, 28772, 32957, -14523, -33504, -29295, -30084, -29415, -29250, -28907, -28411, -28474, -28461, -28420, -27777, -27684, -27735, -27202, -26847, -26915, -26763, -26245, -26249, -26176, -25562, -25363, -25369, -25156, -24789, -24858, -24585, -23959, -23892, -23816, -23803, -23710, -23477, -22994, -22695, -22690, -22665, -22385, -22252, -22336, -21537, -21060, -21007, -20888, -20852, -20804, -20781, -19686, -19431, -19473, -19400, -19349, -19293, -19249, -19250, -19123, -17832, -17665, -17699, -17772, -17060, -28303, -32519, -31599, -31744, -31848, -30424, -29877, -29957, -29914, -29918, -29885, -29817, -30001, -28494, -27608, -27451, -25372, -25221, -25191, -25147, -25355, -26410, -26423, -26416, -26145, -26332, -25064, -23339, -23430, -23150, -23170, -23135, -23294, -22541, -19752, -19996, -19306, -16567, -16258, -15779, -15674, -15692, -15680, -15699, -15277, -14924, -15248, -13239, -10872, -10724, -10210, -10252, -10171, -10402, -7684, -5769, -6038, -5978, -5343, -5038, -5162, -1953};