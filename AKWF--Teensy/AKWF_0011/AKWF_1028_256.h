/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1028 256 samples */
 
const int16_t AKWF_1028_256_DATA [256] = 
{1070, 3599, 6079, 8562, 11044, 13528, 16145, 17849, 25519, 30162, 28042, 27140, 26036, 24935, 23831, 22727, 21627, 20523, 19420, 18321, 17221, 16121, 15023, 13926, 12832, 11739, 10645, 9554, 8467, 7377, 6292, 5209, 4125, 3046, 1969, 892, -171, -1279, -1772, -1730, -1742, -1746, -1747, -1749, -1749, -1749, -1749, -1749, -1749, -1749, -1749, -1749, -1749, -1749, -1750, -1748, -1746, -1746, -1746, -1743, -1742, -1741, -1740, -1740, -1739, -1738, -1736, -1735, -1733, -1733, -1732, -1731, -1730, -1729, -1726, -1726, -1724, -1723, -1723, -1722, -1719, -1719, -1718, -1715, -1716, -1715, -1713, -1712, -1711, -1709, -1707, -1706, -1706, -1705, -1704, -1702, -1701, -1700, -1699, -1699, -1698, -1696, -1696, -1693, -1692, -1692, -1691, -1690, -1689, -1688, -1686, -1685, -1684, -1682, -1681, -1682, -1681, -1678, -1678, -1677, -1675, -1674, -1674, -1672, -1671, -1671, -1671, -1668, -1667, -1666, -1665, -1665, -1664, -1664, -1663, -1660, -1660, -1659, -1658, -1657, -1657, -1657, -1656, -1654, -1655, -1658, -1629, -2203, -3168, -4064, -4963, -5859, -6747, -7628, -8505, -9373, -10234, -11093, -11941, -12782, -13621, -14449, -15271, -16088, -16896, -17699, -18496, -19285, -20067, -20844, -21610, -22374, -23129, -23876, -24617, -25351, -26077, -26799, -27511, -28216, -28915, -29609, -30292, -30969, -31120, -34631, -17094, 1829, -829, 265, 753, 1254, 1747, 2236, 2717, 3192, 3662, 4126, 4586, 5037, 5484, 5925, 6357, 6787, 7210, 7625, 8036, 8440, 8839, 9232, 9619, 9999, 10375, 10745, 11107, 11464, 11815, 12160, 12501, 12862, 12709, 15786, 5287, -17325, -15377, -14402, -13858, -13196, -12558, -11932, -11316, -10717, -10131, -9558, -8999, -8453, -7921, -7403, -6897, -6404, -5928, -5463, -5013, -4575, -4151, -3742, -3346, -2964, -2594, -2239, -1897, -1569, -1257, -953, -644, -378};