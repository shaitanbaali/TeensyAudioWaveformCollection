/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1082 256 samples */
 
const int16_t AKWF_1082_256_DATA [256] = 
{991, 3369, 5699, 8036, 10370, 12706, 15046, 17380, 19717, 22049, 24407, 26197, 27369, 26438, 24973, 23616, 22241, 20861, 19482, 18106, 16727, 15349, 13973, 12593, 11215, 9839, 8459, 7081, 5705, 4325, 2935, 1624, -196, -2050, -3550, -5120, -6676, -8233, -9793, -11349, -12906, -14465, -16021, -17578, -19138, -20693, -22252, -23810, -25365, -26924, -28449, -30148, -30872, -29307, -27451, -27561, -18365, 2826, 2859, 4600, 6926, 5429, -6022, -2599, 544, 3673, 6824, 9980, 13128, 16280, 19421, 22632, 25434, 27056, 28626, 29810, 33741, 20194, -2725, -514, -1495, -1983, -2472, -2960, -3449, -3938, -4418, -4872, -5672, 3284, 3902, 1211, -743, -2786, -5121, -381, 2040, 3826, 385, -3907, -1275, 270, 1994, 3717, 5441, 7168, 8890, 10615, 12341, 14062, 15787, 17513, 19248, 20862, 23088, 24304, 22724, 22355, 3384, -3155, -3433, -4881, -7416, 1835, 4542, 739, -1728, -4400, -7079, -9752, -12426, -15106, -17778, -20438, -23182, -25281, -26629, -28233, -28303, -26722, -25311, -23874, -22433, -20992, -19554, -18113, -16672, -15235, -13794, -12177, -11685, -4330, 2183, 1935, -1286, 714, 3337, 5894, 7785, 8789, 9872, 10939, 12006, 13075, 14142, 15210, 16278, 17344, 18412, 19460, 20617, 21140, 20227, 18838, 1071, -3204, -3970, -6895, 1328, 4411, 538, -1948, -4645, -7351, -10053, -12751, -15456, -18157, -20856, -23552, -26291, -28780, -30421, -32189, -31956, -29664, -30660, -14675, 3804, 2551, 4456, 5566, 8595, 658, -6782, -2028, 690, 3734, 6771, 9815, 12859, 15896, 18923, 22046, 24229, 25529, 27051, 27962, 26678, 25241, 23846, 22436, 21029, 19622, 18147, 17077, 14404, 30, -1860, -2473, -3989, 1584, 1947, -1016, -3270, -5627, -8037, -10202, -11262, -12200, -13163, -14123, -15083, -16040, -16998, -17948, -18744, -19643, -13087, 2244, 2514, 3860, 6463, -265, -4666, -1052};