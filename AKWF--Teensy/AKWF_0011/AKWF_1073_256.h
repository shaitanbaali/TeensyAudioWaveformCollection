/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1073 256 samples */
 
const int16_t AKWF_1073_256_DATA [256] = 
{74, 271, 468, 674, 885, 1100, 1318, 1537, 1755, 1974, 2183, 2389, 2592, 2650, 3566, -2127, -5568, -4816, -4862, -4762, -4636, -4498, -4350, -4188, -4021, -3854, -3683, -3508, -3347, -3150, -3247, -3669, -4007, -4288, -4522, -4715, -4859, -4894, -5304, -3604, -645, -1617, -2056, -2692, -2622, 2437, 3443, 3401, 3610, 3788, 3973, 4165, 4362, 4562, 4767, 4974, 5179, 5382, 5584, 5780, 5968, 6156, 6332, 6498, 6662, 6808, 6942, 7075, 7196, 7303, 7397, 7486, 7565, 7625, 7682, 7731, 7765, 7794, 7820, 7833, 7837, 7846, 7850, 7843, 7838, 7835, 7826, 7815, 7812, 7809, 7802, 7803, 7810, 7815, 7824, 7846, 7870, 7891, 7927, 7968, 8006, 8060, 8121, 8177, 8244, 8320, 8396, 8473, 8564, 8658, 8745, 8845, 8950, 9050, 9152, 9262, 9372, 9473, 9585, 9697, 9798, 9904, 10015, 10119, 10108, 10808, 4825, 2080, 2728, 2699, 2740, 2907, 3238, -27652, -33847, -32036, -31806, -31040, -30005, -28760, -27294, -25624, -23816, -21867, -19779, -17616, -15246, -14172, -4890, -4210, -9462, -12698, -16201, -19622, -22867, -25758, -28143, -29941, -31175, -31955, -32253, -33289, -30154, -2558, 7327, 9926, 5729, 5646, 4056, 1581, 1396, 283, 1447, 7058, 6621, 6403, 6043, 5598, 5087, 4522, 3932, 3220, 3438, 4445, 5197, 5786, 6262, 6445, 7488, 1902, -1493, 606, 2667, -887, -9366, -6441, -4384, -4725, -1958, 3888, 2697, 2809, 2729, 2659, 2599, 2549, 2515, 2497, 2514, 2394, 3513, 4121, 3961, 3935, 3877, 3805, 3721, 3633, 3538, 3435, 3334, 3229, 3136, 3239, 3401, 3537, 3657, 3766, 3856, 3925, 3981, 3948, 4356, 2652, -3170, -2740, -2638, -2500, -2367, -2245, -2123, -2003, -1888, -1774, -1658, -1542, -1426, -1304, -1176, -1046, -907, -760, -610, -452, -283, -103};