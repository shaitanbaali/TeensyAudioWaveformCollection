/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1045 256 samples */
 
const int16_t AKWF_1045_256_DATA [256] = 
{130, 299, 410, 467, 479, 480, 483, 486, 488, 491, 492, 495, 496, 497, 498, 497, 499, 501, 502, 502, 501, 503, 504, 503, 504, 501, 523, 569, 594, 615, 633, 651, 667, 681, 694, 707, 719, 732, 743, 754, 764, 774, 784, 793, 802, 811, 820, 827, 836, 844, 851, 860, 866, 873, 881, 887, 893, 899, 906, 912, 917, 922, 929, 934, 939, 944, 948, 954, 958, 961, 966, 970, 973, 978, 982, 985, 988, 991, 994, 997, 999, 1002, 1005, 1007, 1010, 1012, 1013, 1016, 1017, 1018, 1020, 1021, 1022, 1022, 1025, 1026, 1026, 1025, 1026, 1028, 1027, 1028, 1014, 992, 981, 971, 963, 956, 950, 946, 949, 907, 1118, 979, 516, 289, 108, 35, -275, 1171, 4159, 5534, 6454, 6967, 6538, 5308, 4667, 4136, 3696, 3328, 3022, 2772, 2573, 2428, 2329, 2310, 1698, 1259, 1099, 1091, 645, -2137, -3734, -4611, -5105, -4501, -3262, -2638, -2111, -1691, -1357, -1099, -909, -743, -969, 2607, 7011, 9410, 11573, 13446, 15129, 16656, 18059, 19358, 20555, 21666, 22698, 23651, 24531, 25342, 26082, 26757, 27367, 27912, 28395, 28815, 29173, 29470, 29705, 29878, 29935, 30276, 26489, 22247, 19831, 17667, 15802, 14159, 12698, 11388, 10223, 9191, 8282, 7496, 6827, 6274, 5835, 5506, 5212, 5512, 2442, -3272, -6214, -8795, -11024, -13010, -14824, -16493, -18034, -19473, -20813, -22063, -23232, -24324, -25337, -26284, -27160, -27967, -28709, -29387, -30001, -30554, -31043, -31470, -31836, -32142, -32386, -32571, -32616, -33077, -30398, -25650, -23116, -20849, -18889, -17128, -15520, -14041, -12667, -11388, -10197, -9081, -8038, -7068, -6161, -5317, -4537, -3815, -3153, -2548, -1998, -1506, -1069, -687, -359, -83};