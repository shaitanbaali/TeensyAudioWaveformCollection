/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1090 256 samples */
 
const int16_t AKWF_1090_256_DATA [256] = 
{915, 2887, 4828, 6777, 8715, 10632, 12516, 14349, 16128, 17848, 19487, 21053, 22535, 23928, 25228, 26430, 27530, 28526, 29411, 30182, 30834, 31370, 31784, 32076, 32243, 32292, 32158, 32192, 32443, 30818, 29517, 27956, 26514, 24932, 23333, 21706, 20177, 18720, 18227, 17077, 14827, 13158, 11652, 10402, 9272, 8162, 7087, 6046, 5135, 5195, 3795, 2390, 1175, 261, -628, -1482, -2498, -3672, -5043, -6562, -8166, -9792, -11354, -12800, -14086, -15174, -16055, -16718, -17148, -17462, -16908, -16297, -16046, -15230, -14273, -13076, -11705, -10225, -8630, -6979, -5279, -3557, -1821, -90, 1636, 3339, 5006, 6638, 8213, 9724, 11163, 12514, 13769, 14923, 15965, 16886, 17686, 18357, 18895, 19300, 19579, 19610, 20206, 20013, 18584, 17431, 16116, 14794, 13398, 11940, 10503, 9156, 8013, 7928, 6443, 5000, 3771, 2841, 1925, 1028, -51, -1299, -2757, -4360, -6048, -7751, -9385, -10898, -12245, -13390, -14325, -15042, -15522, -15890, -15385, -14911, -14904, -14357, -13712, -12877, -11933, -10952, -9930, -8930, -7951, -7010, -6109, -5260, -4463, -3724, -3055, -2457, -1945, -1514, -1244, -781, -93, -1291, -2168, -3309, -4336, -5515, -6720, -7963, -9130, -10233, -10410, -10775, -11719, -12022, -12101, -11887, -11517, -11118, -10735, -10446, -10246, -10141, -10102, -10105, -10120, -10130, -10124, -10095, -10049, -9990, -9924, -9857, -9793, -9735, -9680, -9633, -9588, -9542, -9497, -9449, -9383, -9422, -8791, -8265, -8256, -7794, -7318, -6715, -6042, -5338, -4589, -3835, -3074, -2324, -1588, -893, -240, 358, 889, 1344, 1714, 2006, 2139, 2466, 3026, 1701, 706, -546, -1685, -2968, -4271, -5614, -6876, -8074, -8320, -9234, -11260, -12713, -14011, -15055, -15993, -16912, -17803, -18665, -19416, -19130, -19560, -19604, -19273, -18445, -17318, -15839, -14187, -12388, -10521, -8623, -6719, -4818, -2911, -962};