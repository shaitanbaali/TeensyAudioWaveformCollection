/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1033 256 samples */
 
const int16_t AKWF_1033_256_DATA [256] = 
{511, 1927, 3196, 4283, 5173, 5886, 6450, 6890, 7237, 7508, 7720, 7884, 8008, 8097, 8160, 8200, 8221, 8226, 8218, 8212, 8221, 7767, 14760, 17820, 15588, 17230, 20017, 21947, 22180, 16182, 13210, 14585, 20294, 18376, 16860, 19685, 24146, 28041, 30046, 28509, 25318, 21863, 17681, 12813, 7715, 2892, -1343, -4842, -7601, -9729, -11333, -12529, -13413, -14066, -14481, -14854, -18168, -17239, -15133, -14691, -14110, -12593, -10174, -7269, -4328, -1666, 577, 2387, 3804, 4901, 5752, 6409, 6919, 7311, 7608, 7826, 7981, 8082, 8139, 8161, 8154, 8123, 8074, 8007, 7809, 8235, 6279, -11968, -13799, -12300, -18521, -26062, -31161, -32799, -31650, -28935, -25660, -22711, -19857, -6108, -2738, -4509, -789, 3736, 6302, 6227, 4139, 1026, -2275, -5256, -7726, -9665, -11140, -12265, -13126, -13785, -14295, -14685, -14979, -15191, -15336, -15423, -15463, -15460, -15433, -15597, -14359, -12659, -11350, -9752, -7655, -5212, -2707, -375, 1653, 3332, 4684, 5758, 6606, 7277, 7810, 8232, 8565, 8824, 9022, 9171, 9275, 9345, 9388, 9405, 9403, 9385, 9353, 9312, 9261, 9203, 9141, 9072, 9001, 8926, 8849, 8771, 8692, 8612, 8530, 8450, 8368, 8281, 8222, 7921, 7340, 6855, 6334, 5675, 4902, 4091, 3322, 2638, 2063, 1589, 1206, 896, 644, 440, 270, 131, 16, -79, -157, -222, -276, -319, -354, -383, -405, -424, -439, -450, -459, -466, -472, -474, -479, -810, -1276, -1651, -2107, -2702, -3383, -4076, -4716, -5263, -5711, -6064, -6335, -6542, -6699, -6815, -6899, -6957, -6994, -7015, -7021, -7014, -6996, -6973, -6943, -6905, -6863, -6820, -6773, -6723, -6671, -6619, -6565, -6510, -6455, -6399, -6343, -6288, -6232, -6177, -6122, -6067, -6012, -5956, -5902, -5848, -5790, -5754, -5631, -4812, -3896, -3108, -2123, -849};