/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1034 256 samples */
 
const int16_t AKWF_1034_256_DATA [256] = 
{100, 443, 778, 1114, 1451, 1788, 2126, 2459, 2791, 3117, 3433, 3741, 4036, 4319, 4592, 4854, 5103, 5343, 5574, 5796, 6011, 6218, 6418, 6612, 6802, 6985, 7163, 7341, 7519, 7699, 7882, 8068, 8259, 8453, 8648, 8844, 9037, 9224, 9403, 9572, 9727, 9871, 10003, 10122, 10230, 10329, 10419, 10503, 10579, 10650, 10716, 10780, 10840, 10897, 10952, 11006, 11059, 11110, 11159, 11208, 11255, 11305, 11358, 11419, 11493, 11587, 11703, 11847, 12020, 12229, 12468, 12735, 13032, 13352, 13688, 14037, 14397, 14759, 15120, 15475, 15820, 16155, 16472, 16771, 17049, 17306, 17539, 17748, 17932, 18090, 18223, 18332, 18414, 18472, 18507, 18516, 18502, 18465, 18405, 18323, 18219, 18096, 17952, 17790, 17610, 17412, 17199, 16970, 16727, 16472, 16204, 15924, 15636, 15338, 15033, 14723, 14407, 14087, 13766, 13441, 13117, 12791, 12466, 12141, 11817, 11492, 11168, 10845, 10519, 10194, 9869, 9543, 9217, 8892, 8566, 8241, 7917, 7594, 7275, 6956, 6640, 6326, 6016, 5708, 5404, 5103, 4805, 4512, 4221, 3934, 3652, 3371, 3095, 2824, 2556, 2291, 2031, 1771, 1451, 1049, 567, -36, -803, -1756, -2895, -4229, -5746, -7416, -9215, -11102, -13033, -14979, -16904, -18772, -20566, -22262, -23839, -25294, -26614, -27792, -28836, -29743, -30515, -31161, -31687, -32099, -32407, -32615, -32733, -32769, -32730, -32621, -32449, -32220, -31940, -31613, -31245, -30839, -30398, -29930, -29434, -28914, -28375, -27815, -27241, -26654, -26053, -25444, -24827, -24202, -23571, -22939, -22302, -21663, -21024, -20385, -19747, -19112, -18477, -17847, -17220, -16596, -15979, -15366, -14758, -14157, -13565, -12980, -12405, -11836, -11278, -10728, -10186, -9651, -9127, -8609, -8100, -7602, -7112, -6633, -6167, -5709, -5263, -4827, -4400, -3983, -3574, -3172, -2777, -2392, -2014, -1644, -1282, -926, -579, -231};