/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1076 256 samples */
 
const int16_t AKWF_1076_256_DATA [256] = 
{6421, 6704, 6979, 7252, 7519, 7782, 8040, 8291, 8535, 8769, 8996, 9211, 9415, 9606, 9783, 9943, 10088, 10181, 10395, 10092, 968, -223, 120, 110, 170, 243, 330, 429, 541, 664, 800, 947, 1105, 1274, 1453, 1644, 1843, 2052, 2269, 2496, 2730, 2971, 3218, 3471, 3732, 3997, 4265, 4538, 4813, 5091, 5371, 5580, 6309, 4471, 4842, 6999, 6867, 7201, 7470, 7734, 7992, 8245, 8490, 8726, 8955, 9172, 9378, 9572, 9751, 9914, 10062, 10187, 10148, 11062, -999, -3483, -663, -13, -3, -4, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 10, 35, 73, 125, 188, 265, 355, 458, 573, 699, 838, 988, 1149, 1321, 1503, 1696, 1898, 2109, 2329, 2558, 2793, 3036, 3286, 3540, 3802, 4068, 4337, 4611, 4887, 5165, 5446, 5009, 9122, -13523, -35501, -30850, -30255, -28518, -26402, -23950, -21235, -18333, -15314, -12287, -9323, -6511, -7539, -11002, -14522, -18245, -21968, -25514, -28347, -32741, -26200, 1385, -263, -4, -1, -23, -529, -1528, -4782, 3698, 7943, 188, -210, 33, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -21, 78, -84, -7977, -3701, 708, -155, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};