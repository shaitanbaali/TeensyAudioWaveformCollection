/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1089 256 samples */
 
const int16_t AKWF_1089_256_DATA [256] = 
{190, 854, 1487, 2103, 2705, 3292, 3863, 4405, 4985, 5669, 5460, 5585, 5653, 5779, 5776, 5713, 5546, 5324, 5070, 4811, 4564, 4346, 4157, 3996, 3854, 3726, 3604, 3486, 3363, 3241, 3115, 2992, 2869, 2769, 2585, 2841, 4623, 5829, 7050, 8275, 9802, 11555, 13548, 15684, 17883, 20060, 22173, 24189, 26102, 27932, 29665, 31517, 32536, 30464, 29593, 28676, 27762, 26246, 24280, 21816, 19068, 16173, 13298, 10551, 7972, 5586, 3360, 1258, -769, -2761, -3264, -3694, -4481, -5198, -5698, -5949, -5915, -5698, -5350, -4967, -4608, -4305, -4077, -3917, -3808, -3729, -3664, -3596, -3514, -3420, -3312, -3196, -3097, -2894, -3306, -4778, -5678, -6666, -7680, -8945, -10397, -12026, -13766, -15531, -17277, -18955, -20551, -22061, -23507, -24891, -26245, -27546, -29056, -28842, -27296, -26662, -25648, -24911, -23554, -21826, -19721, -17440, -15103, -12830, -10786, -8790, -6958, -5263, -3607, -2448, 2137, 2678, 4813, 6912, 8413, 10165, 12180, 13917, 15663, 17113, 18465, 19644, 20762, 21837, 22903, 23989, 25095, 26216, 27346, 28448, 29657, 30228, 28715, 28062, 27324, 26580, 25417, 23948, 22157, 20184, 18133, 16111, 14189, 12390, 10732, 9187, 7726, 6327, 4955, 3598, 2251, 906, -425, -1753, -3013, -3258, -3609, -4071, -4481, -4715, -4795, -4695, -4495, -4226, -3950, -3697, -3488, -3327, -3207, -3122, -3052, -2986, -2931, -2779, -3217, -4256, -4854, -5532, -6248, -7130, -8159, -9312, -10526, -11759, -12968, -14118, -15206, -16229, -17197, -18124, -19026, -19907, -20784, -21649, -22509, -23361, -24199, -25022, -25830, -26619, -27388, -28144, -28868, -29630, -30209, -29133, -28505, -27969, -27428, -26606, -25578, -24303, -22897, -21420, -19965, -18573, -17279, -16090, -14990, -13959, -12979, -12029, -11094, -10172, -9253, -8346, -7455, -6581, -5732, -4907, -4109, -3335, -2588, -1862, -1157, -460};