/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1026 256 samples */
 
const int16_t AKWF_1026_256_DATA [256] = 
{346, 1033, 1679, 2299, 2891, 3457, 3994, 4506, 4988, 5445, 5874, 6278, 6657, 7010, 7340, 7645, 7927, 8187, 8425, 8640, 8836, 9011, 9166, 9300, 9415, 9514, 9592, 9652, 9695, 9721, 9729, 9721, 9695, 9651, 9593, 9518, 9427, 9320, 9198, 9060, 8906, 8737, 8555, 8359, 8148, 7925, 7690, 7442, 7183, 6914, 6636, 6351, 6055, 5757, 5454, 5145, 4836, 4526, 4216, 3911, 3609, 3313, 3026, 2748, 2480, 2228, 1991, 1769, 1568, 1387, 1228, 1092, 984, 901, 847, 823, 829, 870, 941, 1046, 1185, 1360, 1569, 1814, 2093, 2408, 2757, 3139, 3553, 3999, 4476, 4983, 5517, 6078, 6662, 7268, 7896, 8541, 9202, 9877, 10560, 11254, 11954, 12653, 13355, 14056, 14750, 15436, 16113, 16774, 17421, 18051, 18658, 19244, 19804, 20336, 20840, 21313, 21753, 22160, 22530, 22862, 23158, 23415, 23631, 23808, 23944, 24039, 24091, 24102, 24073, 24004, 23891, 23740, 23549, 23318, 23048, 22742, 22398, 22018, 21603, 21156, 20675, 20162, 19619, 19044, 18442, 17814, 17156, 16474, 15770, 15040, 14286, 13513, 12718, 11903, 11070, 10217, 9347, 8463, 7558, 6641, 5709, 4761, 3802, 2832, 1847, 851, -153, -1167, -2189, -3220, -4259, -5300, -6348, -7400, -8451, -9505, -10559, -11607, -12655, -13698, -14732, -15760, -16775, -17776, -18766, -19738, -20690, -21624, -22532, -23417, -24274, -25101, -25897, -26659, -27385, -28072, -28721, -29325, -29888, -30405, -30873, -31293, -31664, -31982, -32247, -32459, -32615, -32717, -32765, -32756, -32690, -32570, -32395, -32164, -31879, -31542, -31153, -30712, -30222, -29685, -29102, -28476, -27805, -27098, -26353, -25572, -24761, -23920, -23051, -22158, -21244, -20311, -19365, -18405, -17433, -16458, -15475, -14491, -13510, -12531, -11558, -10594, -9640, -8698, -7773, -6862, -5970, -5099, -4246, -3418, -2614, -1832, -1079, -339};