/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1060 256 samples */
 
const int16_t AKWF_1060_256_DATA [256] = 
{165, 735, 1249, 1897, 2655, 3474, 4242, 4970, 5709, 6513, 7355, 8188, 8974, 9714, 10442, 11162, 11864, 12517, 13112, 13652, 14162, 14644, 15089, 15490, 15854, 16189, 16512, 16824, 17126, 17421, 17719, 18022, 18341, 18682, 19037, 19411, 19803, 20218, 20653, 21105, 21568, 22044, 22522, 23000, 23478, 23947, 24405, 24842, 25254, 25647, 26014, 26352, 26662, 26941, 27190, 27415, 27617, 27796, 27960, 28106, 28242, 28372, 28499, 28627, 28762, 28903, 29049, 29210, 29381, 29566, 29763, 29967, 30180, 30405, 30632, 30859, 31086, 31308, 31522, 31725, 31914, 32088, 32244, 32378, 32493, 32589, 32662, 32715, 32748, 32766, 32766, 32753, 32731, 32696, 32660, 32618, 32576, 32536, 32496, 32462, 32424, 32328, 32759, 26591, 18455, 19375, 20217, 19450, 16812, 14035, 12268, 11650, 11600, 10706, 9252, 7582, 6788, 6413, 6223, 5509, 4613, 3748, 3268, 2960, 2579, 1962, 1216, 545, -17, -534, -1174, -1929, -2753, -3534, -4281, -5023, -5827, -6672, -7510, -8306, -9057, -9784, -10502, -11202, -11853, -12449, -12990, -13496, -13969, -14408, -14805, -15169, -15500, -15815, -16122, -16421, -16718, -17016, -17320, -17643, -17983, -18341, -18721, -19123, -19543, -19986, -20445, -20919, -21403, -21893, -22379, -22863, -23340, -23800, -24245, -24669, -25066, -25434, -25776, -26086, -26368, -26620, -26848, -27050, -27229, -27393, -27544, -27681, -27816, -27950, -28083, -28219, -28365, -28523, -28692, -28873, -29066, -29271, -29486, -29714, -29947, -30188, -30425, -30662, -30896, -31119, -31335, -31533, -31715, -31880, -32023, -32146, -32248, -32332, -32388, -32429, -32453, -32462, -32457, -32441, -32417, -32386, -32355, -32324, -32292, -32263, -32240, -32224, -32214, -32187, -32173, -32382, -24728, -17781, -19107, -19980, -18776, -16114, -13227, -11725, -11169, -11140, -10068, -8539, -6888, -6171, -5847, -5589, -4817, -3866, -3039, -2579, -2292, -1864, -1226, -456};