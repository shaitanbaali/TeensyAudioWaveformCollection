/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1035 256 samples */
 
const int16_t AKWF_1035_256_DATA [256] = 
{367, 948, 1502, 2043, 2570, 3083, 3583, 4066, 4537, 4995, 5439, 5868, 6286, 6690, 7080, 7460, 7824, 8178, 8519, 8847, 9165, 9469, 9762, 10044, 10312, 10569, 10815, 11049, 11271, 11481, 11680, 11869, 12045, 12211, 12367, 12512, 12647, 12774, 12890, 12998, 13097, 13188, 13271, 13346, 13414, 13475, 13528, 13576, 13618, 13652, 13682, 13705, 13724, 13737, 13745, 13748, 13748, 13742, 13732, 13719, 13701, 13680, 13654, 13626, 13596, 13566, 13540, 13520, 13511, 13518, 13544, 13595, 13672, 13777, 13912, 14074, 14261, 14473, 14703, 14949, 15205, 15469, 15737, 16002, 16266, 16520, 16767, 17001, 17221, 17428, 17618, 17792, 17947, 18086, 18207, 18310, 18397, 18467, 18521, 18559, 18579, 18585, 18580, 18559, 18524, 18477, 18419, 18350, 18269, 18177, 18077, 17967, 17848, 17722, 17587, 17446, 17297, 17143, 16983, 16816, 16645, 16470, 16290, 16106, 15919, 15726, 15532, 15334, 15135, 14933, 14726, 14511, 14289, 14053, 13797, 13520, 13212, 12869, 12486, 12058, 11579, 11054, 10473, 9841, 9160, 8427, 7649, 6829, 5968, 5072, 4147, 3192, 2214, 1221, 209, -810, -1836, -2868, -3902, -4931, -5958, -6976, -7985, -8985, -9970, -10943, -11900, -12839, -13761, -14665, -15547, -16412, -17256, -18076, -18876, -19656, -20410, -21145, -21857, -22546, -23212, -23857, -24477, -25077, -25655, -26208, -26743, -27254, -27743, -28214, -28661, -29089, -29495, -29883, -30251, -30599, -30928, -31238, -31529, -31796, -32040, -32255, -32440, -32588, -32695, -32756, -32766, -32723, -32623, -32463, -32242, -31963, -31624, -31230, -30780, -30277, -29728, -29134, -28499, -27826, -27121, -26386, -25626, -24845, -24043, -23228, -22400, -21561, -20715, -19866, -19011, -18160, -17306, -16453, -15607, -14766, -13930, -13103, -12284, -11473, -10676, -9887, -9107, -8344, -7590, -6849, -6123, -5408, -4708, -4024, -3351, -2693, -2052, -1423, -811, -202};