/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1098 256 samples */
 
const int16_t AKWF_1098_256_DATA [256] = 
{6361, 20978, 27807, 29564, 29636, 29231, 28711, 28173, 27638, 27113, 26599, 26092, 25595, 25110, 24633, 24162, 23704, 23253, 22811, 22379, 21952, 21534, 21125, 20723, 20329, 19944, 19563, 19191, 18827, 18468, 18117, 17774, 17434, 17104, 16778, 16459, 16146, 15839, 15537, 15243, 14953, 14668, 14389, 14116, 13847, 13584, 13326, 13072, 12825, 12579, 12340, 12106, 11876, 11649, 11428, 11211, 10997, 10789, 10583, 10381, 10185, 9991, 9801, 9615, 9432, 9252, 9078, 8904, 8735, 8568, 8406, 8247, 8089, 7935, 7784, 7636, 7491, 7349, 7209, 7072, 6937, 6806, 6676, 6549, 6424, 6302, 6182, 6064, 5949, 5836, 5725, 5616, 5509, 5405, 5302, 5202, 5103, 5006, 4910, 4817, 4725, 4636, 4547, 4461, 4376, 4292, 4211, 4131, 4052, 3975, 3899, 3825, 3753, 3681, 3611, 3543, 3476, 3410, 3345, 3281, 3218, 3157, 3098, 3038, 2980, 2924, 2867, 2813, 2760, 2708, 2656, 2605, 2556, 2508, 2459, 2412, 2368, 2323, 2278, 2234, 2192, 2150, 2109, 2068, 2030, 1991, 1953, 1916, 1879, 1844, 1808, 1642, 2156, -2219, -17413, -28436, -32115, -32763, -32467, -31928, -31337, -30745, -30162, -29588, -29026, -28474, -27933, -27401, -26880, -26368, -25868, -25375, -24892, -24420, -23955, -23500, -23053, -22615, -22184, -21764, -21349, -20943, -20545, -20155, -19771, -19396, -19026, -18664, -18310, -17962, -17620, -17285, -16956, -16634, -16318, -16007, -15704, -15405, -15111, -14825, -14542, -14266, -13995, -13729, -13468, -13212, -12961, -12713, -12472, -12236, -12002, -11774, -11550, -11331, -11116, -10903, -10696, -10493, -10294, -10097, -9906, -9717, -9533, -9352, -9174, -9000, -8828, -8660, -8496, -8334, -8175, -8020, -7867, -7718, -7572, -7428, -7286, -7148, -7011, -6879, -6749, -6619, -6493, -6369, -6250, -6130, -6013, -5899, -5787, -5676, -5569, -5463, -5359, -5230, -5280, -4375};