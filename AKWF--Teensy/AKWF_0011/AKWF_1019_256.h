/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1019 256 samples */
 
const int16_t AKWF_1019_256_DATA [256] = 
{899, 2507, 3684, 4538, 4786, 5525, 19412, 30534, 32768, 30094, 24048, 17235, 4018, -14128, -24568, -30237, -28830, -15990, -6409, -598, 2652, 3917, 4403, -8382, -22812, -27908, -27772, -23983, -18091, -11277, -4461, 1736, 6934, 10905, 13624, 15087, 16080, 19492, 21332, 20227, 17453, 13685, 9529, 5415, 1667, -1498, -3992, -5777, -6877, -7371, -7349, -6922, -6198, -5287, -4283, -3261, -2287, -1410, -654, -39, 430, 762, 969, 1065, 1072, 1012, 902, 762, 608, 451, 303, 171, 58, -31, -98, -144, -170, -181, -176, -163, -143, -119, -92, -67, -44, -22, -5, 7, 17, 24, 27, 28, 27, 24, 21, 17, 12, 9, 4, 1, 0, -2, -3, -5, -4, -4, -4, -5, -3, -2, -2, -1, -1, 0, -1, 0, -1, 10, 9, -25, 3111, 6974, 8414, 8252, 7008, 5150, 3043, 953, -931, -2498, -3683, -4539, -4787, -5527, -19413, -30534, -32768, -30093, -24047, -17236, -4017, 14128, 24567, 30237, 28830, 15989, 6407, 597, -2653, -3917, -4404, 8382, 22812, 27908, 27772, 23983, 18090, 11277, 4460, -1737, -6935, -10906, -13625, -15087, -16080, -19492, -21332, -20227, -17454, -13686, -9529, -5415, -1668, 1498, 3991, 5776, 6877, 7370, 7348, 6921, 6197, 5286, 4282, 3260, 2287, 1409, 653, 38, -431, -763, -970, -1066, -1073, -1013, -903, -763, -609, -452, -304, -172, -59, 30, 97, 143, 169, 180, 175, 162, 142, 118, 91, 66, 43, 21, 4, -8, -18, -25, -28, -29, -28, -25, -22, -18, -13, -10, -5, -2, -1, 1, 2, 4, 3, 3, 3, 4, 2, 1, 1, 0, 0, -1, 0, -1, 0, -11, -10, 25, -3112, -6975, -8414, -8253, -7009, -5154, -3051, -931};