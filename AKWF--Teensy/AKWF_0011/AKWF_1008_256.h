/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1008 256 samples */
 
const int16_t AKWF_1008_256_DATA [256] = 
{865, 3317, 5720, 8128, 10534, 12943, 15354, 17759, 20167, 22577, 24978, 27264, 30224, 27411, 18581, 10487, 1881, -1102, 10489, 26531, 29424, 24899, 21558, 17992, 14430, 10873, 7312, 3764, 131, -1022, -858, -872, -986, -3718, -7239, -10611, -14003, -17399, -20799, -24189, -27402, -31625, -27542, -14281, -2057, -6075, -19738, -30942, -30141, -26568, -23576, -20472, -17358, -14247, -11142, -8033, -4937, -1755, -712, -867, -829, -822, -813, -855, 806, 3334, 5715, 8128, 10534, 12943, 15354, 17759, 20167, 22577, 24978, 27264, 30224, 27411, 18581, 10487, 1881, -1102, 10489, 26531, 29424, 24899, 21558, 17992, 14430, 10873, 7312, 3764, 131, -1022, -858, -872, -986, -3718, -7239, -10611, -14003, -17399, -20799, -24189, -27402, -31625, -27542, -14281, -2057, -6075, -19738, -30942, -30141, -26568, -23576, -20472, -17358, -14247, -11142, -8033, -4937, -1755, -712, -867, -829, -822, -813, -855, 806, 3334, 5715, 8128, 10534, 12943, 15354, 17759, 20167, 22577, 24978, 27264, 30224, 27411, 18581, 10487, 1881, -1102, 10489, 26531, 29425, 24899, 21558, 17992, 14430, 10873, 7312, 3764, 131, -1022, -858, -872, -986, -3718, -7239, -10611, -14003, -17399, -20799, -24189, -27402, -31625, -27542, -14281, -2057, -6075, -19738, -30942, -30141, -26568, -23576, -20472, -17358, -14247, -11142, -8033, -4937, -1755, -712, -867, -829, -822, -813, -855, 806, 3334, 5715, 8128, 10534, 12943, 15354, 17759, 20167, 22577, 24978, 27264, 30224, 27411, 18581, 10487, 1881, -1102, 10489, 26531, 29425, 24899, 21558, 17992, 14430, 10873, 7312, 3764, 131, -1022, -858, -872, -986, -3718, -7239, -10611, -14003, -17399, -20799, -24189, -27402, -31625, -27543, -14287, -2058, -6075, -19738, -30942, -30141, -26568, -23575, -20472, -17358, -14247, -11142, -8033, -4937, -1755, -712, -867, -829, -827, -824, -822};