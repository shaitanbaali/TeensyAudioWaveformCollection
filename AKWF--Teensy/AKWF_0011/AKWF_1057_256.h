/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1057 256 samples */
 
const int16_t AKWF_1057_256_DATA [256] = 
{3783, 2882, 1352, 2457, 5740, 8729, 11933, 13752, 15114, 15796, 16860, 18030, 18762, 18355, 17907, 19896, 23287, 23865, 20152, 15318, 11601, 8405, 4218, 1004, 1466, 4521, 7146, 8586, 9736, 11068, 12481, 13709, 14194, 13604, 12698, 12676, 14165, 16675, 18778, 19455, 18809, 17697, 16939, 16587, 15822, 13957, 11541, 10324, 10124, 6733, -1362, -9821, -15038, -18207, -21670, -25710, -29277, -31241, -30559, -27490, -24024, -21754, -20628, -19663, -18343, -16844, -15371, -13924, -12295, -10159, -7455, -4656, -2516, -1426, -892, -164, 632, 727, 644, 2303, 5146, 5493, 1956, -2770, -6389, -9602, -13809, -17023, -16355, -13044, -10253, -8732, -7438, -5877, -4194, -2704, -2046, -2456, -2933, -2141, 203, 3213, 5844, 7650, 8723, 9383, 10073, 10885, 11242, 10627, 9552, 9587, 10316, 7254, -886, -8968, -12986, -14564, -16765, -20036, -23007, -24145, -22459, -18518, -14425, -11779, -10875, -7556, 1658, 562, -1192, -250, 2869, 5687, 8692, 10275, 11468, 12075, 13065, 14135, 14805, 14380, 13904, 15716, 18926, 19571, 15991, 11195, 7550, 4547, 590, -2391, -1659, 1693, 4607, 6336, 7808, 9474, 11209, 12742, 13527, 13231, 12603, 12838, 14566, 17237, 19414, 20114, 19337, 17912, 16989, 16602, 15677, 13579, 11053, 9801, 9524, 6031, -2144, -10680, -15995, -19256, -22778, -26887, -30563, -32643, -32065, -29114, -25794, -23703, -22794, -22059, -20944, -19651, -18411, -17234, -15886, -14045, -11647, -9124, -7225, -6375, -6097, -5618, -5044, -5141, -5401, -3918, -1231, -1027, -4691, -9516, -13204, -16484, -20762, -24024, -23377, -20079, -17265, -15661, -14260, -12588, -10788, -9142, -8307, -8531, -8816, -7809, -5252, -2017, 860, 2929, 4257, 5168, 6127, 7244, 7898, 7576, 6828, 7187, 8200, 5407, -2432, -10199, -13921, -15213, -17114, -20074, -22727, -23592, -21656, -17456, -13119, -10273, -9100, -5616};