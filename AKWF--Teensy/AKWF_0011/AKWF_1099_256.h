/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1099 256 samples */
 
const int16_t AKWF_1099_256_DATA [256] = 
{149, 394, 638, 890, 1149, 1415, 1691, 1974, 2270, 2577, 2896, 3231, 3581, 3949, 4336, 4745, 5177, 5637, 6126, 6647, 7208, 7811, 8461, 9168, 9936, 10773, 11698, 12702, 13749, 14793, 15797, 16753, 17665, 18541, 19393, 20238, 21083, 21947, 22844, 23788, 24798, 25890, 27030, 28143, 29157, 30033, 30768, 31367, 31840, 32203, 32466, 32642, 32739, 32768, 32733, 32642, 32500, 32311, 32079, 31808, 31500, 31157, 30783, 30378, 29942, 29478, 28988, 28467, 27920, 27343, 26736, 26099, 25428, 24720, 23977, 23187, 22350, 21461, 20507, 19485, 18417, 17351, 16331, 15381, 14504, 13698, 12959, 12276, 11646, 11061, 10514, 10005, 9526, 9076, 8652, 8250, 7867, 7504, 7158, 6827, 6509, 6204, 5910, 5625, 5351, 5084, 4825, 4574, 4327, 4087, 3851, 3619, 3392, 3167, 2945, 2725, 2507, 2289, 2073, 1857, 1640, 1424, 1205, 986, 764, 539, 312, 82, -153, -394, -639, -891, -1149, -1416, -1692, -1975, -2271, -2578, -2897, -3232, -3582, -3950, -4337, -4746, -5177, -5637, -6126, -6648, -7209, -7812, -8462, -9168, -9936, -10774, -11698, -12703, -13750, -14793, -15797, -16753, -17666, -18542, -19394, -20238, -21083, -21947, -22845, -23788, -24798, -25890, -27030, -28143, -29157, -30033, -30768, -31367, -31840, -32203, -32466, -32642, -32739, -32768, -32733, -32642, -32500, -32311, -32079, -31808, -31500, -31157, -30783, -30378, -29942, -29478, -28988, -28467, -27920, -27343, -26736, -26099, -25429, -24721, -23977, -23188, -22351, -21461, -20507, -19485, -18418, -17352, -16331, -15382, -14505, -13699, -12960, -12277, -11646, -11062, -10515, -10006, -9527, -9076, -8652, -8250, -7868, -7505, -7159, -6827, -6509, -6205, -5910, -5626, -5352, -5085, -4826, -4574, -4328, -4088, -3852, -3620, -3393, -3168, -2946, -2726, -2508, -2290, -2074, -1858, -1641, -1425, -1206, -987, -765, -541, -314, -80};