/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1024 256 samples */
 
const int16_t AKWF_1024_256_DATA [256] = 
{822, 2042, 3208, 4350, 5462, 6544, 7596, 8616, 9605, 10562, 11486, 12380, 13243, 14071, 14870, 15639, 16375, 17083, 17762, 18411, 19032, 19628, 20193, 20735, 21252, 21744, 22212, 22658, 23082, 23485, 23866, 24231, 24575, 24901, 25211, 25506, 25783, 26048, 26299, 26536, 26762, 26976, 27179, 27373, 27558, 27734, 27903, 28063, 28217, 28365, 28509, 28645, 28778, 28908, 29032, 29155, 29276, 29393, 29509, 29624, 29735, 29846, 29958, 30068, 30178, 30288, 30396, 30506, 30614, 30724, 30832, 30941, 31049, 31158, 31265, 31372, 31478, 31583, 31685, 31786, 31885, 31980, 32074, 32163, 32247, 32328, 32404, 32474, 32541, 32603, 32661, 32712, 32749, 32768, 32756, 32700, 32593, 32422, 32173, 31840, 31421, 30911, 30309, 29620, 28846, 27989, 27059, 26058, 24992, 23873, 22700, 21484, 20231, 18946, 17634, 16307, 14959, 13604, 12247, 10884, 9526, 8177, 6834, 5507, 4198, 2904, 1633, 385, -840, -2037, -3207, -4351, -5463, -6545, -7597, -8617, -9605, -10563, -11486, -12380, -13243, -14072, -14870, -15639, -16375, -17084, -17762, -18411, -19033, -19628, -20193, -20736, -21253, -21744, -22212, -22659, -23082, -23485, -23867, -24231, -24575, -24901, -25212, -25507, -25783, -26049, -26299, -26536, -26762, -26976, -27179, -27373, -27558, -27734, -27903, -28063, -28217, -28365, -28509, -28645, -28779, -28908, -29033, -29155, -29276, -29394, -29509, -29624, -29735, -29846, -29958, -30068, -30178, -30288, -30396, -30506, -30614, -30724, -30832, -30941, -31049, -31158, -31265, -31372, -31478, -31583, -31685, -31786, -31885, -31980, -32074, -32163, -32247, -32328, -32404, -32474, -32541, -32603, -32661, -32712, -32749, -32768, -32756, -32700, -32593, -32422, -32173, -31840, -31421, -30911, -30309, -29620, -28846, -27989, -27059, -26058, -24992, -23873, -22701, -21484, -20232, -18947, -17635, -16307, -14959, -13605, -12248, -10885, -9526, -8178, -6835, -5508, -4199, -2907, -1639, -370};