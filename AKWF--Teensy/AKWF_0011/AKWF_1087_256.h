/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1087 256 samples */
 
const int16_t AKWF_1087_256_DATA [256] = 
{307, 768, 1301, 1866, 2535, 3118, 3726, 4424, 4914, 5463, 5887, 6396, 6986, 7600, 8067, 8546, 8785, 9080, 9544, 9950, 10434, 11023, 11560, 11940, 12169, 12318, 12687, 13181, 13600, 13765, 14027, 14348, 14768, 15012, 15132, 15637, 16094, 16405, 16726, 16673, 16947, 17537, 17729, 17945, 18113, 18099, 18128, 18334, 18595, 18641, 18905, 18896, 18805, 18748, 18975, 19235, 19301, 19275, 19448, 19618, 19482, 19382, 19322, 19302, 19213, 19053, 18935, 18592, 18598, 18599, 18293, 18017, 17919, 17855, 17371, 17148, 17095, 17253, 17265, 17293, 17011, 16718, 16698, 16481, 16239, 15986, 15661, 15518, 15431, 15094, 14701, 14512, 14133, 14055, 13872, 13536, 13306, 12824, 12366, 12066, 11911, 11753, 11595, 11127, 10847, 10691, 10583, 10317, 9993, 9761, 9681, 9198, 8493, 8018, 7598, 7144, 6842, 6512, 6245, 5906, 5533, 5292, 5009, 4741, 4612, 4330, 3660, 3168, 2960, 2800, 2382, 2062, 1760, 1630, 1326, 1179, 817, 427, 201, 3, -263, -468, -625, -914, -1345, -1761, -2025, -2384, -2669, -2797, -3138, -3472, -3594, -4122, -4418, -4623, -4934, -4904, -5253, -5696, -6044, -6364, -6395, -6353, -6374, -6610, -6954, -7211, -7242, -7133, -7183, -7482, -7725, -8038, -8270, -8480, -8536, -8485, -8521, -8621, -8744, -9036, -9026, -9114, -7936, -19467, -24450, -21458, -23695, -25672, -27227, -28779, -29947, -30827, -31546, -32013, -32516, -32759, -32589, -32482, -32453, -31881, -31517, -31115, -30833, -30308, -29923, -29627, -29102, -28609, -28096, -27722, -27115, -26443, -25956, -25409, -24802, -24391, -23762, -23110, -22720, -22210, -21643, -21122, -20480, -19865, -19272, -18535, -17923, -17306, -16574, -15793, -15210, -14613, -13980, -13315, -12549, -11713, -10875, -10506, -9994, -9314, -8483, -7992, -7251, -6637, -6132, -5642, -5165, -4641, -3964, -3187, -2322, -1617, -871, -204};