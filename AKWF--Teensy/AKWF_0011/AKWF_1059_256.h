/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1059 256 samples */
 
const int16_t AKWF_1059_256_DATA [256] = 
{25, 116, 468, 1361, 2748, 3838, 3625, 3202, 3262, 3747, 4198, 4075, 3496, 3207, 3213, 3344, 3355, 3161, 2899, 2726, 2714, 2737, 2700, 2569, 2450, 2399, 2428, 2469, 2484, 2475, 2493, 2564, 2678, 2806, 2934, 3078, 3259, 3490, 3750, 4017, 4281, 4547, 4816, 5085, 5345, 5589, 5814, 6024, 6225, 6414, 6591, 6753, 6902, 7043, 7179, 7312, 7436, 7558, 7680, 7799, 7946, 7875, 9236, 10117, 7991, 7480, 7533, 7869, 7824, 7451, 6952, 6551, 6510, 6466, 6372, 5985, 5661, 5379, 5295, 5162, 4991, 4720, 4496, 4346, 4278, 4246, 4267, 4505, 4805, 4800, 4710, 4762, 4948, 5312, 5545, 5483, 5509, 5719, 6201, 6778, 6754, 6346, 6089, 6076, 6106, 6021, 5764, 5457, 5215, 5079, 4958, 4780, 4540, 4304, 4129, 4010, 3905, 3778, 3643, 3532, 3466, 3430, 3406, 3379, 3222, 3963, -306, -13222, -5639, -1122, -705, -4316, -5848, -6775, -5083, -4084, -4068, -5509, -6671, -6343, -5263, -4539, -4942, -5456, -5847, -5426, -5017, -4736, -4991, -5198, -5217, -4863, -4420, -3932, -3054, -1774, -1323, -1403, -1150, -535, 442, 1348, 1407, 1451, 1918, 2944, 4370, 4811, 4097, 3557, 3600, 3899, 4021, 3772, 3347, 3028, 2965, 2996, 2931, 2702, 2446, 2291, 2270, 2284, 2249, 2165, 2102, 2115, 1976, 3155, -2242, -29657, -21056, -7208, -4644, -11239, -14860, -17097, -13072, -10139, -8481, -10966, -12748, -12631, -10320, -8372, -8229, -9048, -9732, -8961, -7873, -6960, -7192, -7603, -7902, -7534, -7165, -7055, -7418, -7846, -8069, -8064, -8031, -8190, -8458, -8714, -8780, -8744, -8671, -8673, -8671, -8614, -8447, -8226, -8000, -7802, -7604, -7378, -7123, -6865, -6639, -6444, -6266, -6081, -5887, -5680, -5443, -5108, -4470, -3336, -2558, -2576, -2519, -2102, -1291, -277};