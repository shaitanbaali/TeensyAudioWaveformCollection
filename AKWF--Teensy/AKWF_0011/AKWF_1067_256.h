/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1067 256 samples */
 
const int16_t AKWF_1067_256_DATA [256] = 
{19548, 34913, 31735, 32014, 31751, 31487, 31224, 30962, 30698, 30434, 30171, 29908, 29644, 29381, 29117, 28854, 28591, 28327, 28064, 27801, 27537, 27274, 27011, 26747, 26484, 26221, 25957, 25693, 25430, 25167, 24904, 24641, 24377, 24114, 23850, 23586, 23323, 23060, 22796, 22534, 22270, 22006, 21744, 21480, 21216, 20954, 20690, 20427, 20164, 19900, 19636, 19373, 19109, 18847, 18584, 18320, 18057, 17793, 17530, 17266, 17003, 16739, 16476, 16213, 15950, 15687, 15423, 15159, 14896, 14633, 14369, 14106, 13843, 13579, 13316, 13052, 12789, 12526, 12263, 11999, 11736, 11473, 11209, 10946, 10682, 10419, 10156, 9892, 9629, 9366, 9102, 8839, 8576, 8312, 8049, 7786, 7522, 7259, 6995, 6732, 6469, 6206, 5942, 5679, 5416, 5152, 4889, 4625, 4361, 4098, 3835, 3572, 3309, 3045, 2781, 2519, 2228, 2112, 1092, -135, 31, 0, 304, -1171, 8199, 13413, 12917, 12337, -17166, -28679, -26426, -26782, -26688, -26588, -26487, -26383, -26275, -26164, -26051, -25935, -25816, -25694, -25570, -25442, -25312, -25178, -25042, -24903, -24761, -24615, -24468, -24318, -24164, -24008, -23848, -23687, -23521, -23354, -23183, -23009, -22833, -22653, -22471, -22285, -22098, -21907, -21713, -21517, -21316, -21114, -20909, -20700, -20490, -20276, -20060, -19839, -19616, -19391, -19163, -18933, -18698, -18461, -18221, -17979, -17733, -17485, -17234, -16979, -16722, -16462, -16199, -15934, -15665, -15394, -15119, -14879, -14655, -14428, -14200, -13971, -13741, -13511, -13279, -13047, -12813, -12579, -12343, -12106, -11869, -11630, -11391, -11151, -10909, -10666, -10422, -10178, -9933, -9687, -9439, -9190, -8942, -8691, -8439, -8188, -7934, -7680, -7425, -7168, -6912, -6653, -6394, -6134, -5873, -5610, -5348, -5083, -4818, -4553, -4286, -4018, -3749, -3478, -3208, -2935, -2663, -2389, -2093, -1938, -523, 104, -329, 1168, -8193, -13417, -13575, -10948};