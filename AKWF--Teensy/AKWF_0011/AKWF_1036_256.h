/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1036 256 samples */
 
const int16_t AKWF_1036_256_DATA [256] = 
{320, 896, 1455, 2006, 2548, 3077, 3597, 4101, 4595, 5080, 5553, 6019, 6482, 6941, 7399, 7861, 8327, 8803, 9288, 9784, 10294, 10818, 11355, 11905, 12467, 13038, 13619, 14201, 14783, 15361, 15926, 16475, 17002, 17497, 17955, 18370, 18734, 19041, 19283, 19455, 19550, 19565, 19495, 19338, 19088, 18748, 18315, 17789, 17174, 16471, 15684, 14820, 13879, 12872, 11807, 10686, 9524, 8329, 7103, 5862, 4615, 3365, 2130, 912, -280, -1434, -2547, -3616, -4627, -5579, -6470, -7293, -8046, -8730, -9338, -9874, -10337, -10725, -11042, -11288, -11463, -11571, -11612, -11588, -11500, -11352, -11143, -10874, -10546, -10160, -9715, -9213, -8621, -7890, -7006, -5936, -4632, -3066, -1215, 925, 3330, 5971, 8798, 11729, 14701, 17638, 20449, 23083, 25478, 27577, 29352, 30771, 31814, 32479, 32763, 32671, 32216, 31418, 30301, 28884, 27202, 25288, 23165, 20878, 18460, 15941, 13366, 10769, 8179, 5639, 3175, 812, -1415, -3492, -5401, -7119, -8648, -9981, -11109, -12044, -12788, -13351, -13749, -13993, -14100, -14090, -13977, -13782, -13520, -13208, -12862, -12494, -12115, -11736, -11362, -11002, -10660, -10336, -10032, -9749, -9482, -9235, -9003, -8783, -8576, -8378, -8189, -8007, -7834, -7671, -7518, -7379, -7255, -7153, -7073, -7019, -6996, -7006, -7054, -7140, -7266, -7434, -7644, -7894, -8182, -8504, -8857, -9235, -9632, -10042, -10457, -10869, -11271, -11656, -12013, -12339, -12625, -12864, -13054, -13187, -13265, -13282, -13240, -13138, -12978, -12765, -12502, -12193, -11846, -11467, -11062, -10640, -10208, -9774, -9345, -8928, -8531, -8158, -7815, -7507, -7236, -7004, -6813, -6661, -6549, -6475, -6434, -6424, -6438, -6474, -6523, -6580, -6640, -6694, -6737, -6765, -6769, -6748, -6694, -6604, -6476, -6307, -6095, -5842, -5545, -5208, -4833, -4419, -3972, -3496, -2993, -2468, -1928, -1372, -810, -233};