/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1046 256 samples */
 
const int16_t AKWF_1046_256_DATA [256] = 
{4751, 10466, 14512, 17922, 20837, 23358, 25540, 27404, 28979, 30274, 31292, 32035, 32506, 32864, 28138, 23742, 21056, 18629, 16497, 14575, 12807, 11173, 9656, 8232, 6902, 5657, 4485, 3388, 2364, 1403, 509, -320, -1091, -1800, -2449, -3040, -3571, -4047, -4464, -4825, -5129, -5377, -5570, -5705, -5786, -5811, -5807, -5807, -5806, -5805, -5804, -5803, -5801, -5799, -5797, -5796, -5792, -5791, -5789, -5787, -5785, -5783, -5780, -5778, -5775, -5773, -5771, -5769, -5765, -5763, -5761, -5758, -5756, -5754, -5751, -5748, -5746, -5743, -5740, -5737, -5734, -5731, -5729, -5727, -5724, -5722, -5719, -5716, -5713, -5711, -5707, -5705, -5702, -5699, -5697, -5694, -5692, -5690, -5687, -5685, -5681, -5679, -5676, -5672, -5670, -5667, -5664, -5662, -5659, -5656, -5654, -5652, -5648, -5646, -5643, -5640, -5637, -5635, -5633, -5630, -5627, -5624, -5621, -5620, -5617, -5614, -5611, -5609, -5601, -5617, -5553, -4547, -4391, -4437, -4433, -4437, -4440, -4441, -4443, -4441, -4322, -4918, -412, 7902, 12163, 15852, 18947, 21603, 23906, 25891, 27575, 28984, 30119, 30987, 31525, 32220, 30511, 25176, 22259, 19798, 17657, 15744, 13997, 12381, 10883, 9481, 8163, 6928, 5764, 4666, 3635, 2664, 1752, 897, 97, -649, -1340, -1982, -2573, -3111, -3601, -4041, -4431, -4773, -5066, -5310, -5506, -5653, -5753, -5804, -5813, -5810, -5811, -5810, -5806, -5806, -5805, -5802, -5801, -5797, -5796, -5793, -5791, -5789, -5787, -5785, -5781, -5779, -5777, -5775, -5773, -5771, -5768, -5764, -5762, -5760, -5756, -5754, -5755, -5756, -5756, -5758, -5756, -5755, -5756, -5756, -5754, -5754, -5753, -5754, -5739, -5993, -6269, -6420, -6553, -6666, -6763, -6847, -6919, -6980, -7030, -7068, -7098, -7106, -7173, -6716, -6026, -5663, -5349, -5096, -4887, -4721, -4595, -4486, -4543, -3945};