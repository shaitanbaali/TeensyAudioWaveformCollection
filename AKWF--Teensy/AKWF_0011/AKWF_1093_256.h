/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1093 256 samples */
 
const int16_t AKWF_1093_256_DATA [256] = 
{49, -13, 2, 0, 0, 0, 13, -61, 348, 924, 849, 900, 695, 2686, 3774, 3560, 3606, 3563, 3754, 4473, 4462, 4462, 4463, 4463, 4528, 4171, 5698, 12804, 13771, 15802, 15622, 15655, 15656, 15655, 15655, 15656, 15655, 15656, 15656, 15656, 15655, 15588, 15957, 13938, 11034, 11403, 11336, 11334, 11334, 11334, 11335, 11335, 11335, 11334, 11334, 11476, 10711, 14695, 20441, 19645, 19792, 19793, 19792, 19657, 20416, 16964, 6077, 7090, 6983, 6979, 6979, 6979, 6979, 6979, 6979, 6982, 6969, 7017, 7764, 7864, 7839, 7843, 7850, 7813, 7976, 8704, 8709, 8705, 8707, 8708, 8707, 8713, 8684, 8806, 9548, 9579, 9569, 9571, 9613, 9388, 11288, 12494, 12268, 12290, 13004, 13209, 13163, 13172, 13172, 13171, 13172, 13171, 13171, 13171, 13171, 13216, 12972, 14708, 16105, 15862, 15907, 15907, 15906, 15907, 15907, 15946, 15708, 16904, 18335, 14042, 16014, 6991, -28917, -27806, -27930, -27965, -27964, -27964, -27965, -27927, -28134, -26142, -25053, -25268, -25230, -25229, -25229, -25229, -25229, -25225, -25246, -25165, -24417, -24351, -24331, -24532, -23517, -21472, -21663, -21631, -21629, -21617, -21687, -21088, -20707, -20779, -20766, -20764, -20761, -20791, -20095, -19860, -19911, -19901, -19900, -19902, -19901, -19893, -19941, -19271, -18989, -19047, -19037, -19037, -19038, -19038, -19037, -19023, -19100, -18612, -18109, -18322, -17561, -20945, -32187, -31793, -31834, -31850, -31805, -32035, -31143, -23680, -23306, -23418, -23392, -23392, -23392, -23392, -23392, -23392, -23393, -23393, -23436, -23187, -26522, -27956, -27660, -27713, -27713, -27713, -27712, -27713, -27713, -27714, -27713, -27713, -27671, -27897, -25996, -24792, -25020, -24977, -24961, -25006, -24924, -17535, -16315, -15995, -15602, -15668, -15656, -15656, -15657, -15611, -15857, -14121, -12711, -13017, -12664, -12011, -12067, -12057, -12057, -11862, -12916, -7257};