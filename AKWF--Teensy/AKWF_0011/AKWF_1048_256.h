/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1048 256 samples */
 
const int16_t AKWF_1048_256_DATA [256] = 
{165, -85, 2914, 6835, 6927, 7615, 8212, 8806, 9402, 9997, 10590, 11185, 11780, 12373, 12968, 13563, 14154, 14748, 15342, 15934, 16527, 17121, 17713, 18305, 18897, 19489, 20081, 20674, 21265, 21856, 22448, 23039, 23630, 24220, 24810, 25402, 25992, 26583, 27173, 27760, 28351, 28941, 29529, 30119, 30708, 31297, 31856, 32605, 30893, 29754, 29383, 28851, 28340, 27829, 27319, 26806, 26295, 25785, 25274, 24764, 24254, 23742, 23232, 22723, 22212, 21702, 21192, 20681, 20172, 19662, 19152, 18643, 18133, 17623, 17115, 16606, 16096, 15588, 15079, 14569, 14063, 13553, 13045, 12538, 12028, 11520, 11014, 10506, 9999, 9492, 8985, 8478, 7971, 7463, 6956, 6449, 5942, 5438, 4931, 4425, 3920, 3413, 2907, 2402, 1897, 1392, 886, 382, -123, -626, -1131, -1636, -2139, -2644, -3148, -3651, -4156, -4659, -5162, -5666, -6169, -6672, -7176, -7678, -8180, -8683, -9185, -9687, -10190, -10692, -11193, -11696, -12196, -12699, -13199, -13700, -14202, -14703, -15202, -15702, -16203, -16703, -17203, -17704, -18203, -18704, -19204, -19704, -20204, -20702, -21203, -21708, -22142, -24832, -25245, -24844, -24624, -24375, -24127, -23878, -23629, -23379, -23130, -22882, -22632, -22383, -22134, -21885, -21635, -21387, -21137, -20887, -20638, -20390, -20139, -19891, -19643, -19393, -19145, -18895, -18647, -18398, -18149, -17901, -17651, -17404, -17155, -16906, -16658, -16409, -16161, -15914, -15665, -15416, -15169, -14920, -14672, -14425, -14176, -13929, -13681, -13433, -13186, -12939, -12691, -12444, -12196, -11949, -11702, -11454, -11208, -10962, -10714, -10466, -10220, -9973, -9726, -9480, -9233, -8987, -8740, -8494, -8249, -8002, -7756, -7511, -7263, -7017, -6772, -6527, -6280, -6035, -5789, -5543, -5298, -5053, -4807, -4562, -4316, -4072, -3827, -3581, -3336, -3092, -2847, -2602, -2358, -2112, -1867, -1623, -1380, -1134, -891, -646, -403, -155};