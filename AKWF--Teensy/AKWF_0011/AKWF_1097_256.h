/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1097 256 samples */
 
const int16_t AKWF_1097_256_DATA [256] = 
{525, 1367, 2189, 3012, 3831, 4647, 5463, 6270, 7076, 7877, 8670, 9460, 10243, 11015, 11784, 12545, 13297, 14040, 14775, 15498, 16215, 16920, 17612, 18295, 18966, 19624, 20270, 20905, 21525, 22133, 22727, 23304, 23871, 24421, 24955, 25475, 25978, 26464, 26935, 27390, 27827, 28248, 28650, 29034, 29402, 29751, 30082, 30394, 30689, 30963, 31220, 31456, 31673, 31871, 32049, 32209, 32348, 32467, 32567, 32646, 32707, 32746, 32765, 32766, 32745, 32705, 32646, 32564, 32467, 32305, 31956, 31390, 30751, 30206, 29791, 29427, 29030, 28578, 28086, 27575, 27062, 26552, 26048, 25554, 25069, 24591, 24125, 23664, 23215, 22775, 22341, 21917, 21500, 21090, 20690, 20297, 19909, 19532, 19161, 18795, 18438, 18088, 17743, 17406, 17075, 16751, 16397, 15877, 15129, 14273, 13484, 12811, 12200, 11556, 10853, 10105, 9321, 8521, 7714, 6899, 6079, 5257, 4430, 3604, 2777, 1947, 1119, 290, -537, -1364, -2188, -3013, -3832, -4648, -5464, -6271, -7077, -7878, -8671, -9461, -10243, -11016, -11785, -12546, -13297, -14041, -14775, -15499, -16215, -16920, -17612, -18295, -18966, -19624, -20271, -20905, -21526, -22134, -22728, -23305, -23871, -24421, -24955, -25476, -25978, -26464, -26935, -27390, -27827, -28248, -28650, -29034, -29402, -29751, -30082, -30394, -30689, -30963, -31220, -31456, -31673, -31871, -32049, -32209, -32348, -32467, -32567, -32646, -32707, -32746, -32765, -32766, -32745, -32705, -32646, -32564, -32467, -32305, -31956, -31390, -30751, -30206, -29791, -29427, -29030, -28578, -28086, -27575, -27062, -26552, -26048, -25555, -25069, -24591, -24125, -23664, -23215, -22775, -22341, -21917, -21500, -21091, -20690, -20298, -19910, -19533, -19161, -18795, -18439, -18088, -17743, -17407, -17075, -16751, -16398, -15877, -15129, -14274, -13484, -12811, -12201, -11557, -10854, -10105, -9322, -8522, -7715, -6900, -6080, -5258, -4431, -3605, -2778, -1950, -1124, -280};