/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1009 256 samples */
 
const int16_t AKWF_1009_256_DATA [256] = 
{143, 579, 1005, 1433, 1859, 2287, 2715, 3141, 3568, 3996, 4422, 4849, 5276, 5701, 6129, 6555, 6981, 7407, 7833, 8258, 8684, 9110, 9535, 9961, 10386, 10810, 11236, 11661, 12085, 12510, 12934, 13358, 13783, 14207, 14631, 15055, 15479, 15903, 16327, 16750, 17174, 17597, 18018, 18442, 18866, 19287, 19711, 20133, 20555, 20978, 21400, 21822, 22244, 22666, 23088, 23510, 23931, 24297, 24967, 23450, 19015, 14808, 10570, 6382, 1909, -466, -278, -323, -327, -330, -367, -227, -1010, -4423, -7902, -11358, -14827, -18287, -21707, -25348, -27941, -25957, -23519, -21196, -18840, -16485, -14135, -11778, -9423, -7073, -4736, -2299, -385, -294, -316, -308, -307, -308, -310, -309, -310, -311, -312, -313, -313, -315, -316, -316, -318, -319, -319, -321, -322, -322, -324, -325, -326, -326, -327, -329, -329, -330, -331, -332, -332, -334, -335, -335, -335, -336, -338, -338, -339, -338, -339, -341, -341, -340, -341, -342, -341, -342, -341, -342, -344, -343, -343, -343, -343, -343, -343, -343, -344, -343, -341, -342, -341, -342, -341, -340, -341, -341, -339, -338, -338, -337, -338, -336, -335, -335, -334, -333, -332, -332, -331, -329, -328, -327, -326, -325, -325, -323, -322, -320, -319, -318, -316, -315, -313, -312, -310, -309, -307, -306, -304, -302, -301, -299, -296, -295, -293, -291, -289, -287, -285, -283, -280, -278, -276, -273, -273, -274, -276, -277, -276, -303, -175, -1581, -4350, -6947, -9571, -12202, -14827, -17452, -20082, -22706, -25330, -27914, -30717, -32364, -30552, -28617, -26721, -24809, -22902, -20990, -19077, -17171, -15259, -13347, -11441, -9529, -7618, -5712, -3817, -1845, -256, -156, -177, -166, -163, -162, -160, -158, -156, -155};