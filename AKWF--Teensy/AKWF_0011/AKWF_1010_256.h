/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1010 256 samples */
 
const int16_t AKWF_1010_256_DATA [256] = 
{188, 678, 1160, 1641, 2122, 2604, 3086, 3567, 4049, 4531, 5011, 5492, 5974, 6454, 6935, 7416, 7895, 8376, 8857, 9336, 9816, 10296, 10775, 11256, 11735, 12213, 12694, 13172, 13651, 14130, 14609, 15087, 15565, 16044, 16522, 17001, 17477, 17955, 18432, 18910, 19388, 19865, 20342, 20819, 21296, 21772, 22249, 22726, 23201, 23678, 24130, 24709, 24580, 22788, 21004, 19223, 17438, 15656, 13868, 12084, 10301, 8514, 6731, 4949, 3163, 1381, -400, -2185, -3965, -5746, -7530, -9309, -11090, -12872, -14649, -16429, -18211, -19986, -21766, -23545, -25319, -27098, -28859, -30655, -32366, -29822, -25712, -21888, -18011, -14140, -10259, -6396, -2497, 1277, 2073, 1925, 1963, 1964, 1964, 1965, 1965, 1965, 1964, 1964, 1964, 1963, 1962, 1961, 1960, 1960, 1959, 1958, 1956, 1956, 1955, 1954, 1953, 1952, 1951, 1950, 1948, 1948, 1946, 1945, 1945, 1944, 1943, 1942, 1940, 1940, 1939, 1938, 1938, 1937, 1937, 1935, 1935, 1934, 1932, 1933, 1932, 1931, 1932, 1932, 1930, 1929, 1930, 1930, 1930, 1929, 1928, 1929, 1929, 1929, 1929, 1929, 1929, 1929, 1928, 1929, 1930, 1930, 1930, 1930, 1930, 1931, 1932, 1931, 1932, 1933, 1933, 1934, 1934, 1935, 1937, 1937, 1937, 1939, 1940, 1940, 1941, 1942, 1944, 1945, 1946, 1947, 1948, 1949, 1951, 1952, 1950, 1948, 1946, 1945, 1945, 1945, 1945, 1945, 1939, 1940, 1956, 230, -2271, -4638, -7031, -9419, -11811, -14204, -16590, -18982, -21374, -23759, -26151, -28487, -31100, -32137, -29637, -27172, -24710, -22242, -19776, -17304, -14837, -12370, -9898, -7432, -4966, -2683, 760, -1870, -12651, -11851, -11381, -10921, -10437, -9953, -9468, -8985, -8501, -8016, -7533, -7049, -6564, -6082, -5597, -5114, -4631, -4147, -3663, -3181, -2697, -2215, -1732, -1250, -769, -278};