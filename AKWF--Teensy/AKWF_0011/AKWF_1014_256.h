/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1014 256 samples */
 
const int16_t AKWF_1014_256_DATA [256] = 
{23125, 33193, 29528, 28422, 26916, 25407, 23896, 22388, 20876, 19363, 17855, 16343, 14830, 13163, 12524, 3904, -619, 282, 110, 108, 106, 105, 103, 102, 101, 100, 98, 97, 97, 96, 95, 95, 94, 93, 93, 94, 92, 91, 92, 92, 91, 92, 91, 89, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 89, 90, 89, 87, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 274, -705, 4905, 12149, 12882, 14697, 16346, 17989, 19637, 21284, 22927, 24573, 26219, 27854, 28520, 35551, 2303, -36390, -28984, -28447, -26833, -25223, -23613, -21998, -20387, -18774, -17160, -15549, -13791, -12989, -7434, 808, -102, 70, 71, 73, 74, 75, 77, 78, 79, 79, 81, 82, 81, 83, 84, 83, 84, 85, 86, 85, 86, 86, 85, 87, 88, 87, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 85, -9, 532, -7929, -12066, -13033, -14675, -16221, -17765, -19305, -20852, -22395, -23935, -25480, -27022, -28538, -30425, -30371, -23232};