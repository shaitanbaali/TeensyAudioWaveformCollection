/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1012 256 samples */
 
const int16_t AKWF_1012_256_DATA [256] = 
{8885, 9221, 9549, 9877, 10204, 10532, 10859, 11186, 11513, 11840, 12166, 12492, 12818, 13143, 13469, 13794, 14119, 14444, 14769, 15093, 15418, 15742, 16066, 16390, 16715, 17038, 17362, 17685, 18008, 18332, 18656, 18978, 19301, 19624, 19946, 20270, 20592, 20914, 21238, 21559, 21881, 22203, 22525, 22847, 23170, 23491, 23811, 24134, 24456, 24777, 25098, 25419, 25740, 26060, 26381, 26703, 27024, 27344, 27666, 27987, 28305, 28626, 28947, 29266, 29587, 29907, 30227, 30546, 30865, 31186, 31506, 31825, 32138, 32483, 32678, 32131, 31494, 30880, 30259, 29639, 29019, 28398, 27779, 27160, 26541, 25920, 25302, 24681, 24062, 23443, 22822, 22204, 21586, 20967, 20348, 19730, 19110, 18492, 17874, 17256, 16638, 16022, 15403, 14786, 14169, 13551, 12934, 12317, 11700, 11085, 10468, 9790, 9511, 7539, -1184, -1075, -2072, -8309, -8567, -8711, -8905, -9086, -9268, -9449, -9628, -9810, -9989, -10169, -10348, -10527, -10706, -10885, -11064, -11243, -11421, -11599, -11777, -11956, -12133, -12311, -12488, -12666, -12843, -13020, -13196, -13375, -13552, -13729, -13906, -14082, -14257, -14434, -14611, -14788, -14963, -15139, -15316, -15492, -15667, -15843, -16019, -16194, -16370, -16546, -16720, -16896, -17072, -17246, -17421, -17597, -17772, -17946, -18121, -18296, -18471, -18645, -18819, -18994, -19168, -19343, -19517, -19691, -19865, -20039, -20213, -20387, -20561, -20735, -20908, -21082, -21255, -21428, -21602, -21775, -21948, -22121, -22295, -22467, -22641, -22813, -22985, -23159, -23331, -23503, -23675, -23848, -24022, -24194, -24366, -24538, -24710, -24882, -25054, -25226, -25401, -25588, -25770, -25989, -25918, -25387, -24872, -24354, -23837, -23319, -22801, -22283, -21766, -21248, -20730, -20213, -19695, -19178, -18661, -18143, -17627, -17109, -16592, -16077, -15560, -15043, -14528, -14011, -13494, -12979, -12462, -11945, -11431, -10915, -10398, -9884, -9368, -8727, -8896, -3868, -122, -807};