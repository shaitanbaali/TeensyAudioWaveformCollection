/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1037 256 samples */
 
const int16_t AKWF_1037_256_DATA [256] = 
{1045, 2985, 4884, 6776, 8645, 10488, 12295, 14058, 15771, 17430, 19019, 20545, 21994, 23357, 24638, 25828, 26919, 27914, 28802, 29581, 30253, 30812, 31256, 31585, 31774, 31928, 32606, 31891, 30556, 28975, 27262, 25555, 23969, 22616, 21595, 20871, 21009, 21386, 20295, 18889, 17248, 15520, 13844, 12326, 11071, 10176, 9595, 10123, 10169, 9328, 8331, 7127, 5765, 4289, 2734, 1121, -507, -2125, -3709, -5230, -6661, -7984, -9173, -10209, -11081, -11772, -12260, -12626, -12409, -11599, -11194, -10493, -9637, -8642, -7531, -6318, -5023, -3660, -2238, -775, 713, 2223, 3739, 5244, 6735, 8195, 9612, 10983, 12294, 13532, 14696, 15772, 16754, 17639, 18415, 19081, 19631, 20061, 20380, 20487, 20899, 21272, 20188, 18788, 17146, 15421, 13746, 12231, 10976, 10083, 9501, 10032, 10079, 9237, 8241, 7039, 5677, 4202, 2647, 1036, -592, -2209, -3794, -5314, -6743, -8067, -9256, -10292, -11165, -11855, -12342, -12709, -12487, -11729, -11514, -11090, -10582, -10001, -9364, -8686, -7978, -7259, -6539, -5831, -5147, -4497, -3895, -3348, -2864, -2451, -2118, -1863, -1719, -1581, -896, -1603, -2930, -4503, -6207, -7908, -9488, -10831, -11844, -12553, -12433, -11760, -11840, -11846, -11868, -11892, -11919, -11950, -11983, -12018, -12054, -12091, -12129, -12168, -12207, -12245, -12283, -12320, -12355, -12390, -12423, -12453, -12482, -12510, -12532, -12553, -12573, -12587, -12599, -12607, -12600, -12669, -12349, -11589, -11371, -10944, -10436, -9854, -9216, -8535, -7828, -7107, -6386, -5678, -4993, -4342, -3739, -3193, -2708, -2294, -1962, -1705, -1559, -1422, -737, -1444, -2772, -4344, -6049, -7751, -9328, -10671, -11686, -12401, -12253, -11867, -12949, -14346, -15980, -17697, -19366, -20876, -22120, -23006, -23577, -23039, -22383, -21861, -21043, -20071, -18949, -17698, -16337, -14872, -13320, -11694, -9994, -8241, -6440, -4598, -2733, -808};