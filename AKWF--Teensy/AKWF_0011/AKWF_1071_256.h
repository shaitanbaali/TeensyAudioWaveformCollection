/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1071 256 samples */
 
const int16_t AKWF_1071_256_DATA [256] = 
{32545, 32329, 32116, 31906, 31695, 31483, 31272, 31062, 30853, 30642, 30434, 30226, 30018, 29811, 29604, 29397, 29191, 28985, 28779, 28575, 28371, 28165, 27963, 27761, 27557, 27356, 27154, 26953, 26752, 26552, 26352, 26153, 25952, 25755, 25556, 25359, 25162, 24966, 24768, 24573, 24376, 24189, 24001, 23836, 23689, 23540, 23391, 23242, 23096, 22949, 22803, 22657, 22513, 22370, 22226, 22085, 21942, 21802, 21662, 21522, 21384, 21246, 21110, 20972, 20837, 20673, 20699, 19434, 18817, 19292, 19563, 19865, 20167, 20471, 20773, 21076, 21379, 21681, 21984, 22287, 22589, 22892, 23195, 23497, 23800, 24103, 24405, 24708, 25011, 25313, 25617, 25919, 26219, 26522, 26825, 27127, 27430, 27733, 28035, 28338, 28641, 28944, 29247, 29549, 29852, 30155, 30457, 30760, 31063, 31365, 31668, 31971, 31748, 34911, 11279, -2232, 498, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -430, 1955, -9343, -33808, -31212, -31467, -31286, -31103, -30921, -30738, -30555, -30372, -30190, -30007, -29825, -29642, -29459, -29276, -29094, -28911, -28729, -28546, -28363, -28180, -27998, -27816, -27633, -27450, -27267, -27084, -26902, -26720, -26537, -26354, -26173, -25991, -25808, -25626, -25443, -25260, -25078, -24895, -24712, -24530, -24347, -24164, -23982, -23799, -23616, -23434, -23251, -23068, -22886, -22703, -22520, -22338, -22155, -21972, -21790, -21607, -21424, -21243, -21062, -20879, -20696, -20513, -20330, -20148, -19966, -19783, -19600, -19417, -19234, -19052, -18870, -18687, -18508, -18311, -18196, -18460, -18763, -19057, -19353, -19651, -19946, -20243, -20539, -20836, -21133, -21429, -21726, -22022, -22319, -22614, -22912, -23209, -23504, -23802, -24097, -24394, -24690, -24987, -25282, -25580, -25877, -26173, -26470, -26765, -27063, -27358, -27655, -27951, -28249, -28545, -28841, -29138, -29433, -29731, -30027, -30324, -30619, -30917, -30813, -33340, -23279, 1767, -383, -1, 0};