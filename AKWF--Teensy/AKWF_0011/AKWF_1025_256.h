/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1025 256 samples */
 
const int16_t AKWF_1025_256_DATA [256] = 
{354, 1149, 1903, 2634, 3341, 4020, 4671, 5293, 5886, 6448, 6977, 7476, 7943, 8379, 8780, 9150, 9485, 9789, 10058, 10294, 10498, 10669, 10809, 10918, 10994, 11042, 11058, 11048, 11008, 10941, 10848, 10730, 10587, 10423, 10237, 10029, 9804, 9560, 9301, 9026, 8738, 8438, 8128, 7809, 7482, 7151, 6814, 6474, 6134, 5794, 5456, 5122, 4793, 4470, 4154, 3850, 3555, 3274, 3003, 2749, 2512, 2290, 2089, 1905, 1740, 1599, 1479, 1384, 1309, 1262, 1237, 1239, 1266, 1319, 1399, 1505, 1638, 1797, 1983, 2197, 2435, 2700, 2991, 3306, 3645, 4010, 4396, 4805, 5238, 5688, 6160, 6649, 7155, 7680, 8218, 8769, 9334, 9906, 10490, 11084, 11680, 12282, 12890, 13496, 14104, 14711, 15312, 15909, 16498, 17079, 17650, 18208, 18752, 19283, 19795, 20288, 20762, 21214, 21640, 22043, 22420, 22769, 23088, 23377, 23633, 23859, 24049, 24204, 24323, 24405, 24450, 24456, 24423, 24350, 24237, 24083, 23887, 23651, 23374, 23054, 22692, 22291, 21848, 21362, 20840, 20275, 19670, 19028, 18347, 17630, 16876, 16086, 15263, 14408, 13519, 12601, 11655, 10679, 9680, 8655, 7607, 6539, 5452, 4345, 3225, 2090, 943, -212, -1375, -2546, -3719, -4895, -6071, -7241, -8412, -9573, -10726, -11868, -12999, -14112, -15212, -16293, -17351, -18390, -19403, -20389, -21350, -22279, -23176, -24045, -24877, -25671, -26431, -27153, -27834, -28476, -29076, -29633, -30147, -30615, -31040, -31418, -31751, -32037, -32277, -32470, -32614, -32711, -32761, -32764, -32721, -32630, -32493, -32312, -32084, -31813, -31499, -31140, -30741, -30300, -29820, -29303, -28746, -28155, -27529, -26870, -26181, -25460, -24711, -23938, -23135, -22312, -21469, -20603, -19723, -18824, -17910, -16988, -16055, -15111, -14162, -13209, -12253, -11299, -10343, -9391, -8446, -7506, -6573, -5655, -4744, -3849, -2970, -2108, -1266, -427};