/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1029 256 samples */
 
const int16_t AKWF_1029_256_DATA [256] = 
{97, 104, 111, 117, 120, 124, 129, 132, 134, 137, 140, 141, 144, 145, 146, 147, 147, 148, 150, 151, 151, 152, 152, 151, 171, 95, 496, 2350, 4302, 6233, 8164, 10093, 12024, 13949, 15873, 17796, 19712, 21628, 23542, 25449, 27357, 29226, 31273, 32417, 30636, 28684, 26777, 24859, 22947, 21032, 19121, 17217, 15310, 13407, 11512, 9616, 7725, 5840, 3960, 2072, 232, -239, -162, -186, -191, -196, -201, -204, -207, -209, -211, -214, -216, -218, -219, -221, -220, -222, -224, -224, -226, -225, -225, -246, -163, -697, -2310, -3889, -5464, -7034, -8606, -10173, -11730, -13289, -14839, -16385, -17930, -19467, -20998, -22529, -24049, -25566, -27049, -28711, -28725, -27095, -25521, -23765, -22289, -20810, -19331, -17857, -16391, -14924, -13460, -12078, -10627, -9157, -7702, -6198, -5042, -872, 576, 2667, 4827, 6116, 7513, 8891, 10267, 11636, 12998, 14357, 15707, 17053, 18395, 19726, 21053, 22377, 23691, 25001, 26281, 27685, 28409, 27161, 25851, 24564, 23276, 21998, 20719, 19448, 18184, 16924, 15670, 14424, 13180, 11946, 10718, 9492, 8277, 7065, 5860, 4662, 3471, 2290, 1095, -11, -202, -165, -181, -183, -186, -189, -191, -194, -196, -198, -200, -203, -204, -204, -206, -208, -208, -224, -158, -671, -1877, -3006, -4137, -5265, -6381, -7489, -8596, -9688, -10775, -11857, -12928, -13993, -15052, -16101, -17142, -18177, -19202, -20222, -21234, -22236, -23232, -24220, -25199, -26172, -27137, -28091, -29041, -29969, -30951, -31698, -30931, -29962, -29059, -28151, -27251, -26357, -25472, -24596, -23724, -22863, -22009, -21162, -20325, -19495, -18671, -17856, -17049, -16249, -15461, -14677, -13901, -13135, -12375, -11624, -10881, -10146, -9417, -8700, -7988, -7283, -6589, -5902, -5222, -4551, -3889, -3234, -2587, -1948, -1319, -683};