/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1091 256 samples */
 
const int16_t AKWF_1091_256_DATA [256] = 
{676, 3196, 5690, 8199, 10680, 13120, 15493, 17774, 19945, 21992, 23892, 25637, 27214, 28605, 29811, 30818, 31618, 32211, 32591, 32756, 32704, 32437, 31960, 31270, 30378, 29291, 28014, 26559, 24939, 23155, 21223, 19150, 16929, 14577, 12080, 9433, 6631, 3661, 513, -2795, -6269, -9850, -13460, -16961, -20148, -22695, -24166, -24073, -20822, -17835, -21428, -18352, -14758, -10670, -6647, -2940, 220, 2712, 4495, 5540, 5865, 5498, 4465, 2805, 558, -2200, -5370, -8783, -12153, -15081, -16964, -17156, -13469, -10692, -17388, -14754, -11653, -8030, -4515, -1388, 1150, 3025, 4204, 4698, 4550, 3796, 2481, 649, -1649, -4347, -7370, -10591, -13841, -16904, -19478, -21190, -21640, -20083, -16723, -19036, -17275, -13385, -9213, -4803, -480, 3553, 7146, 10243, 12792, 14796, 16270, 17252, 17780, 17903, 17676, 17144, 16358, 15368, 14215, 12940, 11577, 10162, 8724, 7285, 5878, 4513, 3213, 1998, 871, -143, -1046, -1826, -2470, -2982, -3349, -3574, -3648, -3572, -3336, -2943, -2380, -1649, -737, 366, 1661, 3161, 4871, 6776, 8873, 11116, 13439, 15738, 17836, 19481, 20315, 19859, 17371, 11823, 12852, 11697, 7118, 2662, -2003, -6407, -10292, -13511, -15979, -17638, -18493, -18541, -17803, -16296, -14088, -11291, -8111, -4946, -2443, -1537, -3844, -11869, -3903, -325, -4081, -6911, -10005, -12560, -14328, -15173, -15050, -13964, -12002, -9341, -6313, -3523, -1940, -2697, -10689, -11342, 1136, -2795, -5271, -8427, -10962, -12688, -13434, -13174, -11944, -9856, -7116, -4037, -1179, 613, 365, -5535, -8941, 3055, 311, -2367, -5538, -8298, -10411, -11718, -12184, -11837, -10720, -8917, -6513, -3620, -425, 2825, 5780, 7932, 8695, 7020, 2633, 7737, 7674, 4180, 732, -2920, -6327, -9293, -11706, -13511, -14725, -15371, -15498, -15158, -14401, -13329, -11895, -10187, -8349, -6260, -4055, -1673};