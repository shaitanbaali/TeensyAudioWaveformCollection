/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1095 256 samples */
 
const int16_t AKWF_1095_256_DATA [256] = 
{497, 1338, 2003, 2469, 2805, 3091, 3349, 3563, 3721, 3849, 3986, 4152, 4332, 4515, 4728, 5016, 5408, 5880, 6371, 6812, 7177, 7481, 7747, 7993, 8216, 8417, 8610, 8807, 9020, 9256, 9516, 9816, 10169, 10580, 11038, 11511, 11963, 12378, 12748, 13069, 13386, 13613, 11060, 8646, 7982, 8191, 9317, 9859, 9425, 9072, 9746, 11318, 12751, 13167, 12683, 12170, 12292, 12928, 13460, 13519, 13326, 13583, 13578, 10011, 6542, 4830, 3635, 3324, 4434, 6163, 7215, 7096, 6305, 5694, 5857, 6911, 8569, 10343, 11748, 12425, 12261, 11467, 10530, 9993, 10158, 10931, 11875, 12531, 12695, 12494, 12262, 12311, 12781, 13603, 14569, 15429, 15992, 16179, 16069, 15871, 15818, 16048, 16535, 17113, 17591, 17864, 17962, 18017, 18176, 18518, 19032, 19632, 20200, 20640, 20910, 21047, 21136, 21283, 21551, 21937, 22371, 22767, 23028, 23357, 22942, 16222, 5711, -5994, -16607, -22613, -26154, -27922, -29406, -31403, -32739, -32001, -28984, -24941, -21569, -19703, -19071, -19031, -19379, -20422, -22350, -24750, -26757, -27687, -27462, -26408, -24789, -22523, -19429, -15606, -11553, -7946, -5221, -3449, -2539, -2447, -3238, -4895, -7172, -9632, -11829, -13522, -14647, -15193, -15132, -14441, -13213, -11696, -10229, -9053, -8277, -7914, -7950, -8360, -9080, -9963, -10796, -11369, -11548, -11275, -10549, -9397, -7865, -6062, -4188, -2257, -1358, -4575, -7823, -9303, -10513, -11406, -11433, -11028, -11086, -11969, -13314, -14405, -14589, -13561, -11511, -9068, -6994, -5860, -5811, -6549, -7578, -8215, -9245, -12520, -14139, -14684, -14451, -13879, -14115, -14627, -14081, -11905, -8887, -6514, -5659, -5985, -6497, -6557, -6303, -6218, -6470, -6747, -6687, -6315, -6011, -6053, -6287, -6261, -5679, -4690, -3739, -3163, -2949, -2844, -2647, -2376, -2179, -2132, -2153, -2112, -1964, -1773, -1595, -1375, -982, -317};