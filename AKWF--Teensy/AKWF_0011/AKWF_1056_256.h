/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1056 256 samples */
 
const int16_t AKWF_1056_256_DATA [256] = 
{12880, 30027, 9273, 2074, 3906, 10651, 13885, 12942, 9092, 5936, 6988, 9244, 10936, 9130, 7107, 5610, 6499, 7349, 7661, 6571, 5593, 5291, 5850, 6445, 6506, 6211, 5970, 6253, 6759, 7262, 7409, 7462, 7553, 7869, 8209, 8450, 8500, 8472, 8467, 8508, 8522, 8431, 8250, 8026, 7827, 7639, 7442, 7204, 6956, 6722, 6532, 6380, 6252, 6143, 6063, 6027, 6039, 6091, 6171, 6271, 6393, 6539, 6700, 6867, 7029, 7181, 7320, 7441, 7543, 7617, 7659, 7671, 7652, 7605, 7532, 7432, 7310, 7172, 7023, 6867, 6711, 6558, 6413, 6283, 6171, 6079, 6009, 5964, 5944, 5948, 5976, 6025, 6092, 6175, 6270, 6371, 6473, 6577, 6675, 6762, 6836, 6895, 6937, 6959, 6962, 6943, 6905, 6850, 6778, 6693, 6598, 6495, 6388, 6281, 6177, 6080, 5991, 5915, 5853, 5805, 5775, 5754, 5759, 5786, 5805, 5822, 5590, 7590, -12885, -30835, -8694, -2036, -3913, -10786, -14017, -12946, -9109, -5846, -7066, -9270, -11051, -9106, -7127, -5581, -6553, -7383, -7709, -6579, -5599, -5308, -5879, -6487, -6531, -6237, -5984, -6285, -6789, -7301, -7437, -7491, -7579, -7901, -8242, -8483, -8528, -8500, -8497, -8537, -8552, -8458, -8276, -8051, -7851, -7664, -7467, -7228, -6978, -6744, -6555, -6403, -6275, -6166, -6086, -6051, -6063, -6116, -6196, -6297, -6419, -6566, -6728, -6894, -7056, -7209, -7347, -7469, -7571, -7644, -7687, -7697, -7679, -7631, -7556, -7456, -7334, -7196, -7046, -6890, -6734, -6581, -6436, -6305, -6193, -6100, -6032, -5987, -5967, -5971, -5999, -6049, -6117, -6200, -6294, -6395, -6500, -6603, -6699, -6786, -6861, -6921, -6962, -6985, -6986, -6967, -6930, -6874, -6802, -6716, -6620, -6517, -6410, -6303, -6199, -6101, -6013, -5937, -5874, -5827, -5797, -5775, -5782, -5807, -5827, -5865, -5972, -5735};