/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1017 256 samples */
 
const int16_t AKWF_1017_256_DATA [256] = 
{579, 1839, 3065, 4374, 5802, 7365, 9025, 10712, 12369, 13982, 15541, 17136, 18809, 20525, 22233, 23849, 25362, 26788, 27908, 28965, 29968, 30872, 31679, 32306, 32666, 32773, 32679, 32443, 32123, 31733, 31268, 30618, 29736, 28645, 27392, 26023, 24686, 23129, 21260, 19885, 18240, 16452, 14585, 12720, 10920, 9208, 7544, 5877, 4178, 2407, 620, -1079, -2679, -4141, -5428, -6577, -7667, -8725, -9769, -10732, -11466, -12084, -12585, -13070, -13587, -14126, -14712, -15222, -15625, -15930, -16168, -16372, -16619, -16928, -17241, -17509, -17631, -17653, -17578, -17487, -17456, -17424, -17427, -17387, -17236, -17007, -16734, -16445, -16225, -16087, -15997, -15904, -15731, -15478, -15182, -14900, -14689, -14575, -14527, -14477, -14355, -14130, -13930, -13729, -13594, -13528, -13551, -13516, -13405, -13195, -12888, -12554, -12251, -11973, -11724, -11422, -10978, -10397, -9697, -8887, -8073, -7278, -6451, -5505, -4400, -3129, -1754, -374, 934, 2171, 3370, 4612, 5949, 7415, 8994, 10608, 12203, 13730, 15201, 16681, 18215, 19797, 21453, 23138, 24512, 25742, 26800, 27727, 28599, 29393, 30097, 30640, 30968, 31041, 30874, 30549, 30160, 29703, 29159, 28493, 27655, 26596, 25401, 23857, 22094, 20858, 19483, 18084, 16547, 14873, 13128, 11345, 9631, 8017, 6436, 4901, 3341, 1691, 13, -1629, -3174, -4555, -5802, -6875, -7893, -8917, -9895, -10777, -11516, -12124, -12605, -13034, -13468, -13926, -14425, -14904, -15295, -15585, -15765, -15902, -16085, -16303, -16583, -16825, -16921, -16957, -16943, -16762, -16611, -16511, -16446, -16380, -16236, -16001, -15702, -15355, -15066, -14862, -14733, -14639, -14479, -14244, -13975, -13705, -13481, -13361, -13305, -13251, -13214, -13094, -12935, -12774, -12647, -12593, -12608, -12649, -12590, -12412, -12139, -11824, -11515, -11240, -11002, -10737, -10370, -9857, -9213, -8476, -7710, -6937, -6180, -5346, -4357, -3186, -1908, -527};