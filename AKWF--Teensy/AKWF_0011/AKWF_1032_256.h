/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1032 256 samples */
 
const int16_t AKWF_1032_256_DATA [256] = 
{4076, 6068, 6055, 16474, 18856, 18347, 18437, 18429, 18420, 18413, 18405, 18397, 18389, 18382, 18374, 18366, 18358, 18352, 18345, 18337, 18443, 17856, 20666, 30514, 31020, 30873, 30911, 30903, 30894, 30885, 30877, 30869, 30860, 30851, 30843, 30833, 30824, 30815, 30807, 30798, 30789, 30780, 30771, 30763, 30754, 30745, 30736, 30728, 30718, 30710, 30701, 30694, 30685, 30677, 30669, 30661, 30653, 30644, 30634, 30626, 30618, 30610, 30602, 30595, 30587, 30579, 30572, 30563, 30556, 30549, 30541, 30532, 30524, 30517, 30470, 30574, 30218, 22170, 17411, 17945, 17845, 17835, 17829, 17823, 17817, 17810, 17805, 17800, 17794, 17790, 17785, 17779, 17774, 17769, 17764, 17760, 17625, 18002, 16984, -5808, -21281, -19881, -20125, -20139, -20243, -19733, -23577, -31692, -32946, -32702, -32763, -32762, -32758, -32756, -32752, -32750, -32745, -32741, -32738, -32733, -32727, -32723, -32718, -32713, -32707, -32702, -32696, -32691, -32684, -32679, -32673, -32667, -32661, -32655, -32647, -32642, -32637, -32629, -32623, -32617, -32610, -32604, -32597, -32591, -32584, -32578, -32571, -32564, -32557, -32551, -32545, -32538, -32530, -32524, -32518, -32512, -32504, -32498, -32492, -32484, -32477, -32471, -32464, -32457, -32451, -32445, -32438, -32430, -32424, -32418, -32411, -32405, -32397, -32391, -32385, -32377, -32372, -32340, -32368, -32414, -26334, -19811, -19662, -19734, -19695, -19691, -19685, -19679, -19673, -19668, -19663, -19657, -19653, -19648, -19643, -19638, -19633, -19628, -19624, -19619, -19614, -19610, -19605, -19600, -19596, -19593, -19588, -19583, -19579, -19575, -19571, -19567, -19563, -19558, -19553, -19550, -19545, -19541, -19537, -19533, -19529, -19526, -19521, -19517, -19513, -19509, -19505, -19501, -19462, -19563, -19299, -12781, -6823, -6839, -6875, -6847, -6844, -6842, -6838, -6836, -6833, -6829, -6828, -6825, -6823, -6821, -6818, -6815, -6813, -6812, -6809, -6807, -6808, -6726, -7152, -4744};