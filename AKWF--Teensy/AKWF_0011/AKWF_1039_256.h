/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1039 256 samples */
 
const int16_t AKWF_1039_256_DATA [256] = 
{502, 2339, 4141, 5948, 7753, 9561, 11373, 13179, 14988, 16800, 18606, 20416, 22228, 24034, 25845, 27655, 29441, 31328, 32669, 32409, 32025, 30856, 29381, 27957, 26523, 25091, 23655, 22218, 20785, 19346, 17909, 16472, 15032, 13594, 12156, 10715, 9278, 7839, 6395, 4957, 3517, 2074, 635, -806, -2249, -3688, -5131, -6574, -8013, -9456, -10899, -12336, -13759, -15285, -15608, -14812, -14113, -13396, -12677, -11958, -11239, -10517, -9797, -9076, -8352, -7631, -6908, -6183, -5461, -4737, -4011, -3287, -2562, -1835, -1112, -385, 341, 1066, 1793, 2518, 3226, 4026, 4306, 3039, 1606, 182, -1245, -2678, -4109, -5537, -6960, -8439, -9312, -9655, -10022, -10378, -10735, -11091, -11447, -11805, -12161, -12518, -12875, -13232, -13591, -13949, -14306, -14664, -15023, -15381, -15739, -16098, -16455, -16814, -17173, -17529, -17869, -18301, -17656, -15930, -14154, -12360, -10560, -8763, -6966, -5164, -3365, -1566, 236, 2036, 3837, 5641, 7440, 9243, 11048, 12848, 14652, 16458, 18258, 20066, 21851, 23949, 25862, 27650, 29441, 31327, 32669, 32409, 32025, 30856, 29381, 27957, 26523, 25091, 23654, 22218, 20784, 19346, 17908, 16472, 15032, 13594, 12155, 10713, 9277, 7836, 6393, 4954, 3513, 2069, 630, -812, -2256, -3696, -5140, -6583, -8023, -9467, -10911, -12349, -13773, -15301, -15614, -14803, -14103, -13386, -12666, -11946, -11227, -10505, -9783, -9060, -8337, -7614, -6890, -6165, -5441, -4716, -3989, -3265, -2538, -1811, -1086, -358, 368, 1094, 1823, 2550, 3257, 4062, 4325, 2981, 1529, 105, -1325, -2760, -4194, -5626, -7051, -8536, -9379, -9678, -10048, -10404, -10762, -11119, -11477, -11835, -12191, -12549, -12908, -13266, -13624, -13984, -14342, -14701, -15061, -15420, -15779, -16139, -16497, -16857, -17215, -17572, -17913, -18356, -17587, -15690, -13909, -12110, -10304, -8502, -6700, -4895, -3096, -1259};