/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1080 256 samples */
 
const int16_t AKWF_1080_256_DATA [256] = 
{607, 1488, 2352, 3219, 4085, 4951, 5819, 6685, 7552, 8420, 9285, 10153, 11021, 11886, 12754, 13621, 14486, 15352, 16209, 17128, 16880, 15922, 15078, 14209, 13343, 12477, 11609, 10742, 9876, 9008, 8142, 7276, 6408, 5541, 4675, 3807, 2941, 2056, 1281, -375, -2439, -4012, -5653, -7288, -8923, -10554, -12190, -13825, -15457, -17092, -18728, -20359, -21995, -23630, -25261, -26896, -28531, -29668, -34004, -9777, 3109, 1297, 2480, 3207, 3936, 4663, 5392, 5851, 8045, 634, -7101, -3165, -1101, 1264, 3622, 5985, 8350, 10672, 13198, 14422, 13591, 12883, 12158, 11431, 10702, 9973, 9246, 8517, 7789, 7063, 6333, 5605, 4878, 4148, 3421, 2693, 1965, 1245, 481, -15, 0, 9, -714, -1777, -2781, -3797, -4811, -5827, -6843, -7856, -8872, -9889, -10901, -11918, -12934, -13947, -14963, -15979, -16992, -18005, -19012, -20076, -19739, -18620, -17630, -16614, -15599, -14584, -13569, -12554, -11539, -10523, -9509, -8494, -7477, -6464, -5448, -4431, -3419, -2404, -1395, -344, 41, -12, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 6, -18, 98, 1143, 2344, 3508, 4679, 5853, 7023, 8196, 9369, 10540, 11712, 12886, 14056, 15159, 16321, 17495, 18670, 19846, 20629, 23913, 7584, -2936, -1997, -3332, -4318, -5058, -7407, -1296, 7122, 3489, 1607, -557, -2716, -4874, -7040, -9067, -11936, -11052, 334, 149, 266, 373, 470, 567, 664, 760, 857, 954, 1051, 1148, 1243, 1340, 1404, 1676, 701, -486, -708, -722, 585, 187, -217, -612, -1009, -1409, -1806, -2204, -2603, -3001, -3399, -3798, -4196, -4595, -4986, -5412, -5939, -5704, -5386, -5088, -4786, -4485, -4184, -3881, -3580, -3278, -2977, -2675, -2374, -2073, -1772, -1470, -1168, -867, -568, -255, -10, 1, -2, 0};