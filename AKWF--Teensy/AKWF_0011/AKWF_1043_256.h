/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1043 256 samples */
 
const int16_t AKWF_1043_256_DATA [256] = 
{3279, 3482, 3680, 3879, 4077, 4274, 4472, 4669, 4865, 5063, 5259, 5455, 5652, 5847, 6043, 6239, 6434, 6629, 6824, 7018, 7214, 7409, 7602, 7798, 7992, 8187, 8382, 8577, 8770, 8965, 9160, 9354, 9549, 9743, 9938, 10131, 10325, 10519, 10713, 10908, 11101, 11297, 11491, 11684, 11878, 12071, 12267, 12461, 12655, 12848, 13042, 13236, 13430, 13625, 13819, 14013, 14207, 14402, 14596, 14790, 14983, 15177, 15371, 15564, 15758, 15952, 16146, 16340, 16534, 16726, 16922, 17114, 17308, 17502, 17697, 17889, 18083, 18276, 18469, 18664, 18857, 19050, 19243, 19436, 19628, 19822, 20014, 20207, 20400, 20592, 20785, 20976, 21167, 21359, 21549, 21741, 21932, 22123, 22312, 22502, 22691, 22879, 23067, 23255, 23443, 23628, 23813, 23997, 23674, 26563, 10883, -5183, -2277, -2595, -2404, -2214, -2023, -1832, -1639, -1448, -1256, -1064, -871, -678, -486, -293, -102, 93, 285, 477, 672, 865, 1058, 1253, 1448, 1640, 1834, 2027, 2221, 2002, 4461, -6549, -25945, -23128, -23134, -22718, -22313, -21922, -21540, -21169, -20809, -20456, -20113, -19778, -19453, -19134, -18820, -18516, -18217, -17923, -17635, -17353, -17076, -16803, -16535, -16271, -16009, -15754, -15499, -15250, -15005, -14760, -14519, -14281, -14045, -13813, -13582, -13353, -13126, -12901, -12678, -12456, -12236, -12016, -11799, -11584, -11369, -11155, -10944, -10731, -10521, -10311, -10103, -9894, -9689, -9482, -9277, -9071, -8867, -8664, -8461, -8258, -8055, -7855, -7652, -7453, -7252, -7051, -6853, -6654, -6453, -6253, -6056, -5858, -5660, -5462, -5264, -5067, -4869, -4673, -4476, -4279, -4082, -3885, -3689, -3493, -2962, -4640, 17321, 26480, 24741, 24787, 27672, 16070, -28142, -30023, -31941, -32660, -32750, -32488, -32028, -31457, -30833, -30185, -29536, -28897, -28274, -27665, -27078, -26510, -25961, -25431, -24768, -25213, -11678, -17621};