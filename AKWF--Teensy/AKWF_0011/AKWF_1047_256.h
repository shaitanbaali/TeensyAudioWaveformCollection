/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1047 256 samples */
 
const int16_t AKWF_1047_256_DATA [256] = 
{320, 997, 1660, 2325, 2989, 3652, 4318, 4981, 5644, 6309, 6970, 7634, 8299, 8960, 9622, 10285, 10946, 11609, 12271, 12932, 13593, 14255, 14915, 15576, 16238, 16897, 17558, 18218, 18877, 19538, 20197, 20855, 21516, 22174, 22833, 23492, 24150, 24808, 25467, 26124, 26772, 27465, 27969, 27376, 26639, 25936, 25227, 24517, 23807, 23095, 22384, 21674, 20964, 20254, 19546, 18836, 18128, 17420, 16711, 16002, 15296, 14587, 13880, 13173, 12465, 11758, 11052, 10344, 9637, 8930, 8222, 7517, 6809, 6101, 5395, 4687, 3977, 3271, 2562, 1853, 1145, 438, -263, -1017, -847, -113, 531, 1195, 1855, 2515, 3178, 3840, 4502, 5165, 5827, 6488, 7151, 7813, 8475, 9137, 9796, 10458, 11121, 11780, 12442, 13104, 13763, 14425, 15085, 15745, 16406, 17066, 17725, 18385, 19045, 19703, 20364, 21023, 21680, 22340, 22999, 23657, 24316, 24973, 25631, 26271, 26995, 27304, 25498, 23271, 21125, 18959, 16798, 14634, 12467, 10307, 8143, 5977, 3818, 1654, -510, -2667, -4830, -6992, -9149, -11336, -13334, -16314, -17834, -16873, -16271, -15606, -14941, -14279, -13612, -12948, -12283, -11617, -10953, -10288, -9621, -8956, -8291, -7626, -6961, -6297, -5641, -4926, -5244, -5988, -6597, -7235, -7871, -8503, -9140, -9777, -10409, -11044, -11679, -12312, -12950, -13585, -14218, -14853, -15488, -16120, -16753, -17387, -18021, -18656, -19288, -19920, -20555, -21186, -21820, -22453, -23085, -23717, -24350, -24981, -25613, -26245, -26876, -27508, -28139, -28769, -29400, -30032, -30661, -31291, -31914, -32583, -32376, -31639, -30985, -30313, -29643, -28972, -28302, -27630, -26962, -26290, -25621, -24950, -24279, -23610, -22938, -22269, -21599, -20928, -20258, -19590, -18921, -18251, -17583, -16914, -16244, -15576, -14906, -14236, -13571, -12901, -12233, -11567, -10898, -10231, -9564, -8896, -8228, -7563, -6895, -6171, -5819, -3083, -755, -383};