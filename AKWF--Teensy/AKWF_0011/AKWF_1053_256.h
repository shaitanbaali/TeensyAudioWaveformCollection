/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1053 256 samples */
 
const int16_t AKWF_1053_256_DATA [256] = 
{608, 1496, 2363, 3231, 4095, 4955, 5810, 6656, 7496, 8327, 9148, 9958, 10758, 11544, 12318, 13079, 13823, 14554, 15269, 15965, 16646, 17309, 17952, 18578, 19183, 19768, 20333, 20877, 21399, 21900, 22379, 22834, 23268, 23678, 24064, 24428, 24766, 25081, 25373, 25638, 25880, 26098, 26290, 26458, 26601, 26719, 26813, 26882, 26926, 26946, 26941, 26914, 26861, 26783, 26683, 26559, 26411, 26241, 26048, 25832, 25595, 25336, 25055, 24754, 24432, 24090, 23727, 23345, 22945, 22526, 22089, 21635, 21164, 20676, 20173, 19654, 19120, 18573, 18012, 17437, 16876, 16166, 16020, 20248, 19049, 21436, 22307, 22212, 23613, 23732, 23150, 23311, 23726, 23716, 23513, 23403, 23288, 23079, 22831, 22528, 22678, 18278, 16595, 15182, 11754, 11202, 8860, 6951, 6276, 5107, 3311, 1766, 516, -821, -2250, -3627, -4932, -6567, -6733, -3628, -5817, -3620, -4076, -4484, -3763, -4462, -5506, -5718, -5787, -6244, -6776, -7163, -7530, -7941, -8340, -8682, -8852, -13850, -14424, -16755, -19399, -19930, -22239, -23645, -24018, -25032, -26493, -27592, -28434, -29357, -30317, -31144, -32239, -31770, -28152, -29752, -26914, -26787, -26526, -25154, -25196, -25542, -25040, -24392, -24118, -23900, -23524, -23116, -22742, -22329, -21858, -21357, -20843, -20310, -19758, -19200, -18642, -18083, -17527, -16980, -16438, -15906, -15385, -14872, -14369, -13878, -13394, -12921, -12457, -11999, -11550, -11109, -10672, -10243, -9819, -9401, -8987, -8576, -8169, -7768, -7447, -6583, -9662, -11513, -11474, -14509, -14245, -15547, -16740, -16525, -16599, -17340, -17869, -18028, -18202, -18452, -18630, -18740, -18853, -18964, -19042, -19086, -19103, -19087, -19029, -18929, -18786, -18597, -18364, -18086, -17763, -17397, -16989, -16540, -16053, -15529, -14969, -14378, -13755, -13103, -12425, -11721, -10994, -10248, -9480, -8696, -7897, -7082, -6256, -5420, -4572, -3718, -2859, -1994, -1127, -241};