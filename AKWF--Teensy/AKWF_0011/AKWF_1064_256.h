/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1064 256 samples */
 
const int16_t AKWF_1064_256_DATA [256] = 
{5, 26, 74, 152, 267, 424, 625, 875, 1174, 1528, 1935, 2398, 2918, 3491, 4121, 4806, 5541, 6329, 7166, 8046, 8971, 9934, 10930, 11959, 13013, 14088, 15181, 16283, 17391, 18501, 19604, 20695, 21773, 22826, 23851, 24846, 25799, 26710, 27574, 28382, 29135, 29825, 30449, 31006, 31490, 31899, 32232, 32485, 32660, 32751, 32768, 32759, 32733, 32678, 32592, 32468, 32301, 32090, 31829, 31517, 31152, 30731, 30256, 29725, 29137, 28496, 27800, 27050, 26253, 25406, 24513, 23582, 22611, 21605, 20572, 19513, 18432, 17339, 16233, 15123, 14017, 12915, 11824, 10755, 9705, 8687, 7703, 6756, 5856, 5006, 4209, 3470, 2795, 2185, 1645, 1179, 786, 471, 235, 79, 7, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -2, -15, -51, -114, -212, -349, -529, -755, -1030, -1358, -1738, -2175, -2665, -3211, -3813, -4471, -5180, -5942, -6755, -7612, -8515, -9458, -10437, -11450, -12492, -13556, -14641, -15739, -16844, -17956, -19063, -20161, -21248, -22313, -23354, -24367, -25341, -26275, -27164, -28000, -28782, -29505, -30162, -30752, -31273, -31718, -32088, -32378, -32590, -32719, -32766, -32764, -32747, -32705, -32633, -32526, -32379, -32190, -31951, -31664, -31325, -30930, -30483, -29980, -29421, -28807, -28139, -27416, -26644, -25823, -24954, -24044, -23091, -22103, -21085, -20038, -18968, -17883, -16781, -15672, -14565, -13457, -12360, -11279, -10216, -9181, -8178, -7209, -6285, -5408, -4581, -3813, -3105, -2461, -1886, -1384, -954, -603, -331, -139, -28, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};