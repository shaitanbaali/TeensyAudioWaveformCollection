/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1092 256 samples */
 
const int16_t AKWF_1092_256_DATA [256] = 
{698, 2603, 4531, 6509, 8511, 10523, 12526, 14492, 16410, 18262, 20024, 21693, 23253, 24690, 26005, 27193, 28249, 29177, 29981, 30663, 31234, 31698, 32064, 32342, 32543, 32674, 32747, 32768, 32748, 32694, 32612, 32510, 32391, 32261, 32120, 31972, 31817, 31654, 31482, 31299, 31101, 30882, 30640, 30367, 30058, 29706, 29304, 28845, 28326, 27739, 27081, 26351, 25547, 24671, 23731, 22726, 21673, 20582, 19463, 18337, 17222, 16130, 15086, 14106, 13206, 12399, 11698, 11112, 10651, 10317, 10109, 10025, 10059, 10205, 10450, 10785, 11197, 11673, 12200, 12766, 13357, 13962, 14569, 15169, 15754, 16315, 16844, 17338, 17792, 18201, 18564, 18876, 19138, 19347, 19506, 19612, 19666, 19672, 19627, 19535, 19399, 19220, 19001, 18744, 18451, 18126, 17772, 17387, 16975, 16535, 16066, 15566, 15033, 14458, 13839, 13168, 12434, 11630, 10751, 9782, 8718, 7554, 6279, 4898, 3411, 1816, 128, -1644, -3496, -5400, -7344, -9309, -11267, -13205, -15100, -16928, -18676, -20329, -21867, -23287, -24578, -25732, -26753, -27638, -28388, -29010, -29511, -29895, -30177, -30362, -30461, -30486, -30446, -30352, -30213, -30039, -29839, -29618, -29385, -29146, -28902, -28659, -28419, -28182, -27949, -27718, -27487, -27253, -27013, -26759, -26488, -26195, -25872, -25515, -25116, -24668, -24170, -23614, -23001, -22329, -21595, -20806, -19967, -19084, -18168, -17233, -16289, -15356, -14448, -13583, -12778, -12047, -11405, -10868, -10444, -10139, -9959, -9904, -9970, -10154, -10448, -10841, -11321, -11877, -12494, -13157, -13854, -14570, -15292, -16010, -16714, -17392, -18040, -18650, -19215, -19735, -20206, -20624, -20989, -21300, -21556, -21761, -21912, -22010, -22058, -22057, -22006, -21910, -21770, -21586, -21362, -21099, -20800, -20466, -20099, -19701, -19272, -18814, -18325, -17803, -17250, -16657, -16022, -15343, -14608, -13812, -12951, -12009, -10985, -9871, -8658, -7345, -5930, -4412, -2799, -1053};