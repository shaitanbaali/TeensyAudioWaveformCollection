/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1077 256 samples */
 
const int16_t AKWF_1077_256_DATA [256] = 
{32010, 31978, 31920, 31835, 31724, 31587, 31422, 31230, 31011, 30763, 30489, 30185, 29852, 29489, 29094, 28668, 28211, 27718, 27191, 26628, 26023, 25378, 24691, 23952, 23162, 22317, 21403, 20417, 19346, 18167, 16863, 15392, 13678, 11935, 7109, 13121, 9280, -1961, 382, -12, 82, 2, -3726, 12773, 26629, 24238, 24516, 24303, 24029, 23695, 23296, 22837, 22307, 21707, 21032, 20275, 19429, 18484, 17419, 16217, 14840, 13219, 11346, 8306, 6478, 9148, 13581, 17309, 20, -51, 21, 0, 143, 564, 1265, 2182, 3775, 4875, -28328, -33839, -32449, -32662, -32616, -32560, -32492, -32413, -32323, -32223, -32112, -31990, -31856, -31711, -31555, -31387, -31209, -31018, -30815, -30600, -30373, -30132, -29880, -29615, -29337, -29045, -28739, -28419, -28085, -27735, -27370, -26989, -26591, -26177, -25744, -25292, -24820, -24329, -23812, -23274, -22710, -22118, -21496, -20843, -20152, -19423, -18649, -17820, -16932, -15971, -14919, -13752, -12426, -10878, -8951, -6102, -6155, -6627, -6775, -6994, -7212, -7436, -7663, -7895, -8133, -8376, -8624, -8877, -9137, -9401, -9672, -9949, -10233, -10524, -10820, -11124, -11437, -11756, -12085, -12422, -12768, -13124, -13491, -13869, -14259, -14662, -15079, -15511, -15958, -16424, -16910, -17419, -17952, -18514, -19109, -19741, -20419, -21152, -21951, -22845, -23862, -25074, -26209, -30709, -6670, 1539, -320, 0, 0, -1, 0, -1, -3, -9, -18, -28, -42, -58, -77, -98, -122, -149, -178, -210, -244, -281, -321, -364, -408, -456, -507, -560, -616, -673, -734, -798, -865, -935, -1006, -1081, -1159, -1239, -1322, -1408, -1496, -1588, -1682, -1780, -1880, -1982, -2089, -2198, -2310, -2424, -2542, -2663, -2787, -2914, -3044, -3177, -3314, -3454, -3596, -3741, -3891, -4044, -4201, -4361, -4524, -4690, -4860, -5034, -5213, -5393, -5578, -5768, -5959, -6160};