/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1062 256 samples */
 
const int16_t AKWF_1062_256_DATA [256] = 
{129, 577, 992, 1389, 1762, 2127, 2484, 2838, 3197, 3561, 3936, 4323, 4725, 5148, 5590, 6050, 6526, 7021, 7532, 8052, 8583, 9117, 9651, 10187, 10712, 11224, 11727, 12213, 12675, 13118, 13540, 13940, 14315, 14672, 15005, 15322, 15627, 15916, 16194, 16469, 16739, 17009, 17287, 17564, 17851, 18146, 18451, 18767, 19098, 19435, 19780, 20134, 20496, 20858, 21223, 21588, 21948, 22297, 22641, 22975, 23293, 23596, 23885, 24158, 24411, 24652, 24872, 25080, 25277, 25462, 25631, 25799, 25960, 26115, 26271, 26428, 26583, 26747, 26909, 27082, 27255, 27438, 27623, 27812, 28006, 28202, 28396, 28592, 28783, 28969, 29148, 29318, 29484, 29636, 29776, 29900, 30018, 30122, 30214, 30289, 30352, 30414, 30463, 30500, 30531, 30559, 30584, 30605, 30627, 30646, 30672, 30646, 31149, 31680, 31060, 30859, 30920, 31140, 31235, 31258, 30926, 30766, 30201, 28273, 27459, 26880, 26286, 25344, 24317, 23301, 22434, 21687, 20904, 20051, 19109, 18265, 17483, 16787, 16054, 15310, 14546, 13840, 13175, 12533, 11874, 11199, 10517, 9852, 9196, 8526, 7840, 7123, 6400, 5667, 4925, 4166, 3389, 2590, 1789, 980, 169, -643, -1462, -2275, -3084, -3881, -4669, -5445, -6207, -6961, -7692, -8410, -9114, -9805, -10485, -11158, -11820, -12476, -13129, -13781, -14433, -15093, -15754, -16421, -17096, -17781, -18478, -19178, -19884, -20607, -21331, -22062, -22798, -23530, -24268, -25004, -25736, -26462, -27179, -27891, -28593, -29282, -29961, -30629, -31286, -31908, -32665, -32190, -29382, -28142, -27908, -27692, -26802, -25589, -24310, -23427, -22842, -22288, -21504, -20558, -19725, -19102, -18665, -18191, -17641, -17051, -16558, -16165, -15834, -15459, -15029, -14582, -14158, -13753, -13335, -12859, -12326, -11770, -11198, -10612, -9993, -9336, -8646, -7946, -7245, -6546, -5845, -5139, -4443, -3776, -3129, -2514, -1922, -1361, -828, -322};