/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1054 256 samples */
 
const int16_t AKWF_1054_256_DATA [256] = 
{8099, 11404, 13329, 4474, 6887, 10328, 18113, 18751, 16855, 13792, 13994, 16668, 18303, 18244, 15762, 14636, 14246, 15510, 15551, 15128, 13831, 13490, 13735, 14512, 14892, 14945, 15016, 15472, 16388, 17326, 18148, 18718, 19391, 20154, 21057, 21817, 22421, 22829, 23188, 23512, 23779, 23891, 23831, 23653, 23409, 23137, 22807, 22412, 21956, 21502, 21078, 20700, 20360, 20069, 19833, 19680, 19611, 19638, 19737, 19901, 20138, 20432, 20888, 20634, 25135, 29273, 29832, 29217, 29303, 29940, 31665, 32244, 32467, 31731, 31702, 31744, 32143, 31931, 31447, 30745, 30304, 30060, 29804, 29430, 28892, 28472, 28200, 28132, 28067, 28031, 27992, 28091, 28304, 28626, 28966, 29318, 29679, 30077, 30511, 30932, 31317, 31635, 31910, 32138, 32319, 32420, 32452, 32404, 32298, 32133, 31930, 31676, 31383, 31072, 30756, 30447, 30146, 29878, 29634, 29441, 29289, 29197, 29153, 29166, 29234, 29343, 29212, 30883, 24836, -9416, -11989, -12137, -4365, -6970, -11828, -18335, -19104, -16205, -14156, -14353, -17635, -18731, -18625, -16010, -15211, -15049, -16329, -16288, -15681, -14489, -14180, -14560, -15224, -15556, -15474, -15573, -16007, -16926, -17773, -18516, -19031, -19674, -20431, -21309, -22037, -22603, -23009, -23383, -23737, -24006, -24130, -24091, -23950, -23747, -23509, -23208, -22844, -22419, -21990, -21588, -21217, -20887, -20596, -20357, -20191, -20108, -20106, -20179, -20319, -20514, -20892, -20563, -25026, -29138, -29681, -29070, -29172, -29840, -31615, -32263, -32557, -31893, -31949, -32078, -32568, -32432, -32012, -31370, -30976, -30760, -30532, -30156, -29610, -29172, -28863, -28747, -28626, -28526, -28419, -28447, -28593, -28849, -29131, -29432, -29751, -30118, -30528, -30940, -31324, -31659, -31957, -32220, -32439, -32593, -32678, -32685, -32631, -32525, -32366, -32157, -31909, -31624, -31324, -31027, -30732, -30453, -30196, -29972, -29793, -29657, -29575, -29541, -29561, -29625, -29735, -29893};