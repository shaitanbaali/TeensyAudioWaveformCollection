/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1050 256 samples */
 
const int16_t AKWF_1050_256_DATA [256] = 
{16292, 15844, 15404, 14961, 14518, 14073, 13628, 13183, 12736, 12289, 11842, 11395, 10947, 10499, 10050, 9601, 9153, 8704, 8255, 7807, 7356, 6906, 6459, 6008, 5559, 5110, 4660, 4211, 3762, 3311, 2863, 2414, 1964, 1514, 1066, 617, 169, -279, -729, -1177, -1626, -2075, -2523, -2970, -3420, -3867, -4316, -4763, -5211, -5659, -6106, -6553, -7001, -7449, -7894, -8342, -8790, -9236, -9682, -10129, -10575, -11022, -11468, -11913, -12360, -12805, -13251, -13697, -14140, -14042, -17567, 20472, 35405, 32164, 32748, 32752, 32756, 32759, 32760, 32762, 32764, 32763, 32764, 32763, 32764, 32762, 32761, 32759, 32758, 32756, 32754, 32752, 32750, 32748, 32745, 32742, 32739, 32736, 32733, 32730, 32728, 32724, 32720, 32718, 32714, 32710, 32708, 32704, 32700, 32696, 32693, 32690, 32686, 32682, 32678, 32674, 32671, 32668, 32664, 32661, 32657, 32653, 32649, 32645, 32641, 32436, 33420, 29786, -13471, -16630, -15207, -14966, -14522, -14077, -13632, -13187, -12741, -12294, -11847, -11399, -10951, -10503, -10054, -9606, -9158, -8707, -8258, -7811, -7362, -6911, -6462, -6014, -5563, -5114, -4665, -4215, -3766, -3317, -2867, -2418, -1969, -1520, -1070, -621, -173, 275, 724, 1172, 1622, 2070, 2517, 2967, 3415, 3862, 4311, 4759, 5206, 5654, 6102, 6548, 6997, 7443, 7891, 8338, 8785, 9231, 9678, 10124, 10571, 11018, 11464, 11909, 12357, 12801, 13247, 13693, 14135, 14038, 17563, -20476, -35410, -32168, -32752, -32757, -32759, -32762, -32764, -32766, -32767, -32767, -32768, -32767, -32767, -32766, -32764, -32764, -32762, -32760, -32758, -32756, -32754, -32751, -32749, -32746, -32743, -32740, -32737, -32734, -32732, -32727, -32724, -32722, -32717, -32714, -32711, -32707, -32703, -32701, -32697, -32693, -32690, -32686, -32682, -32680, -32676, -32672, -32668, -32664, -32660, -32656, -32652, -32649, -32646, -32642, -32638, -32634};