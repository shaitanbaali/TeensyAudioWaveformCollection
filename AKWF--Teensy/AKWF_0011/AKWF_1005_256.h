/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1005 256 samples */
 
const int16_t AKWF_1005_256_DATA [256] = 
{289, 291, 294, 296, 298, 300, 302, 302, 305, 305, 308, 308, 307, 318, 583, -1019, 25613, 34312, 32366, 32709, 32707, 32703, 32700, 32696, 32692, 32687, 32681, 32676, 32670, 32665, 32657, 32651, 32643, 32636, 32629, 32622, 32615, 32608, 32601, 32593, 32584, 32577, 32570, 32560, 32553, 32545, 32536, 32529, 32520, 32512, 32503, 32495, 32486, 32478, 32470, 32461, 32453, 32444, 32436, 32427, 32418, 32410, 32402, 32393, 32384, 32375, 32367, 32358, 32349, 32341, 32333, 32324, 32315, 32306, 32297, 32290, 32280, 32272, 32263, 32255, 32246, 32237, 32229, 32220, 32212, 32203, 32194, 32185, 32177, 32168, 32160, 32151, 32142, 31572, 34587, 18364, -2834, 282, -305, -311, -317, -321, -326, -330, -334, -337, -339, -343, -345, -665, 1123, -6882, -31378, -29905, -30148, -30154, -30152, -29699, -32172, -21939, 32319, 32437, 32219, 32321, 32322, 32187, 32838, 30433, 1538, -867, -216, -352, -354, -356, -357, -360, -359, -361, -363, -362, -364, -374, -638, 964, -25668, -34368, -32420, -32764, -32762, -32759, -32755, -32750, -32747, -32741, -32736, -32730, -32726, -32719, -32712, -32705, -32697, -32690, -32683, -32676, -32669, -32662, -32655, -32648, -32639, -32631, -32624, -32614, -32607, -32600, -32590, -32583, -32574, -32566, -32558, -32549, -32542, -32532, -32525, -32515, -32507, -32498, -32490, -32481, -32472, -32464, -32456, -32447, -32438, -32429, -32421, -32412, -32403, -32395, -32387, -32378, -32369, -32360, -32351, -32344, -32334, -32326, -32317, -32308, -32300, -32291, -32283, -32274, -32265, -32256, -32249, -32239, -32231, -32222, -32213, -32205, -32196, -31626, -34640, -18417, 2780, -337, 251, 256, 263, 267, 272, 275, 279, 282, 286, 288, 290, 611, -1177, 6827, 31324, 29851, 30094, 30101, 30099, 29644, 32120, 21887, -32370, -32488, -32270, -32372, -32373, -32372, -32370, -32367};