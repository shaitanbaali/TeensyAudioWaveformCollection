/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1055 256 samples */
 
const int16_t AKWF_1055_256_DATA [256] = 
{25691, 26218, 23951, 12969, 15008, 18506, 25394, 24417, 20780, 16886, 16784, 19232, 20046, 18911, 15441, 13780, 13072, 13939, 13347, 12201, 10324, 9602, 9564, 9979, 9916, 9510, 9224, 9408, 10084, 10727, 11222, 11472, 11870, 12391, 13046, 13531, 13832, 13949, 14039, 14101, 14085, 13905, 13548, 13082, 12560, 12014, 11409, 10744, 10032, 9329, 8667, 8067, 7518, 7025, 6606, 6279, 6058, 5935, 5902, 5946, 6064, 6251, 6495, 6776, 7078, 7378, 7667, 7931, 8157, 8329, 8438, 8475, 8437, 8325, 8139, 7880, 7554, 7173, 6744, 6281, 5798, 5304, 4814, 4343, 3898, 3495, 3140, 2839, 2597, 2419, 2302, 2246, 2245, 2294, 2385, 2509, 2656, 2816, 2977, 3129, 3261, 3367, 3436, 3463, 3444, 3374, 3256, 3087, 2871, 2616, 2321, 1997, 1653, 1294, 930, 572, 225, -101, -400, -667, -897, -1087, -1237, -1344, -1413, -1445, -1445, -1418, -1371, -1307, -1239, -1168, -1107, -1057, -1026, -1020, -1042, -1095, -1181, -1299, -1451, -1632, -1840, -2073, -2323, -2588, -2860, -3135, -3406, -3668, -3915, -4145, -4353, -4536, -4692, -4821, -4923, -5000, -5052, -5084, -5098, -5099, -5091, -5080, -5068, -5062, -5064, -5080, -5111, -5162, -5234, -5326, -5441, -5577, -5732, -5905, -6093, -6293, -6502, -6714, -6929, -7139, -7343, -7539, -7720, -7888, -8039, -8172, -8287, -8384, -8464, -8530, -8581, -8621, -8652, -8679, -8703, -8727, -8755, -8789, -8832, -8887, -8954, -9034, -9128, -9237, -9360, -9496, -9642, -9798, -9963, -10132, -10303, -10474, -10643, -10808, -10967, -11116, -11256, -11383, -11500, -11605, -11699, -11780, -11851, -11914, -11970, -12020, -12067, -12113, -12159, -12207, -12260, -12320, -12386, -12462, -12544, -12637, -12740, -12852, -12971, -13098, -13231, -13369, -13509, -13651, -13793, -13934, -14070, -14193, -14335, -14447, -14561, -14565, -15206, -12726};