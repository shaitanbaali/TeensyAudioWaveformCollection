/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1061 256 samples */
 
const int16_t AKWF_1061_256_DATA [256] = 
{2122, 5551, 9209, 10460, 10947, 11288, 13068, 15230, 16924, 17534, 17663, 18134, 19056, 20147, 20761, 21024, 21100, 21489, 22069, 22715, 23145, 23472, 23826, 24373, 25039, 25714, 26316, 26880, 27498, 28181, 28896, 29553, 30145, 30674, 31177, 31647, 32061, 32371, 32584, 32709, 32766, 32741, 32593, 32689, 29691, 24304, 24204, 24507, 24009, 22233, 20413, 19019, 18444, 18225, 17689, 16796, 15806, 15316, 15159, 15184, 14963, 14651, 14344, 14289, 14339, 14377, 14261, 14049, 13839, 13664, 13488, 13210, 12818, 12341, 11847, 11331, 10787, 10181, 9524, 8845, 8185, 7546, 6926, 6322, 5737, 5200, 4728, 4314, 3951, 3640, 3378, 3172, 3018, 2902, 2817, 2751, 2700, 2654, 2610, 2548, 2465, 2356, 2214, 2034, 1817, 1562, 1263, 926, 554, 156, -262, -703, -1152, -1605, -2050, -2484, -2897, -3288, -3648, -3978, -4269, -4526, -4740, -4924, -5074, -5194, -5284, -5356, -5417, -5468, -5512, -5565, -5628, -5701, -5790, -5904, -6044, -6209, -6398, -6615, -6854, -7117, -7398, -7695, -8000, -8308, -8620, -8930, -9228, -9510, -9777, -10027, -10249, -10452, -10626, -10778, -10906, -11012, -11095, -11163, -11218, -11264, -11304, -11343, -11383, -11428, -11485, -11555, -11635, -11733, -11849, -11979, -12124, -12291, -12467, -12653, -12849, -13056, -13259, -13461, -13665, -13859, -14041, -14211, -14373, -14515, -14639, -14748, -14842, -14917, -14978, -15025, -15062, -15091, -15112, -15126, -15144, -15162, -15182, -15210, -15240, -15287, -15339, -15406, -15477, -15564, -15655, -15759, -15868, -15982, -16097, -16218, -16334, -16445, -16555, -16656, -16746, -16827, -16900, -16961, -17008, -17043, -17068, -17086, -17090, -17087, -17079, -17068, -17052, -17034, -17015, -17003, -16995, -16989, -16985, -16988, -17001, -17023, -17046, -17076, -17107, -17145, -17190, -17234, -17274, -17312, -17349, -17382, -17412, -17340, -17736, -15565, -2252, 1429, -397, -975};