/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1023 256 samples */
 
const int16_t AKWF_1023_256_DATA [256] = 
{335, 1094, 1888, 2731, 3614, 4533, 5484, 6455, 7443, 8441, 9435, 10425, 11402, 12358, 13295, 14201, 15073, 15916, 16719, 17482, 18208, 18891, 19535, 20140, 20704, 21228, 21717, 22172, 22591, 22979, 23340, 23675, 23987, 24279, 24550, 24810, 25059, 25299, 25536, 25771, 26009, 26254, 26510, 26782, 27068, 27376, 27708, 28064, 28443, 28843, 29262, 29693, 30129, 30560, 30973, 31364, 31717, 32028, 32290, 32497, 32647, 32737, 32767, 32738, 32652, 32511, 32317, 32074, 31785, 31456, 31088, 30688, 30257, 29801, 29324, 28829, 28320, 27801, 27275, 26743, 26209, 25671, 25133, 24597, 24063, 23527, 22993, 22461, 21927, 21390, 20849, 20302, 19751, 19193, 18626, 18054, 17474, 16887, 16292, 15692, 15087, 14481, 13871, 13265, 12659, 12057, 11461, 10873, 10290, 9718, 9156, 8602, 8063, 7533, 7016, 6511, 6016, 5533, 5061, 4593, 4127, 3660, 3181, 2682, 2160, 1597, 997, 351, -345, -1091, -1887, -2732, -3614, -4534, -5485, -6456, -7444, -8441, -9436, -10426, -11403, -12359, -13295, -14202, -15074, -15916, -16719, -17483, -18208, -18892, -19536, -20141, -20705, -21228, -21717, -22172, -22591, -22979, -23341, -23675, -23986, -24279, -24551, -24811, -25059, -25299, -25536, -25771, -26009, -26254, -26510, -26782, -27068, -27376, -27708, -28064, -28443, -28843, -29263, -29693, -30129, -30560, -30973, -31364, -31717, -32028, -32290, -32497, -32647, -32737, -32767, -32738, -32652, -32511, -32317, -32074, -31785, -31456, -31088, -30688, -30257, -29801, -29324, -28829, -28320, -27802, -27274, -26742, -26208, -25670, -25133, -24597, -24063, -23527, -22994, -22461, -21927, -21390, -20849, -20302, -19751, -19192, -18627, -18055, -17475, -16887, -16293, -15693, -15088, -14482, -13872, -13265, -12659, -12057, -11462, -10873, -10291, -9719, -9157, -8603, -8063, -7534, -7017, -6512, -6016, -5533, -5062, -4593, -4128, -3661, -3182, -2683, -2160, -1598, -1001, -342};