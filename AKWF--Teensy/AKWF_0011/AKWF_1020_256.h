/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1020 256 samples */
 
const int16_t AKWF_1020_256_DATA [256] = 
{14970, 23945, 23125, 25314, 26579, 27324, 28075, 28659, 29144, 29564, 29921, 30232, 30503, 30739, 30948, 31134, 31298, 31444, 31576, 31692, 31798, 31892, 31978, 32054, 32123, 32186, 32242, 32293, 32340, 32381, 32420, 32454, 32486, 32514, 32540, 32563, 32584, 32603, 32621, 32637, 32652, 32665, 32677, 32687, 32697, 32706, 32714, 32720, 32727, 32734, 32739, 32743, 32747, 32751, 32754, 32757, 32760, 32762, 32764, 32766, 32766, 32767, 32768, 32767, 32767, 32768, 32767, 32766, 32765, 32763, 32761, 32759, 32756, 32754, 32750, 32746, 32742, 32737, 32731, 32726, 32719, 32711, 32703, 32694, 32683, 32672, 32660, 32646, 32631, 32615, 32597, 32577, 32555, 32531, 32504, 32474, 32442, 32407, 32367, 32324, 32276, 32223, 32164, 32100, 32028, 31948, 31860, 31762, 31653, 31531, 31394, 31242, 31070, 30876, 30658, 30410, 30126, 29799, 29422, 28980, 28458, 27833, 27066, 26103, 24834, 22966, 20683, 9913, -15116, -23939, -23075, -25314, -26579, -27324, -28075, -28659, -29144, -29564, -29921, -30232, -30503, -30739, -30948, -31134, -31298, -31444, -31576, -31692, -31798, -31892, -31978, -32054, -32123, -32186, -32242, -32293, -32340, -32381, -32420, -32454, -32486, -32514, -32540, -32563, -32584, -32603, -32621, -32637, -32652, -32665, -32677, -32687, -32697, -32706, -32714, -32720, -32727, -32734, -32739, -32743, -32747, -32751, -32754, -32757, -32760, -32762, -32764, -32766, -32766, -32767, -32768, -32767, -32767, -32768, -32767, -32766, -32765, -32763, -32761, -32759, -32756, -32754, -32750, -32746, -32742, -32737, -32731, -32726, -32719, -32711, -32703, -32694, -32683, -32672, -32660, -32646, -32631, -32615, -32597, -32577, -32555, -32531, -32504, -32474, -32442, -32407, -32367, -32324, -32276, -32223, -32164, -32100, -32028, -31948, -31860, -31762, -31653, -31531, -31394, -31242, -31070, -30876, -30658, -30410, -30126, -29799, -29422, -28980, -28458, -27833, -27067, -26104, -24834, -23017, -20705, -9644};