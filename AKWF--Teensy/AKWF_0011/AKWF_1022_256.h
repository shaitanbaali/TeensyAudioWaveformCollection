/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1022 256 samples */
 
const int16_t AKWF_1022_256_DATA [256] = 
{774, 2044, 3340, 4602, 5845, 7071, 8273, 9447, 10597, 11721, 12814, 13880, 14919, 15922, 16898, 17842, 18752, 19631, 20475, 21285, 22063, 22805, 23511, 24182, 24819, 25418, 25983, 26512, 27008, 27473, 27907, 28312, 28691, 29044, 29372, 29677, 29961, 30224, 30469, 30694, 30903, 31096, 31275, 31438, 31590, 31728, 31855, 31972, 32077, 32174, 32262, 32340, 32411, 32475, 32532, 32582, 32625, 32662, 32693, 32720, 32739, 32754, 32764, 32768, 32767, 32760, 32749, 32733, 32711, 32683, 32650, 32610, 32566, 32512, 32453, 32388, 32313, 32232, 32141, 32040, 31931, 31811, 31680, 31538, 31382, 31213, 31029, 30830, 30616, 30383, 30133, 29863, 29571, 29258, 28920, 28559, 28171, 27755, 27311, 26835, 26328, 25787, 25209, 24597, 23949, 23264, 22545, 21792, 21002, 20180, 19322, 18432, 17511, 16555, 15568, 14553, 13505, 12428, 11325, 10192, 9033, 7850, 6639, 5407, 4154, 2881, 1596, 359, -792, -2038, -3339, -4603, -5846, -7072, -8274, -9448, -10598, -11721, -12814, -13881, -14919, -15922, -16898, -17843, -18752, -19631, -20476, -21286, -22064, -22805, -23510, -24183, -24819, -25418, -25983, -26512, -27008, -27473, -27907, -28312, -28691, -29044, -29372, -29677, -29961, -30224, -30469, -30694, -30903, -31096, -31275, -31438, -31590, -31728, -31855, -31972, -32077, -32174, -32262, -32340, -32411, -32475, -32532, -32582, -32625, -32662, -32693, -32720, -32739, -32754, -32764, -32768, -32767, -32760, -32749, -32733, -32711, -32683, -32650, -32610, -32566, -32512, -32453, -32388, -32313, -32232, -32141, -32040, -31932, -31811, -31680, -31538, -31382, -31213, -31029, -30830, -30616, -30383, -30133, -29863, -29571, -29258, -28920, -28559, -28170, -27755, -27311, -26836, -26329, -25787, -25209, -24597, -23949, -23264, -22546, -21792, -21002, -20180, -19323, -18432, -17511, -16556, -15568, -14554, -13506, -12429, -11326, -10193, -9034, -7851, -6640, -5408, -4155, -2884, -1602, -344};