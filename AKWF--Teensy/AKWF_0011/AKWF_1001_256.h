/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1001 256 samples */
 
const int16_t AKWF_1001_256_DATA [256] = 
{24901, 25075, 25246, 25416, 25585, 25755, 25924, 26091, 26260, 26428, 26595, 26761, 26929, 27095, 27262, 27428, 27594, 27759, 27926, 28091, 28256, 28421, 28585, 28751, 28917, 29081, 29246, 29410, 29575, 29738, 29903, 30067, 30231, 30396, 30559, 30723, 30886, 31052, 31215, 31378, 31541, 31705, 31868, 32031, 32195, 32360, 32519, 32700, 32695, 32507, 32342, 32172, 32003, 31833, 31664, 31494, 31325, 31155, 30986, 30816, 30645, 30474, 30305, 30136, 29966, 29797, 29627, 29457, 29288, 29119, 28949, 28780, 28610, 28441, 28271, 28102, 27934, 27766, 27596, 27426, 27257, 27087, 26919, 26752, 26582, 26412, 26243, 26075, 25907, 25737, 25569, 25401, 25231, 25063, 24895, 24726, 24118, 26318, 13239, -2881, -444, -905, -910, -914, -917, -922, -924, -927, -930, -933, -934, -936, -938, -940, -941, -942, -942, -943, -946, -945, -945, -1210, 263, -6588, -23297, -21985, -22351, -22462, -22575, -22687, -22798, -22909, -23019, -23129, -23241, -23351, -23460, -23569, -23678, -23788, -23897, -24005, -24114, -24223, -24332, -24440, -24548, -24657, -24764, -24873, -24980, -25089, -25196, -25305, -25412, -25519, -25628, -25735, -25841, -25949, -26058, -26164, -26271, -26378, -26487, -26594, -26701, -26807, -26914, -27020, -27128, -27237, -27344, -27450, -27557, -27664, -27770, -27877, -27984, -28090, -28197, -28304, -28409, -28520, -28606, -28493, -28342, -28199, -28055, -27910, -27764, -27619, -27475, -27330, -27186, -27041, -26897, -26753, -26608, -26464, -26320, -26175, -26031, -25887, -25742, -25599, -25456, -25312, -25167, -25023, -24878, -24734, -24590, -24445, -24304, -24160, -24015, -23871, -23727, -23585, -23440, -23296, -23152, -23010, -22865, -22721, -22579, -22435, -22291, -22148, -22004, -21861, -21406, -22978, -14442, 1201, -582, -250, -245, -242, -239, -236, -233, -229, -227, -225, -223, -221, -219, -217, -216, -215, -214, -212, -211, -212};