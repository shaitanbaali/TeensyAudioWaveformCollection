/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1078 256 samples */
 
const int16_t AKWF_1078_256_DATA [256] = 
{32763, 32742, 32701, 32642, 32566, 32472, 32360, 32228, 32079, 31913, 31730, 31527, 31308, 31071, 30816, 30544, 30255, 29950, 29626, 29288, 28930, 28557, 28169, 27762, 27342, 26906, 26452, 25985, 25502, 25005, 24492, 23965, 23422, 22867, 22299, 21715, 21119, 20509, 19885, 19250, 18602, 17941, 17270, 16586, 15890, 15184, 14464, 13734, 12995, 12243, 11479, 10708, 9923, 9127, 8323, 7521, 6623, 6137, 6724, 7194, 7688, 8199, 8725, 9264, 9818, 10385, 10966, 11560, 12169, 12789, 13423, 14069, 14727, 15398, 16080, 16774, 17480, 18196, 18925, 19665, 20413, 21175, 21947, 22727, 23522, 24327, 25141, 25969, 26809, 27661, 28532, 29418, 30288, 31169, 32958, 883, -6069, -3364, -2796, -1881, -870, -23, 20, 40, 93, 160, 243, 346, 466, 604, 761, 935, 1127, 1338, 1564, 1810, 2072, 2351, 2647, 2962, 3292, 3636, 4000, 4379, 4773, 5024, 6228, 3812, -30500, -33367, -32542, -32642, -32566, -32472, -32360, -32228, -32079, -31913, -31730, -31527, -31308, -31071, -30816, -30544, -30255, -29950, -29626, -29288, -28930, -28558, -28170, -27763, -27342, -26906, -26452, -25985, -25502, -25006, -24492, -23965, -23422, -22867, -22300, -21715, -21120, -20510, -19886, -19251, -18603, -17942, -17271, -16586, -15890, -15184, -14465, -13734, -12995, -12243, -11480, -10708, -9924, -9128, -8324, -7522, -6624, -6138, -6725, -7195, -7689, -8200, -8725, -9264, -9819, -10386, -10967, -11561, -12169, -12789, -13424, -14069, -14728, -15399, -16080, -16775, -17481, -18197, -18925, -19665, -20413, -21175, -21947, -22728, -23523, -24327, -25141, -25969, -26809, -27661, -28532, -29418, -30288, -31169, -32958, -861, 6091, 3379, 2808, 1890, 875, 26, -18, -39, -91, -158, -242, -344, -466, -605, -762, -935, -1128, -1339, -1565, -1811, -2073, -2353, -2650, -2964, -3295, -3641, -4006, -4385, -4781, -5194, -5620, -6072};