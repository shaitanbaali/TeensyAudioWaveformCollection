/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1088 256 samples */
 
const int16_t AKWF_1088_256_DATA [256] = 
{5851, 3125, -2329, 2039, 3320, 3478, 4120, 4288, 3791, 4105, 3975, 4436, 4742, 4527, 4400, 4197, 3526, 3611, 2935, 2477, 2492, 2432, 2320, 1640, 1536, 522, 729, 1709, 213, -88, 249, -511, -397, 718, -824, 1, 233, -186, 65, 63, 268, 760, -270, 121, 266, -7, 409, 636, 842, 874, 1246, 973, 1311, 1638, 2079, 2353, 2039, 2379, 2913, 3383, 2830, 2989, 3333, 2807, 4336, 7744, 2491, 3863, 5111, 5132, 4866, 5250, 5495, 5739, 4467, 5066, 5487, 5014, 4878, 5478, 5245, 4359, 4615, 4616, 4584, 4652, 4317, 4392, 4561, 3702, 3651, 4430, 2821, 3491, 4478, 3321, 2942, 4243, 2887, 3003, 3269, 3669, 3192, 2429, 3289, 3776, 2652, 3628, 3630, 3458, 3828, 2923, 2566, 3554, 3504, 2774, 2830, 2532, 2463, 2579, 2465, 2792, 2061, 2856, 2642, 4336, 20322, 19048, 26043, 30707, 19184, 28414, 30952, 31028, 31062, 30799, 29415, 29029, 27732, 26308, 24925, 23364, 21328, 19317, 17155, 15695, 14249, 12137, 10384, 8893, 6920, 4900, 3104, 1119, -156, -1039, -3194, -3910, -5365, -7337, -7933, -7435, -9341, -9693, -10119, -11053, -11117, -12398, -12423, -11676, -13158, -13625, -13795, -13408, -13396, -14024, -14092, -14058, -13679, -13766, -14065, -14086, -13117, -12846, -12845, -12786, -13037, -11651, -11863, -12025, -11829, -12133, -10760, -7221, -11778, -10839, -10247, -9307, -8855, -9703, -9993, -8814, -9375, -9447, -9083, -8809, -9019, -8620, -8555, -8916, -9065, -8809, -8515, -8902, -8943, -8687, -8846, -9050, -8734, -8458, -9473, -8567, -8245, -9607, -9147, -7671, -8775, -8456, -8217, -8142, -7822, -8259, -7611, -7183, -8093, -7393, -7134, -6749, -6697, -7609, -7376, -6691, -6599, -6544, -5999, -6127, -6024, -5786, -5965, -5337, -5517, -5059, -4750, -4883, -4316, -4687};