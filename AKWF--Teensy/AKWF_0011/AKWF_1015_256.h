/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1015 256 samples */
 
const int16_t AKWF_1015_256_DATA [256] = 
{19282, 33334, 28217, 26673, 24569, 22463, 20353, 18248, 16140, 14028, 11924, 9814, 7703, 5589, 3551, 760, -39, 119, 84, 83, 81, 81, 79, 79, 77, 76, 76, 75, 76, 74, 73, 74, 74, 73, 72, 73, 72, 73, 72, 70, 71, 71, 71, 71, 71, 71, 71, 71, 71, 70, 71, 70, 69, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 69, 70, 69, 67, 68, 94, -19, 610, 2979, 5270, 7568, 9869, 12165, 14467, 16768, 19062, 21364, 23663, 25957, 27161, 35390, 6014, -36274, -27830, -26733, -24481, -22232, -19984, -17731, -15481, -13233, -10978, -8729, -6465, -4320, -1543, 224, 12, 57, 59, 59, 60, 62, 62, 62, 63, 64, 64, 65, 66, 67, 67, 66, 67, 68, 67, 68, 68, 68, 68, 67, 69, 70, 69, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 69, 43, 163, -1087, -3412, -5534, -7689, -9849, -12006, -14159, -16319, -18475, -20627, -22785, -24939, -27059, -29696, -29625, -19592};