/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1074 256 samples */
 
const int16_t AKWF_1074_256_DATA [256] = 
{-20354, -19047, -17765, -16480, -15195, -13908, -12619, -11333, -10044, -8753, -7467, -6218, -4402, -5547, -8302, 2037, 517, 805, 806, 807, 807, 807, 806, 807, 808, 808, 808, 808, 808, 808, 808, 808, 808, 807, 806, 807, 807, 806, 806, 805, 803, 803, 802, 800, 800, 799, 796, 795, 792, 790, 787, 784, 782, 777, 753, 1194, -930, -12396, 3889, 1856, 1753, 1340, 904, 721, 743, 741, 742, 741, 742, 742, 741, 742, 743, 742, 743, 745, 744, 745, 745, 746, 746, 747, 748, 748, 748, 749, 748, 749, 750, 749, 751, 752, 751, 752, 752, 751, 752, 753, 753, 752, 755, 756, 755, 756, 756, 755, 757, 758, 757, 758, 759, 758, 759, 760, 759, 760, 761, 762, 762, 762, 763, 763, 764, 765, 764, 765, 766, 766, 766, 766, 765, 767, 769, 768, 769, 769, 768, 769, 770, 769, 770, 773, 773, 773, 773, 773, 772, 774, 775, 774, 775, 776, 775, 776, 777, 776, 777, 779, 778, 779, 780, 779, 780, 782, 781, 782, 783, 783, 783, 783, 782, 783, 785, 786, 786, 786, 785, 786, 787, 786, 787, 789, 789, 788, 789, 790, 789, 791, 792, 791, 792, 793, 792, 793, 794, 793, 794, 796, 795, 796, 797, 797, 797, 797, 797, 797, 799, 800, 800, 800, 800, 799, 800, 801, 801, 800, 802, 803, 803, 802, 803, 804, 804, 804, 803, 805, 806, 805, 806, 806, 806, 806, 806, 806, 806, 806, 806, 830, 607, 1703, 1175, -2233, -310, 666, 740, 723, 730, 731, 731, 731, 733, 734, 734, 735, 735, 735};