/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1021 256 samples */
 
const int16_t AKWF_1021_256_DATA [256] = 
{3309, 6523, 8065, 9715, 11125, 12354, 13494, 14538, 15507, 16414, 17263, 18066, 18824, 19541, 20224, 20874, 21492, 22084, 22648, 23187, 23704, 24198, 24671, 25125, 25560, 25976, 26377, 26758, 27125, 27477, 27813, 28136, 28446, 28741, 29023, 29293, 29551, 29797, 30032, 30256, 30469, 30671, 30861, 31042, 31214, 31375, 31528, 31670, 31803, 31928, 32044, 32149, 32247, 32337, 32416, 32488, 32552, 32607, 32654, 32694, 32724, 32747, 32762, 32768, 32767, 32758, 32739, 32714, 32681, 32638, 32588, 32530, 32464, 32388, 32306, 32213, 32112, 32003, 31885, 31757, 31621, 31475, 31320, 31155, 30979, 30794, 30600, 30394, 30178, 29951, 29711, 29461, 29199, 28924, 28638, 28338, 28022, 27695, 27353, 26996, 26624, 26236, 25830, 25407, 24967, 24505, 24025, 23523, 22998, 22451, 21877, 21276, 20647, 19986, 19289, 18559, 17785, 16966, 16098, 15169, 14174, 13101, 11927, 10634, 9178, 7474, 5437, 1959, -3363, -6513, -8056, -9715, -11125, -12354, -13494, -14538, -15507, -16414, -17263, -18066, -18824, -19541, -20224, -20875, -21492, -22084, -22648, -23187, -23703, -24198, -24671, -25125, -25560, -25976, -26377, -26759, -27125, -27477, -27813, -28136, -28446, -28741, -29023, -29293, -29551, -29797, -30032, -30256, -30469, -30671, -30861, -31042, -31214, -31375, -31528, -31670, -31803, -31928, -32044, -32149, -32247, -32337, -32416, -32488, -32552, -32607, -32654, -32694, -32724, -32747, -32762, -32768, -32767, -32758, -32739, -32714, -32681, -32638, -32588, -32530, -32464, -32388, -32306, -32213, -32112, -32003, -31885, -31757, -31621, -31475, -31320, -31155, -30979, -30794, -30600, -30394, -30178, -29951, -29711, -29460, -29199, -28924, -28638, -28338, -28023, -27695, -27354, -26997, -26624, -26236, -25830, -25407, -24967, -24505, -24025, -23523, -22999, -22451, -21877, -21276, -20648, -19986, -19290, -18560, -17786, -16967, -16098, -15170, -14175, -13101, -11928, -10635, -9178, -7484, -5450, -1893};