/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1031 256 samples */
 
const int16_t AKWF_1031_256_DATA [256] = 
{3083, 7139, 6601, 6699, 6698, 6698, 6698, 6698, 6698, 6698, 6698, 6698, 6698, 6697, 6696, 6696, 6696, 6693, 6693, 6692, 6691, 6691, 6691, 6688, 6688, 6687, 6686, 6685, 6683, 6681, 6680, 6679, 6678, 6676, 6674, 6673, 6673, 6670, 6670, 6669, 6668, 6666, 6665, 6663, 6661, 6660, 6658, 6657, 6657, 6655, 6653, 6652, 6651, 6650, 6649, 6647, 6645, 6643, 6642, 6640, 6638, 6639, 6637, 6634, 6634, 6634, 6632, 6631, 6629, 6628, 6626, 6627, 6667, 6520, 7003, 14304, 19881, 19590, 19616, 19628, 19626, 19624, 19621, 19618, 19616, 19613, 19611, 19607, 19605, 19601, 19598, 19594, 19592, 19588, 19585, 19581, 19578, 19575, 19571, 19567, 19565, 19561, 19557, 19553, 19549, 19547, 19543, 19539, 19535, 19531, 19526, 19524, 19520, 19516, 19512, 19508, 19505, 19501, 19497, 19493, 19490, 19486, 19482, 19478, 19474, 19470, 19467, 19463, 19459, 19455, 19451, 19447, 19443, 19439, 19435, 19432, 19428, 19424, 19420, 19416, 19412, 19409, 19405, 19401, 19396, 19394, 19390, 19385, 19381, 19378, 19374, 19462, 19003, 22617, 30709, 32680, 32277, 32364, 32357, 32353, 32350, 31993, 33687, 24691, -8854, -24425, -19251, -19792, -19709, -19699, -19685, -19675, -19666, -19655, -19645, -19635, -19626, -19618, -19609, -19600, -19591, -19584, -19576, -19568, -19560, -19552, -19546, -19538, -19531, -19524, -19516, -19511, -19503, -19496, -19429, -19653, -18815, -8987, -5968, -6566, -6438, -6434, -6430, -6426, -6422, -6420, -6415, -6412, -6409, -6406, -6403, -6401, -6399, -6397, -6394, -6391, -6388, -6385, -6385, -6383, -6380, -6379, -6378, -6373, -6373, -6371, -6368, -6368, -6366, -6363, -6362, -6360, -6360, -6356, -6354, -6353, -6349, -6349, -6348, -6347, -6345, -6343, -6342, -6340, -6338, -6336, -6336, -6334, -6332, -6331, -6330, -6327, -6327, -6274, -6543, -5321};