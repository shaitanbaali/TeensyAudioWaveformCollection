/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1041 256 samples */
 
const int16_t AKWF_1041_256_DATA [256] = 
{2899, 4180, 5435, 6694, 7951, 9210, 10471, 11729, 12988, 14231, 15542, 16526, 15484, 14039, 12673, 11289, 9908, 8522, 7136, 5700, 4639, 1762, -1943, -407, 1447, -767, -4939, -1410, 3958, 5552, 7495, 9385, 11280, 13110, 15271, 15432, 11815, 8587, 3467, 2904, 5637, 7670, 9819, 11971, 14150, 14533, 13931, 13472, 12988, 12501, 12015, 11680, 10362, 15593, 21699, 20168, 19569, 18830, 18087, 17345, 16603, 15858, 15115, 14372, 13626, 12882, 12137, 11388, 10643, 9896, 9148, 8400, 7652, 6903, 6155, 5406, 4657, 3864, 3409, 1340, -1672, 1415, -1066, -4393, -5377, -6820, -8195, -9575, -10956, -12334, -13717, -15088, -16458, -17836, -19214, -20593, -21979, -23361, -24749, -26139, -27527, -28919, -30287, -31779, -32554, -31387, -30125, -28886, -27636, -26389, -25137, -23883, -22632, -21376, -20119, -18865, -17607, -16339, -15126, -13618, -11461, -9315, -7095, -5381, -951, 1863, -201, -1228, 2595, 4265, 5417, 6695, 7951, 9210, 10471, 11729, 12988, 14232, 15543, 16527, 15485, 14039, 12673, 11289, 9908, 8523, 7137, 5700, 4639, 1762, -1943, -405, 1447, -767, -4939, -1410, 3959, 5553, 7495, 9386, 11280, 13110, 15272, 15432, 11815, 8587, 3467, 2904, 5638, 7671, 9820, 11971, 14150, 14534, 13931, 13472, 12988, 12502, 12016, 11680, 10361, 15594, 21699, 20168, 19569, 18830, 18087, 17345, 16603, 15859, 15115, 14372, 13626, 12882, 12137, 11389, 10644, 9897, 9148, 8401, 7652, 6904, 6157, 5407, 4658, 3865, 3409, 1340, -1668, 1400, -931, -4186, -5200, -6652, -8040, -9432, -10825, -12214, -13608, -15001, -16392, -17787, -19179, -20572, -21967, -23360, -24753, -26147, -27538, -28930, -30300, -31791, -32565, -31396, -30131, -28890, -27639, -26390, -25137, -23884, -22632, -21376, -20121, -18868, -17610, -16341, -15128, -13619, -11458, -9307, -7079, -5351, -930, 1842, -145, -1432};