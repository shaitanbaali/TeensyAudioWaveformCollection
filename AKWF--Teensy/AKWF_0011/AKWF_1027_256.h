/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1027 256 samples */
 
const int16_t AKWF_1027_256_DATA [256] = 
{6802, 9132, 10391, 11343, 12077, 12661, 13136, 13497, 13858, 14116, 13811, 14319, 11656, 9014, 9007, 8781, 8670, 8606, 8646, 8024, 17395, 22725, 23088, 23833, 24181, 24628, 24816, 23580, 27134, 30196, 30174, 30268, 30071, 29980, 29909, 29850, 29799, 29751, 29708, 29670, 29635, 29601, 29503, 29846, 27045, 24259, 24114, 23760, 23539, 23364, 23091, 23701, 16792, 11482, 11175, 10423, 9941, 9566, 9138, 9462, 6423, 1510, 1117, 231, -614, -1233, -1749, -2197, -2588, -2937, -3250, -3528, -3780, -4008, -4280, -4092, -7031, -9938, -10191, -10646, -10964, -11218, -11349, -12126, -2894, 2315, 2573, 3220, 3543, 3698, 3839, 3056, 6574, 9649, 9624, 9715, 9509, 9408, 9332, 9263, 9204, 9154, 9106, 9066, 9031, 8999, 8905, 9254, 6461, 3685, 3551, 3213, 3004, 2842, 2584, 3207, -3690, -8986, -9280, -10019, -10491, -10854, -10909, -12520, 1758, 11683, 11815, 13876, 7415, 1144, 1334, 741, 403, 111, -160, -440, -643, -888, -1642, -1544, -4576, -7552, -7866, -8373, -8740, -9038, -9211, -10026, -831, 4342, 4565, 5180, 5465, 5590, 5698, 4880, 8365, 11409, 11350, 11406, 11166, 11031, 10918, 10816, 10722, 10634, 10549, 10469, 10395, 10324, 10189, 10493, 7658, 4838, 4660, 4274, 4022, 3815, 3513, 4094, -2843, -8177, -8511, -9288, -9795, -10193, -10642, -10341, -13402, -18334, -18748, -19653, -20517, -21154, -21686, -22150, -22556, -22917, -23243, -23535, -23800, -24039, -24322, -24144, -27091, -30009, -30271, -30732, -31057, -31317, -31455, -32237, -23009, -17803, -17549, -16903, -16584, -16430, -16288, -17072, -13553, -10477, -10501, -10408, -10613, -10708, -10782, -10846, -10899, -10944, -10985, -11018, -11046, -11072, -11160, -10806, -13592, -16362, -16489, -16821, -17023, -17180, -17432, -16803, -23693, -28985, -29273, -30007, -30473, -30830, -30879, -32486, -18199, -8271, -7939, -6905};