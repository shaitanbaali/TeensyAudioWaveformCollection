/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1081 256 samples */
 
const int16_t AKWF_1081_256_DATA [256] = 
{-2241, -5497, -8687, -11886, -15083, -18280, -21484, -24676, -27475, -32919, -6973, 5576, 5940, 8869, 11425, 13980, 16531, 19087, 21644, 23304, 30757, -9666, -28307, -15012, -312, -1353, -1252, -1658, -3307, -3759, -4443, -5094, -5617, -6955, -3865, 710, 183, 449, 592, 735, 878, 1020, 1163, 1306, 1438, 1638, 1554, -161, -494, -723, -1108, 665, 1179, 780, -457, 435, -87, -475, -888, -1299, -1710, -2122, -2532, -2893, -3584, -1012, 241, -4, 59, 77, 94, 112, 130, 147, 165, 182, 200, 218, 235, 253, 266, 304, 232, -43, -61, -90, -155, 0, 121, 40, -3, -54, -104, -155, -204, -256, -306, -357, -406, -458, -508, -556, -632, -636, -596, -566, -533, -499, -465, -433, -401, -368, -336, -302, -267, -236, -203, -170, -142, -92, 12, -2, 34, 59, 73, 88, 103, 120, 135, 150, 165, 180, 195, 211, 226, 241, 256, 272, 288, 303, 296, 280, 264, 248, 233, 218, 203, 187, 172, 156, 142, 127, 111, 95, 80, 65, 50, 34, 18, 3, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};