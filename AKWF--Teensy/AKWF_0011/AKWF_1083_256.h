/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1083 256 samples */
 
const int16_t AKWF_1083_256_DATA [256] = 
{1279, 4245, 7152, 10067, 12974, 15907, 18754, 20321, 21548, 22839, 24122, 25410, 24814, 23416, 22115, 21015, 19189, 1891, -509, 77, -53, -67, -82, -85, -148, 88, 1434, 2858, 4260, 5671, 7078, 8485, 9896, 11303, 12711, 14123, 15529, 16954, 18395, 19831, 21269, 22710, 24145, 25564, 27075, 28248, 27073, 25450, 24810, 20300, -541, -2472, -3602, -6521, -1174, 6746, 2358, -295, -3229, -6161, -9092, -12031, -14968, -17895, -20872, -23658, -25319, -26808, -28335, -29889, -29267, -27627, -26160, -24656, -23155, -21648, -20139, -18634, -17122, -15610, -14100, -12586, -11072, -9560, -8045, -6530, -5018, -3504, -1997, -448, 58, -20, -4, -5, -2, -21, 88, 433, 767, 1103, 1439, 1767, 2103, 2440, 2777, 3116, 3454, 3790, 4126, 4462, 4798, 5134, 5469, 5806, 6134, 6500, 6657, 6319, 5983, 5649, 5313, 4977, 4641, 4305, 3969, 3633, 3297, 2961, 2625, 2290, 1954, 1617, 1282, 946, 613, 264, 4, -1, 1, 0, 0, -1, -1, 0, -9, -30, -50, -69, -89, -109, -130, -151, -171, -190, -210, -230, -250, -270, -290, -310, -329, -349, -369, -392, -394, -371, -351, -332, -312, -292, -272, -252, -233, -213, -193, -173, -153, -132, -111, -91, -76, -14, 6, 7, 32, 41, 51, 61, 71, 80, 89, 100, 109, 119, 128, 138, 148, 157, 168, 177, 187, 190, 180, 171, 161, 151, 141, 131, 123, 113, 103, 93, 83, 74, 65, 54, 45, 35, 26, 16, -4, 24, -138, -1596, -3269, -4892, -6525, -8161, -9792, -11426, -13063, -14694, -16329, -17965, -19597, -21232, -22868, -24499, -26133, -27769, -29384, -31071, -32476, -31301, -29573, -27787, -27121, -21496, 1061, 2373, 3575, 4637, 7328, -731, -5701, -1288};