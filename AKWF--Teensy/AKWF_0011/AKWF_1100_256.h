/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1100 256 samples */
 
const int16_t AKWF_1100_256_DATA [256] = 
{77, 283, 485, 685, 887, 1087, 1288, 1488, 1688, 1889, 2088, 2289, 2491, 2692, 2895, 3098, 3301, 3506, 3712, 3918, 4126, 4336, 4546, 4759, 4973, 5189, 5407, 5627, 5850, 6075, 6303, 6534, 6768, 7004, 7244, 7483, 7713, 7935, 8145, 8342, 8530, 8707, 8873, 9029, 9177, 9315, 9445, 9566, 9680, 9786, 9884, 9974, 10059, 10137, 10209, 10274, 10333, 10387, 10436, 10480, 10518, 10552, 10581, 10606, 10627, 10644, 10657, 10665, 10671, 10674, 10672, 10668, 10661, 10651, 10638, 10623, 10605, 10584, 10562, 10537, 10510, 10482, 10451, 10419, 10384, 10348, 10310, 10271, 10232, 10190, 10147, 10102, 10057, 10011, 9963, 9915, 9866, 9815, 9765, 9712, 9660, 9607, 9553, 9499, 9444, 9388, 9332, 9276, 9220, 9163, 9106, 9047, 8989, 8932, 8872, 8815, 8755, 8697, 8639, 8579, 8520, 8461, 8402, 8343, 8283, 8224, 8165, 8106, 8047, 7988, 7930, 7871, 7812, 7754, 7696, 7638, 7581, 7523, 7466, 7408, 7351, 7295, 7238, 7182, 7127, 7071, 7016, 6961, 6906, 6852, 6797, 6743, 6690, 6637, 6583, 6530, 6478, 6426, 6375, 6253, 6370, 5608, -8682, -24762, -31184, -32687, -32586, -32040, -31392, -30730, -30077, -29432, -28799, -28179, -27568, -26968, -26381, -25802, -25234, -24677, -24128, -23590, -23061, -22541, -22031, -21529, -21035, -20551, -20076, -19607, -19147, -18695, -18250, -17814, -17384, -16961, -16546, -16137, -15736, -15342, -14952, -14570, -14193, -13823, -13459, -13102, -12749, -12401, -12060, -11723, -11391, -11065, -10744, -10426, -10115, -9808, -9504, -9206, -8912, -8622, -8337, -8054, -7776, -7501, -7230, -6963, -6699, -6437, -6181, -5926, -5675, -5426, -5181, -4939, -4699, -4461, -4226, -3995, -3763, -3535, -3310, -3086, -2864, -2645, -2427, -2210, -1996, -1783, -1571, -1361, -1151, -943, -737, -531, -328, -120};