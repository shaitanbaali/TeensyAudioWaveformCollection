/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1052 256 samples */
 
const int16_t AKWF_1052_256_DATA [256] = 
{8931, 22350, 31463, 31793, 27232, 27219, 29206, 29080, 28240, 28349, 28696, 28621, 28474, 28511, 28564, 28539, 28510, 28515, 28519, 28509, 28499, 28496, 28492, 28484, 28478, 28471, 28465, 28458, 28451, 28445, 28438, 28430, 28423, 28416, 28410, 28402, 28395, 28388, 28381, 28374, 28366, 28358, 28351, 28344, 28337, 28329, 28321, 28314, 28307, 28299, 28292, 28284, 28276, 28269, 28262, 28254, 28246, 28239, 28231, 28224, 28216, 28209, 28201, 28194, 28186, 28179, 28171, 28164, 28156, 28149, 28141, 28134, 28126, 28119, 28110, 28103, 28096, 28089, 28081, 28073, 28066, 28058, 28051, 28043, 28036, 28028, 28021, 28013, 28006, 27998, 27990, 27983, 27976, 27968, 27961, 27953, 27945, 27938, 27930, 27923, 27867, 28060, 27141, 17421, 13959, 145, -2880, 9144, 14809, -1497, -12323, -11212, 10024, 23956, 13731, -1835, -4207, -9689, -11818, -19899, -27283, -22312, -19309, -21686, -22804, -21712, -21309, -21799, -21932, -21710, -21664, -21756, -21764, -21719, -21713, -21727, -21721, -21709, -21706, -21704, -21699, -21693, -21687, -21683, -21678, -21673, -21667, -21662, -21656, -21651, -21646, -21640, -21634, -21629, -21624, -21618, -21613, -21607, -21601, -21596, -21590, -21584, -21579, -21574, -21567, -21561, -21556, -21551, -21545, -21538, -21532, -21527, -21522, -21516, -21510, -21505, -21499, -21493, -21487, -21481, -21476, -21470, -21464, -21458, -21453, -21448, -21441, -21435, -21430, -21425, -21419, -21412, -21407, -21401, -21396, -21390, -21384, -21378, -21373, -21367, -21361, -21355, -21350, -21344, -21338, -21332, -21327, -21321, -21315, -21309, -21304, -21299, -21292, -21286, -21281, -21276, -21270, -21264, -21258, -21253, -21247, -21241, -21235, -21230, -21224, -21218, -21213, -21206, -21201, -21195, -21190, -21185, -21178, -21172, -21167, -21162, -21156, -21150, -21145, -21139, -21133, -21127, -21122, -21116, -21110, -21105, -21099, -21093, -21087, -21082, -20958, -21644, -18141, -9825, -15281, -2560};