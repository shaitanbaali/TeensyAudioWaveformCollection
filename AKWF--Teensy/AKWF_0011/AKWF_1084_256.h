/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1084 256 samples */
 
const int16_t AKWF_1084_256_DATA [256] = 
{2261, 5663, 8073, 9698, 9662, 9116, 7726, 5855, 4523, 3353, 2598, 1469, 801, 116, -603, -989, -1510, -1792, -2149, -2390, -2565, -2769, -2813, -2769, -2663, -2578, -2457, -2271, -2574, -2637, -2167, -1547, 1705, 1978, 1073, 492, -335, -928, -1156, -1182, -1091, -910, -565, -66, 121, 270, 353, 459, 554, 627, 682, 727, 762, 784, 798, 805, 631, 1426, -3144, -16942, -18715, -13681, -7114, -2811, 185, 4592, 6875, 7776, 8292, 7643, 6690, 5290, 3502, 2731, 1962, 1036, 369, -51, -649, -1074, -1334, -1686, -1919, -2055, -2205, -2377, -2775, -2661, -2436, -1854, -1498, -1343, -1104, -1289, 252, 4309, 2090, -304, -1548, -3960, -8822, -9418, -6118, -3975, -1807, -653, 286, 1166, 1914, 2282, 2321, 2203, 1877, 1596, 1456, 1235, 1027, 902, 765, 611, 263, 1289, -5064, -24364, -25656, -16947, -11261, -4174, 1833, 6006, 8760, 10653, 10822, 10138, 8666, 6855, 4944, 4065, 2722, 1940, 875, 60, -528, -1209, -1605, -2110, -2376, -2713, -2936, -3138, -3181, -3115, -3002, -2874, -2715, -2517, -2687, -2789, -2338, -1683, 1597, 1886, 991, 417, -413, -993, -1192, -1179, -1043, -786, -429, -57, 136, 312, 455, 575, 669, 719, 784, 835, 872, 896, 912, 920, 742, 1529, -2929, -17351, -21894, -15462, -9888, -5242, -2192, 1836, 5056, 6344, 7072, 6969, 6468, 5742, 4481, 2848, 1257, 413, -228, -774, -1069, -1445, -1767, -2010, -2190, -2313, -2383, -2408, -2418, -2396, -2359, -2221, -2505, -3174, -2447, -1927, -704, 4119, 5243, 2435, 781, -734, -3049, -4623, -4677, -3306, -1782, -906, -322, 193, 478, 725, 922, 1048, 1123, 1139, 1103, 1048, 1015, 964, 913, 880, 624, 1535, -3909, -20598, -21711, -14184, -9210, -3192};