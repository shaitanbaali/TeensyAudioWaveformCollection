/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1011 256 samples */
 
const int16_t AKWF_1011_256_DATA [256] = 
{364, 110, 8646, 13951, 17275, 21057, 24758, 28671, 31517, 31275, 30942, 30635, 30310, 29980, 29646, 29307, 28963, 28613, 28258, 27901, 27536, 27167, 26794, 26417, 26034, 25647, 25256, 24858, 24458, 24052, 23642, 23227, 22806, 22383, 21954, 21522, 21096, 20686, 20273, 19860, 19446, 19029, 18614, 18195, 17777, 17357, 16935, 16513, 16090, 15665, 15239, 14814, 14385, 13956, 13526, 13094, 12663, 12230, 11794, 11360, 10923, 10485, 9885, 10327, 3976, -783, 8042, 10018, 10028, 10519, 10936, 11353, 11771, 12188, 12605, 13024, 13442, 13858, 14275, 14693, 15109, 15526, 15944, 16360, 16778, 17195, 17610, 18028, 18444, 18860, 19277, 19693, 20109, 20525, 20941, 21357, 21772, 22188, 22604, 23019, 23435, 23849, 24265, 24680, 25094, 25511, 25924, 26338, 26753, 27169, 27583, 27997, 28410, 28825, 29239, 29652, 30066, 30478, 30891, 31305, 31674, 32283, 31509, 27787, 24116, 20438, 16610, 13775, 4215, -960, -7940, -10281, -10301, -10799, -11227, -11652, -12077, -12504, -12926, -13352, -13775, -14198, -14622, -15044, -15467, -15889, -16311, -16732, -17155, -17575, -17997, -18418, -18838, -19258, -19679, -20099, -20519, -20940, -21358, -21777, -22198, -22616, -23035, -23455, -23873, -24291, -24711, -25128, -25546, -25965, -26383, -26800, -27219, -27636, -28053, -28470, -28888, -29306, -29722, -30138, -30555, -30973, -31388, -31799, -32199, -32711, -30549, -26903, -23501, -20046, -16447, -13980, -3997, -1799, -12079, -15343, -19345, -23270, -27168, -31267, -32603, -31946, -31574, -31150, -30726, -30303, -29878, -29453, -29030, -28605, -28180, -27756, -27331, -26907, -26482, -26058, -25633, -25209, -24784, -24360, -23936, -23511, -23087, -22664, -22238, -21816, -21392, -20967, -20544, -20120, -19697, -19273, -18850, -18426, -18004, -17581, -17157, -16735, -16312, -15889, -15467, -15045, -14621, -14201, -13778, -13356, -12935, -12513, -12090, -11670, -11247, -10827, -10406, -9984, -9565, -9137};