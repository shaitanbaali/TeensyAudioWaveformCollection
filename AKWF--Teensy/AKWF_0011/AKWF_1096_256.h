/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1096 256 samples */
 
const int16_t AKWF_1096_256_DATA [256] = 
{487, 1907, 3794, 5901, 8057, 10181, 12216, 14138, 15941, 17628, 19194, 20619, 21952, 23176, 24306, 25334, 26255, 27093, 27852, 28519, 29124, 29674, 30154, 30581, 30967, 31298, 31593, 31869, 32116, 32319, 32490, 32642, 32732, 32766, 32750, 32652, 32467, 32245, 31979, 31696, 31465, 31323, 31130, 30836, 30532, 30214, 29884, 29588, 29308, 29010, 28719, 28413, 28053, 27667, 27262, 26810, 26318, 25840, 25370, 24906, 24503, 24187, 23952, 23467, 22945, 22517, 22066, 21617, 21193, 20776, 20375, 20015, 19662, 19356, 19113, 18892, 18674, 18515, 18407, 18339, 18354, 18469, 18656, 18883, 19131, 19259, 19355, 19603, 19884, 20096, 20218, 20273, 20250, 20168, 19954, 19484, 19092, 18769, 18492, 18156, 17738, 17293, 16797, 16228, 15615, 14946, 14202, 13368, 12503, 11596, 10633, 9661, 8669, 7637, 6597, 5576, 4563, 3567, 2618, 1737, 904, 127, -538, -1034, -1389, -1798, -2237, -2794, -3645, -4532, -5296, -5999, -6642, -7265, -7920, -8583, -9273, -9973, -10671, -11366, -12041, -12682, -13292, -13866, -14389, -14879, -15319, -15699, -16174, -16720, -17090, -17371, -17658, -17928, -18157, -18371, -18602, -18807, -18991, -19160, -19289, -19403, -19511, -19588, -19595, -19543, -19424, -19203, -18906, -18608, -18392, -18234, -17969, -17643, -17327, -17115, -17013, -16987, -17047, -17193, -17390, -17620, -17920, -18264, -18611, -18982, -19363, -19702, -19965, -21195, -21826, -22605, -23224, -23782, -24300, -24692, -25037, -25353, -25669, -25993, -26284, -26525, -26772, -27021, -27257, -27520, -27826, -28154, -28488, -28855, -29194, -29441, -29632, -29901, -30201, -30485, -30763, -30977, -31102, -31174, -31191, -31108, -31088, -31272, -31277, -31138, -30931, -30706, -30450, -30176, -29879, -29530, -29121, -28748, -28512, -28106, -27574, -26987, -26313, -25551, -24735, -23856, -22881, -21830, -20665, -19367, -17966, -16452, -14805, -13016, -11100, -9059, -6909, -4731, -2651, -821};