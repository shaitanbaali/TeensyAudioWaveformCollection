/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1018 256 samples */
 
const int16_t AKWF_1018_256_DATA [256] = 
{318, 837, 1385, 1951, 2528, 3111, 3699, 4285, 4870, 5451, 6025, 6594, 7156, 7710, 8264, 8820, 9384, 9963, 10563, 11182, 11827, 12495, 13181, 13885, 14602, 15323, 16047, 16767, 17477, 18178, 18863, 19529, 20181, 20812, 21426, 22023, 22602, 23164, 23711, 24241, 24756, 25255, 25736, 26203, 26652, 27081, 27491, 27881, 28248, 28594, 28913, 29207, 29476, 29715, 29928, 30112, 30267, 30393, 30490, 30560, 30600, 30614, 30602, 30562, 30497, 30408, 30295, 30159, 29999, 29818, 29614, 29389, 29144, 28877, 28590, 28283, 27958, 27615, 27253, 26873, 26479, 26066, 25639, 25198, 24742, 24272, 23792, 23297, 22793, 22278, 21752, 21218, 20675, 20122, 19562, 18995, 18421, 17839, 17252, 16656, 16054, 15447, 14832, 14214, 13589, 12958, 12324, 11682, 11037, 10389, 9735, 9077, 8418, 7754, 7087, 6419, 5745, 5071, 4396, 3717, 3037, 2357, 1674, 997, 274, -584, -1508, -2462, -3439, -4432, -5440, -6461, -7488, -8523, -9563, -10601, -11639, -12676, -13702, -14721, -15729, -16721, -17699, -18659, -19597, -20515, -21411, -22279, -23123, -23937, -24719, -25471, -26190, -26875, -27526, -28141, -28719, -29261, -29764, -30229, -30657, -31043, -31393, -31703, -31973, -32202, -32393, -32544, -32656, -32729, -32765, -32762, -32722, -32645, -32531, -32382, -32200, -31983, -31733, -31452, -31139, -30795, -30425, -30025, -29600, -29152, -28679, -28186, -27673, -27144, -26597, -26039, -25466, -24884, -24295, -23698, -23098, -22494, -21888, -21285, -20681, -20080, -19487, -18898, -18316, -17746, -17185, -16637, -16100, -15575, -15066, -14571, -14088, -13622, -13171, -12734, -12312, -11906, -11513, -11134, -10770, -10419, -10079, -9752, -9436, -9129, -8833, -8542, -8261, -7985, -7712, -7445, -7180, -6917, -6655, -6392, -6127, -5862, -5592, -5318, -5045, -4774, -4509, -4249, -3992, -3735, -3473, -3198, -2906, -2591, -2248, -1877, -1477, -1051, -607, -139};