/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1070 256 samples */
 
const int16_t AKWF_1070_256_DATA [256] = 
{32579, 31990, 31414, 30838, 30264, 29692, 29118, 28549, 27980, 27410, 26852, 26288, 25732, 25185, 24635, 24089, 23544, 22998, 22456, 21915, 21372, 20828, 20329, 19622, 18941, 19540, 20091, 20647, 21200, 21758, 22315, 22871, 23429, 23986, 24541, 25097, 25654, 26211, 26769, 27325, 27881, 28437, 28993, 29551, 30109, 30665, 31222, 31170, 34963, 16156, -2603, 597, 0, -88, 395, -1598, -11898, -11510, -11079, -10706, -10314, -9919, -9528, -9133, -8741, -8348, -7956, -7568, -7148, -6910, -7223, -7558, -7885, -8214, -8542, -8872, -9202, -9530, -9860, -10189, -10519, -10848, -11094, -11867, -10389, -86, 43, -23, 0, 0, 0, 0, 0, 0, 0, 110, -508, 6239, 8948, 8046, 7894, 7627, 7360, 7094, 6828, 6560, 6294, 6026, 5760, 5497, 5223, 4986, 5134, 5369, 5584, 5805, 6025, 6244, 6465, 6685, 6904, 7125, 7345, 7564, 7785, 8005, 8067, 9128, 3654, -655, 148, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -90, 396, -2174, -5521, -4749, -4592, -4337, -4082, -3829, -3576, -3321, -3062, -3168, -3447, -3697, -3950, -4204, -4460, -4617, -5387, -2620, 411, -95, -292, 1296, -6760, -19499, -17681, -17839, -17690, -17539, -17389, -17239, -17088, -16939, -16788, -16638, -16490, -16338, -16189, -16038, -15889, -15738, -15588, -15438, -15289, -15138, -14988, -14838, -14689, -14537, -14388, -14239, -14088, -13938, -13788, -13638, -13488, -13337, -13188, -13039, -12887, -12738, -12588, -12437, -12287, -12138, -11988, -11838, -11687, -11538, -11387, -11238, -11086, -10938, -10788, -10643, -10469, -10450, -10870, -11301, -11728, -12158, -12587, -13017, -13446, -13874, -14304, -14733, -15162, -15592, -16020, -16449, -16879, -16974, -19188, -8162, 1405, -321, 0, 0, 0};