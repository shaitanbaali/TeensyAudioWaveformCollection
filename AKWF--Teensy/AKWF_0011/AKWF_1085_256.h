/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1085 256 samples */
 
const int16_t AKWF_1085_256_DATA [256] = 
{1488, -9181, -9231, -4620, -2243, -64, 1877, 3427, 4698, 5751, 6622, 7352, 7970, 8494, 8948, 9341, 9686, 9994, 10267, 10514, 10738, 10941, 11129, 11300, 11459, 11606, 11741, 11865, 11981, 12087, 12184, 12272, 12352, 12424, 12488, 12545, 12593, 12635, 12669, 12696, 12715, 12727, 12733, 12731, 12723, 12707, 12686, 12657, 12622, 12581, 12533, 12478, 12418, 12352, 12279, 12201, 12116, 12027, 11932, 11831, 11725, 11614, 11498, 11376, 11249, 11118, 10982, 10841, 10697, 10548, 10394, 10237, 10076, 9910, 9742, 9570, 9393, 9214, 9032, 8846, 8658, 8467, 8273, 8077, 7878, 7677, 7474, 7269, 7062, 6853, 6643, 6431, 6218, 6003, 5788, 5572, 5354, 5136, 4918, 4698, 4479, 4259, 4039, 3819, 3599, 3379, 3161, 2942, 2723, 2506, 2290, 2074, 1860, 1646, 1433, 1223, 1012, 805, 599, 393, 190, -10, -209, -406, -600, -792, -983, -1171, -1356, -1539, -1719, -1897, -2072, -2243, -2411, -2578, -2741, -2901, -3057, -3211, -3362, -3508, -3652, -3792, -3929, -4063, -4193, -4319, -4442, -4561, -4677, -4789, -4897, -5002, -5102, -5200, -5293, -5382, -5468, -5551, -5629, -5704, -5774, -5841, -5904, -5963, -6019, -6071, -6118, -6163, -6203, -6240, -6273, -6302, -6328, -6350, -6368, -6383, -6394, -6402, -6406, -6407, -6404, -6398, -6388, -6376, -6359, -6340, -6317, -6291, -6262, -6231, -6196, -6157, -6117, -6072, -6026, -5977, -5924, -5869, -5812, -5751, -5689, -5625, -5558, -5488, -5416, -5342, -5265, -5187, -5107, -5025, -4941, -4855, -4768, -4678, -4587, -4495, -4400, -4305, -4208, -4109, -4010, -3910, -3808, -3705, -3601, -3497, -3391, -3285, -3178, -3071, -2962, -2853, -2745, -2635, -2857, -796, -10920, -28074, -15662, -17920, -21275, -22828, -24302, -25447, -26211, -26707, -26985, -27086, -27045, -26893, -26650, -26264, -26268, -23815};