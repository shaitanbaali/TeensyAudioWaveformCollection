/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1058 256 samples */
 
const int16_t AKWF_1058_256_DATA [256] = 
{478, 1113, 1618, 2112, 2826, 3642, 4356, 4950, 5508, 6101, 6768, 7440, 8073, 8642, 9208, 9800, 10424, 11043, 11640, 12209, 12781, 13363, 13949, 14523, 15068, 15590, 16096, 16585, 17050, 17482, 17870, 18217, 18526, 18795, 19019, 19193, 19312, 19382, 19407, 19237, 19516, 17958, -15053, -29196, -2842, 8479, 4440, -3543, -7521, -4043, 2454, 7479, 6581, 4190, 3508, 7176, 11340, 13867, 13569, 13022, 13720, 15894, 17887, 18523, 18030, 17405, 17503, 17920, 18040, 17337, 16172, 13519, 10341, 8127, 6271, 4088, 1601, -842, -2833, -4312, -5392, -6303, -7017, -7384, -7234, -6593, -5601, -4682, -4044, -3365, -2495, -1524, -637, 56, 573, 994, 1358, 1620, 1706, 1587, 1304, 917, 458, -85, -715, -1412, -2133, -2833, -3482, -4075, -4602, -5048, -5384, -5597, -5683, -5648, -5501, -5252, -4902, -4466, -3963, -3420, -2854, -2293, -1741, -1241, -2499, -5128, -6973, -8299, -9711, -11533, -13652, -15690, -17371, -18615, -19664, -20605, -21388, -21803, -21521, -20394, -19508, -18885, -18171, -17098, -15742, -14274, -12879, -11569, -10254, -8848, -7401, -6045, -4846, -3815, -2891, -2061, -1351, -822, -488, -328, -300, -395, -611, -953, -1414, -1956, -2556, -3141, -3595, -3965, -4297, -4575, -4767, -4843, -4806, -4678, -4481, -4219, -3891, -3503, -3072, -2625, -2183, -1759, -1362, -1001, -693, -449, -282, -192, -175, -233, -360, -556, -808, -1106, -1436, -1788, -2146, -2502, -2838, -3144, -3410, -3627, -3789, -3892, -3930, -3907, -3826, -3688, -3502, -3276, -3016, -2733, -2442, -2151, -1870, -1608, -1375, -1179, -1027, -922, -868, -863, -907, -999, -1132, -1304, -1504, -1724, -1955, -2193, -2424, -2645, -2845, -3015, -3152, -3253, -3315, -3336, -3316, -3257, -3160, -3032, -2879, -2706, -2520, -2327, -2133, -1948, -1773, -1644, -1299, -344};