/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1079 256 samples */
 
const int16_t AKWF_1079_256_DATA [256] = 
{1659, 4737, 7754, 10780, 13803, 16826, 19820, 24130, 23948, 22465, 21267, 20018, 18766, 17519, 16057, 15968, 8900, -1678, -1055, -1899, -2493, -3318, 1205, 940, -1295, -3087, -4982, -6736, -7499, -7921, -9440, -5279, 907, 185, 510, 674, 837, 1000, 1163, 1325, 1490, 1652, 1815, 1978, 2141, 2248, 2745, 1385, -907, -267, -749, -967, -1500, 354, 1083, 390, -18, -469, -922, -1374, -1825, -2278, -2696, -3329, -3011, 296, 547, 842, 1141, 1437, 1654, 2377, 257, -1965, -932, -432, 154, 737, 1315, 1920, 2458, 215, -308, -351, -506, -645, -783, -922, -1061, -1177, -1445, -397, 18, -893, -1717, -2474, -3709, -2727, 1670, -2065, -1456, -410, 515, 1458, 2402, 3348, 4218, 5548, 4785, -1131, -1954, -3020, -4058, -5096, -6134, -7170, -8208, -9246, -10282, -11227, -12707, -12189, 10401, 10149, 6662, 3977, 1265, -2058, -1499, 737, 734, 1139, 1485, 1832, 2178, 2526, 2873, 3219, 3429, 4526, -983, -3476, -1333, -85, 1299, 154, -294, -359, -510, -649, -789, -929, -1069, -1209, -1348, -1459, -1762, -1213, 1550, 1004, 518, 37, -460, -854, -1829, -300, 938, 287, -981, -225, 289, 842, 1396, 1948, 2501, 3025, 3727, 3677, -208, -692, -1022, -1400, -1769, -2138, -2508, -2775, -3704, 1377, 3302, 1953, 1275, 493, -289, -1071, -1853, -2688, -3181, -5563, -7408, -6692, -6390, -6021, -5652, -5214, -5222, -2985, 618, 497, 806, 1310, -332, -841, 39, 640, 1279, 1924, 2567, 3219, 3621, 3880, 4162, 4440, 4665, 5218, 4354, -1617, 1151, 118, -2178, -4187, -6244, -8295, -10350, -12407, -14458, -16513, -18569, -20620, -22676, -24732, -26782, -28287, -33297, -20362, 3760, 2072, 3855, 5106, 6356, 7586, 8788, 10552, -6533, -8295, -4165, -1289};