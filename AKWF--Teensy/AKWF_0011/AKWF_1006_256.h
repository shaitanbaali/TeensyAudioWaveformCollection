/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1006 256 samples */
 
const int16_t AKWF_1006_256_DATA [256] = 
{29804, 29808, 29808, 29810, 29810, 29808, 29809, 29806, 29804, 29800, 29797, 29792, 29789, 29785, 29292, 32145, 17743, -226, 29889, 29936, 29714, 29761, 29756, 29749, 29743, 29733, 29609, 30155, 28163, 547, -2344, -173, -6613, -33301, -32688, -32736, -32768, -32768, -32766, -32765, -32763, -32759, -32442, -34523, -24865, -24327, -34498, -32324, -32655, -32649, -32642, -32636, -32629, -32622, -32615, -32503, -32978, -31296, -3758, -805, -1571, -1287, -1907, 394, 28005, 30304, 29681, 29810, 29810, 29808, 29809, 29806, 29804, 29800, 29797, 29792, 29789, 29785, 29292, 32145, 17743, -226, 29890, 29933, 29701, 29765, 29759, 29752, 29745, 29740, 29618, 30164, 28174, 548, -2344, -173, -6613, -33301, -32688, -32736, -32768, -32768, -32766, -32765, -32763, -32759, -32442, -34523, -24865, -24327, -34498, -32324, -32655, -32649, -32642, -32636, -32629, -32622, -32615, -32503, -32978, -31296, -3758, -805, -1571, -1287, -1906, 394, 28005, 30304, 29681, 29810, 29810, 29808, 29809, 29806, 29804, 29800, 29797, 29792, 29789, 29785, 29292, 32145, 17743, -226, 29890, 29933, 29701, 29765, 29759, 29752, 29745, 29740, 29618, 30164, 28174, 548, -2344, -173, -6613, -33301, -32688, -32736, -32768, -32768, -32766, -32765, -32763, -32759, -32442, -34523, -24865, -24327, -34498, -32324, -32655, -32649, -32642, -32636, -32629, -32622, -32615, -32503, -32978, -31296, -3758, -805, -1571, -1287, -1906, 394, 28005, 30304, 29681, 29810, 29811, 29809, 29808, 29806, 29804, 29800, 29797, 29792, 29789, 29785, 29292, 32145, 17743, -226, 29890, 29933, 29701, 29765, 29759, 29752, 29745, 29740, 29618, 30164, 28174, 548, -2344, -173, -6613, -33301, -32688, -32736, -32768, -32768, -32766, -32765, -32763, -32759, -32442, -34523, -24865, -24327, -34498, -32324, -32655, -32649, -32642, -32636, -32629, -32622, -32615, -32503, -32978, -31296, -3758, -805, -1571, -1415, -1409, -1405};