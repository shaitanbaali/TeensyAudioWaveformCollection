/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1002 256 samples */
 
const int16_t AKWF_1002_256_DATA [256] = 
{-24129, -24912, -25680, -26449, -27218, -27986, -28755, -29521, -30289, -31054, -31820, -32589, -32518, -32090, -31724, -31346, -30969, -30591, -30211, -29834, -29455, -29076, -28699, -28319, -27941, -27562, -27183, -26804, -26426, -26046, -25668, -25289, -24910, -24051, -26262, -7778, 5496, 2989, 3461, 3466, 3470, 3474, 3477, 3479, 3481, 3484, 3486, 3487, 3489, 3488, 3489, 3486, 3412, 3896, -6368, -9749, -9551, -10133, -10599, -11065, -11529, -11986, -12489, -12490, -12084, -11733, -11372, -11012, -10652, -10289, -9927, -9448, -9761, -6441, 3936, 3451, 3527, 3535, 3536, 3536, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3539, 3537, 3535, 3536, 3536, 3536, 3533, 3532, 3533, 3533, 3530, 3529, 3530, 3529, 3527, 3527, 3527, 3525, 3523, 3524, 3523, 3520, 3521, 3520, 3517, 3518, 3518, 3516, 3516, 3516, 3513, 3512, 3513, 3511, 3509, 3510, 3508, 3506, 3507, 3505, 3503, 3504, 3503, 3684, 2708, 8312, 14571, 13919, 14420, 14738, 15056, 15374, 15693, 16010, 16321, 16668, 16674, 16366, 16093, 15815, 15538, 15259, 14981, 14704, 14426, 14012, 14486, 10648, 2803, 3570, 3428, 3426, 3423, 3420, 3417, 3416, 3413, 3411, 3409, 3407, 3405, 3404, 3402, 3401, 3399, 3399, 3397, 3397, 3394, 3394, 3392, 3391, 3548, 2700, 7165, 13466, 12841, 13243, 13485, 13725, 13966, 14208, 14448, 14688, 14929, 15163, 15429, 15498, 15230, 14977, 14722, 14467, 14212, 13956, 13702, 13446, 13128, 13218, 11554, 3368, 3284, 3329, 3308, 3305, 3304, 3302, 3299, 3297, 3295, 3293, 3292, 3290, 3288, 3286, 3286, 3283, 3283, 3280, 3280, 3278, 3276, 3276, 3275, 3275, 3273, 3271, 3272, 3269, 3269, 3269, 3266, 3266, 3266, 3263, 3263, 3262, 3260, 3260, 3259, 3257, 3257, 3257};