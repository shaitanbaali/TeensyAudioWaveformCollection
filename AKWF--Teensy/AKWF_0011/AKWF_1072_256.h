/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1072 256 samples */
 
const int16_t AKWF_1072_256_DATA [256] = 
{29155, 25738, 19870, 12381, 3616, 2530, 4053, 4453, 5083, 5697, 6309, 6921, 7533, 8139, 8741, 9341, 9935, 10527, 11111, 11689, 12264, 12829, 13387, 13942, 14486, 15025, 15554, 16075, 16589, 17092, 17583, 18067, 18540, 19004, 19454, 19894, 20321, 20736, 21139, 21529, 21907, 22271, 22619, 22953, 23277, 23586, 23881, 24162, 24428, 24683, 24924, 25154, 25368, 25571, 25763, 25941, 26108, 26266, 26412, 26547, 26673, 26790, 26896, 26996, 27086, 27169, 27245, 27316, 27378, 27435, 27487, 27533, 27577, 27615, 27648, 27677, 27706, 27731, 27753, 27774, 27790, 27805, 27820, 27831, 27843, 27853, 27862, 27869, 27875, 27882, 27887, 27891, 27895, 27899, 27901, 27905, 27904, 27906, 27908, 27910, 27914, 27920, 27927, 27935, 27948, 27959, 27971, 27986, 28005, 28022, 28041, 28063, 28087, 28111, 28136, 28167, 28198, 28230, 28264, 28297, 28333, 28371, 28411, 28450, 28491, 28532, 28574, 28617, 28659, 28702, 28745, 28787, 28830, 28871, 28912, 28953, 28993, 29032, 29069, 29107, 29142, 29179, 29212, 29246, 29276, 29307, 29336, 29367, 29394, 29419, 29444, 29469, 29492, 29513, 29534, 29552, 29574, 29594, 29609, 29626, 29644, 29659, 29674, 29689, 29703, 29719, 29731, 29744, 29757, 29770, 29780, 29794, 29803, 29811, 29823, 29834, 29842, 29849, 29857, 29865, 29872, 29878, 29883, 29890, 29895, 29898, 29902, 29905, 29908, 29911, 29913, 29916, 29917, 29916, 29921, 29922, 29921, 29921, 29921, 29921, 29921, 29921, 29921, 29921, 29921, 29921, 29841, 30145, 29263, 631, -3112, -1589, -1292, -777, -245, 305, 870, 1439, 1997, 2831, -3762, -5422, -4850, -4722, -4480, -4199, -3885, -3605, -2868, -7409, -14976, -20505, -24597, -27257, -28760, -29477, -29744, -29808, -29813, -29824, -29911, -30095, -30351, -30644, -30950, -31236, -31480, -31672, -31809, -31893, -31941, -31962, -31969, -31460, -34216, -20033};