/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1040 256 samples */
 
const int16_t AKWF_1040_256_DATA [256] = 
{5341, 14623, 14990, 15145, 15482, 15736, 16015, 16281, 16548, 16825, 17085, 17361, 17626, 17897, 18165, 18431, 18700, 18967, 19236, 19501, 19772, 20035, 20305, 20570, 20838, 21104, 21370, 21640, 21898, 22169, 22435, 22699, 22970, 23229, 23500, 23762, 24027, 24295, 24552, 24829, 25083, 25356, 25619, 25874, 26155, 26401, 26680, 26936, 27198, 27474, 27718, 28004, 28248, 28520, 28788, 29033, 29322, 29553, 29839, 30096, 30343, 30636, 30855, 31157, 31390, 31657, 31939, 32150, 32439, 32844, 30616, 27301, 24051, 21147, 17668, 15523, -544, -3351, -2021, -1661, -1468, -697, -3036, -3585, -3571, -3792, -3881, -4062, -4182, -4320, -4484, -4588, -4767, -4878, -5029, -5175, -5294, -5462, -5571, -5729, -5860, -5992, -6147, -6264, -6423, -6547, -6687, -6830, -6953, -7108, -7229, -7376, -7513, -7642, -7793, -7913, -8062, -8192, -8327, -8473, -8597, -8745, -8873, -9013, -9151, -9279, -9425, -9550, -9694, -9829, -9960, -10102, -10230, -10373, -10504, -10642, -10779, -10908, -11050, -11179, -11317, -11452, -11585, -11724, -11853, -11995, -12126, -12261, -12397, -12529, -12667, -12798, -12936, -13069, -13203, -13340, -13471, -13609, -13741, -13876, -14011, -14143, -14279, -14412, -14546, -14681, -14814, -14948, -15081, -15218, -15350, -15484, -15617, -15751, -15884, -16016, -16148, -16280, -16416, -16548, -16682, -16815, -16948, -17082, -17214, -17348, -17477, -17611, -17744, -17875, -18011, -18138, -18275, -18404, -18534, -18672, -18796, -18930, -19072, -19164, -18747, -18300, -17870, -17432, -16995, -16563, -16121, -15692, -15252, -14820, -14379, -13944, -13513, -13068, -12642, -12199, -11765, -11334, -10887, -10465, -10018, -9590, -9152, -8711, -8289, -7835, -7416, -6971, -6537, -6112, -5652, -5251, -4789, -4361, -3952, -3413, -3321, -1297, -18, -488, -530, -681, -819, -946, -1090, -1219, -1363, -1486, -1639, -1758, -1902, -2051, -2142, -2360, -2357, -2910};