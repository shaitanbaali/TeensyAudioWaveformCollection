/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1069 256 samples */
 
const int16_t AKWF_1069_256_DATA [256] = 
{10576, 10517, 10458, 10399, 10342, 10283, 10224, 10166, 10107, 10049, 9989, 9932, 9873, 9814, 9756, 9697, 9639, 9579, 9521, 9463, 9405, 9345, 9287, 9228, 9170, 9111, 9053, 8994, 8936, 8877, 8819, 8759, 8701, 8642, 8584, 8526, 8467, 8408, 8350, 8291, 8233, 8173, 8116, 8057, 7998, 7941, 7880, 7823, 7764, 7705, 7647, 7588, 7530, 7471, 7413, 7354, 7295, 7237, 7179, 7120, 7061, 7002, 6944, 6885, 6827, 6768, 6710, 6651, 6593, 6534, 6475, 6416, 6358, 6300, 6242, 6182, 6139, 6018, 6305, 7438, 9457, 6634, -8403, -33590, -30927, -30237, -29240, -28235, -27229, -26224, -25219, -24214, -23211, -22206, -21201, -20218, -19119, -18873, -19671, -20378, -21097, -21817, -22538, -23258, -23980, -24702, -25421, -26142, -26864, -27584, -28305, -29026, -29745, -30467, -30585, -34523, -15561, 2565, -589, 114, -509, 2737, 7114, 6010, 5701, 5267, 4839, 4407, 3996, 4181, 4560, 4901, 5247, 5596, 5908, 6438, 6079, 241, -73, 20, 0, 0, 0, 0, 0, 0, 0, -77, 342, -3343, -5106, -4424, -4233, -3965, -3697, -3433, -3161, -2906, -3007, -3219, -3411, -3606, -3802, -3997, -4193, -4388, -4493, -5172, -2637, 393, -90, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 23, -125, 3237, 3958, 3454, 3221, 2947, 2674, 2388, 2473, 2758, 3010, 3268, 3452, 4101, 1632, -299, 67, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};