/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1063 256 samples */
 
const int16_t AKWF_1063_256_DATA [256] = 
{23454, 33061, 31491, 32018, 32218, 32404, 32564, 32682, 32752, 32767, 32726, 32631, 32488, 32311, 32091, 31836, 31560, 31259, 30934, 30585, 30211, 29812, 29390, 28944, 28475, 27982, 27466, 26928, 26369, 25789, 25190, 24572, 23934, 23282, 22613, 21928, 21231, 20522, 19801, 19073, 18336, 17591, 16844, 16092, 15339, 14587, 13834, 13086, 12345, 11609, 10881, 10165, 9459, 8769, 8094, 7435, 6795, 6177, 5578, 5004, 4455, 3932, 3436, 2971, 2534, 2129, 1757, 1418, 1114, 845, 612, 415, 257, 135, 52, 7, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, -4, -13, -29, -53, -88, -135, -194, -266, -353, -456, -574, -709, -861, -1030, -1218, -1424, -1648, -1892, -2155, -2436, -2738, -3057, -3397, -3755, -4131, -4525, -4938, -5366, -5813, -6275, -6753, -7247, -7754, -8274, -8808, -9355, -9910, -10476, -11053, -11635, -12226, -12823, -13423, -14029, -14637, -15245, -15855, -16464, -17068, -17672, -18271, -18863, -19449, -20026, -20594, -21153, -21698, -22232, -22752, -23256, -23745, -24217, -24670, -25106, -25520, -25914, -26287, -26637, -26964, -27267, -27546, -27799, -28029, -28230, -28404, -28553, -28675, -28768, -28658, -29648, -24546};