/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1016 256 samples */
 
const int16_t AKWF_1016_256_DATA [256] = 
{1986, 21582, 26449, 25088, 25051, 24798, 24543, 24284, 24021, 23755, 23485, 23213, 22938, 22660, 22378, 22093, 21807, 21516, 21224, 20929, 20630, 20328, 20025, 19718, 19408, 19095, 18781, 18464, 18144, 17820, 17494, 17167, 16836, 16502, 16167, 15828, 15480, 15131, 14780, 14429, 14077, 13723, 13371, 13015, 12659, 12304, 11948, 11590, 11131, 11341, 8415, 889, 1397, 1305, 1301, 1299, 1297, 1294, 1293, 1290, 1290, 1288, 1287, 1285, 1283, 1283, 1280, 1281, 1280, 1277, 1278, 1278, 1276, 1274, 1275, 1275, 1275, 1273, 1272, 1273, 1276, 1343, 925, 8601, 11265, 11079, 11508, 11847, 12185, 12523, 12861, 13199, 13536, 13874, 14211, 14547, 14885, 15221, 15558, 15894, 16231, 16567, 16904, 17240, 17575, 17911, 18248, 18582, 18919, 19254, 19589, 19924, 20258, 20596, 20931, 21265, 21600, 21935, 22269, 22604, 22939, 23273, 23606, 23939, 24273, 24609, 24943, 25275, 25609, 25944, 26222, 26550, 27404, -6852, -20659, -26737, -32561, -32183, -31631, -31143, -30629, -30115, -29601, -29085, -28569, -28053, -27537, -27023, -26504, -25986, -25470, -24952, -24434, -23917, -23399, -22881, -22363, -21844, -21326, -20808, -20290, -19772, -19254, -18736, -18218, -17700, -17182, -16665, -16147, -15629, -15113, -14594, -14076, -13559, -13043, -12525, -11875, -12113, -8192, 1802, 1127, 1246, 1251, 1254, 1257, 1258, 1260, 1261, 1264, 1263, 1266, 1267, 1266, 1269, 1270, 1269, 1270, 1270, 1270, 1270, 1272, 1273, 1273, 1273, 1273, 1273, 1273, 1273, 1139, 1882, -1471, -11473, -11361, -11978, -12491, -13003, -13515, -14025, -14537, -15047, -15558, -16067, -16577, -17087, -17596, -18106, -18617, -19127, -19634, -20143, -20653, -21161, -21667, -22177, -22685, -23193, -23700, -24209, -24716, -25223, -25730, -26238, -26744, -27251, -27758, -28264, -28770, -29277, -29783, -30289, -30795, -31269, -31840, -32114, -25450, -16403};