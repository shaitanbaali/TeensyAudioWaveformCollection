/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1007 256 samples */
 
const int16_t AKWF_1007_256_DATA [256] = 
{28301, 28306, 28310, 28313, 28315, 28318, 28317, 28317, 28317, 28315, 28312, 28310, 28307, 28304, 28299, 28295, 28291, 28286, 28281, 28274, 28283, 28288, 28280, 28274, 28267, 28261, 28256, 28250, 28244, 28235, 28227, 27775, 30046, 19657, -29999, -33463, -32518, -32765, -32767, -32768, -32767, -32766, -32765, -32761, -32759, -32755, -32752, -32747, -32742, -32736, -32732, -32726, -32719, -32712, -32706, -32699, -32693, -32686, -32679, -32670, -32635, -32455, -33657, -6437, 27596, 28566, 28179, 28313, 28315, 28318, 28317, 28317, 28317, 28315, 28312, 28310, 28307, 28304, 28299, 28295, 28291, 28286, 28281, 28274, 28283, 28288, 28280, 28274, 28267, 28262, 28257, 28250, 28244, 28237, 28227, 27775, 30046, 19657, -29999, -33463, -32518, -32765, -32767, -32768, -32767, -32766, -32765, -32761, -32759, -32755, -32752, -32747, -32742, -32736, -32732, -32726, -32719, -32712, -32706, -32699, -32693, -32686, -32679, -32670, -32635, -32454, -33657, -6437, 27597, 28566, 28179, 28313, 28315, 28318, 28317, 28317, 28317, 28315, 28312, 28310, 28307, 28304, 28299, 28295, 28291, 28286, 28281, 28274, 28283, 28288, 28280, 28274, 28267, 28262, 28257, 28250, 28243, 28237, 28228, 27774, 30046, 19657, -29999, -33463, -32517, -32765, -32767, -32768, -32767, -32766, -32765, -32761, -32759, -32755, -32752, -32747, -32742, -32736, -32732, -32726, -32719, -32712, -32706, -32699, -32693, -32686, -32679, -32670, -32635, -32454, -33657, -6437, 27597, 28566, 28179, 28313, 28317, 28317, 28317, 28317, 28317, 28315, 28312, 28310, 28307, 28304, 28299, 28295, 28291, 28286, 28281, 28274, 28283, 28287, 28283, 28285, 28265, 28261, 28251, 28245, 28237, 28228, 28220, 27766, 30036, 19649, -29998, -33464, -32517, -32765, -32767, -32768, -32766, -32765, -32765, -32761, -32759, -32755, -32752, -32746, -32742, -32737, -32732, -32726, -32719, -32712, -32706, -32699, -32693, -32686, -32678, -32670, -32635, -32584, -33150, -8272};