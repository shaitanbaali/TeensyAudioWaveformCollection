/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1042 256 samples */
 
const int16_t AKWF_1042_256_DATA [256] = 
{30182, 33016, 32499, 32607, 32616, 32623, 32630, 32636, 32642, 32647, 32652, 32656, 32660, 32664, 32667, 32670, 32672, 32674, 32676, 32679, 32680, 32682, 32682, 32684, 32686, 32688, 32687, 32689, 32690, 32689, 32691, 32692, 32691, 32692, 32692, 32693, 32694, 32693, 32694, 32694, 32694, 32694, 32694, 32693, 32694, 32693, 32693, 32693, 32693, 32693, 32694, 32693, 32693, 32692, 32692, 32691, 32690, 32689, 32689, 32688, 32687, 32685, 32686, 32684, 32676, 32706, 32771, 32763, 32762, 32760, 32757, 32754, 32751, 32748, 32743, 32675, 33017, 31294, 28258, 28614, 28541, 28547, 28393, 29802, 30753, 3474, -6426, -4375, -4770, -4777, -4784, -4792, -4812, -4836, -4604, -14950, -17395, -16828, -16935, -16940, -16944, -16948, -16951, -16954, -16958, -16959, -16961, -16962, -16966, -16968, -16969, -16971, -16972, -16973, -16974, -16975, -16975, -16978, -16978, -16977, -16979, -16979, -16980, -16979, -16980, -16981, -16980, -16981, -16981, -16981, -16982, -16981, -16981, -16982, -16981, -16982, -16983, -16982, -16982, -16983, -16982, -16982, -16982, -16984, -16983, -16982, -16983, -16983, -16983, -16983, -16982, -16982, -16983, -16983, -16982, -16983, -16983, -16984, -16983, -16984, -16983, -16982, -16983, -16983, -16983, -16983, -16982, -16982, -16982, -16984, -16982, -16983, -16983, -16983, -16984, -16984, -16983, -16982, -16983, -16983, -16983, -16984, -16984, -16983, -16982, -16982, -16983, -16983, -16983, -16984, -16983, -16983, -16984, -16984, -16983, -16983, -16983, -16982, -16983, -16983, -16982, -16982, -16982, -16983, -16982, -16984, -16983, -16982, -16981, -16981, -16982, -16982, -16981, -16982, -16981, -16981, -16982, -16981, -16980, -16980, -16980, -16979, -16980, -16979, -16977, -16977, -16976, -16976, -16975, -16973, -16974, -16972, -16971, -16970, -16968, -16965, -16963, -16961, -16960, -16957, -16953, -16951, -16947, -16944, -16939, -16934, -16929, -16909, -16971, -16725, -12798, -12389, -12378, -12836, -14999, -13534};