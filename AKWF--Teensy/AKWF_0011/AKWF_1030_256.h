/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1030 256 samples */
 
const int16_t AKWF_1030_256_DATA [256] = 
{386, 163, 849, 1370, 1909, 2443, 2972, 3495, 4012, 4525, 5033, 5534, 6030, 6519, 7003, 7484, 7957, 8425, 8889, 9345, 9798, 10243, 10682, 11127, 11363, 12585, 11628, -11446, -14895, -12607, -12128, -11334, -10566, -9809, -9061, -8326, -7601, -6887, -6182, -5490, -4807, -4133, -3474, -2824, -2184, -1541, -983, 69, 2366, 4737, 7091, 9443, 11801, 14183, 16447, 19027, 28354, 29544, 27820, 26732, 25536, 24336, 23141, 21945, 20745, 19357, 19263, 12280, -794, 1453, 2431, 3590, 4755, 5919, 7080, 8242, 9403, 10562, 11722, 12881, 14036, 15191, 16346, 17495, 18646, 19795, 20940, 22086, 23230, 24369, 25510, 26647, 27764, 28956, 29783, 28808, 27603, 26459, 25302, 24146, 22994, 21843, 20692, 19545, 18401, 17257, 16119, 14980, 13843, 12713, 11582, 10453, 9330, 8206, 7086, 5972, 4855, 3745, 2639, 1532, 440, -696, -1583, -1644, -1635, -1644, -1646, -1648, -1649, -1652, -1652, -1654, -1656, -1655, -1655, -1655, -1655, -1655, -1655, -1655, -1656, -1655, -1653, -1652, -1653, -1652, -1650, -1649, -1650, -1649, -1649, -1648, -1645, -1646, -1644, -1646, -1642, -1653, -2411, -3436, -4410, -5387, -6361, -7334, -8301, -9263, -10224, -11178, -12130, -13078, -14019, -14960, -15896, -16824, -17752, -18675, -19591, -20506, -21417, -22320, -23222, -24119, -25009, -25897, -26781, -27660, -28535, -29404, -30269, -31118, -32024, -32648, -31917, -31017, -30161, -29299, -28443, -27590, -26741, -25897, -25058, -24222, -23393, -22566, -21743, -20929, -20116, -19309, -18509, -17709, -16917, -16130, -15346, -14568, -13797, -13027, -12263, -11507, -10753, -10005, -9178, -8948, -3715, -1594, -2883, -3467, -4161, -4849, -5531, -6208, -6883, -7551, -8215, -8876, -9528, -10179, -10823, -11463, -12098, -12729, -13352, -13973, -14587, -15195, -15802, -16402, -16996, -17586, -18171, -18749, -19324, -19892, -20466, -20706, -22930, -16161};