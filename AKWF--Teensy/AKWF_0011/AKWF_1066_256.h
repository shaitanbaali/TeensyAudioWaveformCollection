/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1066 256 samples */
 
const int16_t AKWF_1066_256_DATA [256] = 
{22534, 34468, 32057, 32319, 32162, 32006, 31848, 31692, 31535, 31378, 31221, 31065, 30908, 30751, 30594, 30437, 30281, 30124, 29967, 29810, 29653, 29497, 29340, 29183, 29025, 28869, 28712, 28555, 28399, 28242, 28085, 27928, 27771, 27615, 27458, 27301, 27144, 26987, 26830, 26674, 26517, 26359, 26203, 26046, 25889, 25732, 25576, 25419, 25262, 25106, 24949, 24792, 24635, 24478, 24321, 24164, 24008, 23851, 23694, 23537, 23381, 23224, 23066, 22910, 22753, 22596, 22440, 22283, 22126, 21969, 21812, 21655, 21498, 21341, 21185, 21028, 20871, 20714, 20558, 20400, 20244, 20087, 19930, 19774, 19617, 19460, 19303, 19146, 18989, 18832, 18675, 18519, 18362, 18205, 18049, 17892, 17735, 17578, 17421, 17264, 17107, 16951, 16794, 16637, 16480, 16323, 16167, 16010, 15853, 15692, 15412, 16004, 3347, -755, 163, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -19, 3, 83, -11349, -13795, -13364, -13589, -13713, -13838, -13962, -14086, -14211, -14335, -14459, -14584, -14708, -14833, -14957, -15081, -15206, -15330, -15455, -15579, -15703, -15828, -15952, -16077, -16201, -16326, -16449, -16574, -16699, -16823, -16948, -17071, -17196, -17321, -17445, -17569, -17694, -17818, -17943, -18067, -18191, -18316, -18440, -18565, -18689, -18813, -18938, -19062, -19187, -19311, -19435, -19560, -19684, -19808, -19934, -20057, -20182, -20306, -20430, -20555, -20680, -20803, -20928, -21052, -21177, -21302, -21425, -21550, -21675, -21799, -21923, -22048, -22171, -22297, -22422, -22545, -22670, -22794, -22918, -23043, -23167, -23292, -23416, -23540, -23665, -23790, -23913, -24038, -24162, -24287, -24412, -24536, -24660, -24784, -24909, -25033, -25157, -25282, -25407, -25531, -25656, -25779, -25904, -26028, -26153, -26277, -26402, -26526, -26650, -26775, -26899, -27024, -27148, -27272, -27397, -27521, -27646, -27770, -27894, -28004, -27921, -29336, -11200};