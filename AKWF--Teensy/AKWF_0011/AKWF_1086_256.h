/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1086 256 samples */
 
const int16_t AKWF_1086_256_DATA [256] = 
{1563, 4991, 7313, 9524, 11367, 12870, 14126, 15175, 16059, 16813, 17458, 18016, 18504, 18933, 19312, 19651, 19953, 20227, 20473, 20695, 20896, 21078, 21241, 21388, 21517, 21633, 21733, 21820, 21892, 21952, 21997, 22031, 22052, 22059, 22055, 22040, 22012, 21972, 21921, 21859, 21785, 21700, 21604, 21499, 21382, 21256, 21118, 20970, 20814, 20647, 20471, 20286, 20091, 19889, 19677, 19456, 19227, 18991, 18746, 18494, 18235, 17968, 17694, 17413, 17125, 16832, 16533, 16227, 15916, 15599, 15276, 14949, 14618, 14281, 13941, 13596, 13247, 12895, 12538, 12179, 11817, 11452, 11084, 10715, 10343, 9969, 9594, 9217, 8839, 8460, 8080, 7699, 7319, 6938, 6557, 6176, 5796, 5416, 5038, 4659, 4283, 3908, 3533, 3163, 2793, 2425, 2060, 1698, 1337, 980, 626, 274, -72, -417, -757, -1094, -1427, -1756, -2080, -2401, -2717, -3028, -3336, -3638, -3933, -4226, -4513, -4794, -5071, -5341, -5606, -5866, -6120, -6367, -6610, -6846, -7076, -7301, -7518, -7730, -7937, -8135, -8328, -8515, -8694, -8869, -9036, -9196, -9351, -9498, -9639, -9774, -9902, -10024, -10138, -10247, -10348, -10444, -10532, -10614, -10689, -10758, -10821, -10878, -10927, -10970, -11008, -11039, -11063, -11082, -11094, -11100, -11101, -11094, -11083, -11066, -11043, -11013, -10979, -10939, -10893, -10842, -10786, -10724, -10657, -10586, -10509, -10427, -10341, -10250, -10154, -10054, -9950, -9841, -9728, -9611, -9489, -9364, -9235, -9102, -8967, -8826, -8684, -8537, -8388, -8236, -8080, -7922, -7762, -7598, -7432, -7264, -7093, -6921, -6747, -6570, -6391, -6211, -6030, -5847, -6027, -3673, -25294, -25299, -17527, -22107, -24126, -25495, -26744, -27598, -28135, -28435, -28540, -28489, -28315, -28039, -27683, -27264, -26791, -26276, -25727, -25148, -24545, -23924, -23285, -22632, -21968, -21293, -20611, -19922, -19224, -18061, -20014, -2422, 6700, -3225};