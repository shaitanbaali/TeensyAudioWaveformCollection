/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1013 256 samples */
 
const int16_t AKWF_1013_256_DATA [256] = 
{32755, 32759, 32763, 32765, 32767, 32768, 32767, 32765, 32763, 32761, 32758, 32754, 32751, 32213, 35105, 11817, -2073, 696, 183, 180, 176, 174, 171, 168, 165, 164, 162, 161, 158, 158, 155, 156, 155, 152, 152, 153, 150, 149, 150, 149, 150, 148, 146, 147, 147, 147, 147, 147, 147, 146, 147, 145, 143, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 143, 144, 142, 140, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 731, -2427, 15715, 35221, 32033, 32627, 32625, 32621, 32618, 32613, 32608, 32603, 32598, 32572, 31877, 35875, -7041, -36584, -31810, -32686, -32686, -32689, -32687, -32686, -32686, -32682, -32680, -32677, -32202, -34789, -22250, 2285, -383, 107, 110, 114, 117, 119, 121, 124, 125, 127, 128, 130, 132, 133, 135, 134, 135, 137, 138, 138, 137, 138, 141, 140, 141, 141, 141, 141, 141, 141, 140, 141, 143, 144, 143, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 144, 143, 144, 141, 140, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 141, 132, -132, 1469, -25138, -33828, -31883, -32226, -32224, -32220, -32217, -32212, -32208, -32202, -32197, -32191, -32186, -32180, -32169, -32336};