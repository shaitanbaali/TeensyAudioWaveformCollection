/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1038 256 samples */
 
const int16_t AKWF_1038_256_DATA [256] = 
{656, 2743, 4814, 6901, 8982, 11048, 13086, 15076, 17013, 18885, 20673, 22374, 23976, 25464, 26836, 28083, 29191, 30162, 30985, 31655, 32172, 32527, 32732, 32714, 32155, 31134, 29773, 28122, 26223, 24106, 21813, 19367, 16798, 14143, 11425, 8670, 5917, 3183, 494, -2112, -4621, -7011, -9249, -11323, -13214, -14897, -16366, -17603, -18594, -19337, -19821, -20042, -19992, -19752, -19397, -18939, -18396, -17778, -17090, -16343, -15544, -14699, -13816, -12901, -11959, -11001, -10030, -9051, -8076, -7106, -6148, -5211, -4296, -3411, -2562, -1753, -988, -274, 387, 992, 1534, 2014, 2426, 2768, 3041, 3240, 3365, 3419, 3301, 2971, 2495, 1897, 1196, 404, -461, -1390, -2372, -3391, -4438, -5502, -6570, -7631, -8677, -9692, -10672, -11605, -12480, -13292, -14032, -14692, -15267, -15751, -16139, -16429, -16615, -16709, -16567, -16056, -15288, -14305, -13137, -11806, -10327, -8722, -7007, -5189, -3294, -1334, 683, 2735, 4811, 6901, 8982, 11048, 13086, 15076, 17013, 18885, 20673, 22374, 23976, 25464, 26836, 28083, 29191, 30162, 30985, 31655, 32172, 32527, 32732, 32714, 32155, 31134, 29772, 28122, 26223, 24106, 21813, 19367, 16798, 14144, 11427, 8671, 5918, 3185, 498, -2107, -4616, -7005, -9243, -11318, -13209, -14892, -16362, -17600, -18593, -19335, -19820, -20042, -19992, -19752, -19397, -18939, -18396, -17778, -17090, -16343, -15544, -14699, -13816, -12901, -11959, -11001, -10030, -9051, -8076, -7106, -6148, -5211, -4296, -3411, -2563, -1753, -988, -274, 387, 992, 1534, 2014, 2426, 2768, 3041, 3240, 3365, 3419, 3301, 2971, 2495, 1897, 1196, 404, -461, -1390, -2372, -3391, -4438, -5502, -6570, -7631, -8677, -9692, -10672, -11605, -12480, -13292, -14032, -14692, -15267, -15751, -16139, -16429, -16615, -16709, -16567, -16056, -15288, -14305, -13137, -11806, -10327, -8722, -7007, -5192, -3303, -1306};