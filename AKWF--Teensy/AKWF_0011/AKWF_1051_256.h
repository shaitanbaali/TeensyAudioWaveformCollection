/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1051 256 samples */
 
const int16_t AKWF_1051_256_DATA [256] = 
{15449, 15356, 15263, 15168, 15073, 14977, 14880, 14781, 14682, 14583, 14483, 14382, 14280, 14179, 14076, 13973, 13870, 13765, 13660, 13556, 13450, 13344, 13238, 13131, 13025, 12917, 12809, 12701, 12592, 12483, 12374, 12265, 12155, 12045, 11934, 11823, 11711, 11600, 11488, 11376, 11264, 11151, 11037, 10924, 10809, 10696, 10582, 10466, 10352, 10236, 10120, 10004, 9887, 9771, 9653, 9536, 9417, 9300, 9182, 9063, 8943, 8824, 8704, 8584, 8463, 8342, 8221, 8100, 7977, 7855, 7732, 7610, 7487, 7363, 7239, 7115, 6989, 6865, 6740, 6613, 6488, 6361, 6233, 6107, 5979, 5851, 5722, 5593, 5464, 5336, 5206, 5075, 4944, 4813, 4682, 4551, 4419, 4286, 4153, 4021, 3887, 3752, 3617, 3483, 3348, 3212, 3077, 2940, 2804, 2668, 2529, 2391, 2253, 2115, 1976, 1837, 1697, 1557, 1416, 1275, 1134, 992, 850, 708, 565, 421, 278, 134, -11, -154, -299, -445, -591, -737, -884, -1030, -1177, -1322, -1466, -1609, -1751, -1893, -2035, -2174, -2314, -2452, -2589, -2726, -2862, -2998, -3132, -3265, -3398, -3531, -3662, -3792, -3921, -4051, -4179, -4305, -4432, -4557, -4682, -4806, -4930, -5052, -5174, -5294, -5415, -5535, -5652, -5770, -5887, -6002, -6117, -6232, -6346, -6459, -6571, -6682, -6794, -6904, -7013, -7121, -7230, -7335, -7441, -7547, -7652, -7756, -7859, -7961, -8063, -8163, -8263, -8363, -8462, -8560, -8657, -8754, -8849, -8945, -9039, -9133, -9226, -9397, -9022, -11200, -16680, -14803, -13452, -12027, -10597, -9167, -7741, -6311, -4881, -3455, -2024, -596, 829, 2259, 3686, 5112, 6541, 7967, 9393, 10821, 12245, 13002, 18092, 1803, -32497, -28938, -29756, -29901, -30046, -30190, -30333, -30477, -30619, -30762, -30905, -31046, -31186, -31328, -31469, -31609, -31751, -31890, -32031, -32170, -32310, -32449, -32589, -32730};