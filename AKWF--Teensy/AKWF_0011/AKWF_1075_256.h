/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1075 256 samples */
 
const int16_t AKWF_1075_256_DATA [256] = 
{32167, 31293, 30436, 29576, 28716, 27855, 26993, 26132, 25270, 24406, 23543, 22680, 21815, 20951, 20086, 19220, 18355, 17488, 16620, 15755, 14887, 14018, 13150, 12280, 11411, 10543, 9671, 8801, 7931, 7059, 6187, 5317, 4463, 3507, 3081, 4021, 4895, 5770, 6651, 7530, 8409, 9291, 10170, 11052, 11934, 12815, 13698, 14581, 15463, 16346, 17231, 18114, 18999, 19884, 20767, 21653, 22539, 23422, 24309, 25195, 26079, 26967, 27852, 28737, 29624, 30508, 30961, 34271, 6969, -3764, -387, 37, 861, 1891, 2480, -21031, -24072, -21816, -20793, -19578, -18364, -17148, -15932, -14717, -13499, -12283, -11068, -9850, -8634, -7683, -5007, -17915, -23263, -20264, -18972, -17418, -15860, -14305, -12749, -11191, -9636, -8126, -6295, -8169, -7855, -5786, -4958, -5044, -5029, -5031, -5034, -5037, -5039, -5041, -5045, -5047, -5050, -5053, -5057, -5058, -5060, -5063, -5066, -5069, -5072, -5075, -5077, -5080, -5082, -5085, -5088, -5091, -5093, -5096, -5099, -5102, -5103, -5107, -5109, -5112, -5115, -5118, -5121, -5123, -5125, -5128, -5131, -5134, -5137, -5139, -5141, -5144, -5147, -5150, -5153, -5155, -5157, -5160, -5163, -5166, -5169, -5170, -5173, -5176, -5178, -5180, -5183, -5185, -5188, -5190, -5192, -5194, -5196, -5198, -5201, -5203, -5205, -5206, -5208, -5210, -5211, -5212, -5215, -5215, -5215, -5217, -5218, -5218, -5218, -5219, -5218, -5217, -5207, -5244, -4754, -3793, -3116, -3456, -3905, -3888, -6372, -8799, -8306, -8293, -8203, -8114, -8023, -7934, -7843, -7753, -7663, -7573, -7483, -7393, -7302, -7213, -7123, -7032, -6943, -6852, -6763, -6672, -6582, -6492, -6402, -6313, -6223, -6134, -6044, -5954, -5866, -5776, -5688, -5599, -5510, -5422, -5335, -5247, -5159, -5203, -4061, -8744, -10331, -1684, -4380, -4753, -5185, -5612, -6347, 687, 1877, 528, -250, -1121, -1993, -2883};