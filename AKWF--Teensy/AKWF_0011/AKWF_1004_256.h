/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1004 256 samples */
 
const int16_t AKWF_1004_256_DATA [256] = 
{224, 232, 239, 245, 250, 255, 260, 264, 267, 271, 606, -1260, 7020, 33962, 32529, 32755, 32768, 32767, 32765, 32761, 32758, 32755, 32750, 32745, 32741, 32735, 32729, 32724, 32717, 32710, 32703, 32696, 32688, 32681, 32674, 32667, 32660, 32653, 32643, 32636, 32629, 32619, 32612, 32605, 32595, 32588, 32579, 32572, 32563, 32555, 32546, 32538, 32529, 32521, 32513, 32504, 32495, 32487, 32478, 32469, 32460, 32452, 32443, 32435, 32426, 32417, 32409, 31821, 34918, 17706, -2691, 477, -124, -130, -135, -139, -144, -149, -152, -156, -159, -161, -316, 514, -2889, -22457, -22677, -22558, -22601, -22598, -22598, -22596, -22593, -22591, -22588, -22585, -22582, -22579, -22574, -22570, -22565, -22562, -22557, -22552, -22548, -22542, -22537, -22533, -22527, -22522, -22517, -22511, -22505, -22500, -22494, -22489, -22482, -22478, -22471, -22467, -22460, -22454, -22449, -22036, -24211, -9829, 1727, -389, 11, 16, 19, 22, 25, 28, 30, 33, 34, 36, 38, 40, 40, 410, -1586, 14463, 24035, 22124, 22472, 22471, 22470, 22467, 22465, 22463, 22460, 22457, 22453, 22449, 22446, 22442, 22437, 22433, 22428, 22423, 22419, 22413, 22408, 22404, 22398, 22392, 22387, 22382, 22376, 22370, 22365, 22360, 22354, 22347, 22343, 22336, 22332, 22324, 22319, 22151, 23034, 19356, -131, -179, -105, -146, -149, -153, -156, -159, -161, -163, -166, -168, -171, -537, 1528, -24370, -34456, -32263, -32654, -32651, -32649, -32646, -32641, -32638, -32633, -32628, -32623, -32618, -32611, -32605, -32600, -32593, -32586, -32580, -32573, -32566, -32558, -32549, -32541, -32535, -32527, -32517, -32511, -32503, -32493, -32487, -32477, -32469, -32462, -32452, -32445, -32435, -32428, -32419, -32411, -32403, -32395, -32385, -32378, -32369, -32360, -32351, -32344, -32334, -32326, -32317, -32308, -32300, -32291, -32283, -32274, -32265};