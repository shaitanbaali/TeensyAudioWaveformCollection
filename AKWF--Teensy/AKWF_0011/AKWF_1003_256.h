/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1003 256 samples */
 
const int16_t AKWF_1003_256_DATA [256] = 
{2462, 2462, 2462, 2461, 2462, 2465, 2465, 2465, 2488, 2422, 2543, 13404, 15065, 15819, 8773, 1468, 2687, 2458, 2456, 2455, 2456, 2453, 2451, 2452, 2451, 2448, 2449, 2449, 2447, 2445, 2446, 2446, 2444, 2442, 2443, 2443, 2971, 113, 20718, 35001, 32257, 32762, 32759, 32756, 32751, 32746, 32742, 32736, 32730, 32723, 32719, 32712, 32705, 32698, 32344, 34271, 25374, 2537, 4352, 4026, 4019, 4014, 4010, 4004, 4000, 3997, 3993, 3990, 3723, 4915, -8174, -10408, -10034, 2075, 2394, 2238, 2277, 2276, 2273, 2274, 2270, 2269, 2270, 2268, 2266, 2267, 2266, 2264, 2169, 2691, 511, -10186, -9955, -10828, -6650, 2988, 2103, 2264, 2264, 2264, 2264, 2261, 2260, 2383, 1695, 4711, 15165, 14569, 15320, 5145, 1613, 2394, 2255, 2253, 2251, 2252, 2250, 2248, 2249, 2248, 2246, 2246, 2246, 2245, 2242, 2243, 2243, 2242, 2240, 2240, 2240, 1798, 4258, -9403, -22695, -11875, -14966, -9320, 2741, 2143, 2234, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2243, 2072, 3002, -6514, -10871, -9947, -10272, 361, 2697, 2143, 2243, 2243, 2243, 2243, 2243, 2441, 1373, 9649, 15455, 14480, 15475, 9883, 1374, 2431, 2233, 2233, 2232, 2229, 2230, 2230, 2227, 2226, 2227, 2225, 2223, 2224, 2224, 2222, 2220, 2221, 1622, 4831, -12961, -34046, -30762, -31373, -31372, -31369, -31366, -31363, -31357, -31353, -31349, -31343, -31338, -31333, -31327, -31319, -31314, -31308, -31301, -31294, -31286, -31279, -31272, -31265, -31258, -31250, -31243, -31235, -31225, -31171, -31222, -31405, -2359, 3566, 2155, 2418, 2423, 2428, 2432, 2435, 2438, 2441, 2443, 2446, 2448, 2449, 2451, 2451, 2454, 2456, 2456, 2455, 2458, 2247, 3387, -2634, -10898, -9716, -9935};