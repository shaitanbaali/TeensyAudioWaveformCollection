/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0432 256 samples */
 
const int16_t AKWF_0432_256_DATA [256] = 
{13609, 16411, 3626, 2767, 2645, 2074, 1932, 1111, 206, 859, 2117, 3180, 4396, 5650, 6603, 6941, 6635, 6368, 6616, 7122, 7740, 8453, 9227, 10040, 10881, 11741, 12621, 13501, 14383, 15268, 16144, 17015, 17871, 18716, 19557, 20378, 21175, 21957, 22719, 23462, 24183, 24879, 25551, 26193, 26809, 27402, 27963, 28490, 28986, 29458, 29899, 30310, 30689, 31039, 31351, 31633, 31891, 32113, 32300, 32456, 32586, 32680, 32740, 32767, 32763, 32732, 32665, 32561, 32427, 32268, 32069, 31837, 31580, 31290, 30970, 30615, 30230, 29814, 29365, 28888, 28389, 27852, 27280, 26687, 26066, 25416, 24742, 24037, 23312, 22566, 21797, 21020, 20214, 19385, 18549, 17699, 16838, 15968, 15086, 14207, 13323, 12442, 11565, 10710, 9872, 9066, 8306, 7606, 7010, 6564, 6385, 6633, 6916, 6491, 5433, 4157, 2939, 1857, 798, 229, 1136, 2100, 2236, 2466, 3387, 5730, 13513, 13380, -13568, -16483, -3571, -2768, -2646, -2074, -1933, -1112, -207, -860, -2118, -3181, -4397, -5650, -6604, -6942, -6636, -6369, -6617, -7122, -7740, -8453, -9227, -10041, -10882, -11741, -12622, -13501, -14384, -15268, -16145, -17015, -17872, -18715, -19557, -20379, -21175, -21957, -22720, -23463, -24183, -24880, -25551, -26194, -26809, -27402, -27963, -28489, -28986, -29458, -29899, -30310, -30689, -31039, -31351, -31633, -31891, -32113, -32300, -32456, -32586, -32680, -32740, -32767, -32763, -32732, -32665, -32561, -32427, -32268, -32069, -31837, -31580, -31290, -30970, -30615, -30230, -29814, -29365, -28888, -28389, -27852, -27281, -26688, -26066, -25417, -24741, -24037, -23313, -22566, -21798, -21020, -20215, -19386, -18549, -17699, -16839, -15969, -15087, -14207, -13324, -12442, -11565, -10710, -9872, -9067, -8307, -7607, -7011, -6565, -6386, -6634, -6917, -6492, -5434, -4158, -2940, -1858, -799, -230, -1137, -2101, -2237, -2467, -3388, -5788, -13530, -12973};