/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0492 256 samples */
 
const int16_t AKWF_0492_256_DATA [256] = 
{-2530, -8186, -12751, -16505, -19724, -22538, -24996, -27099, -28862, -30285, -31371, -32131, -32588, -32766, -32699, -32418, -31947, -31309, -30521, -29605, -28566, -27419, -26183, -24859, -23466, -22018, -20521, -18995, -17453, -15895, -14348, -12818, -11315, -9849, -8425, -7054, -5745, -4498, -3320, -2213, -1202, 348, 2152, 3665, 4986, 6147, 7176, 8084, 8872, 9542, 10089, 10517, 10830, 11035, 11137, 11149, 11082, 10940, 10729, 10455, 10131, 9762, 9352, 8909, 8436, 7945, 7436, 6911, 6383, 5854, 5322, 4796, 4282, 3786, 3259, 3277, 3762, 4063, 4259, 4398, 4505, 4590, 4654, 4693, 4701, 4680, 4622, 4532, 4411, 4268, 4106, 3924, 3732, 3529, 3318, 3100, 2877, 2652, 2426, 2199, 1977, 1759, 1549, 1343, 1147, 958, 776, 615, 411, 648, 1447, 2090, 2600, 3031, 3416, 3762, 4072, 4343, 4563, 4736, 4857, 4930, 4957, 4944, 4899, 4818, 4710, 4576, 4418, 4244, 4054, 3849, 3633, 3409, 3180, 2946, 2711, 2471, 2236, 2004, 1777, 1559, 1346, 1141, 951, 754, 618, 1189, 1932, 2486, 2935, 3326, 3677, 3989, 4266, 4499, 4687, 4822, 4909, 4951, 4949, 4914, 4842, 4739, 4613, 4462, 4293, 4106, 3904, 3693, 3470, 3242, 3010, 2775, 2537, 2298, 2068, 1840, 1619, 1405, 1198, 999, 812, 633, 463, 312, 154, 73, 709, 1487, 2077, 2563, 2992, 3381, 3730, 4044, 4312, 4529, 4696, 4812, 4879, 4900, 4887, 4840, 4758, 4651, 4516, 4358, 4185, 3996, 3793, 3578, 3357, 3130, 2899, 2666, 2429, 2195, 1967, 1748, 1528, 1326, 1786, 2498, 3017, 3426, 3774, 4082, 4351, 4585, 4780, 4928, 5029, 5080, 5088, 5059, 4991, 4891, 4765, 4613, 4441, 4253, 4047, 3832, 3605, 3370, 3131, 2889, 2647, 2402, 2162, 1928, 1700, 1478, 1264, 1057};