/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0459 256 samples */
 
const int16_t AKWF_0459_256_DATA [256] = 
{31, 138, 267, 427, 633, 903, 1287, 2297, 3338, 6294, 10917, 9685, 6276, 4326, 4411, 5390, 5905, 5444, 4407, 3468, 2989, 2893, 2893, 2789, 2578, 2366, 2252, 2248, 2302, 2357, 2386, 2401, 2423, 2461, 2513, 2563, 2603, 2631, 2650, 2669, 2690, 2704, 2712, 2714, 2712, 2708, 2699, 2673, 2235, 357, -3283, -14013, -29009, -25903, -14917, -7738, -6748, -9009, -10514, -9520, -6902, -4422, -3036, -2530, -2195, -1585, -754, -22, 368, 422, 308, 199, 166, 175, 170, 121, 39, -41, -98, -129, -144, -150, -146, -122, -72, 1, 100, 221, 370, 557, 807, 1126, 1867, 3054, 4763, 9853, 10645, 7350, 4731, 4207, 5059, 5839, 5694, 4773, 3738, 3095, 2900, 2899, 2839, 2655, 2429, 2277, 2240, 2282, 2341, 2380, 2396, 2414, 2446, 2495, 2548, 2591, 2623, 2644, 2663, 2683, 2700, 2710, 2714, 2713, 2710, 2702, 2693, 2486, 1200, -1838, -8974, -25398, -28777, -18483, -9416, -6510, -8168, -10266, -10114, -7840, -5147, -3373, -2644, -2326, -1826, -1037, -236, 280, 433, 353, 228, 169, 171, 176, 142, 68, -16, -82, -121, -140, -149, -149, -133, -91, -26, 65, 178, 317, 489, 716, 1006, 1524, 2724, 3810, 8156, 11145, 8526, 5386, 4162, 4715, 5661, 5854, 5128, 4056, 3253, 2928, 2896, 2874, 2727, 2501, 2315, 2241, 2263, 2322, 2370, 2392, 2407, 2433, 2477, 2531, 2578, 2614, 2638, 2656, 2676, 2695, 2708, 2713, 2714, 2711, 2705, 2698, 2617, 1820, -671, -5462, -19939, -30068, -22271, -11838, -6797, -7358, -9743, -10459, -8737, -5987, -3830, -2802, -2432, -2030, -1318, -483, 150, 417, 393, 265, 180, 167, 177, 159, 96, 10, -63, -111, -136, -147, -150, -141, -108, -49};