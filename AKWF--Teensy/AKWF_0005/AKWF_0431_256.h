/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0431 256 samples */
 
const int16_t AKWF_0431_256_DATA [256] = 
{2210, 2198, 987, 1044, 1535, 2201, 2699, 3085, 3419, 3708, 3994, 4310, 4677, 5118, 5677, 6404, 7302, 8332, 9427, 10480, 11420, 12209, 12827, 13275, 13563, 13705, 13711, 13596, 13396, 13163, 12936, 12733, 12570, 12454, 12384, 12359, 12378, 12437, 12532, 12659, 12814, 12994, 13198, 13420, 13655, 13907, 14176, 14459, 14751, 15054, 15369, 15697, 16033, 16376, 16722, 17084, 17458, 17827, 18202, 18587, 18972, 19372, 19784, 20181, 20591, 21017, 21437, 21860, 22289, 22721, 23175, 23635, 24100, 24572, 25049, 25552, 26100, 26661, 27238, 27893, 28656, 29578, 31011, 32345, 32466, 32445, 32596, 32612, 32949, 30697, 17487, 10804, 13791, 13305, 12738, 13294, 13625, 13576, 13385, 13282, 13405, 13618, 13722, 13713, 13630, 13408, 12978, 12359, 11608, 10712, 9629, 8429, 7265, 6271, 5504, 4923, 4461, 4082, 3751, 3426, 3057, 2606, 2042, 1359, 993, 1324, 2158, 1411, -2227, -2202, -980, -1045, -1536, -2202, -2700, -3086, -3420, -3709, -3995, -4311, -4678, -5119, -5677, -6405, -7303, -8333, -9428, -10481, -11420, -12210, -12828, -13275, -13564, -13706, -13711, -13597, -13396, -13164, -12936, -12734, -12571, -12454, -12384, -12360, -12378, -12437, -12533, -12659, -12814, -12994, -13199, -13421, -13655, -13908, -14177, -14460, -14752, -15054, -15369, -15697, -16034, -16376, -16723, -17084, -17459, -17828, -18202, -18587, -18972, -19372, -19785, -20181, -20591, -21017, -21437, -21859, -22289, -22721, -23175, -23635, -24100, -24572, -25049, -25553, -26100, -26662, -27238, -27893, -28655, -29577, -31009, -32345, -32467, -32445, -32596, -32612, -32949, -30697, -17487, -10805, -13791, -13306, -12739, -13294, -13626, -13577, -13385, -13283, -13406, -13619, -13723, -13714, -13631, -13408, -12979, -12360, -11608, -10713, -9629, -8430, -7266, -6272, -5505, -4924, -4462, -4082, -3752, -3427, -3057, -2607, -2043, -1360, -994, -1333, -2151, -1402};