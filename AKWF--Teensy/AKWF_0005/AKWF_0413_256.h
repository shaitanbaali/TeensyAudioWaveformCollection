/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0413 256 samples */
 
const int16_t AKWF_0413_256_DATA [256] = 
{714, 2476, 3970, 5476, 7147, 9473, 12142, 13706, 14449, 14831, 14997, 15025, 14958, 14824, 14647, 14444, 14225, 13995, 13760, 13526, 13295, 13070, 12855, 12650, 12461, 12288, 12136, 12005, 11898, 11821, 11775, 11764, 11794, 11870, 11997, 12184, 12440, 12775, 13201, 13716, 14312, 14980, 15701, 16462, 17246, 18037, 18829, 19614, 20381, 21133, 21865, 22574, 23266, 23936, 24585, 25214, 25825, 26415, 26989, 27546, 28088, 28464, 29644, 27673, -9718, -12730, -11757, -12045, -12173, -12327, -12503, -12695, -12900, -13119, -13345, -13577, -13813, -14045, -14273, -14490, -14688, -14857, -14979, -15029, -14976, -14771, -14328, -13467, -11629, -8901, -6756, -5142, -3650, -2151, -192, 1919, 3438, 4924, 6508, 8538, 11265, 13284, 14238, 14725, 14957, 15028, 14991, 14877, 14714, 14519, 14305, 14077, 13844, 13610, 13376, 13150, 12930, 12722, 12527, 12348, 12188, 12049, 11933, 11845, 11787, 11667, 12156, 10471, -10500, -12179, -11668, -11774, -11817, -11892, -11997, -12126, -12277, -12449, -12637, -12840, -13056, -13279, -13510, -13745, -13979, -14208, -14430, -14634, -14813, -14951, -15023, -15003, -14847, -14484, -13771, -12288, -9669, -7286, -5583, -4069, -2590, -819, 1367, 3031, 4495, 6042, 7872, 10487, 12837, 14030, 14617, 14910, 15021, 15010, 14916, 14764, 14577, 14367, 14143, 13912, 13676, 13443, 13214, 12992, 12780, 12581, 12398, 12233, 12090, 11872, 12009, 11900, -22438, -30857, -28456, -28302, -27777, -27229, -26662, -26078, -25476, -24855, -24216, -23555, -22872, -22172, -21448, -20704, -19944, -19165, -18376, -17584, -16794, -16023, -15284, -14590, -13963, -13412, -12947, -12573, -12286, -12071, -11919, -11822, -11773, -11766, -11798, -11862, -11956, -12076, -12221, -12386, -12568, -12766, -12977, -13198, -13428, -13661, -13895, -14128, -14352, -14564, -14753, -14907, -15006, -15023, -14923, -14645, -14084, -12959, -10681, -8024, -6156, -4605, -3121, -1544};