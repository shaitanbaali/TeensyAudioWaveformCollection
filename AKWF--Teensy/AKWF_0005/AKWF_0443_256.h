/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0443 256 samples */
 
const int16_t AKWF_0443_256_DATA [256] = 
{1870, 7466, 1417, -4296, -3993, -4099, -2021, -893, -307, -45, 195, 510, 972, 1450, 1890, 2121, 2212, 2565, 345, -4272, -4436, -4097, -3381, -2367, -1176, 59, 3163, 7901, 9283, 12648, 14644, 16204, 17668, 18680, 19363, 19750, 19793, 19238, 18498, 16477, 10524, 7443, 6878, 6236, 6147, 5705, 5375, 5301, 5383, 5627, 6175, 6952, 7309, 6418, 5700, 5333, 5186, 5192, 5388, 5949, 6647, 2677, -627, -17, 79, 118, 291, 504, 780, 1124, 1543, 2405, 4080, 5354, 6271, 7215, 8208, 9203, 10221, 11253, 12242, 13672, 12618, 9109, 10073, 11212, 11987, 13161, 14090, 14980, 15832, 16723, 17443, 18139, 18619, 18598, 18062, 17111, 15886, 14533, 12850, 10745, 8534, 5146, -2210, -5884, -7294, -8440, -8790, -9150, -10143, -9334, -7814, -6769, -5060, -2820, -842, 124, 1333, 3103, 5074, 7200, 9517, 12162, 14853, 12778, 11270, 12955, 12465, 13267, 13844, 14342, 14848, 15195, 15463, 15733, 16260, 16753, 16993, 17376, 17736, 18186, 19069, 19998, 21064, 22727, 22033, 18769, 20193, 19555, 18016, 19529, 18347, 18245, 18055, 17334, 16580, 15864, 14717, 13271, 11399, 9233, 6974, 4735, 2356, -368, -2988, -6629, -14487, -18244, -19635, -20883, -21277, -21782, -21893, -21498, -20812, -19814, -18300, -16426, -14930, -14506, -13971, -12955, -11798, -10499, -9070, -7420, -5744, -8809, -11497, -10318, -9923, -9529, -9393, -9452, -9631, -10030, -10429, -10665, -10320, -10448, -11156, -11929, -12773, -13670, -14609, -15556, -16515, -17032, -19620, -24640, -25244, -25254, -25723, -23332, -12701, -6099, -3607, -2593, -1998, -1754, -1918, -2436, -3419, -4750, -6240, -7888, -9707, -12037, -14319, -17600, -25348, -29235, -30519, -31818, -32294, -32621, -31891, -32522, -31851, -30578, -28829, -26714, -24825, -23933, -22727, -20964, -18793, -16273, -13392, -10076, -6472, -7366, -7658, -3313};