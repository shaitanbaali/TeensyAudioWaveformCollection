/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0469 256 samples */
 
const int16_t AKWF_0469_256_DATA [256] = 
{862, 3154, 5196, 7096, 8909, 10704, 12542, 14460, 16482, 18596, 20759, 22928, 25030, 26990, 28748, 30241, 31413, 32235, 32685, 32759, 32466, 31831, 30893, 29686, 28267, 26689, 24999, 23256, 21510, 19797, 18167, 16648, 15261, 14031, 12966, 12068, 11340, 10773, 10356, 10077, 9916, 9859, 9883, 9972, 10107, 10270, 10447, 10625, 10792, 10939, 11060, 11150, 11207, 11229, 11220, 11178, 11109, 11017, 10905, 10778, 10641, 10499, 10356, 10216, 10081, 9956, 9841, 9740, 9651, 9577, 9517, 9470, 9436, 9413, 9402, 9400, 9403, 9414, 9431, 9451, 9472, 9495, 9519, 9542, 9565, 9586, 9606, 9624, 9642, 9657, 9673, 9687, 9702, 9716, 9730, 9745, 9762, 9780, 9798, 9820, 9843, 9867, 9894, 9923, 9955, 9988, 10024, 10061, 10101, 10143, 10185, 10230, 10276, 10325, 10374, 10424, 10476, 10529, 10582, 10638, 10695, 10752, 10804, 10868, 10637, 9059, 6875, 5665, 4768, 4149, 3410, 2138, 936, -38, -811, -1411, -1924, -2410, -2923, -3499, -4153, -4882, -5677, -6517, -7371, -8221, -9035, -9787, -10462, -11040, -11513, -11873, -12123, -12263, -12301, -12248, -12116, -11917, -11668, -11383, -11077, -10762, -10450, -10151, -9874, -9627, -9413, -9235, -9094, -8991, -8924, -8891, -8887, -8910, -8954, -9018, -9093, -9177, -9268, -9359, -9451, -9538, -9620, -9696, -9765, -9826, -9880, -9928, -9970, -10006, -10039, -10070, -10101, -10132, -10164, -10201, -10242, -10289, -10343, -10403, -10472, -10549, -10635, -10731, -10838, -10953, -11079, -11216, -11364, -11525, -11696, -11879, -12074, -12283, -12506, -12745, -12998, -13270, -13561, -13871, -14204, -14563, -14946, -15358, -15803, -16280, -16793, -17347, -17940, -18581, -19269, -20006, -20795, -21639, -22535, -23484, -24481, -25512, -26563, -27600, -28570, -29396, -29967, -30158, -29856, -28990, -27542, -25521, -22996, -20090, -16918, -13627, -10360, -7216, -4282, -1540};