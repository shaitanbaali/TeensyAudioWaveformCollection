/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0465 256 samples */
 
const int16_t AKWF_0465_256_DATA [256] = 
{2296, 10503, 18470, 25530, 30401, 32582, 32584, 31175, 28832, 25759, 22032, 17721, 13104, 8644, 4700, 1413, -1266, -3427, -5084, -6209, -6803, -6927, -6718, -6342, -5921, -5512, -5151, -4754, -4002, -3018, -2429, -2542, -3094, -3731, -4284, -4687, -4925, -5048, -5057, -4847, -4323, -3512, -2532, -1485, -439, 571, 1542, 2451, 3254, 3906, 4379, 4677, 4824, 4842, 4745, 4538, 4251, 4185, 4557, 4917, 4721, 3978, 3020, 2059, 1161, 357, -392, -1145, -1842, -2362, -2652, -2769, -2797, -2795, -2656, -2023, -1030, -320, -225, -542, -982, -1413, -1781, -2086, -2406, -2653, -2373, -1534, -763, -496, -606, -822, -1019, -1144, -1176, -911, -229, 455, 708, 556, 274, 289, 782, 1268, 1187, 529, -193, -343, 18, 225, -137, -693, -817, -622, -638, -915, -974, -836, -819, -706, -456, -423, -509, -455, -207, -78, -467, -1359, -2127, -2390, -2377, -2208, -2065, -2315, -3010, -3738, -3892, -3342, -2710, -2558, -2826, -2883, -2267, -1363, -820, -832, -1182, -1591, -1665, -1025, -69, 409, 212, -245, -608, -786, -540, 197, 839, 862, 437, -3, -308, -539, -751, -997, -1296, -1562, -1609, -1091, -49, 853, 1125, 891, 503, 132, -183, -471, -803, -1205, -1572, -1761, -1748, -1610, -1431, -1260, -898, -20, 1088, 1779, 1841, 1538, 1125, 715, 351, 11, -370, -782, -1096, -1216, -1164, -1016, -835, -647, -448, -221, 38, 299, 524, 700, 826, 920, 992, 1035, 1076, 1431, 2215, 2903, 3002, 2593, 2000, 1403, 862, 395, -43, -494, -890, -1106, -1112, -976, -779, -569, -359, -137, 103, 356, 585, 760, 883, 967, 1030, 1074, 1099, 1098, 1065, 1052, 420, -2930, -10828, -21589, -29750, -31564, -27881, -21324, -13716, -5561};