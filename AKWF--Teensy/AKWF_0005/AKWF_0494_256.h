/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0494 256 samples */
 
const int16_t AKWF_0494_256_DATA [256] = 
{232, -147, -1289, 709, 2210, 1017, 2013, 3576, 4017, 5259, 3832, 3491, 6413, 6373, 4831, 6250, 7103, 7893, 8326, 7505, 8454, 6942, 4378, 4270, 4264, 3509, 1304, -723, -1130, -276, 750, 2284, 2415, 1746, 2116, 4294, 4941, 7078, 6838, 6035, 5305, 4395, 3900, 6987, 8117, 6181, 6891, 10673, 11277, 12572, 14616, 14832, 17346, 18000, 18892, 19930, 19777, 18350, 17843, 16621, 16866, 16759, 13259, 12853, 12545, 9291, 8148, 7168, 6446, 4385, 4276, 2931, 2454, 2720, 1905, -22, -620, -1259, -1000, 706, 3361, 4125, 4050, 5508, 5716, 6973, 7460, 7416, 8493, 7521, 7108, 9604, 12509, 14600, 17999, 18886, 20856, 24609, 28025, 31041, 32819, 31556, 28650, 26436, 26665, 23356, 19705, 15778, 8272, 2390, -1938, -5006, -9499, -12588, -13950, -16355, -19231, -21927, -25652, -24441, -22825, -20200, -21005, -20698, -19750, -18278, -16434, -16230, -13030, -10384, -9851, -7133, -3610, -226, 1967, 5712, 10219, 11858, 13421, 17353, 20937, 21728, 20232, 18326, 18050, 16751, 15081, 15093, 14225, 12146, 9543, 7237, 5422, 2269, -1297, -6256, -10759, -15133, -14994, -16385, -19344, -19996, -20172, -23057, -24260, -23228, -23437, -22761, -23652, -21372, -17244, -13503, -11594, -10031, -5874, -1857, -955, -1177, -397, 2527, 5470, 4755, 3841, 6161, 6928, 5341, 4745, 6939, 6945, 5282, 6441, 8147, 9326, 10168, 9323, 7398, 4401, 3911, 3888, 2143, -2529, -7132, -8385, -9437, -10573, -15130, -17611, -18715, -19184, -21837, -23330, -24957, -26613, -27599, -26214, -24372, -21356, -21600, -22913, -21419, -21634, -22148, -20613, -19845, -19201, -18850, -18428, -19417, -18339, -16004, -13070, -10616, -10373, -7748, -4295, -3720, -4325, -3708, -4270, -4192, -4963, -4392, -1861, -1765, -2611, -2229, -3070, -3360, -2482, -1181, -1464, -629, -592, -1527, -1432, -386};