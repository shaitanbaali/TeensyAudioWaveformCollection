/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0410 256 samples */
 
const int16_t AKWF_0410_256_DATA [256] = 
{1423, 2509, 3300, 3972, 4742, 5825, 7308, 9046, 10697, 12022, 13134, 14190, 15079, 15756, 17088, 19920, 23164, 25021, 25066, 23869, 21704, 18359, 14432, 11868, 11798, 13532, 16029, 18787, 21460, 23663, 25204, 26004, 25911, 24946, 23517, 22234, 21681, 21906, 22451, 22731, 22378, 21418, 20169, 18836, 17331, 15562, 13892, 12994, 11896, 8556, 2905, -3420, -9472, -15204, -20460, -24927, -28409, -30646, -31174, -30049, -27925, -25586, -23600, -22268, -21667, -21599, -21702, -21674, -21309, -20460, -19107, -17450, -15850, -14539, -13427, -12358, -11464, -10807, -9590, -7016, -3998, -2290, -2390, -3705, -5885, -9152, -12967, -15376, -15234, -13256, -10505, -7460, -4467, -1927, -39, 1101, 1322, 717, -175, -698, -465, 520, 1999, 3567, 4838, 5680, 6272, 6750, 6996, 6912, 6879, 7550, 7814, 5445, 529, -4943, -9774, -13981, -17591, -20412, -22290, -22962, -22028, -19542, -16186, -12763, -10238, -4635, -779, -373, 191, 586, 1080, 1884, 3066, 4494, 5880, 6978, 7881, 8762, 9520, 10099, 11306, 13938, 17034, 18833, 18846, 17649, 15574, 12397, 8677, 6366, 6597, 8669, 11523, 14662, 17735, 20352, 22310, 23531, 23862, 23314, 22288, 21402, 21216, 21749, 22542, 22985, 22624, 21561, 20234, 18802, 17150, 15261, 13533, 12590, 11440, 8048, 2348, -4042, -10186, -16022, -21390, -25995, -29642, -32061, -32792, -31898, -30034, -27992, -26339, -25354, -25106, -25395, -25867, -26217, -26237, -25791, -24842, -23569, -22327, -21359, -20574, -19817, -19217, -18832, -17876, -15546, -12754, -11264, -11567, -13066, -15413, -18841, -22805, -25347, -25327, -23453, -20767, -17737, -14724, -12131, -10154, -8888, -8512, -8934, -9613, -9894, -9398, -8123, -6323, -4412, -2782, -1564, -569, 335, 1017, 1390, 1838, 2988, 3714, 1808, -2642, -7654, -12032, -15785, -18939, -21295, -22722, -22966, -21617, -18733, -15005, -11233, -8356, -2447};