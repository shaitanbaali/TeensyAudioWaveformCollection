/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0403 256 samples */
 
const int16_t AKWF_0403_256_DATA [256] = 
{427, 1062, 1684, 2312, 2941, 3574, 4205, 4836, 5471, 6113, 6746, 7382, 8022, 8656, 9297, 9933, 10566, 11205, 11841, 12469, 13105, 13736, 14360, 14985, 15601, 16212, 16816, 17414, 18003, 18586, 19160, 19722, 20279, 20825, 21362, 21883, 22397, 22901, 23392, 23876, 24350, 24812, 25262, 25703, 26134, 26554, 26963, 27361, 27747, 28122, 28485, 28836, 29176, 29505, 29821, 30121, 30405, 30677, 30932, 31170, 31392, 31601, 31792, 31966, 32125, 32266, 32393, 32500, 32589, 32662, 32714, 32751, 32768, 32763, 32743, 32701, 32637, 32554, 32451, 32326, 32178, 32011, 31818, 31606, 31371, 31112, 30829, 30517, 30180, 29817, 29425, 29005, 28554, 28073, 27564, 27024, 26451, 25851, 25218, 24553, 23854, 23120, 22365, 21588, 20789, 19970, 19133, 18279, 17407, 16523, 15618, 14699, 13771, 12831, 11879, 10918, 9947, 8971, 7986, 6995, 5999, 4999, 3994, 2986, 1982, 977, -25, -1022, -2016, -3004, -3984, -4958, -5922, -6874, -7820, -8752, -9672, -10579, -11474, -12352, -13218, -14066, -14898, -15712, -16510, -17292, -18054, -18795, -19521, -20223, -20908, -21578, -22224, -22854, -23467, -24064, -24638, -25196, -25733, -26248, -26752, -27231, -27697, -28141, -28570, -28975, -29363, -29730, -30074, -30399, -30699, -30981, -31235, -31471, -31685, -31875, -32044, -32191, -32314, -32414, -32490, -32547, -32581, -32592, -32585, -32555, -32508, -32442, -32352, -32244, -32114, -31965, -31799, -31613, -31408, -31184, -30941, -30678, -30401, -30107, -29790, -29459, -29113, -28750, -28374, -27978, -27571, -27150, -26716, -26265, -25804, -25331, -24844, -24344, -23835, -23319, -22796, -22264, -21727, -21185, -20638, -20087, -19534, -18979, -18418, -17863, -17305, -16742, -16184, -15629, -15066, -14507, -13940, -13371, -12801, -12229, -11647, -11071, -10486, -9900, -9314, -8720, -8124, -7525, -6923, -6317, -5713, -5102, -4495, -3883, -3270, -2658, -2044, -1424, -807, -176};