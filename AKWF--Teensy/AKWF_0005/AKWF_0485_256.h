/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0485 256 samples */
 
const int16_t AKWF_0485_256_DATA [256] = 
{311, 1125, 1961, 2832, 3729, 4649, 5590, 6539, 7497, 8459, 9412, 10363, 11305, 12237, 13164, 14082, 14983, 15874, 16756, 17630, 18502, 19368, 20225, 21079, 21921, 22748, 23563, 24357, 25126, 25872, 26588, 27273, 27927, 28543, 29124, 29669, 30176, 30641, 31066, 31445, 31780, 32066, 32300, 32483, 32616, 32702, 32750, 32768, 32755, 32711, 32631, 32517, 32365, 32183, 31969, 31726, 31455, 31155, 30826, 30469, 30084, 29670, 29229, 28758, 28253, 27711, 27134, 26527, 25896, 25239, 24551, 23837, 23090, 22312, 21505, 20664, 19789, 18888, 17960, 17010, 16047, 15064, 14063, 13046, 12005, 10943, 9869, 8783, 7689, 6593, 5494, 4401, 3313, 2232, 1158, 89, -976, -2032, -3076, -4105, -5113, -6106, -7086, -8051, -9000, -9932, -10841, -11730, -12596, -13439, -14265, -15075, -15871, -16660, -17435, -18195, -18938, -19658, -20348, -21012, -21649, -22253, -22824, -23356, -23846, -24300, -24712, -25082, -25407, -25683, -25913, -26101, -26246, -26347, -26400, -26407, -26370, -26302, -26207, -26087, -25947, -25791, -25617, -25434, -25242, -25045, -24841, -24627, -24397, -24152, -23892, -23612, -23313, -22993, -22651, -22283, -21886, -21455, -20989, -20489, -19955, -19388, -18784, -18148, -17487, -16801, -16095, -15375, -14637, -13880, -13106, -12307, -11495, -10676, -9853, -9032, -8217, -7412, -6663, -6013, -5469, -5019, -4650, -4351, -4124, -3973, -3892, -3869, -3892, -3951, -4040, -4151, -4280, -4417, -4556, -4699, -4844, -4987, -5122, -5246, -5359, -5468, -5573, -5678, -5780, -5878, -5968, -6050, -6129, -6207, -6287, -6364, -6433, -6495, -6555, -6619, -6688, -6765, -6846, -6929, -7013, -7100, -7188, -7280, -7375, -7465, -7545, -7612, -7664, -7701, -7721, -7725, -7712, -7679, -7628, -7555, -7462, -7346, -7208, -7051, -6873, -6675, -6457, -6212, -5939, -5637, -5305, -4940, -4536, -4090, -3597, -3057, -2470, -1838, -1164, -430};