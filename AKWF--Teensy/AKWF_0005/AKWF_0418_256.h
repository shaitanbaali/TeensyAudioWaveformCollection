/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0418 256 samples */
 
const int16_t AKWF_0418_256_DATA [256] = 
{1773, 4959, 7947, 10736, 13245, 15429, 17258, 18717, 19821, 20585, 21030, 21189, 21089, 20762, 20240, 19552, 18731, 17799, 16784, 15711, 14598, 13466, 12338, 11226, 10150, 9123, 8157, 7262, 6442, 5790, 3523, -281, -3240, -5829, -8069, -9998, -11627, -12980, -14077, -14927, -15554, -15975, -16208, -16274, -16192, -15986, -15673, -15279, -14825, -14330, -13815, -13297, -12787, -12292, -11817, -11348, -10864, -10330, -9693, -8908, -7937, -6745, -5317, -3628, -1666, 513, 2834, 5220, 7586, 9869, 11999, 13896, 15518, 16831, 17818, 18491, 18863, 18960, 18807, 18435, 17876, 17158, 16313, 15371, 14351, 13283, 12189, 11083, 9989, 8923, 7896, 6922, 6010, 5204, 3362, -326, -4543, -8534, -12307, -15813, -19011, -21897, -24459, -26677, -28557, -30092, -31276, -32116, -32613, -32768, -32588, -32079, -31248, -30099, -28645, -26902, -24877, -22600, -20106, -17423, -14607, -11710, -8762, -5817, -2910, -64, 2679, 5298, 7777, 10085, 12211, 14146, 15870, 17380, 18672, 19737, 20579, 21195, 21586, 21756, 21710, 21449, 20977, 20303, 19436, 18381, 17153, 15774, 14260, 12644, 10972, 9292, 7676, 6197, 4910, 3869, 3116, 2684, 2605, 2864, 3396, 4126, 4987, 5910, 6826, 7669, 8378, 8913, 9256, 9404, 9369, 9165, 8813, 8343, 7774, 7130, 6438, 5716, 4986, 4266, 3567, 2904, 2291, 1732, 1240, 823, 483, 229, 62, -12, 7, 123, 338, 650, 1063, 1577, 2192, 2911, 3733, 4649, 5642, 6688, 7753, 8810, 9825, 10769, 11621, 12359, 12962, 13422, 13730, 13877, 13863, 13687, 13353, 12863, 12227, 11451, 10542, 9515, 8340, 7305, 4549, -1028, -5598, -9605, -13166, -16309, -19039, -21379, -23347, -24953, -26224, -27180, -27841, -28240, -28400, -28349, -28116, -27727, -27207, -26575, -25848, -25037, -24133, -23124, -21979, -20654, -19118, -17347, -15313, -13012, -10433, -7584, -4543, -1327};