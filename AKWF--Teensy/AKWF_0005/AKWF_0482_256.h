/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0482 256 samples */
 
const int16_t AKWF_0482_256_DATA [256] = 
{1245, 3823, 6457, 9048, 11537, 13936, 16339, 18726, 21076, 23265, 25193, 26870, 28279, 29425, 30418, 31276, 31975, 32508, 32765, 32684, 32274, 31591, 30755, 29763, 28621, 27331, 25890, 24311, 22599, 20756, 18798, 16733, 14568, 12323, 10007, 7628, 5214, 2769, 309, -2141, -4576, -6980, -9326, -11612, -13820, -15928, -17932, -19817, -21564, -23172, -24627, -25917, -27039, -27984, -28746, -29324, -29713, -29912, -29922, -29743, -29379, -28830, -28113, -27167, -25918, -24402, -22639, -20654, -18482, -16148, -13676, -11105, -8453, -5752, -3036, -323, 2361, 4981, 7527, 9972, 12287, 14469, 16493, 18338, 20003, 21469, 22727, 23775, 24603, 25209, 25593, 25754, 25694, 25419, 24935, 24248, 23366, 22303, 21068, 19672, 18135, 16465, 14677, 12796, 10828, 8793, 6714, 4598, 2466, 343, -1768, -3846, -5868, -7831, -9716, -11505, -13195, -14768, -16213, -17527, -18698, -19717, -20585, -21293, -21838, -22220, -22438, -22491, -22383, -22116, -21695, -21124, -20411, -19562, -18583, -17488, -16282, -14974, -13583, -12111, -10572, -8983, -7350, -5686, -4010, -2324, -645, 1010, 2641, 4230, 5763, 7240, 8644, 9965, 11203, 12342, 13379, 14310, 15127, 15828, 16409, 16868, 17205, 17417, 17506, 17473, 17320, 17050, 16667, 16174, 15580, 14886, 14099, 13231, 12282, 11264, 10188, 9056, 7880, 6672, 5432, 4177, 2917, 1653, 400, -832, -2043, -3218, -4350, -5436, -6465, -7431, -8332, -9158, -9907, -10578, -11161, -11658, -12066, -12383, -12608, -12744, -12788, -12742, -12608, -12389, -12088, -11707, -11251, -10724, -10130, -9478, -8768, -8009, -7209, -6369, -5499, -4607, -3695, -2772, -1847, -921, -7, 895, 1758, 2371, 2587, 2320, 1609, 613, -546, -1735, -2902, -4072, -5225, -6447, -7746, -9061, -10257, -11280, -12112, -12824, -13483, -14062, -14470, -14619, -14454, -13890, -12945, -11717, -10316, -8761, -7067, -5257, -3306, -1073};