/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0484 256 samples */
 
const int16_t AKWF_0484_256_DATA [256] = 
{144, 607, 1073, 1529, 1971, 2399, 2812, 3209, 3609, 4015, 4421, 4829, 5223, 5590, 5933, 6265, 6597, 6927, 7249, 7544, 7813, 8060, 8282, 8496, 8714, 8933, 9156, 9374, 9572, 9753, 9916, 10083, 10260, 10444, 10636, 10837, 11046, 11264, 11489, 11722, 11964, 12213, 12468, 12733, 13004, 13282, 13568, 13860, 14158, 14463, 14773, 15087, 15408, 15732, 16059, 16390, 16723, 17057, 17393, 17728, 18062, 18396, 18727, 19054, 19378, 19696, 20008, 20313, 20610, 20899, 21178, 21445, 21703, 21968, 22238, 22511, 22787, 23058, 23327, 23589, 23842, 24085, 24316, 24534, 24736, 24923, 25091, 25240, 25370, 25479, 25567, 25633, 25677, 25697, 25694, 25668, 25618, 25546, 25449, 25327, 25183, 25014, 24822, 24607, 24369, 24108, 23824, 23518, 23189, 22840, 22468, 22074, 21661, 21226, 20771, 20297, 19801, 19287, 18754, 18201, 17631, 17043, 16436, 15811, 15171, 14511, 13837, 13147, 12439, 11718, 10980, 10228, 9464, 8684, 7890, 7087, 6270, 5440, 4601, 3751, 2891, 2025, 1148, 264, -624, -1520, -2421, -3326, -4235, -5146, -6057, -6970, -7882, -8792, -9700, -10604, -11503, -12399, -13285, -14164, -15036, -15895, -16745, -17583, -18407, -19217, -20014, -20793, -21555, -22299, -23023, -23729, -24413, -25074, -25714, -26331, -26922, -27489, -28031, -28544, -29033, -29493, -29923, -30326, -30699, -31042, -31356, -31638, -31890, -32110, -32299, -32456, -32582, -32675, -32736, -32765, -32762, -32727, -32660, -32561, -32429, -32267, -32075, -31849, -31594, -31309, -30992, -30646, -30273, -29868, -29436, -28977, -28489, -27975, -27437, -26871, -26281, -25668, -25030, -24370, -23689, -22985, -22261, -21519, -20757, -19978, -19182, -18368, -17540, -16698, -15840, -14973, -14093, -13200, -12319, -11479, -10695, -9980, -9308, -8669, -8043, -7418, -6801, -6196, -5607, -5049, -4521, -4007, -3495, -2987, -2486, -2011, -1563, -1136, -714, -283};