/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0445 256 samples */
 
const int16_t AKWF_0445_256_DATA [256] = 
{714, 1809, 2842, 3842, 4801, 5724, 6611, 7460, 8274, 9057, 9806, 10525, 11218, 11880, 12518, 13133, 13721, 14290, 14836, 15363, 15871, 16361, 16832, 17289, 17730, 18154, 18567, 18964, 19348, 19721, 20081, 20430, 20768, 21096, 21413, 21722, 22020, 22311, 22593, 22866, 23132, 23391, 23642, 23886, 24124, 24355, 24580, 24800, 25011, 25220, 25422, 25619, 25812, 26000, 26182, 26361, 26535, 26704, 26870, 27032, 27189, 27344, 27494, 27642, 27786, 27928, 28064, 28199, 28331, 28459, 28585, 28708, 28829, 28947, 29062, 29176, 29287, 29396, 29502, 29606, 29708, 29808, 29907, 30002, 30096, 30189, 30280, 30369, 30456, 30542, 30626, 30708, 30789, 30869, 30947, 31024, 31098, 31173, 31245, 31316, 31386, 31455, 31522, 31589, 31654, 31718, 31781, 31843, 31904, 31964, 32023, 32081, 32137, 32193, 32249, 32303, 32357, 32409, 32461, 32511, 32561, 32611, 32649, 32391, 33981, 21069, -5596, -16037, -20192, -22854, -25150, -27220, -28857, -30029, -30810, -31299, -31592, -31767, -31873, -31940, -31981, -32001, -32004, -31991, -31963, -31926, -31883, -31833, -31781, -31724, -31665, -31605, -31542, -31477, -31411, -31343, -31274, -31204, -31131, -31057, -30982, -30905, -30828, -30747, -30667, -30585, -30500, -30415, -30327, -30237, -30148, -30054, -29959, -29864, -29765, -29664, -29562, -29457, -29351, -29242, -29131, -29018, -28902, -28784, -28662, -28539, -28413, -28283, -28152, -28017, -27879, -27738, -27593, -27446, -27294, -27140, -26981, -26819, -26652, -26482, -26307, -26129, -25945, -25757, -25563, -25366, -25163, -24954, -24741, -24521, -24294, -24063, -23824, -23579, -23327, -23068, -22801, -22526, -22242, -21951, -21651, -21341, -21022, -20693, -20353, -20003, -19640, -19266, -18880, -18480, -18067, -17639, -17197, -16737, -16263, -15771, -15259, -14730, -14180, -13607, -13014, -12396, -11752, -11084, -10387, -9659, -8902, -8110, -7283, -6421, -5515, -4569, -3579, -2544, -1473, -356};