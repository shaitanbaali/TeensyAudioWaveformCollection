/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0476 256 samples */
 
const int16_t AKWF_0476_256_DATA [256] = 
{9529, 13309, 14664, 14595, 13635, 12186, 10540, 8906, 7405, 6113, 5072, 4280, 3727, 3371, 3337, 2818, 1344, 1653, 1911, 2223, 2555, 2891, 3219, 3528, 3815, 4075, 4306, 4508, 4680, 4850, 4849, 5588, 7120, 7130, 7186, 7228, 7257, 7279, 7295, 7306, 7315, 7320, 7325, 7330, 7333, 7316, 7439, 6921, 5332, 5435, 5426, 5433, 5443, 5453, 5463, 5474, 5485, 5496, 5508, 5520, 5532, 5568, 5456, 6105, 7568, 7526, 7598, 7300, 8807, 11904, 11596, 11664, 11673, 11682, 11690, 11699, 11706, 11694, 11817, 11302, 9713, 9814, 9803, 9806, 9810, 9814, 9817, 9820, 9823, 9826, 9828, 9829, 9829, 9853, 9728, 10365, 11816, 11761, 11764, 11764, 11762, 11760, 11756, 11752, 11749, 11745, 11740, 11805, 11419, 13278, 16715, 15791, 14262, 14350, 14327, 14318, 14309, 14302, 14293, 14284, 14274, 14265, 14254, 14244, 14233, 14140, 14524, 13240, -8198, -10425, -10663, -10635, -10503, -10824, -11102, -11352, -11615, -11889, -12162, -12428, -12678, -12933, -13032, -13753, -15481, -15839, -14716, -11131, -11510, -11586, -11694, -11794, -11886, -11970, -12047, -12117, -12184, -12218, -12395, -11807, -10401, -10497, -10527, -10557, -10585, -10610, -10632, -10651, -10667, -10681, -10691, -10699, -10705, -10728, -10613, -11132, -12725, -12623, -12631, -12623, -12611, -12597, -12582, -12565, -12516, -12668, -11930, -8393, -8391, -8350, -8441, -7775, -6295, -6320, -6282, -6245, -6211, -6176, -6140, -6103, -6065, -6025, -5986, -5945, -5903, -5882, -5722, -6199, -7750, -7608, -7578, -7532, -7484, -7436, -7388, -7339, -7289, -7239, -7189, -7138, -7087, -7012, -7084, -6394, -4891, -4893, -4835, -4778, -4725, -4672, -4618, -4564, -4511, -4456, -4402, -4348, -4295, -4261, -4091, -4558, -6101, -5950, -5913, -5859, -5805, -5753, -5699, -5646, -5594, -5540, -5488, -5873, -3334, -20215, -21563, -6475};