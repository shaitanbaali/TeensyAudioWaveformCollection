/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0436 256 samples */
 
const int16_t AKWF_0436_256_DATA [256] = 
{2242, 7908, 11580, 13515, 14879, 15643, 15966, 15985, 15774, 15409, 14961, 14496, 14094, 13845, 13863, 14229, 14886, 15689, 16461, 17000, 17119, 16666, 15545, 13710, 11172, 7968, 4130, -230, -4594, -8377, -11498, -13957, -15712, -16756, -17142, -16969, -16393, -15607, -14809, -14178, -13842, -13853, -14129, -14545, -15011, -15453, -15803, -15992, -15943, -15567, -14750, -13336, -11089, -7486, -2034, 1756, 2929, 4456, 6099, 7584, 9060, 10505, 11901, 13261, 14585, 15864, 17101, 18298, 19448, 20557, 21622, 22639, 23612, 24538, 25415, 26248, 27032, 27765, 28453, 29090, 29675, 30213, 30700, 31135, 31519, 31852, 32135, 32365, 32544, 32670, 32745, 32768, 32739, 32658, 32525, 32341, 32105, 31817, 31477, 31087, 30645, 30153, 29610, 29018, 28376, 27684, 26944, 26155, 25317, 24434, 23502, 22524, 21501, 20431, 19317, 18162, 16960, 15717, 14435, 13107, 11741, 10339, 8895, 7413, 5897, 4336, 2735, 1184, -2240, -7910, -11575, -13516, -14880, -15644, -15967, -15986, -15774, -15409, -14961, -14497, -14095, -13845, -13863, -14229, -14886, -15689, -16461, -17001, -17120, -16666, -15545, -13711, -11173, -7969, -4131, 229, 4593, 8377, 11497, 13957, 15711, 16755, 17141, 16968, 16392, 15607, 14809, 14177, 13841, 13852, 14128, 14544, 15010, 15453, 15802, 15991, 15942, 15566, 14750, 13335, 11088, 7486, 2032, -1758, -2929, -4458, -6100, -7586, -9061, -10505, -11903, -13262, -14585, -15865, -17102, -18298, -19449, -20557, -21622, -22639, -23612, -24538, -25416, -26249, -27033, -27766, -28453, -29090, -29675, -30213, -30700, -31135, -31519, -31853, -32135, -32365, -32544, -32670, -32745, -32768, -32739, -32658, -32525, -32341, -32105, -31817, -31477, -31087, -30645, -30153, -29610, -29019, -28376, -27684, -26944, -26155, -25317, -24434, -23503, -22524, -21502, -20431, -19318, -18163, -16961, -15717, -14435, -13107, -11742, -10340, -8895, -7414, -5898, -4343, -2774, -1055};