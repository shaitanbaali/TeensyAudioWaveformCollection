/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0486 256 samples */
 
const int16_t AKWF_0486_256_DATA [256] = 
{202, 770, 1319, 1861, 2395, 2921, 3441, 3953, 4458, 4957, 5446, 5930, 6407, 6875, 7338, 7795, 8243, 8685, 9120, 9547, 9970, 10385, 10793, 11195, 11589, 11978, 12360, 12735, 13104, 13467, 13822, 14172, 14515, 14851, 15182, 15507, 15825, 16136, 16443, 16743, 17038, 17327, 17609, 17886, 18158, 18424, 18684, 18939, 19189, 19435, 19675, 19910, 20139, 20364, 20584, 20800, 21011, 21217, 21421, 21618, 21811, 22001, 22186, 22368, 22546, 22720, 22891, 23057, 23221, 23380, 23537, 23690, 23841, 23988, 24132, 24274, 24413, 24548, 24681, 24812, 24940, 25065, 25189, 25310, 25429, 25547, 25661, 25775, 25886, 25995, 26104, 26209, 26314, 25470, 30667, 3438, -32166, -26783, -27645, -27523, -27401, -27276, -27150, -27021, -26889, -26756, -26621, -26484, -26342, -26199, -26052, -25903, -25751, -25597, -25438, -25278, -25113, -24945, -24773, -24598, -24419, -24237, -24051, -23859, -23665, -23465, -23261, -23054, -22840, -22624, -22402, -22174, -21943, -21705, -21462, -21214, -20960, -20700, -20436, -20165, -19888, -19604, -19315, -19018, -18716, -18406, -18090, -17767, -17437, -17099, -16755, -16402, -16042, -15675, -15299, -14916, -14525, -14125, -13718, -13302, -12875, -12443, -12000, -11547, -11087, -10619, -10140, -9653, -9155, -8647, -8131, -7605, -7068, -6523, -5966, -5400, -4825, -4236, -3639, -3032, -2414, -1784, -1146, -496, 165, 836, 1520, 2214, 2918, 3635, 4362, 5099, 5850, 6610, 7380, 8163, 8954, 9757, 10572, 11394, 12229, 13072, 13924, 14786, 15656, 16532, 17418, 18311, 19207, 20111, 21020, 21932, 22848, 23767, 24686, 25608, 26528, 27446, 28365, 29280, 30189, 30116, 36299, 8860, -27277, -20939, -21083, -20218, -19365, -18521, -17684, -16862, -16048, -15246, -14456, -13677, -12907, -12153, -11407, -10673, -9951, -9239, -8539, -7851, -7171, -6503, -5847, -5198, -4560, -3933, -3314, -2705, -2105, -1513, -932, -348};