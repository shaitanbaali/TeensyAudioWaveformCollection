/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0480 256 samples */
 
const int16_t AKWF_0480_256_DATA [256] = 
{752, 2495, 4253, 6063, 7917, 9810, 11737, 13677, 15619, 17549, 19436, 21269, 23027, 24681, 26221, 27626, 28876, 29963, 30873, 31598, 32142, 32497, 32660, 32626, 32390, 31952, 31309, 30466, 29428, 28198, 26791, 25221, 23499, 21655, 19706, 17674, 15596, 13484, 11361, 9254, 7168, 5114, 3110, 1150, -759, -2612, -4417, -6176, -7883, -9550, -11176, -12760, -14309, -15819, -17289, -18726, -20119, -21468, -22773, -24025, -25218, -26353, -27416, -28404, -29312, -30128, -30848, -31465, -31969, -32356, -32620, -32752, -32751, -32610, -32326, -31896, -31317, -30591, -29716, -28692, -27527, -26217, -24770, -23196, -21493, -19673, -17749, -15720, -13605, -11416, -9155, -6845, -4497, -2118, 269, 2653, 5027, 7365, 9660, 11901, 14064, 16143, 18127, 19996, 21746, 23365, 24837, 26162, 27328, 28326, 29155, 29807, 30280, 30572, 30683, 30612, 30360, 29930, 29329, 28557, 27624, 26537, 25299, 23927, 22427, 20807, 19083, 17267, 15366, 13400, 11380, 9313, 7226, 5121, 3015, 927, -1136, -3161, -5129, -7036, -8867, -10608, -12254, -13793, -15213, -16516, -17683, -18745, -19758, -20702, -21561, -22329, -22990, -23534, -23954, -24240, -24386, -24388, -24241, -23944, -23495, -22897, -22149, -21255, -20223, -19054, -17758, -16346, -14824, -13200, -11492, -9706, -7855, -5959, -4021, -2059, -94, 1873, 3821, 5732, 7603, 9416, 11153, 12813, 14378, 15835, 17182, 18404, 19494, 20450, 21260, 21923, 22435, 22792, 22993, 23038, 22930, 22667, 22254, 21695, 20995, 20158, 19194, 18107, 16907, 15606, 14207, 12724, 11172, 9551, 7880, 6173, 4431, 2674, 915, -844, -2583, -4293, -5970, -7596, -9162, -10665, -12088, -13428, -14680, -15831, -16879, -17820, -18646, -19355, -19945, -20413, -20759, -20982, -21080, -21058, -20915, -20655, -20280, -19793, -19201, -18506, -17712, -16829, -15857, -14805, -13679, -12480, -11219, -9900, -8521, -7092, -5615, -4090, -2522, -872};