/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0420 256 samples */
 
const int16_t AKWF_0420_256_DATA [256] = 
{999, 2777, 4633, 6455, 8157, 9618, 10504, 10564, 9796, 8338, 6413, 4227, 1968, -154, -1951, -3266, -4023, -4245, -4016, -3470, -2748, -1979, -1261, -651, -173, 174, 415, 579, 700, 811, 931, 1075, 1246, 1441, 1658, 1888, 2125, 2365, 2609, 2858, 3115, 3386, 3676, 3994, 4341, 4689, 4976, 5121, 5062, 4772, 4264, 3588, 2811, 2010, 1246, 565, -6, -466, -830, -1114, -1345, -1544, -1728, -1909, -2092, -2273, -2571, -2332, -4187, -22288, -32739, -31051, -23665, -13665, -3885, 3838, 8606, 10361, 9661, 7339, 4290, 1256, -1247, -2964, -3881, -4124, -3911, -3464, -2964, -2514, -2125, -1729, -1195, -377, 787, 2259, 3929, 5664, 7364, 8946, 10121, 10545, 10120, 8937, 7183, 5078, 2828, 620, -1333, -2846, -3819, -4235, -4159, -3708, -3029, -2261, -1511, -854, -326, 68, 343, 530, 662, 772, 886, 1020, 1180, 1368, 1578, 1800, 1942, 2577, -757, -14980, -21376, -20138, -14871, -7892, -1159, 4069, 7201, 8230, 7570, 5819, 3609, 1453, -297, -1478, -2099, -2271, -2163, -1946, -1756, -1680, -1744, -1922, -2148, -2320, -2318, -2013, -1285, -96, 1481, 3300, 5187, 7013, 8694, 10025, 10651, 10416, 9380, 7722, 5666, 3427, 1183, -853, -2490, -3609, -4169, -4213, -3851, -3223, -2471, -1710, -1025, -463, -34, 271, 479, 625, 739, 851, 979, 1130, 1239, 1697, -504, -11584, -23757, -28763, -27443, -21833, -14244, -6658, -476, 3588, 5473, 5535, 4382, 2670, 970, -316, -986, -1003, -462, 475, 1621, 2807, 3899, 4799, 5442, 5789, 5822, 5562, 5078, 4469, 3832, 3243, 2752, 2374, 2103, 1915, 1781, 1669, 1555, 1421, 1262, 1077, 865, 637, 396, 144, -120, -400, -702, -1024, -1362, -1708, -2043, -2344, -2578, -2696, -2631, -2299, -1612, -460};