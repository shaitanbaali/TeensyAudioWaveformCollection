/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0479 256 samples */
 
const int16_t AKWF_0479_256_DATA [256] = 
{882, 3025, 5116, 7184, 9205, 11166, 13052, 14837, 16518, 18078, 19500, 20781, 21910, 22873, 23671, 24295, 24740, 25006, 25090, 24993, 24718, 24265, 23643, 22853, 21904, 20816, 19650, 18483, 17359, 16291, 15287, 14338, 13433, 12559, 11698, 10834, 9955, 9043, 8087, 7080, 6009, 4867, 3654, 2363, 994, -445, -1960, -3544, -5184, -6880, -8618, -10384, -12176, -13973, -15762, -17536, -19274, -20962, -22592, -24143, -25603, -26962, -28203, -29315, -30290, -31114, -31780, -32280, -32608, -32758, -32727, -32512, -32112, -31527, -30762, -29816, -28695, -27410, -25960, -24358, -22619, -20743, -18749, -16652, -14456, -12182, -9849, -7461, -5041, -2617, -247, 1985, 4035, 5888, 7530, 8967, 10214, 11279, 12179, 12934, 13556, 14065, 14477, 14805, 15064, 15268, 15427, 15552, 15651, 15734, 15805, 15870, 15933, 15996, 16063, 16131, 16202, 16275, 16346, 16414, 16477, 16529, 16566, 16586, 16584, 16555, 16494, 16397, 16260, 16080, 15852, 15574, 15242, 14855, 14410, 13907, 13345, 12723, 12043, 11305, 10512, 9666, 8768, 7824, 6837, 5811, 4752, 3666, 2556, 1429, 294, -847, -1985, -3126, -4291, -5468, -6644, -7811, -8951, -10053, -11111, -12109, -13038, -13893, -14660, -15336, -15915, -16388, -16754, -17010, -17152, -17178, -17089, -16885, -16569, -16142, -15610, -14973, -14238, -13414, -12503, -11514, -10457, -9336, -8160, -6943, -5687, -4407, -3112, -1806, -505, 783, 2055, 3293, 4494, 5650, 6749, 7788, 8761, 9655, 10473, 11205, 11846, 12397, 12852, 13209, 13469, 13628, 13689, 13651, 13516, 13286, 12964, 12555, 12060, 11485, 10836, 10111, 9268, 8274, 7109, 5771, 4281, 2657, 922, -888, -2750, -4636, -6509, -8346, -10125, -11810, -13387, -14836, -16131, -17264, -18219, -18982, -19549, -19911, -20063, -20007, -19743, -19273, -18603, -17740, -16693, -15471, -14089, -12562, -10898, -9120, -7244, -5285, -3267, -1160};