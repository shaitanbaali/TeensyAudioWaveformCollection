/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0472 256 samples */
 
const int16_t AKWF_0472_256_DATA [256] = 
{51, 307, 739, 1216, 1679, 2127, 2543, 2924, 3276, 3617, 3956, 4301, 4653, 5014, 5385, 5765, 6152, 6548, 6952, 7361, 7778, 8201, 8628, 9063, 9501, 9943, 10390, 10840, 11293, 11749, 12207, 12668, 13132, 13596, 14061, 14531, 14999, 15468, 15942, 16415, 16888, 17363, 17840, 18318, 18796, 19274, 19754, 20236, 20716, 21199, 21682, 22166, 22651, 23136, 23621, 24109, 24596, 25083, 25573, 26062, 26551, 27043, 27534, 28026, 28518, 29008, 29489, 29958, 30391, 30652, 31321, 27234, 6405, -2693, 875, 270, -78, 101, 66, 69, 86, 94, 103, 112, 121, 130, 138, 145, 151, 157, 162, 167, 172, 175, 178, 180, 182, 183, 184, 183, 182, 181, 178, 176, 171, 167, 161, 155, 149, 141, 133, 124, 114, 103, 93, 80, 67, 53, 39, 24, 8, -9, -26, -42, -58, -67, -152, 786, 1109, -32, 111, 121, 45, 39, 20, 1, -14, -31, -46, -61, -75, -87, -99, -110, -119, -130, -138, -146, -153, -159, -165, -170, -174, -177, -180, -183, -183, -185, -185, -183, -182, -180, -178, -174, -170, -166, -161, -155, -148, -142, -134, -127, -118, -109, -100, -90, -80, -71, -64, -64, -85, -202, -254, -1305, -15743, -31683, -31699, -30108, -30257, -29752, -29229, -28768, -28272, -27779, -27288, -26796, -26307, -25817, -25327, -24839, -24351, -23865, -23379, -22893, -22407, -21924, -21440, -20957, -20476, -19995, -19514, -19034, -18556, -18078, -17602, -17125, -16651, -16178, -15705, -15233, -14764, -14295, -13828, -13363, -12900, -12438, -11978, -11520, -11067, -10615, -10166, -9721, -9281, -8845, -8415, -7989, -7568, -7156, -6749, -6349, -5957, -5574, -5198, -4833, -4476, -4127, -3786, -3447, -3102, -2738, -2340, -1908, -1449, -980, -525, -151};