/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0448 256 samples */
 
const int16_t AKWF_0448_256_DATA [256] = 
{9922, 20312, 23875, 22369, 14463, 11201, 18759, 26101, 30213, 31988, 31433, 24099, 7582, -240, 11199, 23264, 28907, 31611, 31971, 27838, 13799, 1594, 6331, 18081, 24366, 26653, 22171, 3214, -12887, -18743, -10620, 11147, 22718, 27545, 29167, 26535, 15948, 7691, 13991, 22713, 27362, 29028, 24755, 4980, -13010, -19945, -19567, -3080, 14088, 20307, 17699, -1276, -17097, -23145, -24686, -19302, -5852, -1646, -13158, -23271, -28246, -30261, -27877, -8948, 12056, 20757, 23792, 20533, 7731, 51, 9482, 20656, 26332, 28604, 26356, 9781, -9279, -17066, -13400, 6071, 19365, 24112, 23514, 7478, -11947, -19949, -21992, -16393, -3524, -1864, -14617, -24344, -29253, -31384, -31012, -20068, 1380, 13245, 13613, -2146, -16839, -22198, -22266, -11700, 3984, 7219, -7734, -21411, -27622, -30569, -30921, -25232, -9109, 1412, -7617, -20858, -27351, -30466, -31076, -28134, -20580, -17534, -23148, -28733, -31785, -32802, -30191, -11445, 10555, 20179, 23837, 22370, 14465, 11203, 18759, 26101, 30214, 31988, 31433, 24099, 7582, -241, 11197, 23264, 28907, 31611, 31970, 27837, 13798, 1592, 6329, 18081, 24367, 26654, 22172, 3213, -12887, -18742, -10618, 11148, 22718, 27545, 29167, 26535, 15946, 7690, 13992, 22714, 27362, 29028, 24755, 4979, -13011, -19946, -19568, -3081, 14087, 20306, 17699, -1277, -17097, -23145, -24687, -19302, -5853, -1646, -13158, -23271, -28246, -30261, -27877, -8948, 12056, 20757, 23792, 20533, 7731, 52, 9481, 20655, 26332, 28604, 26356, 9781, -9280, -17066, -13401, 6069, 19365, 24113, 23514, 7478, -11947, -19949, -21992, -16394, -3523, -1864, -14618, -24344, -29253, -31384, -31012, -20067, 1382, 13246, 13614, -2145, -16838, -22198, -22265, -11700, 3983, 7219, -7736, -21412, -27622, -30569, -30921, -25232, -9108, 1412, -7620, -20860, -27351, -30466, -31076, -28135, -20580, -17534, -23148, -28733, -31785, -32841, -30200, -11370};