/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0478 256 samples */
 
const int16_t AKWF_0478_256_DATA [256] = 
{6408, 15728, 23595, 29255, 32289, 32649, 30497, 26206, 20311, 13481, 6399, -450, -6751, -12348, -17202, -21216, -24245, -26146, -26815, -26289, -24761, -22528, -19902, -17110, -14288, -11474, -8652, -5846, -3118, -598, 1512, 3012, 3746, 3663, 2884, 1679, 429, -436, -508, 503, 2694, 5900, 9716, 13638, 17140, 19805, 21423, 21955, 21522, 20334, 18632, 16645, 14539, 12433, 10377, 8363, 6364, 4349, 2189, -592, -4172, -8059, -11359, -13271, -13495, -12176, -9823, -7134, -4658, -2610, -998, 167, 801, 809, 186, -1003, -2683, -4809, -7345, -10174, -13061, -15664, -17550, -18348, -17876, -16203, -13603, -10425, -7016, -3622, -362, 2684, 5474, 7940, 9962, 11408, 12152, 12103, 11253, 9693, 7630, 5343, 3163, 1416, 336, 49, 540, 1683, 3275, 5084, 6898, 8518, 9778, 10559, 10773, 10375, 9364, 7779, 5704, 3258, 519, -2693, -6442, -10434, -13922, -15981, -16002, -13873, -10034, -5294, -528, 3533, 6444, 8019, 8225, 7195, 5242, 2794, 263, -2113, -4266, -6231, -8055, -9672, -10913, -11561, -11443, -10529, -8949, -6958, -4837, -2805, -994, 573, 1958, 3235, 4467, 5667, 6763, 7622, 8079, 7995, 7324, 6135, 4619, 3038, 1699, 879, 745, 1313, 2436, 3866, 5311, 6512, 7299, 7596, 7413, 6823, 5925, 4817, 3569, 2236, 856, -544, -1925, -3237, -4510, -6060, -8006, -9998, -11416, -11733, -10819, -8880, -6371, -3852, -1731, -117, 1062, 1892, 2397, 2573, 2453, 2100, 1541, 757, -292, -1605, -3080, -4518, -5630, -6150, -5936, -5026, -3606, -1922, -198, 1428, 2919, 4275, 5512, 6613, 7504, 8084, 8239, 7881, 6973, 5562, 3786, 1845, -13, -1538, -2551, -2960, -2786, -2138, -1173, -62, 1055, 2062, 2873, 3428, 3685, 3523, 2543, 476, -2496, -5931, -9387, -12673, -15502, -17375, -17558, -15292, -10235, -2446};