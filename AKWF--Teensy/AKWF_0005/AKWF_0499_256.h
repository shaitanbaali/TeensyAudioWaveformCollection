/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0499 256 samples */
 
const int16_t AKWF_0499_256_DATA [256] = 
{-14505, -14505, -14505, -14506, -14505, -14534, -14469, -14501, -30368, -33357, -32629, -32759, -32755, -32749, -32745, -32740, -32734, -32728, -32597, -33269, -30493, -14550, -14366, -14457, -14417, -14411, -14405, -14400, -14395, -14390, -14385, -14380, -14375, -14370, -14366, -14361, -14357, -14353, -14347, -14030, -15720, -3079, 5258, 3639, 3942, 3944, 3947, 3948, 3950, 3952, 3952, 3953, 3955, 3955, 3956, 3957, 3957, 3957, 3957, 3957, 3957, 3955, 3954, 3955, 3955, 3953, 3952, 3953, 3952, 3952, 3950, 3950, 3949, 3948, 3947, 3947, 3946, 3945, 3944, 3942, 3942, 3941, 3940, 3939, 3938, 3937, 3936, 3935, 3934, 3933, 3932, 3932, 3930, 3929, 3928, 3927, 3927, 3925, 3924, 3923, 3922, 3921, 3920, 3919, 3918, 3917, 3916, 3915, 3913, 3912, 3912, 3911, 3909, 3908, 3907, 3907, 3906, 3904, 3903, 3901, 3900, 3900, 3899, 3898, 3897, 3895, 3895, 3894, 3893, 3891, 3890, 3890, 3888, 3887, 3886, 3885, 3885, 3883, 3882, 3881, 3880, 3880, 3878, 3877, 3876, 3875, 3874, 3873, 3872, 3870, 3870, 3869, 3868, 3866, 3865, 3865, 3864, 3863, 3861, 3860, 3860, 3858, 3857, 3856, 3855, 3855, 3853, 3852, 3851, 3850, 3850, 3848, 3847, 3846, 3845, 3844, 3843, 3842, 3840, 3840, 3839, 3838, 3837, 3836, 3835, 3834, 3833, 3831, 3830, 3830, 3829, 3828, 3827, 3825, 3825, 3823, 3822, 3821, 3820, 3820, 3819, 3818, 3816, 3815, 3815, 3813, 3812, 3811, 3810, 3810, 3808, 3807, 3806, 3804, 3803, 3803, 3802, 3801, 3800, 3798, 3798, 3797, 3796, 3794, 3793, 3793, 3792, 3791, 3789, 3788, 3788, 3787, 3786, 3784, 3783, 3783, 3781, 3780, 3779, 3778, 3778, 3777, 3776, 3774, 3773, 3773, 3771, 3770, 3769, 3768, 3768, 3766, 3765, 3764, 3763, 3763};