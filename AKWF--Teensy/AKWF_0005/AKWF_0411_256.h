/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0411 256 samples */
 
const int16_t AKWF_0411_256_DATA [256] = 
{1733, 6123, 6477, 3128, 182, 7221, 23934, 32936, 26419, 17573, 15604, 17131, 18579, 20193, 20865, 19282, 17482, 17972, 19971, 21343, 21603, 21392, 21110, 20991, 21305, 21896, 22269, 22266, 22181, 22234, 22542, 22391, 18620, 14340, 13998, 17028, 19844, 20949, 15857, 9139, 9545, 14745, 18373, 19003, 18417, 17382, 16453, 16650, 17718, 18194, 17561, 16662, 16209, 16174, 16296, 16394, 16338, 13401, 9137, 8162, 8970, 8647, 7883, 8518, 12786, 16959, 17301, 14597, 12186, 9643, 7925, 10787, 13374, 10953, 6667, 4875, 8299, 12928, 13614, 14300, 14104, 13345, 13105, 13538, 13865, 13705, 13319, 12976, 12738, 12646, 12679, 12677, 12527, 12280, 12197, 11675, 7578, 3041, 2512, 5341, 7898, 8718, 3378, -3524, -3260, 1783, 5380, 5420, 905, -2337, -2493, -1224, -401, -935, -2629, -4436, -5303, -5144, -4750, -4831, -5490, -3672, -409, -15, -1138, -1184, -1288, -1960, 933, 4906, 4747, 943, -2837, -9437, -2752, 8851, 7943, 199, -4256, -6074, -7978, -8373, -7421, -8132, -10635, -12211, -12043, -11626, -11770, -12182, -12787, -13605, -14243, -14431, -14482, -14750, -15175, -15572, -15752, -16368, -20515, -25072, -25653, -22894, -20372, -19556, -24895, -31793, -31495, -26370, -22799, -22196, -22760, -23724, -24543, -24203, -22962, -22280, -22679, -23312, -23464, -23171, -22692, -22208, -21852, -24359, -28169, -28665, -27359, -27182, -27457, -26329, -21555, -16884, -16045, -18246, -20142, -22182, -23409, -20065, -17007, -18982, -22844, -24217, -20387, -15374, -14320, -13267, -13113, -13530, -13443, -12698, -12069, -11945, -12052, -12119, -12088, -11924, -11645, -11413, -11337, -11363, -11232, -11547, -15446, -19791, -20137, -17130, -14400, -13414, -18594, -25341, -24927, -19687, -16147, -15037, -11751, -10588, -12274, -13089, -11672, -10072, -9541, -9430, -9348, -9456, -9457, -9027, -8582, -5898, -2221, -1628, -2567, -2298, -1866, -1706};