/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0460 256 samples */
 
const int16_t AKWF_0460_256_DATA [256] = 
{2978, 2978, 3014, 2812, 5188, 5999, 6470, 9018, 8921, 8934, 8986, 8715, 10811, 12126, 11867, 11970, 11678, 13425, 15131, 14840, 14894, 14894, 14930, 14729, 15654, 18029, 17839, 17873, 17873, 17873, 17927, 17639, 19588, 21078, 20800, 20852, 20852, 20852, 20852, 20852, 20852, 20852, 20853, 20880, 20718, 23143, 23984, 23798, 23831, 23831, 23831, 23831, 23831, 23831, 23831, 23831, 23831, 23831, 23831, 23831, 23870, 23655, 24665, 26985, 26772, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26810, 26853, 26619, 28881, 29977, 29748, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29789, 29675, 30287, 27557, 15440, -2976, -17756, -19911, -23688, -26532, -27704, -29997, -29583, -31971, -32938, -32730, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32755, -32815, -32596, -29961, -29742, -29802, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29789, -29735, -30025, -28116, -26581, -26863, -26810, -26810, -26810, -26810, -26810, -26810, -26810, -26810, -26810, -26810, -26810, -26810, -26793, -26888, -26507, -23890, -23812, -23839, -23831, -23831, -23831, -23831, -23831, -23821, -23867, -23707, -21075, -20793, -20867, -20852, -20852, -20852, -20852, -20800, -21084, -19097, -17650, -17924, -17873, -17822, -18099, -16038, -14679, -14943, -14877, -14972, -14591, -11974, -11896, -11875, -12127, -10812, -8715, -8965, -9033, -8545, -5935, -6055, -5541, -2937, -3087, -2530, 35, -4};