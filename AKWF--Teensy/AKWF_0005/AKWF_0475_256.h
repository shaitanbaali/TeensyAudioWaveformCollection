/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0475 256 samples */
 
const int16_t AKWF_0475_256_DATA [256] = 
{12410, 15371, 16626, 16506, 15596, 14251, 12701, 11372, 10285, 9081, 8098, 7343, 6803, 6434, 6407, 5708, 3755, 4029, 4218, 4461, 4724, 4989, 5247, 5491, 5714, 5913, 6086, 6234, 6355, 6484, 6405, 7271, 9151, 9110, 9131, 9140, 9137, 9127, 9112, 9093, 9073, 9051, 9028, 9005, 8983, 8935, 9063, 8382, 6340, 6445, 6408, 6393, 6380, 6367, 6356, 6345, 6336, 6327, 6319, 6311, 6304, 6328, 6165, 6968, 8802, 8734, 8860, 8183, 12380, 20370, 19536, 19684, 19680, 19675, 19672, 19668, 19664, 19634, 19777, 19112, 17085, 17202, 17177, 17171, 17167, 17163, 17159, 17154, 17150, 17146, 17143, 17138, 17133, 17158, 16996, 17800, 19635, 19561, 19563, 19563, 19558, 19553, 19549, 19544, 19540, 19535, 19531, 19614, 19126, 21486, 25847, 24678, 22742, 22857, 22832, 22826, 22820, 22816, 22810, 22804, 22799, 22792, 22786, 22780, 22776, 22591, 23443, 20992, -20278, -23968, -22982, -23181, -23183, -23182, -23183, -23182, -23182, -23181, -23179, -23177, -23174, -23198, -23047, -23704, -25658, -25895, -24273, -19545, -19857, -19798, -19792, -19788, -19783, -19779, -19774, -19768, -19765, -19730, -19882, -19069, -17224, -17289, -17277, -17268, -17263, -17258, -17254, -17250, -17244, -17239, -17234, -17229, -17224, -17246, -17093, -17749, -19768, -19642, -19656, -19652, -19648, -19641, -19637, -19632, -19547, -19985, -18129, -9082, -8913, -8614, -8762, -7949, -6106, -6171, -6161, -6154, -6150, -6147, -6145, -6142, -6140, -6136, -6134, -6132, -6129, -6153, -6003, -6661, -8682, -8558, -8576, -8574, -8571, -8570, -8567, -8565, -8563, -8561, -8558, -8557, -8555, -8523, -8679, -7868, -6027, -6093, -6085, -6078, -6077, -6076, -6073, -6070, -6068, -6067, -6065, -6062, -6061, -6085, -5936, -6595, -8616, -8492, -8511, -8509, -8507, -8501, -8519, -8405, -8057, -8008, -8017, -8406, -6161, -21444, -22653, -9956};