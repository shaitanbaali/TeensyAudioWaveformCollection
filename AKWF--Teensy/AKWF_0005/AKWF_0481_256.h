/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0481 256 samples */
 
const int16_t AKWF_0481_256_DATA [256] = 
{733, 3037, 5318, 7609, 9878, 12105, 14270, 16347, 18332, 20209, 21957, 23572, 25041, 26345, 27479, 28426, 29182, 29742, 30095, 30236, 30164, 29882, 29392, 28696, 27800, 26713, 25448, 24022, 22447, 20730, 18891, 16938, 14879, 12739, 10520, 8224, 5870, 3455, 985, -1522, -4067, -6632, -9185, -11715, -14195, -16586, -18878, -21047, -23073, -24949, -26649, -28160, -29475, -30575, -31452, -32108, -32539, -32747, -32736, -32504, -32056, -31400, -30548, -29506, -28279, -26876, -25310, -23588, -21733, -19752, -17659, -15480, -13219, -10896, -8540, -6157, -3767, -1394, 962, 3283, 5545, 7751, 9886, 11931, 13884, 15721, 17431, 19011, 20452, 21745, 22889, 23873, 24696, 25356, 25849, 26188, 26383, 26446, 26386, 26208, 25911, 25498, 24973, 24340, 23597, 22745, 21794, 20742, 19596, 18362, 17037, 15629, 14148, 12595, 10981, 9321, 7612, 5868, 4101, 2310, 511, -1288, -3088, -4871, -6626, -8356, -10041, -11680, -13268, -14788, -16239, -17619, -18913, -20116, -21215, -22197, -23065, -23819, -24458, -24984, -25391, -25670, -25818, -25827, -25695, -25423, -25011, -24469, -23799, -23004, -22088, -21048, -19895, -18638, -17280, -15838, -14324, -12745, -11115, -9446, -7747, -6035, -4319, -2609, -922, 734, 2349, 3902, 5385, 6788, 8096, 9306, 10409, 11398, 12281, 13055, 13728, 14312, 14817, 15250, 15622, 15940, 16211, 16438, 16626, 16779, 16904, 17002, 17075, 17123, 17141, 17121, 17059, 16953, 16806, 16616, 16378, 16087, 15741, 15340, 14884, 14373, 13811, 13194, 12532, 11831, 11087, 10297, 9457, 8556, 7590, 6561, 5463, 4302, 3087, 1813, 487, -883, -2298, -3742, -5205, -6683, -8158, -9622, -11068, -12473, -13827, -15120, -16336, -17467, -18499, -19428, -20253, -20967, -21562, -22037, -22382, -22586, -22646, -22551, -22298, -21881, -21306, -20577, -19697, -18671, -17506, -16202, -14765, -13200, -11502, -9688, -7766, -5746, -3647, -1434};