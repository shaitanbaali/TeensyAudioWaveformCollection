/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0463 256 samples */
 
const int16_t AKWF_0463_256_DATA [256] = 
{3160, 10362, 14868, 19844, 26226, 31546, 32511, 28411, 21641, 15299, 10784, 7332, 3423, -1554, -6751, -10709, -12715, -13250, -13298, -13465, -13624, -13269, -12112, -10365, -8553, -7083, -6001, -5105, -4205, -3299, -2537, -2043, -1799, -1665, -1488, -1197, -822, -415, 7, 468, 1010, 1633, 2292, 2927, 3497, 3977, 4368, 4668, 4858, 4924, 4860, 4672, 4377, 3999, 3560, 3073, 2554, 2018, 1485, 973, 494, 57, -335, -683, -984, -1236, -1439, -1601, -1724, -1811, -1870, -1897, -1899, -1877, -1832, -1764, -1689, -1582, -1648, -3487, -8590, -14416, -16162, -12287, -5141, 1971, 6856, 9463, 11414, 13988, 16613, 17535, 15756, 12008, 7972, 4839, 2685, 848, -1277, -3622, -5578, -6627, -6777, -6470, -6142, -5915, -5619, -5061, -4229, -3320, -2561, -2050, -1726, -1469, -1221, -1009, -890, -880, -928, -956, -913, -789, -607, -393, -147, 137, 463, 817, 1170, 1490, 1761, 1979, 2142, 2247, 2291, 2268, 2183, 2043, 1863, 1652, 1422, 1181, 936, 693, 463, 250, 58, -110, -258, -383, -490, -577, -645, -700, -739, -768, -785, -794, -792, -781, -760, -736, -705, -697, -1762, -5941, -12222, -15871, -13819, -7418, -6, 5704, 8877, 10749, 13012, 15734, 17346, 16393, 13046, 8849, 5280, 2809, 931, -1083, -3407, -5557, -6915, -7291, -7030, -6624, -6314, -6009, -5493, -4681, -3714, -2832, -2194, -1778, -1471, -1189, -932, -754, -692, -716, -752, -729, -625, -461, -260, -34, 228, 528, 861, 1201, 1515, 1786, 2000, 2158, 2259, 2301, 2278, 2190, 2046, 1859, 1640, 1399, 1148, 891, 640, 397, 175, -24, -201, -353, -482, -588, -675, -741, -788, -823, -845, -855, -855, -845, -828, -802, -769, -746, -682, -1906, -7918, -18035, -25425, -24932, -17475, -6660};