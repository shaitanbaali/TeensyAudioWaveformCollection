/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0457 256 samples */
 
const int16_t AKWF_0457_256_DATA [256] = 
{8545, 15728, 18069, 18964, 19632, 20428, 21265, 21987, 22528, 22891, 23114, 23246, 23326, 23384, 23430, 23468, 23498, 23521, 23538, 23549, 23559, 23566, 23570, 23574, 23576, 23578, 23579, 23579, 23598, 23525, 23851, 26383, 28013, 28487, 28655, 28825, 29066, 29329, 29558, 29727, 29839, 29904, 29941, 29964, 29981, 29995, 30007, 30016, 30023, 30028, 30033, 30035, 30037, 30038, 30040, 30040, 30041, 30041, 30041, 30041, 30041, 30041, 30041, 30041, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30042, 30013, 29798, 31063, 13721, -10545, -18386, -22069, -24443, -26455, -28208, -29588, -30588, -31272, -31719, -32011, -32205, -32344, -32449, -32531, -32594, -32642, -32677, -32702, -32719, -32732, -32741, -32748, -32754, -32758, -32760, -32762, -32764, -32765, -32766, -32766, -32767, -32766, -32767, -32768, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32757, -32810, -32164, -31060, -30721, -30759, -30782, -30704, -30557, -30395, -30261, -30170, -30120, -30095, -30084, -30077, -30070, -30063, -30057, -30053, -30049, -30047, -30045, -30043, -30043, -30042, -30041, -30042, -30041, -30041, -30041, -30041, -30041, -30041, -30016, -30136, -29145, -26694, -25630, -25588, -25575, -25353, -24968, -24545, -24187, -23942, -23799, -23730, -23697, -23676, -23657, -23639, -23623, -23611, -23571, -23638, -23327, -16971, -10169, -8719, -8828, -8299, -6948, -5144, -3400, -2074, -1233, -783, -567, -458, -384, -306, -226, -158, -108, -72, -47, -33, -25, -15, -10, -9, -6, -5};