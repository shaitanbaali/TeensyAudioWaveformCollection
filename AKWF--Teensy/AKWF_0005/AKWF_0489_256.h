/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0489 256 samples */
 
const int16_t AKWF_0489_256_DATA [256] = 
{2692, 5013, 4538, 6347, 7952, 16175, 25322, 27274, 28559, 29683, 30192, 30538, 30758, 30880, 30952, 30987, 31002, 31005, 30995, 30974, 30943, 30903, 30860, 30816, 30781, 30762, 30764, 30792, 30845, 30914, 30986, 31048, 31082, 31049, 30839, 31592, 19671, 4563, 16821, 18723, 7529, -8896, -25558, -31490, -30341, -30954, -30572, -28900, -27371, -26621, -26273, -25834, -25492, -25803, -26898, -28310, -29557, -30475, -30996, -30832, -29510, -22616, -8275, -2502, 1498, 6127, 11021, 23469, 28930, 29093, 29982, 30348, 30376, 30305, 30034, 29496, 28529, 26821, 23755, 15466, 6367, 5812, 5119, 3767, 4237, 4541, 2836, 2055, 3716, 4815, 3997, 4235, 5850, 6972, 12555, 23800, 27970, 29004, 30255, 30789, 31007, 31088, 31059, 30992, 30932, 30901, 30911, 30956, 31019, 31072, 31077, 30991, 30765, 30346, 29669, 28648, 27141, 24999, 22125, 17649, 9534, 5751, 7415, 7429, 6899, 7582, 14847, 21682, 24031, 26231, 27967, 29077, 29865, 30401, 30742, 30943, 31045, 31083, 31082, 31066, 31051, 31047, 31052, 31066, 31081, 31081, 31053, 30980, 30849, 30649, 30372, 30018, 29598, 29128, 28639, 28179, 27802, 27563, 27501, 27624, 27910, 28247, 28632, 29547, 7323, -18558, -2135, 496, -13282, -30227, -32086, -29552, -29156, -27471, -23664, -18666, -15333, -14703, -15260, -17144, -19975, -19688, -15990, -14784, -17166, -20194, -23210, -26060, -28336, -29929, -30843, -31062, -30479, -28806, -24885, -14343, -5534, -5663, -4914, -4001, -4002, -4178, -4692, -5691, -6738, -8003, -16533, -25436, -27392, -28774, -29868, -30345, -30646, -30811, -30876, -30879, -30823, -30681, -30394, -29870, -28915, -27188, -23765, -14311, -5685, -5177, -4424, -2308, 3546, 4806, 4447, 5834, 6554, 6867, 7002, 6912, 6609, 6059, 5285, 4396, 3861, 4313, 1249, -4560, -4505, -3737, -4699, -5271, -5592, -5748, -5645, -5299, -4735, -4047, -4087, -3181};