/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0415 256 samples */
 
const int16_t AKWF_0415_256_DATA [256] = 
{1817, 4614, 6947, 8874, 10368, 11407, 11942, 11964, 11589, 10966, 10217, 9430, 8667, 7969, 7356, 6843, 6437, 6137, 5940, 5843, 5830, 5896, 6035, 6245, 6521, 6861, 7267, 7736, 8270, 8871, 9540, 10278, 11091, 11980, 12951, 14013, 15167, 16426, 17805, 19298, 20862, 22419, 23888, 25222, 26382, 27350, 28129, 28725, 29147, 29413, 29534, 29524, 29396, 29159, 28826, 28402, 27899, 27321, 26674, 25965, 25203, 24131, 24444, 19199, -16000, -10254, -8352, -7483, -6981, -6589, -6292, -6070, -5917, -5839, -5840, -5925, -6103, -6385, -6774, -7271, -7866, -8552, -9306, -10092, -10853, -11503, -11926, -11977, -11528, -10566, -9138, -7276, -5006, -2314, 750, 3671, 6155, 8230, 9884, 11092, 11812, 12010, 11759, 11211, 10494, 9710, 8934, 8209, 7564, 7016, 6570, 6231, 5998, 5866, 5825, 5864, 5978, 6162, 6414, 6732, 7114, 7560, 8072, 8649, 9286, 9775, 11836, 3951, -18105, -11440, -10645, -9430, -8664, -8030, -7499, -7055, -6676, -6365, -6125, -5952, -5852, -5827, -5886, -6037, -6292, -6652, -7119, -7686, -8348, -9087, -9868, -10643, -11335, -11835, -12007, -11707, -10887, -9588, -7848, -5691, -3122, -142, 2882, 5487, 7678, 9456, 10794, 11656, 12003, 11866, 11387, 10707, 9935, 9152, 8409, 7738, 7162, 6686, 6317, 6055, 5895, 5829, 5845, 5938, 6102, 6336, 6634, 6998, 7424, 7736, 9209, 3991, -14299, -23209, -23874, -25235, -26062, -26797, -27436, -28000, -28490, -28895, -29206, -29422, -29531, -29518, -29369, -29073, -28617, -27986, -27169, -26163, -24968, -23604, -22114, -20550, -18994, -17522, -16168, -14930, -13796, -12752, -11798, -10924, -10126, -9402, -8748, -8160, -7639, -7182, -6789, -6462, -6199, -6003, -5878, -5827, -5856, -5972, -6189, -6511, -6939, -7472, -8103, -8814, -9586, -10372, -11103, -11687, -11995, -11878, -11239, -10106, -8523, -6514, -4099, -1222};