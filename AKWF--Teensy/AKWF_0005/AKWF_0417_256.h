/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0417 256 samples */
 
const int16_t AKWF_0417_256_DATA [256] = 
{160, 584, 963, 1341, 1754, 2233, 2811, 3510, 4356, 5374, 6560, 7890, 9324, 10820, 12351, 13874, 15346, 16738, 18018, 19169, 20188, 21074, 21830, 22467, 22992, 23415, 23747, 23998, 24178, 24294, 24357, 24373, 24348, 24289, 24204, 24095, 23971, 23836, 23695, 23555, 23419, 23293, 23183, 23093, 23030, 22999, 23005, 23056, 23156, 23315, 23533, 23804, 24124, 24476, 24847, 25224, 25589, 25931, 26236, 26495, 26698, 26837, 26906, 26899, 26812, 26641, 26385, 26040, 25607, 25084, 24472, 23749, 23067, 21521, 18022, 14872, 11954, 9168, 6489, 3918, 1454, -918, -3196, -5379, -7482, -9504, -11444, -13322, -15135, -16887, -18593, -20249, -21859, -23429, -24948, -26408, -27792, -29069, -30205, -31168, -31927, -32456, -32732, -32734, -32450, -31901, -31131, -30176, -29076, -27873, -26604, -25314, -24039, -22796, -21601, -20463, -19373, -18333, -17339, -16380, -15451, -14547, -13658, -12782, -11913, -11044, -10173, -9299, -8416, -7524, -6618, -5696, -4758, -3800, -2822, -1830, -750, -538, -1501, -2105, -2586, -2973, -3286, -3536, -3732, -3883, -3993, -4069, -4118, -4144, -4154, -4155, -4152, -4152, -4163, -4192, -4245, -4330, -4451, -4612, -4815, -5055, -5325, -5609, -5879, -6102, -6241, -6266, -6148, -5861, -5386, -4699, -3812, -2765, -1593, -333, 973, 2294, 3585, 4809, 5947, 6984, 7914, 8741, 9467, 10102, 10654, 11131, 11543, 11899, 12207, 12475, 12711, 12919, 13106, 13277, 13436, 13589, 13739, 13885, 14069, 13677, 12070, 9934, 7773, 5591, 3407, 1239, -897, -3004, -5067, -7071, -9019, -10897, -12688, -14395, -16000, -17491, -18864, -20103, -21196, -22136, -22908, -23508, -23931, -24177, -24253, -24172, -23947, -23592, -23119, -22543, -21870, -21111, -20281, -19384, -18432, -17435, -16396, -15327, -14239, -13132, -12018, -10907, -9800, -8709, -7642, -6603, -5603, -4652, -3754, -2918, -2153, -1460, -845, -298};