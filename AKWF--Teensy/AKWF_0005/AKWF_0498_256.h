/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0498 256 samples */
 
const int16_t AKWF_0498_256_DATA [256] = 
{13367, 13370, 13372, 13372, 13372, 13373, 13372, 13372, 13372, 13370, 13369, 13367, 13365, 13363, 13362, 13360, 13357, 13355, 13353, 13350, 13347, 13343, 13341, 13339, 13335, 13333, 13330, 13327, 13323, 13319, 13316, 13313, 13310, 13307, 13304, 13300, 13296, 13293, 13290, 13286, 13283, 13280, 13276, 13272, 13269, 13266, 13262, 13259, 13256, 13251, 13248, 13245, 13241, 13238, 13235, 13230, 13227, 13224, 13220, 13217, 13214, 13209, 13206, 13203, 13199, 13196, 13192, 13188, 13185, 13181, 13178, 13175, 13171, 13168, 13164, 13160, 13156, 13153, 13150, 13146, 13143, 13139, 13135, 13132, 13129, 13125, 13122, 13118, 13114, 13111, 13108, 13104, 13101, 13097, 13093, 13090, 13086, 13083, 13080, 13075, 13072, 13069, 13065, 13062, 13059, 13055, 13051, 13048, 13044, 13041, 13038, 13034, 13030, 13026, 13023, 13020, 13016, 13014, 13009, 13005, 13002, 12999, 12995, 12992, 12989, 12985, 12981, 12978, 12974, 12971, 12967, 12964, 12960, 12957, 12953, 12950, 12947, 12944, 12940, 12936, 12932, 12923, 12734, 13861, -4931, -11073, -9701, -9948, -9950, -9950, -9951, -9953, -9952, -9953, -9951, -9950, -9951, -9949, -9948, -9946, -9945, -9943, -9942, -9940, -9939, -9937, -9935, -9933, -9931, -9929, -9927, -9924, -9921, -9920, -9918, -9915, -10277, -8290, -24905, -34320, -32413, -32758, -32753, -32748, -32743, -32738, -32732, -32726, -32719, -32712, -32706, -32698, -32692, -32685, -32677, -32670, -32662, -32654, -32647, -32639, -32630, -32622, -32614, -32606, -32598, -32590, -32581, -32574, -32564, -32556, -32548, -32187, -34106, -17226, -8136, -9984, -9640, -9633, -9626, -9622, -9615, -9610, -9604, -9600, -9595, -9592, -9587, -9582, -9579, -9575, -9572, -9568, -9564, -9560, -9557, -9554, -9551, -9548, -9545, -9541, -9538, -9536, -9532, -9530, -9527, -9524, -9522, -9519, -9515, -9513, -9510, -9508, -9505, -9502, -9500, -9497};