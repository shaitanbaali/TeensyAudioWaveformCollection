/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0452 256 samples */
 
const int16_t AKWF_0452_256_DATA [256] = 
{-7777, -23601, -30033, -32492, -32510, -30856, -28722, -26954, -25369, -23429, -20789, -17364, -13378, -9290, -5633, -2772, -717, 683, 1599, 2200, 2613, 2902, 3111, 3258, 3357, 3422, 3469, 3506, 3535, 3558, 3575, 3585, 3590, 3594, 3597, 3600, 3602, 3603, 3603, 3604, 3606, 3606, 3606, 3606, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3607, 3605, 3602, 3599, 3597, 3596, 3596, 3594, 3593, 3594, 3594, 3594, 3594, 3594, 3594, 3591, 3587, 3585, 3583, 3583, 3581, 3581, 3581, 3580, 3580, 3580, 3580, 3580, 3580, 3580, 3580, 3580, 3580, 3580, 3579, 3576, 3572, 3570, 3569, 3569, 3568, 3567, 3567, 3566, 3563, 3559, 3557, 3556, 3556, 3554, 3554, 3554, 3554, 3553, 3553, 3553, 3553, 3553, 3553, 3553, 3553, 3552, 3550, 3546, 3544, 3543, 3541, 3541, 3540, 3540, 3540, 3540, 3540, 3540, 3539, 3536, 3533, 3530, 3529, 3528, 3527, 3527, 3527, 3527, 3527, 3526, 3525, 3525, 3525, 3525, 3525, 3525, 3524, 3522, 3518, 3517, 3515, 3514, 3514, 3514, 3513, 3513, 3513, 3513, 3513, 3513, 3512, 3509, 3505, 3503, 3502, 3501, 3500, 3500, 3500, 3500, 3500, 3500, 3500, 3499, 3498, 3495, 3491, 3490, 3488, 3487, 3487, 3487, 3486, 3485, 3485, 3485, 3485, 3485, 3485, 3485, 3485, 3485, 3485, 3485, 3484, 3480, 3477, 3475, 3474, 3474, 3472, 3471, 3472, 3472, 3472, 3472, 3469, 3465, 3463, 3461, 3461, 3459, 3459, 3459, 3458, 3458, 3458, 3458, 3458, 3458, 3458, 3458, 3456, 3452, 3449, 3448, 3447, 3447, 3446, 3444, 3445, 3445, 3445, 3445, 3445, 3444, 3439, 3436, 3434, 3434, 3433, 3431, 3432, 3431, 3431, 3431, 3431, 3431, 3431, 3431, 3431, 3431};