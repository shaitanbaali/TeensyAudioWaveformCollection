/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0421 256 samples */
 
const int16_t AKWF_0421_256_DATA [256] = 
{308, 607, 738, 786, 793, 779, 759, 740, 724, 712, 704, 698, 695, 693, 692, 692, 692, 692, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 693, 692, 692, 691, 692, 692, 692, 692, 692, 691, 690, 689, 690, 690, 690, 690, 690, 689, 688, 689, 689, 689, 689, 688, 687, 688, 688, 688, 688, 688, 687, 686, 687, 687, 687, 687, 687, 686, 685, 686, 686, 686, 686, 686, 684, 683, 684, 684, 684, 684, 683, 682, 683, 683, 683, 683, 682, 681, 682, 682, 682, 682, 682, 681, 680, 681, 681, 681, 681, 680, 679, 680, 680, 680, 680, 680, 679, 678, 679, 679, 678, 679, 678, 676, 677, 677, 677, 677, 676, 676, 676, 676, 676, 676, 676, 676, 675, 674, 675, 675, 675, 675, 674, 673, 674, 674, 674, 674, 674, 673, 672, 673, 673, 672, 673, 671, 670, 671, 671, 671, 671, 670, 670, 670, 670, 670, 670, 670, 669, 668, 669, 669, 669, 669, 669, 668, 668, 668, 668, 668, 668, 667, 667, 667, 667, 667, 667, 666, 667, 666, 664, 665, 665, 665, 665, 664, 663, 664, 664, 664, 664, 663, 662, 663, 663, 663, 663, 663, 662, 661, 662, 662, 662, 662, 662, 661, 660, 661, 661, 661, 661, 660, 659, 658, 659, 659, 659, 659, 659, 658, 657, 658, 658, 658, 658, 657, 656, 657, 657, 657, 657, 657, 656, 655, 656, 656, 441, 1427, -3818, -25187, -33041, -30627, -24880, -18467, -12749, -8225, -4913, -2624, -1135, -212};