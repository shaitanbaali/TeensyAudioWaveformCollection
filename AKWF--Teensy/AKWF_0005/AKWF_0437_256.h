/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0437 256 samples */
 
const int16_t AKWF_0437_256_DATA [256] = 
{497, 1617, 2715, 3805, 4880, 5945, 6999, 8035, 9060, 10070, 11062, 12040, 13001, 13942, 14868, 15775, 16661, 17531, 18379, 19205, 20013, 20797, 21558, 22301, 23018, 23711, 24382, 25028, 25649, 26246, 26817, 27362, 27882, 28375, 28841, 29281, 29694, 30078, 30436, 30766, 31067, 31341, 31585, 31802, 31990, 32149, 32279, 32381, 32452, 32495, 32510, 32495, 32450, 32377, 32274, 32144, 31984, 31796, 31578, 31331, 31057, 30754, 30424, 30065, 29679, 29266, 28826, 28357, 27864, 27344, 26797, 26225, 25628, 25005, 24358, 23688, 22992, 22275, 21533, 20768, 19985, 19177, 18348, 17501, 16631, 15742, 14836, 13909, 12966, 12006, 11027, 10033, 9025, 7998, 6960, 5909, 4842, 3765, 2676, 1573, 463, -710, -2115, -3823, -5838, -8170, -10821, -13804, -17094, -20621, -24253, -27582, -29909, -27586, -1991, 29450, 31555, 26820, 24254, 20555, 16939, 13705, 10723, 8077, 5762, 3756, 2060, 655, -516, -1611, -2714, -3806, -4881, -5946, -7000, -8036, -9061, -10071, -11062, -12041, -13001, -13943, -14868, -15776, -16661, -17531, -18380, -19205, -20014, -20798, -21558, -22301, -23018, -23711, -24383, -25028, -25649, -26246, -26817, -27362, -27882, -28375, -28841, -29282, -29694, -30078, -30436, -30766, -31068, -31341, -31585, -31802, -31990, -32149, -32279, -32381, -32452, -32495, -32510, -32495, -32450, -32377, -32274, -32144, -31984, -31796, -31578, -31331, -31057, -30754, -30424, -30066, -29679, -29266, -28826, -28357, -27864, -27344, -26797, -26225, -25628, -25005, -24359, -23688, -22992, -22275, -21534, -20769, -19985, -19177, -18348, -17502, -16632, -15743, -14837, -13910, -12966, -12007, -11027, -10034, -9026, -7999, -6961, -5910, -4843, -3766, -2677, -1574, -464, 709, 2115, 3822, 5837, 8169, 10821, 13803, 17093, 20620, 24252, 27582, 29909, 27584, 1965, -29457, -31550, -26821, -24254, -20555, -16940, -13705, -10723, -8077, -5763, -3759, -2065, -642};