/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0441 256 samples */
 
const int16_t AKWF_0441_256_DATA [256] = 
{1965, 4471, 6529, 8287, 9790, 11099, 12240, 13274, 14240, 10651, 7731, 8367, 8501, 9088, 9808, 10428, 11055, 12372, 13229, 14312, 15465, 16367, 17099, 17627, 18014, 18330, 18616, 18791, 18806, 19147, 16464, 11406, 10903, 10731, 10732, 11064, 11233, 11577, 12044, 12585, 13270, 14230, 15158, 15689, 15880, 16237, 16714, 17253, 17829, 18428, 19345, 18968, 14001, 12642, 13177, 13267, 13823, 14342, 14884, 15495, 16166, 16971, 18200, 19611, 20666, 21538, 22313, 23014, 23663, 24286, 24870, 25452, 26053, 22164, 19001, 19433, 19410, 19793, 21028, 22695, 23773, 24566, 25231, 25957, 26740, 27351, 27842, 28191, 28434, 28618, 28773, 28820, 28716, 28943, 26151, 20987, 20379, 20103, 20002, 20230, 20295, 20535, 20898, 21334, 21914, 22771, 23596, 24025, 24115, 24373, 24751, 25194, 25676, 26183, 27011, 26546, 21497, 20055, 20455, 20533, 20360, 14837, 12358, 9292, 6574, 3753, 923, -1210, -3784, -5706, -7380, -8752, -9865, -10753, -11450, -11941, -12242, -16894, -20706, -20831, -21347, -21313, -21076, -20876, -20522, -22238, -22563, -23073, -23427, -23636, -23757, -23790, -23790, -23788, -23782, -23850, -24033, -23849, -26652, -31803, -32381, -32610, -32684, -32295, -31464, -31018, -30178, -29384, -28502, -27409, -26410, -25838, -25616, -25231, -24732, -24178, -23592, -22991, -22073, -22452, -27419, -28781, -28246, -28155, -27596, -27076, -26529, -25913, -25236, -24424, -23186, -21767, -20700, -19816, -19028, -18314, -17651, -17012, -16410, -15811, -15192, -19061, -22204, -21752, -21765, -21297, -20675, -20136, -19552, -18967, -18380, -17669, -16867, -16218, -15674, -15262, -14949, -14686, -14448, -14310, -14323, -13998, -16689, -21749, -22249, -22416, -22406, -22063, -21886, -21530, -21050, -20497, -19799, -18827, -17885, -17339, -17135, -16762, -16271, -15718, -15126, -14512, -13580, -13942, -18893, -20237, -19634, -19309, -18359, -17395, -16042, -13921, -11184, -8032, -4475, -877};