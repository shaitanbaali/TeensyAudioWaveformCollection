/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0500 256 samples */
 
const int16_t AKWF_0500_256_DATA [256] = 
{32759, 32762, 32765, 32767, 32767, 32768, 32767, 32765, 32763, 32760, 32757, 32753, 32749, 32744, 32739, 32734, 32728, 32722, 32716, 32709, 32702, 32696, 32688, 32681, 32675, 32666, 32658, 32652, 32644, 32635, 32627, 32619, 32611, 32603, 32595, 32587, 32579, 32570, 32562, 32554, 32544, 32536, 32528, 32520, 32512, 32502, 32493, 32485, 32478, 32468, 32459, 32451, 32443, 32434, 32425, 32417, 32409, 32399, 32391, 32383, 32373, 32364, 32356, 32348, 32338, 32330, 32322, 32312, 32304, 32296, 32287, 32278, 32270, 32261, 32252, 32244, 32236, 32226, 32217, 32209, 32200, 32191, 32183, 32175, 32166, 32157, 32149, 32141, 32131, 32123, 32115, 32106, 32097, 32089, 32080, 32071, 32062, 32054, 32046, 32036, 32025, 32197, 30581, 9950, 15042, -8783, -3832, 25533, 22367, -26574, -28530, 9050, 37975, 21548, -9720, -8193, 14615, -22377, -25546, -24859, -24968, -24967, -24967, -24965, -24964, -24962, -24959, -24955, -24953, -24949, -24945, -24941, -24937, -24932, -24927, -24922, -24917, -24912, -24906, -24901, -24895, -24890, -24884, -24878, -24872, -24866, -24859, -24853, -24847, -24841, -24835, -24829, -24822, -24815, -24810, -24803, -24796, -24791, -24784, -24777, -24771, -24764, -24758, -24751, -24745, -24738, -24732, -24725, -24718, -24712, -24705, -24699, -24692, -24686, -24679, -24673, -24666, -24660, -24653, -24646, -24640, -24633, -24626, -24619, -24613, -24607, -24600, -24594, -24587, -24581, -24574, -24567, -24560, -24554, -24547, -24541, -24534, -24528, -24521, -24515, -24508, -24502, -24495, -24488, -24482, -24475, -24469, -24462, -24456, -24449, -24442, -24436, -24429, -24422, -24417, -24409, -24403, -24396, -24390, -24383, -24377, -24370, -24364, -24357, -24351, -24344, -24338, -24331, -24325, -24318, -24312, -24305, -24299, -24292, -24285, -24279, -24272, -24266, -24259, -24253, -24247, -24240, -24234, -24227, -24220, -24214, -24207, -24201, -24194, -24188, -23969, -26001, -16795, -3837, -24176, 83};