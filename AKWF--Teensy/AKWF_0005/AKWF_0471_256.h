/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0471 256 samples */
 
const int16_t AKWF_0471_256_DATA [256] = 
{4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4696, 4745, 4490, 5480, 13768, 14184, 14059, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14088, 14106, 14056, 14146, 22245, 23653, 23308, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23371, 23361, 22842, 25901, -19803, -35656, -32142, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32763, -32709, -33071, -25216, -22950, -23466, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23374, -23237, -23994, -17042, -13490, -14224, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -14090, -13919, -14837, -8943, -3969, -4867, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699, -4699};