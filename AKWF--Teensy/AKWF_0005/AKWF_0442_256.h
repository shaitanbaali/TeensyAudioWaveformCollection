/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0442 256 samples */
 
const int16_t AKWF_0442_256_DATA [256] = 
{1327, 3724, 5678, 7219, 8756, 10015, 11105, 12387, 12493, 9650, 9858, 9893, 8063, 9242, 8752, 8755, 9228, 9278, 9384, 9574, 9499, 9238, 8761, 8057, 7218, 6325, 5329, 4016, 2582, 818, -4531, -8152, -9337, -10658, -11413, -12293, -13109, -13647, -14036, -14283, -14263, -13991, -13867, -14670, -15621, -16261, -16793, -17230, -17550, -17685, -17462, -20225, -24168, -24719, -25374, -26040, -26647, -27287, -27832, -28354, -28789, -28995, -28565, -28200, -28215, -28224, -28197, -28166, -28135, -28103, -28110, -27880, -28537, -32049, -32691, -32364, -32433, -31503, -23896, -17454, -14707, -13237, -12318, -11686, -11421, -11398, -11624, -12080, -12657, -13257, -13925, -14856, -15865, -17021, -21707, -24813, -25173, -25596, -25351, -25103, -23923, -23685, -22835, -21366, -19582, -17456, -15378, -14092, -12816, -11098, -9109, -6878, -4371, -1517, 1855, 2406, 1897, 5115, 9683, 14711, 13202, 7613, 7458, 5150, 4162, 2301, 251, -1641, -3029, -3772, -3834, -3334, -2373, -1342, 1489, -3319, -17684, 1270, 5554, 16531, 15272, 9628, 8538, 11462, 15740, 20746, 21485, 22560, 23106, 23290, 23775, 24057, 24190, 24247, 24221, 23917, 23532, 22809, 19040, 16374, 16324, 16303, 16802, 17152, 17527, 18158, 18894, 19730, 20779, 22025, 23061, 23107, 22953, 23043, 23193, 23381, 23636, 24033, 24755, 22455, 18951, 18824, 18600, 18202, 17897, 17639, 17449, 17289, 17224, 17406, 18252, 19048, 19490, 19961, 20474, 21005, 21543, 22079, 22571, 23287, 22874, 19578, 19172, 19615, 19529, 19746, 19810, 19776, 19711, 19624, 19477, 19246, 18935, 18385, 17580, 16541, 15376, 14163, 12865, 11270, 9574, 7508, 2136, -1636, -3040, -4430, -5239, -6063, -7439, -8073, -7735, -8014, -7917, -7485, -7135, -7655, -8283, -8569, -8713, -8739, -8620, -8297, -7589, -9871, -13269, -13447, -15093, -15916, -16528, -16994, -16277, -14356, -11503, -8154, -4653, -1323};