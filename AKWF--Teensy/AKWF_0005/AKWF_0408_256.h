/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0408 256 samples */
 
const int16_t AKWF_0408_256_DATA [256] = 
{474, 1523, 2480, 3345, 4092, 4709, 5183, 5513, 5698, 5750, 5678, 5501, 5238, 4911, 4545, 4158, 3776, 3415, 3094, 2826, 2620, 2482, 2417, 2423, 2496, 2631, 2821, 3056, 3328, 3627, 3945, 4273, 4607, 4939, 5266, 5587, 5899, 6201, 6495, 6780, 7057, 7327, 7587, 7838, 8078, 8302, 8509, 8694, 8852, 8980, 9073, 9128, 9143, 9116, 9048, 8941, 8798, 8626, 8429, 8217, 7999, 7784, 7583, 7405, 7258, 7151, 7090, 7079, 7121, 7216, 7364, 7557, 7793, 8062, 8355, 8664, 8976, 9282, 9572, 9835, 10063, 10250, 10391, 10484, 10526, 10518, 10463, 10365, 10230, 10064, 9875, 9670, 9458, 9246, 9041, 8849, 8674, 8522, 8395, 8293, 8219, 8169, 8144, 8141, 8157, 8187, 8230, 8281, 8336, 8394, 8451, 8505, 8554, 8597, 8633, 8662, 8683, 8695, 8699, 8694, 8682, 8662, 8632, 8594, 8545, 8487, 8418, 8339, 8246, 8144, 8030, 7906, 7773, 7631, 7483, 7332, 7179, 7026, 6877, 6734, 6601, 6479, 6370, 6277, 6200, 6139, 6094, 6065, 6050, 6048, 6053, 6067, 6083, 6100, 6113, 6102, 6158, 5808, 3109, -423, -4075, -7886, -11750, -15571, -19225, -22617, -25647, -28213, -30253, -31709, -32547, -32761, -32365, -31403, -29928, -28024, -25787, -23309, -20704, -18085, -15542, -13178, -11076, -9292, -7881, -6870, -6266, -6062, -6232, -6736, -7521, -8527, -9692, -10944, -12223, -13471, -14630, -15662, -16532, -17218, -17710, -18006, -18115, -18051, -17837, -17496, -17052, -16534, -15963, -15359, -14740, -14116, -13493, -12871, -12253, -11629, -10993, -10341, -9663, -8955, -8218, -7450, -6662, -5859, -5058, -4278, -3538, -2858, -2262, -1770, -1399, -1164, -1073, -1129, -1330, -1667, -2122, -2673, -3296, -3957, -4623, -5261, -5836, -6314, -6672, -6883, -6929, -6801, -6497, -6020, -5382, -4601, -3700, -2711, -1663, -567};