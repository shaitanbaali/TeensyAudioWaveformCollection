/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0425 256 samples */
 
const int16_t AKWF_0425_256_DATA [256] = 
{2321, 10179, 16534, 21688, 25717, 28740, 30868, 32178, 32739, 32585, 31722, 30126, 27756, 24572, 20507, 15539, 9709, 3025, -3929, -9855, -14574, -18184, -20757, -22384, -23116, -22993, -22029, -20219, -17545, -13979, -9539, -4237, 1745, 7399, 12203, 16145, 19191, 21366, 22688, 23167, 22800, 21558, 19396, 16234, 11991, 6604, -31, -6980, -13168, -18515, -22961, -26508, -29221, -31138, -32306, -32761, -32505, -31518, -29746, -27116, -23528, -18851, -13005, -5863, 2423, 10149, 16520, 21688, 25717, 28740, 30868, 32178, 32739, 32585, 31722, 30126, 27756, 24572, 20507, 15539, 9709, 3025, -3929, -9855, -14574, -18184, -20757, -22384, -23116, -22993, -22029, -20219, -17545, -13979, -9539, -4237, 1745, 7399, 12203, 16145, 19191, 21366, 22688, 23167, 22800, 21558, 19396, 16234, 11991, 6604, -31, -6980, -13168, -18515, -22961, -26508, -29221, -31138, -32306, -32761, -32505, -31518, -29746, -27115, -23528, -18851, -13005, -5863, 2423, 10149, 16520, 21688, 25717, 28740, 30868, 32178, 32739, 32585, 31722, 30126, 27756, 24572, 20507, 15539, 9709, 3024, -3929, -9855, -14574, -18184, -20757, -22384, -23116, -22993, -22029, -20219, -17545, -13979, -9539, -4237, 1745, 7399, 12203, 16145, 19191, 21366, 22688, 23167, 22800, 21558, 19396, 16234, 11991, 6604, -31, -6980, -13168, -18515, -22961, -26508, -29221, -31138, -32306, -32761, -32505, -31518, -29746, -27115, -23528, -18851, -13005, -5863, 2423, 10149, 16520, 21688, 25717, 28740, 30868, 32178, 32739, 32585, 31722, 30126, 27756, 24572, 20507, 15539, 9709, 3024, -3929, -9855, -14574, -18184, -20757, -22384, -23116, -22993, -22029, -20219, -17545, -13979, -9539, -4237, 1745, 7399, 12203, 16145, 19191, 21366, 22688, 23167, 22800, 21558, 19396, 16234, 11991, 6604, -31, -6980, -13168, -18516, -22961, -26508, -29221, -31138, -32306, -32761, -32505, -31518, -29746, -27115, -23528, -18866, -13041, -5740};