/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0477 256 samples */
 
const int16_t AKWF_0477_256_DATA [256] = 
{1487, 4181, 6801, 9405, 11970, 14499, 16973, 19375, 21708, 23961, 26119, 28183, 30133, 32034, 32822, 32749, 32765, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32766, 32752, 32810, 32437, 31005, 29418, 27729, 25941, 24052, 22073, 20015, 17878, 15669, 13413, 11098, 8744, 6360, 3950, 1518, -910, -3330, -5776, -7931, -9419, -10989, -12869, -14753, -16459, -17947, -19284, -20536, -21767, -22986, -24175, -25311, -26367, -27321, -28175, -28925, -29565, -30066, -30558, -30574, -23349, -14307, -11647, -11569, -10880, -9123, -6751, -4443, -2675, -1549, -940, -642, -487, -387, -293, -206, -134, -84, -50, -29, -17, -11, -6, -3, -2, 9, -24, 188, 1444, 3145, 4829, 6540, 8380, 10338, 12319, 14256, 16093, 17806, 19407, 20905, 22304, 23617, 24836, 25956, 26974, 27884, 28685, 29376, 29951, 30413, 30758, 30986, 31097, 31089, 30965, 30743, 30305, 30193, 32289, 32840, 32768, 32613, 31643, 30524, 29312, 27928, 26370, 24638, 22762, 20773, 18691, 16526, 14300, 12013, 9681, 7313, 4912, 2491, 61, -2368, -4791, -7190, -9570, -11908, -14206, -16451, -18630, -20736, -22771, -24715, -26570, -28327, -29961, -31540, -32685, -32779, -32761, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32758, -32795, -31920, -30357, -28749, -27021, -25194, -23272, -21257, -19170, -17004, -14772, -12494, -10164, -7793, -5400, -2981, -550, 1811, 4536, 3367, -2516, -6764, -9962, -12903, -15907, -18966, -21929, -24697, -27222, -29483, -31637, -32809, -32753, -32765, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32765, -32758, -32796, -31772, -29845, -27884, -25807, -23634, -21369, -19023, -16607, -14127, -11594, -9024, -6415, -3791, -1094};