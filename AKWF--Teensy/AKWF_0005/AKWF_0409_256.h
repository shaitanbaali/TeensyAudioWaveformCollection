/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0409 256 samples */
 
const int16_t AKWF_0409_256_DATA [256] = 
{373, 1259, 2131, 2996, 3833, 4628, 5365, 6023, 6590, 7051, 7395, 7614, 7704, 7666, 7504, 7227, 6846, 6377, 5837, 5247, 4624, 3992, 3370, 2774, 2222, 1728, 1302, 951, 680, 490, 381, 347, 385, 485, 642, 846, 1089, 1365, 1667, 1990, 2332, 2689, 3060, 3447, 3849, 4268, 4705, 5163, 5639, 6135, 6648, 7175, 7712, 8253, 8790, 9316, 9822, 10296, 10733, 11120, 11451, 11720, 11920, 12048, 12103, 12083, 11994, 11837, 11620, 11350, 11034, 10685, 10310, 9921, 9528, 9138, 8760, 8403, 8071, 7769, 7501, 7268, 7071, 6909, 6783, 6689, 6625, 6589, 6580, 6594, 6629, 6686, 6762, 6856, 6969, 7100, 7250, 7419, 7605, 7809, 8031, 8267, 8518, 8778, 9045, 9316, 9584, 9846, 10095, 10328, 10538, 10720, 10871, 10984, 11060, 11096, 11090, 11042, 10954, 10826, 10664, 10469, 10246, 10000, 9737, 9458, 9171, 8881, 8591, 8305, 8027, 7758, 7504, 7263, 7038, 6829, 6638, 6462, 6304, 6162, 6036, 5927, 5833, 5756, 5694, 5647, 5617, 5603, 5603, 5620, 5653, 5700, 5761, 5834, 5918, 6010, 6109, 6212, 6315, 6417, 6514, 6601, 6678, 6741, 6768, 6861, 6467, 3758, 378, -3055, -6591, -10157, -13677, -17063, -20259, -23188, -25782, -28005, -29815, -31191, -32132, -32648, -32762, -32513, -31947, -31117, -30076, -28888, -27606, -26277, -24951, -23660, -22426, -21270, -20193, -19191, -18257, -17371, -16512, -15660, -14791, -13888, -12938, -11931, -10865, -9753, -8599, -7429, -6272, -5152, -4105, -3168, -2369, -1739, -1306, -1084, -1085, -1313, -1760, -2412, -3246, -4235, -5339, -6522, -7745, -8961, -10133, -11227, -12204, -13041, -13718, -14220, -14543, -14686, -14657, -14468, -14137, -13684, -13130, -12497, -11808, -11080, -10331, -9575, -8821, -8074, -7338, -6608, -5885, -5162, -4429, -3683, -2919, -2130, -1318, -463};