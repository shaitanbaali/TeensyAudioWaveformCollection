/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0495 256 samples */
 
const int16_t AKWF_0495_256_DATA [256] = 
{505, 804, 560, 610, 599, 571, 557, 541, 525, 509, 493, 477, 462, 448, 435, 421, 408, 395, 383, 371, 359, 347, 337, 323, 316, 304, 295, 286, 274, 268, 257, 249, 241, 232, 225, 218, 209, 202, 196, 187, 183, 176, 169, 163, 158, 151, 148, 144, 140, 142, 38, 1774, 58, -1347, 432, 73, 39, 114, 90, 91, 92, 89, 88, 85, 85, 84, 82, 82, 80, 77, 78, 77, 75, 74, 73, 71, 71, 69, 68, 67, 68, 64, 65, 65, 63, 61, 61, 60, 59, 58, 58, 57, 57, 54, 55, 53, 53, 53, 49, 49, 49, 46, 41, 27, -5, -174, 77, -2323, -23446, -19372, 2776, 2823, 1077, 1938, 1813, 1715, 1707, 1651, 1602, 1554, 1507, 1464, 1420, 1377, 1336, 1295, 1258, 1220, 1184, 1147, 1114, 1079, 1047, 1014, 985, 956, 925, 897, 870, 843, 817, 792, 768, 743, 719, 696, 674, 651, 629, 610, 588, 568, 545, 528, 507, 487, 466, 446, 425, 406, 386, 365, 346, 323, 304, 282, 263, 240, 221, 204, 186, 179, 184, 209, 251, 294, 322, 323, 292, 144, -92, 21, 271, 303, 277, 244, 190, 134, 91, 74, 71, 78, 86, 98, 107, 116, 126, 133, 140, 146, 150, 154, 159, 162, 163, 164, 165, 166, 165, 163, 164, 162, 159, 158, 154, 154, 149, 148, 146, 143, 139, 137, 136, 133, 129, 127, 126, 123, 119, 118, 115, 115, 109, 109, 106, 104, 101, 100, 99, 96, 95, 92, 90, 90, 84, 80, 65, 42, -14, -300, 594, -8896, -31735, -8128, 5186, -582};