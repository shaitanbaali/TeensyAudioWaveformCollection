/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0456 256 samples */
 
const int16_t AKWF_0456_256_DATA [256] = 
{787, 2064, 2094, 2761, 3242, 2174, 2710, 5550, 7988, 9844, 11529, 13139, 14703, 16201, 17614, 18916, 20098, 21173, 22146, 23026, 23827, 24558, 25223, 25833, 26391, 26902, 27372, 27804, 28201, 28569, 28908, 29221, 29511, 29780, 30029, 30261, 30476, 30676, 30862, 31035, 31197, 31345, 31484, 31613, 31733, 31844, 31947, 32043, 32131, 32212, 32286, 32355, 32418, 32474, 32525, 32571, 32612, 32648, 32679, 32704, 32726, 32744, 32756, 32764, 32767, 32767, 32763, 32754, 32740, 32722, 32700, 32672, 32640, 32604, 32562, 32515, 32463, 32406, 32343, 32275, 32199, 32118, 32030, 31936, 31833, 31722, 31604, 31475, 31339, 31192, 31033, 30863, 30681, 30484, 30273, 30047, 29802, 29540, 29257, 28950, 28621, 28264, 27877, 27457, 26999, 26501, 25958, 25363, 24710, 23992, 23199, 22321, 21347, 20259, 19041, 17672, 16117, 14366, 12317, 9407, 7402, 7799, 7822, 6692, 6186, 5277, 3516, 1205, -800, -2020, -2059, -2730, -3211, -2141, -2676, -5520, -7961, -9821, -11508, -13119, -14685, -16186, -17599, -18904, -20087, -21163, -22136, -23017, -23819, -24550, -25216, -25827, -26385, -26897, -27367, -27799, -28197, -28565, -28904, -29218, -29508, -29777, -30026, -30258, -30473, -30674, -30860, -31032, -31193, -31343, -31481, -31611, -31731, -31842, -31945, -32041, -32129, -32210, -32284, -32353, -32415, -32473, -32523, -32569, -32610, -32645, -32676, -32703, -32724, -32741, -32754, -32762, -32766, -32766, -32761, -32752, -32738, -32720, -32698, -32671, -32638, -32601, -32561, -32513, -32461, -32404, -32341, -32272, -32198, -32116, -32029, -31933, -31831, -31720, -31601, -31473, -31337, -31189, -31031, -30860, -30678, -30481, -30271, -30044, -29799, -29537, -29254, -28947, -28617, -28259, -27872, -27452, -26994, -26495, -25952, -25356, -24702, -23985, -23191, -22312, -21338, -20248, -19028, -17658, -16102, -14347, -12297, -9383, -7375, -7772, -7796, -6667, -6159, -5253, -3495, -1141};