/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0423 256 samples */
 
const int16_t AKWF_0423_256_DATA [256] = 
{-25887, -25799, -11521, -5556, -2521, -1052, -347, -14, 144, 221, 258, 276, 284, 289, 291, 292, 293, 294, 294, 294, 295, 296, 296, 296, 296, 296, 295, 296, 296, 295, 296, 296, 296, 296, 296, 296, 296, 296, 296, 296, 296, 295, 296, 296, 296, 296, 296, 296, 296, 296, 296, 296, 296, 296, 295, 296, 295, 295, 295, 295, 294, 295, 295, 295, 295, 295, 295, 294, 295, 294, 294, 294, 294, 293, 294, 294, 294, 294, 294, 294, 294, 294, 293, 294, 293, 293, 293, 292, 293, 293, 293, 293, 293, 293, 292, 293, 292, 292, 292, 292, 291, 292, 292, 292, 292, 292, 292, 291, 292, 291, 291, 291, 291, 290, 291, 291, 291, 291, 291, 291, 291, 291, 290, 291, 290, 290, 290, 289, 290, 290, 290, 290, 290, 290, 289, 290, 289, 289, 289, 289, 288, 289, 289, 289, 289, 289, 289, 289, 289, 288, 289, 288, 288, 288, 287, 288, 288, 288, 288, 288, 288, 288, 287, 288, 287, 286, 286, 286, 286, 285, 286, 286, 286, 286, 285, 286, 285, 285, 285, 285, 285, 284, 285, 285, 285, 285, 285, 285, 285, 285, 285, 284, 284, 284, 284, 284, 283, 284, 284, 284, 284, 284, 284, 284, 283, 283, 283, 283, 283, 282, 283, 283, 283, 283, 283, 283, 283, 283, 283, 283, 282, 282, 282, 281, 282, 282, 282, 282, 282, 282, 282, 281, 281, 281, 281, 281, 281, 281, 280, 281, 281, 281, 281, 281, 281, 280, 280, 280, 280, 279, 280, 280, 280, 280, 280, 280};