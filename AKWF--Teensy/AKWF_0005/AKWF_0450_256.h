/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0450 256 samples */
 
const int16_t AKWF_0450_256_DATA [256] = 
{3486, 8351, 12194, 15371, 17986, 20139, 21913, 23375, 24592, 25608, 26460, 27180, 27793, 28316, 28766, 29154, 29490, 29784, 30041, 30265, 30465, 30643, 30802, 30944, 31072, 31188, 31294, 31390, 31479, 31560, 31636, 31705, 31771, 31832, 31889, 31942, 31993, 32040, 32087, 32130, 32171, 32210, 32247, 32284, 32320, 32353, 32386, 32417, 32447, 32476, 32505, 32532, 32559, 32585, 32611, 32636, 32661, 32684, 32707, 32721, 32784, 32570, 31679, 31209, 31185, 31228, 31210, 31132, 31035, 30954, 30901, 30881, 30883, 30897, 30916, 30936, 30955, 30975, 30994, 31013, 31032, 31050, 31068, 31085, 31102, 31116, 31129, 31142, 31152, 31160, 31167, 31171, 31174, 31174, 31171, 31165, 31156, 31142, 31125, 31103, 31076, 31043, 31003, 30956, 30901, 30836, 30760, 30672, 30569, 30450, 30311, 30151, 29965, 29748, 29495, 29200, 28854, 28448, 27972, 27409, 26741, 25947, 24995, 23755, 22789, 18757, 5635, -4140, -8981, -12514, -15724, -18580, -20954, -22846, -24328, -25486, -26410, -27160, -27780, -28300, -28740, -29113, -29432, -29701, -29931, -30126, -30294, -30436, -30558, -30663, -30752, -30829, -30895, -30951, -30998, -31037, -31069, -31096, -31118, -31134, -31146, -31155, -31161, -31164, -31164, -31162, -31157, -31149, -31140, -31129, -31116, -31102, -31087, -31070, -31052, -31032, -31011, -30990, -30968, -30944, -30920, -30895, -30868, -30840, -30813, -30784, -30754, -30735, -30652, -30924, -31821, -32234, -32305, -32303, -32331, -32397, -32476, -32540, -32581, -32597, -32594, -32582, -32564, -32544, -32523, -32500, -32475, -32449, -32421, -32392, -32361, -32328, -32295, -32259, -32223, -32185, -32146, -32104, -32060, -32014, -31965, -31914, -31860, -31802, -31741, -31675, -31605, -31529, -31447, -31359, -31262, -31157, -31042, -30914, -30773, -30617, -30442, -30246, -30025, -29774, -29489, -29161, -28782, -28344, -27829, -27222, -26505, -25644, -24602, -23329, -21741, -19740, -17147, -13540, -8399, -2163};