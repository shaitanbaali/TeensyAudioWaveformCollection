/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0453 256 samples */
 
const int16_t AKWF_0453_256_DATA [256] = 
{3110, 8033, 12394, 16251, 19590, 22445, 24854, 26842, 28428, 29410, 30746, 21728, -4152, -16717, -20268, -21462, -21945, -22647, -23439, -23805, -23459, -22284, -20249, -17388, -13856, -9822, -5356, -721, 3630, 7327, 10440, 13083, 15345, 17286, 18967, 20432, 21711, 22835, 23828, 24706, 25489, 26189, 26813, 27375, 27881, 28339, 28753, 29130, 29473, 29786, 30072, 30332, 30572, 30791, 30992, 31177, 31346, 31502, 31645, 31776, 31896, 32007, 32107, 32199, 32283, 32358, 32426, 32487, 32542, 32590, 32631, 32668, 32698, 32722, 32741, 32755, 32764, 32767, 32766, 32759, 32747, 32730, 32707, 32678, 32644, 32604, 32559, 32508, 32450, 32385, 32313, 32235, 32147, 32053, 31949, 31836, 31712, 31579, 31434, 31275, 31103, 30916, 30714, 30493, 30253, 29991, 29706, 29394, 29051, 28677, 28264, 27809, 27308, 26751, 26132, 25442, 24665, 23791, 22805, 21678, 20389, 18905, 17176, 15152, 12758, 9886, 6337, 1889, -3151, -7993, -12368, -16237, -19580, -22436, -24847, -26836, -28423, -29406, -30742, -21734, 4145, 16717, 20270, 21464, 21950, 22652, 23444, 23811, 23465, 22292, 20259, 17401, 13874, 9844, 5383, 749, -3604, -7305, -10421, -13065, -15329, -17273, -18955, -20422, -21702, -22826, -23821, -24700, -25483, -26183, -26808, -27370, -27877, -28334, -28750, -29127, -29469, -29782, -30069, -30329, -30569, -30788, -30989, -31174, -31344, -31499, -31642, -31774, -31894, -32004, -32105, -32197, -32281, -32357, -32424, -32485, -32539, -32588, -32630, -32666, -32696, -32721, -32740, -32754, -32762, -32766, -32765, -32757, -32745, -32728, -32705, -32677, -32642, -32603, -32558, -32505, -32448, -32383, -32312, -32233, -32146, -32051, -31947, -31834, -31710, -31577, -31432, -31272, -31101, -30914, -30711, -30491, -30250, -29988, -29702, -29390, -29048, -28673, -28260, -27805, -27304, -26746, -26126, -25435, -24658, -23784, -22796, -21669, -20379, -18893, -17162, -15136, -12738, -9871, -6331, -1790};