/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0429 256 samples */
 
const int16_t AKWF_0429_256_DATA [256] = 
{1136, 3239, 5892, 9491, 12709, 14531, 15003, 15043, 18275, 21669, 23008, 27007, 28836, 28779, 28607, 28856, 29043, 29046, 29344, 30638, 32677, 30216, 25972, 20934, 13777, 9382, 4787, 5155, 6661, 9445, 12710, 14988, 15760, 15169, 13723, 11982, 10315, 8932, 6875, 4174, 1318, -1426, -3994, -6447, -8802, -10988, -12937, -14592, -15942, -17022, -17846, -18419, -18738, -18801, -18623, -18225, -17638, -16908, -16100, -15381, -14813, -13967, -12931, -11814, -10614, -9480, -8783, -9400, -12283, -15498, -17017, -18626, -21629, -22151, -18413, -14518, -10970, -6820, -1499, 5095, 10166, 12350, 13472, 14613, 15371, 15203, 13366, 10458, 7884, 5491, 2943, 777, -246, 152, 1600, 3443, 5192, 6677, 7880, 8896, 9831, 10575, 11036, 11234, 11245, 11122, 10865, 10446, 9847, 9089, 8205, 7236, 6208, 5130, 4018, 2890, 1759, 655, -401, -1399, -2318, -3149, -3883, -4514, -5039, -5461, -5785, -6022, -6180, -6259, -6216, -5865, -5588, -5672, -5801, -5540, -2600, 1942, 3775, 6189, 8818, 10263, 10646, 11763, 8235, 3946, 481, -4478, -8805, -11333, -12231, -11371, -8796, -3573, 2418, 4642, 7722, 7427, 7147, 7111, 5077, 1068, -1982, -3701, -5115, -6535, -7645, -8123, -7945, -7512, -7258, -7323, -7551, -7729, -7830, -7963, -8234, -8634, -9071, -9425, -9607, -9542, -9120, -8084, -5987, -2675, 912, 3510, 5061, 6049, 7326, 8541, 7802, 5239, 2607, 115, -3394, -7277, -11309, -15757, -19761, -22086, -23009, -23623, -23957, -23611, -22846, -21996, -20973, -19637, -17764, -15302, -12654, -10499, -9331, -9157, -9611, -10268, -10891, -11444, -11973, -12483, -12893, -13101, -13035, -12674, -12044, -11173, -10089, -8802, -7331, -5707, -3961, -2138, -282, 1580, 3414, 5183, 6870, 8446, 9888, 11190, 12339, 13334, 14182, 14892, 15478, 15953, 16321, 16543, 16479, 15681, 12283, 7642, 5248, 867};