/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0470 256 samples */
 
const int16_t AKWF_0470_256_DATA [256] = 
{1120, 4455, 7356, 9875, 12382, 14807, 17132, 19313, 21336, 23172, 24798, 26213, 27409, 28394, 29179, 29789, 30239, 30556, 30761, 30870, 30904, 30876, 30804, 30701, 30584, 30471, 30376, 30310, 30281, 30293, 30340, 30415, 30501, 30584, 30647, 30674, 30659, 30591, 30468, 30289, 30055, 29766, 29421, 29018, 28556, 28036, 27460, 26834, 26164, 25460, 24734, 24000, 23260, 22520, 21781, 21039, 20290, 19529, 18747, 17945, 17124, 16281, 15427, 14564, 13694, 12826, 11958, 11090, 10226, 9367, 8512, 7672, 6855, 6053, 5135, 4232, 3405, 2649, 1957, 1325, 749, 222, -257, -689, -1071, -1394, -1646, -1819, -1903, -1887, -1762, -1523, -1159, -661, -21, 775, 1742, 2882, 4210, 5713, 7109, 8539, 10094, 11732, 13439, 15193, 16965, 18742, 20501, 22216, 23847, 25322, 26580, 27573, 28253, 28604, 28638, 28389, 27910, 27253, 26459, 25560, 24576, 23525, 22415, 21246, 20018, 18727, 17368, 15944, 14459, 12917, 11332, 9704, 8040, 6329, 4245, 1986, -261, -2514, -4783, -6764, -8407, -9996, -11484, -12877, -14167, -15354, -16450, -17459, -18382, -19232, -20004, -20697, -21319, -21870, -22359, -22806, -23225, -23640, -24076, -24547, -25067, -25640, -26260, -26919, -27604, -28294, -28977, -29637, -30263, -30846, -31375, -31839, -32226, -32520, -32706, -32770, -32701, -32492, -32146, -31674, -31091, -30412, -29662, -28861, -28018, -27152, -26269, -25366, -24453, -23532, -22600, -21669, -20743, -19821, -18918, -18026, -17140, -16259, -15371, -14467, -13547, -12606, -11650, -10695, -9749, -8836, -7975, -7176, -6467, -5801, -5141, -4624, -4260, -4061, -4040, -4213, -4593, -5199, -5997, -6846, -7842, -9010, -10333, -11794, -13385, -15090, -16878, -18730, -20603, -22445, -24199, -25795, -27161, -28238, -28973, -29336, -29318, -28940, -28244, -27279, -26105, -24782, -23357, -21867, -20332, -18751, -17121, -15424, -13632, -11737, -9709, -7586, -5087, -1961};