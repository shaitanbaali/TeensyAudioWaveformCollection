/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0419 256 samples */
 
const int16_t AKWF_0419_256_DATA [256] = 
{1057, 3734, 5936, 7756, 9220, 10370, 11252, 11897, 12329, 12552, 12557, 12341, 11915, 11307, 10545, 9667, 8716, 7722, 6723, 5752, 4827, 3971, 3195, 2503, 1897, 1374, 921, 531, 188, -126, -429, -739, -1076, -1449, -1868, -2334, -2839, -3368, -3884, -4340, -4661, -4749, -4489, -3786, -2592, -910, 1234, 3785, 6667, 9706, 12593, 15066, 16939, 18069, 18368, 17792, 16363, 14182, 11411, 8268, 4970, 1716, -1298, -3935, -6090, -7692, -8718, -9180, -9116, -8587, -7675, -6470, -5054, -3516, -1940, -385, 1089, 2440, 3644, 4684, 5554, 6267, 6833, 7276, 7625, 7906, 8153, 8397, 8660, 8941, 9211, 9425, 9535, 9492, 9262, 8829, 8187, 7352, 6350, 5211, 3981, 2696, 1398, 130, -1080, -2207, -3224, -4122, -4896, -5544, -6178, -5997, -11216, -22367, -28549, -31854, -32746, -31639, -28970, -25155, -20613, -15729, -10815, -6174, -2028, 1476, 4214, 6142, 7266, 7626, 7303, 6408, 5080, 3472, 1760, 141, -1186, -2036, -2282, -1865, -776, 945, 3248, 5992, 8869, 11582, 13879, 15571, 16525, 16652, 15918, 14372, 12146, 9428, 6415, 3327, 357, -2343, -4639, -6448, -7726, -8458, -8666, -8398, -7723, -6718, -5466, -4055, -2558, -1046, 414, 1786, 3032, 4114, 5026, 5890, 1289, -6488, -11012, -13902, -15287, -15414, -14528, -12874, -10694, -8210, -5617, -3097, -788, 1206, 2804, 3963, 4670, 4924, 4755, 4207, 3341, 2224, 932, -444, -1814, -3073, -4094, -4748, -4900, -4462, -3402, -1735, 477, 3176, 6246, 9418, 12388, 14896, 16751, 17825, 18031, 17339, 15784, 13500, 10672, 7504, 4230, 1050, -1871, -4382, -6395, -7855, -8741, -9072, -8895, -8276, -7295, -6041, -4604, -3063, -1496, 19, 1442, 2743, 388, -6822, -14333, -20157, -24350, -26852, -27780, -27327, -25718, -23204, -20029, -16446, -12673, -8894, -5275, -1872};