/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0455 256 samples */
 
const int16_t AKWF_0455_256_DATA [256] = 
{37, 112, 117, 90, 64, 46, 13, 592, 2719, 5497, 8014, 10271, 12356, 14297, 16104, 17765, 19263, 20612, 21814, 22883, 23838, 24691, 25453, 26141, 26758, 27316, 27821, 28278, 28693, 29071, 29415, 29729, 30017, 30280, 30521, 30743, 30945, 31132, 31304, 31462, 31606, 31740, 31862, 31974, 32076, 32170, 32255, 32332, 32403, 32466, 32522, 32572, 32616, 32654, 32686, 32713, 32734, 32750, 32761, 32767, 32767, 32764, 32754, 32740, 32720, 32695, 32665, 32629, 32588, 32540, 32487, 32427, 32361, 32287, 32207, 32118, 32022, 31916, 31802, 31677, 31541, 31394, 31234, 31060, 30872, 30667, 30444, 30201, 29937, 29650, 29334, 28990, 28612, 28196, 27738, 27233, 26670, 26047, 25350, 24567, 23689, 22692, 21557, 20261, 18762, 17020, 14985, 12571, 9685, 7088, 5655, 4747, 3795, 2838, 1997, 1350, 904, 619, 464, 291, 671, 2485, 307, -1978, -500, 277, 208, 113, -4, -77, -84, -58, -31, -16, 13, -565, -2691, -5472, -7991, -10249, -12337, -14280, -16089, -17752, -19252, -20601, -21806, -22875, -23831, -24684, -25447, -26135, -26753, -27311, -27816, -28274, -28689, -29067, -29412, -29726, -30014, -30277, -30518, -30740, -30944, -31130, -31302, -31459, -31604, -31738, -31860, -31972, -32075, -32168, -32254, -32331, -32401, -32464, -32520, -32570, -32614, -32652, -32684, -32711, -32732, -32748, -32759, -32765, -32766, -32762, -32752, -32738, -32719, -32694, -32664, -32628, -32586, -32539, -32485, -32426, -32360, -32285, -32205, -32117, -32020, -31914, -31799, -31675, -31539, -31392, -31231, -31058, -30869, -30663, -30441, -30199, -29934, -29646, -29331, -28986, -28608, -28192, -27734, -27228, -26665, -26042, -25344, -24560, -23681, -22683, -21548, -20250, -18750, -17006, -14968, -12551, -9662, -7061, -5627, -4716, -3763, -2805, -1963, -1315, -870, -586, -431, -260, -640, -2451, -272, 2010, 533, -242, -173, -75};