/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0454 256 samples */
 
const int16_t AKWF_0454_256_DATA [256] = 
{908, 1873, 1663, 1320, 586, 873, 1343, 1302, 1054, 816, 1467, 5523, 8412, 5974, 4923, 7387, 10024, 12224, 14106, 15759, 17288, 18719, 20049, 21272, 22382, 23379, 24275, 25076, 25795, 26444, 27029, 27558, 28039, 28475, 28872, 29233, 29563, 29864, 30140, 30392, 30624, 30838, 31032, 31212, 31378, 31529, 31668, 31797, 31914, 32021, 32120, 32209, 32291, 32365, 32432, 32492, 32545, 32593, 32634, 32669, 32699, 32723, 32742, 32756, 32764, 32767, 32767, 32760, 32749, 32732, 32710, 32682, 32649, 32611, 32567, 32517, 32460, 32398, 32328, 32252, 32168, 32075, 31975, 31866, 31747, 31617, 31476, 31323, 31157, 30977, 30781, 30568, 30336, 30084, 29810, 29510, 29182, 28823, 28429, 27994, 27516, 26985, 26396, 25741, 25006, 24182, 23253, 22197, 20991, 19609, 18006, 16147, 13949, 11390, 11068, 12931, 10619, 5727, 3801, 3639, 3685, 3622, 3066, 2422, 2882, 3064, 3233, 2818, -870, -1833, -1616, -1279, -546, -833, -1307, -1266, -1019, -780, -1431, -5495, -8389, -5948, -4896, -7362, -10004, -12205, -14089, -15744, -17275, -18707, -20037, -21263, -22374, -23371, -24268, -25070, -25789, -26439, -27024, -27553, -28035, -28471, -28868, -29230, -29560, -29861, -30137, -30390, -30622, -30835, -31030, -31210, -31375, -31527, -31666, -31795, -31912, -32020, -32118, -32208, -32290, -32364, -32430, -32491, -32544, -32591, -32632, -32667, -32697, -32721, -32740, -32754, -32763, -32767, -32765, -32758, -32747, -32730, -32708, -32681, -32648, -32609, -32565, -32515, -32459, -32397, -32327, -32250, -32166, -32074, -31973, -31863, -31744, -31615, -31474, -31320, -31154, -30974, -30778, -30565, -30334, -30082, -29807, -29507, -29178, -28819, -28425, -27989, -27511, -26980, -26390, -25735, -25000, -24174, -23245, -22187, -20981, -19597, -17993, -16132, -13930, -11369, -11049, -12914, -10598, -5701, -3773, -3608, -3653, -3590, -3034, -2390, -2850, -3041, -3194, -2753};