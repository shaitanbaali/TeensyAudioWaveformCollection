/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0433 256 samples */
 
const int16_t AKWF_0433_256_DATA [256] = 
{704, 1639, 1515, 689, 189, 257, 617, 1185, 1906, 2716, 3573, 4452, 5330, 6186, 7014, 7805, 8549, 9249, 9900, 10498, 11047, 11543, 11989, 12388, 12736, 13038, 13296, 13508, 13679, 13810, 13902, 13953, 13965, 13941, 13884, 13795, 13675, 13528, 13355, 13159, 12940, 12699, 12439, 12161, 11866, 11555, 11229, 10888, 10536, 10172, 9795, 9410, 9014, 8609, 8197, 7775, 7346, 6914, 6472, 6026, 5574, 5117, 4656, 4190, 3721, 3249, 2773, 2293, 1814, 1332, 845, 360, -123, -603, -1078, -1548, -2010, -2465, -2911, -3347, -3771, -4183, -4580, -4960, -5323, -5662, -5979, -6267, -6520, -6734, -6901, -7008, -7039, -6968, -6758, -6340, -5572, -4236, -2711, -2028, -2356, -3216, -4175, -5014, -5765, -6112, -4302, 750, 7682, 13097, 16436, 19031, 23148, 24787, -5628, -33090, -26857, -23027, -20975, -15964, -9144, -1500, 3567, 5150, 4670, 3706, 2395, 785, -732, -1631, -1512, -689, -189, -257, -617, -1186, -1906, -2715, -3574, -4453, -5329, -6186, -7014, -7806, -8550, -9250, -9900, -10499, -11048, -11544, -11990, -12388, -12737, -13039, -13297, -13509, -13680, -13810, -13902, -13953, -13965, -13941, -13884, -13795, -13676, -13530, -13356, -13160, -12940, -12700, -12441, -12162, -11867, -11556, -11230, -10889, -10537, -10172, -9796, -9411, -9015, -8609, -8198, -7776, -7349, -6915, -6474, -6027, -5576, -5118, -4657, -4191, -3722, -3251, -2776, -2295, -1815, -1333, -847, -362, 122, 603, 1077, 1547, 2009, 2464, 2910, 3346, 3770, 4181, 4580, 4959, 5322, 5661, 5978, 6266, 6519, 6733, 6900, 7007, 7038, 6967, 6758, 6339, 5571, 4234, 2710, 2027, 2354, 3215, 4174, 5012, 5762, 6110, 4301, -750, -7682, -13097, -16437, -19030, -23155, -24825, 5617, 33104, 26860, 23025, 20977, 15966, 9146, 1500, -3567, -5151, -4671, -3708, -2399, -766};