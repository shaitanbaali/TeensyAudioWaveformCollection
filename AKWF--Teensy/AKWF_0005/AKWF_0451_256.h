/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0451 256 samples */
 
const int16_t AKWF_0451_256_DATA [256] = 
{2826, 7505, 11181, 13955, 16084, 17873, 19402, 20690, 22135, 24055, 26009, 27407, 28077, 28134, 27688, 26595, 24725, 22894, 22472, 23455, 24913, 26336, 27594, 28654, 29508, 30164, 30605, 30825, 30871, 30868, 30955, 31173, 31436, 31613, 31602, 31387, 31038, 30615, 30098, 29428, 28653, 27973, 27170, 25242, 19724, 7764, -5394, -14418, -20321, -24443, -27336, -29349, -30687, -31483, -31891, -32072, -32168, -32265, -32396, -32547, -32678, -32755, -32760, -32677, -32499, -32241, -31954, -31696, -31466, -31227, -30982, -30751, -30389, -29600, -28358, -27255, -26929, -27322, -28105, -29137, -30223, -31028, -31336, -31161, -30644, -29906, -29014, -28020, -26979, -25983, -25225, -24845, -24708, -24487, -23883, -22710, -20891, -18536, -15960, -13441, -10881, -7964, -4823, -1983, 874, 4428, 7298, 5874, -2334, -11104, -16960, -20991, -23909, -26076, -27650, -28689, -29159, -28993, -28177, -26801, -25138, -20654, -13604, -8308, -4251, 98, 4715, 9113, 13114, 16534, 19260, 21326, 22915, 24231, 25331, 26243, 27222, 28480, 29754, 30669, 31111, 31151, 30861, 30163, 29011, 27893, 27553, 28008, 28770, 29545, 30246, 30838, 31307, 31647, 31835, 31850, 31725, 31562, 31490, 31563, 31702, 31782, 31714, 31475, 31113, 30688, 30189, 29554, 28815, 28172, 27424, 25602, 20508, 9133, -4105, -13483, -19601, -23863, -26846, -28912, -30271, -31054, -31412, -31515, -31511, -31499, -31524, -31576, -31606, -31569, -31434, -31173, -30759, -30207, -29583, -28971, -28372, -27726, -27041, -26357, -25377, -23404, -20114, -16806, -15453, -16163, -17993, -20451, -22964, -24756, -25427, -25013, -23746, -21808, -19251, -16135, -12620, -9099, -6457, -5390, -5402, -5245, -3817, -617, 3526, 7327, 10274, 12384, 13971, 15322, 16424, 17156, 17757, 18684, 19359, 18026, 11330, -424, -10086, -16283, -20639, -23800, -26072, -27610, -28461, -28624, -28148, -27193, -26032, -22732, -17882, -14733, -12595, -10164, -6770, -2123};