/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0440 256 samples */
 
const int16_t AKWF_0440_256_DATA [256] = 
{302, 886, 1336, 1023, 1129, 1425, 527, 369, 1906, 2875, 3614, 4508, 5358, 6195, 7034, 7863, 8682, 9495, 10299, 11090, 11875, 12648, 13409, 14161, 14901, 15626, 16342, 17043, 17729, 18403, 19062, 19706, 20336, 20949, 21547, 22129, 22693, 23241, 23773, 24285, 24781, 25258, 25716, 26156, 26577, 26978, 27360, 27722, 28064, 28386, 28688, 28969, 29229, 29468, 29686, 29884, 30060, 30214, 30347, 30459, 30549, 30617, 30663, 30688, 30691, 30672, 30632, 30569, 30486, 30380, 30252, 30104, 29934, 29742, 29530, 29296, 29041, 28766, 28470, 28153, 27817, 27460, 27083, 26688, 26272, 25837, 25384, 24912, 24421, 23914, 23387, 22844, 22284, 21706, 21113, 20504, 19878, 19239, 18583, 17913, 17230, 16533, 15821, 15099, 14363, 13614, 12856, 12085, 11304, 10514, 9713, 8903, 8086, 7259, 6424, 5585, 4736, 3881, 3019, 2190, 1000, 129, 1065, 1525, 924, 1176, 1140, 470, -294, -890, -1335, -1025, -1130, -1426, -528, -370, -1907, -2876, -3615, -4509, -5359, -6196, -7035, -7864, -8683, -9496, -10299, -11091, -11875, -12649, -13410, -14162, -14901, -15627, -16342, -17043, -17729, -18404, -19062, -19706, -20337, -20950, -21548, -22130, -22693, -23242, -23773, -24285, -24781, -25258, -25716, -26156, -26577, -26978, -27360, -27722, -28064, -28386, -28688, -28969, -29229, -29468, -29686, -29884, -30060, -30214, -30347, -30459, -30549, -30617, -30663, -30688, -30691, -30672, -30632, -30570, -30486, -30380, -30252, -30104, -29934, -29742, -29530, -29296, -29041, -28766, -28470, -28153, -27817, -27460, -27083, -26688, -26272, -25837, -25385, -24912, -24422, -23914, -23388, -22844, -22284, -21706, -21113, -20505, -19879, -19239, -18584, -17914, -17231, -16533, -15822, -15100, -14363, -13614, -12857, -12086, -11305, -10515, -9714, -8904, -8087, -7260, -6425, -5585, -4737, -3882, -3020, -2191, -1000, -130, -1066, -1526, -925, -1180, -1147, -451};