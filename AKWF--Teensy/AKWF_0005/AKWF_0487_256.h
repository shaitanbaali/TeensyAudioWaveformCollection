/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0487 256 samples */
 
const int16_t AKWF_0487_256_DATA [256] = 
{679, 2398, 4047, 5623, 7082, 8394, 9530, 10462, 11181, 11679, 11953, 12012, 11867, 11539, 11053, 10437, 9726, 8952, 8153, 7367, 6624, 5961, 5407, 4985, 4718, 4622, 4704, 4969, 5415, 6035, 6814, 7735, 8779, 9914, 11118, 12361, 13610, 14762, 16133, 16420, 2118, -13058, -17567, -16023, -15508, -19292, -24780, -27833, -27302, -25241, -23903, -23492, -22604, -20172, -16476, -12535, -8997, -5700, -2176, 1660, 5463, 8826, 11591, 13870, 15780, 17268, 18192, 18463, 18118, 17263, 15978, 14298, 12243, 9880, 7326, 4683, 2046, -501, -2901, -5071, -6929, -8421, -9502, -10151, -10355, -10112, -9432, -8341, -6880, -5106, -3069, -842, 1506, 3914, 6293, 8580, 10714, 12627, 14273, 15614, 16611, 17249, 17521, 17428, 16988, 16223, 15172, 13874, 12379, 10749, 9030, 7286, 5580, 3959, 2478, 1186, 116, -698, -1235, -1482, -1437, -1105, -501, 351, 1420, 2674, 4066, 5552, 7090, 8625, 10116, 11521, 12793, 13902, 14820, 15521, 15992, 16226, 16222, 15987, 15535, 14890, 14075, 13122, 12068, 10946, 9796, 8658, 7565, 6553, 5656, 4895, 4296, 3874, 3639, 3594, 3740, 4066, 4560, 5204, 5975, 6845, 7788, 8774, 9770, 10672, 11785, 11851, -2155, -17005, -21566, -20292, -20014, -23887, -29406, -32578, -32293, -30532, -29468, -29295, -28660, -26529, -23172, -19573, -16354, -13356, -10130, -6590, -3072, 33, 2573, 4655, 6394, 7735, 8541, 8726, 8324, 7436, 6137, 4463, 2430, 101, -2412, -5010, -7601, -10108, -12475, -14620, -16464, -17958, -19055, -19734, -19984, -19800, -19193, -18183, -16814, -15136, -13197, -11067, -8812, -6492, -4188, -1964, 122, 2005, 3642, 4993, 6023, 6715, 7062, 7067, 6742, 6110, 5210, 4075, 2754, 1306, -224, -1775, -3289, -4718, -6010, -7119, -8011, -8655, -9028, -9119, -8924, -8450, -7707, -6719, -5517, -4134, -2612, -957};