/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0434 256 samples */
 
const int16_t AKWF_0434_256_DATA [256] = 
{17594, 22703, 14052, 13726, 12281, 9245, 4970, 1253, 107, 871, 2001, 2934, 3904, 4876, 5833, 6785, 7724, 8656, 9578, 10486, 11386, 12271, 13143, 14004, 14851, 15683, 16501, 17303, 18088, 18860, 19612, 20349, 21069, 21769, 22451, 23115, 23759, 24384, 24989, 25572, 26136, 26679, 27200, 27700, 28178, 28631, 29064, 29474, 29860, 30224, 30564, 30880, 31172, 31440, 31684, 31903, 32099, 32268, 32414, 32534, 32630, 32700, 32746, 32767, 32762, 32733, 32678, 32598, 32494, 32365, 32211, 32033, 31829, 31600, 31348, 31071, 30770, 30447, 30098, 29726, 29332, 28913, 28472, 28010, 27524, 27018, 26490, 25938, 25367, 24777, 24164, 23533, 22882, 22211, 21523, 20816, 20089, 19348, 18589, 17812, 17020, 16212, 15389, 14553, 13702, 12835, 11958, 11067, 10164, 9252, 8327, 7391, 6449, 5494, 4531, 3564, 2590, 1617, 627, 331, 2208, 6300, 10543, 12876, 14383, 16025, 20335, 12836, -17767, -22700, -13994, -13726, -12281, -9246, -4971, -1255, -108, -872, -2001, -2935, -3905, -4877, -5834, -6786, -7725, -8657, -9578, -10486, -11386, -12272, -13144, -14005, -14852, -15682, -16501, -17303, -18089, -18860, -19613, -20349, -21069, -21770, -22451, -23115, -23759, -24384, -24990, -25573, -26136, -26679, -27199, -27700, -28178, -28631, -29064, -29475, -29861, -30224, -30564, -30880, -31172, -31440, -31684, -31903, -32099, -32268, -32414, -32534, -32630, -32700, -32746, -32767, -32762, -32733, -32678, -32598, -32494, -32365, -32211, -32033, -31829, -31600, -31348, -31071, -30770, -30447, -30098, -29726, -29332, -28914, -28472, -28011, -27525, -27018, -26489, -25938, -25367, -24777, -24165, -23533, -22882, -22211, -21523, -20816, -20089, -19348, -18589, -17812, -17020, -16213, -15389, -14554, -13702, -12835, -11959, -11068, -10165, -9253, -8328, -7392, -6450, -5495, -4532, -3565, -2590, -1618, -628, -332, -2209, -6301, -10544, -12877, -14384, -16086, -20362, -12570};