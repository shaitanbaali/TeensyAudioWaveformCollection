/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0416 256 samples */
 
const int16_t AKWF_0416_256_DATA [256] = 
{17695, 15812, 7957, 667, -3005, -4078, -3698, -2724, -1677, -805, -186, 195, 391, 460, 452, 404, 343, 285, 243, 230, 247, 300, 382, 455, 419, 258, 60, -107, -198, -236, -581, -985, -1040, -843, -549, -278, -83, 105, 330, 533, 648, 654, 566, 419, 254, 100, -22, -106, -156, -179, -178, -159, -126, -88, -49, -14, 14, 35, 50, 57, -76, 966, -5599, -15173, 13072, 10936, 5025, 199, -2219, -2854, -2536, -1845, -1120, -528, -115, 137, 262, 298, 277, 225, 168, 119, 83, 59, 51, 58, 87, 143, 223, 327, 433, 454, 334, 146, -29, -144, -176, -409, -866, -1027, -888, -610, -328, -118, 59, 274, 485, 627, 662, 596, 460, 295, 134, 0, -96, -155, -184, -190, -176, -147, -109, -69, -32, -2, -93, 745, -3789, -12286, -101, 11239, 8998, 4401, 473, -1774, -2567, -2460, -1924, -1274, -688, -237, 66, 245, 333, 358, 342, 302, 249, 185, 112, 26, -67, -169, -255, -294, -254, -167, -73, 2, 49, 69, 68, 55, 36, 16, -1, -16, -26, -32, -36, -37, -38, -38, -39, -41, -41, -34, -21, -1, 22, 54, 97, 155, 236, 337, 451, 514, 439, 258, 68, -82, -136, -261, -703, -1001, -955, -714, -424, -190, -15, 182, 402, 576, 648, 615, 499, 340, 175, 30, -79, -149, -188, -200, -192, -166, -130, -90, -51, -15, 12, 33, 46, 56, 60, 61, 60, 58, 56, 53, 52, 53, 49, 4, -85, -187, -257, -276, -242, -174, -92, -13, 48, 86, 102, 101, 87, 66, 44, 23, 5, -8, -16, -20, -152, 457, -1388, -27332};