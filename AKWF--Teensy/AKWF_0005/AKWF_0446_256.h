/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0446 256 samples */
 
const int16_t AKWF_0446_256_DATA [256] = 
{584, 2658, 4556, 6329, 7975, 9505, 10926, 12240, 13463, 14599, 15654, 16638, 17557, 18413, 19214, 19966, 20669, 21331, 21954, 22538, 23091, 23613, 24105, 24572, 25014, 25433, 25831, 26209, 26568, 26911, 27236, 27547, 27844, 28128, 28398, 28658, 28906, 29144, 29372, 29590, 29800, 30001, 30195, 30381, 30560, 30732, 30898, 31059, 31212, 31361, 31504, 31642, 31776, 31905, 32029, 32150, 32267, 32379, 32488, 32502, 32856, 31675, 14319, -1554, -4605, -4226, -5767, -9256, -12689, -15140, -16538, -17069, -16972, -16473, -15748, -14904, -13979, -12974, -11864, -10629, -9255, -7724, -6029, -4164, -2140, -38, 2023, 3967, 5777, 7459, 9025, 10475, 11821, 13072, 14233, 15313, 16321, 17258, 18134, 18954, 19721, 20440, 21116, 21750, 22347, 22911, 23442, 23944, 24420, 24869, 25296, 25701, 26084, 26450, 26799, 27129, 27445, 27747, 28035, 28310, 28573, 28824, 29066, 29108, 30111, 26234, 2002, -12703, -16922, -19048, -20941, -22958, -24725, -26025, -26854, -27296, -27461, -27451, -27337, -27168, -26963, -26730, -26463, -26164, -25835, -25473, -25082, -24664, -24217, -23743, -23240, -22703, -22135, -21532, -20888, -20203, -19474, -18693, -17860, -16966, -16004, -14972, -13858, -12652, -11351, -9938, -8397, -6723, -4887, -2893, -799, 1305, 3300, 5158, 6891, 8500, 9989, 11374, 12660, 13850, 14959, 15991, 16950, 17849, 18687, 19469, 20205, 20558, 22852, 13754, -11301, -20294, -23735, -25636, -27072, -28399, -29527, -30375, -30946, -31288, -31466, -31535, -31539, -31506, -31448, -31373, -31280, -31170, -31046, -30909, -30760, -30602, -30435, -30259, -30075, -29881, -29680, -29471, -29251, -29022, -28782, -28532, -28272, -27998, -27712, -27413, -27099, -26768, -26422, -26059, -25676, -25274, -24850, -24402, -23930, -23430, -22902, -22342, -21748, -21116, -20445, -19728, -18963, -18148, -17272, -16333, -15325, -14238, -13065, -11798, -10421, -8925, -7299, -5519, -3583, -1476};