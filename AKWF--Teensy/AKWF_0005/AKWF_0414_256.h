/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0414 256 samples */
 
const int16_t AKWF_0414_256_DATA [256] = 
{671, 1707, 2570, 3282, 3836, 4220, 4418, 4426, 4288, 4057, 3780, 3489, 3206, 2948, 2722, 2531, 2381, 2270, 2198, 2161, 2157, 2181, 2233, 2310, 2412, 2538, 2688, 2862, 3060, 3282, 3529, 3802, 4103, 4432, 4792, 5185, 5611, 6078, 6587, 7143, 7743, 8384, 9051, 9739, 10436, 11135, 11832, 12526, 13209, 13886, 14554, 15210, 15859, 16499, 17129, 17752, 18367, 18973, 19573, 20166, 20747, 21076, 23015, 14210, -8069, -3501, -3113, -2767, -2583, -2437, -2328, -2246, -2189, -2160, -2161, -2192, -2258, -2362, -2507, -2691, -2910, -3165, -3444, -3734, -4016, -4257, -4413, -4432, -4265, -3910, -3381, -2693, -1852, -857, 277, 1358, 2277, 3045, 3656, 4104, 4370, 4443, 4350, 4148, 3882, 3592, 3306, 3037, 2798, 2595, 2430, 2305, 2220, 2171, 2155, 2169, 2211, 2280, 2373, 2491, 2632, 2797, 2986, 3200, 3435, 3610, 4412, 1298, -7705, -4129, -3966, -3483, -3205, -2970, -2775, -2610, -2470, -2355, -2266, -2203, -2165, -2156, -2177, -2234, -2328, -2461, -2634, -2844, -3089, -3363, -3651, -3938, -4194, -4379, -4443, -4332, -4029, -3548, -2904, -2105, -1155, -53, 1065, 2030, 2840, 3498, 3994, 4313, 4440, 4390, 4213, 3961, 3675, 3386, 3111, 2862, 2650, 2473, 2337, 2240, 2181, 2156, 2162, 2197, 2258, 2343, 2454, 2589, 2746, 2791, 3575, 550, -22993, -21608, -21214, -20565, -20026, -19439, -18845, -18242, -17626, -17002, -16373, -15733, -15081, -14421, -13752, -13073, -12389, -11695, -10996, -10297, -9602, -8917, -8256, -7622, -7030, -6483, -5983, -5524, -5105, -4718, -4365, -4043, -3747, -3479, -3237, -3019, -2827, -2658, -2512, -2391, -2294, -2221, -2175, -2156, -2167, -2210, -2291, -2409, -2567, -2764, -2998, -3262, -3547, -3837, -4108, -4324, -4438, -4395, -4158, -3739, -3154, -2410, -1516, -451};