/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0483 256 samples */
 
const int16_t AKWF_0483_256_DATA [256] = 
{288, 681, 1028, 1357, 1667, 1955, 2207, 2418, 2596, 2758, 2912, 3073, 3249, 3436, 3619, 3791, 3955, 4111, 4262, 4421, 4600, 4795, 5007, 5224, 5433, 5635, 5844, 6069, 6312, 6569, 6819, 7061, 7298, 7527, 7759, 8011, 8278, 8561, 8855, 9142, 9421, 9691, 9968, 10262, 10570, 10888, 11220, 11562, 11915, 12277, 12647, 13025, 13409, 13799, 14192, 14591, 14991, 15392, 15796, 16199, 16599, 16999, 17395, 17786, 18174, 18554, 18928, 19295, 19654, 20002, 20341, 20668, 20984, 21287, 21576, 21852, 22114, 22359, 22588, 22801, 22997, 23175, 23334, 23476, 23616, 23757, 23898, 24037, 24173, 24304, 24429, 24548, 24658, 24759, 24849, 24929, 24995, 25048, 25086, 25109, 25115, 25105, 25076, 25028, 24961, 24874, 24766, 24637, 24486, 24313, 24116, 23896, 23654, 23388, 23097, 22783, 22445, 22081, 21694, 21282, 20846, 20387, 19902, 19394, 18863, 18307, 17730, 17130, 16507, 15863, 15200, 14512, 13808, 13082, 12337, 11576, 10796, 9999, 9188, 8360, 7518, 6665, 5797, 4917, 4029, 3129, 2220, 1305, 381, -546, -1478, -2417, -3357, -4297, -5240, -6182, -7121, -8060, -8993, -9922, -10846, -11762, -12671, -13572, -14461, -15340, -16209, -17061, -17902, -18729, -19537, -20330, -21107, -21863, -22601, -23318, -24013, -24688, -25340, -25968, -26572, -27152, -27705, -28234, -28734, -29208, -29655, -30072, -30461, -30823, -31152, -31453, -31723, -31963, -32172, -32350, -32497, -32612, -32696, -32748, -32768, -32757, -32715, -32640, -32534, -32397, -32229, -32030, -31800, -31540, -31248, -30929, -30579, -30199, -29792, -29356, -28892, -28403, -27886, -27342, -26775, -26181, -25565, -24925, -24261, -23576, -22870, -22142, -21396, -20632, -19847, -19048, -18231, -17398, -16553, -15693, -14819, -13937, -13040, -12135, -11222, -10299, -9370, -8438, -7497, -6568, -5690, -4872, -4134, -3461, -2835, -2243, -1676, -1133, -618, -131};