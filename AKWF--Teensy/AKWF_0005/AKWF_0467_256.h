/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0467 256 samples */
 
const int16_t AKWF_0467_256_DATA [256] = 
{2365, 8577, 14208, 19418, 24051, 27870, 30652, 32272, 32786, 32383, 31272, 29580, 27389, 24806, 21959, 19011, 16108, 13325, 10705, 8266, 5978, 3712, 1415, -642, -2244, -3531, -4713, -5806, -6756, -7530, -8085, -8404, -8530, -8520, -8386, -8102, -7640, -7006, -6238, -5368, -4415, -3398, -2329, -1214, -84, 1030, 2115, 3174, 4261, 5356, 6308, 7036, 7579, 7976, 8214, 8262, 8105, 7747, 7231, 6612, 5894, 5060, 4126, 3126, 2095, 1068, 62, -916, -1854, -2739, -3554, -4281, -4915, -5451, -5890, -6236, -6482, -6628, -6679, -6644, -6529, -6338, -6082, -5777, -5478, -5418, -5700, -5881, -5599, -5041, -4497, -4006, -3498, -2936, -2267, -1466, -625, 120, 734, 1220, 1550, 1770, 1896, 1836, 1573, 1181, 689, 111, -516, -1193, -1927, -2675, -3388, -4109, -4925, -5705, -6212, -6445, -6552, -6554, -6383, -6021, -5485, -4774, -3927, -3016, -2096, -1166, -233, 665, 1494, 2228, 2851, 3357, 3751, 4039, 4227, 4312, 4303, 4214, 4057, 3844, 3585, 3286, 2957, 2602, 2229, 1849, 1426, 705, -417, -1459, -2021, -2286, -2549, -2827, -3027, -3100, -2989, -2660, -2194, -1709, -1248, -787, -288, 239, 747, 1197, 1572, 1874, 2123, 2344, 2538, 2695, 2821, 2957, 3161, 3357, 3376, 3191, 2901, 2553, 2121, 1576, 913, 138, -717, -1588, -2429, -3229, -3978, -4658, -5246, -5713, -6045, -6240, -6309, -6263, -6112, -5864, -5529, -5121, -4661, -4165, -3648, -3122, -2589, -2064, -1554, -1063, -600, -164, 222, 402, 308, 224, 382, 672, 915, 1093, 1257, 1437, 1670, 1969, 2280, 2525, 2684, 2758, 2727, 2629, 2480, 2216, 1831, 1385, 895, 367, -161, -670, -1168, -1639, -2071, -2561, -3457, -5344, -9133, -14956, -20862, -24531, -25676, -25467, -24569, -22834, -19977, -15806, -10347, -3912};