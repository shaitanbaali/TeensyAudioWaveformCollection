/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0462 256 samples */
 
const int16_t AKWF_0462_256_DATA [256] = 
{4775, 11242, 16882, 22391, 27777, 31728, 32790, 31601, 30219, 29441, 28442, 26477, 23857, 21121, 17986, 14469, 11398, 9248, 7614, 5608, 3041, 714, -762, -1600, -2133, -2573, -3451, -4848, -5981, -6347, -6507, -7090, -7646, -7690, -7645, -7722, -7462, -6706, -5820, -4996, -4091, -3053, -1985, -891, 242, 1332, 2290, 3130, 3906, 4627, 5023, 4777, 4812, 6160, 7809, 8112, 7189, 6245, 5805, 5661, 5541, 5154, 4194, 2887, 1876, 1360, 960, 460, 132, -185, -1208, -3009, -4739, -5576, -5503, -5071, -4556, -3973, -3861, -4340, -4513, -3660, -2192, -1403, -1792, -2392, -2284, -1613, -727, 136, 164, -816, -1580, -1294, -861, -1309, -1770, -1422, -1250, -1715, -1841, -1213, -528, -195, 33, 284, 450, 595, 820, 1002, 975, 794, 627, 560, -161, -2460, -3572, -374, 4094, 4878, 2288, -77, -633, -36, 836, 1282, 1630, 2879, 3997, 3011, 212, -2306, -3199, -3770, -5646, -7388, -7384, -7020, -8092, -10095, -11424, -11695, -12196, -13515, -14703, -14864, -14086, -13362, -13196, -12879, -11715, -9901, -7761, -5504, -3919, -3277, -2571, -1090, 344, 820, 1103, 1942, 2517, 2420, 2491, 3096, 3656, 3852, 3923, 3985, 3948, 3859, 3815, 3722, 3440, 3019, 2586, 2196, 1371, -454, -1668, -550, 1375, 1649, 330, -1012, -1697, -1922, -1925, -2086, -2849, -3981, -4702, -4724, -4443, -4181, -3820, -3460, -3536, -4068, -4486, -4267, -3430, -2387, -1345, -318, 314, 454, 745, 1696, 2999, 3742, 3593, 3254, 3362, 3812, 4345, 4797, 4669, 3873, 3213, 3223, 3323, 2851, 2348, 2352, 2287, 1867, 1669, 1929, 2208, 2273, 2290, 2338, 2343, 2335, 2374, 2393, 2294, 2106, 1905, 781, -4393, -14029, -20449, -17914, -11823, -10416, -14529, -19756, -22731, -22342, -18877, -13867, -8375, -1915};