/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0474 256 samples */
 
const int16_t AKWF_0474_256_DATA [256] = 
{1098, 3725, 5919, 7800, 9358, 10690, 11888, 12957, 13902, 14734, 15461, 16102, 16657, 17131, 17539, 17885, 18181, 18432, 18652, 18848, 19029, 19208, 19389, 19581, 19788, 20014, 20264, 20539, 20837, 21159, 21496, 21846, 22178, 22483, 22810, 23147, 23448, 23733, 24003, 24222, 24392, 24529, 24631, 24692, 24701, 24664, 24584, 24463, 24304, 24112, 23887, 23639, 23372, 23091, 22800, 22506, 22215, 21929, 21656, 21389, 21148, 20897, 19644, 17782, 16422, 15405, 14602, 13975, 13492, 13116, 12827, 12604, 12433, 12306, 12231, 12195, 12158, 12124, 12111, 12103, 12065, 12027, 12007, 11980, 11927, 11858, 11783, 11699, 11602, 11492, 11370, 11243, 11106, 10962, 10812, 10654, 10493, 10328, 10163, 9995, 9825, 9654, 9480, 9309, 9138, 8965, 8797, 8629, 8464, 8300, 8140, 7981, 7828, 7679, 7536, 7396, 7257, 7126, 6999, 6876, 6754, 6639, 6501, 6471, 7551, 8995, 9931, 10659, 9186, 5666, 2933, 964, -554, -1693, -2565, -3232, -3732, -4096, -4352, -4527, -4635, -4686, -4692, -4663, -4604, -4516, -4411, -4287, -4150, -4002, -3848, -3684, -3513, -3338, -3161, -2981, -2802, -2624, -2448, -2273, -2077, -1860, -1677, -1527, -1373, -1240, -1140, -1043, -961, -909, -896, -911, -950, -1018, -1113, -1242, -1401, -1587, -1802, -2047, -2321, -2621, -2948, -3301, -3683, -4089, -4520, -4979, -5452, -5977, -7547, -9764, -11520, -12971, -14243, -15373, -16389, -17324, -18197, -19020, -19810, -20575, -21339, -22102, -22832, -23538, -24246, -24939, -25586, -26221, -26859, -27472, -28049, -28592, -29111, -29604, -30064, -30488, -30882, -31238, -31560, -31846, -32092, -32304, -32475, -32608, -32701, -32755, -32767, -32737, -32665, -32552, -32395, -32194, -31953, -31669, -31343, -30977, -30568, -30122, -29640, -29119, -28562, -27975, -27349, -26692, -26009, -25294, -24552, -23757, -23011, -21839, -16913, -10484, -5702, -1898};