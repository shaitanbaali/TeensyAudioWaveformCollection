/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0407 256 samples */
 
const int16_t AKWF_0407_256_DATA [256] = 
{459, 1169, 1902, 2673, 3477, 4311, 5172, 6048, 6936, 7830, 8715, 9588, 10440, 11263, 12055, 12808, 13519, 14191, 14821, 15409, 15964, 16487, 16983, 17461, 17926, 18383, 18842, 19308, 19783, 20275, 20786, 21314, 21864, 22429, 23010, 23600, 24194, 24787, 25371, 25936, 26478, 26987, 27453, 27876, 28245, 28558, 28811, 29002, 29130, 29197, 29203, 29151, 29047, 28893, 28696, 28461, 28186, 27927, 27389, 26738, 25898, 24744, 23718, 22496, 21298, 20002, 18616, 17165, 15678, 14166, 12641, 11117, 9599, 8089, 6601, 5131, 3684, 2254, 1217, 129, -784, -1721, -2635, -3457, -4205, -4895, -5539, -6150, -6730, -7294, -7794, -7921, -8146, -8174, -8267, -8306, -8249, -8113, -7906, -7639, -7317, -6945, -6525, -6063, -5560, -5016, -4484, -3710, -2743, -1805, -753, 213, 1222, 2274, 3339, 4395, 5429, 6421, 7359, 8238, 9047, 9777, 10429, 10995, 11476, 11870, 12179, 12406, 12554, 12629, 12636, 12579, 12466, 12305, 12069, 11928, 12017, 11978, 12058, 12009, 11975, 11966, 11964, 11952, 11913, 11835, 11710, 11529, 11285, 10975, 10594, 10139, 9613, 9017, 8353, 7628, 6850, 6025, 5164, 4276, 3369, 2457, 1546, 645, -237, -1097, -1930, -2730, -3501, -4241, -4949, -5633, -6295, -6939, -7574, -8204, -8833, -9468, -10115, -10774, -11452, -12148, -12852, -13614, -14742, -15759, -16957, -18062, -19183, -20350, -21535, -22717, -23877, -24992, -26054, -27053, -27975, -28816, -29573, -30240, -30820, -31314, -31721, -32052, -32310, -32501, -32636, -32720, -32761, -32765, -32740, -32689, -32615, -32520, -32405, -32267, -32104, -31913, -31685, -31416, -31102, -30732, -30302, -29805, -29236, -28591, -27867, -27061, -26178, -25216, -24178, -23073, -21903, -20677, -19407, -18097, -16758, -15403, -14036, -12669, -11299, -10311, -9259, -8379, -7471, -6589, -5800, -5084, -4424, -3805, -3206, -2621, -2037, -1444, -835, -188};