/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0402 256 samples */
 
const int16_t AKWF_0402_256_DATA [256] = 
{518, 3211, 4740, 6366, 7340, 7153, 7480, 9101, 10052, 12358, 15641, 18011, 18427, 18856, 20788, 21779, 21608, 21652, 22964, 23472, 23263, 23599, 24458, 25346, 25995, 26205, 26352, 26583, 27354, 28132, 28107, 27799, 27522, 27307, 28140, 29071, 29504, 30079, 30592, 32124, 32446, 31985, 32451, 32173, 31350, 31123, 31375, 31684, 31308, 31101, 31697, 31829, 32108, 32302, 31968, 32212, 31382, 30225, 30171, 30405, 29666, 27895, 27176, 26780, 26635, 26821, 27692, 27661, 27012, 26849, 27079, 26613, 26153, 26407, 26478, 28708, 10159, -14441, -18024, -18804, -18493, -18512, -18461, -18436, -17780, -18182, -18832, -18698, -18696, -18705, -18461, -18426, -18708, -20059, -20364, -19762, -19805, -21316, -22351, -23099, -23304, -22575, -21469, -20548, -19594, -19533, -19527, -19634, -19645, -19735, -19117, -18439, -17867, -17354, -17717, -17796, -16777, -14428, -12135, -9986, -9763, -11713, -12259, -11469, -10469, -10889, -11746, -11747, -12661, -13154, -12785, -11518, -9094, -8008, -8504, -9433, -9210, -8453, -7824, -7316, -5903, -4338, -3902, -5189, -5872, -5576, -6040, -6826, -7277, -6867, -5433, -5117, -5636, -5833, -7380, -8565, -9050, -9172, -9231, -9361, -9516, -9939, -10551, -11819, -12890, -13672, -13092, -12880, -12769, -13014, -12848, -13605, -14100, -13690, -13738, -15630, -16641, -17466, -17417, -15042, -13465, -13354, -13467, -12977, -11919, -11281, -10576, -9617, -8631, -8528, -9038, -9062, -8264, -7916, -7770, -6735, -6174, -6073, -6088, -7246, -7716, -7874, -7640, -7616, -7664, -7475, -7022, -7319, -8698, -9672, -10259, -10226, -9575, -8640, -8397, -8211, -8579, -8400, -8347, -8426, -8370, -7774, -8108, -8260, -8127, -7740, -6802, -6056, -6005, -6145, -5940, -5871, -5869, -6496, -6982, -5987, -4724, -3277, -1823, -113, 722, -301, -433, 264, 41, -630, -515, 35, 35, -98, -1770, -2573, -2400, -4223, -3156, -555};