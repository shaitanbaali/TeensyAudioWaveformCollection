/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0404 256 samples */
 
const int16_t AKWF_0404_256_DATA [256] = 
{1479, 3616, 5921, 7632, 9067, 10335, 11944, 13382, 13994, 14586, 15570, 16450, 17335, 18144, 18395, 19308, 20030, 20736, 20875, 21155, 21695, 22117, 22451, 22475, 22700, 22967, 23234, 23517, 24097, 24520, 24861, 25232, 25859, 26288, 26698, 27068, 27962, 28594, 29173, 29273, 29484, 29806, 30075, 30327, 30570, 30793, 30974, 31103, 31235, 31403, 31551, 31705, 31863, 32004, 32098, 32143, 32158, 32194, 32493, 32311, 32301, 32522, 32702, 32585, 30177, 30035, 30139, 30166, 30205, 30240, 30239, 30193, 30126, 30080, 30010, 29926, 29863, 29813, 29776, 29630, 29322, 29280, 29220, 29163, 29111, 29048, 28975, 28847, 28669, 28482, 28283, 28118, 27793, 27413, 27232, 26985, 26759, 26539, 26282, 26018, 25761, 25495, 25189, 24844, 24484, 24160, 23812, 23417, 23026, 22639, 22159, 21421, 20964, 20499, 19967, 19406, 18817, 18189, 17520, 16555, 14832, 13006, 11410, 9937, 8585, 6924, 4393, 1510, -3986, -6265, -7608, -8795, -10291, -11594, -12845, -14084, -15278, -16404, -17456, -18428, -19309, -20088, -20791, -21461, -22102, -22478, -22772, -23207, -23560, -23888, -24221, -24569, -24889, -25201, -25541, -25874, -26145, -26621, -27069, -27310, -27788, -28188, -28392, -28603, -28781, -28911, -29282, -29601, -29743, -29893, -30020, -30121, -30189, -30241, -30293, -30354, -30415, -30451, -30473, -30485, -30487, -30497, -30546, -30632, -30737, -30800, -30646, -30434, -30283, -30169, -30020, -30159, -32569, -32722, -32601, -32510, -32388, -32253, -32159, -31940, -31599, -31477, -31299, -31115, -30897, -30615, -30320, -30028, -29733, -29430, -29133, -28862, -28606, -28332, -28094, -27900, -27730, -27567, -27415, -27283, -27112, -26843, -26829, -27087, -26746, -26448, -26165, -25810, -25390, -24941, -24495, -24052, -23592, -23122, -22591, -22002, -21369, -20710, -20048, -19390, -18734, -18033, -17165, -16118, -15259, -14584, -14277, -13458, -13421, -13117, -12445, -11149, -9643, -7797, -4583, -1785};