/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0468 256 samples */
 
const int16_t AKWF_0468_256_DATA [256] = 
{1464, 4156, 6797, 9952, 14028, 18583, 22737, 25912, 27947, 28852, 28751, 27797, 26039, 23502, 20338, 16865, 13399, 10123, 7140, 4491, 2178, 238, -1291, -2410, -3163, -3631, -3890, -3992, -3973, -3862, -3690, -3491, -3292, -3103, -2915, -2715, -2486, -2218, -1903, -1536, -1109, -618, -69, 537, 1014, 761, -623, -2741, -4808, -6334, -7192, -7418, -7102, -6312, -5044, -3280, -1146, 1028, 2541, 2721, 1677, 159, -1187, -2135, -2699, -2936, -2871, -2443, -1562, -253, 1282, 2836, 4642, 7240, 10646, 14202, 17172, 19182, 20173, 20217, 19452, 17967, 15779, 12965, 9736, 6417, 3549, 1866, 1595, 2157, 2811, 3196, 3260, 3021, 2494, 1644, 380, -1315, -3302, -5348, -7045, -7713, -7025, -5471, -3818, -2488, -1560, -998, -775, -892, -1416, -2375, -3659, -4916, -5071, -2951, 1256, 6073, 10171, 13059, 14712, 15248, 14783, 13293, 10687, 7060, 2857, -1467, -5708, -9596, -12792, -15123, -16344, -16601, -16622, -16916, -17352, -17615, -17611, -17390, -17034, -16641, -16253, -15790, -15152, -14355, -13997, -15348, -18934, -23682, -28009, -31029, -32548, -32674, -31588, -29401, -26073, -21612, -16370, -10900, -5876, -2161, -169, 531, 692, 747, 769, 754, 742, 825, 1143, 1794, 2702, 3678, 4439, 4379, 3050, 777, -1659, -3725, -5302, -6403, -7065, -7313, -7106, -6402, -5280, -4007, -3211, -3576, -5078, -6998, -8644, -9738, -10282, -10337, -9948, -9084, -7668, -5736, -3482, -1145, 1397, 4692, 8850, 13242, 17117, 20041, 21908, 22784, 22796, 22049, 20555, 18368, 15696, 12830, 10278, 8781, 8663, 9436, 10332, 10935, 11167, 11048, 10597, 9796, 8561, 6854, 4806, 2652, 602, -1237, -2849, -4222, -5325, -6116, -6548, -6617, -6360, -5840, -5113, -4209, -3167, -2019, -941, -540, -1305, -2931, -4629, -5846, -6427, -6383, -5787, -4709, -3142, -991};