/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0428 256 samples */
 
const int16_t AKWF_0428_256_DATA [256] = 
{11797, 22964, 23925, 20511, 15591, 12236, 12267, 19473, 32349, 32574, 30871, 30020, 23703, 20337, 23985, 29312, 29087, 24208, 20747, 25593, 29440, 11694, -3688, -19990, -25252, -16212, -4685, 12650, 15374, 11764, 7205, 4585, 4799, 5283, 3704, 267, -1926, -1550, -2299, -3681, -5001, -6026, -6692, -7099, -7377, -7610, -7827, -8009, -8140, -8215, -8237, -8212, -8140, -8022, -7862, -7676, -7501, -7431, -7662, -8755, -9743, -8849, -7383, -6312, -6099, -7205, -10493, -18777, -30384, -32472, -24398, -21317, -27251, -21153, -4748, 3174, 5093, 6231, 13128, 23472, 23489, 13178, 5760, 6496, 11315, 12548, 4254, -6913, -11940, -11069, -7802, -4596, -2427, -1121, -170, 710, 1454, 1697, 1019, 66, -390, -461, -384, -320, -320, -350, -364, -336, -267, -171, -65, 40, 135, 216, 279, 326, 357, 376, 383, 383, 376, 361, 337, 303, 251, 175, 68, -70, -215, -307, 68, 1166, 537, -1598, -2921, 528, 16520, 25796, 17756, 12373, 10357, 9838, 13693, 16518, -3958, -16797, -21361, -22151, -14601, -5077, -427, 1370, 4969, 20324, 26393, 19634, 13083, -586, -623, 6219, 3642, -6356, -10728, -8675, -4452, -1259, -503, -1489, -2333, -2340, -1932, -1908, -2492, -3386, -4285, -5016, -5545, -5906, -6099, -6048, -5594, -4502, -2388, 1624, 8417, 16023, 18441, 13510, 6723, 4788, 10674, 15375, 7618, -6606, -14776, -15648, -15473, -15657, -21360, -30657, -33427, -30007, -20184, -15644, -18084, -22599, -24697, -21552, -14222, -7093, -3064, -2149, -2805, -3627, -4098, -4291, -4415, -4556, -4661, -4644, -4466, -4151, -3756, -3324, -2875, -2413, -1935, -1444, -949, -455, 35, 517, 992, 1461, 1923, 2379, 2831, 3277, 3721, 4167, 4614, 5074, 5552, 6058, 6605, 7205, 7856, 8539, 9155, 9408, 8624, 3978, -10203, -16028, -10749, -8912};