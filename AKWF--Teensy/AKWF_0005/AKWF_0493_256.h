/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0493 256 samples */
 
const int16_t AKWF_0493_256_DATA [256] = 
{-24019, -32582, -26952, -24981, -23701, -23467, -24487, -25929, -27059, -27648, -27779, -27632, -27365, -27098, -26888, -26742, -26661, -26621, -26598, -26581, -26562, -26543, -26521, -26499, -26480, -26466, -26458, -26454, -26455, -26458, -26462, -26474, -26487, -26501, -26518, -26535, -26554, -26574, -26559, -26725, -26261, -18647, -17787, -19324, -19934, -20123, -20048, -19871, -19710, -19611, -19577, -19599, -19649, -19714, -19772, -19814, -19845, -19866, -19883, -19897, -19913, -19924, -19934, -19944, -19952, -19958, -19963, -19966, -19968, -19968, -19970, -19968, -19952, -19942, -20106, -12920, -10718, -12187, -12663, -12776, -12652, -12448, -12268, -12155, -12106, -12107, -12139, -12180, -12215, -12236, -12248, -12255, -12253, -12248, -12253, -12253, -12251, -12253, -12256, -12258, -12258, -12256, -12254, -12252, -12251, -12247, -12241, -12141, -12709, -6195, -2601, -4065, -4504, -4606, -4482, -4281, -4102, -3992, -3952, -3961, -3998, -4046, -4088, -4113, -4132, -4144, -4146, -4147, -4154, -4160, -4164, -4168, -4173, -4175, -4179, -4182, -4183, -4184, -4183, -4184, -4181, -4178, -4176, -4173, -4093, -4495, -2705, 4881, 4754, 3876, 3610, 3630, 3803, 4004, 4155, 4234, 4250, 4226, 4182, 4134, 4100, 4079, 4064, 4058, 4057, 4052, 4046, 4044, 4038, 4033, 4030, 4027, 4024, 4022, 4022, 4022, 4022, 4023, 4027, 4029, 4031, 4036, 4038, 4041, 4045, 4136, 3675, 5793, 13254, 12890, 12022, 11717, 11703, 11863, 12066, 12224, 12313, 12337, 12317, 12273, 12227, 12192, 12170, 12154, 12147, 12145, 12141, 12133, 12130, 12125, 12120, 12117, 12114, 12111, 12108, 12108, 12108, 12108, 12108, 12164, 11899, 12971, 20610, 20996, 19848, 19386, 19256, 19361, 19563, 19751, 19873, 19925, 19921, 19887, 19841, 19804, 19780, 19762, 19755, 19755, 19753, 19748, 19745, 19742, 19739, 19738, 19735, 19733, 19731, 19731, 19731, 19732, 19735, 19737, 19740, 19743};