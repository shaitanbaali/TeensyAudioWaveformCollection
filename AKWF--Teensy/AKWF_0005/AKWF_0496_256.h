/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0496 256 samples */
 
const int16_t AKWF_0496_256_DATA [256] = 
{-211, -60, 628, 658, -235, -1380, -2322, -3060, -3968, -4981, -4769, -2728, -708, 68, 112, -67, -332, -620, -918, -1263, -1650, -1946, -1988, -1707, -1305, -1104, -1210, -1535, -1909, -2155, -2247, -2360, -2630, -2809, -2479, -2660, -5134, -12845, -28091, -31744, -21469, -13003, -7988, -4608, -2232, -414, 1008, 2021, 2594, 2787, 2727, 2557, 2417, 2398, 2492, 2658, 2888, 3174, 3424, 3503, 3371, 3244, 3262, 3260, 3161, 3769, 6072, 9164, 8969, 3938, -1203, -3916, -5374, -5384, -3474, -646, 2031, 4054, 5586, 6955, 8107, 8862, 8660, 6261, 2229, -486, -107, 2978, 7245, 9338, 8277, 5965, 3729, 2349, 1691, 1029, 94, -244, 586, -38, -4794, -17818, -29835, -23754, -14762, -9819, -6555, -4182, -2267, -511, 1183, 2719, 3833, 4109, 9371, 12830, 8312, 5651, 6152, 8333, 10922, 11905, 10364, 7883, 5423, 3671, 2724, 1996, 1345, 1678, 2798, 2812, 1375, -436, -1922, -3092, -4582, -6382, -6124, -2501, 1000, 2142, 2017, 1567, 1031, 502, 3, -523, -1050, -1445, -1530, -1267, -910, -771, -954, -1384, -1843, -2118, -2240, -2399, -2712, -2891, -2561, -2782, -5363, -13863, -29484, -31451, -20534, -12422, -7601, -4358, -2080, -347, 990, 1916, 2423, 2563, 2489, 2336, 2219, 2201, 2266, 2378, 2523, 2681, 2801, 2791, 2639, 2496, 2445, 2385, 2281, 2526, 3493, 4518, 4053, 2041, 231, -734, -1336, -1443, -715, 515, 1679, 2471, 2943, 3240, 3393, 3416, 3215, 2538, 1540, 897, 1063, 1961, 3293, 4767, 5957, 6332, 5993, 5939, 6633, 6989, 6050, 5904, 7482, 5655, -4895, -21560, -22200, -14604, -9703, -6694, -4631, -3043, -1648, -208, 1352, 2907, 4209, 4648, 11575, 17463, 12668, 9352, 9741, 10112, 9298, 8046, 6416, 4530, 2769, 1529, 808, 244};