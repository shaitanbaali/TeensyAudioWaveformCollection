/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0430 256 samples */
 
const int16_t AKWF_0430_256_DATA [256] = 
{5287, 15909, 17474, 10843, 3876, 2135, 2332, 4854, 6592, 5572, 5889, 7768, 11339, 17149, 18301, 18599, 20953, 20195, 20323, 20902, 21376, 21851, 22340, 22748, 23083, 23366, 23595, 23785, 24030, 24325, 24596, 24765, 24666, 24256, 23566, 22620, 21676, 18431, 16645, 15990, 15307, 14776, 14694, 13353, 11107, 9817, 7990, 6163, 6308, -1789, -25707, -25350, -22733, -23836, -22874, -20667, -17308, -13126, -7842, -5843, -9451, -17382, -24542, -21104, -20351, -19513, -18957, -18614, -18374, -18490, -14594, -10704, -10934, -10634, -10199, -9793, -11217, -12312, -13412, -12739, -14501, -16882, -17698, -19648, -17339, -16433, -18380, -19641, -20735, -21639, -22341, -22856, -23213, -23382, -23432, -23291, -23027, -20226, -18830, -17961, -17424, -12800, -8854, -8288, -7147, -6170, -5286, -4392, -4101, -5109, -6295, -4512, -450, -572, 90, 972, 2139, 3224, 5036, 7317, 6475, 5181, 3417, 1424, -1007, 1918, 427, -6462, 2795, 12528, 13184, 5762, -1981, -4461, -4968, -3028, -1825, -3252, -3384, -1954, 1173, 6503, 7230, 7189, 9170, 8163, 8145, 8654, 9169, 9739, 10365, 11053, 11748, 12408, 13136, 13899, 14702, 15605, 16561, 17392, 18033, 18408, 18520, 18351, 18231, 15830, 14900, 15095, 15311, 15729, 16555, 16175, 14840, 14418, 13457, 12363, 13236, 5774, -17620, -16735, -13673, -14322, -12929, -10263, -6460, -1888, 3773, 6027, 2655, -5135, -12285, -8877, -8248, -7626, -7392, -7467, -7677, -8309, -4982, -1683, -2511, -2838, -3068, -3377, -5588, -7467, -9402, -9538, -12114, -15346, -17041, -19892, -18560, -18624, -21493, -23631, -25589, -27323, -28801, -29987, -30931, -31661, -32148, -32428, -32580, -30200, -29273, -28837, -28721, -24464, -20794, -20448, -19398, -18418, -17496, -16461, -15909, -16612, -17402, -15109, -10476, -10004, -8699, -7208, -5406, -3656, -1114, 1906, 1877, 1387, 440, -686, -2222, 1622, 1043, -4631};