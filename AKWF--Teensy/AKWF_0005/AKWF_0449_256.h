/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0449 256 samples */
 
const int16_t AKWF_0449_256_DATA [256] = 
{5794, 9465, 10561, 11763, 13342, 14937, 16248, 17180, 17779, 18135, 18337, 18464, 18556, 18634, 18697, 18748, 18785, 18811, 18830, 18842, 18852, 18859, 18864, 18866, 18866, 18865, 18864, 18862, 18860, 18859, 18858, 18855, 18853, 18851, 18848, 18846, 18843, 18841, 18838, 18835, 18832, 18829, 18826, 18824, 18821, 18818, 18815, 18812, 18809, 18807, 18804, 18800, 18797, 18794, 18792, 18790, 18786, 18784, 18781, 18778, 18774, 18773, 18769, 18767, 18764, 18760, 18757, 18754, 18751, 18748, 18745, 18743, 18740, 18737, 18734, 18730, 18728, 18725, 18723, 18720, 18716, 18713, 18710, 18707, 18705, 18702, 18699, 18696, 18692, 18689, 18686, 18683, 18681, 18678, 18675, 18672, 18669, 18666, 18664, 18660, 18658, 18655, 18652, 18649, 18646, 18643, 18736, 18247, 21545, 27809, 29676, 28743, 27762, 28114, 28875, 29470, 29810, 29943, 29958, 29930, 29904, 29897, 29907, 29923, 29867, 29976, 29708, 9640, -9947, -15876, -18627, -20832, -23080, -25109, -26684, -27789, -28517, -28973, -29257, -29443, -29596, -29618, -30157, -31740, -32640, -32331, -26632, -21752, -22307, -23434, -23630, -23017, -21918, -20744, -19812, -19244, -18978, -18884, -18855, -18832, -18796, -18753, -18710, -18675, -18650, -18631, -18617, -18607, -18600, -18592, -18586, -18584, -18580, -18576, -18572, -18569, -18566, -18562, -18557, -18553, -18551, -18547, -18545, -18543, -18540, -18536, -18532, -18529, -18526, -18523, -18520, -18517, -18514, -18511, -18508, -18506, -18502, -18499, -18497, -18494, -18491, -18488, -18484, -18482, -18479, -18476, -18472, -18470, -18467, -18464, -18461, -18457, -18455, -18452, -18450, -18448, -18445, -18442, -18439, -18435, -18431, -18428, -18427, -18425, -18421, -18418, -18415, -18411, -18408, -18405, -18403, -18399, -18397, -18394, -18391, -18387, -18385, -18382, -18380, -18377, -18374, -18370, -18367, -18364, -18361, -18359, -18355, -18353, -18350, -18347, -18344, -18341, -18273, -18479, -17668, -4792};