/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0447 256 samples */
 
const int16_t AKWF_0447_256_DATA [256] = 
{2450, 7283, 11196, 14471, 17203, 19493, 21418, 23038, 24413, 25585, 26584, 27443, 28184, 28822, 29378, 29861, 30281, 30648, 30969, 31249, 31495, 31710, 31896, 32059, 32201, 32321, 32425, 32512, 32584, 32642, 32688, 32721, 32744, 32757, 32759, 32751, 32734, 32708, 32672, 32628, 32574, 32513, 32443, 32362, 32274, 32177, 32069, 31952, 31826, 31690, 31543, 31387, 31218, 31039, 30848, 30646, 30429, 30201, 29959, 29703, 29434, 29148, 28848, 28534, 28202, 27854, 27490, 27108, 26709, 26292, 25856, 25403, 24930, 24439, 23931, 23403, 22856, 22292, 21710, 21109, 20495, 19863, 19217, 18558, 17884, 17198, 16507, 15804, 15097, 14386, 13670, 12955, 12243, 11535, 10834, 10141, 9459, 8793, 8141, 7507, 6893, 6301, 5734, 5193, 4676, 4186, 3726, 3296, 2897, 2528, 2186, 1876, 1596, 1343, 1122, 927, 753, 609, 485, 380, 292, 224, 171, 130, 98, 72, 52, 37, 26, 19, 14, 5, -12, -43, -88, -147, -218, -309, -423, -555, -712, -893, -1102, -1335, -1601, -1895, -2220, -2572, -2960, -3376, -3821, -4295, -4797, -5327, -5886, -6469, -7072, -7698, -8343, -9005, -9683, -10372, -11072, -11781, -12494, -13211, -13929, -14643, -15358, -16066, -16767, -17459, -18143, -18811, -19469, -20112, -20739, -21351, -21946, -22522, -23083, -23625, -24147, -24653, -25139, -25605, -26056, -26485, -26896, -27292, -27669, -28029, -28373, -28699, -29010, -29306, -29586, -29852, -30104, -30342, -30566, -30778, -30976, -31162, -31338, -31501, -31654, -31796, -31926, -32047, -32158, -32259, -32351, -32434, -32507, -32572, -32626, -32673, -32710, -32738, -32757, -32766, -32766, -32756, -32736, -32706, -32664, -32609, -32543, -32463, -32367, -32256, -32127, -31979, -31810, -31616, -31395, -31145, -30860, -30536, -30166, -29742, -29257, -28701, -28055, -27305, -26430, -25398, -24175, -22712, -20935, -18760, -16056, -12640, -8230, -2843};