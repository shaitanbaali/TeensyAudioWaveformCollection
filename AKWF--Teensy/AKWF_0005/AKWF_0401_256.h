/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0401 256 samples */
 
const int16_t AKWF_0401_256_DATA [256] = 
{2027, 3599, 4340, 5485, 6601, 6637, 6752, 8226, 9648, 9989, 10656, 12772, 15064, 16925, 18082, 19054, 21515, 23896, 25566, 26850, 27532, 27626, 27997, 27994, 27770, 27503, 27971, 27832, 26415, 24469, 24022, 23887, 23649, 23231, 22032, 20609, 19947, 20668, 22081, 23425, 23976, 22709, 20954, 19191, 17997, 18369, 18717, 19176, 19645, 18578, 16643, 15704, 16606, 17022, 16845, 18107, 19363, 19719, 20225, 20594, 21774, 23744, 25112, 25209, 25238, 25874, 25701, 24881, 23597, 23056, 23713, 24127, 25088, 25849, 25134, 24587, 24755, 25596, 26853, 27372, 27755, 29143, 30555, 30666, 30983, 31551, 31254, 30175, 28839, 27884, 26722, 26262, 26170, 26495, 27164, 30000, 32078, 32607, 32732, 31370, 29565, 28760, 28069, 26855, 26066, 25369, 25013, 25030, 25154, 25805, 26635, 27780, 29018, 29256, 29509, 29272, 29633, 29922, 29773, 30028, 29251, 27960, 26153, 24238, 23973, 24893, 23600, 5720, -2628, -3453, -4331, -5485, -6602, -6638, -6753, -8227, -9648, -9990, -10656, -12773, -15065, -16926, -18083, -19054, -21515, -23896, -25566, -26850, -27532, -27626, -27997, -27994, -27771, -27503, -27971, -27832, -26415, -24469, -24023, -23887, -23650, -23232, -22033, -20609, -19947, -20668, -22081, -23425, -23976, -22709, -20954, -19191, -17998, -18370, -18718, -19177, -19645, -18578, -16644, -15705, -16606, -17022, -16846, -18107, -19364, -19720, -20225, -20594, -21775, -23745, -25112, -25209, -25238, -25874, -25701, -24882, -23597, -23057, -23713, -24127, -25088, -25849, -25134, -24588, -24755, -25596, -26853, -27372, -27755, -29144, -30555, -30666, -30983, -31551, -31254, -30175, -28840, -27884, -26722, -26262, -26170, -26495, -27164, -30000, -32078, -32607, -32732, -31370, -29565, -28760, -28069, -26855, -26066, -25369, -25013, -25030, -25154, -25806, -26636, -27780, -29018, -29256, -29509, -29272, -29633, -29922, -29774, -30028, -29251, -27960, -26153, -24239, -23973, -24903, -23591, -5740};