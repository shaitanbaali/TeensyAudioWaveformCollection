/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0438 256 samples */
 
const int16_t AKWF_0438_256_DATA [256] = 
{1480, 731, 727, 643, 122, 384, 401, 211, 108, 70, 236, 2837, 3984, 1012, 1426, 3090, 4012, 5075, 6158, 7197, 8233, 9254, 10257, 11249, 12223, 13179, 14121, 15043, 15947, 16834, 17699, 18546, 19373, 20179, 20962, 21726, 22466, 23183, 23878, 24548, 25194, 25818, 26415, 26988, 27537, 28058, 28553, 29023, 29465, 29882, 30270, 30631, 30965, 31271, 31548, 31798, 32020, 32212, 32377, 32512, 32619, 32697, 32747, 32767, 32759, 32722, 32656, 32561, 32438, 32285, 32104, 31895, 31657, 31390, 31096, 30774, 30424, 30047, 29642, 29211, 28754, 28268, 27757, 27221, 26658, 26071, 25459, 24821, 24160, 23477, 22768, 22036, 21284, 20508, 19712, 18895, 18055, 17198, 16321, 15422, 14508, 13576, 12624, 11658, 10674, 9674, 8661, 7632, 6590, 5536, 4468, 3392, 2319, 1124, 1858, 4229, 1596, -440, 147, 203, 275, 420, 327, 221, 805, 798, 818, 905, -1472, -739, -723, -644, -123, -385, -402, -212, -109, -71, -237, -2839, -3986, -1014, -1427, -3090, -4013, -5076, -6159, -7198, -8233, -9255, -10258, -11250, -12224, -13180, -14122, -15043, -15948, -16834, -17700, -18546, -19374, -20180, -20963, -21726, -22466, -23183, -23878, -24549, -25195, -25818, -26415, -26988, -27538, -28058, -28554, -29023, -29465, -29882, -30270, -30631, -30965, -31271, -31548, -31799, -32020, -32212, -32377, -32512, -32619, -32697, -32747, -32767, -32759, -32722, -32656, -32561, -32438, -32285, -32104, -31895, -31657, -31390, -31096, -30774, -30424, -30047, -29643, -29211, -28754, -28268, -27757, -27221, -26658, -26071, -25459, -24821, -24160, -23477, -22768, -22037, -21285, -20509, -19712, -18895, -18056, -17198, -16321, -15423, -14508, -13576, -12625, -11659, -10675, -9675, -8662, -7633, -6591, -5537, -4469, -3393, -2320, -1125, -1860, -4231, -1597, 440, -148, -204, -276, -421, -328, -222, -806, -806, -798, -958};