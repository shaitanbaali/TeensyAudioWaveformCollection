/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0439 256 samples */
 
const int16_t AKWF_0439_256_DATA [256] = 
{134, 1057, 2279, 3343, 4416, 5489, 6545, 7586, 8615, 9631, 10629, 11614, 12583, 13532, 14467, 15383, 16280, 17158, 18019, 18856, 19677, 20475, 21249, 22005, 22737, 23444, 24131, 24793, 25429, 26044, 26632, 27196, 27735, 28246, 28731, 29191, 29624, 30029, 30409, 30759, 31083, 31378, 31645, 31884, 32095, 32277, 32431, 32556, 32652, 32719, 32758, 32768, 32749, 32701, 32623, 32518, 32384, 32221, 32029, 31810, 31561, 31284, 30979, 30647, 30286, 29899, 29485, 29044, 28575, 28081, 27559, 27014, 26442, 25845, 25224, 24578, 23907, 23215, 22498, 21758, 20998, 20214, 19409, 18584, 17738, 16871, 15988, 15083, 14161, 13223, 12265, 11292, 10303, 9298, 8278, 7246, 6198, 5138, 4067, 2982, 1895, 759, -34, -40, 26, -5, -2, 0, -1, 0, 0, 3, -1, -20, 1202, -9, -1421, 209, 90, -69, 16, 1, -3, 0, -1, -1, -6, 10, -133, -1058, -2279, -3344, -4416, -5490, -6546, -7587, -8616, -9632, -10629, -11615, -12583, -13533, -14467, -15384, -16281, -17159, -18019, -18857, -19677, -20476, -21249, -22005, -22737, -23445, -24132, -24793, -25430, -26044, -26632, -27196, -27735, -28246, -28731, -29191, -29624, -30029, -30409, -30759, -31083, -31378, -31645, -31884, -32095, -32277, -32431, -32556, -32652, -32719, -32758, -32768, -32749, -32701, -32623, -32518, -32384, -32221, -32029, -31810, -31561, -31284, -30979, -30647, -30286, -29899, -29485, -29044, -28575, -28081, -27560, -27014, -26442, -25845, -25224, -24578, -23907, -23215, -22498, -21758, -20998, -20214, -19409, -18585, -17738, -16872, -15989, -15084, -14161, -13224, -12266, -11292, -10304, -9299, -8279, -7247, -6198, -5139, -4068, -2983, -1896, -760, 33, 39, -27, 4, 1, -1, 0, -1, -1, -4, 0, 19, -1201, 11, 1421, -211, -91, 68, -17, -2, 2, -1, 0, 0, -1, 0};