/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0461 256 samples */
 
const int16_t AKWF_0461_256_DATA [256] = 
{2317, 8262, 13970, 19317, 24046, 27911, 30710, 32332, 32754, 31925, 29898, 26817, 22895, 18391, 13468, 8349, 3297, -1483, -5802, -9502, -12495, -14768, -16327, -17200, -17432, -17137, -16443, -15423, -14160, -12771, -11336, -9890, -8450, -7034, -5635, -4234, -2817, -1355, 170, 1754, 3406, 5101, 6795, 8454, 10017, 11392, 12470, 13252, 13779, 13984, 13779, 13140, 12081, 10638, 8867, 6819, 4567, 2181, -262, -2651, -4901, -6944, -8695, -10071, -11050, -11674, -11992, -12023, -11761, -11206, -10386, -9323, -8027, -6598, -5114, -3584, -2011, -400, 1171, 2625, 3959, 5172, 6242, 7171, 7965, 8541, 8864, 8963, 8859, 8519, 7900, 7086, 6138, 5014, 3744, 2400, 1044, -277, -1525, -2658, -3638, -4440, -5039, -5421, -5586, -5539, -5295, -4870, -4279, -3622, -3077, -2464, -1523, -358, 832, 1974, 3065, 4102, 5072, 5947, 6693, 7398, 8175, 8900, 9397, 9589, 9473, 9117, 8460, 7404, 6092, 4648, 3057, 1287, -640, -2631, -4582, -6513, -8408, -10189, -11757, -13017, -13990, -14680, -15021, -14966, -14504, -13623, -12323, -10705, -8844, -6762, -4516, -2224, 4, 2141, 4150, 5925, 7402, 8585, 9468, 10042, 10318, 10310, 10044, 9553, 8871, 8033, 7075, 6027, 4922, 3781, 2634, 1463, 177, -1078, -2145, -3046, -3829, -4504, -5058, -5480, -5768, -5927, -5969, -5915, -5770, -5531, -5201, -4786, -4286, -3684, -2994, -2270, -1559, -879, -224, 421, 1051, 1666, 2280, 2838, 3302, 3687, 4006, 4275, 4450, 4491, 4417, 4239, 3957, 3596, 3170, 2651, 2036, 1367, 674, -42, -792, -1514, -2159, -2750, -3266, -3673, -3946, -4074, -4055, -3890, -3591, -3169, -2639, -2028, -1358, -661, 34, 705, 1238, 1218, 298, -1135, -2660, -4277, -6111, -8208, -10521, -12914, -15231, -17303, -18907, -19749, -19560, -18284, -15962, -12639, -8396, -3198};