/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0473 256 samples */
 
const int16_t AKWF_0473_256_DATA [256] = 
{1, 2, 3, 4, 4, 5, 4, 4, 5, 4, 3, 3, 4, 3, 2, 3, 2, 1, 2, 1, 1, 2, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 19, -27, 485, 3613, 6512, 7020, 7645, 8742, 9702, 10502, 11202, 11799, 12286, 12673, 12979, 13213, 13382, 13494, 13555, 13574, 13557, 13512, 13445, 13360, 13262, 13156, 13044, 12930, 12817, 12706, 12599, 12498, 12403, 12315, 12236, 12165, 12104, 12051, 12008, 11974, 11950, 11937, 11933, 11940, 11957, 11987, 12027, 12080, 12146, 12226, 12321, 12430, 12555, 12694, 12849, 13018, 13203, 13403, 13617, 13847, 14090, 14349, 14622, 14909, 15211, 15506, 15765, 16391, 9031, -7399, -8645, -5957, -11945, -13692, -13112, -14539, -15689, -16175, -16437, -16558, -16541, -16409, -16188, -15904, -15572, -15210, -14834, -14457, -14091, -13744, -13420, -13123, -12857, -12623, -12421, -12252, -12113, -12004, -11923, -11866, -11833, -11819, -11823, -11842, -11874, -11916, -11966, -12021, -12080, -12141, -12202, -12262, -12318, -12370, -12416, -12453, -12482, -12498, -12502, -12491, -12462, -12411, -12335, -12228, -12083, -11890, -11642, -11327, -10931, -10437, -9809, -8996, -7913, -6324, -3537, -759, -744, -1192, -430, 231, 567, 818, 1005, 1116, 1168, 1183, 1166, 1122, 1056, 974, 884, 787, 690, 594, 501, 414, 334, 259, 194, 136, 85, 43, 8, -21, -44, -61, -74, -82, -87, -89, -88, -85, -81, -76, -70, -63, -57, -50, -43, -37, -31, -26, -21, -16, -12, -9, -6, -4, -1};