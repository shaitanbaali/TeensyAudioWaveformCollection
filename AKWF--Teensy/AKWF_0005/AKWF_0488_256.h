/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0488 256 samples */
 
const int16_t AKWF_0488_256_DATA [256] = 
{589, 1591, 2418, 3084, 3572, 3877, 4000, 3948, 3730, 3363, 2870, 2274, 1602, 886, 154, -564, -1238, -1842, -2350, -2740, -2996, -3105, -3058, -2853, -2490, -1975, -1319, -538, 352, 1334, 2379, 3466, 4573, 5672, 6742, 7764, 8712, 9576, 10342, 10998, 11541, 11968, 12280, 12486, 12591, 12610, 12556, 12445, 12296, 12128, 11959, 11807, 11690, 11625, 11623, 11698, 11859, 12110, 12455, 12892, 13418, 14029, 14452, 16771, 8505, 283, 6366, 6287, 3113, -2623, -7622, -9968, -11208, -13232, -16360, -19496, -21510, -22345, -22721, -23147, -23486, -23278, -22303, -20753, -18939, -17004, -14879, -12461, -9807, -7079, -4413, -1877, 533, 2808, 4875, 6661, 8127, 9258, 10072, 10576, 10767, 10652, 10260, 9636, 8824, 7868, 6814, 5704, 4591, 3528, 2554, 1709, 1027, 530, 241, 174, 330, 707, 1292, 2069, 3013, 4093, 5282, 6538, 7824, 9106, 10342, 11500, 12547, 13454, 14198, 14763, 15135, 15309, 15286, 15074, 14681, 14129, 13440, 12637, 11749, 10811, 9849, 8896, 7988, 7144, 6396, 5766, 5268, 4918, 4724, 4689, 4811, 5084, 5498, 6036, 6679, 7409, 8198, 9023, 9861, 10682, 11466, 12191, 12835, 13382, 13820, 14137, 14331, 14397, 14340, 14165, 13884, 13507, 13050, 12532, 11973, 11390, 10804, 10238, 9705, 9227, 8816, 8486, 8245, 8101, 8057, 8111, 8263, 8505, 8578, 10489, 2197, -6038, -466, -830, -4172, -9980, -15068, -17589, -19037, -21237, -24494, -27756, -29928, -30955, -31537, -32159, -32690, -32686, -31935, -30620, -29043, -27341, -25445, -23257, -20832, -18323, -15865, -13521, -11289, -9176, -7254, -5594, -4236, -3191, -2443, -1988, -1829, -1959, -2351, -2964, -3754, -4680, -5698, -6766, -7837, -8858, -9791, -10598, -11247, -11714, -11978, -12027, -11855, -11468, -10876, -10093, -9145, -8058, -6861, -5593, -4288, -2980, -1710, -487};