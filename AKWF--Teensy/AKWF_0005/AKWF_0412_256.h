/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0412 256 samples */
 
const int16_t AKWF_0412_256_DATA [256] = 
{18, 56, 90, 121, 147, 170, 190, 205, 217, 225, 230, 232, 231, 229, 223, 217, 210, 202, 202, 267, 61, 3240, 19042, 32263, 31160, 24971, 18370, 13625, 8750, 1121, -6892, -12292, -14623, -15386, -15894, -16402, -16786, -16998, -17057, -16983, -16798, -16534, -16222, -15873, -15482, -15028, -14474, -13783, -12908, -11729, -10041, -7875, -5821, -4274, -2742, -757, 1347, 3118, 4304, 5093, 5804, 6547, 7288, 7961, 8511, 8912, 9176, 9319, 9354, 9294, 9144, 8912, 8602, 8223, 7794, 7331, 6862, 6411, 5989, 5593, 5217, 4852, 4499, 4199, 3654, 6121, 18730, 28940, 26279, 18783, 14153, 11286, 6395, -218, -6087, -10213, -12775, -14008, -14596, -14988, -15258, -15398, -15431, -15383, -15263, -15074, -14816, -14480, -14060, -13541, -12893, -12066, -10964, -9477, -7723, -6113, -4890, -3850, -2583, -976, 591, 1992, 3162, 3966, 4512, 4965, 5373, 5730, 6027, 6261, 6433, 6539, 6577, 6553, 6473, 6345, 6180, 5986, 5771, 5541, 5299, 5051, 4796, 4535, 4268, 3990, 3704, 3455, 2917, 5447, 19987, 32322, 31156, 25268, 18689, 13735, 8748, 1013, -7135, -12562, -14811, -15524, -16046, -16594, -17019, -17266, -17342, -17264, -17060, -16770, -16434, -16070, -15676, -15233, -14704, -14049, -13226, -12140, -10596, -8496, -6310, -4617, -3123, -1210, 940, 2835, 4148, 4992, 5717, 6475, 7244, 7952, 8537, 8968, 9256, 9419, 9473, 9429, 9294, 9075, 8777, 8407, 7979, 7510, 7027, 6559, 6119, 5710, 5323, 4950, 4586, 4224, 3853, 3461, 3030, 2545, 2015, 1469, 952, 509, 162, -110, -362, -623, -880, -1114, -1312, -1475, -1604, -1701, -1769, -1810, -1826, -1821, -1794, -1751, -1693, -1619, -1534, -1439, -1336, -1229, -1117, -1005, -892, -783, -678, -577, -484, -396, -316, -243, -178, -118, -67, -21};