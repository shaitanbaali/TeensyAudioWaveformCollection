/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0490 256 samples */
 
const int16_t AKWF_0490_256_DATA [256] = 
{2421, 1540, 1910, 4093, 5462, 6101, 5673, 8300, 14111, 19026, 22942, 26130, 28476, 30180, 31419, 32244, 32662, 32622, 31807, 30187, 28385, 11349, 6448, 15218, 11301, 1253, -7227, -19279, -28459, -30360, -32121, -29101, -24744, -24469, -24668, -24627, -24731, -24979, -25798, -28823, -32496, -31170, -24113, -11412, -3255, -896, 2970, 6620, 15085, 26698, 31373, 32460, 32568, 31617, 30641, 30570, 31403, 32411, 32683, 31794, 29413, 24616, 15930, 6740, 4446, 2965, 565, -1451, -2585, -4462, -5903, -6257, -6197, -6175, -6210, -5804, -4745, -3094, -1495, -1289, 1091, 2055, 2935, 5101, 6127, 5962, 5109, 5214, 5540, 5139, 5419, 6195, 5523, 3719, 1803, 1107, -1028, -2380, -4187, -6051, -6193, -10434, -16955, -20988, -23561, -25189, -25917, -25957, -25338, -23969, -21676, -18280, -13649, -8094, -5170, -5838, -4708, -2381, -1233, -1760, 1454, 2155, 768, 1961, 2550, 2659, 2619, 2289, 1740, 1002, 1164, 2726, -494, -3054, -834, -1494, -2930, -3654, -4324, -4795, -5033, -5082, -4936, -4578, -3999, -3195, -2193, -1076, -1645, -1572, 2393, 1644, 1428, 3358, 4470, 5349, 6002, 6254, 6106, 5729, 5460, 5466, 5714, 6065, 6256, 6117, 5694, 5084, 4339, 3517, 2682, 1895, 1230, 790, 737, 1522, 3095, 3881, 3682, 2791, 1276, 610, 816, 1222, 1770, 2404, 3048, 3663, 4217, 4685, 5052, 5314, 5472, 5531, 5491, 5349, 5092, 4705, 4184, 3533, 2769, 1937, 1076, 982, 2828, 1153, -3218, -2187, -391, -1420, -2184, -2704, -3252, -3676, -3996, -4232, -4385, -4469, -4494, -4474, -4419, -4340, -4252, -4166, -4093, -4046, -4032, -4058, -4130, -4250, -4416, -4619, -4856, -5114, -5379, -5634, -5863, -6050, -6180, -6248, -6256, -6229, -6205, -6212, -6243, -6251, -6172, -5950, -5559, -4981, -4212, -3270, -2184, -1060, -1696, -1401};