/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0427 256 samples */
 
const int16_t AKWF_0427_256_DATA [256] = 
{429, 1586, 3173, 5056, 7146, 9372, 11666, 13958, 16201, 18351, 20363, 22223, 23909, 25409, 26731, 27874, 28846, 29665, 30345, 30899, 31347, 31703, 31981, 32197, 32360, 32481, 32571, 32634, 32680, 32710, 32731, 32744, 32752, 32757, 32759, 32761, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32761, 32761, 32761, 32761, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32763, 32762, 32762, 32762, 32762, 32762, 32762, 32761, 32759, 32755, 32747, 32730, 32705, 32662, 32598, 32506, 32375, 32201, 31970, 31674, 31304, 30849, 30301, 29654, 28900, 28035, 27060, 25971, 24769, 23464, 22058, 20558, 18985, 17341, 15648, 13928, 12192, 10467, 8779, 7144, 5593, 4154, 2850, 1720, 798, 176, -128, -687, -1556, -2612, -3816, -5139, -6543, -8003, -9501, -11007, -12509, -13990, -15429, -16821, -18156, -19420, -20616, -21737, -22776, -23743, -24632, -25445, -26187, -26862, -27469, -28018, -28511, -28951, -29345, -29695, -30006, -30282, -30524, -30739, -30928, -31094, -31239, -31366, -31478, -31573, -31657, -31729, -31791, -31843, -31888, -31924, -31954, -31977, -31995, -32006, -32012, -32012, -32008, -31998, -31982, -31963, -31937, -31905, -31866, -31822, -31770, -31709, -31641, -31566, -31473, -31424, -31562, -31769, -31983, -32204, -32407, -32571, -32680, -32738, -32758, -32762, -32762, -32759, -32744, -32700, -32612, -32481, -32314, -32133, -31964, -31830, -31749, -31731, -31775, -31872, -32005, -32158, -32311, -32449, -32564, -32649, -32707, -32739, -32755, -32761, -32762, -32762, -32762, -32758, -32746, -32717, -32664, -32571, -32430, -32227, -31950, -31586, -31125, -30552, -29856, -29027, -28054, -26931, -25646, -24201, -22596, -20832, -18922, -16891, -14753, -12551, -10330, -8130, -6020, -4069, -2349, -956, -107};