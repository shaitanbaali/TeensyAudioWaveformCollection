/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0458 256 samples */
 
const int16_t AKWF_0458_256_DATA [256] = 
{2951, 6517, 8069, 9445, 10577, 11556, 12425, 13203, 13915, 14578, 15196, 15779, 16332, 16855, 17363, 17852, 18324, 18784, 19231, 19669, 20099, 20520, 20935, 21341, 21745, 22144, 22539, 22932, 23318, 23705, 24091, 24476, 24859, 25242, 25625, 26010, 26392, 26780, 27012, 26161, 23150, 15901, -5131, -16425, -19763, -22341, -23368, -23449, -23121, -22821, -22816, -23145, -23637, -24057, -24254, -24191, -23914, -23504, -23036, -22572, -22147, -21767, -21418, -21080, -20730, -20355, -19953, -19526, -19079, -18619, -18149, -17673, -17189, -16690, -16172, -15631, -15057, -14451, -13797, -13083, -12284, -11369, -10199, -8093, -6130, 101, 5945, 7513, 9021, 10219, 11245, 12146, 12952, 13685, 14362, 14994, 15589, 16151, 16683, 17196, 17691, 18168, 18633, 19083, 19524, 19957, 20380, 20798, 21207, 21610, 22012, 22408, 22801, 23190, 23576, 23962, 24348, 24732, 25114, 25497, 25881, 26265, 26649, 26994, 26639, 24354, 19626, 2473, -14675, -18548, -21695, -23160, -23492, -23246, -22897, -22777, -23006, -23471, -23937, -24217, -24240, -24026, -23650, -23193, -22724, -22283, -21889, -21533, -21193, -20849, -20483, -20089, -19671, -19230, -18773, -18307, -17833, -17351, -16858, -16347, -15814, -15253, -14657, -14020, -13329, -12562, -11684, -10660, -8874, -6850, -2643, 4770, 7020, 8558, 9843, 10920, 11856, 12693, 13448, 14141, 14788, 15395, 15966, 16509, 17026, 17528, 18011, 18480, 18934, 19378, 19814, 20240, 20659, 21072, 21476, 21879, 22276, 22670, 23062, 23447, 23834, 24220, 24603, 24987, 25370, 25753, 26138, 26519, 26903, 26910, 25396, 21747, 10012, -11094, -17460, -20855, -22825, -23472, -23361, -23001, -22779, -22893, -23303, -23795, -24151, -24261, -24119, -23788, -23350, -22879, -22425, -22016, -21648, -21305, -20966, -20608, -20223, -19814, -19379, -18926, -18464, -17991, -17512, -17025, -16520, -15994, -15444, -14859, -14238, -13567, -12828, -11990, -11036, -9628, -7396, -4839};