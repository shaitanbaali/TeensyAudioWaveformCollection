/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0426 256 samples */
 
const int16_t AKWF_0426_256_DATA [256] = 
{505, 2365, 4151, 5904, 7613, 9278, 10897, 12462, 13976, 15436, 16835, 18181, 19468, 20691, 21857, 22962, 24003, 24986, 25908, 26766, 27566, 28306, 28986, 29608, 30171, 30676, 31126, 31520, 31858, 32142, 32372, 32548, 32672, 32743, 32762, 32730, 32645, 32508, 32319, 32079, 31786, 31441, 31045, 30595, 30092, 29537, 28929, 28267, 27552, 26783, 25961, 25087, 24160, 23182, 22154, 21074, 19946, 18773, 17551, 16286, 14982, 13634, 12252, 10837, 9388, 7913, 6415, 4892, 3357, 1808, 247, -1296, -2802, -4264, -5674, -7037, -8351, -9608, -10812, -11961, -13050, -14085, -15061, -15976, -16834, -17631, -18369, -19047, -19667, -20225, -20725, -21166, -21548, -21872, -22136, -22343, -22493, -22585, -22620, -22598, -22521, -22387, -22196, -21949, -21647, -21290, -20879, -20411, -19890, -19316, -18688, -18006, -17274, -16490, -15654, -14773, -13840, -12861, -11840, -10773, -9665, -8519, -7334, -6116, -4868, -3587, -2285, -958, 385, 1720, 3033, 4325, 5587, 6818, 8018, 9179, 10304, 11390, 12430, 13428, 14380, 15284, 16139, 16946, 17699, 18404, 19054, 19651, 20195, 20687, 21121, 21502, 21827, 22097, 22312, 22470, 22572, 22618, 22607, 22539, 22414, 22232, 21991, 21692, 21335, 20920, 20445, 19912, 19319, 18665, 17954, 17181, 16349, 15459, 14508, 13498, 12434, 11309, 10127, 8894, 7604, 6262, 4872, 3429, 1943, 415, -1144, -2698, -4238, -5768, -7277, -8762, -10223, -11652, -13049, -14412, -15734, -17016, -18258, -19451, -20599, -21700, -22749, -23750, -24699, -25594, -26439, -27231, -27968, -28653, -29285, -29861, -30387, -30860, -31279, -31646, -31961, -32223, -32434, -32593, -32699, -32755, -32758, -32709, -32608, -32454, -32247, -31986, -31671, -31301, -30875, -30394, -29855, -29258, -28604, -27889, -27115, -26282, -25387, -24430, -23416, -22336, -21197, -19999, -18738, -17418, -16042, -14606, -13115, -11573, -9975, -8330, -6641, -4906, -3136, -1291};