/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0466 256 samples */
 
const int16_t AKWF_0466_256_DATA [256] = 
{925, 3232, 5069, 6582, 7836, 8887, 9782, 10555, 11249, 11898, 12525, 13131, 13695, 14186, 14577, 14840, 14950, 14887, 14632, 14176, 13516, 12663, 11641, 10470, 9185, 7819, 6403, 4975, 3568, 2210, 929, -257, -1335, -2292, -3128, -3842, -4435, -4916, -5293, -5575, -5774, -5899, -5958, -5963, -5920, -5837, -5718, -5569, -5396, -5202, -4990, -4765, -4529, -4286, -4041, -3797, -3557, -3325, -3104, -2897, -2706, -2532, -2377, -2241, -2123, -2021, -1934, -1861, -1796, -1738, -1682, -1626, -1566, -1499, -1422, -1332, -1227, -1106, -967, -810, -636, -443, -233, -8, 231, 483, 744, 1015, 1290, 1567, 1846, 2120, 2389, 2650, 2900, 3135, 3357, 3557, 3794, 4745, 7526, 12114, 16933, 20328, 21671, 21067, 18872, 15466, 11108, 5914, 65, -5921, -11402, -15969, -19465, -21922, -23448, -24103, -23918, -22931, -21270, -19139, -16737, -14227, -11701, -9214, -6838, -4633, -2649, -923, 563, 1852, 2976, 3974, 4869, 5680, 6433, 7149, 7835, 8494, 9111, 9662, 10131, 10496, 10740, 10852, 10814, 10622, 10273, 9774, 9140, 8384, 7530, 6600, 5615, 4601, 3583, 2578, 1609, 690, -170, -959, -1675, -2313, -2875, -3365, -3785, -4138, -4433, -4674, -4865, -5013, -5122, -5197, -5239, -5254, -5242, -5208, -5153, -5081, -4992, -4890, -4778, -4656, -4530, -4402, -4271, -4143, -4017, -3895, -3778, -3667, -3561, -3459, -3359, -3261, -3162, -3062, -2956, -2844, -2724, -2592, -2447, -2288, -2113, -1921, -1711, -1484, -1240, -978, -700, -407, -101, 217, 546, 883, 1227, 1573, 1921, 2267, 2609, 2944, 3271, 3586, 3891, 4177, 4531, 6008, 10363, 17574, 25168, 30541, 32717, 31892, 28650, 23602, 17165, 9515, 921, -7820, -15724, -22168, -26933, -30102, -31866, -32344, -31593, -29688, -26832, -23347, -19545, -15676, -11875, -8224, -4816, -1688};