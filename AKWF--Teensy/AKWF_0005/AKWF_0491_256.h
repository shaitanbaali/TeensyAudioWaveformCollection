/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0491 256 samples */
 
const int16_t AKWF_0491_256_DATA [256] = 
{-11374, -25856, -32064, -32420, -29251, -24337, -19157, -14551, -10535, -6857, -3486, -576, 1677, 3193, 4023, 4278, 4089, 3587, 2904, 2156, 1421, 768, 236, -163, -431, -586, -646, -633, -568, -469, -357, -244, -140, -55, 12, 57, 82, 96, 104, 104, 44, 2026, 4475, 5447, 5519, 5057, 4326, 3497, 2666, 1878, 1167, 558, 66, -297, -541, -672, -712, -680, -593, -479, -350, -225, -117, -28, 37, 76, 101, 108, 108, 100, 83, 66, 45, 49, -90, 1558, 4140, 5272, 5454, 5060, 4372, 3567, 2746, 1965, 1252, 635, 133, -246, -500, -648, -699, -677, -599, -487, -363, -238, -130, -39, 29, 71, 97, 107, 108, 102, 85, 66, 45, 58, -108, 1207, 3921, 5250, 5533, 5194, 4524, 3720, 2886, 2087, 1358, 718, 195, -204, -476, -641, -706, -693, -620, -512, -385, -257, -144, -51, 22, 65, 95, 108, 110, 104, 89, 71, 50, 29, 13, 2, 7, -32, 119, 2502, 4698, 5478, 5445, 4926, 4177, 3354, 2526, 1753, 1060, 470, 1, -343, -568, -684, -709, -668, -574, -457, -327, -206, -101, -14, 45, 80, 103, 109, 109, 98, 81, 62, 40, 21, 8, -3, -6, -8, -10, 2, -49, 168, 2624, 4758, 5500, 5438, 4906, 4150, 3322, 2496, 1726, 1035, 448, -14, -353, -572, -687, -711, -666, -569, -451, -322, -201, -95, -11, 47, 82, 104, 109, 109, 99, 81, 61, 48, 14, 40, 2212, 4514, 5380, 5401, 4920, 4195, 3382, 2564, 1795, 1102, 512, 35, -313, -542, -667, -699, -663, -576, -460, -334, -212, -108, -21, 40, 78, 100, 107, 108, 99, 81, 62, 40, 23, 10};