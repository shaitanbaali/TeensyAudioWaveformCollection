/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0424 256 samples */
 
const int16_t AKWF_0424_256_DATA [256] = 
{1844, 4100, 4938, 4980, 5389, 6348, 7400, 8156, 8455, 8505, 8614, 8853, 9101, 9232, 9196, 9069, 8946, 8852, 8750, 8596, 8378, 8123, 7865, 7612, 7355, 7079, 6780, 6471, 6163, 5862, 5563, 5264, 4963, 4666, 4377, 4097, 3829, 3569, 3318, 3077, 2849, 2634, 2433, 2244, 2066, 1901, 1750, 1611, 1485, 1372, 1269, 1177, 1097, 1026, 966, 916, 873, 839, 813, 793, 780, 773, 772, 774, 782, 793, 808, 768, 934, 320, -10701, -20420, -19142, -15144, -11145, -6978, -6536, -7226, -5423, -2957, -921, 200, -133, -475, 136, 1141, 2037, 2528, 2609, 2699, 3019, 3439, 3797, 3985, 4031, 4068, 4157, 4270, 4350, 4362, 4324, 4276, 4238, 4204, 4154, 4078, 3982, 3881, 3783, 3686, 3582, 3469, 3352, 3234, 3120, 3007, 2895, 2783, 2672, 2564, 2461, 2361, 2265, 2173, 2085, 2001, 1922, 1849, 1780, 1715, 1655, 1600, 1549, 1503, 1461, 1423, 1390, 1360, 1334, 1311, 1292, 1276, 1263, 1252, 1243, 1238, 1234, 1232, 1232, 1234, 1238, 1242, 1233, 1156, 1651, -5653, -18386, -20136, -16233, -12394, -7880, -6015, -7027, -6024, -3531, -1347, 191, 249, -309, -11, 923, 1874, 2512, 2680, 2709, 2945, 3341, 3726, 3967, 4040, 4060, 4125, 4231, 4322, 4354, 4323, 4271, 4227, 4191, 4146, 4076, 3984, 3882, 3782, 3684, 3582, 3473, 3358, 3239, 3124, 3012, 2901, 2790, 2679, 2571, 2468, 2368, 2272, 2180, 2092, 2008, 1929, 1855, 1785, 1721, 1661, 1605, 1554, 1508, 1466, 1428, 1395, 1364, 1337, 1315, 1295, 1278, 1265, 1254, 1245, 1240, 1236, 1235, 1234, 1236, 1238, 1242, 1246, 996, 2282, -6866, -28721, -33025, -30882, -27635, -21942, -16561, -17648, -17566, -13062, -7803, -3103, -1529, -3103, -3249, -954};