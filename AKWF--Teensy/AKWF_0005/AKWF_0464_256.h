/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0464 256 samples */
 
const int16_t AKWF_0464_256_DATA [256] = 
{8131, 16080, 17848, 18737, 21867, 26757, 29957, 28405, 22417, 15120, 9360, 5622, 2606, -1075, -5696, -10248, -13394, -14587, -14335, -13571, -12831, -12028, -10786, -8925, -6682, -4523, -2809, -1606, -729, 18, 671, 1144, 1363, 1355, 1268, 1307, 1732, 2714, 4736, 7892, 10013, 8468, 3801, -828, -3172, -3509, -3400, -4061, -5581, -6972, -7042, -5531, -3308, -1441, -329, 362, 1152, 2256, 3454, 4306, 4546, 4271, 3794, 3354, 2971, 2524, 1916, 1174, 441, -141, -535, -785, -969, -1122, -1218, -1225, -1175, -1315, -2318, -5335, -12650, -24387, -32691, -28396, -12701, 4180, 14307, 17551, 18278, 20521, 25114, 29321, 29512, 24735, 17485, 11031, 6699, 3636, 274, -4099, -8825, -12557, -14393, -14519, -13836, -13068, -12327, -11268, -9605, -7447, -5203, -3319, -1961, -997, -220, 468, 1015, 1321, 1374, 1294, 1264, 1538, 2310, 3904, 6799, 9622, 9443, 5526, 517, -2672, -3525, -3391, -3721, -5023, -6607, -7206, -6171, -4053, -1982, -625, 146, 854, 1859, 3074, 4085, 4537, 4405, 3959, 3493, 3101, 2691, 2138, 1430, 676, 33, -422, -710, -912, -1074, -1191, -1233, -1187, -1211, -1836, -3981, -9588, -20315, -31004, -31420, -18625, -945, 11841, 17009, 18011, 19473, 23439, 28213, 30036, 26776, 19958, 12955, 7925, 4624, 1498, -2545, -7289, -11503, -14003, -14615, -14095, -13314, -12589, -11676, -10229, -8201, -5927, -3891, -2359, -1287, -467, 250, 855, 1249, 1379, 1326, 1254, 1398, 1990, 3235, 5717, 8877, 9965, 7127, 2090, -1895, -3437, -3443, -3501, -4502, -6127, -7180, -6685, -4810, -2609, -990, -78, 594, 1488, 2666, 3796, 4456, 4499, 4121, 3639, 3225, 2838, 2341, 1679, 922, 225, -292, -628, -851, -1024, -1159, -1231, -1210, -1176, -1513, -3009, -7168, -16295, -28099, -32898, -24028, -6551};