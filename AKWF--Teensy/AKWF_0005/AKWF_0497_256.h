/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0497 256 samples */
 
const int16_t AKWF_0497_256_DATA [256] = 
{-16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16272, -16880, -14396, -104, -188, 1061, -11176, -17444, -16148, -16383, -16383, -16383, -16383, -16383, -16383, -16093, -17656, -6732, 1226, -515, 1060, -5208, -17476, -16140, -16383, -16383, -16383, -16209, -17193, -12794, 672, -138, -5, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -32, 55, -104, -14396, -16880, -16272, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16161, -17394, -4790, 1002, -221, 0, 0, 0, 0, 0, 0, -281, 1237, -10095, -17570, -16115, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16384, -16594, -15420, -28184, -33739, -32554, -32482, -34025, -22893, -15176, -16658, -16383, -16216, -17159, -12984, 602, -121, -7, 0, 0, 0, 0, 0, 0, 0, 0, 0, -14, -62, 368, -13539, -17055, -16238, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16338, -16522, -15945, -1517, 393, -92, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -41, 109, -323, -14714, -16811, -16285, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16383, -16141, -17472, -10963, 1128, -253, 0, 0, 0, 182, -843, 3783, 16931, 17105, 12400, -801, 169, 1, 0, 0, 0, 0, 0, 0, 0};