/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0444 256 samples */
 
const int16_t AKWF_0444_256_DATA [256] = 
{500, 1277, 2024, 2760, 3478, 4181, 4867, 5534, 6185, 6820, 7436, 8038, 8624, 9193, 9748, 10289, 10815, 11329, 11829, 12317, 12793, 13256, 13708, 14149, 14580, 14999, 15410, 15810, 16200, 16583, 16955, 17319, 17675, 18023, 18364, 18696, 19020, 19339, 19651, 19954, 20252, 20545, 20829, 21108, 21382, 21649, 21912, 22169, 22419, 22666, 22908, 23143, 23377, 23605, 23827, 24046, 24261, 24471, 24676, 24879, 25078, 25274, 25464, 25652, 25837, 26018, 26195, 26370, 26541, 26710, 26875, 27037, 27196, 27353, 27507, 27658, 27807, 27953, 28097, 28239, 28377, 28514, 28649, 28781, 28910, 29038, 29164, 29288, 29409, 29530, 29647, 29763, 29878, 29990, 30100, 30209, 30315, 30422, 30525, 30628, 30728, 30827, 30925, 31022, 31116, 31210, 31302, 31393, 31482, 31570, 31656, 31741, 31826, 31909, 31991, 32071, 32151, 32230, 32306, 32382, 32457, 32531, 32589, 32362, 34027, 18976, -4660, -12776, -17100, -19946, -22584, -25115, -27234, -28818, -29907, -30602, -31027, -31281, -31436, -31535, -31595, -31626, -31628, -31608, -31569, -31515, -31450, -31378, -31301, -31218, -31133, -31044, -30954, -30861, -30764, -30667, -30568, -30466, -30363, -30257, -30151, -30042, -29931, -29820, -29704, -29589, -29471, -29351, -29229, -29105, -28979, -28852, -28722, -28590, -28455, -28318, -28180, -28038, -27894, -27747, -27599, -27447, -27292, -27135, -26976, -26814, -26649, -26479, -26308, -26133, -25956, -25775, -25590, -25402, -25210, -25014, -24816, -24613, -24406, -24196, -23981, -23762, -23539, -23310, -23078, -22841, -22599, -22351, -22099, -21842, -21579, -21312, -21037, -20757, -20472, -20179, -19880, -19576, -19264, -18945, -18620, -18286, -17945, -17597, -17239, -16874, -16500, -16116, -15726, -15324, -14912, -14492, -14060, -13616, -13163, -12698, -12220, -11731, -11229, -10713, -10184, -9640, -9082, -8510, -7921, -7315, -6694, -6053, -5395, -4719, -4020, -3304, -2566, -1808, -1038, -250};