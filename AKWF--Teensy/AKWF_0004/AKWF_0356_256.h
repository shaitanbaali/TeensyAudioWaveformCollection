/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0356 256 samples */
 
const int16_t AKWF_0356_256_DATA [256] = 
{567, 2585, 4500, 6328, 8048, 9660, 11167, 12568, 13877, 15101, 16241, 17308, 18309, 19244, 20125, 20952, 21727, 22460, 23148, 23797, 24408, 24985, 25527, 26039, 26521, 26975, 27403, 27805, 28181, 28536, 28868, 29177, 29467, 29736, 29985, 30216, 30428, 30623, 30801, 30961, 31106, 31234, 31347, 31445, 31528, 31597, 31652, 31692, 31720, 31734, 31736, 31725, 31702, 31667, 31621, 31562, 31493, 31413, 31322, 31221, 31110, 30988, 30858, 30717, 30568, 30410, 30242, 30067, 29883, 29691, 29491, 29284, 29070, 28848, 28619, 28383, 28142, 27894, 27640, 27379, 27114, 26842, 26566, 26284, 25998, 25706, 25411, 25111, 24807, 24498, 24186, 23871, 23552, 23230, 22905, 22578, 22246, 21913, 21578, 21240, 20900, 20559, 20215, 19869, 19523, 19175, 18827, 18477, 18125, 17775, 17422, 17069, 16717, 16364, 16011, 15659, 15305, 14952, 14602, 14250, 13899, 13550, 13167, 13172, 11080, 10287, 8993, 6701, 5461, 3192, 1379, -521, -2481, -4450, -6372, -8201, -9929, -11547, -13053, -14458, -15767, -16984, -18120, -19181, -20169, -21096, -21964, -22775, -23538, -24252, -24922, -25553, -26145, -26700, -27223, -27714, -28173, -28606, -29010, -29387, -29742, -30072, -30379, -30665, -30928, -31172, -31397, -31602, -31788, -31957, -32108, -32243, -32362, -32464, -32550, -32623, -32680, -32722, -32750, -32765, -32767, -32755, -32731, -32693, -32645, -32584, -32511, -32427, -32333, -32227, -32110, -31984, -31848, -31701, -31546, -31381, -31207, -31025, -30833, -30634, -30426, -30210, -29988, -29757, -29519, -29275, -29024, -28766, -28502, -28232, -27956, -27675, -27388, -27095, -26799, -26496, -26189, -25878, -25563, -25243, -24920, -24593, -24262, -23929, -23591, -23251, -22909, -22563, -22216, -21866, -21513, -21160, -20804, -20446, -20088, -19727, -19365, -19004, -18640, -18276, -17912, -17547, -17181, -16816, -16451, -16085, -15621, -15911, -12432, -13628, -10037, -9461, -7173, -5200, -3349, -1373};