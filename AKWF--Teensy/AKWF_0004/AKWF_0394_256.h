/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0394 256 samples */
 
const int16_t AKWF_0394_256_DATA [256] = 
{594, 1498, 2376, 3251, 4117, 4976, 5827, 6667, 7500, 8323, 9134, 9936, 10727, 11507, 12277, 13037, 13784, 14521, 15248, 15961, 16665, 17358, 18037, 18707, 19364, 20009, 20643, 21265, 21874, 22472, 23056, 23627, 24186, 24730, 25259, 25776, 26277, 26763, 27234, 27688, 28126, 28548, 28950, 29336, 29704, 30051, 30380, 30690, 30978, 31245, 31493, 31718, 31922, 32104, 32264, 32402, 32518, 32612, 32684, 32733, 32761, 32767, 32755, 32720, 32666, 32594, 32503, 32396, 32273, 32134, 31982, 31818, 31641, 31455, 31260, 31055, 30842, 30622, 30392, 30153, 29904, 29644, 29372, 29087, 28787, 28471, 28142, 27795, 27432, 27053, 26656, 26244, 25816, 25371, 24911, 24437, 23945, 23439, 22917, 22376, 21818, 21242, 20643, 20026, 19386, 18724, 18041, 17335, 16607, 15860, 15092, 14304, 13500, 12678, 11841, 10992, 10130, 9257, 8377, 7486, 6592, 5694, 4790, 3887, 2985, 2081, 1181, 285, -608, -1495, -2375, -3252, -4117, -4976, -5828, -6668, -7500, -8323, -9135, -9936, -10728, -11508, -12278, -13038, -13785, -14522, -15248, -15962, -16666, -17358, -18038, -18707, -19364, -20010, -20644, -21265, -21874, -22472, -23056, -23627, -24186, -24730, -25260, -25776, -26277, -26763, -27235, -27688, -28126, -28548, -28950, -29336, -29704, -30051, -30380, -30690, -30978, -31245, -31493, -31718, -31922, -32104, -32264, -32402, -32518, -32612, -32684, -32733, -32761, -32767, -32755, -32720, -32666, -32594, -32503, -32396, -32273, -32135, -31982, -31818, -31641, -31455, -31259, -31055, -30842, -30621, -30391, -30152, -29905, -29644, -29372, -29086, -28786, -28471, -28141, -27794, -27431, -27052, -26656, -26244, -25816, -25371, -24911, -24437, -23946, -23439, -22916, -22375, -21818, -21242, -20644, -20027, -19386, -18724, -18041, -17335, -16607, -15861, -15092, -14304, -13501, -12679, -11841, -10993, -10130, -9257, -8376, -7487, -6592, -5694, -4791, -3888, -2985, -2083, -1185, -273};