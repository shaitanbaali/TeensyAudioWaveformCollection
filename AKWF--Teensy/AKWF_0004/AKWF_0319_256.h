/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0319 256 samples */
 
const int16_t AKWF_0319_256_DATA [256] = 
{544, 1408, 2279, 3175, 4090, 5025, 5978, 6943, 7923, 8913, 9907, 10910, 11914, 12914, 13913, 14905, 15883, 16851, 17802, 18731, 19639, 20521, 21370, 22188, 22966, 23702, 24401, 25054, 25669, 26244, 26777, 27271, 27728, 28146, 28527, 28873, 29183, 29457, 29697, 29901, 30070, 30202, 30296, 30353, 30370, 30348, 30283, 30177, 30027, 29831, 29590, 29303, 28967, 28582, 28147, 27664, 27129, 26547, 25913, 25232, 24504, 23728, 22909, 22048, 21144, 20203, 19226, 18213, 17170, 16095, 14990, 13861, 12705, 11524, 10325, 9100, 7855, 6594, 5312, 4011, 2697, 1364, 17, -1340, -2714, -4097, -5485, -6882, -8273, -9660, -11046, -12418, -13777, -15120, -16440, -17734, -19001, -20230, -21421, -22569, -23668, -24716, -25709, -26642, -27515, -28324, -29066, -29741, -30349, -30885, -31354, -31753, -32084, -32349, -32547, -32682, -32754, -32766, -32720, -32619, -32462, -32253, -31993, -31684, -31328, -30925, -30479, -29989, -29456, -28884, -28272, -27622, -26937, -26219, -25467, -24687, -23880, -23046, -22192, -21318, -20426, -19524, -18609, -17685, -16758, -15827, -14897, -13972, -13051, -12137, -11236, -10345, -9469, -8611, -7766, -6940, -6135, -5345, -4577, -3828, -3097, -2386, -1696, -1023, -370, 263, 878, 1474, 2049, 2606, 3141, 3655, 4148, 4619, 5066, 5489, 5885, 6257, 6599, 6913, 7196, 7449, 7667, 7854, 8007, 8125, 8209, 8259, 8275, 8258, 8208, 8127, 8016, 7875, 7707, 7512, 7293, 7048, 6780, 6492, 6179, 5847, 5495, 5122, 4729, 4319, 3888, 3437, 2970, 2482, 1977, 1455, 916, 362, -203, -780, -1361, -1945, -2532, -3114, -3692, -4261, -4818, -5359, -5879, -6375, -6840, -7275, -7672, -8029, -8342, -8609, -8828, -8995, -9109, -9170, -9175, -9126, -9021, -8862, -8651, -8386, -8071, -7708, -7297, -6843, -6347, -5808, -5232, -4620, -3972, -3292, -2581, -1839, -1071, -258};