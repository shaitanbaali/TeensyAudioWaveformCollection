/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0374 256 samples */
 
const int16_t AKWF_0374_256_DATA [256] = 
{505, 1857, 3403, 5180, 7169, 9353, 11650, 13973, 16282, 18533, 20738, 22802, 24663, 26384, 28014, 29532, 30954, 31761, 29746, 28471, 28330, 28307, 28263, 28117, 27868, 27571, 27319, 27158, 27010, 26745, 26325, 25733, 24936, 23855, 22504, 20931, 19185, 17325, 15400, 13450, 11466, 9420, 7304, 5135, 2939, 703, -1615, -4019, -6399, -8908, -12567, -15650, -17954, -19944, -21758, -23505, -25174, -26722, -28174, -29493, -30567, -31460, -32129, -32556, -32758, -32699, -32337, -31688, -30800, -29725, -28527, -27228, -25868, -24499, -23117, -21724, -20347, -18977, -17644, -16380, -15115, -14206, -15248, -15514, -14765, -13772, -12665, -11467, -10181, -8769, -7176, -5375, -3419, -1426, 505, 2316, 4016, 5578, 6985, 8203, 9220, 10073, 10787, 11422, 11971, 12466, 12875, 13106, 13185, 13106, 12833, 12324, 11694, 10808, 8635, 6938, 5959, 5230, 4621, 4017, 3409, 2885, 2386, 1834, 1301, 857, 560, 450, 533, 810, 1312, 2063, 3049, 4253, 5594, 6987, 8396, 9785, 11181, 12482, 13630, 14690, 15710, 16680, 17627, 18038, 15710, 14207, 13924, 13840, 13815, 13769, 13698, 13659, 13743, 13989, 14320, 14603, 14793, 14873, 14807, 14514, 14000, 13312, 12483, 11565, 10606, 9638, 8662, 7648, 6582, 5472, 4333, 3136, 1836, 428, -980, -2539, -5278, -7474, -8931, -10125, -11196, -12248, -13271, -14229, -15155, -16024, -16730, -17340, -17810, -18121, -18289, -18276, -18040, -17597, -16991, -16276, -15511, -14713, -13922, -13184, -12494, -11851, -11280, -10763, -10327, -9990, -9673, -9736, -11770, -13049, -13342, -13404, -13355, -13210, -12960, -12556, -11953, -11116, -10098, -9016, -7956, -6972, -6053, -5218, -4492, -3902, -3452, -3102, -2810, -2517, -2223, -1899, -1578, -1355, -1202, -1129, -1171, -1370, -1615, -2045, -3694, -4803, -5129, -5144, -4988, -4768, -4506, -4124, -3686, -3281, -2838, -2283, -1562, -602};