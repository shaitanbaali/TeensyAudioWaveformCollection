/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0364 256 samples */
 
const int16_t AKWF_0364_256_DATA [256] = 
{1668, 4004, 5995, 7740, 9256, 10566, 11691, 12641, 13438, 14092, 14614, 15016, 15307, 15495, 15588, 15598, 15512, 15430, 16115, 17196, 18115, 18893, 19557, 20133, 20626, 21044, 21386, 21658, 21856, 21982, 22038, 22017, 21923, 21757, 21521, 21209, 20826, 20371, 19845, 19258, 18600, 17874, 17089, 16242, 15342, 14383, 13381, 12374, 11156, 10672, 16486, 20168, 21846, 24030, 24909, 24529, 23027, 20644, 18461, 16927, 15666, 15361, 19693, 21581, 21696, 22835, 23147, 24849, 26771, 24311, 20763, 16810, 12436, 7666, 2513, -2755, -7348, -11166, -14371, -17043, -19258, -21097, -22616, -23857, -24868, -25676, -26307, -26786, -27124, -27338, -27440, -27435, -27335, -27143, -26867, -26512, -26081, -25579, -25011, -24377, -23686, -22938, -22140, -21296, -20411, -19487, -18537, -17561, -16561, -15563, -15253, -15495, -15701, -15852, -15968, -16060, -16140, -16200, -16241, -16258, -16246, -16196, -16113, -15991, -15828, -15620, -15370, -15075, -14734, -14346, -13916, -13445, -12932, -12381, -11786, -11159, -10503, -9817, -9105, -8373, -7620, -6857, -6079, -5300, -4522, -3740, -2969, -2213, -1469, -735, -29, 637, 1260, 1840, 2378, 2867, 3318, 3733, 4105, 4435, 4733, 4998, 5219, 5417, 5521, 5932, 4630, -5401, -9996, -10710, -11718, -12462, -13182, -14048, -15086, -16080, -16793, -17074, -16875, -16219, -15125, -13638, -11801, -9639, -7194, -4504, -1584, 1439, 4286, 6879, 9214, 11300, 13158, 14791, 16217, 17454, 18515, 19415, 20165, 20774, 21257, 21621, 21874, 22021, 22068, 22024, 21890, 21671, 21379, 21008, 20565, 20062, 19494, 18863, 18181, 17449, 16669, 15852, 14999, 14110, 13203, 12270, 11329, 10377, 9421, 8477, 7542, 6616, 5714, 4750, 4263, 1179, -8136, -11836, -14345, -17616, -22672, -27904, -29392, -30966, -32491, -32594, -31293, -29711, -27972, -26074, -24018, -21798, -19439, -16963, -14380, -11727, -9029, -6305, -3591, -848};