/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0330 256 samples */
 
const int16_t AKWF_0330_256_DATA [256] = 
{662, 1747, 2817, 3908, 5018, 6155, 7321, 8511, 9727, 10953, 12164, 13350, 14498, 15586, 16601, 17525, 18347, 19074, 19710, 20266, 20756, 21193, 21595, 21986, 22385, 22807, 23263, 23755, 24281, 24840, 25421, 26016, 26618, 27211, 27782, 28326, 28838, 29314, 29748, 30127, 30447, 30703, 30898, 31044, 31156, 31244, 31320, 31390, 31451, 31498, 31529, 31550, 31571, 31602, 31651, 31720, 31814, 31930, 32062, 32203, 32338, 32459, 32557, 32629, 32673, 32687, 32675, 32634, 32560, 32445, 32282, 32070, 31810, 31510, 31182, 30837, 30489, 30143, 29795, 29443, 29085, 28721, 28351, 27973, 27585, 27192, 26795, 26395, 25998, 25607, 25217, 24820, 24407, 23967, 23497, 22994, 22457, 21890, 21300, 20696, 20084, 19456, 18808, 18143, 17458, 16756, 16049, 15347, 14665, 14009, 13376, 12758, 12141, 11512, 10872, 10227, 9575, 8919, 8264, 7614, 6979, 6365, 5770, 5190, 4609, 4007, 3370, 2679, 1924, 1110, 233, -716, -1735, -2823, -3972, -5158, -6366, -7572, -8752, -9892, -10979, -11998, -12949, -13818, -14598, -15296, -15922, -16492, -17026, -17535, -18030, -18523, -19018, -19518, -20019, -20518, -21018, -21528, -22051, -22589, -23140, -23701, -24267, -24834, -25393, -25942, -26478, -26997, -27498, -27979, -28436, -28874, -29290, -29684, -30054, -30399, -30719, -31016, -31293, -31553, -31799, -32030, -32236, -32412, -32551, -32652, -32717, -32752, -32766, -32767, -32759, -32744, -32729, -32709, -32681, -32650, -32613, -32568, -32505, -32416, -32293, -32131, -31929, -31688, -31411, -31115, -30815, -30523, -30245, -29978, -29727, -29492, -29270, -29066, -28888, -28731, -28585, -28440, -28280, -28096, -27886, -27651, -27397, -27123, -26822, -26492, -26119, -25700, -25244, -24757, -24237, -23681, -23077, -22424, -21721, -20969, -20174, -19332, -18430, -17469, -16456, -15398, -14320, -13247, -12182, -11130, -10084, -9034, -7977, -6911, -5838, -4765, -3692, -2605, -1506, -388};