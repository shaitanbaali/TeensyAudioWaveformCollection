/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0341 256 samples */
 
const int16_t AKWF_0341_256_DATA [256] = 
{858, 2526, 4254, 6018, 7751, 9389, 10895, 12234, 13380, 14311, 15025, 15549, 15892, 16045, 15996, 15741, 15294, 14693, 13995, 13267, 12546, 11860, 11237, 10701, 10261, 9924, 9713, 9672, 9837, 10208, 10759, 11439, 12179, 12898, 13535, 14045, 14379, 14501, 14407, 14119, 13655, 13042, 12320, 11529, 10688, 9791, 8808, 7712, 6487, 5120, 3631, 2050, 375, -1383, -3211, -5093, -7000, -8891, -10706, -12337, -13692, -14711, -15346, -15587, -15443, -14948, -14139, -13052, -11748, -10279, -8685, -7012, -5288, -3558, -1845, -145, 1526, 3124, 4608, 5938, 7084, 8056, 8872, 9551, 10106, 10529, 10818, 10985, 11025, 10938, 10757, 10535, 10320, 10136, 9976, 9818, 9620, 9332, 8923, 8370, 7659, 6782, 5760, 4650, 3494, 2340, 1250, 280, -540, -1209, -1754, -2203, -2578, -2895, -3148, -3325, -3434, -3493, -3516, -3506, -3472, -3409, -3278, -3013, -2558, -1871, -945, 211, 1562, 3048, 4615, 6205, 7749, 9186, 10474, 11574, 12466, 13128, 13562, 13793, 13838, 13686, 13320, 12736, 11943, 10969, 9873, 8715, 7529, 6344, 5187, 4081, 3038, 2068, 1194, 468, -72, -421, -600, -653, -648, -651, -723, -905, -1235, -1744, -2433, -3269, -4233, -5297, -6416, -7551, -8681, -9819, -10995, -12236, -13560, -14983, -16482, -18034, -19635, -21281, -22957, -24653, -26337, -27975, -29507, -30828, -31849, -32509, -32767, -32612, -32059, -31145, -29910, -28391, -26653, -24747, -22715, -20601, -18433, -16248, -14078, -11911, -9768, -7698, -5741, -3941, -2332, -908, 346, 1451, 2416, 3230, 3894, 4414, 4783, 5003, 5104, 5141, 5165, 5198, 5237, 5263, 5231, 5100, 4834, 4415, 3829, 3071, 2167, 1172, 132, -903, -1876, -2730, -3432, -3986, -4416, -4750, -5013, -5220, -5364, -5435, -5442, -5402, -5328, -5223, -5095, -4938, -4708, -4342, -3776, -2973, -1923, -599};