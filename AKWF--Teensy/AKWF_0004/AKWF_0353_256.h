/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0353 256 samples */
 
const int16_t AKWF_0353_256_DATA [256] = 
{655, 653, 1183, 1447, 1986, 1913, 2360, 2669, 2619, 2577, 2844, 3290, 3406, 3939, 3995, 4581, 4552, 5506, 5967, 5882, 5898, 5910, 5855, 6204, 7051, 7247, 7161, 7388, 7877, 7957, 8515, 9067, 9199, 9169, 9183, 9150, 9604, 10163, 10540, 10421, 10800, 11150, 11346, 11841, 11790, 11779, 11864, 12434, 12468, 13054, 13053, 13865, 14497, 14411, 14365, 14768, 15136, 15009, 15432, 15784, 15692, 15830, 16381, 16429, 16962, 17521, 17738, 17649, 18175, 18389, 18341, 18350, 18929, 18983, 19224, 19674, 19790, 20323, 20378, 20958, 20976, 20974, 20947, 21508, 21577, 22218, 23013, 22932, 22889, 23206, 23605, 23756, 24285, 24243, 24238, 24287, 24866, 24918, 25406, 25969, 26269, 26153, 26621, 26866, 27164, 27578, 27520, 27494, 27665, 28187, 28244, 28818, 28853, 29428, 29484, 30017, 30132, 30583, 30824, 30878, 31457, 30653, 35144, 14293, -36361, -31930, -31920, -31420, -31467, -31457, -31450, -31482, -31028, -30468, -30091, -30210, -29832, -29483, -29275, -28839, -28433, -28134, -28189, -28185, -28167, -27587, -27533, -26999, -26884, -26426, -26223, -25863, -25556, -25311, -24853, -24910, -24928, -24801, -24246, -24237, -23524, -22916, -22934, -22975, -22446, -22295, -21895, -21578, -21628, -21670, -21403, -20957, -20834, -20345, -19996, -19613, -19660, -19072, -18988, -18999, -19051, -18555, -18359, -17999, -17691, -17437, -17024, -16891, -15806, -15710, -15734, -15728, -15725, -15748, -15130, -14426, -14402, -14470, -14011, -13759, -13498, -12927, -12442, -12446, -12496, -12226, -11740, -11852, -11562, -11089, -11176, -10612, -10500, -10054, -9787, -9829, -9879, -9562, -9163, -9006, -8498, -8468, -7393, -7168, -7217, -7216, -6652, -6530, -6563, -5991, -5864, -5955, -5583, -5230, -5054, -4482, -3956, -3944, -3867, -3289, -3265, -3312, -3125, -2582, -2673, -2171, -1975, -1615, -1307, -1054, -643, -492, 36, -8, -1, 0};