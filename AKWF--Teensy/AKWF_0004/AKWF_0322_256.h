/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0322 256 samples */
 
const int16_t AKWF_0322_256_DATA [256] = 
{594, 2148, 3644, 5055, 6445, 7839, 9181, 10494, 11788, 13059, 14285, 15485, 16586, 17691, 18781, 19836, 20852, 21797, 22714, 23586, 24432, 25186, 25871, 26521, 27088, 27578, 28028, 28408, 28731, 28985, 29199, 29421, 29616, 29764, 29879, 29988, 30091, 30186, 30292, 30441, 30599, 30789, 30985, 31153, 31303, 31443, 31560, 31646, 31717, 31753, 31796, 31786, 31757, 31667, 31545, 31374, 31174, 30896, 30302, 29764, 29380, 28966, 28510, 28086, 27647, 27249, 26900, 26524, 26213, 25945, 25643, 25397, 25187, 24944, 24668, 24432, 24194, 23912, 23584, 23189, 22805, 22423, 22003, 21561, 21082, 20544, 19932, 19232, 18448, 17586, 16653, 15669, 14647, 13606, 12566, 11568, 10621, 9688, 8802, 7992, 7229, 6428, 5649, 4890, 4164, 3472, 2747, 2064, 1424, 916, 608, 56, -217, -406, -717, -894, -1020, -1169, -1266, -1336, -1354, -1375, -1318, -1202, -723, -452, -294, -149, -77, -10, 5, -9, -59, -164, -275, -359, -482, -636, -799, -1007, -1252, -1578, -1964, -2401, -2881, -3402, -3935, -4501, -5113, -5737, -6396, -7078, -7784, -8501, -9279, -10080, -10917, -11769, -12641, -13521, -14368, -15244, -16093, -16906, -17662, -18350, -18984, -19545, -20084, -20612, -21117, -21668, -22175, -22680, -23220, -23685, -24116, -24535, -24937, -25278, -25630, -25978, -26356, -26726, -27166, -27611, -28414, -29107, -29677, -30243, -30723, -31205, -31591, -31930, -32227, -32410, -32571, -32698, -32728, -32750, -32766, -32714, -32602, -32518, -32427, -32294, -32127, -31906, -31715, -31554, -31386, -31232, -31082, -30921, -30739, -30527, -30298, -30059, -29825, -29611, -29429, -29279, -29163, -29054, -28954, -28911, -28892, -28886, -28843, -28670, -28424, -28103, -27727, -27298, -26761, -26186, -25616, -24974, -24029, -23321, -22426, -21362, -20353, -19272, -18009, -16763, -15470, -14035, -12633, -11173, -9648, -8044, -6071, -4305, -2621, -963};