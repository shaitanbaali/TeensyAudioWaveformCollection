/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0393 256 samples */
 
const int16_t AKWF_0393_256_DATA [256] = 
{181, 595, 998, 1397, 1794, 2191, 2589, 2988, 3391, 3797, 4210, 4628, 5055, 5490, 5935, 6390, 6855, 7334, 7825, 8328, 8845, 9375, 9918, 10476, 11047, 11631, 12229, 12839, 13460, 14094, 14737, 15390, 16053, 16722, 17398, 18080, 18764, 19451, 20140, 20828, 21512, 22194, 22867, 23536, 24194, 24839, 25473, 26093, 26694, 27277, 27839, 28378, 28896, 29385, 29847, 30281, 30684, 31055, 31393, 31696, 31963, 32194, 32387, 32540, 32655, 32731, 32766, 32761, 32717, 32631, 32505, 32341, 32137, 31894, 31614, 31297, 30947, 30561, 30142, 29692, 29213, 28704, 28169, 27609, 27025, 26420, 25795, 25152, 24492, 23817, 23128, 22429, 21721, 21004, 20281, 19553, 18821, 18088, 17355, 16622, 15893, 15167, 14445, 13732, 13025, 12325, 11638, 10959, 10291, 9638, 8996, 8367, 7753, 7153, 6568, 5999, 5444, 4903, 4380, 3869, 3371, 2888, 2417, 1958, 1511, 1073, 645, 225, -187, -595, -998, -1398, -1795, -2192, -2589, -2989, -3392, -3798, -4211, -4629, -5056, -5490, -5936, -6391, -6856, -7335, -7826, -8328, -8846, -9376, -9919, -10477, -11048, -11632, -12230, -12839, -13461, -14095, -14738, -15391, -16054, -16722, -17398, -18081, -18765, -19452, -20141, -20828, -21512, -22194, -22867, -23536, -24195, -24840, -25475, -26093, -26694, -27277, -27839, -28378, -28896, -29386, -29847, -30281, -30684, -31055, -31393, -31696, -31963, -32194, -32387, -32540, -32655, -32731, -32765, -32761, -32717, -32631, -32505, -32341, -32137, -31894, -31614, -31297, -30946, -30560, -30141, -29691, -29213, -28704, -28168, -27610, -27025, -26420, -25795, -25151, -24492, -23818, -23129, -22430, -21721, -21004, -20281, -19553, -18820, -18088, -17355, -16622, -15893, -15168, -14446, -13732, -13025, -12326, -11638, -10960, -10292, -9639, -8996, -8368, -7754, -7153, -6569, -6000, -5445, -4904, -4381, -3869, -3372, -2889, -2418, -1958, -1511, -1074, -648, -221};