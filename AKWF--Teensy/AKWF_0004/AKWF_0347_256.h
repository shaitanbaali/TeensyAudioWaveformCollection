/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0347 256 samples */
 
const int16_t AKWF_0347_256_DATA [256] = 
{4032, 6155, 5761, 5836, 5836, 5838, 5839, 5839, 5839, 5839, 5839, 5839, 5839, 5838, 5837, 5863, 5831, 5787, 13702, 18955, 18342, 18453, 18452, 18449, 18446, 18444, 18440, 18437, 18434, 18430, 18426, 18423, 18418, 18415, 18411, 18406, 18402, 18398, 18394, 18389, 18385, 18381, 18376, 18371, 18367, 18362, 18358, 18353, 18348, 18343, 18339, 18334, 18342, 18389, 17991, 24955, 31355, 30839, 30916, 30917, 30911, 30905, 30898, 30891, 30885, 30878, 30871, 30864, 30857, 30849, 30842, 30834, 30827, 30819, 30811, 30803, 30796, 30788, 30780, 30772, 30765, 30756, 30748, 30740, 30732, 30724, 30715, 30707, 30700, 30692, 30684, 30676, 30668, 30660, 30652, 30643, 30634, 30626, 30618, 30610, 30602, 30594, 30586, 30577, 30569, 30561, 30553, 30545, 30537, 30529, 30520, 30485, 30508, 30544, 22619, 17359, 17961, 17841, 17834, 17827, 17820, 17813, 17807, 17801, 17795, 17789, 17783, 17777, 17772, 17766, 17761, 17471, 18757, 12099, -15554, -20995, -19883, -20164, -20156, -20020, -27743, -33256, -32656, -32762, -32762, -32758, -32755, -32751, -32746, -32742, -32736, -32731, -32724, -32718, -32712, -32705, -32699, -32692, -32684, -32677, -32670, -32662, -32654, -32647, -32640, -32631, -32623, -32615, -32607, -32599, -32591, -32583, -32574, -32565, -32557, -32549, -32541, -32532, -32523, -32516, -32507, -32498, -32490, -32481, -32473, -32464, -32455, -32447, -32438, -32430, -32421, -32412, -32404, -32395, -32386, -32377, -32330, -32433, -32071, -23564, -19217, -19819, -19695, -19688, -19680, -19673, -19666, -19659, -19652, -19646, -19639, -19633, -19627, -19621, -19615, -19609, -19603, -19597, -19592, -19585, -19580, -19574, -19569, -19563, -19557, -19551, -19546, -19541, -19535, -19530, -19524, -19519, -19514, -19508, -19502, -19384, -19988, -14766, -6818, -6847, -6876, -6844, -6841, -6837, -6833, -6829, -6826, -6823, -6820, -6816, -6814, -6811, -6808, -6733, -7122, -5021};