/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0355 256 samples */
 
const int16_t AKWF_0355_256_DATA [256] = 
{200, 698, 1182, 1664, 2142, 2617, 3089, 3555, 4019, 4478, 4932, 5383, 5829, 6270, 6708, 7140, 7566, 7990, 8407, 8819, 9228, 9631, 10028, 10421, 10808, 11189, 11566, 11937, 12302, 12663, 13017, 13367, 13710, 14048, 14380, 14708, 15028, 15343, 15653, 15957, 16255, 16548, 16834, 17115, 17391, 17659, 17923, 18181, 18433, 18680, 18920, 19155, 19384, 19608, 19825, 20038, 20245, 20445, 20640, 20830, 21014, 21193, 21366, 21534, 21696, 21853, 22004, 22151, 22292, 22427, 22557, 22683, 22803, 22918, 23027, 23132, 23232, 23328, 23418, 23503, 23583, 23659, 23730, 23797, 23859, 23916, 23969, 24018, 24062, 24102, 24137, 24169, 24196, 24219, 24238, 24253, 24265, 24272, 24276, 24276, 24272, 24264, 24254, 24239, 24222, 24200, 24175, 24147, 24117, 24082, 24045, 24005, 23962, 23916, 23866, 23815, 23760, 23703, 23643, 23581, 23516, 23449, 23379, 23307, 23233, 23157, 23078, 22964, 23443, 20820, 13256, 14580, 15901, 12710, 9930, 7447, 4823, 2090, -639, -3290, -5802, -8142, -10314, -12317, -14154, -15846, -17399, -18823, -20134, -21339, -22444, -23463, -24399, -25258, -26050, -26777, -27443, -28055, -28614, -29124, -29590, -30013, -30396, -30741, -31050, -31325, -31568, -31779, -31962, -32117, -32244, -32346, -32423, -32476, -32506, -32514, -32501, -32467, -32413, -32340, -32248, -32138, -32011, -31866, -31705, -31528, -31336, -31128, -30906, -30670, -30420, -30157, -29880, -29593, -29292, -28979, -28655, -28320, -27975, -27620, -27254, -26879, -26494, -26101, -25699, -25289, -24871, -24445, -24013, -23573, -23126, -22674, -22214, -21749, -21280, -20804, -20323, -19838, -19349, -18855, -18358, -17856, -17352, -16845, -16334, -15821, -15306, -14788, -14269, -13748, -13225, -12702, -12177, -11652, -11126, -10600, -10073, -9548, -9021, -8494, -7971, -7446, -6923, -6401, -5880, -5360, -4844, -4327, -3814, -3303, -2793, -2286, -1783, -1281, -784, -280};