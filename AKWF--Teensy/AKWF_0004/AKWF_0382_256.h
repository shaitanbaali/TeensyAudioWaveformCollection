/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0382 256 samples */
 
const int16_t AKWF_0382_256_DATA [256] = 
{-9338, -20137, -28219, -31587, -23566, -19369, -13003, -9848, -13968, -13247, -20567, -23682, -23561, -15936, -13399, -13180, -17125, -23779, -23690, -19895, -13667, -11527, -3861, -3774, -6623, -14196, -13588, -13614, -14036, -12240, -4068, -4198, -4195, -4058, -12211, -14019, -13644, -5505, -3999, -3481, -8575, -14407, -13472, -13556, -14070, -6332, -3646, -4412, -3373, -8944, -14317, -13739, -12470, -4178, -4083, -4131, -4111, -4109, -4107, -4105, -4103, -4101, -4100, -4098, -4097, -4095, -4094, -4092, -4090, -4089, -4088, -4086, -4085, -4084, -4083, -4082, -4080, -4078, -4077, -4075, -4074, -4073, -4072, -4071, -4069, -4068, -4067, -4066, -4065, -4064, -4063, -4062, -3937, -4623, -1400, 6002, 5322, 5446, 5446, 5446, 5446, 5446, 5446, 5446, 5444, 5444, 5444, 5443, 5442, 5442, 5440, 5440, 5437, 5436, 5435, 5435, 5433, 5432, 5431, 5430, 5429, 5427, 5425, 5425, 5423, 5422, 5421, 5419, 5418, 5417, 5415, 5414, 5413, 5411, 5410, 5409, 5407, 5405, 5404, 5403, 5401, 5400, 5399, 5398, 5396, 5394, 5393, 5392, 5390, 5389, 5387, 5386, 5385, 5383, 5381, 5381, 5379, 5378, 5376, 5375, 5374, 5372, 5370, 5368, 5366, 5365, 5364, 5362, 5361, 5360, 5358, 5357, 5355, 5354, 5353, 5351, 5350, 5348, 5347, 5346, 5344, 5342, 5341, 5340, 5338, 5337, 5336, 5334, 5333, 5331, 5330, 5328, 5327, 5326, 5324, 5322, 5322, 5320, 5319, 5317, 5316, 5315, 5313, 5311, 5310, 5309, 5307, 5306, 5305, 5303, 5301, 5299, 5298, 5297, 5295, 5293, 5293, 5291, 5290, 5288, 5287, 5286, 5284, 5282, 5281, 5280, 5278, 5277, 5275, 5274, 5273, 5271, 5270, 5269, 5267, 5266, 5265, 5263, 5262, 5260, 5259, 5258, 5256, 5255, 5253, 5252, 5250, 5249, 5248, 5246, 5245, 5243, 5242, 5241, 5239, 5238};