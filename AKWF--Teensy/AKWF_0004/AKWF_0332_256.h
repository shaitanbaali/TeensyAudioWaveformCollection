/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0332 256 samples */
 
const int16_t AKWF_0332_256_DATA [256] = 
{160, 430, 693, 958, 1222, 1487, 1752, 2017, 2282, 2547, 2812, 3077, 3343, 3607, 3872, 4137, 4402, 4668, 4933, 5197, 5462, 5728, 5993, 6258, 6523, 6788, 7054, 7319, 7583, 7848, 8113, 8379, 8644, 8909, 9173, 9439, 9704, 9969, 10234, 10498, 10764, 11030, 11294, 11559, 11824, 12089, 12355, 12620, 12884, 13149, 13415, 13680, 13945, 14210, 14475, 14740, 15005, 15270, 15535, 15800, 16065, 16331, 16595, 16860, 17126, 17391, 17655, 17921, 18185, 18450, 18714, 18980, 19245, 19510, 19774, 20039, 20305, 20570, 20835, 21100, 21365, 21631, 21895, 22160, 22425, 22691, 22956, 23221, 23486, 23750, 24016, 24281, 24546, 24811, 25076, 25341, 25606, 25871, 26136, 26401, 26667, 26931, 27197, 27461, 27726, 27992, 28257, 28522, 28787, 29052, 29317, 29582, 29847, 30112, 30378, 30642, 30907, 31172, 31437, 31703, 31968, 32208, 32438, 32869, 24836, 10116, -423, -7983, -13844, -18261, -21573, -24050, -25878, -27215, -28178, -28850, -29303, -29588, -29742, -29798, -29779, -29703, -29581, -29427, -29246, -29045, -28830, -28602, -28366, -28123, -27875, -27623, -27367, -27111, -26851, -26591, -26329, -26066, -25804, -25540, -25276, -25012, -24747, -24483, -24218, -23953, -23688, -23425, -23159, -22894, -22629, -22364, -22099, -21834, -21569, -21304, -21039, -20774, -20509, -20244, -19979, -19714, -19449, -19183, -18918, -18654, -18389, -18123, -17858, -17593, -17328, -17064, -16798, -16533, -16268, -16003, -15738, -15473, -15209, -14944, -14679, -14414, -14149, -13884, -13618, -13354, -13089, -12824, -12559, -12293, -12028, -11764, -11499, -11233, -10968, -10703, -10438, -10174, -9908, -9643, -9378, -9113, -8848, -8583, -8317, -8053, -7788, -7523, -7257, -6992, -6727, -6463, -6197, -5932, -5667, -5402, -5137, -4872, -4607, -4342, -4077, -3812, -3546, -3282, -3017, -2752, -2487, -2221, -1956, -1692, -1427, -1161, -896, -631, -367, -98};