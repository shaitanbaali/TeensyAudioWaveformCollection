/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0369 256 samples */
 
const int16_t AKWF_0369_256_DATA [256] = 
{6865, 20242, 28781, 32114, 32745, 32564, 30841, 25257, 14644, 1650, -10486, -20123, -25673, -27938, -27965, -26066, -22115, -16225, -9219, -2491, 2954, 7263, 10062, 11347, 11375, 10470, 8962, 7165, 5319, 3575, 2005, 611, -656, -1983, -3389, -4838, -6250, -7502, -8437, -8888, -8717, -7821, -6181, -3843, -1054, 1955, 5286, 8529, 11306, 13374, 14566, 14807, 14074, 12393, 9862, 6653, 3065, -429, -3882, -7166, -9901, -11911, -13117, -13506, -13108, -11984, -10227, -7965, -5383, -2684, -163, 2146, 4292, 6033, 7251, 7896, 7960, 7469, 6477, 5080, 3414, 1623, -76, -1669, -3121, -4252, -4952, -5172, -4899, -4148, -2991, -1541, 24, 1676, 3379, 4940, 6216, 7091, 7497, 7394, 6777, 5679, 4173, 2372, 463, -1468, -3473, -5356, -6965, -8180, -8937, -9185, -8920, -8163, -6961, -5400, -3575, -1637, 221, 2067, 3981, 5892, 7560, 8718, 9166, 8803, 7637, 5790, 3477, 1051, -1189, -3246, -4852, -5812, -6075, -5666, -4695, -3325, -1743, -190, 1247, 2547, 3566, 4225, 4501, 4415, 4005, 3333, 2456, 1448, 395, -652, -1745, -2810, -3784, -4613, -5242, -5627, -5732, -5541, -5042, -4252, -3211, -1976, -657, 657, 2008, 3297, 4407, 5258, 5790, 5974, 5802, 5301, 4514, 3509, 2375, 1197, 91, -905, -1814, -2539, -3029, -3263, -3241, -2988, -2542, -1949, -1278, -586, 50, 616, 1095, 1429, 1588, 1561, 1355, 987, 497, -55, -660, -1297, -1892, -2400, -2769, -2963, -2963, -2757, -2360, -1786, -1080, -304, 496, 1341, 2163, 2904, 3503, 3922, 4136, 4130, 3904, 3476, 2877, 2146, 1337, 507, -275, -1036, -1735, -2313, -2740, -2998, -3073, -2977, -2728, -2347, -1875, -1354, -820, -316, 118, 484, 765, 939, 996, 934, 781, 506, -2408, -9352, -17172, -22707, -24770, -23182, -17127, -5969};