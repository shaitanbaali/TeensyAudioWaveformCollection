/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0344 256 samples */
 
const int16_t AKWF_0344_256_DATA [256] = 
{11058, 11060, 11061, 11063, 11063, 11064, 11065, 11064, 11063, 11063, 11062, 11061, 11060, 11059, 11057, 11056, 11053, 11052, 11049, 11047, 11046, 11043, 11041, 11039, 11036, 11034, 11031, 11028, 11026, 11023, 11020, 11018, 11015, 11012, 11010, 11007, 11004, 11001, 10999, 10995, 10993, 10990, 10987, 10984, 10981, 10979, 10977, 10973, 10970, 10968, 10965, 10961, 10959, 10956, 10953, 10950, 10947, 10944, 10941, 10938, 10935, 10932, 10929, 10927, 10924, 10921, 11218, 9554, 17502, 33899, 32197, 32503, 32499, 32492, 32487, 32482, 32475, 32469, 32463, 32457, 32449, 32442, 32435, 32427, 32420, 32413, 32406, 32398, 32390, 32382, 32374, 32366, 32358, 32350, 32341, 32333, 32325, 32318, 32308, 32301, 32291, 32284, 32275, 32267, 32258, 32249, 32241, 32232, 32225, 32216, 32206, 32198, 32190, 32181, 32173, 32164, 32154, 32148, 32138, 32130, 32122, 32112, 32104, 32096, 32086, 31813, 33101, 28325, -29013, -33788, -32496, -32765, -32767, -32768, -32767, -32768, -32767, -32766, -32764, -32761, -32757, -32754, -32749, -32745, -32739, -32733, -32728, -32721, -32715, -32708, -32701, -32694, -32687, -32681, -32673, -32666, -32659, -32651, -32643, -32634, -32627, -32619, -32610, -32602, -32594, -32587, -32578, -32570, -32561, -32553, -32544, -32536, -32527, -32518, -32510, -32502, -32494, -32486, -32476, -32467, -32459, -32450, -32441, -32433, -32258, -33162, -29350, -10669, -10782, -10813, -10776, -10769, -10763, -10757, -10752, -10745, -10740, -10736, -10731, -10726, -10722, -10717, -10713, -10710, -10706, -10701, -10698, -10694, -10691, -10687, -10684, -10680, -10677, -10674, -10670, -10667, -10664, -10660, -10657, -10654, -10651, -10648, -10645, -10642, -10639, -10635, -10632, -10629, -10627, -10625, -10622, -10618, -10616, -10613, -10610, -10607, -10604, -10601, -10598, -10595, -10592, -10589, -10586, -10584, -10580, -10578, -10575, -10572, -10569, -10566, -10563, -10561, -10557, -10554, -10552, -10549};