/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0375 256 samples */
 
const int16_t AKWF_0375_256_DATA [256] = 
{12205, 12209, 12212, 12215, 12217, 12219, 12590, 10608, 21786, 34405, 32390, 32765, 32761, 32758, 32754, 32752, 32747, 32741, 32736, 32731, 32724, 32719, 32712, 32706, 32699, 32692, 32685, 32677, 32670, 32662, 32655, 32647, 32639, 32631, 32624, 32615, 32607, 32599, 32590, 32583, 32575, 32566, 32557, 32550, 32541, 32532, 32524, 32515, 32507, 32499, 32490, 32481, 32472, 32464, 32455, 32446, 32438, 32431, 32421, 32413, 32404, 32395, 32386, 32377, 32369, 32360, 32351, 32344, 32334, 32095, 33394, 17002, 10613, 11993, 11738, 11731, 11725, 11719, 11713, 11708, 11701, 11697, 11691, 11686, 11682, 11678, 11673, 11669, 11665, 11660, 11656, 11653, 11649, 11644, 11641, 11637, 11634, 11631, 11626, 11623, 11619, 11617, 11613, 11610, 11606, 11603, 11600, 11596, 11593, 11589, 11586, 11583, 11580, 11577, 11573, 11571, 11568, 11564, 11561, 11557, 11555, 11552, 11548, 11545, 11542, 11539, 11536, 11533, 11530, 11526, 11275, 12665, -3537, -10211, -8776, -9035, -9037, -9038, -9038, -9039, -9038, -9038, -9038, -9037, -9037, -9036, -9035, -9034, -9032, -9031, -9029, -9028, -9026, -9025, -9023, -9022, -9020, -9017, -9016, -9267, -7873, -14435, -30413, -29368, -29532, -29543, -29539, -29534, -29530, -29525, -29520, -29514, -29508, -29502, -29496, -29490, -29484, -29477, -29470, -29462, -29456, -29449, -29442, -29434, -29428, -29421, -29413, -29406, -29398, -29391, -29383, -29376, -29368, -29361, -29352, -29345, -29337, -29330, -29322, -29315, -29307, -29300, -29291, -29284, -29275, -29268, -29260, -29253, -29245, -29237, -29229, -29221, -29213, -29206, -29198, -29190, -29183, -29174, -29167, -29159, -29151, -29143, -29135, -29127, -29120, -29112, -29104, -29097, -29088, -29081, -29073, -29065, -29058, -29050, -29042, -29034, -29027, -29018, -29011, -29003, -28996, -28987, -28980, -28972, -28964, -28808, -29615, -26242, -8387, -8341, -8406, -8367, -8361, -8355, -8351, -8346};