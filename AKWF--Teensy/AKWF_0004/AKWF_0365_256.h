/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0365 256 samples */
 
const int16_t AKWF_0365_256_DATA [256] = 
{14267, 33087, 29481, 26672, 27621, 28089, 27892, 27817, 27857, 27869, 27860, 27859, 27862, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27861, 27858, 27696, 28207, 24177, -4975, -31282, -30976, -26834, -27315, -28073, -27949, -27817, -27847, -27870, -27863, -27858, -27861, -27862, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27861, -27846, -27708, -28549, -18459};