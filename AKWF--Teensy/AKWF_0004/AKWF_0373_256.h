/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0373 256 samples */
 
const int16_t AKWF_0373_256_DATA [256] = 
{1233, 2323, 3824, 5254, 6067, 7328, 9819, 13157, 16201, 18995, 21147, 22127, 23164, 25079, 25758, 26160, 27002, 27596, 28368, 29159, 29336, 29531, 29626, 30041, 30952, 31241, 31882, 32153, 32257, 32726, 32625, 32360, 32306, 31907, 31807, 31969, 31406, 31251, 30488, 30298, 30212, 29289, 28468, 27965, 27800, 28510, 28757, 27727, 26217, 24119, 22408, 21585, 21173, 20949, 20753, 20019, 19204, 17835, 15879, 13940, 12486, 11992, 11498, 10024, 8290, 7060, 5266, 2966, 1315, 77, -1355, -2892, -4214, -5502, -6843, -8178, -9671, -11202, -13358, -15777, -17850, -19749, -22174, -24280, -25796, -27425, -28596, -28828, -28510, -28083, -27851, -27552, -27044, -26787, -27267, -27159, -26931, -26560, -26065, -25804, -25731, -25932, -27091, -27750, -27433, -26492, -25445, -25727, -25794, -25400, -24827, -23946, -22817, -22025, -20710, -18662, -16388, -14955, -14508, -14770, -15368, -16180, -16541, -16328, -16076, -15482, -15368, -15783, -15955, -15951, -15891, -15736, -15672, -16103, -16291, -16593, -16317, -15956, -16066, -16500, -16399, -16101, -17601, -19067, -20139, -21351, -22143, -22301, -21688, -21300, -20594, -19485, -18434, -18406, -18461, -18471, -18200, -17180, -16265, -14871, -12843, -10489, -8469, -6669, -4984, -3183, -1741, 13, 2301, 4246, 5662, 6282, 6749, 7246, 8369, 9874, 11452, 12577, 13462, 14695, 15570, 15549, 15391, 16136, 16762, 15980, 15284, 15529, 15880, 15653, 15439, 15041, 15060, 15814, 16659, 17019, 17157, 17359, 17478, 17745, 18344, 18019, 16774, 15688, 14244, 12440, 10396, 8728, 7680, 7222, 7071, 7268, 8022, 8395, 8058, 6782, 6036, 5539, 4526, 3763, 3353, 2334, 840, -936, -3095, -4569, -5872, -7102, -8797, -10652, -11788, -12038, -12345, -12925, -13362, -13902, -14120, -14561, -14784, -14519, -14746, -15421, -15442, -15195, -14731, -13614, -12729, -12044, -10532, -8586, -7000, -5997, -5193, -4229, -2499, -684};