/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0381 256 samples */
 
const int16_t AKWF_0381_256_DATA [256] = 
{6030, 5867, 16977, 19417, 19067, 17955, 26500, 33831, 25632, 17913, 19178, 18910, 19000, 18767, 7451, 5644, 5883, 6918, -2475, -7799, -6725, -6923, -6925, -6924, -6925, -6928, -6927, -6928, -6927, -6925, -6924, -6924, -6925, -6922, -6765, -7641, 2545, 6740, 5837, 5999, 5999, 5999, 5999, 5999, 5999, 5999, 5998, 5997, 5997, 5997, 5995, 5993, 5994, 5992, 5991, 5989, 5988, 5803, 6816, -2992, -7749, -6756, -6935, -6935, -6935, -6935, -6935, -6935, -6936, -6934, -6932, -6933, -6932, -6930, -6931, -6928, -6928, -6925, -6925, -6923, -6921, -6921, -6919, -6917, -6916, -6914, -6912, -6910, -6909, -6907, -6906, -6905, -6902, -6900, -6899, -6896, -6896, -6893, -6892, -6890, -6888, -6886, -6884, -6883, -6881, -6879, -6877, -6875, -6874, -6872, -6870, -6869, -6866, -6864, -6863, -6861, -6859, -6858, -6855, -6853, -6852, -6851, -6849, -6846, -6845, -6843, -6840, -6838, -6610, -7829, -1174, 7108, 5854, 6088, 6091, 6091, 6091, 6091, 6091, 6091, 6091, 6091, 6089, 6087, 6088, 6088, 6086, 6085, 6084, 6082, 6082, 6081, 6080, 6078, 6077, 6076, 6074, 6073, 6071, 6070, 6068, 6067, 6066, 6065, 6063, 6061, 6060, 6058, 6056, 6055, 6055, 6052, 6051, 6049, 6047, 6046, 6044, 6043, 6041, 6040, 6038, 6036, 6034, 6033, 6032, 6030, 6028, 6027, 6024, 6023, 6022, 6020, 6019, 6018, 6016, 6014, 6012, 6011, 6010, 6008, 6006, 6005, 6003, 6001, 5999, 5998, 5997, 5995, 5993, 5991, 5990, 5988, 5987, 5986, 5983, 5982, 5980, 5978, 5977, 5975, 5806, 6738, 2357, -7709, -6783, -6952, -6953, -6952, -6952, -6952, -6952, -6953, -6952, -6950, -6949, -6950, -6948, -6946, -6946, -6944, -6943, -6942, -6942, -7076, -6319, -9745, -20382, -18922, -28648, -33418, -33407, -23675, -19495, -18046, -6756, -6918};