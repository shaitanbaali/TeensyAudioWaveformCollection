/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0313 256 samples */
 
const int16_t AKWF_0313_256_DATA [256] = 
{4156, 10283, 15926, 21002, 25313, 28719, 31123, 32463, 32741, 31990, 30288, 27732, 24455, 20618, 16363, 11864, 7297, 2795, -1487, -5416, -8905, -11862, -14222, -15964, -17069, -17549, -17437, -16782, -15647, -14101, -12233, -10126, -7862, -5535, -3220, -987, 1088, 2962, 4592, 5937, 6986, 7728, 8165, 8309, 8183, 7814, 7233, 6479, 5594, 4613, 3581, 2536, 1510, 536, -354, -1146, -1818, -2359, -2766, -3035, -3168, -3175, -3066, -2856, -2557, -2190, -1773, -1319, -852, -383, 70, 494, 880, 1220, 1505, 1732, 1900, 2009, 2061, 2060, 2011, 1920, 1796, 1645, 1473, 1292, 1106, 922, 746, 584, 439, 315, 214, 135, 81, 50, 40, 51, 77, 117, 168, 225, 286, 347, 405, 456, 499, 532, 553, 562, 555, 535, 502, 456, 398, 329, 251, 166, 76, -18, -113, -209, -304, -394, -479, -559, -630, -694, -749, -796, -833, -861, -881, -893, -897, -894, -885, -870, -850, -828, -803, -775, -746, -717, -688, -659, -632, -605, -581, -558, -538, -519, -503, -488, -475, -463, -453, -443, -435, -427, -420, -413, -406, -399, -391, -383, -375, -367, -359, -349, -339, -330, -320, -310, -299, -289, -279, -269, -258, -249, -240, -231, -223, -216, -208, -202, -195, -189, -184, -179, -175, -171, -166, -162, -159, -156, -152, -149, -147, -143, -140, -137, -134, -131, -128, -125, -122, -118, -115, -112, -110, -107, -103, -101, -98, -96, -93, -90, -88, -85, -83, -81, -79, -78, -76, -74, -73, -71, -69, -68, -67, -66, -64, -64, -63, -62, -60, -58, -66, -50, -144, -1846, -5266, -9578, -14189, -18540, -22181, -24795, -26152, -26140, -24744, -22044, -18188, -13380, -7877, -1807};