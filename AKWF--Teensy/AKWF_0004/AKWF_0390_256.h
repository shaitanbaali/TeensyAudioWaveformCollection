/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0390 256 samples */
 
const int16_t AKWF_0390_256_DATA [256] = 
{176, 602, 1060, 1534, 2014, 2495, 2974, 3447, 3913, 4371, 4819, 5258, 5686, 6045, 6665, 5862, -2068, -7158, -7095, -6376, -5548, -4726, -3942, -3200, -2505, -1859, -1264, -725, -258, 102, 497, 951, 1419, 1897, 2375, 2853, 3324, 3791, 4249, 4697, 5136, 5565, 5981, 6387, 6782, 7164, 7535, 7895, 8242, 8577, 8902, 9214, 9516, 9807, 10086, 10351, 10515, 11246, 7479, -1466, -3772, -3510, -2936, -2311, -1712, -1158, -656, -222, 112, 485, 911, 1350, 1797, 2246, 2692, 3135, 3570, 3999, 4419, 4829, 5230, 5621, 6001, 6370, 6728, 7076, 7412, 7738, 8053, 8356, 8649, 8933, 9205, 9468, 9721, 9962, 10195, 10418, 10613, 10803, 11147, 4321, -2964, -3783, -3405, -2833, -2242, -1680, -1160, -689, -273, 46, 376, 765, 1168, 1578, 1992, 2404, 2812, 3215, 3611, 3999, 4380, 4751, 5113, 5466, 5808, 6141, 6464, 6777, 7080, 7373, 7655, 7928, 8193, 8446, 8691, 8926, 9152, 9369, 9578, 9718, 10151, 9008, 327, -4461, -4576, -4082, -3478, -2872, -2297, -1759, -1261, -805, -395, -65, 221, 568, 938, 1317, 1700, 2083, 2464, 2840, 3210, 3574, 3931, 4278, 4618, 4949, 5270, 5584, 5888, 6182, 6467, 6743, 7010, 7268, 7517, 7757, 7988, 8210, 8425, 8627, 8737, 9366, 5776, -2981, -5626, -5367, -4799, -4164, -3541, -2951, -2394, -1871, -1385, -938, -533, -183, 87, 389, 732, 1086, 1446, 1368, 4151, -10594, -33810, -30767, -29790, -28512, -27196, -25873, -24551, -23231, -21922, -20630, -19354, -18103, -16879, -15680, -14515, -13383, -12284, -11222, -10217, -9265, -8060, -14736, -23155, -23455, -22380, -21110, -19791, -18479, -17191, -15934, -14706, -13512, -12358, -11239, -10159, -9122, -8125, -7170, -6259, -5390, -4566, -3787, -3052, -2366, -1729, -1143, -615, -163};