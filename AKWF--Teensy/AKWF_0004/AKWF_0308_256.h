/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0308 256 samples */
 
const int16_t AKWF_0308_256_DATA [256] = 
{1918, 5435, 8794, 12039, 15127, 18029, 20722, 23172, 25368, 27295, 28935, 30287, 31347, 32108, 32580, 32766, 32675, 32319, 31711, 30870, 29809, 28548, 27113, 25516, 23784, 21941, 20001, 17994, 15940, 13853, 11762, 9684, 7629, 5625, 3681, 1809, 29, -1653, -3229, -4686, -6022, -7231, -8307, -9253, -10064, -10741, -11288, -11706, -11999, -12174, -12234, -12186, -12037, -11795, -11468, -11062, -10589, -10055, -9467, -8836, -8171, -7477, -6764, -6039, -5308, -4581, -3861, -3154, -2468, -1805, -1170, -567, -1, 529, 1018, 1467, 1872, 2233, 2551, 2825, 3055, 3244, 3392, 3499, 3569, 3604, 3604, 3573, 3512, 3425, 3314, 3182, 3032, 2865, 2685, 2494, 2294, 2089, 1879, 1668, 1458, 1248, 1043, 844, 650, 466, 291, 124, -30, -174, -305, -426, -533, -628, -710, -780, -839, -885, -921, -946, -960, -965, -961, -949, -930, -903, -870, -833, -790, -743, -694, -642, -588, -532, -476, -420, -364, -310, -256, -204, -154, -107, -62, -19, 19, 55, 88, 118, 144, 167, 187, 204, 218, 228, 236, 242, 244, 244, 242, 238, 232, 225, 216, 205, 194, 182, 169, 156, 141, 127, 114, 99, 85, 71, 58, 45, 33, 21, 10, 0, -9, -17, -25, -32, -39, -44, -49, -52, -56, -58, -59, -61, -60, -61, -60, -58, -57, -55, -52, -49, -46, -43, -40, -37, -33, -30, -26, -23, -19, -16, -13, -10, -7, -4, -2, 0, 2, 4, 6, 8, 9, 11, 11, 12, 12, 6, 29, -371, -1614, -3510, -5904, -8636, -11578, -14604, -17590, -20449, -23091, -25436, -27438, -29043, -30216, -30941, -31203, -31001, -30343, -29244, -27734, -25832, -23580, -21018, -18180, -15118, -11880, -8505, -5054, -1490};