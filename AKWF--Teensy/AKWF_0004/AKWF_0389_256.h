/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0389 256 samples */
 
const int16_t AKWF_0389_256_DATA [256] = 
{394, 1399, 2373, 3335, 4280, 5209, 6120, 7009, 7878, 8725, 9547, 10346, 11122, 11870, 12596, 13296, 13970, 14621, 15248, 15850, 16430, 16988, 17524, 18041, 18539, 19018, 19482, 19930, 20363, 20784, 21194, 21593, 21984, 22367, 22743, 23115, 23481, 23843, 24204, 24561, 24917, 25273, 25627, 25980, 26333, 26685, 27036, 27387, 27733, 28079, 28422, 28759, 29092, 29419, 29738, 30049, 30350, 30640, 30918, 31181, 31429, 31660, 31873, 32067, 32240, 32390, 32517, 32620, 32697, 32745, 32767, 32761, 32726, 32660, 32566, 32439, 32282, 32095, 31878, 31628, 31350, 31042, 30705, 30340, 29947, 29529, 29084, 28614, 28122, 27608, 27072, 26518, 25946, 25358, 24754, 24137, 23507, 22867, 22217, 21557, 20892, 20220, 19542, 18862, 18178, 17490, 16803, 16113, 15421, 14731, 14039, 13347, 12656, 11964, 11270, 10579, 9885, 9189, 8494, 7795, 7093, 6390, 5682, 4970, 4253, 3531, 2803, 2070, 1328, 581, -173, -936, -1706, -2485, -3270, -4061, -4861, -5669, -6479, -7297, -8120, -8945, -9774, -10605, -11434, -12265, -13094, -13917, -14738, -15552, -16357, -17154, -17938, -18710, -19468, -20211, -20935, -21643, -22329, -22992, -23635, -24252, -24845, -25412, -25952, -26463, -26947, -27402, -27828, -28225, -28590, -28929, -29238, -29517, -29768, -29992, -30188, -30359, -30504, -30625, -30722, -30798, -30853, -30889, -30906, -30907, -30893, -30865, -30825, -30773, -30711, -30642, -30564, -30481, -30393, -30299, -30203, -30102, -30000, -29897, -29791, -29684, -29575, -29464, -29353, -29239, -29120, -29000, -28874, -28742, -28606, -28461, -28306, -28142, -27967, -27778, -27574, -27355, -27118, -26863, -26587, -26289, -25968, -25623, -25250, -24852, -24425, -23968, -23484, -22967, -22419, -21842, -21231, -20587, -19914, -19209, -18472, -17707, -16911, -16086, -15236, -14359, -13458, -12537, -11594, -10635, -9662, -8674, -7675, -6670, -5656, -4640, -3625, -2610, -1600, -577};