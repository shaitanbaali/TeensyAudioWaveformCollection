/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0339 256 samples */
 
const int16_t AKWF_0339_256_DATA [256] = 
{1997, 4805, 7264, 9449, 11418, 13212, 14826, 16238, 17455, 18475, 19269, 19861, 20334, 20739, 21074, 21318, 21465, 21502, 21402, 21189, 20985, 20866, 20815, 20794, 20773, 20718, 20585, 20370, 20137, 19925, 19708, 19459, 19159, 18793, 18327, 17762, 17160, 16558, 15937, 15280, 14574, 13808, 12956, 12020, 11078, 10180, 9307, 8434, 7551, 6637, 5656, 4654, 3816, 3259, 2959, 2849, 2867, 2950, 3025, 3064, 3117, 3204, 3295, 3351, 3350, 3270, 3079, 2776, 2419, 2047, 1642, 1185, 667, 76, -615, -1401, -2204, -2974, -3728, -4491, -5272, -6093, -6987, -7931, -8811, -9554, -10181, -10734, -11247, -11754, -12306, -12908, -13497, -14039, -14559, -15090, -15649, -16253, -16939, -17709, -18498, -19274, -20055, -20860, -21703, -22594, -23563, -24606, -25647, -26636, -27595, -28545, -29499, -30477, -31521, -32465, -32753, -32045, -30388, -27955, -24962, -21620, -18111, -14578, -11050, -7549, -4165, -958, 2041, 4790, 7259, 9450, 11418, 13212, 14826, 16238, 17455, 18475, 19269, 19861, 20333, 20739, 21074, 21318, 21465, 21502, 21402, 21189, 20985, 20866, 20815, 20794, 20773, 20718, 20585, 20370, 20137, 19925, 19708, 19459, 19159, 18793, 18327, 17762, 17160, 16558, 15937, 15280, 14574, 13808, 12956, 12020, 11078, 10180, 9307, 8434, 7551, 6637, 5656, 4654, 3816, 3259, 2959, 2849, 2867, 2950, 3025, 3064, 3117, 3204, 3295, 3351, 3350, 3270, 3079, 2776, 2419, 2048, 1642, 1185, 667, 76, -615, -1401, -2204, -2974, -3728, -4491, -5272, -6093, -6987, -7931, -8811, -9554, -10181, -10734, -11247, -11754, -12306, -12908, -13497, -14039, -14559, -15090, -15649, -16253, -16939, -17709, -18498, -19274, -20055, -20860, -21703, -22594, -23563, -24606, -25648, -26636, -27595, -28545, -29499, -30477, -31521, -32465, -32753, -32045, -30388, -27955, -24962, -21620, -18111, -14578, -11050, -7554, -4177, -919};