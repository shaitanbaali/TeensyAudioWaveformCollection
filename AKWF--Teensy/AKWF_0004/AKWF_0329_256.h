/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0329 256 samples */
 
const int16_t AKWF_0329_256_DATA [256] = 
{4789, 16208, 20856, 25809, 28280, 27017, 22422, 15303, 6615, -2600, -11267, -18547, -23708, -28881, -32640, -28145, -19962, -10668, -1609, 6206, 12101, 15603, 16629, 15547, 12990, 9755, 6404, 3323, 640, -1554, -3039, -6277, -8862, -8022, -7748, -7673, -9298, -9574, -12446, -12789, -9302, -3545, 2112, 6334, 9078, 9788, 7861, 2059, -2019, -566, 308, 3663, 8076, 11815, 14021, 14256, 12559, 9358, 5398, 1574, -1522, -3530, -4352, -4180, -3307, -2356, -2294, -3371, -4325, -3877, -2239, -881, 583, 6059, 8411, 7449, 5786, 4167, 2980, 2139, 1213, 240, -640, -1113, -1028, -330, 4791, 7727, 6150, 3643, 1055, -1129, -2664, -3480, -3644, -3708, 154, 4747, 4727, 3573, 2112, 691, -305, -902, -181, 7083, 12905, 12365, 10863, 7620, 2075, -4036, -2392, 431, -125, -132, 825, 4466, 8852, 12422, 15345, 11380, 3962, -2400, -10978, -20436, -22795, -23259, -25595, -26305, -24862, -21243, -16240, -6963, 4306, 10115, 13397, 15114, 15567, 15018, 13289, 13287, 15728, 13180, 8192, 2865, -1913, -5680, -8255, -9603, -9844, -9442, -4449, 147, 52, -1241, -2908, -4535, -5835, -6651, -6930, -6753, -6275, -5570, -4637, -3850, -3697, -3558, -3285, -2996, -2713, -2414, -2241, -2601, -2205, -2338, -3950, -4325, -3360, -1418, 1098, 3531, 5156, 5499, 4441, 2263, -519, -3241, -5358, -6606, -6820, -5718, -3165, -4112, -4616, -1936, 441, 2420, 3986, 4810, 4600, 3228, 1124, -5118, -13131, -15734, -15593, -13897, -11679, -9532, -7461, -8586, -12192, -10686, -7196, -3372, 52, 2898, 3333, -1507, -4591, -4486, -3630, -2274, 4447, 7248, 1700, 323, 2346, 4996, 7615, 10031, 11208, 8328, 9296, 12810, 15511, 16316, 14642, 9488, -1390, -8592, -9407, -7761, -4706, -1082, 2483, 5801, 4508, 3355, 6462, 10845, 11994, -4335, -16307, -9082};