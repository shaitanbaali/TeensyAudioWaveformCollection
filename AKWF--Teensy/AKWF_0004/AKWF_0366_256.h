/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0366 256 samples */
 
const int16_t AKWF_0366_256_DATA [256] = 
{2039, 5274, 8372, 11437, 14471, 17439, 20274, 22886, 25221, 27233, 28896, 30224, 31235, 31959, 32434, 32694, 32768, 32684, 32462, 32117, 31657, 31089, 30408, 29591, 28601, 27384, 25914, 24180, 22197, 20060, 17905, 15822, 13835, 11940, 10119, 8385, 6780, 5322, 4005, 2819, 1742, 776, -63, -760, -1304, -1675, -1859, -1838, -1611, -1189, -613, 65, 796, 1538, 2271, 3015, 3792, 4610, 5451, 6283, 7099, 7894, 8643, 9322, 9908, 10381, 10730, 10946, 11014, 10919, 10669, 10293, 9807, 9208, 8494, 7674, 6790, 5890, 5010, 4181, 3410, 2668, 1932, 1189, 448, -266, -925, -1513, -2011, -2410, -2711, -2913, -3022, -3049, -3000, -2887, -2717, -2479, -2156, -1733, -1208, -600, 54, 719, 1359, 1948, 2467, 2915, 3291, 3604, 3861, 4068, 4230, 4343, 4407, 4417, 4371, 4270, 4120, 3926, 3692, 3423, 3113, 2748, 2300, 1748, 1102, 394, -340, -1056, -1724, -2320, -2832, -3262, -3616, -3899, -4121, -4285, -4393, -4445, -4441, -4380, -4266, -4107, -3907, -3674, -3411, -3122, -2794, -2405, -1942, -1390, -771, -117, 532, 1141, 1683, 2143, 2507, 2776, 2953, 3042, 3050, 2986, 2857, 2661, 2375, 1976, 1450, 815, 106, -640, -1389, -2120, -2847, -3602, -4398, -5226, -6053, -6864, -7657, -8414, -9110, -9724, -10232, -10621, -10883, -11005, -10967, -10767, -10431, -9978, -9411, -8724, -7924, -7044, -6134, -5236, -4385, -3597, -2856, -2144, -1447, -760, -101, 498, 1016, 1418, 1671, 1738, 1587, 1217, 652, -63, -913, -1920, -3101, -4455, -5932, -7447, -8977, -10567, -12243, -14046, -15997, -18061, -20180, -22277, -24260, -26072, -27668, -29021, -30135, -31016, -31682, -32155, -32455, -32599, -32596, -32453, -32175, -31760, -31201, -30477, -29533, -28297, -26698, -24697, -22364, -19783, -16982, -14016, -10923, -7737, -4487, -1132};