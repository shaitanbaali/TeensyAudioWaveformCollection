/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0383 256 samples */
 
const int16_t AKWF_0383_256_DATA [256] = 
{125, 547, 916, 1244, 1546, 1892, 2374, 3035, 3881, 4902, 6067, 7353, 8732, 10169, 11650, 13148, 14644, 16132, 17597, 19028, 20428, 21792, 23127, 24461, 25784, 27056, 28242, 29310, 30240, 31027, 31663, 32150, 32495, 32699, 32770, 32718, 32546, 32263, 31875, 31388, 30807, 30128, 29313, 28310, 27109, 25732, 24202, 22558, 20845, 19090, 17332, 15603, 13916, 12298, 10761, 9309, 7954, 6699, 5538, 4476, 3512, 2635, 1847, 1141, 509, -59, -614, -1221, -1910, -2683, -3530, -4430, -5364, -6311, -7253, -8177, -9071, -9922, -10730, -11488, -12192, -12845, -13446, -13995, -14498, -14956, -15373, -15753, -16101, -16418, -16712, -16984, -17240, -17482, -17716, -17945, -18173, -18404, -18645, -18910, -19208, -19539, -19890, -20236, -20556, -20838, -21069, -21247, -21369, -21433, -21442, -21397, -21298, -21150, -20952, -20708, -20414, -20074, -19687, -19253, -18771, -18241, -17659, -17028, -16343, -15604, -14811, -13960, -13051, -12084, -11059, -9972, -8826, -7621, -6355, -5036, -3671, -2269, -847, 593, 2043, 3489, 4932, 6363, 7772, 9162, 10523, 11850, 13148, 14416, 15658, 16895, 18115, 19289, 20388, 21381, 22253, 22995, 23599, 24068, 24403, 24607, 24685, 24644, 24488, 24221, 23850, 23381, 22816, 22160, 21418, 20594, 19690, 18714, 17665, 16549, 15371, 14133, 12839, 11499, 10111, 8682, 7222, 5732, 4232, 2736, 1248, -214, -1645, -3041, -4391, -5693, -6947, -8144, -9285, -10371, -11399, -12370, -13289, -14152, -14973, -15763, -16527, -17267, -17968, -18604, -19164, -19636, -20016, -20306, -20508, -20629, -20677, -20658, -20579, -20450, -20278, -20070, -19831, -19569, -19289, -18994, -18690, -18382, -18069, -17755, -17445, -17135, -16831, -16530, -16232, -15938, -15647, -15356, -15066, -14772, -14465, -14102, -13631, -13040, -12334, -11531, -10653, -9728, -8775, -7816, -6871, -5949, -5066, -4229, -3440, -2706, -2029, -1407, -843, -324};