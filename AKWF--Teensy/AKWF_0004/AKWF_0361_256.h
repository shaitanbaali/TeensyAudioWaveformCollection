/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0361 256 samples */
 
const int16_t AKWF_0361_256_DATA [256] = 
{7968, 31095, 21393, 12210, 9461, 6699, 4829, 3443, 2320, 1379, 564, -163, -820, -1416, -1959, -2452, -2896, -3296, -3651, -3963, -4234, -4465, -4657, -4812, -4933, -5020, -5075, -5101, -5100, -5073, -5022, -4950, -4859, -4750, -4625, -4486, -4335, -4173, -4003, -3827, -3643, -3456, -3266, -3073, -2881, -2689, -2499, -2310, -2126, -1945, -1768, -1597, -1431, -1271, -1117, -971, -831, -698, -573, -454, -342, -243, -268, 593, -5459, -10844, -4667, -3432, -2167, -1305, -684, -202, 188, 519, 802, 1052, 1272, 1466, 1638, 1787, 1916, 2027, 2119, 2194, 2253, 2296, 2324, 2339, 2342, 2333, 2313, 2283, 2244, 2198, 2144, 2084, 2019, 1949, 1876, 1799, 1719, 1638, 1556, 1472, 1389, 1306, 1224, 1142, 1063, 985, 910, 836, 765, 697, 631, 568, 510, 453, 399, 348, 301, 257, 216, 178, 142, 114, 65, -72, 2700, -9647, -12165, -5361, -5053, -3931, -3225, -2739, -2335, -2000, -1703, -1431, -1176, -937, -708, -490, -285, -90, 93, 266, 426, 575, 712, 838, 953, 1054, 1146, 1226, 1295, 1355, 1403, 1443, 1474, 1496, 1509, 1515, 1514, 1506, 1492, 1473, 1448, 1418, 1385, 1348, 1308, 1265, 1220, 1173, 1124, 1073, 1023, 971, 921, 869, 818, 767, 717, 668, 620, 574, 528, 480, 316, 1046, -5128, -10627, -4556, -3418, -2242, -1463, -918, -504, -174, 100, 335, 541, 723, 884, 1027, 1153, 1263, 1357, 1436, 1501, 1552, 1590, 1617, 1632, 1636, 1629, 1614, 1590, 1558, 1518, 1472, 1421, 1363, 1303, 1237, 1169, 1099, 1027, 953, 878, 803, 728, 653, 580, 508, 436, 367, 299, 234, 171, 111, 54, 0, -52, -101, -146, -190, -229, -266, -300, -331, -360, -379, -427};