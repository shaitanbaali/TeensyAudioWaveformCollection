/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0315 256 samples */
 
const int16_t AKWF_0315_256_DATA [256] = 
{10595, 23542, 26613, 21728, 13052, 4460, -1925, -5521, -6749, -6382, -5164, -3643, -2146, -845, 185, 908, 1317, 1427, 1284, 961, 542, 116, -242, -491, -612, -615, -530, -392, -239, -98, 10, 82, 117, 121, 106, 81, 55, 33, 18, 10, 9, 12, 18, 24, 30, 32, 34, 32, 28, 24, 18, 14, 9, 5, 1, -1, -3, -5, -6, -8, -164, 785, -3576, -11455, -1228, 6679, 8789, 5976, 1486, -1944, -3293, -2825, -1413, 69, 1067, 1416, 1230, 759, 242, -158, -382, -445, -404, -321, -239, -182, -153, -142, -140, -135, -123, -104, -82, -58, -36, -17, -3, 7, 15, 22, 27, 31, 34, 37, 37, 36, 37, 36, 34, 31, 28, 25, 21, 19, 15, 12, 9, 6, -4, -60, 147, -3451, -13464, -23168, -28407, -27031, -26580, -27342, -9760, 4217, 10433, 9818, 6170, 3002, 2056, 3549, 6788, 10778, 14618, 17708, 19717, 20541, 20214, 18854, 16632, 13735, 10398, 6870, 3372, 131, -2683, -4967, -6657, -7751, -8297, -8361, -8030, -7391, -6533, -5529, -4448, -3348, -2275, -1265, -354, 438, 1098, 1613, 1982, 2210, 2308, 2289, 2170, 1972, 1715, 1421, 1109, 796, 495, 221, -17, -216, -374, -490, -563, -599, -601, -578, -686, 327, -3959, -11759, -1452, 6532, 8713, 5962, 1525, -1863, -3179, -2690, -1267, 218, 1211, 1549, 1348, 859, 323, -97, -341, -422, -397, -326, -256, -208, -184, -177, -175, -170, -156, -133, -107, -78, -51, -29, -10, 5, 15, 25, 33, 38, 43, 45, 46, 45, 44, 41, 39, 34, 30, 26, 22, 18, 15, 11, 7, 4, -5, -48, 128, -3288, -10919, -16366, -16855, -11168, -7574, -6058};