/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0395 256 samples */
 
const int16_t AKWF_0395_256_DATA [256] = 
{587, 1784, 2945, 4098, 5235, 6358, 7465, 8550, 9616, 10662, 11684, 12683, 13660, 14610, 15537, 16439, 17314, 18165, 18990, 19787, 20562, 21311, 22032, 22730, 23402, 24049, 24673, 25271, 25844, 26394, 26920, 27423, 27903, 28357, 28790, 29200, 29587, 29950, 30293, 30611, 30907, 31181, 31431, 31662, 31868, 32053, 32216, 32357, 32476, 32574, 32652, 32709, 32746, 32765, 32765, 32749, 32716, 32667, 32606, 32531, 32447, 32352, 32249, 32139, 32021, 31899, 31772, 31642, 31508, 31372, 31233, 31094, 30953, 30810, 30667, 30523, 30380, 30236, 30094, 29953, 29816, 29683, 29558, 29444, 29340, 29249, 29167, 29091, 29016, 28940, 28858, 28762, 28646, 28501, 28322, 28104, 27843, 27537, 27185, 26784, 26337, 25840, 25297, 24707, 24072, 23390, 22667, 21901, 21093, 20248, 19364, 18443, 17490, 16503, 15485, 14442, 13369, 12273, 11159, 10021, 8869, 7705, 6526, 5342, 4154, 2959, 1768, 580, -604, -1779, -2944, -4098, -5235, -6359, -7466, -8551, -9617, -10663, -11684, -12683, -13660, -14610, -15537, -16439, -17314, -18165, -18990, -19788, -20562, -21311, -22032, -22730, -23402, -24049, -24672, -25271, -25844, -26394, -26920, -27423, -27903, -28357, -28790, -29201, -29587, -29950, -30293, -30611, -30907, -31181, -31431, -31662, -31868, -32053, -32216, -32357, -32477, -32574, -32652, -32709, -32746, -32765, -32766, -32749, -32716, -32668, -32606, -32531, -32447, -32352, -32249, -32139, -32021, -31899, -31773, -31642, -31508, -31372, -31234, -31094, -30953, -30811, -30668, -30524, -30380, -30236, -30094, -29953, -29817, -29683, -29559, -29444, -29340, -29249, -29167, -29091, -29017, -28941, -28858, -28762, -28646, -28502, -28322, -28104, -27844, -27538, -27185, -26784, -26337, -25841, -25297, -24707, -24072, -23391, -22668, -21902, -21093, -20248, -19364, -18443, -17491, -16503, -15486, -14442, -13369, -12274, -11159, -10021, -8869, -7706, -6527, -5343, -4153, -2962, -1774, -565};