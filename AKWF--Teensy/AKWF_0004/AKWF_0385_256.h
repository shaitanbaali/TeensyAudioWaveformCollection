/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0385 256 samples */
 
const int16_t AKWF_0385_256_DATA [256] = 
{150, 445, 1463, 2994, 4414, 5276, 5490, 5388, 5210, 5029, 4844, 4638, 4403, 4139, 3891, 3535, 3822, 9194, 16356, 17222, 13507, 10729, 9654, 9169, 8752, 8307, 7789, 7185, 6535, 5545, 4181, 3157, 2572, 1780, 831, -5374, -18010, -26538, -29118, -29948, -31712, -32778, -32213, -31143, -30269, -28997, -27126, -24965, -22753, -20526, -18899, -20022, -22445, -22436, -16013, -6336, -458, 1818, 2892, 3778, 4640, 5493, 6300, 6980, 7468, 7742, 7837, 7840, 7683, 6338, 4328, 3462, 3944, 4573, 4787, 4778, 4723, 4663, 4618, 4595, 4588, 4576, 4546, 4489, 4410, 4316, 4210, 4087, 3943, 3767, 3562, 3348, 3140, 2935, 2731, 2528, 2329, 2139, 1952, 1768, 1587, 1412, 1253, 1122, 1021, 941, 869, 800, 743, 695, 645, 599, 558, 513, 458, 393, 316, 215, 91, -45, -182, -317, -457, -611, -779, -955, -1131, -1305, -1472, -1626, -1747, -1824, -1857, -1879, -1725, -1021, -298, -3, 35, 9, -21, -56, -107, -180, -267, -364, -469, -583, -696, -806, -915, -1020, -1120, -1224, -1303, -352, 1493, 2871, 3669, 3810, 3531, 3107, 2679, 4530, 7765, 7786, 5027, 2845, 2360, 2691, 3022, 2823, 2990, 2918, 1224, -867, -1884, -1304, 33, 871, 213, -1092, -1687, -929, 451, 2048, 3616, 4358, 3753, 2545, 1928, 1860, 1988, 2791, 4091, 4796, 4881, 4572, 3970, 3478, 3723, 4825, 5629, 5578, 4364, 2924, 2150, 1794, 1954, 2932, 3681, 3773, 3345, 2028, 635, -34, 410, 1559, 2194, 2199, 1951, 1665, 1402, 1177, 979, 790, 598, 394, 190, -5, -187, -347, -484, -531, -1112, -2950, -4494, -4960, -4874, -4669, -4458, -4237, -3994, -3720, -3417, -3093, -2759, -2419, -2085, -1766, -1460, -1165, -880, -604, -338, -79};