/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0304 256 samples */
 
const int16_t AKWF_0304_256_DATA [256] = 
{1, 0, -451, 2124, -10201, -31417, -22400, -17151, -11714, -6688, -2134, 1939, 5507, 8549, 11081, 13105, 14630, 15687, 16301, 16501, 16325, 15809, 14996, 13922, 12630, 11166, 9561, 7861, 6102, 4312, 2532, 788, -897, -2494, -3986, -5358, -6591, -7679, -8613, -9387, -9999, -10452, -10744, -10885, -10878, -10733, -10459, -10068, -9570, -8978, -8305, -7567, -6771, -5935, -5072, -4190, -3304, -2426, -1563, -727, 72, 831, 1541, 2196, 2793, 3327, 3795, 4198, 4532, 4799, 5000, 5135, 5210, 5223, 5182, 5087, 4945, 4759, 4533, 4274, 3986, 3672, 3340, 2994, 2637, 2275, 1912, 1551, 1197, 853, 521, 206, -91, -369, -625, -858, -1068, -1252, -1411, -1546, -1656, -1741, -1803, -1843, -1860, -1858, -1836, -1797, -1742, -1673, -1592, -1499, -1397, -1287, -1173, -1054, -931, -809, -686, -564, -445, -330, -219, -114, -16, 76, 162, 239, 309, 370, 424, 468, 506, 535, 556, 571, 579, 580, 575, 564, 549, 528, 504, 477, 446, 412, 379, 342, 304, 267, 229, 192, 155, 119, 85, 52, 22, -7, -33, -57, -79, -99, -116, -130, -143, -153, -160, -165, -169, -170, -170, -168, -163, -159, -152, -144, -136, -126, -116, -106, -95, -84, -73, -62, -52, -41, -31, -21, -11, -4, 4, 11, 17, 23, 29, 33, 38, 41, 44, 46, 46, 46, 47, 47, 46, 45, 42, 41, 39, 35, 33, 31, 28, 25, 22, 19, 16, 13, 10, 7, 4, 1, -1, -2, -4, -6, -7, -8, -10, -11, -12, -13, -13, -12, -13, -13, -12, -13, -12, -12, -11, -11, -10, -8, -8, -7, -7, -6, -5, -4, -3, -2, -2, -2, -1, 0};