/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0312 256 samples */
 
const int16_t AKWF_0312_256_DATA [256] = 
{4457, 11975, 18855, 24747, 29218, 31961, 32798, 31688, 28722, 24116, 18206, 11364, 4041, -3278, -10183, -16254, -21140, -24610, -26497, -26747, -25410, -22630, -18640, -13708, -8186, -2430, 3226, 8431, 12897, 16406, 18778, 19928, 19846, 18595, 16301, 13147, 9374, 5224, 960, -3142, -6861, -9991, -12363, -13884, -14498, -14214, -13089, -11233, -8797, -5943, -2867, 229, 3174, 5792, 7937, 9518, 10458, 10733, 10361, 9397, 7926, 6059, 3931, 1680, -556, -2638, -4453, -5908, -6925, -7472, -7536, -7136, -6319, -5152, -3726, -2133, -478, 1132, 2613, 3878, 4859, 5518, 5828, 5787, 5415, 4753, 3853, 2780, 1607, 411, -738, -1772, -2634, -3285, -3692, -3844, -3745, -3413, -2880, -2185, -1383, -524, 337, 1147, 1860, 2438, 2851, 3083, 3126, 2988, 2684, 2237, 1684, 1059, 402, -244, -847, -1372, -1791, -2088, -2251, -2277, -2173, -1953, -1636, -1247, -812, -362, 76, 475, 813, 1073, 1242, 1315, 1290, 1175, 981, 722, 418, 89, -244, -561, -844, -1078, -1250, -1352, -1384, -1343, -1239, -1078, -874, -640, -391, -143, 88, 293, 460, 579, 648, 664, 630, 550, 431, 284, 117, -56, -226, -383, -518, -623, -693, -725, -720, -679, -606, -506, -388, -258, -126, 2, 118, 216, 290, 339, 360, 353, 321, 267, 195, 110, 19, -73, -160, -237, -301, -347, -374, -380, -367, -336, -290, -232, -165, -94, -26, 37, 94, 140, 172, 190, 192, 181, 157, 123, 80, 32, -16, -63, -108, -145, -174, -193, -201, -199, -187, -165, -137, -104, -68, -31, 5, 36, 63, 83, 96, 101, 98, 88, 72, 52, 27, 2, -40, -17, -333, -2757, -6886, -11615, -16044, -19424, -21223, -21118, -19020, -15052, -9518, -2676};