/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0399 256 samples */
 
const int16_t AKWF_0399_256_DATA [256] = 
{1195, 3245, 4980, 6869, 8848, 10740, 12687, 14418, 15931, 17075, 17830, 18512, 19141, 19699, 20354, 20791, 21356, 21830, 22390, 23291, 23939, 24599, 25417, 25970, 26446, 26500, 26518, 26582, 26889, 27308, 27596, 27844, 27931, 27571, 27213, 26892, 26604, 26399, 26323, 26513, 26823, 26963, 26707, 26344, 26056, 25810, 25192, 24595, 24249, 23837, 22982, 22233, 21857, 21436, 20488, 19669, 18921, 18036, 17204, 16421, 15707, 14982, 14854, 15042, 15402, 15952, 16660, 17437, 18062, 18480, 18608, 18743, 18974, 19111, 19634, 20319, 20733, 21113, 21517, 22102, 22738, 23711, 24767, 25573, 26183, 26452, 26415, 26470, 26576, 26805, 27140, 27698, 28547, 29218, 30039, 31229, 32108, 32409, 32516, 32509, 32647, 32739, 32376, 32414, 32614, 32574, 32582, 32384, 32148, 31496, 30282, 29288, 28778, 27908, 27098, 26858, 26680, 26788, 23449, 13570, 11335, 5144, -699, -5125, -8278, -10732, -12798, -14529, -16247, -17770, -18948, -19728, -20192, -20387, -20247, -20350, -20570, -20906, -21147, -21478, -21976, -22383, -22771, -23326, -23919, -24482, -24829, -25071, -25178, -25430, -25500, -25413, -25513, -25944, -26167, -26392, -26621, -26942, -27155, -27249, -27525, -27993, -28406, -28701, -28671, -28619, -28446, -27908, -27135, -26292, -25325, -23919, -22539, -21487, -20804, -20175, -19358, -19036, -18765, -18283, -17939, -17710, -17721, -17779, -18000, -18248, -18468, -18694, -18724, -18688, -18590, -18667, -18738, -18816, -19113, -19474, -19840, -20124, -20497, -20859, -21189, -21530, -21887, -22198, -22619, -22743, -23090, -23842, -24444, -24920, -25270, -25492, -25779, -26123, -26229, -26287, -26442, -26613, -26837, -26969, -27197, -27237, -27348, -27616, -27937, -28396, -28792, -29073, -29223, -29207, -28803, -27827, -26602, -25073, -23084, -21184, -19478, -18015, -16691, -15421, -14305, -12954, -11528, -10394, -9199, -8226, -7671, -7420, -7325, -7529, -7660, -7304, -6425, -4886, -3008, -897};