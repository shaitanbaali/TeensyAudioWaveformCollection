/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0350 256 samples */
 
const int16_t AKWF_0350_256_DATA [256] = 
{603, 1529, 2469, 3439, 4426, 5423, 6426, 7431, 8438, 9441, 10431, 11428, 12435, 13435, 14423, 15384, 16310, 17201, 18046, 18837, 19577, 20265, 20896, 21468, 21978, 22421, 22800, 23113, 23358, 23539, 23651, 23645, 23568, 23497, 23391, 23257, 23100, 22929, 22758, 22581, 22406, 22244, 22101, 21984, 21893, 21822, 21769, 21756, 21766, 21810, 21898, 22017, 22172, 22364, 22587, 22842, 23131, 23449, 23793, 24137, 24410, 24546, 24348, 23923, 23584, 23297, 22963, 22548, 22082, 21596, 21055, 20460, 19858, 19291, 18770, 18267, 17749, 17208, 16649, 16079, 15501, 14914, 14325, 13744, 13163, 12564, 11940, 11284, 10599, 9884, 9134, 8348, 7517, 6634, 5695, 4658, 3539, 2379, 1155, -133, -1467, -2840, -4239, -5654, -7082, -8517, -9948, -11382, -12825, -14265, -15698, -17113, -18496, -19843, -21147, -22396, -23591, -24719, -25777, -26770, -27697, -28555, -29337, -30064, -30748, -31381, -31943, -32371, -32643, -32763, -32736, -32577, -32282, -31859, -31321, -30673, -29923, -29078, -28164, -27200, -26199, -25175, -24136, -23105, -22093, -21095, -20112, -19146, -18197, -17275, -16391, -15548, -14757, -14021, -13335, -12697, -12136, -11679, -11328, -11177, -11143, -11093, -11129, -11238, -11405, -11609, -11821, -12050, -12284, -12493, -12659, -12787, -12886, -12981, -13078, -13138, -13202, -13268, -13314, -13359, -13398, -13423, -13447, -13472, -13492, -13509, -13529, -13567, -13647, -13708, -13765, -13845, -13946, -14072, -14207, -14353, -14508, -14661, -14803, -14928, -15031, -15113, -15175, -15209, -15214, -15186, -15124, -15035, -14922, -14783, -14621, -14438, -14233, -14007, -13761, -13495, -13214, -12923, -12621, -12315, -12009, -11709, -11436, -11264, -11146, -10988, -10852, -10738, -10640, -10551, -10455, -10359, -10261, -10149, -10016, -9853, -9672, -9474, -9254, -9011, -8737, -8430, -8093, -7726, -7327, -6897, -6439, -5954, -5431, -4844, -4177, -3477, -2742, -1962, -1141, -259};