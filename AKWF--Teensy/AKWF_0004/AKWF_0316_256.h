/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0316 256 samples */
 
const int16_t AKWF_0316_256_DATA [256] = 
{10291, 25296, 32473, 31088, 24292, 15185, 6066, -1344, -5902, -7228, -5878, -3102, -279, 1598, 2218, 1847, 1049, 349, 41, 151, 519, 925, 1192, 1240, 1086, 812, 514, 272, 124, 67, 73, 103, 130, 135, 120, 92, 65, 46, 40, 43, 49, 55, 55, 49, 39, 27, 16, 8, 3, 2, 3, 6, 10, 15, 19, 26, 32, 40, 48, 57, -50, 583, -3514, -12949, -11612, -3405, 7412, 14212, 14702, 10004, 3109, -2924, -6221, -6419, -4367, -1462, 1025, 2359, 2445, 1653, 551, -365, -822, -797, -451, -10, 337, 494, 459, 303, 115, -31, -99, -94, -45, 12, 52, 61, 41, 5, -32, -60, -76, -79, -76, -71, -68, -71, -76, -82, -88, -90, -90, -87, -82, -76, -69, -63, -57, -51, -43, -44, -138, 421, -5922, -17141, -20426, -16925, -951, 13795, 22270, 22956, 18280, 10968, 3218, -3260, -7282, -8372, -6966, -4212, -1429, 434, 1082, 781, 81, -507, -703, -491, -37, 439, 760, 848, 725, 474, 196, -27, -159, -202, -182, -138, -101, -84, -91, -111, -133, -147, -149, -144, -134, -126, -125, -130, -138, -149, -160, -168, -173, -174, -173, -170, -167, -163, -157, -152, -145, -138, -130, -121, -229, 405, -3694, -13128, -11790, -3583, 7234, 14034, 14525, 9827, 2932, -3100, -6397, -6594, -4542, -1635, 853, 2189, 2276, 1485, 385, -529, -985, -958, -610, -166, 183, 342, 309, 156, -30, -173, -240, -232, -180, -119, -76, -65, -81, -114, -149, -174, -185, -185, -178, -170, -164, -163, -164, -166, -168, -167, -163, -156, -147, -136, -143, -190, 108, -6053, -18794, -21934, -18006, -13343, -14445, -18278, -14747, -6860};