/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0334 256 samples */
 
const int16_t AKWF_0334_256_DATA [256] = 
{-2165, -4840, -6811, -8328, -9490, -10380, -11062, -11582, -11980, -12286, -12519, -12698, -12835, -12939, -13019, -13080, -13126, -13162, -13190, -13211, -13227, -13240, -13249, -13256, -13261, -13265, -13269, -13271, -13273, -13274, -13275, -13277, -13278, -13277, -13278, -13279, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13278, -13279, -13278, -13302, -13233, -13695, -17148, -21147, -23873, -25943, -27547, -28771, -29710, -30426, -30974, -31395, -31716, -31961, -32150, -32293, -32403, -32488, -32552, -32601, -32639, -32667, -32689, -32707, -32719, -32729, -32737, -32743, -32747, -32750, -32753, -32756, -32756, -32758, -32759, -32759, -32760, -32759, -32759, -32761, -32762, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32761, -32759, -32671, -32998, -30325, -17775, -4922, 3886, 10616, 15821, 19808, 22849, 25176, 26961, 28323, 29365, 30165, 30774, 31241, 31598, 31872, 32080, 32241, 32363, 32457, 32528, 32583, 32625, 32657, 32682, 32700, 32714, 32726, 32734, 32741, 32746, 32750, 32752, 32754, 32756, 32757, 32759, 32759, 32760, 32760, 32759, 32760, 32762, 32761, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32762, 32761, 32739, 32809, 32345, 28892, 24893, 22167, 20098, 18494, 17269, 16330, 15614, 15065, 14645, 14325, 14079, 13891, 13747, 13637, 13552, 13489, 13439, 13401, 13372, 13350, 13334, 13321, 13310, 13304, 13298, 13293, 13290, 13287, 13285, 13284, 13282, 13282, 13281, 13280, 13280, 13280, 13280, 13280, 13280, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13278, 13307, 13205, 13972, 17741, 21530, 24238, 25593, 19962, 11437, 5552, 1151};