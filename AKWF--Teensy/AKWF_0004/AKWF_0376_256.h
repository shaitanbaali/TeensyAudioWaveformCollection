/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0376 256 samples */
 
const int16_t AKWF_0376_256_DATA [256] = 
{4755, 4757, 4759, 4761, 4762, 4764, 4764, 4766, 4766, 4766, 4766, 4766, 4934, 4034, 9310, 14716, 13811, 13980, 13978, 13976, 13975, 13973, 13970, 13968, 13965, 13963, 13960, 13957, 13955, 13952, 13949, 13956, 13952, 13831, 21751, 23487, 23070, 23141, 23137, 23132, 23127, 23124, 23119, 23114, 23108, 23103, 23098, 23092, 23087, 23081, 23075, 23070, 23064, 23059, 23054, 23047, 23042, 23036, 23030, 23024, 23018, 23012, 23005, 23000, 22995, 22988, 22982, 22976, 22970, 22963, 22958, 22952, 22945, 22939, 22934, 22928, 22921, 22915, 22909, 22903, 22896, 22891, 22885, 22878, 22873, 22867, 22861, 22854, 22848, 22842, 22836, 22829, 22823, 22817, 22976, 22082, 28103, 32709, 31843, 31996, 31989, 31982, 31974, 31967, 31959, 31952, 31945, 31937, 31930, 31921, 31913, 31905, 31897, 31889, 31881, 31873, 31865, 31857, 31848, 31809, 31942, 31439, 23287, 22333, 22966, 21174, 13078, 14079, 7883, 4124, 121, -5325, -11700, -14878, -14204, -14339, -22346, -23857, -23492, -23559, -23613, -23316, -24494, -32586, -32827, -32739, -32758, -32754, -32749, -32743, -32738, -32732, -32726, -32719, -32713, -32706, -32700, -32693, -32686, -32678, -32671, -32663, -32544, -33161, -25888, -22887, -23524, -23401, -23394, -23386, -23379, -23373, -23366, -23359, -23352, -23344, -23338, -23332, -23324, -23317, -23312, -23305, -23298, -23292, -23285, -23279, -23272, -23266, -23259, -23253, -23247, -23241, -23234, -23228, -23221, -23215, -23209, -23203, -23196, -23190, -23184, -23178, -23172, -23165, -23159, -23152, -23146, -23140, -23133, -23127, -23122, -23116, -23109, -23102, -23096, -23090, -23084, -23077, -23071, -23065, -23060, -23053, -23047, -23041, -23035, -22865, -23738, -17587, -13105, -13946, -13784, -13777, -13773, -13768, -13762, -13756, -13752, -13747, -13742, -13738, -13734, -13731, -13727, -13722, -13717, -13713, -13710, -13674, -13812, -13313, -5165, -4291, -4516, -4468, -4465, -4462};