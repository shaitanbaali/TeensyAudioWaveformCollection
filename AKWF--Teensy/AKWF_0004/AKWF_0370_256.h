/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0370 256 samples */
 
const int16_t AKWF_0370_256_DATA [256] = 
{7425, 18658, 26116, 30093, 31592, 31405, 29922, 27387, 24138, 20618, 17217, 14093, 11195, 8326, 5217, 1786, -1945, -6336, -11053, -15531, -19336, -22127, -23757, -24184, -23418, -21468, -18388, -14348, -9669, -4767, -252, 3835, 7635, 10768, 13141, 14746, 15611, 15767, 15243, 14077, 12283, 9907, 7051, 3838, 565, -2696, -6084, -9252, -11952, -14040, -15404, -15993, -15793, -14814, -13093, -10695, -7754, -4441, -1055, 2247, 5665, 8922, 11782, 14119, 15846, 16922, 17331, 17067, 16146, 14589, 12441, 9793, 6768, 3539, 414, -2599, -5620, -8356, -10654, -12416, -13571, -14109, -14029, -13351, -12117, -10390, -8267, -5860, -3318, -852, 1441, 3680, 5697, 7349, 8549, 9249, 9429, 9087, 8253, 6976, 5335, 3430, 1398, -578, -2602, -4596, -6379, -7855, -8941, -9574, -9734, -9404, -8602, -7351, -5718, -3782, -1652, 509, 2949, 5754, 8576, 11091, 13031, 14209, 14539, 14024, 12738, 10808, 8407, 5757, 3066, 570, -1671, -3813, -5725, -7339, -8641, -9618, -10248, -10523, -10424, -9940, -9067, -7826, -6272, -4465, -2522, -615, 1185, 2941, 4499, 5753, 6621, 7070, 7093, 6709, 5951, 4880, 3576, 2119, 627, -820, -2299, -3713, -4962, -5979, -6708, -7108, -7161, -6858, -6212, -5245, -4007, -2571, -1022, 518, 2122, 3742, 5246, 6555, 7609, 8350, 8753, 8803, 8505, 7872, 6936, 5746, 4360, 2846, 1295, -174, -1617, -3020, -4280, -5334, -6132, -6644, -6856, -6769, -6400, -5771, -4926, -3911, -2791, -1634, -513, 512, 1483, 2344, 3036, 3515, 3768, 3780, 3558, 3126, 2505, 1745, 890, 21, -861, -1756, -2593, -3320, -3887, -4267, -4434, -4375, -4097, -3604, -2924, -2094, -1156, -183, 804, 1845, 2857, 3784, 4589, 5226, 5662, 5881, 5877, 5635, 5225, 4336, 193, -8335, -18665, -26938, -31490, -32767, -31276, -26314, -17014, -4474};