/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0398 256 samples */
 
const int16_t AKWF_0398_256_DATA [256] = 
{868, 2400, 3900, 5401, 6894, 8378, 9850, 11300, 12730, 14137, 15510, 16854, 18162, 19426, 20649, 21827, 22951, 24026, 25046, 26005, 26908, 27749, 28526, 29239, 29889, 30470, 30987, 31437, 31821, 32138, 32390, 32577, 32701, 32761, 32760, 32698, 32578, 32400, 32166, 31880, 31541, 31151, 30715, 30231, 29702, 29131, 28518, 27866, 27178, 26451, 25691, 24901, 24079, 23231, 22360, 21466, 20556, 19633, 18697, 17756, 16815, 15872, 14936, 14009, 13092, 12194, 11313, 10453, 9620, 8812, 8033, 7287, 6573, 5892, 5249, 4641, 4070, 3539, 3043, 2586, 2168, 1785, 1441, 1134, 862, 625, 422, 251, 113, 7, -71, -120, -142, -139, -112, -59, 14, 107, 222, 354, 505, 671, 855, 1051, 1261, 1484, 1714, 1938, 2138, 2307, 2441, 2536, 2589, 2600, 2570, 2502, 2395, 2253, 2080, 1877, 1650, 1403, 1137, 860, 572, 279, -16, -310, -601, -884, -1158, -1420, -1668, -1900, -2116, -2312, -2491, -2650, -2787, -2906, -3004, -3082, -3141, -3182, -3205, -3212, -3203, -3180, -3143, -3097, -3039, -2973, -2901, -2823, -2741, -2659, -2574, -2491, -2412, -2336, -2265, -2203, -2152, -2110, -2084, -2072, -2081, -2110, -2164, -2245, -2354, -2494, -2670, -2879, -3126, -3412, -3737, -4102, -4507, -4950, -5434, -5955, -6513, -7109, -7738, -8399, -9091, -9811, -10555, -11325, -12113, -12920, -13743, -14575, -15418, -16268, -17120, -17973, -18825, -19668, -20507, -21335, -22147, -22944, -23723, -24481, -25215, -25925, -26603, -27253, -27870, -28449, -28993, -29495, -29954, -30369, -30736, -31053, -31317, -31527, -31680, -31774, -31808, -31778, -31682, -31521, -31292, -30993, -30625, -30186, -29676, -29097, -28448, -27730, -26949, -26102, -25195, -24234, -23216, -22149, -21039, -19882, -18686, -17454, -16186, -14886, -13557, -12198, -10815, -9411, -7981, -6536, -5075, -3599, -2117, -593};