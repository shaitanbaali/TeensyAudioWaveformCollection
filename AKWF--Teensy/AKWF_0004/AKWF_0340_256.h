/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0340 256 samples */
 
const int16_t AKWF_0340_256_DATA [256] = 
{976, 3618, 6066, 8292, 10262, 12000, 13536, 14879, 16075, 17164, 18199, 19244, 20341, 21508, 22744, 24014, 25295, 26510, 27526, 28256, 28669, 28783, 28645, 28291, 27788, 27208, 26621, 26100, 25699, 25437, 25309, 25280, 25340, 25466, 25583, 25598, 25483, 25256, 24940, 24549, 24115, 23676, 23286, 22994, 22841, 22846, 22996, 23220, 23381, 23302, 22884, 22102, 20945, 19431, 17605, 15507, 13229, 10864, 8500, 6237, 4146, 2254, 572, -927, -2260, -3437, -4541, -5667, -6842, -8056, -9289, -10531, -11756, -12930, -14002, -14930, -15673, -16219, -16582, -16804, -16906, -16982, -17167, -17550, -18171, -19015, -20037, -21210, -22466, -23739, -24960, -26060, -26987, -27727, -28284, -28696, -28977, -29149, -29291, -29498, -29797, -30173, -30604, -31078, -31565, -32028, -32412, -32674, -32769, -32683, -32431, -32050, -31560, -30962, -30189, -29129, -27727, -26007, -24031, -21875, -19601, -17244, -14806, -12293, -9699, -7031, -4330, -1644, 1014, 3606, 6062, 8292, 10262, 12000, 13536, 14879, 16075, 17164, 18199, 19244, 20341, 21508, 22744, 24014, 25295, 26510, 27526, 28256, 28669, 28783, 28645, 28291, 27788, 27208, 26621, 26100, 25699, 25437, 25309, 25281, 25339, 25466, 25583, 25598, 25483, 25256, 24940, 24549, 24115, 23676, 23286, 22994, 22841, 22846, 22996, 23220, 23381, 23302, 22884, 22102, 20945, 19431, 17605, 15507, 13229, 10864, 8500, 6237, 4146, 2254, 572, -927, -2260, -3437, -4541, -5667, -6842, -8056, -9289, -10531, -11756, -12930, -14002, -14930, -15673, -16219, -16582, -16804, -16906, -16982, -17167, -17550, -18171, -19015, -20037, -21210, -22466, -23739, -24960, -26060, -26987, -27727, -28284, -28696, -28977, -29149, -29291, -29498, -29797, -30173, -30604, -31078, -31565, -32028, -32412, -32674, -32769, -32683, -32431, -32051, -31560, -30962, -30189, -29129, -27727, -26007, -24031, -21875, -19601, -17244, -14806, -12293, -9699, -7035, -4341, -1608};