/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0391 256 samples */
 
const int16_t AKWF_0391_256_DATA [256] = 
{551, 2524, 4218, 5792, 7275, 8670, 9975, 11188, 12317, 13363, 14327, 15216, 16032, 16779, 17467, 18099, 18676, 19210, 19700, 20151, 20568, 20953, 21309, 21641, 21950, 22238, 22507, 22760, 22998, 23222, 23434, 23636, 23826, 24006, 24181, 24345, 24505, 24656, 24803, 24944, 25080, 25213, 25340, 25465, 25585, 25702, 25817, 25928, 26036, 26144, 26247, 26349, 26449, 26546, 26644, 26738, 26830, 26922, 27012, 27101, 27187, 27244, 27469, 27033, 20890, 20456, 20679, 20731, 20808, 20885, 20961, 21036, 21108, 21178, 21247, 21315, 21381, 21444, 21505, 21564, 21621, 21675, 21727, 21775, 21821, 21863, 21901, 21936, 21966, 21992, 22012, 22027, 22034, 22037, 22033, 22019, 21997, 21965, 21925, 21870, 21803, 21723, 21625, 21511, 21378, 21223, 21045, 20840, 20603, 20337, 20033, 19690, 19303, 18867, 18379, 17834, 17226, 16550, 15806, 14984, 14086, 13111, 12055, 10923, 9717, 8402, 7253, 5171, -4561, -6666, -7840, -9181, -10417, -11582, -12671, -13679, -14612, -15465, -16241, -16946, -17583, -18154, -18666, -19124, -19531, -19893, -20213, -20494, -20743, -20962, -21150, -21314, -21457, -21579, -21683, -21772, -21843, -21904, -21949, -21985, -22011, -22029, -22036, -22036, -22031, -22020, -22001, -21978, -21950, -21917, -21880, -21840, -21795, -21748, -21698, -21644, -21589, -21531, -21470, -21409, -21343, -21277, -21208, -21138, -21067, -20993, -20918, -20841, -20765, -20714, -20491, -20927, -27068, -27504, -27280, -27224, -27138, -27050, -26961, -26870, -26777, -26685, -26588, -26491, -26392, -26290, -26188, -26083, -25975, -25865, -25752, -25636, -25517, -25394, -25268, -25138, -25002, -24864, -24719, -24571, -24414, -24252, -24082, -23904, -23719, -23522, -23315, -23095, -22864, -22617, -22355, -22076, -21775, -21454, -21109, -20736, -20333, -19898, -19424, -18909, -18352, -17744, -17080, -16360, -15573, -14716, -13785, -12774, -11681, -10504, -9238, -7882, -6438, -4901, -3276, -1402};