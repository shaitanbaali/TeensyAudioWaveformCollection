/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0384 256 samples */
 
const int16_t AKWF_0384_256_DATA [256] = 
{601, 2489, 4334, 6175, 7996, 9793, 11562, 13288, 14972, 16609, 18185, 19702, 21155, 22534, 23839, 25065, 26207, 27265, 28235, 29111, 29899, 30592, 31188, 31690, 32096, 32406, 32621, 32741, 32766, 32697, 32533, 32279, 31932, 31500, 30980, 30376, 29692, 28930, 28092, 27186, 26213, 25176, 24085, 22938, 21743, 20508, 19230, 17917, 16582, 15217, 13833, 12437, 11027, 9612, 8200, 6785, 5378, 3985, 2601, 1235, -109, -1436, -2735, -4011, -5264, -6482, -7673, -8835, -9962, -11058, -12120, -13146, -14140, -15100, -16022, -16911, -17764, -18580, -19362, -20106, -20809, -21475, -22103, -22686, -23230, -23730, -24185, -24594, -24957, -25269, -25533, -25745, -25907, -26018, -26076, -26081, -26034, -25935, -25783, -25577, -25319, -25007, -24642, -24224, -23752, -23226, -22649, -22018, -21334, -20602, -19817, -18982, -18101, -17172, -16197, -15181, -14122, -13022, -11889, -10715, -9512, -8281, -7020, -5738, -4437, -3118, -1788, -451, 890, 2232, 3572, 4906, 6226, 7532, 8821, 10083, 11321, 12530, 13701, 14839, 15937, 16988, 17998, 18960, 19870, 20732, 21540, 22292, 22991, 23634, 24217, 24744, 25213, 25622, 25974, 26265, 26497, 26670, 26781, 26831, 26820, 26749, 26616, 26424, 26173, 25863, 25494, 25071, 24591, 24058, 23475, 22842, 22159, 21434, 20663, 19850, 18999, 18110, 17184, 16229, 15240, 14223, 13180, 12111, 11021, 9912, 8782, 7636, 6475, 5298, 4109, 2908, 1695, 475, -749, -1986, -3224, -4469, -5716, -6960, -8207, -9452, -10689, -11922, -13148, -14358, -15558, -16741, -17902, -19043, -20157, -21237, -22287, -23298, -24264, -25187, -26059, -26874, -27634, -28331, -28960, -29524, -30016, -30434, -30777, -31040, -31223, -31324, -31340, -31270, -31113, -30868, -30533, -30109, -29594, -28989, -28293, -27510, -26638, -25678, -24638, -23511, -22307, -21027, -19672, -18248, -16762, -15208, -13601, -11944, -10237, -8490, -6712, -4905, -3081, -1202};