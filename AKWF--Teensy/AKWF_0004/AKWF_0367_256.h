/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0367 256 samples */
 
const int16_t AKWF_0367_256_DATA [256] = 
{517, 1818, 2686, 3343, 3899, 4415, 4940, 5505, 6149, 6905, 7808, 8914, 10277, 11972, 14008, 16305, 18739, 21198, 23546, 25677, 27547, 29115, 30374, 31340, 32030, 32471, 32684, 32693, 32531, 32228, 31819, 31323, 30755, 30132, 29465, 28763, 28035, 27285, 26524, 25754, 24978, 24201, 23431, 22662, 21904, 21158, 20420, 19700, 18997, 18309, 17640, 16992, 16363, 15754, 15171, 14606, 14064, 13547, 13051, 12579, 12131, 11703, 11298, 10916, 10556, 10219, 9903, 9606, 9329, 9072, 8832, 8607, 8399, 8203, 8022, 7856, 7701, 7557, 7422, 7297, 7184, 7078, 6980, 6890, 6806, 6730, 6658, 6593, 6533, 6477, 6426, 6380, 6338, 6299, 6263, 6230, 6201, 6172, 6147, 6125, 6103, 6085, 6068, 6053, 6038, 6027, 6014, 6004, 5995, 5987, 5979, 5973, 5967, 5962, 5957, 5954, 5951, 5949, 5947, 5945, 5944, 5941, 5941, 5941, 5941, 5892, 6130, 5254, -5259, -6131, -5893, -5942, -5942, -5944, -5943, -5945, -5945, -5947, -5948, -5951, -5955, -5959, -5963, -5966, -5972, -5979, -5984, -5993, -6002, -6012, -6023, -6035, -6048, -6062, -6080, -6097, -6117, -6140, -6164, -6190, -6218, -6250, -6285, -6322, -6364, -6409, -6457, -6511, -6568, -6632, -6701, -6774, -6855, -6941, -7037, -7138, -7249, -7370, -7498, -7638, -7789, -7952, -8127, -8314, -8518, -8734, -8969, -9219, -9487, -9776, -10082, -10411, -10762, -11134, -11526, -11945, -12385, -12848, -13334, -13842, -14373, -14927, -15503, -16101, -16723, -17362, -18022, -18702, -19397, -20110, -20841, -21583, -22337, -23100, -23870, -24647, -25423, -26195, -26962, -27717, -28453, -29168, -29851, -30494, -31087, -31616, -32065, -32417, -32642, -32710, -32588, -32247, -31665, -30821, -29690, -28254, -26511, -24488, -22221, -19796, -17340, -14965, -12806, -10961, -9461, -8255, -7272, -6459, -5770, -5177, -4638, -4123, -3591, -2986, -2227, -1157};