/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0317 256 samples */
 
const int16_t AKWF_0317_256_DATA [256] = 
{909, -8620, -19565, -8870, 5633, 29116, 32057, 19183, 183, -14476, -21154, -20690, -15301, -7297, 1058, 7562, 10666, 10092, 6847, 2687, -756, -2564, -2708, -1784, -573, 317, 630, 422, -57, -530, -804, -816, -612, -307, -16, 179, 252, 222, 135, 40, -29, -60, -58, -38, -19, -9, -11, -23, -38, -48, -51, -47, -38, -26, -16, -8, -4, -3, -3, -2, -1, 0, 1, 3, 5, -176, 912, -5274, -16079, -1823, 14206, 22190, 16066, 2129, -10939, -17277, -15652, -8559, -27, 6438, 9057, 7971, 4601, 774, -2074, -3271, -2932, -1675, -243, 793, 1191, 1008, 495, -58, -436, -558, -456, -236, -12, 135, 179, 135, 49, -35, -88, -100, -78, -41, -7, 13, 17, 10, -3, -13, -19, -19, -13, -5, 1, 6, 8, -9, -111, 538, -8463, -21604, -9573, 7151, 13089, 4597, -4856, 3468, 11312, 28027, 26529, 11418, -7939, -21256, -25611, -22723, -15312, -5853, 3346, 10121, 13072, 12101, 8364, 3716, -141, -2257, -2605, -1798, -644, 228, 537, 331, -150, -632, -921, -950, -764, -474, -195, -7, 63, 35, -47, -136, -200, -224, -215, -188, -161, -144, -140, -146, -154, -158, -154, -143, -129, -111, -94, -82, -73, -67, -62, -57, -52, -48, -42, -36, -32, -210, 880, -5305, -16108, -1849, 14182, 22169, 16046, 2110, -10957, -17293, -15667, -8573, -39, 6426, 9046, 7960, 4591, 764, -2082, -3279, -2940, -1683, -250, 787, 1184, 1002, 489, -63, -442, -563, -462, -242, -19, 129, 173, 130, 43, -41, -94, -106, -84, -48, -14, 7, 11, 4, -8, -19, -25, -25, -20, -12, -5, -1, 1, 1, 0, 0, 1, 2, 5, 10};