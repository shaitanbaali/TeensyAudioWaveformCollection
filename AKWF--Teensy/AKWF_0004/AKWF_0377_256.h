/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0377 256 samples */
 
const int16_t AKWF_0377_256_DATA [256] = 
{4837, 4838, 4839, 4841, 4841, 4842, 4843, 4843, 4843, 4843, 4843, 4843, 4898, 4597, 5791, 13985, 14229, 14143, 14164, 14162, 14132, 14254, 13838, 5605, 4620, 4878, 4856, 4608, 12524, 14562, 13908, 14675, 22923, 23607, 23417, 23497, 23261, 24035, 32867, 25927, 22881, 23538, 23419, 23414, 23410, 23403, 23398, 23393, 23387, 23382, 23376, 23370, 23364, 23358, 23353, 23346, 23341, 23334, 23328, 23323, 23316, 23310, 23304, 23298, 23292, 23286, 23280, 23273, 23267, 23261, 23255, 23250, 23244, 23237, 23231, 23225, 23219, 23113, 23667, 21156, 13484, 13939, 13858, 13850, 13844, 13839, 13834, 13830, 13825, 13820, 13657, 14509, 9975, 3751, 4637, 4468, 4464, 4461, 4458, 4455, 4453, 4450, 4447, 4445, 4443, 4441, 4439, 4437, 4379, 4676, 3480, -4713, -4960, -4876, -4899, -4900, -4902, -4901, -4901, -4901, -4901, -4901, -4902, -4901, -4899, -4900, -4900, -4898, -4898, -4897, -4895, -4896, -4894, -4894, -4892, -4891, -4890, -4890, -4888, -4887, -4886, -4885, -4884, -4722, -5580, -495, 5108, 4298, 4447, 4449, 4449, 4449, 4451, 4449, 4449, 4280, 5186, -792, -5762, -3982, -10246, -14913, -14043, -14203, -14365, -13485, -19819, -24210, -23365, -23518, -23515, -23512, -23508, -23504, -23501, -23496, -23491, -23486, -23482, -23477, -23471, -23466, -23461, -23456, -23450, -23445, -23438, -23434, -23427, -23422, -23416, -23410, -23404, -23398, -23393, -23386, -23380, -23240, -23972, -20397, -13407, -14162, -14018, -14012, -14007, -14003, -13999, -13994, -13989, -13984, -13980, -13975, -13970, -13966, -13961, -13956, -13953, -13949, -13944, -13940, -13937, -13932, -13927, -13925, -13920, -13916, -13913, -13908, -13905, -13901, -13896, -13893, -13889, -13886, -13881, -13878, -13874, -13870, -13867, -13862, -13755, -14335, -11698, -4100, -4605, -4516, -4511, -4508, -4505, -4503, -4500, -4498, -4496, -4493, -4492, -4491};