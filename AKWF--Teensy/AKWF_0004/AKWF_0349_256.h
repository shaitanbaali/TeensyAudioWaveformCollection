/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0349 256 samples */
 
const int16_t AKWF_0349_256_DATA [256] = 
{721, 2910, 4890, 6731, 8466, 10222, 12110, 14277, 16707, 19171, 21427, 23254, 24472, 24918, 24525, 23291, 21206, 18264, 14556, 10146, 5059, -513, -6169, -11369, -15618, -18677, -20532, -21251, -20931, -19735, -17843, -15449, -12809, -10182, -7721, -5537, -3732, -2365, -1317, -383, 553, 1427, 2105, 2464, 2419, 1955, 1150, 116, -1085, -2428, -3852, -5297, -6717, -8010, -8973, -9335, -8919, -7685, -5698, -3125, -178, 2930, 6005, 8900, 11452, 13528, 15121, 16250, 16937, 17227, 17277, 17282, 17319, 17300, 17094, 16542, 15524, 13994, 11951, 9431, 6433, 2929, -1053, -5474, -10288, -15330, -20297, -24798, -28446, -31012, -32438, -32772, -32127, -30687, -28645, -26182, -23512, -20850, -18304, -15938, -13816, -11977, -10371, -8926, -7607, -6457, -5564, -5031, -4923, -5228, -5881, -6803, -7916, -9146, -10412, -11659, -12854, -13918, -14679, -14931, -14458, -13149, -11094, -8501, -5629, -2691, 138, 2720, 4975, 6895, 8511, 9847, 10946, 11874, 12756, 13759, 14962, 16268, 17495, 18499, 19149, 19344, 19040, 18208, 16759, 14657, 11969, 8776, 5119, 1129, -2870, -6450, -9226, -11016, -11822, -11781, -11155, -10171, -8934, -7542, -6140, -4860, -3768, -2904, -2288, -1889, -1610, -1326, -964, -542, -141, 153, 285, 246, 86, -133, -395, -704, -1074, -1548, -2167, -2896, -3587, -3994, -3904, -3236, -2039, -456, 1327, 3131, 4823, 6310, 7507, 8382, 8975, 9325, 9463, 9438, 9349, 9331, 9437, 9606, 9699, 9563, 9108, 8301, 7147, 5677, 3899, 1797, -589, -3199, -6006, -8930, -11797, -14369, -16424, -17846, -18621, -18801, -18486, -17779, -16774, -15556, -14239, -12951, -11771, -10761, -9976, -9434, -9088, -8823, -8578, -8363, -8234, -8282, -8558, -9042, -9672, -10387, -11186, -12074, -13040, -14076, -15138, -16131, -16901, -17224, -16913, -15902, -14231, -12043, -9557, -6945, -4257, -1597};