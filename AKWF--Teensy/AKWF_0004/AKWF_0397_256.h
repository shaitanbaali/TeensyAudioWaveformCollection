/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0397 256 samples */
 
const int16_t AKWF_0397_256_DATA [256] = 
{419, 1370, 2477, 3763, 5172, 6665, 8222, 9817, 11435, 13060, 14669, 16253, 17799, 19293, 20732, 22106, 23404, 24631, 25775, 26834, 27810, 28697, 29493, 30203, 30821, 31347, 31786, 32136, 32402, 32591, 32710, 32763, 32757, 32696, 32582, 32418, 32208, 31955, 31659, 31325, 30953, 30544, 30103, 29627, 29120, 28583, 28015, 27418, 26797, 26146, 25468, 24766, 24038, 23284, 22506, 21703, 20878, 20028, 19151, 18250, 17326, 16372, 15392, 14384, 13341, 12270, 11171, 10056, 8948, 7875, 6869, 5970, 5192, 4537, 3995, 3543, 3165, 2846, 2573, 2339, 2135, 1956, 1798, 1658, 1532, 1419, 1320, 1236, 1165, 1108, 1064, 1036, 1020, 1018, 1029, 1053, 1091, 1143, 1206, 1282, 1370, 1471, 1584, 1709, 1846, 1994, 2154, 2327, 2510, 2705, 2910, 3127, 3354, 3593, 3842, 4102, 4372, 4653, 4943, 5246, 5557, 5878, 6210, 6550, 6882, 7202, 7551, 1285, -11701, -15048, -10631, -7058, -6214, -6328, -6171, -5726, -5290, -4958, -4679, -4404, -4129, -3863, -3612, -3373, -3145, -2927, -2721, -2526, -2342, -2169, -2008, -1858, -1720, -1594, -1480, -1378, -1289, -1212, -1149, -1097, -1058, -1032, -1020, -1021, -1035, -1064, -1106, -1161, -1230, -1315, -1412, -1524, -1649, -1789, -1947, -2124, -2325, -2559, -2830, -3145, -3520, -3968, -4503, -5147, -5909, -6793, -7786, -8855, -9964, -11084, -12185, -13261, -14306, -15317, -16299, -17254, -18181, -19083, -19962, -20813, -21641, -22446, -23225, -23980, -24712, -25415, -26094, -26748, -27372, -27970, -28540, -29080, -29589, -30067, -30511, -30922, -31297, -31634, -31933, -32189, -32402, -32570, -32687, -32753, -32763, -32714, -32600, -32416, -32157, -31814, -31384, -30864, -30252, -29550, -28760, -27880, -26911, -25860, -24721, -23501, -22208, -20841, -19408, -17918, -16375, -14794, -13189, -11565, -9945, -8349, -6787, -5291, -3884, -2589, -1438, -436};