/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0343 256 samples */
 
const int16_t AKWF_0343_256_DATA [256] = 
{32748, 32755, 32759, 32764, 32766, 32767, 32768, 32767, 32767, 32765, 32762, 32759, 32756, 32752, 32747, 32743, 32737, 32731, 32726, 32720, 32713, 32706, 32701, 32694, 32686, 32679, 32671, 32664, 32657, 32649, 32641, 32634, 32626, 32617, 32609, 32601, 32592, 32585, 32576, 32568, 32560, 32551, 32543, 32534, 32526, 32517, 32508, 32501, 32492, 32483, 32475, 32466, 32457, 32449, 32440, 32431, 32423, 32415, 32405, 32396, 32388, 32379, 32371, 32363, 32354, 32344, 32337, 32328, 32318, 32311, 32303, 32293, 32284, 32276, 32267, 32257, 32250, 32242, 32232, 32224, 32216, 32206, 32197, 32190, 32181, 32172, 32164, 32155, 32146, 32137, 32129, 32120, 32112, 32104, 32094, 32085, 32078, 32068, 32059, 32053, 32043, 32034, 32026, 32017, 32008, 32000, 31991, 31983, 31975, 31966, 31956, 31948, 31940, 31930, 31923, 31915, 31905, 31898, 31888, 31879, 31872, 31863, 31854, 31847, 31837, 31828, 30662, 36875, -5341, -37644, -31628, -32752, -32754, -32756, -32757, -32756, -32757, -32755, -32753, -32750, -32747, -32742, -32739, -32734, -32728, -32724, -32717, -32712, -32705, -32700, -32693, -32686, -32679, -32671, -32664, -32657, -32649, -32642, -32634, -32626, -32618, -32610, -32602, -32594, -32586, -32577, -32570, -32561, -32553, -32545, -32535, -32527, -32518, -32510, -32503, -32493, -32485, -32477, -32467, -32459, -32450, -32441, -32433, -32425, -32416, -32407, -32399, -32390, -32381, -32374, -32365, -32355, -32347, -32339, -32329, -32320, -32313, -32304, -32295, -32287, -32278, -32268, -32261, -32252, -32243, -32235, -32227, -32217, -32208, -32200, -32191, -32182, -32174, -32166, -32156, -32148, -32140, -32130, -32122, -32115, -32105, -32096, -32089, -32079, -32070, -32062, -32054, -32045, -32037, -32028, -32018, -32011, -32002, -31993, -31986, -31977, -31967, -31959, -31951, -31941, -31933, -31925, -31916, -31908, -31899, -31890, -31882, -31873, -31864, -31857, -31848, -31839, -31831, -30703, -36716, -4412};