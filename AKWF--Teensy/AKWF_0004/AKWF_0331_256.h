/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0331 256 samples */
 
const int16_t AKWF_0331_256_DATA [256] = 
{352, 671, 566, 371, 420, 879, 1663, 2491, 3055, 3195, 2985, 2674, 2534, 2707, 3126, 3560, 3756, 3586, 3116, 2564, 2174, 2084, 2251, 2496, 2610, 2479, 2143, 1773, 1565, 1634, 1947, 2357, 2690, 2843, 2844, 2825, 2939, 3273, 3797, 4380, 4867, 5166, 5289, 5341, 5453, 5698, 6059, 6435, 6701, 6780, 6685, 6504, 6346, 6286, 6317, 6364, 6332, 6166, 5879, 5550, 5277, 5123, 5090, 5116, 5125, 5064, 4941, 4817, 4767, 4841, 5039, 5305, 5567, 5778, 5931, 6070, 6249, 6506, 6833, 7184, 7495, 7723, 7862, 7945, 8019, 8119, 8242, 8357, 8416, 8386, 8267, 8092, 7909, 7750, 7625, 7513, 7379, 7203, 6986, 6760, 6563, 6427, 6357, 6337, 6336, 6333, 6326, 6332, 6380, 6489, 6660, 6873, 7096, 7304, 7490, 7662, 7838, 8033, 8243, 8450, 8629, 8759, 8834, 8863, 8864, 8853, 8833, 8796, 8724, 8607, 8447, 8255, 8054, 7861, 7684, 7522, 7363, 7201, 7038, 6885, 6759, 6674, 6635, 6635, 6665, 6711, 6772, 6849, 6953, 7088, 7251, 7434, 7623, 7802, 7966, 8114, 8249, 8375, 8465, 8493, 8995, -2133, -20364, -29924, -32759, -29420, -22013, -14602, -10685, -11549, -15901, -20890, -23833, -23661, -21301, -18848, -18148, -19632, -22089, -23476, -22217, -18236, -13078, -9057, -7999, -10203, -14296, -17983, -19301, -17619, -13886, -10010, -7763, -7866, -9693, -11774, -12713, -11994, -10210, -8629, -8376, -9746, -12020, -13902, -14278, -12867, -10372, -8084, -7148, -7940, -9890, -11827, -12654, -11920, -10029, -7944, -6621, -6468, -7168, -7917, -7933, -6915, -5211, -3581, -2745, -2964, -3897, -4809, -5009, -4234, -2793, -1376, -652, -908, -1905, -3044, -3705, -3600, -2901, -2110, -1748, -2051, -2848, -3677, -4066, -3803, -3048, -2223, -1762, -1856, -2353, -2856, -2951, -2451, -1482, -407};