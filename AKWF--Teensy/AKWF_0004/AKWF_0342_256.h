/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0342 256 samples */
 
const int16_t AKWF_0342_256_DATA [256] = 
{5578, 14910, 22911, 28817, 32107, 32682, 30758, 26845, 21579, 15676, 9779, 4373, -162, -3576, -5796, -6850, -6915, -6454, -5636, -3974, -1464, 1000, 2742, 3779, 4355, 4612, 4498, 4019, 3303, 2494, 1687, 942, 243, -301, -561, -662, -623, -452, -206, 71, 331, 568, 744, 842, 855, 797, 687, 534, 298, -243, -1444, -3362, -5345, -6775, -6977, -5488, -2597, 747, 3421, 4756, 4754, 3849, 2609, 1513, 773, 499, 667, 944, 1148, 1202, 1089, 863, 598, 387, 253, 187, 154, 132, 99, 35, -110, -590, -1318, -1535, -991, -357, -144, -236, -336, -315, -273, -287, -329, -357, -374, -401, -510, -633, -649, -678, -716, -733, -747, -762, -784, -795, -806, -822, -849, -875, -893, -908, -977, -1339, -2370, -4115, -6152, -9358, -14200, -19191, -23108, -25737, -26994, -26563, -24069, -19275, -12313, -3687, 5710, 14872, 22894, 28817, 32107, 32682, 30758, 26845, 21579, 15676, 9779, 4373, -162, -3576, -5796, -6850, -6915, -6454, -5636, -3974, -1464, 1000, 2742, 3779, 4355, 4612, 4498, 4019, 3303, 2494, 1687, 942, 243, -301, -561, -662, -623, -452, -206, 71, 331, 568, 744, 842, 855, 797, 687, 534, 298, -243, -1444, -3362, -5345, -6775, -6977, -5488, -2596, 747, 3421, 4756, 4754, 3849, 2609, 1513, 773, 499, 667, 944, 1148, 1202, 1089, 863, 598, 387, 253, 187, 154, 132, 99, 35, -110, -590, -1318, -1535, -991, -357, -144, -236, -336, -315, -273, -287, -329, -357, -374, -401, -510, -633, -649, -678, -716, -733, -747, -762, -784, -795, -806, -822, -849, -875, -893, -908, -977, -1339, -2370, -4115, -6152, -9358, -14200, -19191, -23108, -25737, -26994, -26563, -24069, -19292, -12355, -3552};