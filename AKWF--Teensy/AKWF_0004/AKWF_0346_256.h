/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0346 256 samples */
 
const int16_t AKWF_0346_256_DATA [256] = 
{-23478, -34419, -32384, -32765, -32767, -32650, -33282, -28172, -19795, -19722, -19776, -19742, -19739, -19736, -19733, -19730, -19726, -19723, -19719, -19715, -19711, -19707, -19702, -19698, -19694, -19689, -19685, -19680, -19675, -19671, -19666, -19661, -19656, -19651, -19646, -19641, -19636, -19631, -19626, -19621, -19616, -19611, -19606, -19601, -19595, -19590, -19585, -19579, -19575, -19570, -19564, -19559, -19554, -19548, -19544, -19538, -19533, -19528, -19523, -19517, -19513, -19507, -19501, -19497, -19492, -19371, -19941, -16422, -7201, -6288, -6503, -6441, -6437, -6433, -6429, -6426, -6423, -6420, -6417, -6414, -6411, -6408, -6406, -6403, -6401, -6398, -6397, -6394, -6392, -6390, -6387, -6386, -6384, -6381, -6380, -6378, -6375, -6374, -6372, -6369, -6368, -6366, -6364, -6362, -6361, -6359, -6357, -6355, -6353, -6351, -6350, -6348, -6347, -6345, -6343, -6341, -6339, -6338, -6336, -6334, -6332, -6331, -6330, -6327, -6265, -6494, -5520, 3731, 7151, 6582, 6698, 6699, 6699, 6699, 6699, 6699, 6698, 6698, 6697, 6697, 6696, 6695, 6694, 6693, 6692, 6691, 6689, 6689, 6688, 6685, 6684, 6683, 6681, 6679, 6678, 6677, 6675, 6673, 6672, 6671, 6669, 6667, 6665, 6664, 6662, 6660, 6659, 6657, 6655, 6653, 6652, 6650, 6648, 6646, 6645, 6643, 6641, 6640, 6637, 6635, 6634, 6633, 6631, 6629, 6627, 6629, 6730, 6140, 12185, 19860, 19595, 19610, 19626, 19624, 19621, 19617, 19614, 19610, 19606, 19602, 19598, 19594, 19590, 19585, 19581, 19576, 19571, 19567, 19562, 19557, 19552, 19548, 19543, 19538, 19533, 19528, 19523, 19518, 19513, 19507, 19503, 19497, 19493, 19487, 19482, 19477, 19472, 19468, 19462, 19456, 19452, 19446, 19441, 19436, 19430, 19426, 19421, 19415, 19410, 19405, 19399, 19394, 19390, 19384, 19379, 19485, 18948, 21950, 31325, 32582, 32294, 32357, 32330, 31917, 34353, 5059};