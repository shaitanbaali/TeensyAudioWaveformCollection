/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0326 256 samples */
 
const int16_t AKWF_0326_256_DATA [256] = 
{3214, 9907, 15807, 20849, 24839, 27689, 29382, 29953, 29492, 28113, 25966, 23196, 19966, 16446, 12769, 9080, 5510, 2143, -926, -3627, -5931, -7802, -9229, -10223, -10797, -10982, -10813, -10334, -9592, -8633, -7512, -6275, -4966, -3635, -2315, -1039, 157, 1255, 2237, 3085, 3794, 4361, 4784, 5066, 5217, 5245, 5160, 4978, 4710, 4372, 3977, 3542, 3076, 2596, 2112, 1633, 1170, 729, 317, -61, -401, -705, -967, -1190, -1373, -1518, -1628, -1705, -1751, -1772, -1771, -1750, -1713, -1663, -1603, -1537, -1467, -1395, -1324, -1254, -1186, -1123, -1065, -1012, -964, -922, -886, -854, -827, -804, -785, -768, -754, -742, -730, -719, -709, -699, -687, -674, -661, -647, -630, -612, -593, -572, -550, -526, -503, -478, -451, -424, -397, -370, -343, -316, -290, -263, -238, -213, -188, -165, -142, -121, -101, -82, -63, -47, -31, -15, -1, 12, 24, 36, 48, 59, 69, 79, 88, 96, 105, 112, 119, 125, 132, 138, 144, 149, 154, 158, 163, 167, 171, 174, 176, 179, 181, 182, 184, 185, 185, 186, 187, 186, 187, 186, 186, 185, 184, 182, 181, 180, 177, 175, 173, 170, 168, 165, 161, 159, 156, 152, 148, 145, 142, 138, 134, 131, 127, 123, 119, 116, 111, 107, 103, 100, 95, 91, 87, 83, 79, 74, 71, 67, 63, 59, 55, 51, 48, 43, 40, 36, 32, 29, 25, 21, 18, 15, 12, 9, 5, 2, 0, -3, -5, -8, -11, -14, -16, -20, -23, -25, -28, -30, -32, -35, -37, -40, -42, -44, -46, -49, -89, -34, -522, -9009, -21717, -27556, -30368, -32528, -32180, -28767, -23499, -17353, -10670, -3548};