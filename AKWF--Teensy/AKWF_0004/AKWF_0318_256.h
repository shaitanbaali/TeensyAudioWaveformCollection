/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0318 256 samples */
 
const int16_t AKWF_0318_256_DATA [256] = 
{449, 1392, 2247, 3029, 3935, 4848, 5770, 6687, 7588, 8478, 9349, 10202, 11032, 11835, 12614, 13368, 14091, 14788, 15461, 16104, 16723, 17317, 17883, 18430, 18951, 19450, 19930, 20388, 20825, 21247, 21649, 22035, 22404, 22757, 23096, 23421, 23729, 24045, 24144, 24117, 24458, 24673, 24795, 24940, 25060, 25183, 25311, 25438, 25567, 25698, 25827, 25958, 26075, 26096, 26238, 26306, 26276, 26327, 26328, 26253, 26193, 26105, 25957, 25793, 25599, 25353, 25020, 24254, 23003, 20432, 16863, 14701, 12927, 10560, 8017, 5494, 3014, 612, -1695, -3871, -5876, -7706, -9368, -10883, -12279, -13561, -14730, -15805, -16785, -17672, -18474, -19195, -19843, -20424, -20945, -21409, -21824, -22192, -22519, -22807, -23058, -23258, -23635, -24089, -24141, -24284, -24486, -24634, -24775, -24887, -24965, -25018, -25044, -25039, -24995, -24937, -24856, -24725, -24584, -24416, -24205, -23975, -23715, -23423, -23102, -22751, -22363, -21938, -21473, -20859, -20236, -19688, -19032, -18350, -17627, -16888, -16139, -15371, -14600, -13767, -12932, -12125, -11308, -10492, -9681, -8870, -8069, -7284, -6513, -5750, -5009, -4284, -3577, -2889, -2215, -1564, -932, -311, 287, 868, 1431, 1980, 2512, 3032, 3519, 4004, 4184, 4147, 4703, 5069, 5281, 5537, 5759, 5974, 6193, 6422, 6652, 6881, 7111, 7342, 7553, 7640, 7882, 8033, 8054, 8181, 8244, 8209, 8200, 8148, 7987, 7813, 7611, 7327, 6977, 6381, 5938, 5570, 4986, 4404, 3820, 3229, 2629, 2031, 1445, 867, 302, -241, -758, -1258, -1729, -2177, -2601, -2991, -3357, -3698, -4008, -4291, -4550, -4782, -4983, -5167, -5320, -5451, -5563, -5646, -5710, -5755, -5781, -5753, -6060, -6528, -6345, -6346, -6461, -6510, -6560, -6574, -6555, -6504, -6415, -6293, -6109, -5916, -5690, -5391, -5078, -4725, -4321, -3878, -3402, -2874, -2305, -1695, -1036, -306};