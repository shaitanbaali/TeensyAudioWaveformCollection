/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0337 256 samples */
 
const int16_t AKWF_0337_256_DATA [256] = 
{631, 1940, 3372, 4923, 6345, 7435, 8193, 8701, 9032, 9264, 9503, 9818, 10164, 10494, 10853, 11304, 11866, 12563, 13435, 14487, 15582, 16595, 17530, 18443, 19355, 20298, 21337, 22497, 23699, 24869, 26016, 27184, 28379, 29597, 30885, 32137, 32775, 32349, 30860, 28509, 25496, 22043, 18397, 14715, 11036, 7392, 3852, 524, -2537, -5316, -7748, -9817, -11674, -13432, -15084, -16590, -17920, -19046, -19916, -20496, -20874, -21132, -21259, -21218, -21010, -20637, -20064, -19321, -18657, -18276, -18180, -18285, -18522, -18815, -19055, -19177, -19228, -19252, -19206, -19030, -18703, -18205, -17492, -16564, -15557, -14596, -13680, -12750, -11788, -10765, -9614, -8311, -6936, -5564, -4187, -2763, -1286, 238, 1856, 3510, 4818, 5476, 5483, 4970, 4066, 2908, 1661, 436, -777, -1992, -3149, -4165, -5003, -5641, -6024, -6144, -6138, -6125, -6099, -6005, -5819, -5512, -5017, -4309, -3468, -2568, -1605, -534, 647, 1935, 3370, 4923, 6345, 7435, 8193, 8701, 9032, 9264, 9503, 9818, 10164, 10494, 10853, 11304, 11866, 12563, 13435, 14487, 15582, 16595, 17530, 18443, 19355, 20298, 21337, 22497, 23699, 24869, 26016, 27184, 28379, 29597, 30885, 32137, 32775, 32349, 30860, 28509, 25496, 22043, 18397, 14715, 11036, 7392, 3852, 524, -2537, -5316, -7748, -9817, -11674, -13432, -15084, -16590, -17920, -19046, -19916, -20496, -20874, -21132, -21259, -21218, -21010, -20637, -20064, -19321, -18657, -18276, -18180, -18285, -18522, -18815, -19055, -19177, -19228, -19252, -19206, -19030, -18703, -18205, -17492, -16564, -15557, -14596, -13680, -12750, -11788, -10765, -9614, -8311, -6936, -5564, -4187, -2763, -1286, 238, 1856, 3510, 4818, 5476, 5483, 4970, 4066, 2908, 1661, 436, -777, -1992, -3149, -4165, -5003, -5641, -6024, -6144, -6138, -6125, -6099, -6005, -5819, -5512, -5017, -4309, -3468, -2570, -1611, -517};