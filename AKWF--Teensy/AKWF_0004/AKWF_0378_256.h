/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0378 256 samples */
 
const int16_t AKWF_0378_256_DATA [256] = 
{3524, 3526, 3529, 3744, 2606, 8919, 16401, 15236, 15454, 15454, 15454, 15453, 15452, 15450, 15449, 15447, 15445, 15441, 15440, 15436, 15434, 15431, 15436, 15485, 15094, 25136, 27847, 27218, 27325, 27320, 27315, 27311, 27305, 27299, 27293, 27287, 27281, 27104, 28041, 23474, 14544, 15510, 15326, 15320, 15316, 15312, 15305, 15300, 15296, 15290, 15286, 15281, 15276, 15271, 15266, 15302, 15114, 15749, 26278, 27399, 27100, 27152, 27146, 27140, 27134, 27128, 27122, 27116, 27111, 27104, 27098, 27092, 27084, 27078, 27072, 27040, 27118, 26899, 16456, 14783, 15189, 15106, 15101, 15095, 15090, 15085, 15079, 15074, 15070, 15064, 15060, 15054, 15049, 15045, 15040, 15036, 15032, 15026, 15022, 15017, 15014, 14838, 15777, 11212, 2283, 3252, 3072, 3068, 3064, 3062, 3060, 3056, 3054, 3052, 3050, 3048, 3046, 3045, 3043, 3041, 3040, 3209, 2226, 11485, 15113, 3653, 2817, 3082, 3237, 2110, 8246, 15884, 14724, 14937, 14874, 15196, 13936, 3416, 2886, 3042, 3004, 3001, 3000, 2998, 2996, 2995, 2994, 2991, 2990, 2989, 2988, 2986, 2986, 2984, 2984, 2777, 3721, -2555, -13118, -21367, -20703, -20855, -20871, -20849, -20780, -31079, -33176, -32669, -32756, -32752, -32748, -32741, -32735, -32731, -32724, -32718, -32711, -32706, -32698, -32691, -32684, -32676, -32669, -32662, -32653, -32646, -32638, -32630, -32622, -32614, -32392, -33532, -25730, -19757, -20862, -20647, -20641, -20633, -20626, -20619, -20612, -20606, -20600, -20592, -20586, -20579, -20574, -20568, -20562, -20556, -20550, -20544, -20538, -20532, -20526, -20520, -20514, -20508, -20502, -20496, -20490, -20487, -20481, -20475, -20469, -20463, -20457, -20451, -20447, -20441, -20435, -20430, -20424, -20417, -20413, -20408, -20402, -20396, -20390, -20385, -20376, -20287, -20807, -10917, -7876, -8557, -8431, -8426, -8422, -8418, -8415, -8411, -8407, -8403, -8400, -8397};