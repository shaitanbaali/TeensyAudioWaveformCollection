/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0351 256 samples */
 
const int16_t AKWF_0351_256_DATA [256] = 
{1706, 10477, 21683, 30018, 32719, 27050, 15310, 2418, -8010, -14173, -17152, -18474, -18058, -15637, -11464, -6608, -2624, -303, 507, 675, 1199, 2578, 4653, 6614, 7504, 6873, 4984, 2660, 780, -163, -183, 293, 675, 478, -571, -2485, -4951, -7387, -9047, -9187, -7597, -4566, -396, 4331, 8669, 11512, 12019, 10032, 6188, 1601, -2556, -5434, -6687, -6473, -5264, -3583, -1851, -397, 537, 910, 786, 253, -399, -1377, -7676, -11989, -8770, -302, 9338, 14568, 15596, 12580, 6516, 1203, -1200, -1291, -1316, -2584, -4248, -5240, -5464, -5668, -6350, -7177, -7389, -6266, -3361, 1070, 5809, 9246, 10326, 9132, 6610, 3935, 1985, 1032, 787, 690, 217, -896, -2582, -4563, -6456, -7820, -8188, -7285, -5161, -2059, 1491, 4774, 7164, 8279, 8133, 7045, 5427, 3628, 1824, 97, -1501, -2924, -4105, -5011, -5593, -5794, -5362, -5149, -8936, -11712, -10756, -3113, 9245, 19299, 24720, 23383, 16767, 7794, -895, -6926, -10541, -12803, -13321, -11532, -7776, -3584, -860, -325, -1297, -2357, -2212, -352, 2777, 5925, 7701, 7426, 5376, 2515, -71, -1656, -1989, -1284, -50, 1115, 1651, 1150, -483, -2944, -5542, -7308, -7596, -6315, -3551, 301, 4437, 7800, 9467, 9054, 6886, 3760, 574, -1968, -3487, -3956, -3638, -2913, -2131, -1547, -1265, -1188, -1153, -1063, -763, -692, -6083, -9802, -6406, 1756, 10597, 14656, 14379, 10226, 3445, -2062, -4142, -3457, -2386, -2425, -2919, -2967, -2605, -2604, -3444, -4749, -5692, -5457, -3488, 84, 4156, 7162, 8037, 6826, 4454, 2087, 582, 181, 543, 1034, 1072, 362, -1045, -2868, -4720, -6159, -6726, -6150, -4464, -1869, 1154, 3919, 5817, 6515, 6088, 4920, 3471, 2092, 918, -52, -904, -1548, -3014, -8956, -14899, -15213, -11709, -7311, -6397, -3513};