/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0368 256 samples */
 
const int16_t AKWF_0368_256_DATA [256] = 
{284, 1345, 2381, 3422, 4461, 5496, 6536, 7568, 8608, 9566, 10087, 10523, 10969, 11404, 11836, 12265, 12687, 13107, 13523, 13932, 14341, 14745, 15145, 15541, 15933, 16322, 16706, 17087, 17463, 17837, 18205, 18570, 18931, 19287, 19640, 19988, 20331, 20671, 21006, 21336, 21663, 21984, 22301, 22614, 22921, 23223, 23523, 23815, 24103, 24387, 24665, 24939, 25208, 25472, 25730, 25984, 26232, 26476, 26714, 26947, 27176, 27399, 27617, 27829, 28037, 28240, 28437, 28629, 28816, 28999, 29175, 29348, 29515, 29677, 29833, 29985, 30133, 30275, 30413, 30545, 30673, 30796, 30916, 31030, 31140, 31246, 31346, 31443, 31535, 31623, 31707, 31787, 31863, 31936, 32004, 32068, 32129, 32187, 32240, 32292, 32338, 32382, 32423, 32462, 32496, 32529, 32559, 32587, 32611, 32633, 32655, 32672, 32687, 32702, 32715, 32725, 32734, 32742, 32748, 32753, 32757, 32761, 32763, 32766, 32767, 32499, 33811, 28989, -28989, -33811, -32499, -32768, -32766, -32764, -32761, -32759, -32755, -32751, -32744, -32738, -32729, -32719, -32708, -32694, -32679, -32662, -32643, -32620, -32598, -32571, -32543, -32510, -32477, -32440, -32400, -32358, -32312, -32263, -32210, -32154, -32094, -32032, -31965, -31895, -31820, -31742, -31659, -31574, -31483, -31388, -31289, -31186, -31077, -30965, -30848, -30726, -30600, -30470, -30335, -30195, -30049, -29898, -29744, -29584, -29420, -29249, -29075, -28895, -28709, -28519, -28325, -28125, -27918, -27709, -27493, -27272, -27045, -26814, -26579, -26338, -26090, -25839, -25583, -25321, -25055, -24783, -24506, -24226, -23939, -23649, -23352, -23051, -22746, -22435, -22120, -21801, -21476, -21148, -20814, -20477, -20136, -19789, -19439, -19083, -18725, -18362, -17995, -17623, -17249, -16869, -16486, -16100, -15709, -15315, -14917, -14515, -14107, -13699, -13285, -12867, -12447, -12021, -11589, -11156, -10716, -10266, -9833, -9056, -8005, -6981, -5939, -4905, -3865, -2827, -1788, -730};