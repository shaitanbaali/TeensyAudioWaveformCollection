/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0338 256 samples */
 
const int16_t AKWF_0338_256_DATA [256] = 
{1319, 4040, 6584, 8871, 10855, 12574, 14069, 15359, 16498, 17535, 18531, 19538, 20596, 21731, 22943, 24196, 25481, 26801, 28008, 28853, 29269, 29301, 29032, 28518, 27849, 27110, 26383, 25734, 25218, 24859, 24661, 24587, 24628, 24786, 24987, 25077, 25017, 24832, 24557, 24209, 23829, 23459, 23156, 22957, 22903, 23010, 23272, 23646, 24122, 24683, 25057, 24826, 23877, 22294, 20221, 17773, 15105, 12354, 9631, 7039, 4653, 2504, 610, -1062, -2524, -3769, -4880, -6013, -7207, -8446, -9699, -10950, -12168, -13314, -14333, -15195, -15862, -16320, -16580, -16689, -16659, -16501, -16366, -16508, -17007, -17819, -18866, -20099, -21433, -22782, -24077, -25248, -26243, -27048, -27657, -28110, -28419, -28584, -28680, -28866, -29181, -29600, -30092, -30639, -31203, -31744, -32204, -32548, -32737, -32752, -32605, -32334, -31955, -31467, -30790, -29791, -28407, -26664, -24627, -22384, -20005, -17530, -14967, -12338, -9644, -6889, -4112, -1359, 1357, 4027, 6580, 8871, 10855, 12574, 14069, 15359, 16498, 17535, 18531, 19538, 20596, 21731, 22943, 24196, 25481, 26801, 28008, 28853, 29269, 29301, 29032, 28518, 27849, 27110, 26382, 25733, 25218, 24859, 24661, 24587, 24628, 24786, 24987, 25077, 25017, 24831, 24557, 24209, 23829, 23459, 23156, 22957, 22903, 23010, 23272, 23646, 24122, 24683, 25057, 24826, 23877, 22294, 20221, 17773, 15105, 12354, 9631, 7039, 4653, 2504, 610, -1062, -2524, -3769, -4880, -6013, -7207, -8446, -9699, -10950, -12168, -13314, -14333, -15195, -15862, -16320, -16580, -16689, -16659, -16501, -16366, -16508, -17007, -17819, -18866, -20099, -21433, -22782, -24077, -25248, -26243, -27048, -27657, -28110, -28419, -28584, -28680, -28866, -29181, -29600, -30092, -30639, -31203, -31744, -32204, -32548, -32737, -32752, -32605, -32334, -31955, -31467, -30790, -29791, -28407, -26664, -24627, -22384, -20005, -17530, -14967, -12338, -9644, -6893, -4124, -1322};