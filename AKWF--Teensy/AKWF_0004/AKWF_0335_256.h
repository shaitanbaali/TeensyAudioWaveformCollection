/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0335 256 samples */
 
const int16_t AKWF_0335_256_DATA [256] = 
{1975, 4935, 7552, 9835, 11668, 13300, 15179, 17292, 19290, 20979, 22409, 23461, 23969, 24140, 24413, 24805, 25017, 24944, 24751, 24422, 23892, 23442, 23537, 24175, 24990, 25763, 26522, 27091, 27257, 27173, 27216, 27347, 27210, 26651, 25794, 24588, 22956, 21164, 19682, 18534, 17378, 16041, 14605, 12951, 10934, 8780, 6930, 5414, 3941, 2406, 979, -355, -1666, -2677, -2928, -2430, -1559, -549, 620, 1751, 2618, 3359, 4327, 5466, 6405, 6963, 7250, 7194, 6694, 6004, 5573, 5408, 5153, 4619, 3873, 2787, 1208, -648, -2347, -3864, -5485, -7325, -9205, -11137, -13186, -15067, -16307, -16911, -17238, -17503, -17681, -17942, -18496, -19190, -19646, -19902, -20311, -21028, -21927, -23061, -24505, -25997, -27064, -27685, -28202, -28790, -29370, -30061, -31012, -31998, -32582, -32738, -32759, -32752, -32553, -32184, -31710, -30865, -29195, -26708, -23792, -20685, -17366, -14044, -10951, -7946, -4690, -1242, 2025, 4919, 7547, 9835, 11668, 13300, 15179, 17292, 19290, 20979, 22409, 23461, 23969, 24140, 24413, 24805, 25017, 24944, 24751, 24422, 23892, 23442, 23537, 24175, 24990, 25763, 26522, 27090, 27257, 27173, 27216, 27347, 27210, 26651, 25794, 24588, 22956, 21164, 19682, 18534, 17378, 16040, 14605, 12951, 10934, 8780, 6930, 5414, 3941, 2406, 979, -355, -1666, -2677, -2928, -2430, -1559, -549, 620, 1751, 2618, 3359, 4327, 5466, 6405, 6963, 7250, 7194, 6694, 6004, 5573, 5408, 5153, 4619, 3873, 2787, 1208, -648, -2347, -3864, -5485, -7325, -9205, -11137, -13186, -15067, -16307, -16911, -17238, -17503, -17681, -17942, -18496, -19190, -19646, -19902, -20311, -21028, -21927, -23061, -24505, -25997, -27064, -27685, -28202, -28790, -29370, -30061, -31012, -31998, -32582, -32738, -32759, -32752, -32553, -32184, -31710, -30865, -29195, -26708, -23792, -20685, -17366, -14044, -10951, -7950, -4702, -1202};