/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0400 256 samples */
 
const int16_t AKWF_0400_256_DATA [256] = 
{547, 1456, 3557, 4833, 4998, 5616, 5270, 4187, 3735, 3891, 4928, 6872, 8153, 7092, 6840, 7176, 7516, 7521, 8469, 9257, 10124, 10226, 9237, 8183, 6293, 4747, 4962, 4684, 5794, 7596, 9472, 9852, 9972, 11306, 12380, 13231, 14351, 14250, 14773, 16184, 17687, 19094, 19272, 19395, 19919, 20996, 22870, 24686, 24037, 22257, 20971, 19903, 18797, 17460, 16587, 16166, 14886, 13995, 13914, 14656, 15613, 16511, 16994, 17482, 18002, 18077, 18138, 18826, 20485, 22217, 23220, 24199, 25059, 26010, 26990, 27369, 26251, 25633, 26126, 25628, 25647, 27359, 30174, 32567, 32518, 31232, 30741, 30055, 27918, 28829, 14279, -9551, -14531, -16481, -17625, -18512, -19089, -19101, -18685, -18776, -19236, -19801, -20599, -20775, -20971, -21168, -21548, -23543, -25451, -25925, -25771, -24562, -24975, -26821, -28344, -28862, -28952, -27886, -26277, -24895, -24651, -24718, -24390, -23098, -20523, -18389, -19661, -20844, -21164, -21427, -21195, -20602, -19647, -19027, -19159, -20137, -19589, -17473, -16464, -15324, -13676, -12993, -13767, -14261, -14115, -15247, -15522, -15941, -16384, -16259, -16866, -18282, -19497, -20458, -20547, -19475, -19136, -19198, -18298, -16521, -14896, -12914, -9616, -7908, -6879, -6436, -5221, -3923, -4367, -3831, -2195, -2047, -2415, -2590, -3405, -3644, -4212, -5804, -6631, -6855, -6466, -5473, -3365, -3209, -4094, -2368, 336, 2305, 4217, 5627, 6766, 7393, 8057, 7481, 6045, 5258, 5061, 4028, 3344, 3043, 2267, 2294, 2480, 2428, 2353, 1402, 844, 360, -1626, -3478, -5089, -6357, -7033, -6874, -3665, 386, 1653, 1085, 67, -983, -1369, -2237, -2126, -1237, -67, 657, 358, 701, 1520, 1729, 1667, 1393, 61, -1935, -1327, 717, 2359, 2752, 2696, 2739, 2625, 1728, -63, -1347, -1732, -1297, -69, 1202, 2879, 3668, 3038, 1345, -114, -1528, -917, -4};