/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0305 256 samples */
 
const int16_t AKWF_0305_256_DATA [256] = 
{-76, 477, -22819, -31790, -32489, -32279, -29930, -25970, -20764, -14699, -8185, -1549, 4876, 10798, 16026, 20384, 23754, 26102, 27415, 27730, 27127, 25710, 23607, 20947, 17884, 14563, 11111, 7667, 4346, 1232, -1583, -4042, -6110, -7757, -8980, -9790, -10205, -10259, -9992, -9452, -8687, -7746, -6686, -5549, -4382, -3228, -2118, -1083, -148, 676, 1373, 1937, 2369, 2673, 2854, 2924, 2895, 2781, 2595, 2355, 2074, 1765, 1445, 1123, 808, 513, 240, -2, -210, -385, -523, -627, -696, -735, -745, -731, -696, -644, -580, -506, -428, -346, -265, -187, -115, -49, 8, 58, 98, 131, 154, 169, 177, 178, 173, 163, 150, 134, 116, 97, 77, 59, 40, 23, 8, -4, -16, -25, -31, -37, -40, -42, -41, -40, -37, -34, -31, -26, -21, -17, -13, -9, -5, -1, 1, 2, 5, 6, 7, 8, 7, 7, 8, 7, 6, 6, 5, 4, 2, 2, 1, 0, 0, -1, -2, -2, -1, -2, -2, -2, -3, -3, -2, -1, -2, -1, -2, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};