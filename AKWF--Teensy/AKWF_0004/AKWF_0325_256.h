/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0325 256 samples */
 
const int16_t AKWF_0325_256_DATA [256] = 
{-1646, -3463, -3032, -899, -356, -9606, -14350, 10394, 31122, 21910, -8553, -31861, -25652, -665, 25080, 32206, 17184, -9750, -29261, -28622, -10420, 12459, 25494, 22337, 6237, -11805, -21124, -17297, -4135, 9795, 16677, 13540, 3341, -7518, -12962, -10788, -3204, 4975, 9189, 7626, 1839, -4542, -8062, -6862, -2095, 2954, 5347, 4076, 568, -2844, -4173, -2947, -193, 2348, 3330, 2510, 649, -1025, -1609, -932, 453, 1672, 2050, 1473, 389, -523, -804, -408, 344, 1082, 1263, 629, -217, -695, -560, -33, 492, 684, 437, -2, -305, -295, 12, 496, 999, 2471, 4167, -8152, -23538, -15434, 7319, 26220, 26663, 11360, -11206, -27373, -25727, -7696, 14369, 26028, 22047, 5979, -12020, -21732, -18297, -5063, 9299, 16808, 14163, 4012, -7174, -13027, -11080, -3491, 4848, 9594, 8589, 2989, -3556, -7339, -6607, -2383, 2609, 5517, 5028, 1847, -1925, -4148, -3863, -1411, 12484, 21614, -2758, -25433, -26221, 533, 23320, 20455, 1048, -18582, -22460, -11091, 9285, 22650, 20261, 4696, -12342, -20017, -15119, -1423, 11897, 17190, 11917, 477, -9984, -13721, -9418, -303, 8084, 11107, 7760, 644, -5844, -8190, -5636, -65, 5240, 7273, 5290, 860, -3222, -4748, -3204, 104, 3028, 4060, 2841, 229, -2237, -3286, -2627, -751, 1239, 2047, 1304, -396, -1939, -2454, -1776, -467, 644, 989, 522, -357, -1109, -1326, -912, 7, 703, 513, -97, -590, -629, -320, 60, 267, 173, 108, 23, -650, -1366, -1976, -4232, 2279, 21365, 22144, 1276, -22484, -30525, -19111, 3331, 24821, 30277, 16404, -7456, -24987, -26705, -13257, 6462, 20833, 22286, 11119, -5047, -16497, -17619, -8877, 4187, 13397, 14071, 6828, -3169, -10197, -10769, -4978, 2968, 8149, 7999, 3401, -2436, -6124, -5883, -2418, 1868, 4475, 4183, 1439};