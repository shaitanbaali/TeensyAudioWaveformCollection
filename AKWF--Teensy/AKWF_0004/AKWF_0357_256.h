/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0357 256 samples */
 
const int16_t AKWF_0357_256_DATA [256] = 
{234, 612, 975, 1329, 1674, 2012, 2341, 2661, 2973, 3278, 3574, 3862, 4142, 4413, 4692, 4959, 5223, 9239, 17623, 24206, 28200, 30578, 31896, 32547, 32765, 32711, 32483, 32143, 31732, 31275, 30789, 30284, 29767, 29244, 28716, 28183, 27650, 27117, 26582, 26051, 25518, 24988, 24459, 23931, 23405, 22883, 22361, 21844, 21329, 20814, 20303, 19798, 19294, 18794, 18298, 17804, 17315, 16830, 16347, 15871, 15398, 14928, 14464, 14005, 13550, 13099, 12653, 12212, 11777, 11346, 10919, 10499, 10083, 9673, 9268, 8868, 8473, 8085, 7689, 7298, 6919, 2980, -5306, -11931, -16005, -18481, -19912, -20686, -21035, -21115, -21025, -20828, -20561, -20251, -19914, -19560, -19195, -18825, -18451, -18074, -17698, -17323, -16948, -16575, -16203, -15833, -15466, -15099, -14735, -14376, -14017, -13660, -13307, -12957, -12609, -12265, -11923, -11584, -11250, -10917, -10588, -10263, -9941, -9623, -9308, -8995, -8689, -8386, -8085, -7790, -7498, -7210, -6927, -6648, -6372, -6101, -5834, -5571, -5312, -5058, -4807, -4563, -4345, -4019, -4327, -7724, -9286, -8767, -8343, -7938, -7558, -7195, -6847, -6511, -6181, -5859, -5544, -5233, -4928, -4628, -4333, -4044, -3759, -3479, -3205, -2934, -2667, -2407, -2152, -1901, -1655, -1414, -1178, -948, -721, -499, -283, -73, 133, 334, 532, 723, 909, 1091, 1270, 1443, 1611, 1774, 1934, 2089, 2239, 2385, 2526, 2663, 2796, 2924, 3050, 3170, 3286, 3397, 3507, 3610, 3710, 3807, 3899, 3988, 4059, 4132, 4177, 446, -7472, -13577, -17186, -19238, -20275, -20673, -20665, -20402, -19979, -19458, -18878, -18261, -17627, -16984, -16336, -15692, -15052, -14416, -13789, -13169, -12554, -11951, -11356, -10769, -10192, -9623, -9063, -8512, -7970, -7437, -6914, -6398, -5893, -5397, -4909, -4430, -3961, -3501, -3049, -2607, -2174, -1750, -1333, -928, -531, -135};