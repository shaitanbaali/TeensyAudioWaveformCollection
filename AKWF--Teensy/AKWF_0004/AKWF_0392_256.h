/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0392 256 samples */
 
const int16_t AKWF_0392_256_DATA [256] = 
{28314, 28506, 28692, 28879, 29067, 29255, 29441, 29629, 29817, 30004, 30190, 30379, 30567, 30753, 30941, 31129, 31316, 31506, 31667, 31950, 31824, 25139, 24229, 24678, 24817, 25004, 25192, 25380, 25567, 25754, 25941, 26129, 26317, 26503, 26691, 26880, 27066, 27253, 27442, 27629, 27816, 28004, 28191, 28380, 28568, 28754, 28941, 29130, 29317, 29503, 29692, 29879, 30066, 30253, 30442, 30629, 30816, 31003, 31191, 31379, 31566, 31655, 32387, 29940, 23942, 24584, 24696, 24878, 25067, 25255, 25443, 25630, 25816, 26003, 26192, 26379, 26566, 26754, 26942, 27129, 27316, 27504, 27692, 27878, 28067, 28254, 28442, 28630, 28816, 29004, 29193, 29379, 29566, 29755, 29942, 30128, 30316, 30505, 30691, 30878, 31066, 31253, 31442, 31632, 31692, 32554, 27388, 23824, 24691, 24752, 24941, 25130, 25317, 25505, 25692, 25878, 26066, 26255, 26441, 26628, 26817, 27004, 27191, 27379, 27566, 27150, 30530, 14542, -28636, -27804, -27559, -27487, -27298, -27111, -26924, -26737, -26548, -26362, -26173, -25986, -25799, -25611, -25424, -25238, -25049, -24860, -24699, -24415, -24541, -31227, -32136, -31688, -31547, -31362, -31173, -30986, -30799, -30612, -30425, -30236, -30049, -29861, -29673, -29486, -29299, -29111, -28924, -28737, -28548, -28361, -28174, -27986, -27798, -27612, -27424, -27236, -27049, -26862, -26673, -26487, -26299, -26111, -25924, -25737, -25548, -25362, -25175, -24986, -24800, -24711, -23979, -26426, -32424, -31782, -31669, -31486, -31299, -31111, -30923, -30736, -30550, -30362, -30173, -29987, -29798, -29611, -29424, -29236, -29049, -28861, -28674, -28486, -28299, -28112, -27923, -27736, -27549, -27362, -27173, -26987, -26800, -26610, -26424, -26236, -26048, -25861, -25674, -25486, -25300, -25113, -24924, -24734, -24673, -23811, -28977, -32542, -31675, -31612, -31423, -31236, -31049, -30861, -30674, -30487, -30299, -30111, -29924, -29736, -29548, -29362, -29173, -28986, -28799, -28123, -30565, -16272};