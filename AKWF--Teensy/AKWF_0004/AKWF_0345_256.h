/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0345 256 samples */
 
const int16_t AKWF_0345_256_DATA [256] = 
{-32755, -32760, -32764, -32766, -32767, -32580, -33611, -28627, -18874, -19934, -19738, -19736, -19734, -19731, -19727, -19724, -19720, -19717, -19713, -19709, -19705, -19701, -19697, -19692, -19688, -19683, -19679, -19674, -19669, -19664, -19660, -19655, -19650, -19645, -19640, -19635, -19630, -19625, -19620, -19615, -19610, -19604, -19600, -19594, -19589, -19584, -19579, -19573, -19569, -19563, -19558, -19553, -19547, -19542, -19538, -19532, -19527, -19522, -19516, -19511, -19507, -19501, -19496, -19491, -19485, -19364, -20009, -17209, -6149, -6486, -6443, -6428, -6425, -6421, -6417, -6414, -6410, -6407, -6405, -6402, -6399, -6396, -6393, -6391, -6389, -6386, -6384, -6382, -6380, -6377, -6376, -6373, -6371, -6369, -6367, -6365, -6363, -6361, -6359, -6358, -6356, -6354, -6352, -6350, -6349, -6347, -6345, -6343, -6341, -6340, -6338, -6336, -6334, -6333, -6331, -6329, -6327, -6326, -6323, -6322, -6321, -6319, -6317, -6315, -6314, -6259, -6517, -5558, 5964, 6924, 6664, 6718, 6718, 6719, 6719, 6719, 6719, 6718, 6718, 6717, 6716, 6716, 6715, 6713, 6712, 6711, 6710, 6709, 6708, 6706, 6705, 6704, 6702, 6700, 6699, 6698, 6696, 6694, 6693, 6691, 6690, 6687, 6686, 6685, 6683, 6681, 6680, 6678, 6676, 6674, 6673, 6671, 6669, 6667, 6666, 6664, 6662, 6660, 6659, 6657, 6655, 6653, 6651, 6650, 6648, 6646, 6866, 5668, 11992, 20674, 19429, 19657, 19654, 19651, 19648, 19644, 19641, 19637, 19633, 19629, 19625, 19621, 19616, 19612, 19607, 19603, 19598, 19593, 19589, 19584, 19579, 19574, 19570, 19564, 19560, 19555, 19550, 19545, 19540, 19535, 19530, 19524, 19519, 19514, 19509, 19504, 19499, 19493, 19489, 19483, 19478, 19473, 19468, 19463, 19458, 19452, 19447, 19442, 19437, 19432, 19426, 19421, 19416, 19411, 19405, 19401, 19539, 18741, 22364, 32798, 32316, 32379, 32385, 32378, 32371, 32365};