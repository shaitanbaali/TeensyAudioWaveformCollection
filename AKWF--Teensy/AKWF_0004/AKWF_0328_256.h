/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0328 256 samples */
 
const int16_t AKWF_0328_256_DATA [256] = 
{562, 1617, 2623, 3608, 4573, 5534, 6449, 7304, 8100, 8832, 9501, 10084, 10775, 11698, 12154, 12573, 12913, 13173, 13354, 13469, 13529, 13541, 13544, 13923, 13903, 13798, 13688, 13563, 13429, 13298, 13108, 13199, 13365, 13179, 13046, 13026, 12140, 10486, 8777, 7557, 6361, 5563, 5097, 4889, 4850, 4920, 5429, 5563, 5560, 5513, 5401, 5199, 5019, 5121, 4753, 4333, 3889, 3436, 2992, 2568, 2612, 2410, 2151, 1992, 1904, 1890, 1949, 2035, 2576, 2998, 3232, 3521, 3825, 4145, 4474, 4812, 5156, 5477, 5866, 6619, 7064, 7761, 8818, 10169, 11703, 13333, 15005, 16712, 18445, 20192, 21944, 23680, 25380, 27005, 28500, 29862, 31076, 32048, 32645, 32738, 32282, 31349, 30071, 28814, 27591, 26340, 25078, 23786, 22444, 21069, 19688, 18359, 17132, 16001, 14945, 13965, 13046, 12156, 11280, 10272, 8894, 7907, 6908, 5913, 4954, 4042, 3184, 2362, 1550, 738, -502, -1438, -2252, -3070, -3889, -4671, -5394, -6035, -7062, -7830, -8408, -8996, -9539, -10037, -10419, -11075, -11668, -11884, -12099, -12247, -12342, -12345, -12724, -12924, -12906, -12933, -12942, -12947, -12890, -13121, -13441, -13429, -13501, -13606, -13799, -14124, -14806, -15717, -16109, -16471, -16769, -17009, -17206, -17347, -17528, -18027, -18057, -17987, -17826, -17554, -17170, -16686, -16134, -15485, -15205, -14735, -14038, -13406, -12799, -12237, -11727, -11280, -10901, -10595, -10377, -10230, -10497, -10497, -10320, -10194, -10062, -9932, -9808, -9687, -9566, -9436, -9293, -9128, -8945, -8820, -8855, -9107, -9552, -10154, -10873, -11674, -12512, -13368, -14251, -15098, -16237, -17472, -18301, -19116, -19849, -20508, -21085, -21593, -22088, -22653, -23385, -23552, -23767, -24023, -24061, -23895, -23507, -22903, -22094, -21110, -20006, -18838, -17633, -16394, -15106, -13782, -12430, -11052, -9670, -8300, -6958, -5666, -4430, -3228, -2122, -754};