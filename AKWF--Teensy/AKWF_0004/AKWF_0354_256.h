/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0354 256 samples */
 
const int16_t AKWF_0354_256_DATA [256] = 
{115, 361, 592, 815, 1029, 1237, 1436, 1628, 1813, 1991, 2163, 2328, 2486, 2639, 2787, 2928, 3063, 3195, 3319, 3440, 3557, 3668, 3775, 3877, 3976, 4071, 4161, 4249, 4332, 4412, 4488, 4561, 4631, 4698, 4763, 4824, 4882, 4939, 4992, 5043, 5092, 5138, 5182, 5223, 5263, 5301, 5336, 5371, 5403, 5433, 5462, 5489, 5514, 5539, 5561, 5582, 5602, 5620, 5637, 5653, 5668, 5682, 5694, 5705, 5716, 5724, 5733, 5741, 5747, 5753, 5758, 5762, 5765, 5768, 5771, 5771, 5772, 5772, 5771, 5769, 5767, 5765, 5762, 5758, 5754, 5750, 5745, 5739, 5733, 5727, 5720, 5713, 5706, 5698, 5691, 5682, 5673, 5664, 5655, 5645, 5635, 5625, 5615, 5604, 5593, 5582, 5570, 5559, 5548, 5536, 5524, 5512, 5499, 5487, 5475, 5462, 5449, 5436, 5422, 5409, 5395, 5382, 5368, 5355, 5341, 5327, 5313, 5299, 5285, 5271, 5257, 5241, 5227, 5213, 5199, 5185, 5170, 5156, 5140, 5126, 5111, 5097, 5081, 5067, 5052, 5037, 5023, 5008, 4992, 4978, 4963, 4947, 4933, 4918, 4904, 4888, 4873, 4858, 4843, 4829, 4813, 4798, 4784, 4769, 4754, 4738, 4724, 4709, 4695, 4679, 4665, 4650, 4636, 4621, 4606, 4591, 4577, 4562, 4547, 4533, 4518, 4503, 4489, 4475, 4460, 4446, 4431, 4416, 4402, 4388, 4374, 4360, 4225, 4694, 3113, -25518, -28602, -24847, -26271, -28498, -30444, -31797, -32541, -32774, -32608, -32146, -31468, -30641, -29715, -28722, -27692, -26647, -25596, -24551, -23523, -22511, -21522, -20560, -19621, -18711, -17829, -16972, -16145, -15344, -14568, -13818, -13094, -12393, -11717, -11063, -10430, -9822, -9233, -8662, -8114, -7584, -7072, -6578, -6100, -5640, -5196, -4766, -4352, -3953, -3567, -3195, -2837, -2491, -2157, -1835, -1524, -1224, -936, -658, -390, -127};