/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0396 256 samples */
 
const int16_t AKWF_0396_256_DATA [256] = 
{498, 1649, 2772, 3893, 5003, 6103, 7192, 8264, 9321, 10362, 11381, 12382, 13363, 14320, 15256, 16171, 17058, 17924, 18766, 19579, 20372, 21137, 21877, 22592, 23283, 23946, 24586, 25200, 25788, 26353, 26891, 27405, 27894, 28358, 28799, 29216, 29607, 29975, 30320, 30640, 30937, 31210, 31460, 31688, 31893, 32074, 32234, 32373, 32488, 32584, 32658, 32713, 32748, 32766, 32765, 32749, 32719, 32678, 32626, 32568, 32505, 32443, 32380, 32321, 32266, 32216, 32172, 32132, 32098, 32066, 32037, 32008, 31977, 31941, 31900, 31848, 31785, 31709, 31616, 31505, 31376, 31228, 31058, 30869, 30656, 30422, 30168, 29896, 29605, 29289, 28949, 28584, 28195, 27782, 27345, 26884, 26400, 25895, 25369, 24822, 24256, 23672, 23069, 22450, 21812, 21154, 20480, 19783, 19064, 18326, 17561, 16770, 15954, 15108, 14233, 13329, 12394, 11428, 10436, 9414, 8369, 7305, 6218, 5117, 4005, 2881, 1751, 620, -515, -1645, -2771, -3893, -5003, -6103, -7192, -8264, -9321, -10362, -11382, -12383, -13364, -14321, -15257, -16171, -17058, -17924, -18766, -19580, -20372, -21138, -21878, -22593, -23283, -23947, -24586, -25200, -25788, -26353, -26891, -27405, -27894, -28359, -28799, -29216, -29607, -29975, -30320, -30640, -30937, -31210, -31460, -31688, -31893, -32075, -32234, -32373, -32488, -32584, -32659, -32713, -32748, -32766, -32765, -32749, -32719, -32678, -32626, -32568, -32505, -32442, -32380, -32320, -32266, -32216, -32171, -32132, -32097, -32066, -32037, -32007, -31976, -31941, -31900, -31848, -31785, -31709, -31616, -31505, -31376, -31228, -31058, -30868, -30656, -30422, -30168, -29895, -29604, -29289, -28948, -28584, -28195, -27782, -27345, -26884, -26400, -25895, -25368, -24821, -24256, -23672, -23069, -22450, -21812, -21154, -20480, -19783, -19064, -18325, -17561, -16770, -15954, -15109, -14233, -13330, -12394, -11429, -10437, -9415, -8370, -7305, -6218, -5117, -4006, -2883, -1757, -605};