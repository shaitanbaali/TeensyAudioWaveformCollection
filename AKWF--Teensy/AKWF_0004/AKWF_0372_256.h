/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0372 256 samples */
 
const int16_t AKWF_0372_256_DATA [256] = 
{404, 1617, 2459, 3702, 4883, 5174, 5146, 6040, 7328, 7192, 6753, 7404, 8417, 8873, 9204, 9481, 9970, 11387, 13000, 14129, 14769, 15359, 15721, 16047, 16707, 16641, 15328, 14038, 12523, 10529, 8270, 6284, 4988, 4408, 4269, 4517, 5548, 6552, 7007, 6557, 6462, 7077, 7234, 7521, 8398, 8820, 8633, 8239, 7331, 7017, 7003, 6993, 6485, 5451, 4882, 5183, 5557, 5407, 5322, 5009, 4918, 4625, 4321, 4510, 4346, 3355, 2816, 2592, 2337, 2694, 2918, 2640, 2976, 3895, 4501, 4375, 3912, 3414, 3730, 4211, 4967, 4912, 5073, 5651, 5547, 5835, 7389, 10256, 13016, 15571, 17685, 18607, 19226, 21024, 21978, 22195, 23057, 23762, 24510, 25451, 25697, 25810, 25870, 26055, 26910, 27199, 27664, 28026, 27949, 28356, 28316, 27896, 27764, 27364, 26975, 27129, 26345, 25910, 24888, 24114, 23786, 22562, 21220, 20282, 19600, 19881, 20099, 18940, 17159, 14847, 12693, 11597, 11162, 10988, 11077, 10683, 10205, 9330, 7818, 6199, 5036, 4867, 5092, 4341, 3084, 2376, 1326, -580, -2037, -3065, -4302, -5894, -7350, -8755, -10271, -11762, -13445, -15163, -17388, -20083, -22429, -24440, -26854, -29196, -30582, -31892, -32722, -32381, -31192, -29614, -28189, -26607, -24843, -23009, -22120, -20724, -19028, -17230, -15293, -13616, -12341, -11363, -11595, -11815, -11068, -9683, -8040, -7780, -7849, -7345, -6716, -5891, -4779, -4110, -3228, -1642, 233, 1286, 1110, -3, -1676, -3718, -5531, -6669, -7808, -8624, -9754, -11614, -13294, -14683, -15902, -16915, -17786, -19107, -20167, -21191, -21686, -21747, -22206, -23024, -23437, -23153, -24556, -26422, -27602, -28929, -29905, -30264, -29768, -29319, -28798, -27737, -26647, -26509, -26775, -26847, -26833, -25915, -24999, -23722, -21746, -19249, -17060, -15233, -13592, -11908, -10539, -9192, -7073, -5267, -3885, -3457, -3269, -3148, -2382, -1085};