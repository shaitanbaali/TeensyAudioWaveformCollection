/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0301 256 samples */
 
const int16_t AKWF_0301_256_DATA [256] = 
{1398, 4071, 7230, 10816, 14709, 18737, 22690, 26283, 29300, 31498, 32639, 32640, 31410, 28976, 25429, 20942, 15737, 10032, 4095, -1850, -7555, -12818, -17468, -21445, -24647, -27026, -28590, -29406, -29509, -28966, -27849, -26288, -24353, -22145, -19751, -17258, -14737, -12229, -9791, -7499, -5338, -3333, -1524, 78, 1506, 2713, 3761, 4617, 5315, 5861, 6259, 6538, 6714, 6771, 6781, 6700, 6568, 6382, 6167, 5918, 5640, 5372, 5071, 4766, 4481, 4181, 3893, 3609, 3336, 3076, 2823, 2590, 2357, 2158, 1964, 1765, 1607, 1446, 1294, 1164, 1035, 925, 811, 739, 646, 573, 513, 450, 402, 371, 334, 326, 297, 299, 290, 295, 321, 357, 377, 420, 481, 548, 619, 711, 824, 954, 1086, 1256, 1436, 1628, 1827, 2077, 2355, 2646, 2949, 3290, 3640, 3996, 4304, 4597, 4837, 4978, 4978, 4778, 4313, 3522, 2356, 712, -1422, -4066, -7227, -10817, -14709, -18737, -22689, -26283, -29300, -31498, -32639, -32640, -31410, -28975, -25429, -20942, -15737, -10033, -4095, 1850, 7554, 12817, 17468, 21445, 24647, 27025, 28589, 29406, 29509, 28966, 27849, 26288, 24353, 22145, 19751, 17257, 14736, 12229, 9791, 7499, 5338, 3332, 1523, -79, -1507, -2714, -3762, -4618, -5316, -5862, -6259, -6539, -6715, -6771, -6782, -6701, -6569, -6382, -6167, -5919, -5640, -5372, -5071, -4767, -4482, -4182, -3894, -3610, -3337, -3077, -2824, -2591, -2358, -2158, -1965, -1766, -1608, -1447, -1295, -1164, -1035, -926, -812, -740, -647, -574, -514, -451, -403, -372, -335, -327, -298, -300, -291, -296, -321, -358, -378, -421, -482, -548, -620, -712, -825, -954, -1087, -1257, -1437, -1629, -1828, -2077, -2356, -2647, -2950, -3291, -3641, -3997, -4305, -4598, -4838, -4979, -4979, -4778, -4313, -3526, -2369, -680};