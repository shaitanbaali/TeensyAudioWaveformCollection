/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0371 256 samples */
 
const int16_t AKWF_0371_256_DATA [256] = 
{1533, 5192, 8448, 11211, 13458, 15252, 16702, 17925, 19039, 20127, 21238, 22383, 23533, 24635, 25622, 26413, 26947, 27165, 27019, 26472, 25476, 24007, 22056, 19620, 16741, 13500, 9976, 6313, 2665, -759, -4230, -7806, -11299, -14623, -17736, -20593, -23158, -25417, -27363, -28983, -30293, -31306, -32038, -32511, -32741, -32735, -32490, -31994, -31224, -30155, -28755, -27012, -24902, -22433, -19635, -16524, -13174, -9663, -6068, -2532, 751, 4089, 7491, 10768, 13852, 16670, 19182, 21372, 23225, 24752, 25969, 26886, 27527, 27910, 28049, 27954, 27633, 27094, 26330, 25351, 24163, 22761, 21166, 19395, 17463, 15404, 13254, 11042, 8822, 6627, 4499, 2487, 657, -995, -2607, -4124, -5512, -6746, -7815, -8720, -9447, -10015, -10427, -10688, -10819, -10823, -10721, -10519, -10242, -9899, -9508, -9079, -8623, -8142, -7594, -6966, -6298, -5639, -5041, -4542, -4185, -3995, -3974, -4126, -4430, -4865, -5399, -5994, -6616, -7231, -7811, -8333, -8785, -9155, -9441, -9630, -9736, -9752, -9678, -9506, -9231, -8849, -8344, -7710, -6945, -6040, -5000, -3838, -2559, -1201, 166, 1637, 3245, 4916, 6623, 8323, 9980, 11571, 13069, 14446, 15692, 16790, 17732, 18511, 19118, 19549, 19804, 19877, 19767, 19465, 18979, 18301, 17431, 16377, 15139, 13733, 12170, 10464, 8648, 6758, 4811, 2860, 972, -807, -2639, -4493, -6298, -8017, -9625, -11101, -12424, -13581, -14565, -15378, -16009, -16464, -16739, -16843, -16777, -16555, -16169, -15636, -14969, -14169, -13258, -12252, -11159, -9999, -8799, -7570, -6335, -5117, -3933, -2800, -1742, -769, 88, 873, 1617, 2283, 2861, 3347, 3740, 4035, 4244, 4364, 4403, 4372, 4274, 4127, 3938, 3714, 3473, 3225, 2978, 2742, 2530, 2347, 2205, 2098, 2067, 1866, 634, -1724, -5038, -8770, -12322, -15220, -17133, -17903, -17499, -15954, -13381, -9989, -6092, -2034};