/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0363 256 samples */
 
const int16_t AKWF_0363_256_DATA [256] = 
{1283, 3416, 4969, 6211, 7233, 8099, 8845, 9488, 10044, 10519, 10913, 11232, 11477, 11649, 11754, 11792, 11767, 11682, 11541, 11347, 11104, 10817, 10490, 10127, 9732, 9310, 8863, 8398, 7920, 7428, 6932, 6432, 5933, 5438, 4951, 4474, 4011, 3564, 3133, 2724, 2335, 1968, 1626, 1306, 1011, 741, 494, 271, 72, -104, -257, -390, -502, -596, -673, -725, -730, -1037, 3566, 8670, 9419, 8612, 7061, 5315, 3674, 2284, 1176, 324, -311, -774, -1120, -1383, -1590, -1759, -1901, -2022, -2126, -2214, -2287, -2346, -2390, -2421, -2436, -2438, -2427, -2402, -2367, -2320, -2262, -2193, -2023, -2444, 2432, 9582, 11006, 10290, 8559, 6499, 4511, 2792, 1415, 357, -428, -991, -1401, -1707, -1944, -2136, -2296, -2432, -2497, -2813, -1902, 5100, 8665, 8602, 7232, 5285, 3273, 1463, -27, -1151, -1953, -2516, -2910, -3187, -3385, -3525, -3625, -3695, -3741, -3767, -3777, -3768, -3744, -3706, -3652, -3569, -3473, -3561, 2288, 7890, 8633, 7719, 6016, 4121, 2369, 912, -220, -1035, -1595, -1981, -2247, -2430, -2561, -2656, -2727, -2781, -2822, -2851, -2869, -2876, -2870, -2854, -2827, -2789, -2740, -2682, -2559, -2701, -1625, 6238, 10392, 10486, 9161, 7187, 5116, 3237, 1683, 473, -431, -1075, -1531, -1864, -2113, -2306, -2460, -2589, -2696, -2787, -2862, -2922, -2967, -2996, -3011, -3010, -2994, -2965, -2922, -2865, -2796, -2718, -2629, -2530, -2425, -2314, -2197, -2077, -1953, -1828, -1703, -1578, -1454, -1331, -1213, -1097, -985, -878, -775, -677, -585, -499, -418, -343, -274, -211, -153, -100, -53, -12, 25, 57, 84, 108, 128, 143, 156, 166, 173, 177, 180, 180, 95, 303, -254, -21089, -32424, -32581, -31205, -28155, -23892, -18928, -13834, -9073, -4933, -1431};