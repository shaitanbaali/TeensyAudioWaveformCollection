/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0320 256 samples */
 
const int16_t AKWF_0320_256_DATA [256] = 
{421, 1746, 3022, 4214, 5389, 6570, 7701, 8808, 9899, 10975, 12013, 13034, 13970, 14923, 15876, 16815, 17731, 18596, 19452, 20287, 21118, 21881, 22599, 23310, 23968, 24575, 25179, 25742, 26275, 26767, 27232, 27700, 28133, 28538, 28908, 29255, 29572, 29855, 30123, 30407, 30674, 30950, 31212, 31437, 31618, 31778, 31907, 31988, 32043, 32057, 32068, 32017, 31947, 31812, 31648, 31438, 31212, 30915, 30374, 29877, 29511, 29124, 28691, 28288, 27872, 27479, 27123, 26729, 26387, 26081, 25730, 25427, 25155, 24845, 24502, 24200, 23901, 23564, 23191, 22761, 22356, 21967, 21554, 21136, 20699, 20223, 19693, 19099, 18445, 17740, 16995, 16225, 15442, 14660, 13894, 13161, 12468, 11805, 11184, 10621, 10077, 9467, 8849, 8222, 7599, 6983, 6309, 5655, 5025, 4493, 4099, 3497, 3114, 2777, 2329, 1986, 1665, 1323, 1020, 728, 487, 240, 59, -72, 88, 85, -8, -101, -251, -409, -613, -844, -1110, -1426, -1747, -2036, -2362, -2710, -3059, -3445, -3854, -4331, -4851, -5404, -5984, -6583, -7176, -7778, -8404, -9019, -9644, -10263, -10877, -11475, -12099, -12717, -13342, -13956, -14574, -15208, -15817, -16434, -17029, -17603, -18143, -18642, -19113, -19540, -19969, -20411, -20850, -21344, -21817, -22304, -22830, -23299, -23745, -24187, -24621, -25001, -25395, -25788, -26207, -26616, -27083, -27546, -28297, -28949, -29498, -30038, -30497, -30955, -31320, -31654, -31957, -32160, -32350, -32518, -32595, -32674, -32754, -32767, -32723, -32705, -32676, -32597, -32475, -32289, -32121, -31967, -31793, -31615, -31423, -31202, -30937, -30621, -30262, -29867, -29447, -29021, -28600, -28190, -27802, -27429, -27076, -26763, -26480, -26230, -25966, -25603, -25198, -24746, -24267, -23763, -23175, -22573, -21994, -21376, -20520, -19862, -19077, -18162, -17291, -16377, -15309, -14260, -13172, -11960, -10783, -9549, -8265, -6910, -5255, -3763, -2332, -917};