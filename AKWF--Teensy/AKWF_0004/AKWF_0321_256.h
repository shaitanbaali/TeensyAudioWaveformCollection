/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0321 256 samples */
 
const int16_t AKWF_0321_256_DATA [256] = 
{456, 1949, 3424, 4842, 6272, 7738, 9178, 10612, 12045, 13471, 14856, 16216, 17468, 18713, 19930, 21088, 22182, 23174, 24107, 24959, 25749, 26401, 26938, 27388, 27699, 27871, 27943, 27884, 27709, 27420, 27061, 26730, 26400, 25986, 25554, 25158, 24816, 24532, 24329, 24241, 24229, 24316, 24472, 24680, 24906, 25180, 25500, 25823, 26178, 26550, 26967, 27359, 27771, 28144, 28503, 28836, 29161, 29419, 29517, 29619, 29797, 29940, 30003, 30059, 30073, 30130, 30236, 30310, 30446, 30625, 30767, 30960, 31184, 31362, 31488, 31637, 31758, 31802, 31766, 31621, 31448, 31236, 30939, 30572, 30117, 29549, 28848, 27997, 26992, 25840, 24545, 23129, 21612, 20021, 18398, 16832, 15339, 13820, 12360, 11017, 9775, 8552, 7413, 6360, 5399, 4528, 3675, 2911, 2243, 1718, 1322, 852, 593, 387, 147, 24, -78, -171, -223, -280, -289, -321, -321, -309, -128, -71, -98, -143, -252, -323, -407, -487, -575, -687, -779, -815, -874, -948, -1025, -1148, -1313, -1573, -1912, -2324, -2805, -3357, -3951, -4612, -5358, -6156, -7035, -7987, -9016, -10114, -11335, -12639, -14033, -15487, -16989, -18481, -19908, -21401, -22848, -24213, -25460, -26568, -27551, -28387, -29132, -29801, -30383, -30932, -31396, -31803, -32174, -32430, -32603, -32711, -32763, -32718, -32649, -32548, -32456, -32334, -32262, -32180, -32303, -32363, -32379, -32398, -32361, -32364, -32294, -32176, -32015, -31739, -31444, -31117, -30689, -30260, -29832, -29343, -28808, -28323, -27855, -27374, -26888, -26386, -25953, -25593, -25271, -25011, -24803, -24635, -24500, -24394, -24329, -24322, -24390, -24544, -24793, -25129, -25536, -25937, -26326, -26818, -27324, -27811, -28203, -28400, -28460, -28377, -28177, -27868, -27392, -26832, -26226, -25540, -24616, -23761, -22789, -21675, -20525, -19324, -17965, -16591, -15177, -13649, -12164, -10637, -9091, -7514, -5758, -4126, -2547, -1003};