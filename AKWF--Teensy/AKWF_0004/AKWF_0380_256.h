/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0380 256 samples */
 
const int16_t AKWF_0380_256_DATA [256] = 
{6710, 6709, 6711, 6713, 6713, 6713, 6713, 6713, 6713, 6713, 6713, 6711, 6709, 6710, 6709, 6707, 6707, 6706, 6705, 6704, 6702, 6701, 6699, 6698, 6696, 6694, 6693, 6691, 6691, 6689, 6687, 6685, 6684, 6682, 6680, 6679, 6678, 6675, 6674, 6672, 6670, 6668, 6667, 6665, 6664, 6661, 6660, 6658, 6656, 6654, 6653, 6650, 6649, 6648, 6646, 6644, 6642, 6640, 6639, 6638, 6635, 6634, 6632, 6629, 6628, 6626, 6625, 6623, 6621, 6619, 6618, 6616, 6613, 6612, 6610, 6609, 6607, 6606, 6603, 6601, 6600, 6598, 6597, 6594, 6593, 6591, 6589, 6587, 6585, 6583, 6582, 6581, 6579, 6577, 6575, 6573, 6571, 6569, 6568, 6566, 6564, 6562, 6561, 6559, 6557, 6555, 6554, 6951, 4770, 15409, 35214, 29427, 19087, 19730, 19620, 19613, 19609, 19605, 19601, 19597, 19593, 19589, 19584, 19579, 19575, 19410, 20190, 17298, -17430, -20322, -19538, -19701, -19701, -19702, -19704, -19701, -19702, -19701, -19699, -19698, -19696, -19832, -19044, -22554, -33012, -33999, -26712, -5409, -6830, -6585, -6576, -6572, -6569, -6566, -6563, -6560, -6557, -6555, -6552, -6549, -6547, -6545, -6542, -6540, -6537, -6535, -6533, -6531, -6529, -6527, -6526, -6523, -6521, -6518, -6517, -6516, -6513, -6511, -6509, -6507, -6505, -6503, -6502, -6501, -6499, -6496, -6495, -6493, -6491, -6489, -6488, -6486, -6484, -6483, -6480, -6478, -6476, -6475, -6474, -6471, -6470, -6468, -6466, -6464, -6463, -6461, -6460, -6458, -6456, -6454, -6453, -6450, -6448, -6447, -6446, -6444, -6442, -6440, -6439, -6437, -6434, -6433, -6432, -6430, -6428, -6426, -6425, -6423, -6421, -6420, -6418, -6416, -6415, -6413, -6411, -6409, -6407, -6406, -6404, -6403, -6401, -6399, -6397, -6395, -6393, -6392, -6390, -6389, -6387, -6385, -6383, -6381, -6380, -6379, -6376, -6375};