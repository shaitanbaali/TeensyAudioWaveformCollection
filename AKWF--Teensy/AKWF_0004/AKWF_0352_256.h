/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0352 256 samples */
 
const int16_t AKWF_0352_256_DATA [256] = 
{63, 332, 755, 1350, 2086, 2883, 3700, 4524, 5300, 5948, 6448, 6833, 7131, 7358, 7566, 7840, 8242, 8769, 9383, 10058, 10780, 11504, 12161, 12701, 13116, 13434, 13688, 13895, 14067, 14232, 14431, 14729, 15158, 15723, 16425, 17271, 18257, 19371, 20570, 21798, 23003, 24140, 25169, 26087, 26883, 27574, 28150, 28643, 29047, 29399, 29744, 30096, 30509, 30952, 31398, 31846, 32220, 32487, 32677, 32765, 32744, 32654, 32491, 32230, 31892, 31513, 31083, 30595, 30087, 29569, 29022, 28439, 27840, 27244, 26634, 25979, 25272, 24519, 23693, 22767, 21737, 20612, 19413, 18154, 16826, 15453, 14081, 12756, 11516, 10377, 9323, 8364, 7529, 6816, 6214, 5679, 5184, 4705, 4252, 3815, 3390, 2912, 2367, 1724, 996, 183, -655, -1558, -2486, -3396, -4366, -5232, -6014, -6759, -7410, -7927, -8556, -9145, -9546, -10171, -10653, -10861, -11235, -11558, -11541, -11658, -11940, -11942, -11959, -12168, -12206, -12233, -12484, -12662, -12754, -13103, -13598, -13839, -13841, -13910, -14178, -14427, -14389, -14191, -14233, -14614, -14869, -14598, -14010, -13639, -13655, -13647, -13226, -12561, -12198, -12375, -12774, -12953, -12818, -12681, -12913, -13512, -14165, -14641, -14979, -15428, -16176, -17139, -18063, -18763, -19212, -19504, -19774, -20061, -20304, -20435, -20421, -20299, -20126, -20032, -20039, -20112, -20188, -20233, -20182, -20028, -19879, -19759, -19705, -19736, -19779, -19827, -19878, -19865, -19824, -19855, -19931, -19988, -20019, -19987, -19835, -19553, -19162, -18689, -18190, -17737, -17347, -16962, -16509, -15962, -15327, -14573, -13664, -12663, -11718, -10940, -10353, -9914, -9537, -9189, -8852, -8487, -8056, -7562, -7083, -6730, -6552, -6524, -6572, -6632, -6633, -6517, -6248, -5807, -5213, -4517, -3829, -3238, -2823, -2606, -2569, -2648, -2742, -2783, -2701, -2518, -2232, -1840, -1410, -965, -556, -269, -104, -36, -56, -56};