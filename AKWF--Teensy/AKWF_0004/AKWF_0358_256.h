/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0358 256 samples */
 
const int16_t AKWF_0358_256_DATA [256] = 
{8117, 22738, 27884, 27567, 28152, 29203, 22928, 18266, 18080, 21579, 20549, 15573, 9536, 5024, 1408, -3566, 397, 1335, 4647, 6376, 4466, 3074, -834, -3626, -7469, -9169, -10683, -11451, -12857, -13384, -16182, -20357, -7869, -3046, -4679, -4553, 1421, 9392, 9191, 7850, 8221, 11375, 11102, 8987, 7548, 7841, 7442, 2991, 4880, 2275, 2201, 2068, 400, 1050, 70, 61, -1841, -2601, -3893, -4470, -6279, -15325, -16374, -19387, -759, 7887, 5791, 533, -1706, -1355, -5735, -6681, -2293, 6185, 10102, 9605, 7260, 5390, 3244, -1334, 2228, 2332, 4757, 5863, 3834, 2964, 246, -763, -2424, -1807, -1164, -236, -650, -1049, -4648, -10514, -482, 1341, -3573, -6740, -3775, 1681, -367, -2794, -2745, 785, 1461, 708, 860, 2792, 3937, 825, 3780, 1966, 2435, 2657, 1245, 2141, 1460, 1794, 817, -719, -16165, -12767, -7491, -21933, -20079, -16169, 5657, 18070, 20109, 16484, 14075, 12951, 5335, -79, -645, 2830, 2259, -1675, -6104, -8573, -9842, -12283, -5667, -1996, 4048, 8413, 8959, 9753, 7696, 6392, 3642, 2622, 1366, 436, -1531, -2986, -7028, -12710, -1940, 1024, -2540, -4366, -280, 5912, 4100, 1368, 599, 2898, 2072, -288, -1664, -1017, -786, -4364, -1399, -2757, -1470, -174, -388, 1690, 2061, 3296, 2483, 2635, 2054, 1965, 417, -8594, -9832, -13239, 4809, 12713, 9740, 3506, 232, -483, -5919, -7878, -4430, 3209, 6413, 5348, 2594, 480, -1739, -6230, -2423, -1930, 1007, 2729, 1398, 1282, -654, -881, -1782, -454, 831, 2315, 2354, 2297, -1083, -6852, 3153, 4829, -339, -3853, -1321, 3639, 1047, -1950, -2479, 484, 627, -617, -897, 674, 1542, -1758, 1097, -902, 564, -3367, -24907, -16635, -20809, -9330, -6499, -12067, -30146, -28117, -19466, -29061, -22795, -15480};