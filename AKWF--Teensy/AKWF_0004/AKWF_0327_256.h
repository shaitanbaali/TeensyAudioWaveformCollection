/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0327 256 samples */
 
const int16_t AKWF_0327_256_DATA [256] = 
{341, 742, 1009, 1331, 1812, 2455, 3214, 4045, 4923, 5838, 6778, 7738, 8704, 9661, 10607, 11535, 12442, 13335, 14212, 15073, 15927, 16773, 17614, 18457, 19302, 20150, 20984, 21496, 19646, 16513, 15279, 14715, 14269, 13451, 12253, 11055, 10127, 9502, 9094, 8812, 8588, 8395, 8219, 8039, 7831, 7576, 7260, 6881, 6446, 5965, 5453, 4923, 4386, 3862, 3367, 2912, 2515, 2185, 1916, 1844, 840, -864, -1356, -1565, -1634, -1778, -2005, -2139, -2075, -1814, -1404, -890, -298, 357, 1063, 1813, 2588, 3374, 4165, 4953, 5735, 6512, 7284, 8050, 8816, 9580, 10344, 11116, 11896, 12680, 13472, 14339, 13260, 10993, 10479, 10447, 10501, 10254, 9695, 9141, 8801, 8691, 8737, 8866, 9034, 9220, 9417, 9613, 9792, 9935, 10036, 10091, 10107, 10088, 10046, 9987, 9920, 9858, 9811, 9786, 9794, 9841, 9919, 10161, 9431, 7964, 7669, 7618, 7667, 7601, 7414, 7282, 7313, 7507, 7819, 8206, 8645, 9122, 9629, 10157, 10696, 11230, 11755, 12266, 12762, 13246, 13719, 14181, 14638, 15094, 15549, 16009, 16478, 16762, 16891, 16578, 13824, 9756, 7551, 6003, 4577, 2793, 646, -1475, -3290, -4763, -5975, -7023, -7979, -8881, -9749, -10614, -11502, -12437, -13438, -14505, -15627, -16797, -17994, -19199, -20399, -21569, -22687, -23739, -24701, -25560, -26320, -26840, -28249, -30314, -31118, -31590, -31876, -32190, -32541, -32753, -32724, -32457, -32001, -31403, -30691, -29883, -28995, -28035, -27023, -25977, -24904, -23815, -22717, -21605, -20484, -19359, -18222, -17076, -15922, -14751, -13567, -12375, -11166, -9877, -10531, -12370, -12452, -12048, -11555, -11362, -11479, -11586, -11478, -11138, -10639, -10057, -9434, -8790, -8135, -7478, -6838, -6232, -5667, -5146, -4666, -4217, -3792, -3384, -2981, -2574, -2154, -1711, -1234, -720, -174, 532, 267, -736, -568, -150};