/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0323 256 samples */
 
const int16_t AKWF_0323_256_DATA [256] = 
{1455, 4300, 5353, 5608, 6003, 6644, 7095, 7232, 7214, 7199, 7195, 7165, 7080, 6922, 6691, 6250, 5882, 5595, 5292, 5024, 4795, 4591, 4401, 4212, 4050, 3890, 3732, 3580, 3431, 4348, 5936, 9851, 14955, 17877, 19557, 20291, 20761, 21147, 21245, 21069, 20798, 20558, 20395, 20255, 20088, 19908, 19674, 19284, 18949, 18665, 18384, 18145, 17914, 17714, 17534, 17374, 17216, 17068, 16942, 16817, 16704, 16595, 16561, 18240, 21420, 23067, 23532, 23464, 23494, 23716, 23823, 23736, 23559, 23398, 23265, 23110, 22931, 22719, 22462, 22057, 21705, 21414, 21125, 20857, 20619, 20399, 20196, 19999, 19807, 19641, 19469, 19299, 19140, 19741, 20820, 23457, 27288, 29820, 31254, 31872, 32262, 32562, 32613, 32415, 32137, 31891, 31708, 31549, 31382, 31188, 30952, 30569, 30245, 29963, 29688, 29442, 29220, 29016, 28828, 28658, 28497, 28348, 28196, 28007, 26968, 23747, 14465, -527, -9316, -15446, -19742, -22386, -23305, -23284, -23278, -23780, -24804, -26085, -27306, -28281, -28959, -29375, -29646, -29951, -30186, -30412, -30692, -30993, -31297, -31574, -31817, -32019, -32198, -32353, -32491, -32632, -32766, -32235, -31276, -28833, -25082, -22422, -20863, -20184, -19738, -19391, -19335, -19553, -19863, -20131, -20316, -20496, -20680, -20888, -21141, -21548, -21896, -22184, -22470, -22728, -22950, -23151, -23331, -23495, -23649, -23792, -23926, -24043, -24151, -24251, -24295, -22735, -19608, -17883, -17386, -17461, -17411, -17171, -17046, -17135, -17312, -17472, -17614, -17754, -17935, -18144, -18398, -18808, -19144, -19429, -19705, -19939, -20166, -20359, -20536, -20700, -20843, -20995, -21119, -21245, -21373, -20727, -19609, -16813, -12229, -8344, -6019, -4984, -4294, -3737, -3567, -3798, -4150, -4424, -4613, -4757, -4923, -5113, -5368, -5839, -6218, -6504, -6782, -7013, -7198, -7330, -7424, -7491, -7507, -7494, -7455, -7346, -7174, -6803, -6075, -3278};