/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0314 256 samples */
 
const int16_t AKWF_0314_256_DATA [256] = 
{315, 1363, 1980, 4870, -4299, -12797, 8257, 18363, 21544, 19091, 13376, 6721, 949, -2836, -4285, -3614, -1432, 1499, 4443, 6818, 8285, 8726, 8229, 7014, 5369, 3590, 1920, 536, -474, -1101, -1390, -1422, -1300, -1118, -955, -862, -861, -953, -1123, -1342, -1581, -1805, -1993, -2130, -2208, -2228, -2198, -2125, -2022, -1900, -1764, -1626, -1488, -1351, -1219, -1088, -959, -830, -702, -573, -445, -318, -196, -78, 35, 138, -94, 1789, -6591, -22091, -21170, -63, 12122, 16990, 16835, 13924, 10176, 6883, 4654, 3552, 3272, 3334, 3269, 2738, 1578, -173, -2330, -4627, -6752, -8435, -9489, -9808, -9393, -8328, -6762, -4874, -2847, -863, 939, 2463, 3646, 4467, 4940, 5096, 4984, 4662, 4182, 3598, 2948, 2277, 1606, 964, 368, -170, -639, -1034, -1347, -1577, -1725, -1793, -1788, -1715, -1589, -1413, -1206, -976, -738, -499, -272, -66, -209, 1985, -7815, -16868, 3703, 13400, 16250, 13542, 7645, 880, -4935, -8699, -10064, -9253, -6881, -3713, -492, 2194, 4004, 4811, 4698, 3881, 2643, 1274, 13, -969, -1588, -1836, -1760, -1450, -1006, -525, -89, 252, 471, 569, 563, 480, 349, 205, 71, -35, -108, -144, -150, -132, -102, -65, -30, -3, 15, 23, 24, 17, 9, -2, -11, -18, -23, -22, -21, -18, -11, -8, -330, 1471, -6984, -22609, -21541, -845, -19427, -13754, -5687, -2542, -381, 1725, 4369, 7576, 11017, 14225, 16726, 18190, 18488, 17676, 15977, 13694, 11180, 8748, 6632, 4985, 3852, 3193, 2905, 2853, 2888, 2872, 2701, 2305, 1653, 747, -381, -1677, -3082, -4531, -5957, -7309, -8546, -9624, -10526, -11233, -11733, -12026, -12113, -11999, -11692, -11205, -10554, -9755, -8829, -7801, -6688, -5521, -4323, -3115, -1928, -757};