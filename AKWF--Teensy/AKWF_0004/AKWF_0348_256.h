/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0348 256 samples */
 
const int16_t AKWF_0348_256_DATA [256] = 
{344, 1364, 2649, 3716, 4706, 5715, 6721, 7725, 8730, 9736, 10739, 11743, 12749, 13750, 14748, 15777, 16596, 16945, 17274, 17608, 17940, 18272, 18604, 18936, 19268, 19598, 19930, 20261, 20589, 20930, 21201, 21220, 21211, 21208, 21203, 21198, 21193, 21188, 21183, 21178, 21173, 21168, 21161, 21160, 21136, 20849, 20498, 20160, 19820, 19480, 19139, 18800, 18460, 18119, 17779, 17439, 17097, 16768, 16234, 15545, 14874, 14199, 13525, 12851, 12176, 11503, 10829, 10154, 9481, 8808, 8137, 7451, 6912, 6579, 6240, 5901, 5564, 5227, 4889, 4551, 4215, 3877, 3540, 3204, 2869, 2521, 2268, 2258, 2258, 2256, 2254, 2253, 2252, 2251, 2250, 2249, 2248, 2247, 2246, 2245, 2244, 2243, 2242, 2242, 2241, 2240, 2239, 2238, 2238, 2237, 2236, 2236, 2233, 2238, 2214, 1925, 1580, 1247, 912, 576, 240, -94, -430, -765, -1100, -1436, -1765, -2124, -2452, -2454, -2452, -2454, -2453, -2452, -2453, -2452, -2452, -2451, -2452, -2451, -2451, -2450, -2450, -2449, -2449, -2448, -2447, -2447, -2446, -2446, -2445, -2444, -2444, -2443, -2443, -2442, -2442, -2441, -2440, -2440, -2439, -2439, -2438, -2437, -2437, -2436, -2435, -2435, -2436, -2427, -2470, -2779, -3119, -3451, -3785, -4120, -4453, -4787, -5121, -5455, -5789, -6124, -6457, -6791, -7355, -8036, -8702, -9370, -10038, -10706, -11374, -12042, -12710, -13377, -14044, -14712, -15376, -16054, -16550, -16869, -17204, -17536, -17866, -18198, -18529, -18860, -19191, -19523, -19852, -20183, -20511, -20855, -21066, -21056, -21052, -21048, -21044, -21039, -21033, -21029, -21023, -21018, -21013, -21008, -20999, -21006, -20933, -20601, -20259, -19920, -19579, -19239, -18899, -18558, -18219, -17879, -17538, -17197, -16856, -16521, -15758, -14719, -13715, -12708, -11698, -10688, -9681, -8671, -7662, -6655, -5646, -4639, -3628, -2640, -1723, -697};