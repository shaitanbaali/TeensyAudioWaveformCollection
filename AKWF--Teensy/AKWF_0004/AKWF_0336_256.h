/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0336 256 samples */
 
const int16_t AKWF_0336_256_DATA [256] = 
{1988, 4844, 7339, 9599, 11718, 13719, 15558, 17199, 18637, 19839, 20774, 21503, 22120, 22649, 23061, 23332, 23451, 23394, 23150, 22840, 22642, 22614, 22712, 22878, 23058, 23182, 23188, 23101, 22998, 22887, 22723, 22478, 22137, 21659, 21006, 20238, 19469, 18720, 17949, 17125, 16229, 15225, 14084, 12848, 11609, 10392, 9154, 7878, 6565, 5198, 3805, 2543, 1617, 1113, 984, 1148, 1521, 1989, 2449, 2888, 3349, 3816, 4224, 4533, 4716, 4730, 4533, 4187, 3807, 3415, 2974, 2457, 1850, 1119, 240, -740, -1728, -2698, -3691, -4732, -5834, -7032, -8337, -9631, -10747, -11624, -12312, -12876, -13368, -13862, -14429, -15040, -15622, -16171, -16731, -17332, -17994, -18752, -19650, -20627, -21565, -22444, -23306, -24177, -25071, -26020, -27047, -28101, -29077, -29941, -30716, -31403, -31980, -32438, -32732, -32687, -32074, -30811, -28947, -26565, -23780, -20734, -17552, -14293, -10945, -7550, -4217, -1009, 2032, 4829, 7334, 9599, 11718, 13719, 15558, 17199, 18637, 19839, 20774, 21503, 22120, 22649, 23061, 23332, 23451, 23394, 23150, 22840, 22642, 22614, 22712, 22878, 23058, 23182, 23188, 23101, 22998, 22887, 22723, 22478, 22137, 21659, 21006, 20238, 19469, 18720, 17949, 17125, 16229, 15225, 14084, 12848, 11609, 10392, 9154, 7878, 6565, 5198, 3805, 2543, 1617, 1113, 984, 1148, 1521, 1989, 2450, 2888, 3349, 3816, 4224, 4533, 4716, 4730, 4533, 4187, 3807, 3415, 2974, 2457, 1850, 1119, 240, -740, -1728, -2698, -3691, -4732, -5834, -7032, -8337, -9631, -10747, -11624, -12312, -12876, -13368, -13862, -14429, -15040, -15622, -16171, -16731, -17332, -17994, -18752, -19650, -20627, -21565, -22444, -23306, -24177, -25071, -26020, -27047, -28101, -29077, -29941, -30716, -31403, -31980, -32438, -32732, -32687, -32074, -30811, -28947, -26565, -23780, -20734, -17552, -14293, -10945, -7556, -4229, -969};