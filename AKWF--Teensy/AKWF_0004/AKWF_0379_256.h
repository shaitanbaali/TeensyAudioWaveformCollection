/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0379 256 samples */
 
const int16_t AKWF_0379_256_DATA [256] = 
{11064, 11063, 11066, 11069, 11069, 11069, 11069, 11069, 11069, 11069, 11069, 11066, 11063, 11064, 11063, 11060, 11060, 11057, 11055, 11053, 11051, 11050, 11046, 11045, 11041, 11039, 11037, 11035, 11032, 11029, 11026, 11024, 11022, 11018, 11016, 11013, 11010, 11008, 11004, 11002, 10999, 10997, 10993, 10990, 10987, 10985, 10982, 10980, 10976, 10973, 10970, 10967, 10964, 10961, 10959, 10955, 10953, 10949, 10947, 10944, 10942, 10938, 10935, 10933, 10930, 10926, 10924, 10921, 10917, 10915, 10911, 10910, 10906, 10902, 10900, 10897, 10894, 10892, 10889, 10885, 10883, 10880, 10878, 10873, 10871, 10868, 10865, 10862, 10859, 10857, 10853, 10851, 10847, 10845, 10842, 10840, 10836, 10832, 10830, 10828, 10824, 10822, 10819, 10815, 10813, 10809, 10807, 11136, 9325, 18268, 34051, 32163, 32504, 32499, 32496, 32490, 32485, 32477, 32472, 32466, 32459, 32452, 32444, 32437, 32430, 32156, 33453, 28652, -28994, -33793, -32492, -32763, -32764, -32767, -32768, -32764, -32764, -32762, -32759, -32757, -32753, -32748, -32742, -32739, -32492, -33845, -27705, -10020, -11198, -10992, -10982, -10977, -10974, -10968, -10963, -10960, -10957, -10951, -10947, -10944, -10940, -10937, -10933, -10929, -10925, -10922, -10919, -10915, -10911, -10909, -10906, -10902, -10898, -10896, -10893, -10889, -10887, -10884, -10880, -10878, -10874, -10871, -10868, -10865, -10862, -10859, -10857, -10853, -10851, -10847, -10844, -10842, -10838, -10836, -10832, -10829, -10827, -10823, -10821, -10818, -10815, -10812, -10809, -10806, -10804, -10800, -10796, -10794, -10792, -10789, -10786, -10783, -10779, -10777, -10774, -10772, -10769, -10767, -10762, -10759, -10757, -10754, -10751, -10749, -10745, -10742, -10740, -10736, -10734, -10730, -10728, -10726, -10723, -10718, -10716, -10713, -10711, -10708, -10706, -10702, -10699, -10696, -10693, -10691, -10689, -10685, -10683, -10679, -10676, -10673, -10670, -10667, -10665, -10662, -10660, -10656};