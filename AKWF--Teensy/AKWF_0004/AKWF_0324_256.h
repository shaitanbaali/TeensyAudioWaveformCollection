/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0324 256 samples */
 
const int16_t AKWF_0324_256_DATA [256] = 
{282, 1183, 2082, 3013, 3930, 4794, 5594, 6330, 7009, 7627, 8180, 8671, 9099, 9447, 9742, 9999, 10216, 10404, 10568, 10715, 10847, 10967, 11079, 11184, 11286, 11381, 11486, 11703, 12088, 12847, 14024, 15342, 16633, 17823, 18934, 19974, 20903, 21697, 22364, 22915, 23371, 23739, 24020, 24221, 24344, 24379, 24351, 24278, 24164, 24018, 23848, 23660, 23457, 23252, 23013, 22979, 23203, 23462, 23947, 24445, 24985, 25747, 26753, 27692, 28425, 28965, 29393, 29757, 30038, 30216, 30298, 30298, 30232, 30104, 29919, 29677, 29380, 29018, 28611, 28172, 27706, 27216, 26710, 26192, 25661, 25125, 24584, 24036, 23487, 22934, 22392, 21965, 21707, 21823, 22361, 23042, 23697, 24256, 24737, 25151, 25460, 25636, 25689, 25633, 25489, 25261, 24955, 24576, 24124, 23596, 23013, 22395, 21746, 21074, 20389, 19699, 19010, 18302, 17749, 17519, 17311, 17331, 17218, 16605, 14790, 11812, 8588, 5201, 1696, -1709, -4833, -7623, -10133, -12465, -14680, -16774, -18730, -20516, -22105, -23503, -24723, -25798, -26744, -27576, -28318, -28986, -29588, -30127, -30614, -31049, -31440, -31791, -32108, -32398, -32651, -32768, -32699, -32239, -31346, -30295, -29260, -28313, -27434, -26611, -25888, -25289, -24808, -24429, -24132, -23913, -23766, -23687, -23674, -23733, -23841, -23981, -24146, -24330, -24522, -24715, -24907, -25097, -25250, -25604, -26204, -26823, -27651, -28476, -29262, -29684, -29603, -29318, -29004, -28691, -28333, -27912, -27473, -27052, -26665, -26307, -25975, -25672, -25400, -25162, -24959, -24803, -24675, -24557, -24451, -24349, -24246, -24136, -24016, -23883, -23736, -23574, -23394, -23199, -22973, -22612, -22067, -21126, -19747, -18210, -16680, -15233, -13849, -12518, -11281, -10161, -9156, -8247, -7419, -6664, -5981, -5364, -4811, -4333, -3902, -3504, -3135, -2785, -2446, -2113, -1784, -1431, -1220, -1315, -1409, -1723, -2049, -2348, -2515, -2274, -1539, -607};