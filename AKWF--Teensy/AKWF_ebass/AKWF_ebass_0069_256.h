/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0069 256 samples */
 
const int16_t AKWF_ebass_0069_256_DATA [256] = 
{1419, 3911, 6213, 8395, 10455, 12406, 14256, 16000, 17651, 19209, 20665, 22028, 23302, 24479, 25567, 26569, 27482, 28317, 29070, 29748, 30356, 30892, 31359, 31758, 32094, 32365, 32567, 32701, 32762, 32757, 32686, 32548, 32343, 32069, 31720, 31295, 30794, 30220, 29573, 28856, 28070, 27216, 26304, 25334, 24307, 23233, 22113, 20955, 19766, 18543, 17299, 16043, 14770, 13495, 12227, 10963, 9713, 8486, 7283, 6114, 4983, 3891, 2847, 1852, 906, 7, -844, -1636, -2360, -3021, -3620, -4148, -4613, -5019, -5362, -5644, -5872, -6052, -6186, -6268, -6304, -6288, -6224, -6129, -6009, -5867, -5709, -5526, -5312, -5063, -4776, -4464, -4133, -3786, -3438, -3096, -2763, -2439, -2117, -1794, -1470, -1142, -812, -482, -160, 146, 424, 661, 855, 1007, 1134, 1248, 1369, 1508, 1672, 1855, 2044, 2231, 2403, 2557, 2696, 2825, 2947, 3062, 3170, 3266, 3343, 3387, 3393, 3365, 3301, 3213, 3111, 3000, 2890, 2780, 2663, 2538, 2399, 2243, 2070, 1889, 1705, 1519, 1331, 1137, 926, 688, 411, 93, -264, -652, -1058, -1474, -1888, -2302, -2715, -3137, -3577, -4044, -4543, -5071, -5623, -6193, -6771, -7357, -7947, -8542, -9149, -9777, -10427, -11107, -11807, -12518, -13237, -13950, -14651, -15339, -16011, -16671, -17323, -17970, -18613, -19254, -19886, -20505, -21109, -21695, -22263, -22814, -23351, -23877, -24395, -24900, -25396, -25877, -26339, -26780, -27197, -27590, -27960, -28309, -28636, -28945, -29236, -29505, -29757, -29987, -30197, -30389, -30570, -30744, -30907, -31064, -31213, -31356, -31492, -31618, -31734, -31835, -31921, -31991, -32044, -32079, -32094, -32082, -32041, -31967, -31857, -31708, -31512, -31270, -30972, -30618, -30208, -29738, -29209, -28615, -27950, -27215, -26404, -25508, -24519, -23432, -22231, -20915, -19481, -17921, -16239, -14435, -12501, -10444, -8272, -5989, -3605, -1066};