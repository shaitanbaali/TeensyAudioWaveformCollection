/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0050 256 samples */
 
const int16_t AKWF_ebass_0050_256_DATA [256] = 
{808, 2214, 4125, 6114, 7800, 9813, 11790, 12323, 11977, 12777, 14506, 15643, 15887, 15374, 14718, 14849, 15281, 15017, 14929, 15842, 16421, 16014, 15930, 16874, 17963, 17927, 16934, 16398, 16740, 17149, 16836, 16149, 16282, 17254, 17422, 16763, 16777, 17505, 17639, 16640, 15199, 14795, 15962, 17220, 17095, 16721, 17213, 17593, 17686, 18265, 18976, 19090, 18451, 17015, 15912, 16692, 18365, 18751, 17610, 16371, 16024, 16093, 16064, 16198, 16479, 15966, 14605, 13811, 14041, 14647, 15287, 14876, 13078, 11780, 11444, 10690, 9889, 9835, 9247, 7755, 6625, 5666, 4590, 4559, 5126, 4598, 3578, 3109, 2814, 2570, 2727, 2912, 2694, 2224, 1693, 1228, 998, 1183, 1494, 1326, 1032, 1131, 1235, 1343, 1892, 2615, 3019, 3491, 3985, 3925, 4102, 5366, 6696, 7050, 6811, 6665, 6859, 7480, 8072, 8404, 8939, 9605, 9529, 8606, 8368, 9552, 10519, 10234, 9775, 9666, 9052, 8131, 7595, 7228, 7513, 8123, 6801, 4056, 3120, 3856, 3613, 2860, 2851, 2541, 1602, 683, -599, -1968, -2302, -2610, -4044, -5118, -5112, -5519, -6744, -7538, -7408, -7168, -7839, -9132, -10567, -11960, -12089, -10571, -9132, -8672, -8588, -9087, -10391, -11479, -12165, -13097, -13427, -13153, -13906, -14687, -13362, -11056, -9701, -9071, -9131, -10175, -11279, -11819, -12178, -12157, -11392, -11210, -12333, -12805, -11659, -10501, -10281, -10545, -10622, -10086, -8801, -7295, -5988, -4197, -2996, -4722, -8020, -9682, -9822, -10547, -12259, -13624, -14024, -14251, -15044, -16133, -16656, -16854, -18006, -20473, -22587, -22900, -22592, -23436, -24731, -25039, -24890, -25597, -26682, -27746, -28815, -29194, -29556, -30486, -30699, -30088, -30724, -32479, -32408, -30467, -28517, -26894, -26084, -25579, -23600, -20715, -18658, -16849, -14511, -13299, -13513, -13302, -12022, -10365, -9012, -8435, -7726, -5542, -2577, -460};