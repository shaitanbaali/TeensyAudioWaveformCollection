/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0030 256 samples */
 
const int16_t AKWF_ebass_0030_256_DATA [256] = 
{422, 2054, 3690, 5358, 7028, 8686, 10309, 11870, 13354, 14753, 16031, 17187, 18207, 19071, 19783, 20328, 20700, 20900, 20935, 20811, 20538, 20123, 19577, 18907, 18140, 17284, 16353, 15374, 14361, 13332, 12320, 11337, 10420, 9592, 8877, 8280, 7820, 7498, 7322, 7288, 7392, 7629, 7987, 8458, 9031, 9685, 10415, 11202, 12018, 12847, 13659, 14425, 15132, 15753, 16269, 16677, 16966, 17140, 17207, 17172, 17056, 16870, 16638, 16384, 16126, 15886, 15682, 15529, 15437, 15416, 15476, 15620, 15854, 16183, 16618, 17164, 17833, 18625, 19536, 20551, 21635, 22735, 23777, 24686, 25405, 25909, 26181, 26215, 26005, 25522, 24749, 23688, 22379, 20885, 19304, 17689, 16112, 14607, 13186, 11855, 10608, 9446, 8377, 7406, 6525, 5723, 4975, 4261, 3563, 2882, 2214, 1567, 947, 367, -165, -639, -1048, -1385, -1645, -1823, -1919, -1929, -1849, -1679, -1414, -1056, -608, -79, 529, 1202, 1931, 2707, 3516, 4344, 5189, 6025, 6838, 7605, 8315, 8942, 9468, 9878, 10156, 10292, 10272, 10087, 9728, 9184, 8450, 7519, 6391, 5069, 3566, 1904, 98, -1844, -3894, -6032, -8230, -10443, -12673, -14868, -17010, -19077, -21041, -22889, -24624, -26210, -27644, -28914, -29998, -30907, -31635, -32177, -32540, -32734, -32761, -32641, -32384, -32006, -31517, -30936, -30274, -29543, -28765, -27959, -27135, -26316, -25496, -24685, -23888, -23120, -22375, -21672, -21013, -20402, -19841, -19322, -18837, -18388, -17971, -17587, -17239, -16922, -16635, -16377, -16142, -15926, -15723, -15523, -15323, -15113, -14888, -14647, -14393, -14129, -13864, -13604, -13354, -13128, -12931, -12777, -12676, -12636, -12659, -12738, -12868, -13036, -13230, -13436, -13642, -13836, -14008, -14152, -14258, -14324, -14346, -14317, -14238, -14107, -13918, -13674, -13366, -12993, -12540, -12003, -11366, -10622, -9771, -8816, -7753, -6598, -5342, -3999, -2580, -1059};