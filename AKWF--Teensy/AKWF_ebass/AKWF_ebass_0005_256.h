/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0005 256 samples */
 
const int16_t AKWF_ebass_0005_256_DATA [256] = 
{822, 2639, 4401, 6077, 7717, 9343, 10980, 12639, 14342, 16092, 17882, 19695, 21496, 23226, 24837, 26287, 27565, 28688, 29666, 30502, 31201, 31760, 32181, 32478, 32663, 32756, 32763, 32682, 32500, 32212, 31812, 31301, 30678, 29956, 29140, 28236, 27258, 26223, 25158, 24092, 23032, 21976, 20911, 19808, 18646, 17420, 16131, 14808, 13468, 12108, 10730, 9330, 7916, 6521, 5178, 3914, 2746, 1666, 648, -337, -1311, -2293, -3282, -4291, -5335, -6417, -7519, -8606, -9623, -10538, -11331, -12007, -12590, -13121, -13640, -14192, -14788, -15421, -16058, -16666, -17215, -17701, -18111, -18438, -18668, -18806, -18881, -18946, -19068, -19302, -19675, -20167, -20715, -21248, -21709, -22066, -22323, -22489, -22557, -22525, -22403, -22238, -22106, -22083, -22221, -22530, -22973, -23474, -23936, -24264, -24406, -24368, -24195, -23926, -23607, -23285, -23004, -22825, -22796, -22931, -23208, -23570, -23916, -24127, -24109, -23806, -23235, -22461, -21581, -20700, -19896, -19219, -18702, -18348, -18130, -17989, -17851, -17642, -17298, -16758, -15998, -15038, -13933, -12785, -11708, -10783, -10050, -9504, -9099, -8760, -8400, -7946, -7356, -6607, -5691, -4619, -3421, -2147, -885, 279, 1269, 2025, 2537, 2848, 3023, 3139, 3271, 3459, 3720, 4062, 4487, 5008, 5633, 6344, 7108, 7872, 8589, 9239, 9830, 10377, 10911, 11447, 11990, 12530, 13035, 13471, 13818, 14068, 14232, 14337, 14405, 14464, 14541, 14663, 14850, 15116, 15466, 15906, 16427, 16995, 17582, 18163, 18718, 19236, 19693, 20047, 20258, 20294, 20142, 19794, 19246, 18500, 17551, 16443, 15229, 13940, 12631, 11359, 10164, 9059, 8032, 7052, 6088, 5103, 4066, 2958, 1759, 434, -1024, -2610, -4286, -5989, -7640, -9150, -10466, -11606, -12605, -13497, -14310, -15041, -15663, -16142, -16438, -16515, -16341, -15889, -15137, -14076, -12729, -11156, -9432, -7645, -5857, -4107, -2411, -720};