/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0029 256 samples */
 
const int16_t AKWF_ebass_0029_256_DATA [256] = 
{354, 1565, 2757, 4010, 5319, 6685, 8093, 9525, 10978, 12438, 13912, 15391, 16861, 18308, 19725, 21105, 22449, 23753, 25006, 26200, 27324, 28376, 29337, 30201, 30958, 31594, 32103, 32478, 32705, 32768, 32650, 32336, 31812, 31075, 30127, 28976, 27635, 26110, 24395, 22525, 20507, 18363, 16147, 13855, 11528, 9211, 6921, 4692, 2553, 478, -1501, -3377, -5148, -6795, -8327, -9754, -11084, -12331, -13526, -14702, -15879, -17083, -18325, -19593, -20897, -22204, -23502, -24783, -26026, -27224, -28371, -29424, -30360, -31149, -31754, -32153, -32329, -32275, -31997, -31511, -30834, -29971, -28935, -27735, -26374, -24886, -23278, -21560, -19758, -17881, -15925, -13916, -11842, -9726, -7589, -5440, -3297, -1155, 989, 3116, 5196, 7213, 9125, 10932, 12616, 14173, 15583, 16864, 17998, 18969, 19773, 20403, 20858, 21154, 21294, 21291, 21159, 20904, 20535, 20059, 19491, 18838, 18116, 17342, 16518, 15658, 14781, 13908, 13067, 12269, 11499, 10736, 9961, 9160, 8340, 7503, 6649, 5763, 4829, 3830, 2748, 1574, 295, -1088, -2571, -4139, -5786, -7478, -9202, -10937, -12658, -14363, -16044, -17674, -19244, -20728, -22100, -23358, -24471, -25427, -26210, -26812, -27229, -27463, -27509, -27372, -27054, -26554, -25875, -25024, -24018, -22886, -21648, -20332, -18958, -17541, -16093, -14622, -13124, -11620, -10122, -8641, -7192, -5764, -4343, -2934, -1524, -126, 1252, 2626, 3982, 5319, 6640, 7928, 9173, 10374, 11498, 12537, 13476, 14299, 15008, 15594, 16047, 16359, 16517, 16515, 16351, 16029, 15561, 14967, 14257, 13451, 12551, 11564, 10501, 9363, 8165, 6929, 5673, 4415, 3176, 1936, 707, -515, -1727, -2911, -4050, -5145, -6171, -7123, -8001, -8794, -9515, -10156, -10708, -11159, -11500, -11715, -11806, -11778, -11643, -11406, -11080, -10665, -10166, -9589, -8945, -8236, -7476, -6659, -5789, -4874, -3914, -2920, -1894, -805};