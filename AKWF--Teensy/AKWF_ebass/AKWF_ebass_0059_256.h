/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0059 256 samples */
 
const int16_t AKWF_ebass_0059_256_DATA [256] = 
{458, 1932, 3273, 4547, 5747, 6878, 7947, 8949, 9894, 10784, 11619, 12399, 13132, 13812, 14448, 15039, 15585, 16092, 16558, 16988, 17383, 17747, 18081, 18382, 18661, 18911, 19139, 19342, 19523, 19681, 19818, 19937, 20035, 20116, 20178, 20223, 20250, 20265, 20263, 20245, 20213, 20166, 20108, 20039, 19954, 19859, 19756, 19641, 19520, 19392, 19256, 19114, 18967, 18816, 18657, 18497, 18332, 18166, 17992, 17817, 17639, 17457, 17271, 17082, 16890, 16692, 16490, 16286, 16077, 15860, 15642, 15418, 15193, 14961, 14728, 14490, 14254, 14014, 13774, 13535, 13293, 13053, 12813, 12572, 12329, 12082, 11833, 11574, 11310, 11040, 10758, 10468, 10173, 9868, 9562, 9250, 8938, 8628, 8320, 8019, 7724, 7438, 7156, 6888, 6625, 6371, 6125, 5882, 5645, 5415, 5185, 4958, 4735, 4510, 4285, 4060, 3831, 3606, 3386, 3165, 2951, 2746, 2551, 2375, 2213, 2070, 1948, 1853, 1782, 1732, 1706, 1703, 1721, 1757, 1811, 1881, 1962, 2058, 2166, 2281, 2407, 2547, 2698, 2860, 3037, 3230, 3441, 3670, 3919, 4181, 4465, 4764, 5077, 5399, 5735, 6076, 6418, 6756, 7085, 7399, 7689, 7953, 8184, 8378, 8532, 8635, 8687, 8688, 8628, 8509, 8330, 8089, 7781, 7412, 6973, 6463, 5881, 5217, 4466, 3628, 2687, 1642, 483, -783, -2110, -3485, -4909, -6355, -7822, -9301, -10777, -12242, -13688, -15107, -16485, -17828, -19117, -20356, -21542, -22664, -23728, -24732, -25668, -26544, -27359, -28106, -28796, -29427, -29995, -30508, -30965, -31366, -31715, -32013, -32259, -32457, -32606, -32706, -32758, -32764, -32722, -32633, -32497, -32313, -32081, -31799, -31470, -31091, -30665, -30186, -29656, -29077, -28446, -27762, -27029, -26239, -25398, -24503, -23553, -22547, -21489, -20376, -19206, -17988, -16714, -15391, -14023, -12601, -11139, -9644, -8101, -6528, -4945, -3234, -2206, -912};