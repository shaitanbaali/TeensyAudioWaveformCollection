/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0067 256 samples */
 
const int16_t AKWF_ebass_0067_256_DATA [256] = 
{964, 2638, 4177, 5629, 6993, 8277, 9485, 10618, 11682, 12682, 13619, 14500, 15327, 16100, 16828, 17509, 18147, 18745, 19306, 19829, 20319, 20778, 21206, 21606, 21979, 22326, 22649, 22949, 23227, 23485, 23723, 23942, 24144, 24329, 24497, 24650, 24788, 24912, 25023, 25120, 25205, 25278, 25338, 25387, 25425, 25454, 25471, 25478, 25476, 25464, 25442, 25410, 25370, 25321, 25263, 25196, 25121, 25038, 24945, 24844, 24737, 24621, 24498, 24367, 24228, 24082, 23928, 23767, 23599, 23424, 23243, 23055, 22859, 22658, 22450, 22235, 22014, 21788, 21555, 21317, 21074, 20825, 20570, 20311, 20048, 19780, 19510, 19235, 18958, 18679, 18397, 18114, 17831, 17546, 17262, 16979, 16696, 16417, 16139, 15864, 15594, 15328, 15067, 14813, 14565, 14323, 14091, 13867, 13653, 13449, 13256, 13074, 12904, 12746, 12602, 12470, 12352, 12247, 12156, 12077, 12011, 11957, 11916, 11885, 11864, 11852, 11847, 11849, 11857, 11868, 11881, 11894, 11905, 11914, 11916, 11912, 11898, 11873, 11833, 11778, 11703, 11607, 11487, 11340, 11164, 10956, 10711, 10429, 10104, 9735, 9317, 8844, 8316, 7729, 7073, 6350, 5553, 4673, 3710, 2656, 1504, 248, -1085, -2442, -3805, -5175, -6544, -7903, -9249, -10577, -11877, -13150, -14392, -15593, -16758, -17879, -18955, -19987, -20972, -21908, -22798, -23640, -24434, -25184, -25889, -26547, -27165, -27740, -28274, -28772, -29233, -29657, -30050, -30409, -30738, -31038, -31309, -31554, -31774, -31969, -32141, -32291, -32420, -32526, -32614, -32681, -32729, -32758, -32768, -32761, -32735, -32691, -32629, -32549, -32449, -32331, -32193, -32036, -31858, -31660, -31438, -31194, -30928, -30637, -30319, -29977, -29605, -29204, -28774, -28311, -27815, -27286, -26720, -26115, -25474, -24790, -24064, -23296, -22481, -21620, -20712, -19754, -18745, -17687, -16573, -15406, -14187, -12910, -11578, -10194, -8752, -7256, -5708, -4105, -2456, -718};