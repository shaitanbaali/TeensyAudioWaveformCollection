/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0028 256 samples */
 
const int16_t AKWF_ebass_0028_256_DATA [256] = 
{2019, 5175, 8202, 11139, 13946, 16608, 19089, 21391, 23491, 25372, 27023, 28436, 29608, 30543, 31236, 31690, 31912, 31908, 31685, 31251, 30611, 29772, 28746, 27529, 26122, 24535, 22762, 20810, 18698, 16398, 13934, 11309, 8527, 5617, 2592, -558, -3772, -7036, -10317, -13534, -16683, -19700, -22517, -25081, -27342, -29256, -30780, -31884, -32547, -32775, -32573, -31971, -31002, -29713, -28165, -26401, -24465, -22418, -20285, -18105, -15915, -13689, -11455, -9209, -6939, -4651, -2339, 24, 2417, 4843, 7295, 9726, 12156, 14550, 16864, 19083, 21169, 23079, 24811, 26313, 27554, 28516, 29169, 29492, 29476, 29113, 28397, 27333, 25947, 24243, 22248, 19998, 17522, 14867, 12063, 9138, 6134, 3105, 88, -2922, -5856, -8697, -11423, -13981, -16386, -18614, -20632, -22437, -24013, -25344, -26444, -27291, -27883, -28219, -28302, -28135, -27719, -27061, -26166, -25043, -23711, -22162, -20420, -18498, -16410, -14182, -11826, -9358, -6797, -4175, -1507, 1175, 3871, 6550, 9194, 11768, 14252, 16629, 18873, 20964, 22874, 24580, 26055, 27303, 28292, 29023, 29482, 29671, 29590, 29245, 28645, 27804, 26743, 25469, 24011, 22395, 20638, 18776, 16829, 14811, 12744, 10655, 8549, 6448, 4341, 2239, 147, -1928, -3976, -5991, -7966, -9877, -11702, -13413, -14979, -16392, -17614, -18632, -19430, -19999, -20341, -20462, -20370, -20075, -19591, -18938, -18113, -17134, -16002, -14715, -13282, -11709, -9983, -8124, -6145, -4058, -1916, 279, 2486, 4655, 6741, 8709, 10521, 12135, 13520, 14643, 15484, 16042, 16304, 16282, 15985, 15439, 14667, 13695, 12563, 11293, 9923, 8489, 6984, 5438, 3859, 2238, 588, -1105, -2870, -4693, -6588, -8558, -10579, -12656, -14769, -16877, -18955, -20964, -22848, -24592, -26140, -27449, -28493, -29237, -29659, -29744, -29481, -28870, -27911, -26629, -25022, -23117, -20942, -18547, -15925, -13133, -10204, -7175, -4093, -931};