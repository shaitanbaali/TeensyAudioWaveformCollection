/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0021 256 samples */
 
const int16_t AKWF_ebass_0021_256_DATA [256] = 
{534, 1385, 2206, 3017, 3814, 4598, 5370, 6127, 6870, 7600, 8314, 9014, 9700, 10369, 11024, 11665, 12288, 12897, 13492, 14069, 14632, 15179, 15711, 16228, 16730, 17216, 17689, 18146, 18587, 19015, 19429, 19827, 20211, 20580, 20934, 21275, 21601, 21911, 22208, 22488, 22755, 23007, 23244, 23465, 23672, 23863, 24040, 24203, 24350, 24483, 24602, 24706, 24798, 24875, 24938, 24988, 25026, 25049, 25060, 25056, 25037, 25005, 24958, 24896, 24820, 24728, 24621, 24499, 24365, 24217, 24055, 23883, 23699, 23506, 23303, 23092, 22873, 22647, 22414, 22173, 21927, 21674, 21414, 21148, 20875, 20594, 20307, 20014, 19714, 19408, 19096, 18779, 18458, 18134, 17807, 17482, 17155, 16831, 16510, 16195, 15887, 15586, 15292, 15010, 14736, 14472, 14219, 13977, 13744, 13524, 13314, 13114, 12926, 12749, 12585, 12432, 12292, 12167, 12056, 11960, 11880, 11816, 11768, 11737, 11722, 11723, 11739, 11769, 11811, 11865, 11928, 11997, 12071, 12145, 12219, 12288, 12349, 12399, 12434, 12452, 12451, 12425, 12376, 12298, 12189, 12048, 11871, 11657, 11402, 11103, 10761, 10372, 9937, 9456, 8928, 8354, 7734, 7068, 6361, 5611, 4821, 3995, 3135, 2241, 1321, 374, -598, -1586, -2594, -3616, -4647, -5689, -6737, -7786, -8838, -9889, -10933, -11974, -13008, -14029, -15040, -16038, -17019, -17986, -18933, -19860, -20768, -21651, -22510, -23345, -24152, -24932, -25683, -26401, -27087, -27741, -28359, -28941, -29487, -29993, -30461, -30888, -31274, -31617, -31917, -32173, -32384, -32550, -32669, -32742, -32768, -32747, -32677, -32558, -32393, -32177, -31912, -31599, -31237, -30828, -30370, -29864, -29312, -28715, -28072, -27387, -26660, -25896, -25101, -24276, -23425, -22553, -21663, -20754, -19834, -18902, -17959, -17011, -16055, -15096, -14137, -13174, -12213, -11257, -10301, -9351, -8408, -7470, -6540, -5620, -4707, -3805, -2914, -2032, -1164, -290};