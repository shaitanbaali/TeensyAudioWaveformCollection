/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0001 256 samples */
 
const int16_t AKWF_ebass_0001_256_DATA [256] = 
{502, 2051, 3573, 5092, 6592, 8067, 9504, 10898, 12254, 13579, 14873, 16149, 17405, 18637, 19849, 21027, 22157, 23237, 24251, 25191, 26058, 26856, 27591, 28278, 28928, 29550, 30150, 30723, 31254, 31725, 32121, 32427, 32635, 32746, 32765, 32705, 32584, 32422, 32237, 32044, 31845, 31631, 31388, 31096, 30738, 30311, 29810, 29237, 28600, 27904, 27166, 26399, 25610, 24805, 23982, 23130, 22241, 21312, 20338, 19328, 18293, 17241, 16188, 15146, 14119, 13117, 12135, 11168, 10208, 9234, 8231, 7192, 6110, 4990, 3851, 2705, 1571, 465, -599, -1611, -2561, -3444, -4256, -4995, -5670, -6285, -6843, -7353, -7811, -8218, -8579, -8896, -9170, -9408, -9612, -9781, -9917, -10018, -10085, -10111, -10094, -10022, -9889, -9692, -9431, -9110, -8733, -8315, -7868, -7417, -6985, -6597, -6280, -6050, -5928, -5921, -6039, -6281, -6644, -7123, -7704, -8375, -9121, -9927, -10785, -11687, -12630, -13612, -14635, -15693, -16785, -17910, -19054, -20216, -21387, -22551, -23695, -24800, -25842, -26805, -27664, -28400, -28995, -29430, -29687, -29750, -29605, -29244, -28661, -27855, -26833, -25595, -24157, -22534, -20734, -18781, -16695, -14491, -12197, -9833, -7413, -4968, -2510, -55, 2364, 4738, 7043, 9251, 11353, 13330, 15166, 16856, 18390, 19757, 20958, 21986, 22835, 23507, 23998, 24307, 24435, 24386, 24159, 23763, 23205, 22498, 21642, 20652, 19532, 18288, 16935, 15481, 13933, 12314, 10627, 8883, 7101, 5282, 3437, 1579, -285, -2145, -3983, -5799, -7579, -9312, -11002, -12639, -14216, -15738, -17197, -18585, -19908, -21157, -22325, -23411, -24407, -25308, -26114, -26823, -27435, -27950, -28369, -28696, -28933, -29080, -29136, -29101, -28971, -28747, -28428, -28022, -27531, -26963, -26326, -25622, -24855, -24028, -23137, -22180, -21157, -20062, -18902, -17681, -16405, -15089, -13746, -12378, -10996, -9603, -8187, -6753, -5295, -3809, -2290, -799};