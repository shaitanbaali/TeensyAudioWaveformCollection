/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0054 256 samples */
 
const int16_t AKWF_ebass_0054_256_DATA [256] = 
{426, 1318, 2313, 3125, 3591, 3802, 3977, 4267, 4667, 5089, 5402, 5655, 5907, 6213, 6546, 6911, 7341, 7857, 8428, 9009, 9525, 10011, 10495, 10980, 11310, 11369, 11083, 10585, 10084, 9750, 9598, 9527, 9420, 9309, 9283, 9393, 9599, 9801, 9985, 10204, 10417, 10502, 10308, 9896, 9498, 9372, 9501, 9656, 9721, 9794, 9979, 10271, 10512, 10514, 10392, 10413, 10681, 11056, 11319, 11467, 11754, 12252, 12807, 13170, 13329, 13544, 14024, 14689, 15248, 15515, 15615, 15866, 16361, 16961, 17523, 18011, 18505, 18918, 19026, 18703, 18150, 17674, 17449, 17332, 17170, 16896, 16580, 16276, 15924, 15421, 14758, 14122, 13579, 12945, 11987, 10664, 9131, 7571, 6058, 4542, 2977, 1399, -237, -2014, -4034, -6259, -8452, -10405, -12049, -13526, -15019, -16583, -18169, -19731, -21240, -22672, -23996, -25187, -26295, -27407, -28546, -29652, -30662, -31457, -32014, -32358, -32559, -32684, -32751, -32757, -32679, -32508, -32216, -31796, -31250, -30551, -29684, -28673, -27553, -26288, -24922, -23520, -22079, -20610, -19116, -17595, -16089, -14650, -13303, -12003, -10629, -9177, -7685, -6103, -4376, -2540, -700, 1078, 2737, 4316, 5920, 7503, 8939, 10150, 11160, 12039, 12797, 13399, 13820, 14131, 14448, 14871, 15351, 15763, 16042, 16222, 16348, 16435, 16474, 16463, 16409, 16285, 15990, 15418, 14560, 13535, 12466, 11464, 10573, 9763, 9009, 8248, 7405, 6499, 5605, 4807, 4134, 3492, 2722, 1761, 617, -664, -2022, -3383, -4622, -5630, -6448, -7136, -7756, -8333, -8869, -9365, -9832, -10325, -10788, -11189, -11568, -12023, -12546, -13092, -13626, -14078, -14382, -14491, -14341, -13927, -13360, -12879, -12654, -12625, -12571, -12321, -11883, -11372, -10970, -10720, -10600, -10547, -10535, -10412, -9977, -9162, -8145, -7235, -6669, -6411, -6175, -5699, -4958, -4092, -3241, -2452, -1733, -1144, -678, -184};