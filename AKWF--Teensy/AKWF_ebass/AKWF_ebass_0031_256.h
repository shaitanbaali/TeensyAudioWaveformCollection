/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0031 256 samples */
 
const int16_t AKWF_ebass_0031_256_DATA [256] = 
{632, 1873, 3077, 4270, 5432, 6573, 7686, 8762, 9804, 10810, 11770, 12697, 13587, 14433, 15240, 16001, 16713, 17379, 17988, 18534, 19011, 19407, 19715, 19926, 20029, 20018, 19885, 19625, 19237, 18716, 18070, 17304, 16418, 15432, 14356, 13205, 12006, 10771, 9518, 8278, 7072, 5921, 4855, 3878, 3016, 2283, 1687, 1236, 932, 770, 747, 855, 1080, 1404, 1814, 2293, 2820, 3375, 3939, 4495, 5027, 5526, 5976, 6369, 6702, 6977, 7195, 7363, 7497, 7606, 7707, 7822, 7968, 8165, 8430, 8786, 9243, 9812, 10506, 11321, 12266, 13341, 14537, 15841, 17248, 18727, 20276, 21866, 23466, 25046, 26568, 27998, 29305, 30449, 31396, 32112, 32575, 32769, 32679, 32301, 31640, 30712, 29530, 28120, 26506, 24724, 22806, 20794, 18696, 16558, 14392, 12228, 10097, 8003, 5955, 3984, 2091, 296, -1372, -2929, -4346, -5610, -6707, -7620, -8341, -8865, -9182, -9289, -9187, -8878, -8372, -7679, -6816, -5802, -4653, -3390, -2035, -611, 856, 2344, 3846, 5332, 6791, 8207, 9558, 10838, 12043, 13151, 14159, 15057, 15828, 16479, 16998, 17375, 17608, 17690, 17615, 17382, 16988, 16431, 15708, 14832, 13796, 12602, 11269, 9796, 8199, 6502, 4693, 2804, 852, -1155, -3183, -5224, -7273, -9298, -11277, -13201, -15064, -16836, -18515, -20087, -21524, -22846, -24033, -25083, -25998, -26777, -27420, -27944, -28354, -28661, -28880, -29021, -29105, -29145, -29155, -29151, -29145, -29148, -29169, -29214, -29284, -29384, -29513, -29662, -29831, -30007, -30184, -30349, -30492, -30605, -30675, -30696, -30659, -30555, -30385, -30143, -29825, -29435, -28979, -28456, -27872, -27237, -26556, -25842, -25104, -24352, -23593, -22834, -22088, -21364, -20652, -19966, -19302, -18658, -18030, -17412, -16791, -16159, -15512, -14834, -14124, -13367, -12560, -11699, -10784, -9818, -8796, -7725, -6606, -5449, -4261, -3056, -1826, -561};