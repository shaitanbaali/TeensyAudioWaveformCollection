/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0008 256 samples */
 
const int16_t AKWF_ebass_0008_256_DATA [256] = 
{391, 1929, 3603, 5249, 6719, 7959, 9040, 10144, 11440, 12848, 14166, 15314, 16352, 17362, 18424, 19546, 20645, 21627, 22484, 23306, 24179, 25100, 26007, 26831, 27529, 28120, 28678, 29254, 29806, 30251, 30578, 30835, 31083, 31339, 31593, 31848, 32049, 32063, 31843, 31508, 31196, 30979, 30918, 31039, 31216, 31182, 30755, 30015, 29201, 28441, 27782, 27298, 26947, 26549, 26025, 25496, 25058, 24626, 24014, 23189, 22277, 21332, 20334, 19399, 18696, 18200, 17748, 17268, 16783, 16201, 15353, 14184, 12844, 11494, 10180, 8948, 7962, 7354, 7101, 7113, 7257, 7368, 7244, 6676, 5622, 4182, 2476, 692, -863, -1965, -2609, -2914, -2955, -2761, -2461, -2281, -2373, -2712, -3228, -3881, -4583, -5189, -5576, -5669, -5462, -5008, -4439, -3995, -3916, -4280, -4995, -5922, -6968, -8001, -8816, -9255, -9258, -8837, -8132, -7409, -6917, -6786, -7066, -7786, -8940, -10465, -12159, -13811, -15348, -16788, -18166, -19503, -20823, -22185, -23633, -25158, -26749, -28326, -29721, -30863, -31751, -32382, -32718, -32749, -32567, -32293, -32031, -31826, -31658, -31461, -31155, -30644, -29874, -28821, -27420, -25612, -23380, -20795, -17998, -15057, -12001, -8911, -5836, -2827, 14, 2626, 5027, 7283, 9439, 11456, 13300, 14960, 16393, 17606, 18697, 19729, 20643, 21324, 21722, 21852, 21796, 21638, 21377, 20938, 20248, 19308, 18179, 16973, 15748, 14433, 12939, 11253, 9472, 7676, 5868, 4065, 2270, 426, -1496, -3437, -5324, -7147, -8927, -10653, -12304, -13908, -15523, -17127, -18657, -20042, -21238, -22281, -23263, -24260, -25287, -26276, -27096, -27679, -28084, -28440, -28867, -29359, -29763, -29925, -29816, -29547, -29289, -29125, -28985, -28746, -28301, -27619, -26808, -26043, -25382, -24713, -23925, -23005, -21985, -20897, -19779, -18665, -17564, -16415, -15176, -13936, -12756, -11559, -10276, -8933, -7577, -6201, -4777, -3367, -2020, -771};