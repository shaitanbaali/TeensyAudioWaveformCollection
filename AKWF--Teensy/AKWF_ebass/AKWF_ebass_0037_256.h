/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0037 256 samples */
 
const int16_t AKWF_ebass_0037_256_DATA [256] = 
{974, 2982, 4942, 6886, 8749, 10567, 12307, 13992, 15547, 16974, 18294, 19515, 20668, 21831, 22898, 23931, 24922, 25877, 26896, 27839, 28770, 29646, 30405, 31040, 31615, 32080, 32393, 32609, 32744, 32745, 32670, 32448, 32243, 31846, 31380, 30805, 30173, 29444, 28515, 27474, 26269, 24954, 23648, 22279, 20808, 19321, 17664, 15914, 14157, 12371, 10702, 9049, 7395, 5875, 4387, 3076, 1803, 562, -481, -1476, -2372, -3207, -3954, -4594, -5186, -5685, -6098, -6465, -6774, -7034, -7198, -7326, -7408, -7423, -7429, -7379, -7319, -7214, -7239, -7277, -7236, -7117, -7029, -6805, -6538, -6281, -6008, -5641, -5272, -4944, -4645, -4253, -3859, -3440, -2927, -2524, -2235, -1938, -1714, -1454, -1093, -703, -225, 215, 545, 890, 1127, 1263, 1348, 1424, 1522, 1670, 1836, 1993, 2186, 2334, 2473, 2521, 2507, 2365, 2135, 1864, 1656, 1539, 1578, 1757, 2017, 2314, 2523, 2626, 2687, 2608, 2552, 2512, 2525, 2522, 2517, 2526, 2442, 2270, 1968, 1644, 1328, 1000, 816, 653, 556, 525, 438, 332, 163, -36, -264, -471, -597, -706, -817, -909, -1098, -1369, -1773, -2210, -2719, -3208, -3605, -3967, -4233, -4456, -4671, -4945, -5301, -5770, -6307, -6901, -7485, -8031, -8525, -8980, -9425, -9868, -10352, -10957, -11605, -12385, -13152, -13861, -14542, -15147, -15637, -16098, -16509, -16942, -17410, -17911, -18476, -19058, -19591, -20082, -20518, -20905, -21273, -21611, -21984, -22389, -22814, -23245, -23660, -24024, -24341, -24587, -24749, -24839, -24940, -25018, -25089, -25159, -25220, -25218, -25222, -25211, -25106, -25006, -24955, -25058, -25083, -25140, -25203, -25254, -25306, -25346, -25299, -25192, -25044, -24874, -24634, -24357, -24052, -23615, -23093, -22448, -21726, -20879, -19936, -18881, -17673, -16389, -15078, -13701, -12326, -10892, -9332, -7812, -6203, -4525, -2794, -896};