/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0047 256 samples */
 
const int16_t AKWF_ebass_0047_256_DATA [256] = 
{439, 1489, 2506, 3436, 4397, 5230, 6052, 6761, 7414, 8027, 8447, 8711, 9048, 9209, 9348, 9391, 9341, 9351, 9219, 9085, 8970, 8765, 8546, 8340, 8203, 7980, 7682, 7385, 7009, 6639, 6255, 5753, 5293, 4861, 4367, 3948, 3367, 2936, 2401, 1908, 1492, 1094, 729, 329, 67, -306, -594, -903, -1285, -1556, -1850, -2103, -2263, -2585, -2750, -3038, -3279, -3460, -3558, -3763, -3818, -3839, -3873, -3853, -3847, -3739, -3587, -3345, -3125, -2823, -2510, -2079, -1742, -1281, -882, -443, -2, 421, 741, 1073, 1310, 1619, 1850, 2149, 2547, 2850, 3154, 3573, 4014, 4321, 4656, 4999, 5317, 5579, 5833, 6005, 6044, 6052, 5915, 5660, 5409, 5080, 4707, 4317, 3831, 3271, 2713, 2117, 1573, 1050, 464, -74, -687, -1316, -1893, -2472, -3043, -3683, -4321, -5016, -5730, -6406, -7157, -7934, -8592, -9274, -9965, -10516, -11046, -11497, -11963, -12240, -12416, -12612, -12710, -12774, -12787, -12855, -12807, -12778, -12762, -12733, -12653, -12538, -12471, -12362, -12220, -12067, -11843, -11620, -11354, -11011, -10648, -10324, -9952, -9524, -9151, -8688, -8289, -7903, -7510, -7154, -6855, -6616, -6468, -6283, -6185, -6063, -6013, -5931, -5881, -5822, -5729, -5663, -5548, -5480, -5467, -5455, -5535, -5756, -5978, -6285, -6689, -7137, -7655, -8283, -8952, -9582, -10251, -10922, -11552, -12202, -12899, -13657, -14340, -15119, -15949, -16745, -17664, -18577, -19516, -20537, -21571, -22575, -23617, -24657, -25733, -26688, -27628, -28515, -29316, -30037, -30585, -31074, -31551, -31880, -32148, -32365, -32542, -32589, -32699, -32764, -32697, -32582, -32466, -32290, -32084, -31717, -31284, -30807, -30205, -29359, -28471, -27510, -26470, -25370, -24086, -22902, -21581, -20276, -18931, -17524, -16193, -14854, -13496, -12240, -10996, -9762, -8518, -7332, -6176, -4975, -3873, -2689, -1649, -600};