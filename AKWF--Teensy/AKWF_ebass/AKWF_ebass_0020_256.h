/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0020 256 samples */
 
const int16_t AKWF_ebass_0020_256_DATA [256] = 
{859, 2147, 3420, 4705, 5994, 7286, 8579, 9864, 11145, 12418, 13675, 14919, 16146, 17350, 18534, 19692, 20818, 21917, 22982, 24007, 24998, 25945, 26845, 27701, 28502, 29247, 29935, 30558, 31112, 31595, 32001, 32326, 32565, 32714, 32769, 32726, 32581, 32330, 31968, 31493, 30902, 30188, 29355, 28397, 27322, 26147, 24875, 23519, 22093, 20601, 19055, 17470, 15846, 14196, 12531, 10851, 9169, 7492, 5819, 4163, 2529, 916, -664, -2208, -3716, -5176, -6588, -7949, -9249, -10489, -11667, -12775, -13815, -14782, -15671, -16484, -17217, -17866, -18433, -18914, -19306, -19612, -19830, -19960, -20003, -19960, -19836, -19631, -19350, -18996, -18575, -18090, -17549, -16955, -16317, -15642, -14938, -14215, -13479, -12735, -11993, -11255, -10526, -9812, -9115, -8437, -7784, -7156, -6552, -5979, -5432, -4912, -4421, -3955, -3512, -3091, -2688, -2297, -1917, -1543, -1171, -798, -418, -31, 365, 778, 1202, 1643, 2101, 2575, 3064, 3571, 4092, 4629, 5179, 5741, 6315, 6899, 7492, 8093, 8699, 9308, 9920, 10530, 11135, 11731, 12315, 12881, 13425, 13943, 14428, 14878, 15287, 15652, 15970, 16236, 16448, 16605, 16701, 16739, 16714, 16627, 16477, 16262, 15985, 15644, 15239, 14774, 14248, 13664, 13030, 12346, 11617, 10850, 10045, 9208, 8346, 7461, 6557, 5644, 4719, 3792, 2869, 1946, 1034, 134, -754, -1626, -2479, -3315, -4129, -4920, -5692, -6441, -7167, -7875, -8560, -9226, -9872, -10498, -11107, -11697, -12266, -12816, -13347, -13855, -14342, -14808, -15250, -15672, -16071, -16450, -16808, -17147, -17468, -17771, -18056, -18325, -18575, -18808, -19020, -19211, -19379, -19521, -19635, -19718, -19767, -19781, -19755, -19687, -19574, -19415, -19205, -18943, -18627, -18254, -17822, -17330, -16778, -16169, -15507, -14788, -14019, -13203, -12338, -11431, -10482, -9491, -8462, -7398, -6298, -5167, -4007, -2820, -1613, -357};