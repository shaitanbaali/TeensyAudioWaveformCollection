/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0041 256 samples */
 
const int16_t AKWF_ebass_0041_256_DATA [256] = 
{394, 1651, 2634, 3389, 4004, 4602, 5248, 5960, 6790, 7772, 8934, 10195, 11529, 12948, 14350, 15616, 16682, 17626, 18438, 19104, 19690, 20340, 21059, 21858, 22791, 23878, 24993, 26050, 27001, 27933, 28828, 29546, 30004, 30146, 30013, 29538, 28671, 27451, 25941, 24298, 22545, 20520, 18349, 16083, 13862, 11700, 9605, 7674, 5967, 4448, 3104, 1865, 707, -378, -1368, -2215, -2926, -3561, -4062, -4408, -4642, -4858, -5127, -5433, -5750, -6019, -6242, -6405, -6498, -6500, -6460, -6266, -5964, -5638, -5418, -5314, -5249, -5157, -4971, -4697, -4349, -3923, -3513, -3144, -2881, -2702, -2490, -2247, -2033, -1893, -1864, -1895, -1898, -1825, -1580, -1205, -756, -239, 214, 472, 526, 417, 299, 185, 120, 75, 5, -60, -123, -175, -226, -270, -274, -246, -160, -76, -12, -20, -92, -235, -407, -703, -1061, -1515, -2059, -2615, -3086, -3415, -3620, -3723, -3779, -3883, -4080, -4429, -4867, -5311, -5699, -6035, -6330, -6609, -6878, -7079, -7178, -7187, -7131, -7059, -6990, -6974, -7021, -7099, -7168, -7138, -6993, -6767, -6476, -6190, -5924, -5683, -5470, -5260, -5001, -4665, -4270, -3863, -3491, -3267, -3246, -3378, -3581, -3732, -3750, -3611, -3339, -2994, -2647, -2340, -2078, -1869, -1649, -1402, -1143, -932, -768, -657, -549, -437, -333, -192, 26, 346, 717, 1088, 1454, 1779, 2076, 2327, 2461, 2485, 2434, 2379, 2310, 2189, 2017, 1848, 1690, 1542, 1327, 1031, 576, -42, -775, -1600, -2507, -3487, -4573, -5747, -6951, -8162, -9329, -10420, -11396, -12277, -13178, -14174, -15345, -16708, -18195, -19752, -21354, -22941, -24509, -26024, -27467, -28907, -30299, -31522, -32379, -32762, -32614, -31925, -30761, -29164, -27269, -25254, -23228, -21209, -19172, -17103, -14973, -12797, -10684, -8618, -6590, -4632, -2773, -1049};