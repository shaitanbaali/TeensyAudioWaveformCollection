/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0012 256 samples */
 
const int16_t AKWF_ebass_0012_256_DATA [256] = 
{1156, 4554, 7703, 10610, 13229, 15556, 17618, 19445, 21089, 22593, 23987, 25313, 26594, 27829, 29000, 30067, 30989, 31742, 32298, 32644, 32770, 32664, 32322, 31744, 30955, 29993, 28908, 27759, 26575, 25339, 24032, 22626, 21115, 19521, 17860, 16150, 14417, 12666, 10919, 9209, 7553, 5975, 4499, 3125, 1852, 667, -462, -1558, -2633, -3706, -4784, -5879, -7006, -8159, -9312, -10435, -11470, -12356, -13047, -13518, -13801, -13965, -14086, -14219, -14391, -14606, -14865, -15171, -15519, -15885, -16220, -16470, -16594, -16569, -16414, -16179, -15944, -15780, -15721, -15764, -15861, -15961, -16013, -15989, -15870, -15643, -15301, -14846, -14305, -13728, -13193, -12784, -12574, -12598, -12837, -13215, -13628, -13978, -14186, -14215, -14059, -13736, -13291, -12791, -12314, -11942, -11749, -11783, -12050, -12510, -13071, -13611, -14000, -14141, -13984, -13551, -12923, -12217, -11569, -11089, -10853, -10885, -11160, -11613, -12146, -12646, -12992, -13075, -12810, -12175, -11218, -10037, -8785, -7620, -6676, -6027, -5669, -5539, -5534, -5540, -5458, -5211, -4743, -4034, -3097, -1984, -797, 335, 1300, 1999, 2404, 2547, 2519, 2445, 2442, 2601, 2981, 3605, 4457, 5495, 6656, 7843, 8968, 9935, 10657, 11076, 11175, 10980, 10568, 10035, 9477, 8970, 8565, 8289, 8145, 8123, 8206, 8378, 8620, 8917, 9265, 9661, 10103, 10592, 11114, 11641, 12139, 12560, 12870, 13037, 13049, 12910, 12635, 12248, 11789, 11298, 10824, 10415, 10116, 9960, 9958, 10107, 10387, 10791, 11322, 11970, 12716, 13512, 14281, 14936, 15387, 15563, 15422, 14948, 14139, 12991, 11516, 9746, 7736, 5575, 3402, 1341, -505, -2093, -3418, -4515, -5454, -6313, -7166, -8079, -9100, -10244, -11506, -12843, -14185, -15454, -16591, -17566, -18382, -19046, -19594, -20065, -20472, -20799, -20993, -20987, -20708, -20089, -19073, -17609, -15676, -13312, -10596, -7636, -4561, -1444};