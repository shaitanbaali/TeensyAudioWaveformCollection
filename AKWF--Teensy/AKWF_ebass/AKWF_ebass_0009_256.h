/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0009 256 samples */
 
const int16_t AKWF_ebass_0009_256_DATA [256] = 
{2197, 6471, 10501, 14264, 17706, 20810, 23536, 25874, 27886, 29587, 30930, 31887, 32481, 32744, 32734, 32525, 32171, 31646, 30867, 29771, 28358, 26696, 24886, 22970, 20954, 18832, 16587, 14237, 11814, 9359, 6947, 4620, 2365, 155, -2066, -4319, -6578, -8815, -10979, -13007, -14863, -16530, -18005, -19339, -20587, -21780, -22914, -23933, -24776, -25451, -26000, -26439, -26753, -26930, -26992, -26973, -26909, -26832, -26752, -26628, -26388, -25993, -25456, -24813, -24106, -23402, -22769, -22223, -21691, -21037, -20173, -19105, -17877, -16550, -15201, -13899, -12668, -11513, -10442, -9450, -8489, -7474, -6371, -5205, -4008, -2779, -1491, -151, 1166, 2374, 3418, 4298, 5076, 5881, 6832, 7955, 9186, 10455, 11749, 13022, 14160, 15052, 15636, 15949, 16120, 16340, 16797, 17581, 18622, 19759, 20859, 21840, 22630, 23122, 23236, 23011, 22604, 22214, 22035, 22204, 22716, 23438, 24199, 24847, 25252, 25297, 24937, 24221, 23244, 22136, 21070, 20257, 19868, 19959, 20468, 21226, 21957, 22306, 21975, 20856, 19089, 16977, 14839, 12948, 11488, 10567, 10264, 10589, 11444, 12526, 13358, 13488, 12704, 11102, 9027, 6903, 5029, 3499, 2301, 1442, 989, 944, 1121, 1201, 879, 8, -1334, -2876, -4294, -5353, -5965, -6154, -5985, -5580, -5114, -4747, -4608, -4838, -5597, -6954, -8795, -10819, -12658, -13999, -14635, -14560, -13956, -13075, -12096, -11052, -9939, -8807, -7760, -6922, -6384, -6152, -6104, -6028, -5790, -5426, -5057, -4776, -4621, -4552, -4466, -4253, -3914, -3535, -3126, -2559, -1681, -477, 915, 2288, 3496, 4467, 5151, 5468, 5279, 4459, 2959, 852, -1671, -4402, -7143, -9804, -12323, -14617, -16592, -18187, -19367, -20146, -20603, -20867, -21101, -21474, -22069, -22871, -23792, -24706, -25537, -26258, -26833, -27243, -27422, -27250, -26629, -25500, -23850, -21731, -19225, -16433, -13377, -10011, -6329, -2298};