/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0057 256 samples */
 
const int16_t AKWF_ebass_0057_256_DATA [256] = 
{389, 1653, 2815, 3929, 4990, 5997, 6960, 7870, 8735, 9557, 10334, 11066, 11758, 12404, 13012, 13583, 14111, 14604, 15062, 15485, 15875, 16236, 16568, 16869, 17149, 17400, 17630, 17835, 18019, 18181, 18320, 18440, 18540, 18622, 18687, 18733, 18761, 18775, 18773, 18756, 18722, 18675, 18615, 18544, 18458, 18361, 18256, 18140, 18016, 17887, 17749, 17605, 17457, 17304, 17146, 16986, 16819, 16652, 16479, 16305, 16129, 15949, 15765, 15578, 15387, 15192, 14995, 14794, 14590, 14379, 14167, 13948, 13731, 13508, 13281, 13054, 12827, 12598, 12368, 12141, 11910, 11683, 11456, 11228, 11001, 10768, 10534, 10292, 10046, 9795, 9532, 9264, 8992, 8712, 8431, 8144, 7859, 7576, 7298, 7025, 6758, 6501, 6247, 6006, 5771, 5544, 5326, 5109, 4898, 4695, 4493, 4291, 4095, 3897, 3699, 3502, 3302, 3105, 2912, 2721, 2533, 2357, 2188, 2035, 1896, 1772, 1667, 1584, 1523, 1480, 1458, 1455, 1472, 1503, 1548, 1610, 1679, 1762, 1854, 1954, 2063, 2183, 2315, 2456, 2609, 2777, 2961, 3160, 3378, 3608, 3857, 4120, 4395, 4680, 4978, 5281, 5587, 5888, 6183, 6465, 6726, 6965, 7176, 7351, 7490, 7584, 7631, 7632, 7578, 7470, 7307, 7088, 6809, 6477, 6082, 5627, 5107, 4521, 3858, 3123, 2305, 1404, 411, -668, -1806, -2998, -4247, -5530, -6847, -8191, -9551, -10918, -12286, -13649, -14990, -16317, -17610, -18870, -20092, -21267, -22397, -23478, -24500, -25469, -26382, -27229, -28020, -28753, -29417, -30025, -30570, -31051, -31475, -31838, -32140, -32384, -32566, -32690, -32755, -32762, -32710, -32600, -32432, -32205, -31921, -31576, -31177, -30721, -30210, -29643, -29019, -28344, -27618, -26838, -26010, -25130, -24203, -23231, -22210, -21144, -20039, -18889, -17698, -16477, -15215, -13923, -12606, -11255, -9887, -8506, -7100, -5685, -4279, -2781, -1888, -777};