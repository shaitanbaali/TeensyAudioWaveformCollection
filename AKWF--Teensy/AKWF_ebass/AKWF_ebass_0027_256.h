/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0027 256 samples */
 
const int16_t AKWF_ebass_0027_256_DATA [256] = 
{566, 1482, 2462, 3520, 4672, 5913, 7246, 8637, 10062, 11483, 12883, 14245, 15548, 16779, 17945, 19022, 19992, 20816, 21460, 21919, 22221, 22411, 22521, 22559, 22512, 22363, 22120, 21812, 21494, 21208, 20987, 20841, 20770, 20769, 20833, 20962, 21155, 21409, 21710, 22021, 22291, 22473, 22572, 22652, 22805, 23055, 23359, 23614, 23737, 23713, 23594, 23474, 23427, 23493, 23660, 23894, 24133, 24327, 24451, 24518, 24567, 24654, 24815, 25057, 25346, 25638, 25892, 26092, 26242, 26357, 26455, 26546, 26632, 26701, 26736, 26711, 26605, 26412, 26140, 25806, 25433, 25024, 24582, 24100, 23563, 22973, 22328, 21616, 20857, 20063, 19243, 18416, 17568, 16696, 15804, 14899, 13998, 13114, 12222, 11322, 10419, 9528, 8671, 7843, 7014, 6168, 5299, 4401, 3490, 2549, 1566, 527, -554, -1682, -2824, -3966, -5128, -6324, -7572, -8897, -10273, -11672, -13072, -14429, -15745, -17035, -18305, -19576, -20850, -22109, -23356, -24554, -25676, -26710, -27655, -28526, -29340, -30093, -30772, -31362, -31844, -32216, -32484, -32659, -32751, -32765, -32689, -32518, -32253, -31906, -31499, -31054, -30589, -30117, -29630, -29131, -28620, -28112, -27625, -27175, -26774, -26435, -26159, -25922, -25705, -25484, -25259, -25044, -24852, -24672, -24463, -24177, -23785, -23285, -22714, -22115, -21510, -20887, -20207, -19449, -18626, -17774, -16931, -16113, -15308, -14517, -13736, -12978, -12252, -11545, -10854, -10196, -9596, -9076, -8632, -8230, -7858, -7518, -7229, -7014, -6872, -6796, -6783, -6829, -6936, -7081, -7229, -7349, -7446, -7555, -7702, -7898, -8119, -8324, -8490, -8610, -8691, -8732, -8719, -8642, -8496, -8302, -8084, -7856, -7601, -7295, -6929, -6507, -6063, -5618, -5177, -4734, -4291, -3871, -3520, -3263, -3084, -2942, -2792, -2624, -2473, -2391, -2403, -2491, -2608, -2701, -2742, -2731, -2685, -2602, -2471, -2262, -1950, -1509, -935, -215};