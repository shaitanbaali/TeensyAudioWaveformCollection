/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0070 256 samples */
 
const int16_t AKWF_ebass_0070_256_DATA [256] = 
{400, 1413, 2413, 3428, 4455, 5498, 6552, 7595, 8607, 9569, 10471, 11315, 12102, 12843, 13558, 14258, 14940, 15592, 16190, 16726, 17203, 17622, 17994, 18342, 18679, 19007, 19317, 19597, 19839, 20044, 20212, 20354, 20483, 20599, 20693, 20759, 20795, 20800, 20777, 20743, 20715, 20705, 20720, 20763, 20840, 20939, 21048, 21157, 21270, 21395, 21537, 21711, 21925, 22172, 22435, 22700, 22955, 23195, 23429, 23667, 23910, 24153, 24388, 24607, 24803, 24975, 25127, 25253, 25350, 25418, 25457, 25458, 25405, 25289, 25109, 24856, 24531, 24149, 23718, 23243, 22720, 22142, 21500, 20783, 19988, 19124, 18199, 17219, 16201, 15158, 14086, 12986, 11863, 10717, 9553, 8377, 7201, 6042, 4906, 3793, 2719, 1686, 701, -220, -1047, -1768, -2382, -2895, -3305, -3628, -3882, -4081, -4237, -4360, -4455, -4530, -4591, -4646, -4710, -4806, -4951, -5143, -5376, -5650, -5958, -6294, -6645, -7015, -7414, -7839, -8291, -8769, -9276, -9806, -10353, -10912, -11481, -12064, -12661, -13280, -13920, -14579, -15258, -15941, -16619, -17292, -17961, -18627, -19295, -19973, -20656, -21338, -22011, -22666, -23306, -23923, -24521, -25110, -25688, -26252, -26806, -27349, -27878, -28389, -28876, -29336, -29766, -30164, -30537, -30881, -31196, -31482, -31738, -31964, -32158, -32325, -32470, -32587, -32678, -32739, -32767, -32759, -32717, -32642, -32540, -32412, -32258, -32081, -31879, -31650, -31391, -31100, -30774, -30415, -30023, -29595, -29136, -28644, -28113, -27544, -26935, -26295, -25633, -24955, -24270, -23583, -22889, -22185, -21467, -20725, -19970, -19217, -18473, -17749, -17054, -16382, -15735, -15107, -14501, -13925, -13380, -12869, -12401, -11972, -11569, -11196, -10865, -10579, -10344, -10160, -10023, -9921, -9835, -9748, -9641, -9502, -9333, -9147, -8957, -8775, -8607, -8439, -8249, -8009, -7705, -7331, -6889, -6383, -5833, -5250, -4621, -3940, -3199, -2391, -1517, -560};