/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0015 256 samples */
 
const int16_t AKWF_ebass_0015_256_DATA [256] = 
{426, 1462, 2680, 3840, 4952, 6063, 7125, 8196, 9226, 10260, 11275, 12284, 13283, 14251, 15213, 16155, 17078, 17965, 18828, 19657, 20459, 21222, 21938, 22622, 23254, 23843, 24382, 24869, 25309, 25697, 26027, 26306, 26534, 26705, 26831, 26894, 26913, 26882, 26797, 26673, 26496, 26277, 26006, 25695, 25339, 24932, 24478, 23975, 23430, 22832, 22193, 21514, 20793, 20026, 19216, 18373, 17487, 16570, 15622, 14647, 13651, 12628, 11591, 10541, 9481, 8422, 7362, 6305, 5270, 4244, 3242, 2266, 1317, 412, -455, -1285, -2066, -2794, -3482, -4120, -4700, -5234, -5709, -6137, -6515, -6834, -7101, -7322, -7491, -7609, -7682, -7710, -7696, -7628, -7514, -7348, -7130, -6873, -6559, -6203, -5800, -5346, -4851, -4318, -3742, -3127, -2483, -1798, -1084, -350, 408, 1185, 1979, 2781, 3591, 4396, 5200, 6002, 6789, 7560, 8313, 9048, 9758, 10437, 11088, 11707, 12291, 12840, 13348, 13821, 14249, 14636, 14989, 15296, 15566, 15801, 15994, 16150, 16278, 16371, 16418, 16430, 16413, 16359, 16266, 16136, 15966, 15759, 15516, 15229, 14904, 14537, 14136, 13695, 13211, 12687, 12127, 11526, 10881, 10209, 9494, 8739, 7955, 7139, 6293, 5414, 4515, 3592, 2646, 1683, 708, -279, -1292, -2308, -3337, -4377, -5426, -6483, -7543, -8612, -9674, -10741, -11805, -12867, -13927, -14973, -16022, -17060, -18082, -19098, -20095, -21068, -22025, -22949, -23850, -24721, -25550, -26349, -27109, -27828, -28504, -29134, -29716, -30245, -30727, -31163, -31546, -31872, -32154, -32381, -32555, -32678, -32744, -32767, -32736, -32657, -32520, -32335, -32102, -31814, -31489, -31109, -30690, -30231, -29725, -29178, -28592, -27971, -27310, -26614, -25875, -25102, -24293, -23457, -22586, -21684, -20754, -19798, -18827, -17830, -16828, -15797, -14756, -13711, -12654, -11594, -10521, -9462, -8384, -7321, -6265, -5248, -4228, -3124, -1976, -671};