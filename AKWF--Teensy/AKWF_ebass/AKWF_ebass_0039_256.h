/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0039 256 samples */
 
const int16_t AKWF_ebass_0039_256_DATA [256] = 
{869, 2321, 3727, 5173, 6581, 7952, 9318, 10634, 11933, 13189, 14389, 15618, 16792, 17941, 19054, 20099, 21090, 22054, 22949, 23766, 24509, 25139, 25607, 25961, 26210, 26345, 26359, 26269, 26080, 25795, 25446, 24967, 24418, 23787, 23081, 22289, 21460, 20580, 19652, 18748, 17842, 16939, 16039, 15152, 14324, 13569, 12778, 12071, 11407, 10755, 10116, 9557, 9059, 8571, 8112, 7662, 7240, 6845, 6466, 6148, 5829, 5601, 5411, 5315, 5213, 5078, 5036, 5005, 4932, 4847, 4735, 4614, 4454, 4274, 4092, 3871, 3635, 3379, 3115, 2825, 2517, 2177, 1815, 1440, 1030, 657, 268, -120, -493, -845, -1189, -1566, -1880, -2211, -2553, -2913, -3247, -3601, -3989, -4427, -4879, -5390, -5916, -6437, -7014, -7566, -8076, -8632, -9082, -9438, -9816, -10093, -10305, -10505, -10642, -10773, -10869, -10899, -10936, -10936, -10899, -10793, -10680, -10511, -10347, -10165, -9978, -9817, -9641, -9471, -9306, -9145, -8963, -8771, -8516, -8210, -7884, -7534, -7181, -6855, -6468, -6037, -5677, -5340, -5018, -4738, -4478, -4211, -3979, -3749, -3514, -3259, -2952, -2635, -2278, -1887, -1491, -1053, -626, -249, 93, 405, 689, 933, 1134, 1305, 1422, 1512, 1541, 1553, 1535, 1451, 1317, 1176, 999, 761, 450, 118, -258, -676, -1146, -1595, -2031, -2484, -2941, -3391, -3843, -4251, -4676, -5089, -5518, -5973, -6451, -6949, -7484, -8089, -8724, -9393, -10089, -10808, -11586, -12393, -13217, -14045, -14967, -15917, -16904, -17934, -18974, -20035, -21140, -22263, -23403, -24515, -25644, -26688, -27702, -28659, -29534, -30313, -31009, -31607, -32069, -32420, -32645, -32765, -32729, -32593, -32323, -31930, -31431, -30811, -30076, -29260, -28362, -27349, -26241, -25054, -23771, -22462, -21085, -19679, -18295, -16900, -15509, -14243, -12839, -11537, -10262, -8945, -7589, -6244, -4844, -3427, -2015, -563};