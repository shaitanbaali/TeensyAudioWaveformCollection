/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0051 256 samples */
 
const int16_t AKWF_ebass_0051_256_DATA [256] = 
{2055, 5410, 8731, 12075, 15719, 19326, 22156, 24646, 27102, 29371, 31050, 31883, 31381, 30640, 31046, 31866, 32383, 32769, 31959, 30184, 28667, 27729, 27268, 27327, 27014, 25851, 24213, 21994, 19549, 18327, 18200, 17462, 15916, 14597, 13281, 12417, 12414, 12427, 11987, 10982, 9765, 8765, 8449, 8522, 8741, 8639, 7790, 6341, 4753, 3420, 2034, 761, -429, -2158, -4460, -6868, -9296, -12187, -14895, -17163, -19312, -21116, -22253, -23478, -25264, -27036, -28583, -29509, -29780, -29551, -28832, -28068, -27668, -27467, -26569, -25290, -24356, -23006, -20411, -17632, -15083, -11865, -8550, -5623, -3048, -831, 1167, 3295, 5902, 8811, 11917, 14317, 15593, 17151, 19416, 20994, 21512, 21438, 20755, 20302, 20782, 21840, 22774, 23031, 22264, 21057, 20508, 20646, 20563, 20559, 20135, 18420, 16018, 14214, 13319, 13105, 13185, 12732, 11452, 9921, 8829, 8465, 8489, 8302, 7515, 6610, 5836, 5389, 5550, 6173, 6450, 5774, 4774, 3597, 2060, 639, -467, -1944, -3736, -5513, -7725, -9795, -11549, -13663, -16080, -18290, -20346, -22245, -23849, -25882, -28004, -29742, -31158, -32013, -31479, -30181, -29673, -29284, -28458, -27795, -27373, -26615, -24847, -22954, -21114, -18901, -16087, -13113, -10428, -7874, -5182, -3060, -1840, 114, 2981, 5432, 7063, 8363, 9697, 10921, 12152, 13078, 12980, 12225, 11340, 11100, 11943, 13174, 13336, 12595, 11695, 10734, 9783, 9616, 9692, 9349, 8570, 7267, 5585, 4673, 4569, 4961, 5169, 4452, 2825, 1762, 1854, 2315, 2658, 3046, 2878, 2234, 2240, 3085, 3769, 4756, 5618, 5719, 5331, 4590, 3658, 3024, 2555, 1448, -40, -1842, -4030, -6125, -8244, -10884, -13879, -16238, -18651, -21252, -23536, -25780, -28369, -30764, -31870, -32070, -32165, -32050, -31377, -30898, -30944, -30791, -30042, -28544, -26934, -24674, -21062, -17075, -13471, -9544, -4965, -929};