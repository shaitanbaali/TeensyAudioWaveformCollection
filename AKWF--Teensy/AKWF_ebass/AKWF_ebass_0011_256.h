/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0011 256 samples */
 
const int16_t AKWF_ebass_0011_256_DATA [256] = 
{1348, 4013, 6381, 8637, 10748, 12716, 14553, 16273, 17900, 19462, 20962, 22406, 23770, 25037, 26187, 27201, 28068, 28781, 29335, 29729, 29970, 30073, 30052, 29918, 29686, 29353, 28918, 28392, 27783, 27100, 26359, 25564, 24712, 23803, 22841, 21836, 20820, 19820, 18858, 17943, 17062, 16205, 15369, 14550, 13765, 13027, 12340, 11696, 11083, 10475, 9870, 9274, 8703, 8175, 7702, 7278, 6894, 6535, 6183, 5838, 5499, 5177, 4882, 4621, 4385, 4162, 3931, 3669, 3363, 3015, 2640, 2264, 1913, 1600, 1325, 1076, 837, 601, 371, 167, 8, -93, -144, -166, -201, -276, -406, -582, -778, -958, -1105, -1215, -1303, -1396, -1516, -1666, -1833, -1993, -2112, -2175, -2178, -2142, -2095, -2067, -2071, -2101, -2138, -2157, -2146, -2112, -2075, -2062, -2095, -2183, -2316, -2472, -2625, -2761, -2873, -2976, -3087, -3219, -3376, -3540, -3683, -3777, -3803, -3763, -3682, -3586, -3513, -3481, -3501, -3563, -3647, -3737, -3819, -3886, -3941, -3991, -4038, -4080, -4118, -4150, -4180, -4214, -4257, -4308, -4358, -4389, -4385, -4319, -4177, -3950, -3640, -3267, -2863, -2463, -2109, -1834, -1664, -1608, -1662, -1812, -2034, -2298, -2577, -2839, -3053, -3190, -3218, -3116, -2872, -2485, -1966, -1345, -652, 79, 814, 1524, 2190, 2792, 3315, 3749, 4080, 4305, 4427, 4455, 4413, 4317, 4189, 4045, 3901, 3765, 3645, 3545, 3475, 3444, 3462, 3524, 3615, 3699, 3736, 3682, 3491, 3129, 2565, 1775, 751, -516, -2002, -3679, -5514, -7462, -9481, -11539, -13589, -15600, -17552, -19418, -21193, -22884, -24479, -25965, -27322, -28516, -29523, -30338, -30967, -31443, -31807, -32094, -32327, -32514, -32653, -32737, -32768, -32743, -32646, -32447, -32100, -31534, -30701, -29565, -28105, -26335, -24282, -21969, -19451, -16779, -13991, -11163, -8351, -5604, -2904, -565};