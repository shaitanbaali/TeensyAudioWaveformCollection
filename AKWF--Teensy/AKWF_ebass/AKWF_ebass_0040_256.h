/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0040 256 samples */
 
const int16_t AKWF_ebass_0040_256_DATA [256] = 
{1073, 2864, 4631, 6462, 8359, 10251, 12169, 14042, 15871, 17647, 19310, 20888, 22360, 23697, 24887, 25939, 26841, 27613, 28262, 28762, 29107, 29320, 29373, 29284, 29036, 28614, 28018, 27242, 26291, 25183, 23921, 22506, 20998, 19390, 17737, 16069, 14418, 12827, 11296, 9840, 8474, 7191, 6025, 4974, 4053, 3258, 2548, 1931, 1370, 858, 426, 58, -261, -520, -758, -968, -1145, -1292, -1395, -1453, -1486, -1495, -1486, -1474, -1422, -1340, -1246, -1123, -973, -823, -680, -564, -469, -404, -358, -342, -351, -332, -338, -322, -321, -337, -329, -323, -338, -368, -362, -373, -405, -446, -519, -618, -752, -938, -1150, -1356, -1582, -1803, -1986, -2106, -2172, -2231, -2284, -2349, -2424, -2537, -2655, -2796, -2923, -3038, -3157, -3291, -3424, -3612, -3802, -4014, -4216, -4393, -4486, -4537, -4538, -4513, -4473, -4431, -4415, -4435, -4478, -4553, -4648, -4734, -4807, -4847, -4855, -4834, -4787, -4705, -4614, -4484, -4339, -4154, -3965, -3774, -3597, -3445, -3301, -3183, -3073, -2985, -2867, -2754, -2588, -2396, -2159, -1889, -1633, -1387, -1176, -984, -805, -657, -482, -310, -158, -28, 83, 159, 229, 288, 381, 467, 563, 678, 836, 1024, 1224, 1430, 1588, 1687, 1704, 1602, 1411, 1159, 869, 578, 288, 12, -243, -475, -674, -830, -952, -1067, -1213, -1369, -1547, -1744, -1973, -2235, -2515, -2794, -3078, -3360, -3624, -3888, -4158, -4440, -4740, -5085, -5477, -5980, -6599, -7335, -8200, -9174, -10253, -11426, -12696, -14048, -15468, -16931, -18403, -19889, -21353, -22795, -24178, -25488, -26735, -27890, -28957, -29905, -30729, -31397, -31939, -32352, -32621, -32761, -32708, -32448, -31910, -31060, -29905, -28441, -26729, -24777, -22655, -20433, -18177, -15926, -13760, -11658, -9668, -7774, -5977, -4227, -2469, -665};