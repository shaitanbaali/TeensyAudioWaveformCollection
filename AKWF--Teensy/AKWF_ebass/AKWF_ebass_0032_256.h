/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0032 256 samples */
 
const int16_t AKWF_ebass_0032_256_DATA [256] = 
{1220, 3249, 4781, 5834, 6487, 6736, 6729, 6398, 5811, 5224, 5017, 5206, 5820, 6892, 8441, 10286, 12313, 14308, 16217, 18023, 19868, 21759, 23551, 25141, 26535, 27727, 28773, 29662, 30362, 31010, 31647, 32246, 32644, 32774, 32546, 32088, 31486, 30647, 29408, 27701, 25646, 23372, 20988, 18702, 16662, 14890, 13374, 11966, 10478, 8805, 6862, 4685, 2416, 113, -2156, -4341, -6524, -8664, -10533, -12047, -13222, -14072, -14525, -14861, -15169, -15394, -15602, -15831, -15955, -15824, -15492, -15171, -15003, -15011, -14991, -14687, -13994, -13133, -12200, -11203, -10151, -9223, -8505, -7966, -7450, -6816, -6067, -5209, -4400, -3545, -2490, -1068, 772, 3040, 5530, 7955, 10223, 12070, 13342, 14083, 14476, 14553, 14322, 13858, 13223, 12409, 11445, 10529, 9868, 9461, 9296, 9322, 9486, 9737, 9979, 10092, 9945, 9628, 9263, 8758, 7913, 6769, 5488, 4293, 3313, 2527, 1850, 1303, 854, 500, 230, 1, -154, -156, 14, 259, 462, 533, 484, 387, 307, 269, 261, 253, 162, -133, -689, -1507, -2555, -3757, -5086, -6489, -7896, -9293, -10582, -11740, -12769, -13560, -14111, -14396, -14378, -14080, -13595, -12908, -12153, -11396, -10612, -9849, -9094, -8348, -7581, -6816, -6038, -5275, -4621, -4078, -3690, -3457, -3352, -3425, -3643, -4050, -4632, -5335, -6150, -7084, -8065, -8993, -9889, -10779, -11618, -12395, -13112, -13775, -14395, -14993, -15552, -16080, -16547, -16973, -17320, -17553, -17579, -17332, -16765, -15860, -14599, -13100, -11458, -9704, -7984, -6386, -5059, -4093, -3601, -3582, -3987, -4760, -5867, -7260, -8904, -10749, -12754, -14952, -17295, -19694, -22063, -24237, -26143, -27729, -28987, -29910, -30492, -30791, -30881, -30777, -30458, -29941, -29241, -28436, -27608, -26686, -25592, -24276, -22795, -21207, -19567, -17908, -16155, -14378, -12543, -10589, -8480, -6100, -3579, -1020};