/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0036 256 samples */
 
const int16_t AKWF_ebass_0036_256_DATA [256] = 
{935, 2321, 3602, 4861, 6125, 7407, 8714, 9982, 11271, 12501, 13593, 14590, 15509, 16261, 16773, 17173, 17330, 17217, 16978, 16586, 16097, 15565, 15070, 14583, 14248, 14057, 14033, 14218, 14581, 15227, 16067, 17105, 18320, 19634, 21061, 22503, 23856, 25108, 26322, 27289, 28149, 28799, 29351, 29689, 29911, 30007, 30033, 29917, 29644, 29293, 28751, 28029, 27117, 25969, 24816, 23566, 22237, 20848, 19440, 18018, 16486, 14844, 13215, 11571, 10001, 8457, 7006, 5634, 4295, 2990, 1692, 395, -834, -1941, -2952, -3831, -4499, -5057, -5545, -5839, -5993, -6081, -6033, -5983, -5903, -5847, -5867, -5885, -5854, -5694, -5436, -5092, -4694, -4303, -3908, -3587, -3399, -3333, -3326, -3449, -3649, -3886, -4182, -4427, -4657, -4805, -4895, -4887, -4831, -4729, -4648, -4642, -4674, -4800, -4948, -5072, -5071, -4912, -4637, -4280, -3824, -3357, -2940, -2528, -2130, -1764, -1406, -1095, -849, -785, -799, -911, -1179, -1453, -1696, -1920, -2090, -2186, -2201, -2084, -1880, -1663, -1381, -1119, -925, -800, -793, -861, -1113, -1405, -1732, -2168, -2582, -2977, -3348, -3648, -3920, -4122, -4329, -4463, -4602, -4701, -4797, -4913, -5056, -5254, -5466, -5756, -6099, -6501, -6949, -7478, -8110, -8760, -9419, -10049, -10636, -11086, -11444, -11689, -11853, -11888, -11891, -11874, -11763, -11709, -11685, -11667, -11715, -11890, -12195, -12621, -13244, -13976, -14847, -15841, -16817, -17751, -18567, -19209, -19686, -19991, -20117, -20110, -19990, -19817, -19532, -19112, -18676, -18278, -17883, -17628, -17525, -17641, -17898, -18314, -18828, -19493, -20248, -21002, -21809, -22586, -23413, -24265, -25070, -25925, -26874, -27754, -28616, -29481, -30254, -30948, -31624, -32187, -32533, -32725, -32721, -32332, -31641, -30686, -29426, -27815, -26049, -24091, -21955, -19815, -17632, -15430, -13272, -11318, -9382, -7454, -5632, -3855, -2136, -470};