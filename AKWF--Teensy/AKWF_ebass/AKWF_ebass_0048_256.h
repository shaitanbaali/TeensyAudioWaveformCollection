/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0048 256 samples */
 
const int16_t AKWF_ebass_0048_256_DATA [256] = 
{328, 891, 1512, 2050, 2696, 3388, 3982, 4648, 5376, 6075, 6818, 7620, 8287, 9097, 9842, 10542, 11387, 12119, 12874, 13552, 14171, 14776, 15232, 15694, 16039, 16298, 16490, 16584, 16511, 16443, 16209, 15926, 15408, 14945, 14247, 13544, 12855, 11994, 11094, 10050, 9032, 7915, 6821, 5649, 4447, 3301, 2115, 813, -431, -1731, -2914, -4184, -5439, -6633, -7800, -8969, -10138, -11131, -12130, -13067, -13972, -14720, -15550, -16153, -16708, -17283, -17764, -18070, -18319, -18394, -18475, -18395, -18322, -18110, -17842, -17512, -17170, -16762, -16331, -15773, -15238, -14635, -14032, -13409, -12881, -12205, -11537, -10885, -10290, -9666, -9021, -8376, -7801, -7292, -6724, -6253, -5844, -5406, -5100, -4770, -4553, -4359, -4270, -4191, -4192, -4269, -4432, -4612, -4898, -5288, -5714, -6254, -6766, -7418, -8041, -8798, -9624, -10487, -11322, -12194, -13216, -14220, -15269, -16245, -17371, -18459, -19443, -20575, -21663, -22639, -23718, -24683, -25610, -26568, -27489, -28317, -29032, -29659, -30301, -30959, -31436, -31768, -32102, -32400, -32566, -32658, -32732, -32667, -32535, -32328, -32073, -31715, -31202, -30652, -30047, -29370, -28690, -27857, -26961, -26030, -25091, -24066, -23036, -22006, -20921, -19848, -18744, -17576, -16569, -15570, -14618, -13648, -12691, -11862, -11060, -10276, -9538, -8972, -8351, -7716, -7272, -6762, -6342, -6012, -5644, -5300, -5014, -4788, -4558, -4313, -4104, -3976, -3891, -3755, -3694, -3622, -3618, -3646, -3680, -3719, -3794, -3863, -3998, -4150, -4303, -4474, -4528, -4661, -4794, -4858, -4878, -4864, -4918, -4900, -4842, -4771, -4663, -4521, -4379, -4180, -4040, -3905, -3758, -3628, -3548, -3490, -3426, -3277, -3371, -3429, -3486, -3555, -3641, -3717, -3835, -3960, -4078, -4143, -4253, -4310, -4354, -4311, -4291, -4203, -4112, -3935, -3759, -3471, -3178, -2827, -2416, -2055, -1651, -1154, -706, -217};