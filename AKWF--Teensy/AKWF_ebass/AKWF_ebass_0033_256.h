/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0033 256 samples */
 
const int16_t AKWF_ebass_0033_256_DATA [256] = 
{493, 1331, 2030, 2589, 2974, 3189, 3309, 3424, 3637, 4019, 4602, 5388, 6251, 7046, 7760, 8290, 8612, 8733, 8625, 8312, 7881, 7434, 7118, 7017, 7203, 7749, 8576, 9606, 10704, 11806, 12789, 13605, 14237, 14668, 14955, 15141, 15268, 15413, 15609, 15814, 15941, 15969, 15794, 15468, 15005, 14395, 13725, 12990, 12262, 11660, 11256, 11136, 11328, 11859, 12599, 13628, 14875, 16192, 17442, 18554, 19345, 19756, 19650, 19082, 18032, 16530, 14678, 12594, 10508, 8643, 7262, 6525, 6554, 7392, 9003, 11353, 14312, 17657, 21178, 24599, 27577, 29955, 31604, 32529, 32769, 32360, 31306, 29620, 27370, 24539, 21215, 17568, 13715, 9846, 6065, 2662, -96, -2002, -3000, -3137, -2596, -1685, -701, 108, 527, 428, -263, -1544, -3349, -5543, -7880, -10158, -12124, -13613, -14529, -14862, -14544, -13610, -11969, -9695, -6894, -3683, -296, 2984, 6002, 8634, 10770, 12433, 13643, 14437, 14827, 14790, 14388, 13670, 12654, 11407, 9998, 8481, 6889, 5255, 3531, 1770, 6, -1727, -3388, -5073, -6778, -8556, -10479, -12458, -14417, -16326, -18046, -19532, -20878, -22110, -23245, -24195, -24849, -24971, -24460, -23376, -21857, -20145, -18403, -16940, -15805, -15241, -15265, -15883, -17092, -18748, -20454, -21757, -22207, -21664, -20287, -18370, -16404, -14845, -13935, -13790, -14249, -15124, -16223, -17174, -17859, -18121, -17930, -17282, -16392, -15438, -14698, -14347, -14449, -14933, -15632, -16357, -16819, -16942, -16688, -16205, -15794, -15652, -15913, -16488, -17346, -18226, -18927, -19275, -19147, -18567, -17525, -16092, -14393, -12562, -10847, -9461, -8548, -8201, -8316, -8774, -9375, -9990, -10532, -10928, -11129, -11156, -10933, -10507, -9785, -8771, -7533, -6152, -4748, -3433, -2294, -1356, -679, -251, -115, -272, -693, -1319, -1994, -2636, -3127, -3396, -3400, -3164, -2753, -2238, -1663, -1095, -553, -112};