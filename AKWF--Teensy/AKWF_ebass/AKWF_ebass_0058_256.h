/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0058 256 samples */
 
const int16_t AKWF_ebass_0058_256_DATA [256] = 
{417, 1762, 2994, 4172, 5287, 6342, 7348, 8295, 9193, 10042, 10843, 11595, 12305, 12965, 13585, 14163, 14700, 15200, 15660, 16087, 16480, 16842, 17176, 17477, 17757, 18008, 18238, 18442, 18626, 18786, 18924, 19044, 19144, 19225, 19289, 19334, 19362, 19377, 19374, 19357, 19324, 19277, 19217, 19147, 19062, 18965, 18861, 18746, 18622, 18493, 18356, 18213, 18065, 17912, 17754, 17594, 17427, 17260, 17086, 16912, 16734, 16553, 16368, 16180, 15989, 15793, 15594, 15391, 15184, 14971, 14756, 14535, 14313, 14086, 13857, 13626, 13395, 13162, 12927, 12695, 12460, 12228, 11994, 11761, 11528, 11288, 11048, 10800, 10547, 10287, 10017, 9740, 9458, 9168, 8877, 8579, 8284, 7991, 7700, 7416, 7138, 6870, 6604, 6352, 6107, 5868, 5640, 5413, 5191, 4977, 4764, 4552, 4345, 4137, 3927, 3719, 3508, 3300, 3097, 2894, 2695, 2508, 2330, 2167, 2020, 1887, 1776, 1689, 1624, 1578, 1555, 1552, 1568, 1601, 1650, 1716, 1790, 1878, 1975, 2081, 2198, 2325, 2464, 2613, 2776, 2953, 3148, 3358, 3589, 3832, 4094, 4371, 4662, 4961, 5275, 5593, 5913, 6229, 6537, 6832, 7105, 7353, 7572, 7755, 7900, 7998, 8047, 8048, 7991, 7879, 7710, 7482, 7191, 6844, 6431, 5955, 5411, 4793, 4096, 3319, 2455, 1497, 440, -712, -1925, -3188, -4505, -5854, -7230, -8628, -10035, -11442, -12844, -14230, -15588, -16924, -18216, -19470, -20679, -21834, -22939, -23990, -24978, -25911, -26784, -27591, -28341, -29032, -29658, -30226, -30735, -31182, -31576, -31911, -32190, -32414, -32584, -32697, -32757, -32763, -32716, -32614, -32459, -32250, -31987, -31669, -31300, -30875, -30400, -29868, -29283, -28648, -27960, -27219, -26429, -25585, -24692, -23750, -22757, -21713, -20626, -19489, -18305, -17084, -15815, -14509, -13170, -11790, -10383, -8955, -7494, -6015, -4540, -2959, -2011, -829};