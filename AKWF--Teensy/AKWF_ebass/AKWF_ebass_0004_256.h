/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0004 256 samples */
 
const int16_t AKWF_ebass_0004_256_DATA [256] = 
{856, 1387, 2347, 3514, 4549, 5498, 6347, 7093, 7746, 8335, 8884, 9412, 9933, 10452, 10960, 11450, 11909, 12335, 12731, 13094, 13424, 13719, 13971, 14172, 14316, 14398, 14431, 14435, 14423, 14419, 14442, 14494, 14577, 14677, 14788, 14898, 14995, 15080, 15153, 15213, 15256, 15272, 15247, 15165, 15013, 14794, 14519, 14209, 13882, 13567, 13271, 13005, 12772, 12574, 12413, 12287, 12197, 12124, 12050, 11953, 11814, 11624, 11381, 11095, 10784, 10471, 10169, 9891, 9637, 9403, 9183, 8959, 8725, 8470, 8203, 7937, 7688, 7472, 7284, 7129, 6994, 6868, 6750, 6646, 6549, 6456, 6357, 6227, 6057, 5845, 5601, 5347, 5104, 4882, 4679, 4487, 4281, 4059, 3819, 3563, 3312, 3069, 2839, 2626, 2429, 2242, 2073, 1923, 1797, 1703, 1634, 1586, 1547, 1498, 1415, 1275, 1064, 783, 440, 54, -348, -750, -1138, -1497, -1811, -2055, -2193, -2210, -2095, -1860, -1547, -1203, -890, -639, -479, -411, -432, -527, -682, -888, -1133, -1406, -1685, -1954, -2192, -2388, -2538, -2633, -2681, -2676, -2620, -2499, -2304, -2015, -1629, -1154, -622, -60, 488, 986, 1409, 1746, 1991, 2153, 2236, 2250, 2212, 2142, 2061, 1992, 1981, 2058, 2239, 2521, 2896, 3335, 3814, 4321, 4844, 5367, 5879, 6349, 6749, 7047, 7210, 7227, 7095, 6816, 6405, 5867, 5197, 4386, 3422, 2313, 1076, -252, -1613, -2959, -4244, -5441, -6556, -7599, -8592, -9557, -10511, -11471, -12455, -13487, -14603, -15850, -17255, -18825, -20535, -22323, -24104, -25803, -27353, -28707, -29855, -30794, -31539, -32105, -32496, -32716, -32767, -32663, -32430, -32099, -31697, -31244, -30734, -30153, -29473, -28678, -27767, -26745, -25637, -24484, -23294, -22092, -20874, -19627, -18349, -17033, -15677, -14299, -12910, -11516, -10127, -8742, -7350, -5951, -4550, -3153, -1789, -480};