/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0068 256 samples */
 
const int16_t AKWF_ebass_0068_256_DATA [256] = 
{996, 2704, 4298, 5821, 7267, 8639, 9934, 11149, 12286, 13345, 14320, 15214, 16024, 16747, 17384, 17933, 18392, 18763, 19043, 19234, 19335, 19349, 19276, 19121, 18885, 18573, 18189, 17741, 17238, 16684, 16090, 15470, 14829, 14184, 13545, 12922, 12329, 11774, 11264, 10812, 10419, 10089, 9826, 9627, 9489, 9410, 9383, 9402, 9458, 9547, 9659, 9787, 9926, 10070, 10217, 10365, 10512, 10662, 10816, 10980, 11158, 11359, 11590, 11857, 12170, 12534, 12955, 13441, 13991, 14610, 15297, 16046, 16857, 17723, 18631, 19576, 20544, 21519, 22492, 23447, 24371, 25253, 26080, 26841, 27529, 28138, 28659, 29091, 29429, 29673, 29820, 29870, 29824, 29681, 29444, 29112, 28685, 28166, 27555, 26851, 26059, 25177, 24207, 23157, 22023, 20814, 19540, 18201, 16813, 15390, 13941, 12486, 11046, 9635, 8279, 7001, 5814, 4745, 3811, 3023, 2396, 1936, 1647, 1528, 1575, 1780, 2132, 2617, 3222, 3928, 4717, 5576, 6484, 7426, 8388, 9352, 10308, 11244, 12144, 13004, 13813, 14562, 15246, 15857, 16388, 16836, 17197, 17465, 17635, 17704, 17669, 17523, 17264, 16890, 16393, 15771, 15020, 14136, 13116, 11956, 10649, 9200, 7604, 5855, 3964, 1924, -258, -2457, -4587, -6637, -8589, -10445, -12196, -13836, -15370, -16797, -18115, -19334, -20456, -21484, -22429, -23293, -24084, -24811, -25476, -26087, -26654, -27179, -27666, -28124, -28554, -28958, -29342, -29706, -30051, -30380, -30690, -30984, -31260, -31515, -31752, -31967, -32158, -32326, -32468, -32583, -32672, -32732, -32764, -32766, -32740, -32684, -32601, -32490, -32352, -32189, -32002, -31792, -31562, -31312, -31045, -30760, -30459, -30143, -29811, -29462, -29098, -28713, -28310, -27883, -27429, -26949, -26437, -25890, -25305, -24679, -24006, -23289, -22521, -21698, -20822, -19887, -18895, -17847, -16737, -15567, -14341, -13050, -11701, -10296, -8831, -7312, -5742, -4118, -2450, -699};