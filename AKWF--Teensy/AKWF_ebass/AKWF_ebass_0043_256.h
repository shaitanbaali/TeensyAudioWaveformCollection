/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0043 256 samples */
 
const int16_t AKWF_ebass_0043_256_DATA [256] = 
{1329, 3428, 4699, 5889, 7615, 9971, 12978, 16396, 19630, 21769, 22754, 23131, 23268, 23431, 23888, 24799, 26033, 27463, 28788, 29670, 30237, 30458, 30152, 29660, 29485, 29761, 29871, 29050, 27042, 24060, 20731, 17797, 15676, 14482, 14229, 14454, 14191, 12557, 9692, 6343, 3100, 567, -948, -1718, -2509, -3761, -5286, -6871, -8583, -9958, -10465, -10614, -11367, -12842, -14517, -16063, -17198, -17400, -16420, -14521, -11933, -8993, -6495, -5217, -5296, -6330, -7497, -7908, -6588, -3353, 772, 4695, 7698, 9527, 10076, 9801, 9799, 10743, 12435, 14308, 15963, 17074, 17359, 17213, 17382, 18211, 19497, 20868, 21992, 22298, 21231, 18900, 16099, 13586, 11675, 10671, 10789, 11883, 13099, 12976, 10797, 7162, 3409, 507, -1077, -1003, 382, 1937, 2406, 1097, -1367, -4052, -6155, -6949, -6402, -5487, -5447, -6710, -8529, -10135, -11054, -10764, -8887, -5851, -2719, 18, 2305, 3804, 3864, 2756, 1822, 1893, 3190, 5876, 9515, 12615, 13838, 12968, 10844, 8516, 7337, 8081, 9804, 10996, 10809, 9374, 7189, 5030, 3705, 2778, 1398, -390, -2123, -4176, -7462, -11781, -16074, -20232, -23744, -25537, -25348, -24299, -23885, -24553, -26368, -29073, -31584, -32747, -32454, -31204, -29123, -26538, -24208, -22696, -21615, -20474, -19318, -18058, -16265, -13826, -11279, -9013, -6912, -4867, -2817, -624, 1835, 4422, 6932, 9363, 11688, 13532, 14576, 14748, 14373, 13878, 13480, 13183, 12827, 12261, 11223, 9283, 6528, 3732, 1698, 448, -426, -1042, -1360, -1792, -2812, -4320, -5881, -7328, -8785, -10096, -11016, -11629, -12079, -12676, -13652, -15013, -16609, -18179, -19440, -19980, -19706, -19108, -18829, -19068, -19882, -21349, -22938, -23753, -23487, -22608, -21512, -20376, -19672, -19800, -20445, -20870, -20957, -21067, -20961, -20288, -19033, -17140, -14634, -12165, -10361, -8957, -7338, -5472, -3459, -1113};