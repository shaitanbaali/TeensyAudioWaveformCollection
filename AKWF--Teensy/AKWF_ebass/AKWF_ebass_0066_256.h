/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0066 256 samples */
 
const int16_t AKWF_ebass_0066_256_DATA [256] = 
{1166, 4099, 6859, 9494, 11981, 14315, 16495, 18509, 20368, 22072, 23620, 25030, 26307, 27459, 28498, 29424, 30240, 30945, 31536, 32009, 32366, 32606, 32738, 32765, 32696, 32540, 32308, 32010, 31654, 31244, 30787, 30283, 29723, 29101, 28407, 27630, 26766, 25811, 24770, 23655, 22469, 21227, 19941, 18609, 17241, 15845, 14414, 12947, 11443, 9884, 8272, 6609, 4897, 3162, 1426, -290, -1908, -3392, -4771, -6059, -7281, -8462, -9609, -10732, -11836, -12908, -13940, -14917, -15814, -16621, -17323, -17918, -18418, -18839, -19203, -19539, -19865, -20196, -20537, -20887, -21234, -21565, -21865, -22119, -22316, -22452, -22530, -22565, -22571, -22571, -22586, -22635, -22721, -22844, -22990, -23143, -23282, -23386, -23443, -23445, -23395, -23306, -23195, -23087, -23002, -22960, -22969, -23026, -23125, -23254, -23393, -23526, -23634, -23703, -23726, -23703, -23641, -23556, -23463, -23379, -23312, -23263, -23224, -23185, -23124, -23027, -22877, -22661, -22371, -22008, -21580, -21097, -20582, -20054, -19530, -19028, -18549, -18087, -17630, -17159, -16658, -16114, -15511, -14842, -14100, -13278, -12375, -11397, -10346, -9234, -8071, -6861, -5621, -4363, -3098, -1846, -623, 553, 1636, 2620, 3508, 4305, 5022, 5671, 6268, 6830, 7378, 7921, 8472, 9038, 9618, 10214, 10829, 11453, 12085, 12720, 13346, 13959, 14542, 15084, 15576, 16003, 16360, 16636, 16828, 16933, 16963, 16936, 16879, 16830, 16825, 16896, 17062, 17326, 17681, 18106, 18575, 19062, 19538, 19975, 20351, 20650, 20862, 20983, 21019, 20975, 20856, 20659, 20384, 20017, 19554, 18989, 18315, 17535, 16652, 15662, 14576, 13402, 12148, 10832, 9468, 8061, 6615, 5118, 3543, 1866, 49, -1869, -3813, -5773, -7721, -9618, -11432, -13127, -14665, -16024, -17185, -18133, -18870, -19399, -19724, -19856, -19801, -19562, -19140, -18534, -17750, -16793, -15652, -14312, -12765, -11011, -9039, -6838, -4405, -1661};