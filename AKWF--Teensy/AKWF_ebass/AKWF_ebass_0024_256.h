/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0024 256 samples */
 
const int16_t AKWF_ebass_0024_256_DATA [256] = 
{670, 2402, 4085, 5757, 7400, 9016, 10591, 12120, 13608, 15047, 16424, 17743, 18993, 20178, 21296, 22342, 23312, 24205, 25021, 25760, 26422, 27006, 27508, 27934, 28283, 28556, 28753, 28877, 28927, 28906, 28815, 28656, 28431, 28140, 27789, 27374, 26900, 26368, 25781, 25143, 24448, 23700, 22905, 22062, 21176, 20244, 19267, 18247, 17189, 16093, 14962, 13794, 12589, 11353, 10087, 8796, 7476, 6130, 4758, 3367, 1962, 540, -897, -2347, -3808, -5270, -6729, -8194, -9653, -11105, -12548, -13969, -15367, -16751, -18103, -19424, -20710, -21947, -23144, -24293, -25385, -26421, -27393, -28291, -29124, -29880, -30555, -31148, -31651, -32064, -32385, -32611, -32738, -32765, -32695, -32522, -32247, -31872, -31399, -30824, -30155, -29389, -28528, -27582, -26551, -25432, -24237, -22965, -21621, -20224, -18761, -17237, -15671, -14057, -12408, -10738, -9032, -7308, -5577, -3833, -2101, -380, 1337, 3030, 4692, 6324, 7906, 9446, 10938, 12368, 13736, 15034, 16256, 17406, 18477, 19462, 20362, 21171, 21891, 22524, 23065, 23513, 23874, 24147, 24333, 24436, 24457, 24401, 24272, 24073, 23809, 23483, 23105, 22678, 22203, 21690, 21143, 20564, 19968, 19351, 18718, 18080, 17435, 16793, 16155, 15521, 14898, 14291, 13697, 13123, 12568, 12031, 11513, 11017, 10543, 10087, 9648, 9226, 8817, 8423, 8038, 7659, 7285, 6911, 6534, 6152, 5763, 5360, 4942, 4503, 4044, 3563, 3054, 2514, 1944, 1341, 706, 32, -678, -1424, -2208, -3026, -3880, -4771, -5695, -6647, -7626, -8629, -9655, -10704, -11764, -12829, -13897, -14966, -16027, -17078, -18107, -19108, -20075, -21007, -21891, -22725, -23496, -24201, -24836, -25393, -25869, -26258, -26554, -26755, -26860, -26864, -26765, -26565, -26262, -25857, -25347, -24738, -24031, -23226, -22335, -21348, -20276, -19126, -17902, -16602, -15239, -13813, -12333, -10811, -9247, -7645, -6017, -4366, -2706, -1006};