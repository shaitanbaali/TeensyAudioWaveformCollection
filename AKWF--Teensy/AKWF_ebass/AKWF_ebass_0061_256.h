/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0061 256 samples */
 
const int16_t AKWF_ebass_0061_256_DATA [256] = 
{529, 2220, 3743, 5176, 6513, 7761, 8930, 10018, 11036, 11987, 12872, 13692, 14459, 15164, 15819, 16427, 16984, 17498, 17969, 18401, 18796, 19159, 19490, 19788, 20063, 20309, 20533, 20732, 20909, 21064, 21197, 21312, 21407, 21485, 21546, 21589, 21616, 21630, 21628, 21611, 21580, 21534, 21477, 21411, 21329, 21235, 21136, 21025, 20905, 20781, 20648, 20509, 20364, 20216, 20060, 19903, 19738, 19574, 19402, 19228, 19051, 18870, 18684, 18495, 18302, 18103, 17900, 17693, 17482, 17263, 17042, 16813, 16583, 16347, 16107, 15863, 15620, 15373, 15124, 14877, 14626, 14376, 14125, 13872, 13619, 13359, 13097, 12823, 12544, 12258, 11959, 11649, 11335, 11008, 10679, 10342, 10006, 9671, 9337, 9010, 8687, 8376, 8067, 7772, 7483, 7202, 6932, 6662, 6399, 6143, 5889, 5635, 5386, 5134, 4882, 4629, 4371, 4119, 3869, 3621, 3377, 3146, 2925, 2725, 2541, 2376, 2238, 2129, 2047, 1990, 1961, 1958, 1979, 2020, 2080, 2162, 2254, 2364, 2487, 2618, 2762, 2919, 3092, 3276, 3476, 3694, 3932, 4190, 4471, 4765, 5083, 5418, 5767, 6125, 6499, 6878, 7255, 7627, 7988, 8332, 8650, 8938, 9190, 9400, 9567, 9678, 9735, 9736, 9672, 9542, 9348, 9085, 8750, 8346, 7864, 7304, 6661, 5924, 5085, 4143, 3079, 1888, 557, -903, -2423, -3981, -5579, -7185, -8794, -10399, -11978, -13527, -15036, -16495, -17895, -19240, -20512, -21718, -22857, -23919, -24913, -25838, -26689, -27477, -28200, -28855, -29454, -29996, -30478, -30911, -31293, -31625, -31913, -32156, -32358, -32518, -32638, -32719, -32761, -32765, -32731, -32660, -32549, -32400, -32212, -31981, -31711, -31397, -31042, -30640, -30190, -29696, -29151, -28555, -27907, -27204, -26444, -25628, -24750, -23808, -22806, -21738, -20599, -19399, -18125, -16785, -15382, -13904, -12363, -10768, -9100, -7375, -5621, -3699, -2533, -1050};