/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0017 256 samples */
 
const int16_t AKWF_ebass_0017_256_DATA [256] = 
{368, 1218, 2037, 2849, 3649, 4443, 5230, 6009, 6785, 7557, 8325, 9091, 9855, 10613, 11365, 12109, 12839, 13554, 14248, 14913, 15547, 16144, 16697, 17205, 17662, 18064, 18413, 18705, 18940, 19119, 19241, 19306, 19314, 19265, 19157, 18988, 18758, 18465, 18107, 17684, 17197, 16645, 16033, 15362, 14637, 13863, 13040, 12175, 11277, 10344, 9388, 8416, 7431, 6447, 5474, 4516, 3588, 2699, 1856, 1068, 342, -318, -907, -1421, -1857, -2212, -2483, -2671, -2776, -2795, -2728, -2578, -2343, -2022, -1617, -1129, -558, 91, 820, 1621, 2490, 3425, 4418, 5460, 6551, 7682, 8842, 10033, 11242, 12461, 13693, 14923, 16147, 17363, 18560, 19733, 20882, 21994, 23067, 24099, 25080, 26010, 26885, 27699, 28454, 29147, 29773, 30335, 30829, 31252, 31607, 31891, 32101, 32240, 32305, 32299, 32219, 32067, 31845, 31555, 31200, 30781, 30302, 29765, 29173, 28529, 27834, 27092, 26303, 25471, 24595, 23678, 22725, 21737, 20715, 19668, 18595, 17499, 16389, 15260, 14117, 12966, 11801, 10629, 9455, 8274, 7093, 5917, 4742, 3576, 2424, 1279, 150, -963, -2067, -3156, -4233, -5299, -6352, -7391, -8418, -9428, -10420, -11395, -12345, -13274, -14181, -15064, -15926, -16769, -17592, -18399, -19193, -19967, -20727, -21469, -22188, -22887, -23564, -24213, -24839, -25442, -26019, -26578, -27117, -27639, -28145, -28635, -29107, -29559, -29986, -30387, -30758, -31096, -31401, -31672, -31910, -32115, -32291, -32439, -32560, -32654, -32721, -32759, -32767, -32742, -32680, -32582, -32445, -32272, -32062, -31820, -31545, -31241, -30911, -30553, -30168, -29755, -29312, -28838, -28333, -27792, -27217, -26607, -25963, -25290, -24591, -23867, -23128, -22373, -21605, -20829, -20045, -19254, -18460, -17658, -16849, -16035, -15211, -14379, -13541, -12693, -11838, -10978, -10111, -9238, -8361, -7480, -6595, -5710, -4823, -3939, -3060, -2187, -1324, -453};