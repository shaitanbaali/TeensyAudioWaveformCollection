/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0034 256 samples */
 
const int16_t AKWF_ebass_0034_256_DATA [256] = 
{1069, 3745, 6234, 8639, 10929, 13059, 15007, 16738, 18280, 19598, 20706, 21651, 22526, 23361, 24194, 25023, 25897, 26823, 27798, 28761, 29655, 30479, 31181, 31766, 32218, 32525, 32719, 32771, 32733, 32554, 32195, 31654, 30909, 30009, 28925, 27612, 26095, 24450, 22649, 20743, 18727, 16711, 14717, 12783, 10979, 9286, 7733, 6325, 5080, 4000, 3059, 2233, 1539, 965, 497, 120, -189, -445, -651, -803, -888, -929, -968, -940, -893, -828, -739, -650, -580, -540, -493, -439, -386, -390, -368, -349, -335, -310, -304, -302, -282, -250, -211, -165, -146, -146, -138, -143, -158, -200, -227, -268, -327, -388, -454, -495, -501, -511, -530, -578, -618, -652, -691, -729, -740, -742, -772, -816, -861, -909, -966, -1006, -1036, -1066, -1107, -1141, -1176, -1192, -1210, -1263, -1320, -1393, -1473, -1584, -1720, -1875, -2066, -2222, -2354, -2454, -2551, -2676, -2846, -3021, -3209, -3330, -3440, -3522, -3596, -3679, -3778, -3900, -4050, -4200, -4338, -4424, -4509, -4538, -4503, -4393, -4216, -4025, -3849, -3746, -3751, -3728, -3743, -3756, -3732, -3676, -3608, -3540, -3458, -3377, -3306, -3245, -3186, -3126, -3060, -2940, -2839, -2744, -2659, -2615, -2583, -2565, -2503, -2427, -2354, -2297, -2262, -2265, -2294, -2357, -2464, -2582, -2718, -2833, -2934, -3015, -3088, -3160, -3256, -3374, -3493, -3618, -3753, -3899, -4038, -4212, -4388, -4570, -4777, -4991, -5250, -5530, -5827, -6161, -6551, -6994, -7494, -8089, -8736, -9416, -10093, -10796, -11503, -12215, -12935, -13678, -14432, -15211, -16013, -16866, -17749, -18719, -19725, -20831, -21988, -23183, -24393, -25591, -26737, -27801, -28757, -29594, -30324, -30905, -31346, -31610, -31687, -31581, -31240, -30618, -29679, -28393, -26767, -24808, -22488, -19871, -17037, -14003, -10892, -7724, -4628, -1635};