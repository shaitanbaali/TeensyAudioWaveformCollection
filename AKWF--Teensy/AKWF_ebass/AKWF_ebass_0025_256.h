/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0025 256 samples */
 
const int16_t AKWF_ebass_0025_256_DATA [256] = 
{545, 1242, 1890, 2547, 3197, 3841, 4483, 5121, 5754, 6384, 7006, 7622, 8234, 8839, 9442, 10037, 10625, 11206, 11783, 12352, 12915, 13472, 14019, 14561, 15097, 15625, 16147, 16661, 17166, 17666, 18157, 18642, 19120, 19589, 20050, 20505, 20952, 21392, 21824, 22246, 22662, 23072, 23470, 23863, 24248, 24621, 24989, 25347, 25697, 26039, 26369, 26691, 27005, 27310, 27601, 27884, 28158, 28420, 28671, 28911, 29139, 29357, 29561, 29753, 29934, 30099, 30251, 30390, 30514, 30623, 30717, 30796, 30859, 30906, 30935, 30948, 30945, 30924, 30882, 30823, 30746, 30650, 30534, 30397, 30241, 30066, 29870, 29654, 29415, 29156, 28876, 28575, 28252, 27909, 27545, 27159, 26750, 26321, 25871, 25401, 24908, 24396, 23861, 23306, 22734, 22140, 21529, 20895, 20245, 19577, 18889, 18184, 17463, 16724, 15974, 15205, 14419, 13621, 12810, 11986, 11152, 10303, 9443, 8574, 7696, 6811, 5917, 5016, 4106, 3192, 2274, 1356, 431, -496, -1426, -2356, -3281, -4209, -5134, -6058, -6978, -7888, -8794, -9699, -10593, -11481, -12361, -13225, -14082, -14929, -15762, -16585, -17391, -18180, -18961, -19723, -20467, -21196, -21905, -22595, -23269, -23922, -24553, -25164, -25755, -26323, -26870, -27394, -27892, -28369, -28822, -29253, -29659, -30038, -30393, -30726, -31032, -31314, -31570, -31800, -32006, -32187, -32345, -32476, -32584, -32666, -32723, -32758, -32768, -32754, -32718, -32659, -32578, -32474, -32347, -32199, -32032, -31842, -31630, -31402, -31154, -30886, -30601, -30296, -29973, -29634, -29278, -28908, -28521, -28117, -27699, -27269, -26824, -26363, -25892, -25408, -24911, -24405, -23885, -23354, -22815, -22263, -21706, -21139, -20560, -19975, -19381, -18778, -18174, -17559, -16935, -16309, -15674, -15037, -14396, -13747, -13094, -12438, -11778, -11118, -10453, -9784, -9113, -8441, -7769, -7095, -6421, -5744, -5068, -4391, -3719, -3044, -2371, -1697, -1040, -296};