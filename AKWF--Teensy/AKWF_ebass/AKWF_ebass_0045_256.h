/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0045 256 samples */
 
const int16_t AKWF_ebass_0045_256_DATA [256] = 
{722, 1861, 2908, 3959, 4953, 5848, 6725, 7609, 8386, 9069, 9801, 10449, 10921, 11179, 11564, 11790, 12024, 12065, 12095, 12015, 11773, 11557, 11032, 10640, 10138, 9458, 8753, 8004, 7082, 6238, 5181, 4037, 2971, 1668, 408, -763, -2067, -3360, -4816, -6197, -7420, -8916, -10168, -11669, -13199, -14478, -15794, -17250, -18563, -19855, -21145, -22375, -23567, -24634, -25503, -26623, -27402, -28239, -29050, -29788, -30366, -30804, -31381, -31680, -32049, -32206, -32347, -32521, -32446, -32314, -32143, -31920, -31746, -31298, -31059, -30478, -29953, -29574, -28906, -28248, -27703, -26975, -26196, -25435, -24715, -23916, -23158, -22469, -21580, -20665, -19942, -19142, -18333, -17532, -16752, -15994, -15165, -14503, -13794, -13123, -12525, -11948, -11505, -10855, -10388, -9961, -9708, -9272, -8929, -8671, -8346, -7972, -7879, -7791, -7651, -7403, -7381, -7364, -7168, -7057, -7014, -7067, -7167, -7169, -7315, -7360, -7320, -7492, -7450, -7499, -7526, -7568, -7694, -7605, -7567, -7596, -7595, -7498, -7477, -7469, -7288, -7091, -6980, -6789, -6520, -6340, -6105, -5862, -5755, -5426, -5110, -4895, -4522, -4181, -3829, -3625, -3341, -2728, -2612, -2528, -2194, -1944, -1743, -1534, -1374, -1053, -776, -900, -810, -722, -681, -722, -776, -1026, -1141, -1269, -1717, -2133, -2333, -2795, -3245, -3875, -4511, -5105, -5845, -6590, -7292, -8108, -9090, -9934, -10894, -11872, -12825, -13859, -14830, -15797, -16888, -17973, -19043, -20034, -20964, -21995, -22925, -23921, -24873, -25683, -26590, -27326, -28113, -28953, -29534, -30116, -30695, -31170, -31614, -31956, -32257, -32531, -32596, -32672, -32758, -32726, -32502, -32292, -31981, -31760, -31173, -30733, -30306, -29704, -29015, -28296, -27492, -26619, -25586, -24701, -23618, -22514, -21507, -20368, -19193, -18033, -16749, -15510, -14354, -12989, -11757, -10397, -9066, -7760, -6577, -5232, -4005, -2780, -1547, -265};