/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0014 256 samples */
 
const int16_t AKWF_ebass_0014_256_DATA [256] = 
{244, 850, 1513, 2235, 2996, 3781, 4572, 5347, 6091, 6792, 7441, 8028, 8551, 9015, 9427, 9789, 10118, 10429, 10731, 11039, 11373, 11745, 12163, 12626, 13134, 13682, 14262, 14856, 15450, 16026, 16565, 17045, 17457, 17784, 18015, 18142, 18156, 18052, 17827, 17488, 17032, 16462, 15796, 15033, 14191, 13292, 12344, 11360, 10361, 9343, 8318, 7283, 6221, 5133, 3998, 2798, 1520, 155, -1318, -2893, -4577, -6372, -8249, -10200, -12203, -14228, -16250, -18243, -20175, -22025, -23767, -25375, -26860, -28197, -29329, -30252, -31006, -31605, -32073, -32416, -32639, -32751, -32760, -32675, -32494, -32228, -31878, -31438, -30908, -30277, -29540, -28681, -27693, -26563, -25293, -23877, -22329, -20664, -18892, -17042, -15146, -13222, -11306, -9427, -7601, -5851, -4200, -2626, -1231, 833, 2299, 3405, 4469, 5442, 6336, 7158, 7923, 8631, 9281, 9877, 10424, 10922, 11377, 11790, 12159, 12488, 12778, 13018, 13203, 13325, 13372, 13334, 13199, 12965, 12636, 12208, 11693, 11108, 10472, 9803, 9123, 8456, 7818, 7225, 6684, 6198, 5771, 5396, 5067, 4773, 4506, 4253, 4008, 3752, 3481, 3184, 2858, 2496, 2099, 1662, 1188, 679, 149, -389, -926, -1446, -1922, -2346, -2695, -2953, -3112, -3163, -3106, -2951, -2705, -2386, -2021, -1623, -1210, -810, -436, -94, 205, 466, 693, 893, 1075, 1251, 1434, 1624, 1833, 2054, 2299, 2555, 2818, 3090, 3372, 3654, 3938, 4230, 4525, 4823, 5117, 5403, 5663, 5882, 6048, 6144, 6151, 6069, 5884, 5600, 5225, 4768, 4259, 3719, 3170, 2640, 2138, 1685, 1276, 914, 590, 294, 10, -267, -553, -853, -1164, -1479, -1794, -2095, -2367, -2599, -2785, -2919, -2998, -3022, -2999, -2933, -2835, -2714, -2586, -2459, -2339, -2230, -2134, -2044, -1954, -1853, -1729, -1571, -1358, -1079, -724, -275};