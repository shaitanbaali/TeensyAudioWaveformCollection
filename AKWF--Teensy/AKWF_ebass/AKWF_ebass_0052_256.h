/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0052 256 samples */
 
const int16_t AKWF_ebass_0052_256_DATA [256] = 
{681, 1683, 2436, 2705, 2646, 2949, 3793, 4634, 5229, 5682, 5929, 5936, 5929, 6198, 6783, 7585, 8398, 9197, 10132, 10958, 11487, 11909, 12432, 12920, 13416, 14187, 14937, 15280, 15514, 16114, 16945, 17404, 17388, 17478, 17912, 18097, 17799, 17754, 18283, 18728, 18715, 18764, 19305, 19770, 19546, 19037, 19040, 19631, 20148, 20261, 20198, 20122, 20012, 19796, 19491, 19193, 19017, 18979, 18952, 18835, 18773, 18834, 18707, 18202, 17757, 17861, 18194, 18063, 17478, 16962, 16856, 16987, 17044, 16981, 16910, 16723, 16313, 15995, 16118, 16368, 16271, 15996, 15999, 16460, 16988, 17035, 16691, 16549, 16713, 16910, 17134, 17343, 17300, 17025, 16878, 17081, 17299, 17210, 17109, 17574, 18516, 19190, 19384, 19582, 19755, 19609, 19522, 19996, 20644, 20683, 20077, 19526, 19481, 19455, 18888, 18121, 17730, 17564, 17211, 16728, 16262, 15840, 15599, 15485, 15364, 15125, 14626, 13782, 12702, 11691, 10995, 10601, 10110, 9248, 8470, 7867, 6650, 4443, 2138, 684, -59, -794, -1871, -3116, -4268, -5295, -6081, -6444, -6549, -6986, -7825, -8578, -9288, -10430, -12210, -14275, -16114, -17506, -18643, -19987, -21604, -23217, -24575, -25324, -25435, -25272, -25330, -25762, -26327, -26814, -27316, -28033, -28803, -29187, -29150, -29123, -29575, -30615, -31888, -32718, -32505, -31437, -30429, -30166, -30496, -30868, -30759, -30045, -29276, -28986, -29068, -29024, -28513, -27849, -27675, -28085, -28392, -28024, -27070, -25936, -24980, -24401, -24107, -23679, -22672, -21271, -20069, -19301, -18934, -18820, -18777, -18822, -18989, -19009, -18679, -18019, -17194, -16700, -16849, -17128, -16794, -15742, -14305, -12871, -12017, -11929, -12241, -12460, -12246, -11610, -10998, -10702, -10454, -9975, -9446, -9093, -8932, -8914, -8785, -8238, -7455, -6853, -6463, -6307, -6473, -6550, -6277, -5843, -5353, -4901, -4628, -4365, -3735, -2749, -1635, -408};