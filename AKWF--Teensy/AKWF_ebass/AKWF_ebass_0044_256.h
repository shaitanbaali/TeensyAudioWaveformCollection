/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0044 256 samples */
 
const int16_t AKWF_ebass_0044_256_DATA [256] = 
{612, 2494, 4352, 6199, 7998, 9685, 11329, 12900, 14418, 15839, 17159, 18346, 19521, 20509, 21442, 22345, 22863, 23423, 23980, 24268, 24419, 24533, 24517, 24294, 24052, 23822, 23382, 22964, 22463, 21833, 21107, 20448, 19733, 18851, 17955, 16990, 15986, 14903, 13824, 12710, 11470, 10274, 9032, 7796, 6570, 5379, 4120, 2892, 1640, 401, -800, -1999, -3081, -4129, -5241, -6166, -7150, -8034, -8943, -9821, -10687, -11498, -12283, -13155, -13906, -14656, -15408, -16173, -16928, -17690, -18371, -19004, -19512, -20149, -20659, -21178, -21754, -22314, -22887, -23413, -23960, -24513, -25171, -25701, -26307, -26885, -27443, -28022, -28651, -29178, -29637, -30205, -30682, -31040, -31409, -31767, -32061, -32295, -32499, -32644, -32650, -32764, -32627, -32437, -32255, -31979, -31684, -31309, -30876, -30394, -29779, -29200, -28527, -27761, -26992, -26163, -25253, -24329, -23327, -22319, -21246, -20194, -19115, -18064, -17032, -16035, -15073, -14153, -13272, -12437, -11674, -10978, -10305, -9642, -9025, -8603, -8117, -7756, -7389, -7113, -6812, -6567, -6438, -6344, -6288, -6271, -6399, -6545, -6653, -6909, -7152, -7426, -7699, -8033, -8230, -8613, -8852, -9014, -9137, -9205, -9231, -9175, -9062, -8873, -8674, -8420, -8126, -7726, -7404, -6942, -6501, -6066, -5643, -5238, -4742, -4279, -3735, -3242, -2686, -2111, -1609, -1029, -472, 143, 774, 1377, 1940, 2480, 3036, 3526, 3972, 4390, 4740, 4973, 5157, 5289, 5339, 5195, 5043, 4767, 4339, 3931, 3441, 2848, 2176, 1452, 669, -138, -1018, -1972, -2969, -4020, -5097, -6240, -7392, -8661, -9917, -11206, -12490, -13873, -15199, -16446, -17745, -18964, -20152, -21250, -22258, -23234, -24052, -24878, -25413, -25949, -26246, -26458, -26529, -26430, -26225, -25850, -25317, -24712, -23976, -23114, -22049, -20934, -19608, -18308, -16865, -15333, -13752, -12132, -10379, -8591, -6801, -4953, -3082, -1184};