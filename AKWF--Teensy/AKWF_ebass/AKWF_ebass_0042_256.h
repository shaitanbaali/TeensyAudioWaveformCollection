/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0042 256 samples */
 
const int16_t AKWF_ebass_0042_256_DATA [256] = 
{1169, 3017, 4706, 6251, 7625, 8900, 10041, 11075, 12104, 13090, 14023, 14971, 15942, 16925, 17926, 18958, 20026, 21076, 22126, 23175, 24173, 25177, 26130, 27052, 27959, 28794, 29585, 30302, 30934, 31457, 31849, 32136, 32271, 32308, 32164, 31893, 31536, 31076, 30529, 29928, 29248, 28504, 27716, 26809, 25795, 24761, 23626, 22410, 21163, 19848, 18464, 17068, 15635, 14203, 12738, 11271, 9817, 8378, 6960, 5598, 4324, 3162, 2063, 1182, 425, -221, -737, -1134, -1446, -1741, -2034, -2261, -2455, -2639, -2784, -2906, -2993, -3084, -3177, -3258, -3367, -3503, -3683, -3866, -4064, -4272, -4430, -4571, -4675, -4717, -4725, -4689, -4623, -4521, -4393, -4278, -4127, -3959, -3774, -3588, -3428, -3286, -3182, -3156, -3171, -3246, -3351, -3451, -3539, -3582, -3590, -3529, -3412, -3265, -3089, -2896, -2682, -2499, -2319, -2153, -2011, -1895, -1767, -1696, -1665, -1681, -1743, -1893, -2048, -2258, -2457, -2659, -2842, -3006, -3150, -3288, -3375, -3436, -3464, -3475, -3433, -3364, -3269, -3164, -3041, -2941, -2850, -2812, -2810, -2839, -2908, -2971, -3026, -3080, -3146, -3209, -3291, -3385, -3502, -3663, -3763, -3879, -4012, -4099, -4169, -4195, -4213, -4220, -4222, -4257, -4314, -4398, -4505, -4639, -4793, -4974, -5142, -5347, -5579, -5809, -6025, -6242, -6431, -6639, -6827, -7013, -7183, -7349, -7526, -7728, -7970, -8208, -8509, -8840, -9176, -9527, -9887, -10247, -10606, -10977, -11373, -11790, -12231, -12713, -13249, -13795, -14427, -15087, -15790, -16542, -17356, -18219, -19135, -20118, -21152, -22136, -23169, -24173, -25139, -26076, -27008, -27918, -28780, -29565, -30297, -30960, -31524, -32001, -32386, -32614, -32748, -32748, -32633, -32412, -32091, -31619, -31029, -30290, -29404, -28356, -27170, -25838, -24382, -22814, -21160, -19467, -17740, -16017, -14244, -12439, -10581, -8651, -6699, -4718, -2718, -693};