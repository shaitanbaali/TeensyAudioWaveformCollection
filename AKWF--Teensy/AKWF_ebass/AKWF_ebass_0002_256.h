/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0002 256 samples */
 
const int16_t AKWF_ebass_0002_256_DATA [256] = 
{475, 2124, 3790, 5495, 7223, 8964, 10708, 12440, 14159, 15850, 17498, 19104, 20651, 22128, 23534, 24853, 26079, 27210, 28236, 29155, 29968, 30672, 31267, 31762, 32155, 32450, 32649, 32753, 32761, 32676, 32495, 32219, 31850, 31390, 30844, 30214, 29509, 28731, 27890, 26994, 26044, 25046, 24009, 22929, 21809, 20657, 19471, 18255, 17020, 15764, 14496, 13224, 11944, 10667, 9396, 8128, 6867, 5613, 4365, 3123, 1891, 666, -542, -1730, -2896, -4027, -5121, -6178, -7189, -8160, -9093, -9989, -10854, -11692, -12502, -13291, -14056, -14794, -15504, -16182, -16821, -17424, -17987, -18512, -19007, -19475, -19922, -20353, -20771, -21178, -21576, -21961, -22331, -22683, -23008, -23307, -23581, -23827, -24050, -24258, -24455, -24647, -24843, -25040, -25245, -25453, -25655, -25854, -26041, -26210, -26359, -26484, -26585, -26665, -26724, -26767, -26795, -26808, -26808, -26790, -26751, -26688, -26595, -26466, -26298, -26088, -25838, -25550, -25229, -24876, -24500, -24103, -23692, -23260, -22810, -22341, -21848, -21323, -20768, -20175, -19542, -18870, -18156, -17405, -16621, -15804, -14960, -14099, -13216, -12324, -11424, -10520, -9619, -8727, -7843, -6975, -6123, -5285, -4467, -3665, -2876, -2101, -1343, -560, 242, 968, 1701, 2434, 3169, 3905, 4638, 5368, 6092, 6802, 7499, 8177, 8831, 9460, 10059, 10627, 11168, 11679, 12163, 12625, 13070, 13501, 13925, 14348, 14774, 15212, 15663, 16128, 16607, 17095, 17586, 18070, 18537, 18975, 19371, 19714, 19995, 20206, 20344, 20406, 20392, 20302, 20138, 19902, 19595, 19217, 18765, 18243, 17647, 16979, 16243, 15434, 14560, 13628, 12634, 11590, 10494, 9346, 8150, 6909, 5621, 4298, 2942, 1559, 168, -1220, -2597, -3936, -5223, -6441, -7567, -8592, -9499, -10277, -10922, -11427, -11785, -11997, -12065, -11986, -11765, -11404, -10905, -10269, -9501, -8607, -7587, -6454, -5215, -3878, -2458, -925};