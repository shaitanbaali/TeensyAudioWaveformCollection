/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0035 256 samples */
 
const int16_t AKWF_ebass_0035_256_DATA [256] = 
{472, 1956, 3286, 4594, 5947, 7208, 8405, 9529, 10622, 11733, 12805, 13856, 14901, 15920, 16863, 17744, 18571, 19349, 20035, 20619, 21132, 21584, 21972, 22185, 22285, 22274, 22150, 21881, 21562, 21113, 20620, 20042, 19372, 18613, 17804, 16966, 16131, 15273, 14382, 13494, 12623, 11712, 10813, 9906, 9038, 8213, 7407, 6653, 5951, 5309, 4709, 4133, 3635, 3212, 2909, 2656, 2484, 2339, 2233, 2112, 2067, 1985, 1963, 1954, 1964, 2029, 2065, 2077, 2054, 2049, 2049, 2023, 1992, 1901, 1841, 1662, 1487, 1339, 1168, 1087, 1004, 868, 757, 584, 405, 223, 33, -151, -332, -483, -628, -759, -902, -1041, -1095, -1157, -1270, -1383, -1499, -1619, -1739, -1873, -2019, -2169, -2323, -2466, -2614, -2750, -2855, -2916, -2973, -3009, -2989, -2972, -2917, -2865, -2823, -2744, -2698, -2633, -2566, -2479, -2351, -2221, -2071, -1932, -1835, -1733, -1687, -1668, -1684, -1725, -1748, -1735, -1727, -1747, -1750, -1744, -1762, -1760, -1758, -1685, -1567, -1433, -1313, -1191, -1056, -935, -832, -763, -722, -726, -750, -801, -880, -898, -886, -826, -785, -746, -687, -623, -601, -621, -667, -662, -700, -754, -780, -802, -783, -787, -838, -905, -1004, -1187, -1387, -1676, -2019, -2392, -2820, -3230, -3644, -4038, -4455, -4812, -5167, -5515, -5817, -6106, -6370, -6653, -6986, -7315, -7671, -8053, -8505, -8970, -9468, -10017, -10640, -11236, -11881, -12551, -13231, -13995, -14787, -15606, -16459, -17319, -18189, -19057, -19957, -20857, -21773, -22728, -23688, -24672, -25632, -26548, -27479, -28389, -29258, -30067, -30782, -31424, -31966, -32378, -32629, -32753, -32723, -32550, -32218, -31725, -31104, -30347, -29480, -28494, -27412, -26257, -25027, -23726, -22362, -20907, -19373, -17800, -16190, -14502, -12785, -11066, -9326, -7570, -5856, -4171, -2552, -963};