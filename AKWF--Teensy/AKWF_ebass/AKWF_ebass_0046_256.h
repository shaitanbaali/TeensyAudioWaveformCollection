/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0046 256 samples */
 
const int16_t AKWF_ebass_0046_256_DATA [256] = 
{1, 101, 403, 855, 1359, 1938, 2606, 3321, 4038, 4738, 5367, 5511, 5456, 5397, 5273, 4987, 4572, 4079, 3559, 2940, 2225, 1427, 506, -597, -1725, -2853, -4188, -5590, -6994, -8370, -9792, -11235, -12598, -14001, -15324, -16595, -17788, -18853, -19948, -20891, -21746, -22570, -23397, -24033, -24647, -25199, -25632, -26041, -26403, -26780, -26975, -27070, -27171, -27286, -27294, -27177, -27002, -26714, -26439, -26152, -25682, -25116, -24544, -23965, -23332, -22636, -21839, -21125, -20410, -19656, -18931, -18166, -17421, -16738, -15991, -15384, -14716, -13977, -13298, -12626, -11998, -11432, -10898, -10294, -9691, -9113, -8556, -8015, -7544, -7024, -6488, -5968, -5443, -4949, -4492, -4151, -3849, -3580, -3330, -3115, -2984, -2940, -2927, -2932, -2983, -3012, -3149, -3344, -3489, -3636, -3807, -3971, -4168, -4345, -4489, -4604, -4691, -4730, -4723, -4780, -4853, -4763, -4734, -4751, -4712, -4707, -4658, -4609, -4578, -4512, -4394, -4257, -4108, -3995, -3817, -3563, -3310, -3038, -2709, -2361, -2023, -1717, -1399, -1142, -913, -720, -498, -384, -452, -543, -673, -958, -1415, -1900, -2489, -3208, -4030, -4954, -5982, -7117, -8337, -9615, -10980, -12462, -13999, -15512, -17061, -18621, -20194, -21723, -23128, -24486, -25821, -27087, -28192, -29188, -30077, -30824, -31439, -31951, -32331, -32620, -32754, -32750, -32569, -32217, -31776, -31188, -30370, -29415, -28384, -27200, -25926, -24521, -23021, -21471, -19821, -18131, -16438, -14763, -13090, -11395, -9831, -8318, -6819, -5465, -4196, -3127, -2157, -1105, -232, 394, 959, 1375, 1625, 1824, 1864, 1781, 1627, 1290, 883, 409, -175, -828, -1581, -2278, -2894, -3596, -4273, -4832, -5265, -5685, -6071, -6365, -6516, -6579, -6547, -6428, -6234, -5925, -5535, -5143, -4699, -4219, -3719, -3199, -2690, -2214, -1758, -1338, -972, -658, -395, -204, -77, -12};