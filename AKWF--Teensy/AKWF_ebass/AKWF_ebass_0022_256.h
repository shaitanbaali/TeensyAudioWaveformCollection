/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0022 256 samples */
 
const int16_t AKWF_ebass_0022_256_DATA [256] = 
{530, 1799, 2476, 2928, 3390, 3977, 4655, 5438, 6367, 7320, 7669, 7494, 7417, 8051, 9210, 10170, 10779, 11321, 11965, 12457, 12303, 11740, 11447, 11792, 12485, 12950, 13170, 13302, 13250, 12731, 11937, 11495, 11757, 12182, 12269, 12073, 11887, 11717, 11254, 10497, 9916, 9721, 9750, 9692, 9669, 10072, 10613, 10481, 9310, 7587, 6544, 6417, 6656, 6685, 6618, 6431, 5854, 4843, 4110, 4187, 4762, 5394, 5751, 5692, 5073, 4021, 2986, 2655, 2988, 3470, 3256, 2454, 1847, 1895, 2153, 1853, 1164, 595, 205, -106, -293, -164, 111, -97, -1214, -2416, -2970, -2607, -1942, -1361, -1074, -1158, -1623, -2225, -2632, -2533, -2132, -2115, -2674, -3263, -3366, -3239, -3217, -3015, -2380, -1700, -1398, -1521, -1396, -452, 799, 1636, 1544, 1264, 1411, 2095, 3067, 3979, 4648, 4769, 4366, 3829, 3968, 4778, 5667, 5977, 5817, 5578, 5125, 4175, 3451, 3793, 5176, 6272, 6006, 4786, 3366, 2497, 1971, 1348, 612, 165, 14, -450, -1590, -2787, -3566, -3949, -4205, -4148, -3600, -2980, -3083, -3920, -5024, -6011, -7067, -8237, -8862, -8058, -6123, -4202, -3652, -4213, -4748, -4376, -3213, -1657, -17, 2056, 4628, 6241, 6786, 6959, 7806, 9164, 10494, 11620, 12742, 13822, 14423, 14231, 13964, 14192, 15119, 16284, 17316, 18551, 20396, 22077, 22649, 21804, 20548, 19294, 17890, 16416, 15372, 14710, 13725, 11507, 8233, 4879, 2215, 125, -1952, -4124, -6317, -8488, -10646, -12652, -14365, -15574, -16897, -18593, -20454, -22191, -23772, -25306, -26568, -27416, -28355, -29920, -31624, -32620, -32640, -32133, -31471, -30778, -30104, -29512, -28994, -28450, -27833, -27086, -26266, -25347, -24249, -23009, -21845, -20962, -20171, -18934, -17432, -16143, -15109, -13859, -12051, -10019, -8506, -7717, -7231, -6520, -5539, -4310, -2805, -1012};