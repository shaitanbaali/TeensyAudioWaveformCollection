/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0062 256 samples */
 
const int16_t AKWF_ebass_0062_256_DATA [256] = 
{948, 2768, 4424, 5962, 7390, 8714, 9943, 11082, 12138, 13120, 14025, 14864, 15640, 16352, 17009, 17614, 18168, 18676, 19140, 19564, 19951, 20305, 20625, 20915, 21180, 21417, 21631, 21821, 21989, 22137, 22262, 22371, 22460, 22533, 22589, 22627, 22652, 22662, 22657, 22638, 22606, 22560, 22502, 22436, 22355, 22263, 22164, 22054, 21938, 21815, 21684, 21547, 21405, 21258, 21105, 20949, 20788, 20624, 20455, 20282, 20106, 19926, 19741, 19552, 19359, 19159, 18956, 18748, 18535, 18315, 18092, 17861, 17628, 17388, 17144, 16898, 16650, 16397, 16144, 15891, 15634, 15377, 15119, 14860, 14596, 14327, 14054, 13769, 13478, 13178, 12863, 12540, 12208, 11865, 11518, 11163, 10808, 10454, 10102, 9754, 9414, 9082, 8755, 8441, 8132, 7834, 7543, 7254, 6971, 6696, 6420, 6146, 5876, 5602, 5327, 5051, 4772, 4496, 4224, 3953, 3689, 3437, 3198, 2982, 2783, 2608, 2461, 2347, 2261, 2204, 2177, 2178, 2205, 2254, 2326, 2416, 2522, 2646, 2782, 2930, 3090, 3267, 3458, 3664, 3887, 4130, 4394, 4681, 4990, 5315, 5664, 6030, 6410, 6800, 7204, 7611, 8015, 8412, 8795, 9155, 9488, 9787, 10047, 10262, 10427, 10535, 10584, 10572, 10491, 10342, 10123, 9830, 9460, 9014, 8485, 7868, 7157, 6342, 5410, 4359, 3168, 1828, 321, -1320, -3006, -4722, -6460, -8190, -9906, -11597, -13244, -14840, -16379, -17845, -19238, -20559, -21795, -22952, -24031, -25026, -25947, -26794, -27566, -28271, -28911, -29487, -30008, -30475, -30888, -31254, -31573, -31851, -32088, -32288, -32451, -32579, -32673, -32735, -32765, -32764, -32730, -32664, -32565, -32434, -32268, -32066, -31830, -31556, -31243, -30888, -30490, -30048, -29558, -29018, -28426, -27779, -27073, -26308, -25477, -24578, -23613, -22571, -21451, -20258, -18981, -17623, -16184, -14656, -13049, -11363, -9587, -7740, -5789, -3894, -2536, -814};