/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0023 256 samples */
 
const int16_t AKWF_ebass_0023_256_DATA [256] = 
{1131, 1786, 253, 1471, 6493, 8291, 4380, 1791, 5006, 10123, 10447, 7128, 6156, 9907, 14084, 13442, 10934, 11655, 13539, 13653, 12987, 11270, 11204, 15715, 17207, 13191, 11530, 12646, 12185, 11346, 12480, 13701, 13383, 11737, 8521, 9659, 15225, 15350, 10224, 8012, 9874, 11269, 9569, 4620, 684, 5769, 12869, 10255, 4942, 5460, 8570, 10249, 9675, 7169, 5695, 7974, 10140, 9636, 9329, 8797, 9537, 12175, 13578, 11997, 10018, 10345, 12126, 14317, 15041, 12057, 10769, 14616, 18947, 19964, 18169, 17035, 18240, 19801, 18868, 15853, 15074, 15903, 16616, 15996, 13061, 11599, 13052, 14524, 12735, 9938, 9000, 8409, 8088, 6783, 4778, 3931, 2638, 1484, 1684, 613, -3582, -7462, -7708, -7514, -9324, -11666, -14454, -14966, -12478, -13246, -17505, -17502, -13990, -11925, -12201, -15066, -17175, -13832, -9736, -11448, -14103, -13515, -11982, -9277, -6586, -8083, -9355, -5360, -1782, -956, 473, 1557, 4225, 7778, 7930, 6616, 8245, 11072, 12446, 14381, 15097, 13937, 15221, 17040, 16387, 16493, 18957, 21523, 23380, 24660, 23708, 22255, 23076, 24549, 25030, 24871, 24281, 22569, 22206, 23753, 22863, 20278, 18971, 19971, 21392, 20038, 17040, 15769, 17454, 17926, 13990, 9896, 9724, 12523, 12810, 8340, 4368, 4177, 4745, 2034, -2091, -3582, -3001, -3342, -6448, -9029, -8723, -8907, -11094, -13979, -15231, -14809, -14752, -16321, -18783, -18992, -18792, -21061, -22344, -21585, -20130, -20649, -24066, -26147, -25197, -24171, -25740, -28155, -28701, -27955, -26711, -27235, -29540, -30324, -28953, -28390, -30426, -32024, -31551, -29636, -28229, -30117, -32596, -32140, -29594, -27786, -28260, -29501, -29058, -26884, -26247, -27755, -27288, -24181, -22794, -23415, -22572, -20109, -18246, -18683, -19902, -18800, -15456, -14155, -15959, -15422, -10639, -7277, -8849, -11179, -8893, -3008, -99, -3124, -5831, -2944};