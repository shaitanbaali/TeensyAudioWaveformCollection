/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0003 256 samples */
 
const int16_t AKWF_ebass_0003_256_DATA [256] = 
{288, 1228, 2110, 2971, 3804, 4609, 5389, 6139, 6862, 7559, 8227, 8864, 9474, 10050, 10599, 11119, 11606, 12064, 12493, 12893, 13265, 13611, 13932, 14225, 14498, 14746, 14973, 15176, 15359, 15520, 15659, 15780, 15882, 15964, 16029, 16075, 16104, 16119, 16117, 16099, 16065, 16017, 15956, 15885, 15799, 15701, 15595, 15480, 15356, 15227, 15090, 14948, 14801, 14651, 14495, 14338, 14176, 14014, 13847, 13678, 13507, 13335, 13159, 12981, 12801, 12617, 12430, 12241, 12050, 11854, 11657, 11456, 11255, 11050, 10844, 10636, 10431, 10224, 10018, 9814, 9609, 9408, 9207, 9006, 8806, 8603, 8400, 8190, 7978, 7762, 7538, 7310, 7079, 6842, 6606, 6367, 6130, 5897, 5666, 5443, 5225, 5016, 4811, 4616, 4427, 4245, 4071, 3899, 3732, 3571, 3411, 3253, 3100, 2946, 2792, 2639, 2484, 2333, 2185, 2038, 1896, 1761, 1632, 1517, 1412, 1318, 1239, 1177, 1131, 1099, 1082, 1081, 1092, 1115, 1150, 1196, 1248, 1311, 1381, 1456, 1538, 1629, 1729, 1836, 1953, 2082, 2222, 2376, 2544, 2722, 2915, 3120, 3336, 3560, 3795, 4036, 4279, 4521, 4759, 4987, 5199, 5394, 5566, 5710, 5825, 5902, 5941, 5942, 5897, 5808, 5674, 5495, 5267, 4996, 4677, 4311, 3898, 3434, 2916, 2347, 1722, 1041, 303, -493, -1344, -2252, -3220, -4234, -5297, -6407, -7554, -8734, -9945, -11179, -12425, -13690, -14951, -16214, -17470, -18707, -19927, -21122, -22278, -23400, -24480, -25504, -26480, -27400, -28250, -29040, -29759, -30403, -30977, -31473, -31890, -32228, -32485, -32659, -32751, -32761, -32688, -32533, -32297, -31981, -31587, -31115, -30573, -29960, -29284, -28542, -27739, -26886, -25981, -25029, -24038, -23005, -21940, -20846, -19724, -18576, -17414, -16234, -15040, -13844, -12637, -11432, -10232, -9030, -7842, -6670, -5504, -4358, -3245, -2086, -1405, -576};