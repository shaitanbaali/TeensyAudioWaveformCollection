/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0013 256 samples */
 
const int16_t AKWF_ebass_0013_256_DATA [256] = 
{627, 2970, 5432, 7827, 10194, 12545, 14882, 17183, 19408, 21510, 23431, 25158, 26687, 28029, 29204, 30209, 31038, 31690, 32165, 32480, 32667, 32756, 32759, 32659, 32426, 32007, 31339, 30405, 29207, 27774, 26165, 24445, 22683, 20953, 19300, 17756, 16349, 15071, 13893, 12782, 11668, 10485, 9178, 7717, 6121, 4456, 2793, 1219, -203, -1456, -2543, -3494, -4346, -5121, -5836, -6533, -7246, -8013, -8844, -9714, -10567, -11337, -11951, -12378, -12626, -12738, -12800, -12899, -13095, -13427, -13895, -14471, -15119, -15784, -16397, -16891, -17193, -17250, -17041, -16597, -16003, -15374, -14839, -14498, -14398, -14531, -14836, -15232, -15620, -15908, -16031, -15947, -15644, -15155, -14546, -13912, -13360, -12995, -12887, -13053, -13449, -13978, -14526, -14968, -15209, -15189, -14896, -14369, -13700, -13009, -12419, -12037, -11938, -12140, -12593, -13204, -13864, -14470, -14947, -15237, -15298, -15119, -14719, -14166, -13561, -13016, -12622, -12436, -12451, -12605, -12806, -12943, -12917, -12668, -12171, -11445, -10521, -9458, -8344, -7275, -6348, -5636, -5171, -4940, -4882, -4895, -4863, -4696, -4337, -3791, -3082, -2237, -1275, -227, 881, 2003, 3089, 4115, 5059, 5908, 6664, 7322, 7868, 8283, 8570, 8730, 8778, 8727, 8600, 8422, 8214, 8010, 7849, 7778, 7826, 8004, 8298, 8689, 9148, 9655, 10192, 10736, 11269, 11780, 12253, 12658, 12968, 13151, 13186, 13064, 12784, 12341, 11747, 11025, 10226, 9439, 8787, 8400, 8382, 8778, 9559, 10627, 11833, 13040, 14132, 15018, 15640, 15956, 15947, 15621, 15020, 14212, 13288, 12328, 11378, 10430, 9445, 8370, 7164, 5827, 4386, 2887, 1388, -97, -1569, -2960, -4242, -5398, -6403, -7256, -8001, -8714, -9506, -10469, -11652, -13063, -14639, -16294, -17943, -19470, -20757, -21718, -22278, -22389, -22027, -21209, -19993, -18456, -16688, -14771, -12739, -10628, -8442, -6187, -3879, -1479};