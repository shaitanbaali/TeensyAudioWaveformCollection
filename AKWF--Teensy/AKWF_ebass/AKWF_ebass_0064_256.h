/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0064 256 samples */
 
const int16_t AKWF_ebass_0064_256_DATA [256] = 
{1267, 3655, 5774, 7697, 9442, 11025, 12464, 13770, 14959, 16042, 17024, 17917, 18729, 19463, 20131, 20737, 21284, 21779, 22226, 22630, 22994, 23326, 23622, 23889, 24130, 24345, 24537, 24708, 24858, 24988, 25100, 25194, 25273, 25337, 25385, 25419, 25440, 25449, 25445, 25429, 25400, 25360, 25311, 25252, 25180, 25100, 25012, 24916, 24812, 24702, 24585, 24463, 24334, 24201, 24063, 23920, 23773, 23622, 23465, 23305, 23141, 22971, 22797, 22618, 22434, 22245, 22049, 21849, 21641, 21427, 21208, 20981, 20750, 20510, 20266, 20018, 19766, 19509, 19250, 18989, 18723, 18456, 18185, 17912, 17632, 17346, 17053, 16747, 16433, 16105, 15761, 15404, 15036, 14653, 14263, 13863, 13459, 13054, 12648, 12246, 11849, 11460, 11075, 10701, 10335, 9977, 9627, 9278, 8934, 8599, 8260, 7924, 7590, 7250, 6909, 6563, 6212, 5865, 5520, 5175, 4839, 4516, 4210, 3930, 3673, 3446, 3256, 3107, 2995, 2921, 2885, 2887, 2922, 2985, 3079, 3197, 3335, 3496, 3672, 3863, 4070, 4298, 4542, 4807, 5091, 5401, 5736, 6097, 6486, 6893, 7328, 7781, 8248, 8726, 9216, 9709, 10194, 10667, 11121, 11547, 11936, 12284, 12585, 12833, 13023, 13146, 13203, 13189, 13096, 12925, 12673, 12333, 11902, 11380, 10754, 10017, 9160, 8164, 7012, 5692, 4171, 2429, 429, -1760, -3963, -6149, -8308, -10403, -12421, -14353, -16179, -17891, -19490, -20965, -22320, -23562, -24684, -25701, -26617, -27434, -28166, -28817, -29392, -29903, -30352, -30746, -31092, -31393, -31654, -31882, -32076, -32241, -32381, -32496, -32589, -32662, -32716, -32750, -32766, -32765, -32746, -32710, -32655, -32580, -32485, -32368, -32230, -32066, -31876, -31655, -31404, -31117, -30793, -30426, -30012, -29548, -29028, -28446, -27796, -27070, -26265, -25369, -24376, -23283, -22073, -20745, -19291, -17697, -15964, -14089, -12051, -9865, -7483, -5100, -3354, -1087};