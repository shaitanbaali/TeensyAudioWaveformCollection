/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0063 256 samples */
 
const int16_t AKWF_ebass_0063_256_DATA [256] = 
{1085, 3150, 5007, 6715, 8285, 9727, 11054, 12271, 13390, 14422, 15367, 16235, 17031, 17757, 18424, 19033, 19587, 20093, 20553, 20970, 21350, 21695, 22007, 22288, 22544, 22773, 22978, 23161, 23322, 23462, 23582, 23685, 23770, 23839, 23892, 23929, 23951, 23961, 23957, 23939, 23908, 23865, 23811, 23747, 23669, 23583, 23488, 23383, 23272, 23154, 23030, 22898, 22761, 22620, 22472, 22321, 22166, 22006, 21842, 21674, 21501, 21325, 21144, 20959, 20769, 20572, 20371, 20165, 19953, 19734, 19511, 19280, 19046, 18805, 18560, 18311, 18060, 17804, 17547, 17288, 17025, 16762, 16497, 16229, 15957, 15680, 15395, 15100, 14797, 14483, 14154, 13813, 13463, 13102, 12734, 12358, 11979, 11600, 11224, 10851, 10484, 10125, 9772, 9431, 9096, 8770, 8452, 8136, 7826, 7524, 7220, 6918, 6619, 6316, 6012, 5705, 5394, 5088, 4784, 4480, 4185, 3902, 3633, 3389, 3166, 2967, 2802, 2674, 2576, 2512, 2481, 2482, 2512, 2568, 2649, 2752, 2871, 3011, 3164, 3331, 3512, 3711, 3924, 4156, 4406, 4678, 4974, 5293, 5637, 5999, 6385, 6790, 7208, 7638, 8082, 8527, 8968, 9399, 9814, 10205, 10564, 10886, 11165, 11395, 11572, 11686, 11740, 11727, 11641, 11480, 11247, 10931, 10534, 10053, 9478, 8807, 8030, 7134, 6104, 4934, 3600, 2085, 367, -1509, -3418, -5339, -7263, -9158, -11013, -12817, -14553, -16209, -17785, -19265, -20650, -21943, -23135, -24236, -25246, -26165, -27002, -27761, -28444, -29060, -29611, -30101, -30539, -30927, -31266, -31564, -31822, -32045, -32234, -32392, -32520, -32621, -32695, -32742, -32766, -32764, -32738, -32686, -32610, -32507, -32376, -32218, -32029, -31809, -31556, -31267, -30939, -30571, -30161, -29702, -29193, -28630, -28009, -27328, -26577, -25753, -24856, -23875, -22805, -21650, -20395, -19043, -17586, -16020, -14348, -12570, -10671, -8668, -6524, -4414, -2887, -932};