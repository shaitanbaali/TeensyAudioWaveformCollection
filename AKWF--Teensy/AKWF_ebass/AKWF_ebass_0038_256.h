/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0038 256 samples */
 
const int16_t AKWF_ebass_0038_256_DATA [256] = 
{1038, 2910, 4675, 6341, 7944, 9473, 10828, 12050, 13162, 14188, 15149, 16053, 16971, 17882, 18775, 19730, 20599, 21501, 22409, 23299, 24144, 25025, 25905, 26760, 27583, 28381, 29162, 29888, 30544, 31084, 31555, 31912, 32178, 32386, 32525, 32570, 32518, 32367, 32086, 31680, 31157, 30517, 29765, 28914, 27956, 26880, 25711, 24424, 23083, 21659, 20207, 18706, 17200, 15699, 14219, 12773, 11387, 10050, 8771, 7490, 6257, 5110, 4010, 2977, 2024, 1220, 531, -41, -534, -978, -1343, -1670, -1952, -2195, -2372, -2528, -2665, -2722, -2763, -2767, -2739, -2689, -2612, -2568, -2535, -2498, -2498, -2470, -2404, -2311, -2210, -2110, -1997, -1916, -1822, -1747, -1693, -1625, -1520, -1432, -1382, -1189, -1057, -946, -857, -827, -833, -845, -880, -904, -953, -964, -1020, -1067, -1131, -1219, -1308, -1446, -1599, -1667, -1719, -1780, -1812, -1831, -1854, -1890, -1978, -2028, -2122, -2255, -2392, -2565, -2724, -2902, -3082, -3226, -3396, -3551, -3716, -3874, -4016, -4146, -4235, -4318, -4385, -4453, -4530, -4609, -4678, -4764, -4854, -4906, -4989, -5075, -5169, -5290, -5393, -5541, -5696, -5864, -6076, -6304, -6522, -6710, -6862, -6974, -7047, -7086, -7087, -7062, -7030, -6970, -6935, -6895, -6895, -6896, -6913, -6966, -7019, -7101, -7184, -7283, -7407, -7544, -7703, -7857, -8021, -8162, -8344, -8552, -8805, -9108, -9453, -9801, -10186, -10594, -11027, -11472, -11862, -12286, -12688, -13122, -13569, -14029, -14529, -15015, -15537, -16096, -16665, -17305, -18016, -18774, -19593, -20452, -21351, -22252, -23143, -24028, -24917, -25787, -26639, -27450, -28211, -28931, -29577, -30172, -30722, -31242, -31658, -32034, -32337, -32572, -32744, -32766, -32673, -32393, -31945, -31313, -30502, -29538, -28406, -27088, -25611, -23993, -22257, -20442, -18549, -16644, -14688, -12756, -10774, -8785, -6766, -4747, -2761, -777};