/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0049 256 samples */
 
const int16_t AKWF_ebass_0049_256_DATA [256] = 
{972, 3770, 5742, 7223, 8586, 10299, 12742, 15941, 18912, 20677, 20992, 20370, 19957, 20706, 22555, 25128, 28060, 30593, 32196, 32760, 32638, 32103, 31262, 30171, 29258, 28645, 28004, 27210, 26119, 24638, 22891, 21214, 19908, 18941, 17895, 16197, 13668, 10466, 7022, 3883, 1780, 1367, 2417, 3501, 3270, 1455, -1806, -6205, -10536, -13538, -14754, -14612, -13677, -12434, -11538, -11432, -11888, -12545, -13128, -13267, -12596, -11265, -9908, -8776, -7778, -6834, -5802, -4293, -2054, 810, 3975, 6909, 8780, 8887, 7842, 6944, 7165, 8951, 12289, 16475, 20016, 21653, 21343, 19976, 18541, 17878, 18232, 19316, 20352, 20796, 20686, 19991, 18594, 16719, 14938, 13431, 12192, 11485, 11345, 11067, 9660, 6933, 3751, 1190, 322, 1449, 3589, 4971, 4465, 2215, -1058, -4621, -7584, -9273, -9483, -8834, -7961, -7067, -6382, -6329, -6837, -7354, -7369, -6511, -4691, -2201, 219, 1844, 2491, 2693, 3074, 4051, 5845, 8260, 10505, 11959, 12365, 11655, 10238, 9126, 9004, 9718, 10889, 12543, 14194, 14659, 13190, 10407, 7061, 3595, 462, -1900, -3528, -5143, -7082, -9173, -11429, -14047, -16948, -20041, -23286, -26292, -28404, -29499, -29946, -30117, -30206, -30308, -30359, -30021, -28991, -27540, -26042, -24747, -23947, -23800, -23727, -22682, -20499, -17838, -15103, -12203, -9085, -6040, -3408, -1309, 354, 1878, 3681, 6045, 8951, 12155, 15089, 16776, 16716, 15184, 12856, 10415, 8544, 7766, 8034, 8593, 8797, 8333, 6997, 4940, 2844, 1175, -46, -1172, -2272, -3083, -3759, -4528, -5574, -6693, -7682, -8557, -9530, -10538, -11486, -12720, -14628, -16941, -18803, -19594, -19151, -17588, -15677, -14705, -15513, -17798, -20449, -22326, -22981, -22559, -21688, -21038, -21011, -21457, -22032, -22442, -22397, -21703, -20352, -18612, -16804, -15136, -13906, -13245, -12906, -12316, -11075, -9045, -6045, -2407};