/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0060 256 samples */
 
const int16_t AKWF_ebass_0060_256_DATA [256] = 
{493, 2074, 3505, 4859, 6127, 7316, 8436, 9482, 10464, 11385, 12246, 13047, 13798, 14490, 15137, 15737, 16289, 16801, 17269, 17701, 18097, 18461, 18793, 19094, 19372, 19620, 19846, 20047, 20225, 20383, 20518, 20634, 20732, 20811, 20873, 20916, 20944, 20958, 20956, 20938, 20907, 20861, 20802, 20735, 20652, 20557, 20455, 20343, 20222, 20096, 19962, 19821, 19675, 19525, 19368, 19209, 19043, 18877, 18705, 18530, 18352, 18171, 17985, 17796, 17603, 17404, 17201, 16995, 16785, 16567, 16347, 16120, 15892, 15659, 15421, 15180, 14940, 14696, 14452, 14209, 13962, 13717, 13471, 13223, 12975, 12721, 12465, 12199, 11928, 11649, 11357, 11058, 10753, 10437, 10119, 9794, 9470, 9147, 8826, 8512, 8203, 7904, 7609, 7327, 7051, 6784, 6526, 6269, 6018, 5776, 5534, 5293, 5057, 4819, 4580, 4341, 4099, 3859, 3624, 3391, 3161, 2944, 2736, 2548, 2374, 2221, 2092, 1989, 1913, 1859, 1831, 1829, 1848, 1886, 1944, 2020, 2106, 2209, 2324, 2447, 2582, 2730, 2891, 3065, 3254, 3460, 3684, 3926, 4192, 4471, 4771, 5089, 5418, 5759, 6113, 6474, 6834, 7188, 7534, 7862, 8167, 8443, 8685, 8887, 9047, 9155, 9209, 9210, 9148, 9023, 8837, 8585, 8264, 7877, 7416, 6880, 6268, 5568, 4773, 3883, 2881, 1764, 520, -842, -2264, -3730, -5240, -6767, -8306, -9848, -11377, -12886, -14365, -15805, -17196, -18542, -19824, -21048, -22210, -23304, -24334, -25298, -26191, -27023, -27792, -28493, -29135, -29721, -30245, -30717, -31135, -31499, -31818, -32087, -32310, -32488, -32622, -32711, -32759, -32764, -32726, -32647, -32524, -32358, -32148, -31893, -31595, -31250, -30860, -30421, -29933, -29397, -28810, -28171, -27482, -26735, -25934, -25080, -24165, -23190, -22160, -21068, -19912, -18702, -17426, -16093, -14706, -13253, -11751, -10205, -8598, -6948, -5280, -3464, -2366, -979};