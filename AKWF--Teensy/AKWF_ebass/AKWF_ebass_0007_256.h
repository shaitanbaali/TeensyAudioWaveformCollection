/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0007 256 samples */
 
const int16_t AKWF_ebass_0007_256_DATA [256] = 
{250, 1135, 1989, 2852, 3722, 4585, 5463, 6326, 7194, 8042, 8877, 9691, 10468, 11199, 11873, 12488, 13027, 13501, 13901, 14246, 14547, 14814, 15070, 15320, 15575, 15836, 16109, 16383, 16652, 16915, 17164, 17401, 17617, 17819, 18010, 18186, 18351, 18501, 18633, 18738, 18818, 18867, 18888, 18887, 18867, 18839, 18805, 18773, 18743, 18716, 18680, 18630, 18563, 18467, 18340, 18184, 17996, 17784, 17550, 17293, 17018, 16719, 16396, 16045, 15660, 15245, 14803, 14337, 13861, 13384, 12923, 12485, 12082, 11725, 11413, 11147, 10925, 10740, 10591, 10474, 10376, 10295, 10224, 10150, 10059, 9939, 9778, 9566, 9297, 8967, 8573, 8127, 7639, 7117, 6580, 6041, 5504, 4985, 4490, 4022, 3593, 3200, 2846, 2540, 2274, 2048, 1866, 1717, 1599, 1510, 1440, 1385, 1342, 1307, 1285, 1271, 1262, 1261, 1259, 1256, 1247, 1228, 1203, 1168, 1122, 1069, 1011, 950, 885, 819, 746, 670, 595, 519, 447, 391, 360, 367, 426, 545, 736, 995, 1326, 1722, 2171, 2665, 3183, 3718, 4266, 4816, 5356, 5866, 6323, 6716, 7040, 7281, 7431, 7494, 7466, 7357, 7178, 6939, 6649, 6321, 5956, 5560, 5137, 4685, 4200, 3685, 3145, 2584, 2014, 1447, 884, 329, -213, -752, -1297, -1864, -2472, -3127, -3845, -4637, -5504, -6444, -7459, -8542, -9684, -10882, -12125, -13410, -14735, -16080, -17438, -18805, -20150, -21463, -22732, -23932, -25063, -26121, -27095, -27994, -28818, -29568, -30247, -30852, -31377, -31823, -32180, -32450, -32636, -32738, -32767, -32735, -32654, -32533, -32381, -32201, -31997, -31754, -31471, -31143, -30750, -30297, -29772, -29177, -28514, -27783, -26989, -26129, -25215, -24240, -23209, -22115, -20964, -19767, -18521, -17254, -15968, -14687, -13423, -12195, -11008, -9865, -8781, -7727, -6727, -5753, -4817, -3907, -3011, -2153, -1266, -484};