/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0055 256 samples */
 
const int16_t AKWF_ebass_0055_256_DATA [256] = 
{133, 569, 1067, 1566, 1954, 2239, 2534, 2944, 3518, 4284, 5235, 6371, 7606, 8824, 9973, 11059, 12054, 12871, 13502, 13883, 14042, 14069, 14142, 14427, 14903, 15499, 16175, 16907, 17674, 18516, 19379, 20205, 20905, 21462, 21887, 22280, 22637, 22932, 23090, 23099, 23196, 23560, 24286, 25209, 26063, 26655, 26972, 27127, 27340, 27643, 27898, 28056, 28158, 28204, 28270, 28334, 28387, 28359, 28205, 27830, 27186, 26298, 25322, 24413, 23672, 23001, 22243, 21369, 20376, 19343, 18428, 17657, 16917, 16072, 15179, 14341, 13470, 12331, 10783, 8863, 6706, 4648, 2960, 1514, -65, -2068, -4408, -6895, -9226, -11180, -12681, -13910, -15158, -16491, -17820, -19049, -20160, -21150, -22195, -23398, -24793, -26214, -27491, -28565, -29488, -30323, -31083, -31731, -32112, -32211, -32142, -32137, -32181, -32244, -32275, -32231, -32174, -32217, -32420, -32691, -32758, -32505, -31925, -31060, -29921, -28643, -27345, -26071, -24738, -23345, -21937, -20597, -19442, -18617, -17964, -17363, -16580, -15603, -14526, -13464, -12437, -11342, -10008, -8353, -6516, -4760, -3274, -2006, -897, 99, 983, 1697, 2237, 2724, 3322, 4059, 4830, 5553, 6203, 6873, 7644, 8559, 9483, 10283, 10836, 11207, 11424, 11527, 11654, 11885, 12179, 12374, 12361, 12121, 11739, 11472, 11466, 11665, 11858, 11830, 11446, 10850, 10252, 9790, 9377, 8880, 8236, 7453, 6542, 5589, 4689, 3853, 3063, 2299, 1619, 1049, 552, -16, -782, -1718, -2687, -3528, -4119, -4576, -5076, -5749, -6562, -7321, -7901, -8259, -8572, -8991, -9628, -10459, -11467, -12519, -13427, -14155, -14683, -15070, -15304, -15388, -15333, -15121, -14730, -14143, -13469, -12868, -12414, -12146, -12027, -11939, -11856, -11809, -11845, -11938, -11936, -11736, -11300, -10727, -10110, -9494, -8746, -7741, -6624, -5525, -4536, -3615, -2798, -2027, -1321, -820, -579, -555, -534, -300};