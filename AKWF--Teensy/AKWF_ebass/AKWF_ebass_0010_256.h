/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0010 256 samples */
 
const int16_t AKWF_ebass_0010_256_DATA [256] = 
{814, 2561, 4188, 5774, 7283, 8742, 10140, 11484, 12780, 14026, 15226, 16382, 17502, 18577, 19620, 20627, 21595, 22529, 23418, 24256, 25036, 25753, 26393, 26960, 27447, 27854, 28188, 28447, 28642, 28776, 28853, 28880, 28854, 28780, 28662, 28498, 28291, 28048, 27769, 27460, 27123, 26760, 26374, 25965, 25535, 25082, 24609, 24116, 23608, 23085, 22550, 22011, 21464, 20914, 20362, 19809, 19256, 18702, 18149, 17599, 17054, 16510, 15973, 15440, 14908, 14374, 13835, 13283, 12715, 12127, 11512, 10870, 10199, 9498, 8768, 8015, 7239, 6448, 5649, 4850, 4061, 3290, 2549, 1853, 1203, 609, 76, -399, -817, -1182, -1499, -1776, -2021, -2243, -2446, -2636, -2822, -3011, -3207, -3421, -3655, -3917, -4209, -4528, -4877, -5249, -5637, -6032, -6428, -6815, -7186, -7538, -7866, -8169, -8443, -8688, -8905, -9092, -9243, -9359, -9440, -9482, -9485, -9451, -9383, -9285, -9155, -8999, -8819, -8615, -8390, -8150, -7895, -7632, -7370, -7115, -6874, -6659, -6476, -6321, -6198, -6104, -6026, -5957, -5884, -5799, -5691, -5550, -5370, -5146, -4874, -4551, -4178, -3753, -3273, -2744, -2165, -1539, -874, -179, 538, 1265, 1990, 2700, 3382, 4024, 4615, 5149, 5626, 6042, 6390, 6662, 6854, 6961, 6985, 6927, 6793, 6593, 6335, 6029, 5688, 5319, 4932, 4530, 4113, 3682, 3230, 2753, 2243, 1694, 1105, 471, -210, -939, -1718, -2548, -3426, -4359, -5350, -6400, -7510, -8682, -9912, -11195, -12525, -13886, -15274, -16674, -18073, -19464, -20834, -22173, -23477, -24733, -25927, -27051, -28095, -29043, -29890, -30627, -31250, -31760, -32162, -32454, -32648, -32751, -32764, -32696, -32545, -32316, -32007, -31624, -31164, -30634, -30037, -29370, -28639, -27842, -26972, -26028, -25003, -23884, -22669, -21360, -19943, -18439, -16844, -15174, -13448, -11681, -9887, -8079, -6290, -4497, -2758, -999};