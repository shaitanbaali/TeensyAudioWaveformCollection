/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0018 256 samples */
 
const int16_t AKWF_ebass_0018_256_DATA [256] = 
{419, 1280, 2106, 2917, 3708, 4480, 5234, 5964, 6676, 7366, 8033, 8680, 9305, 9905, 10484, 11041, 11574, 12087, 12576, 13042, 13487, 13910, 14310, 14690, 15048, 15384, 15702, 15997, 16274, 16531, 16769, 16989, 17190, 17373, 17540, 17689, 17821, 17938, 18039, 18124, 18194, 18250, 18291, 18320, 18334, 18335, 18325, 18302, 18267, 18221, 18164, 18096, 18019, 17932, 17835, 17729, 17614, 17490, 17359, 17219, 17071, 16915, 16752, 16582, 16403, 16219, 16028, 15830, 15627, 15418, 15202, 14983, 14758, 14529, 14297, 14062, 13822, 13581, 13337, 13091, 12842, 12593, 12342, 12090, 11837, 11583, 11330, 11075, 10821, 10567, 10312, 10060, 9808, 9556, 9308, 9062, 8818, 8576, 8338, 8105, 7876, 7651, 7432, 7220, 7012, 6812, 6619, 6432, 6253, 6083, 5920, 5765, 5619, 5481, 5353, 5234, 5125, 5025, 4937, 4858, 4789, 4733, 4686, 4652, 4628, 4616, 4615, 4625, 4646, 4677, 4718, 4769, 4828, 4893, 4966, 5043, 5125, 5208, 5293, 5377, 5459, 5537, 5610, 5674, 5730, 5775, 5807, 5824, 5824, 5807, 5768, 5707, 5622, 5510, 5370, 5201, 5000, 4764, 4495, 4189, 3845, 3464, 3043, 2582, 2081, 1540, 957, 336, -326, -1026, -1763, -2539, -3350, -4192, -5066, -5972, -6900, -7856, -8833, -9827, -10839, -11864, -12895, -13936, -14978, -16018, -17058, -18087, -19105, -20112, -21097, -22062, -23003, -23916, -24797, -25645, -26455, -27226, -27956, -28639, -29277, -29866, -30403, -30889, -31322, -31698, -32020, -32286, -32492, -32643, -32735, -32769, -32746, -32666, -32529, -32336, -32089, -31788, -31434, -31029, -30575, -30074, -29529, -28944, -28317, -27655, -26957, -26225, -25463, -24671, -23852, -23011, -22146, -21259, -20356, -19435, -18500, -17555, -16596, -15630, -14660, -13682, -12702, -11723, -10742, -9765, -8793, -7823, -6862, -5910, -4966, -4033, -3113, -2205, -1314, -421};