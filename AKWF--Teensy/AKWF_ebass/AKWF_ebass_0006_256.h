/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0006 256 samples */
 
const int16_t AKWF_ebass_0006_256_DATA [256] = 
{509, 1308, 2128, 3105, 3907, 4625, 5382, 6080, 6787, 7463, 8125, 8771, 9393, 10002, 10586, 11160, 11709, 12245, 12757, 13251, 13729, 14184, 14623, 15036, 15435, 15810, 16167, 16503, 16818, 17117, 17393, 17652, 17891, 18113, 18314, 18500, 18666, 18812, 18948, 19062, 19161, 19243, 19309, 19360, 19394, 19414, 19418, 19409, 19384, 19350, 19301, 19239, 19165, 19083, 18991, 18886, 18776, 18654, 18526, 18391, 18249, 18098, 17938, 17777, 17607, 17428, 17241, 17048, 16850, 16644, 16428, 16207, 15980, 15747, 15509, 15263, 15012, 14759, 14501, 14239, 13977, 13714, 13452, 13186, 12927, 12670, 12415, 12163, 11918, 11678, 11443, 11211, 10988, 10772, 10560, 10356, 10158, 9967, 9782, 9599, 9425, 9261, 9100, 8944, 8793, 8651, 8516, 8385, 8264, 8151, 8047, 7949, 7859, 7783, 7711, 7647, 7593, 7548, 7512, 7484, 7466, 7454, 7449, 7453, 7464, 7478, 7495, 7518, 7540, 7563, 7586, 7603, 7618, 7628, 7627, 7618, 7597, 7561, 7510, 7439, 7349, 7240, 7109, 6952, 6772, 6567, 6334, 6075, 5790, 5478, 5140, 4774, 4381, 3959, 3511, 3033, 2530, 1999, 1440, 853, 240, -400, -1072, -1769, -2492, -3245, -4022, -4824, -5651, -6502, -7370, -8260, -9170, -10090, -11027, -11975, -12925, -13887, -14852, -15811, -16769, -17720, -18661, -19590, -20506, -21401, -22280, -23134, -23964, -24768, -25540, -26282, -26991, -27664, -28301, -28899, -29460, -29978, -30456, -30889, -31280, -31628, -31930, -32185, -32395, -32560, -32677, -32747, -32768, -32746, -32672, -32555, -32391, -32176, -31925, -31625, -31282, -30898, -30470, -30003, -29501, -28959, -28379, -27773, -27127, -26454, -25753, -25022, -24270, -23490, -22692, -21875, -21038, -20181, -19318, -18439, -17544, -16647, -15735, -14821, -13899, -12975, -12047, -11119, -10194, -9263, -8342, -7416, -6505, -5596, -4694, -3803, -2921, -2059, -1193, -348};