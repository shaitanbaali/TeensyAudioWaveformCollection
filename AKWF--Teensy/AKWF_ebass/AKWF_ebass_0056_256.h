/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0056 256 samples */
 
const int16_t AKWF_ebass_0056_256_DATA [256] = 
{370, 1569, 2677, 3743, 4760, 5729, 6656, 7538, 8378, 9177, 9934, 10650, 11329, 11964, 12561, 13124, 13646, 14135, 14587, 15006, 15394, 15753, 16085, 16385, 16664, 16915, 17145, 17351, 17534, 17696, 17835, 17957, 18058, 18141, 18205, 18250, 18279, 18294, 18291, 18273, 18240, 18193, 18131, 18061, 17975, 17877, 17772, 17655, 17531, 17402, 17265, 17120, 16971, 16820, 16660, 16501, 16335, 16169, 15997, 15823, 15646, 15467, 15284, 15099, 14910, 14716, 14520, 14322, 14119, 13909, 13701, 13485, 13270, 13050, 12827, 12602, 12378, 12152, 11927, 11704, 11479, 11255, 11032, 10809, 10586, 10358, 10131, 9894, 9653, 9409, 9154, 8893, 8628, 8355, 8082, 7804, 7528, 7255, 6984, 6721, 6463, 6214, 5971, 5738, 5512, 5293, 5082, 4875, 4672, 4476, 4283, 4089, 3901, 3711, 3522, 3333, 3141, 2953, 2770, 2587, 2408, 2240, 2078, 1934, 1801, 1682, 1582, 1505, 1445, 1405, 1383, 1382, 1397, 1426, 1470, 1527, 1594, 1674, 1761, 1857, 1961, 2074, 2200, 2335, 2481, 2641, 2817, 3006, 3215, 3436, 3673, 3925, 4189, 4462, 4749, 5041, 5333, 5624, 5908, 6180, 6433, 6663, 6866, 7036, 7171, 7261, 7307, 7309, 7256, 7150, 6994, 6782, 6513, 6191, 5811, 5372, 4873, 4308, 3674, 2970, 2191, 1333, 390, -633, -1715, -2852, -4046, -5279, -6549, -7850, -9170, -10505, -11847, -13188, -14516, -15835, -17124, -18388, -19620, -20809, -21959, -23063, -24110, -25109, -26052, -26932, -27757, -28522, -29220, -29858, -30434, -30943, -31392, -31778, -32099, -32357, -32553, -32685, -32756, -32762, -32707, -32590, -32409, -32168, -31865, -31499, -31076, -30594, -30055, -29457, -28802, -28095, -27337, -26527, -25669, -24759, -23806, -22808, -21768, -20684, -19566, -18408, -17213, -15994, -14739, -13460, -12161, -10836, -9498, -8156, -6793, -5428, -4078, -2645, -1793, -738};