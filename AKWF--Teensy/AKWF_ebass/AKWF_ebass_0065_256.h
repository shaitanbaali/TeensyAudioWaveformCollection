/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0065 256 samples */
 
const int16_t AKWF_ebass_0065_256_DATA [256] = 
{1448, 4154, 6522, 8645, 10548, 12255, 13789, 15167, 16406, 17524, 18529, 19434, 20250, 20981, 21641, 22235, 22767, 23246, 23676, 24062, 24409, 24721, 25001, 25250, 25476, 25675, 25854, 26011, 26149, 26269, 26372, 26458, 26530, 26588, 26633, 26663, 26682, 26690, 26687, 26672, 26646, 26610, 26564, 26511, 26445, 26371, 26291, 26202, 26106, 26005, 25898, 25784, 25665, 25542, 25413, 25280, 25141, 25000, 24853, 24701, 24547, 24387, 24221, 24052, 23876, 23694, 23507, 23315, 23114, 22907, 22693, 22473, 22248, 22014, 21774, 21530, 21282, 21028, 20770, 20509, 20244, 19977, 19704, 19429, 19147, 18857, 18560, 18248, 17926, 17590, 17236, 16868, 16487, 16090, 15683, 15264, 14840, 14413, 13984, 13558, 13136, 12720, 12308, 11908, 11514, 11128, 10748, 10370, 9997, 9631, 9262, 8894, 8527, 8154, 7778, 7396, 7008, 6623, 6240, 5856, 5481, 5120, 4776, 4462, 4174, 3918, 3704, 3536, 3410, 3326, 3285, 3287, 3327, 3398, 3504, 3638, 3793, 3975, 4173, 4387, 4620, 4875, 5149, 5444, 5762, 6107, 6479, 6881, 7310, 7761, 8240, 8737, 9248, 9770, 10304, 10837, 11362, 11871, 12358, 12813, 13227, 13598, 13918, 14180, 14380, 14510, 14570, 14555, 14457, 14276, 14010, 13650, 13193, 12636, 11964, 11170, 10242, 9157, 7891, 6430, 4733, 2770, 491, -2010, -4499, -6938, -9315, -11587, -13744, -15776, -17666, -19408, -21008, -22458, -23766, -24944, -25990, -26919, -27741, -28463, -29098, -29652, -30134, -30555, -30920, -31235, -31507, -31742, -31942, -32115, -32261, -32384, -32487, -32571, -32639, -32691, -32730, -32754, -32766, -32766, -32752, -32726, -32686, -32632, -32563, -32478, -32375, -32253, -32110, -31943, -31749, -31527, -31271, -30978, -30645, -30264, -29829, -29337, -28778, -28143, -27428, -26618, -25704, -24681, -23530, -22244, -20810, -19212, -17445, -15499, -13351, -11007, -8409, -5772, -3815, -1244};