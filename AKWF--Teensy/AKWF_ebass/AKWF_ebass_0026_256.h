/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0026 256 samples */
 
const int16_t AKWF_ebass_0026_256_DATA [256] = 
{409, 1197, 1958, 2720, 3479, 4234, 4990, 5742, 6490, 7235, 7970, 8704, 9437, 10161, 10880, 11592, 12299, 13001, 13696, 14383, 15061, 15732, 16397, 17054, 17702, 18340, 18968, 19588, 20197, 20798, 21387, 21963, 22531, 23085, 23629, 24162, 24678, 25183, 25676, 26155, 26621, 27072, 27505, 27926, 28331, 28721, 29095, 29452, 29790, 30115, 30422, 30711, 30982, 31234, 31468, 31684, 31882, 32059, 32217, 32356, 32475, 32574, 32653, 32711, 32750, 32767, 32763, 32739, 32694, 32629, 32541, 32434, 32304, 32154, 31984, 31791, 31579, 31346, 31092, 30817, 30525, 30211, 29874, 29521, 29147, 28755, 28345, 27915, 27466, 26999, 26515, 26016, 25497, 24961, 24411, 23845, 23264, 22668, 22057, 21431, 20792, 20141, 19477, 18803, 18114, 17414, 16705, 15987, 15260, 14523, 13775, 13019, 12258, 11490, 10716, 9936, 9148, 8359, 7566, 6765, 5962, 5157, 4350, 3543, 2735, 1923, 1113, 303, -504, -1308, -2113, -2918, -3718, -4516, -5306, -6093, -6878, -7658, -8431, -9195, -9954, -10708, -11455, -12194, -12924, -13643, -14355, -15059, -15754, -16438, -17110, -17770, -18423, -19062, -19692, -20310, -20911, -21502, -22082, -22646, -23201, -23738, -24259, -24770, -25265, -25745, -26212, -26660, -27093, -27514, -27917, -28303, -28672, -29025, -29362, -29682, -29984, -30269, -30537, -30785, -31018, -31231, -31425, -31603, -31762, -31900, -32021, -32123, -32205, -32269, -32313, -32338, -32342, -32327, -32292, -32237, -32163, -32070, -31955, -31822, -31670, -31496, -31303, -31091, -30858, -30608, -30337, -30046, -29737, -29409, -29063, -28700, -28315, -27915, -27496, -27060, -26610, -26140, -25654, -25153, -24638, -24107, -23560, -23000, -22422, -21836, -21237, -20622, -19997, -19361, -18712, -18057, -17390, -16710, -16025, -15329, -14625, -13919, -13201, -12477, -11747, -11010, -10271, -9531, -8780, -8028, -7273, -6514, -5757, -4995, -4230, -3466, -2701, -1936, -1179, -386};