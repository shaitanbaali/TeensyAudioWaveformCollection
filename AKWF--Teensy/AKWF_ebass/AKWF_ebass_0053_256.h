/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0053 256 samples */
 
const int16_t AKWF_ebass_0053_256_DATA [256] = 
{237, 993, 1802, 2521, 3162, 3818, 4627, 5440, 5973, 6326, 6668, 7134, 7685, 8275, 8971, 9678, 10372, 10948, 11384, 11733, 11932, 12051, 12318, 12764, 13277, 13706, 14068, 14363, 14583, 14634, 14521, 14340, 14202, 14232, 14375, 14576, 14747, 14867, 14840, 14856, 14818, 14713, 14692, 14769, 14969, 15194, 15350, 15568, 15943, 16465, 16896, 17139, 17391, 17666, 17894, 18030, 18073, 18124, 18155, 18198, 18160, 17983, 17737, 17450, 17117, 16681, 16076, 15375, 14694, 14020, 13286, 12475, 11596, 10634, 9695, 8724, 7733, 6725, 5772, 4835, 3851, 2644, 1357, 33, -1391, -2863, -4400, -5821, -7123, -8345, -9524, -10610, -11571, -12433, -13128, -13771, -14305, -14749, -15094, -15408, -15662, -15856, -15892, -15811, -15607, -15409, -15216, -15018, -14705, -14296, -13828, -13373, -12919, -12380, -11712, -10942, -10138, -9339, -8529, -7733, -6966, -6268, -5588, -4902, -4115, -3241, -2342, -1492, -792, 175, 1721, 2743, 3229, 3622, 4432, 5511, 6415, 7159, 8176, 9612, 11195, 12493, 13228, 13788, 14443, 15168, 15703, 16145, 16663, 17362, 18101, 18566, 18597, 18295, 17766, 17015, 16219, 15596, 15195, 14699, 14313, 14135, 13936, 13320, 12542, 11746, 11104, 10669, 10340, 10090, 9946, 9905, 9884, 9767, 9626, 9682, 9883, 10167, 10342, 10332, 10016, 9780, 9662, 9477, 9152, 8927, 8919, 8972, 8883, 8461, 7693, 6811, 5998, 5114, 4085, 2949, 1964, 1149, 233, -1037, -2617, -4230, -5768, -7219, -8680, -10174, -11612, -13093, -14724, -16456, -18195, -19898, -21560, -23119, -24561, -25822, -26921, -27910, -28886, -29873, -30810, -31478, -31889, -32200, -32523, -32743, -32736, -32602, -32469, -32255, -31759, -30959, -29928, -28978, -28091, -27096, -25863, -24463, -22995, -21557, -20183, -18691, -16992, -15417, -14202, -13141, -12018, -10798, -9466, -8163, -6841, -5334, -3710, -2247, -1124, -326};