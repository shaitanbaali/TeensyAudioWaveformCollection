/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0016 256 samples */
 
const int16_t AKWF_ebass_0016_256_DATA [256] = 
{595, 1869, 3131, 4340, 5462, 6513, 7515, 8489, 9449, 10393, 11300, 12171, 13002, 13784, 14507, 15149, 15679, 16100, 16446, 16770, 17136, 17582, 18131, 18783, 19516, 20316, 21163, 22027, 22849, 23559, 24087, 24372, 24404, 24199, 23800, 23244, 22572, 21808, 20987, 20146, 19315, 18514, 17735, 16939, 16070, 15081, 13957, 12705, 11375, 10009, 8653, 7323, 6021, 4736, 3445, 2102, 671, -881, -2601, -4488, -6531, -8698, -10919, -13134, -15287, -17323, -19214, -20932, -22468, -23830, -25044, -26136, -27147, -28104, -29013, -29866, -30646, -31339, -31924, -32380, -32677, -32770, -32614, -32174, -31438, -30430, -29193, -27769, -26205, -24542, -22804, -21027, -19234, -17426, -15598, -13705, -11704, -9573, -7315, -4965, -2614, -333, 1812, 3755, 5485, 7011, 8369, 9493, 10532, 11712, 12834, 13858, 14792, 15618, 16305, 16821, 17117, 17148, 16897, 16370, 15616, 14699, 13687, 12635, 11597, 10597, 9654, 8767, 7921, 7098, 6267, 5410, 4517, 3598, 2686, 1840, 1099, 484, 2, -376, -684, -959, -1221, -1456, -1631, -1706, -1623, -1345, -843, -106, 851, 1997, 3267, 4583, 5855, 7008, 7987, 8779, 9401, 9879, 10233, 10480, 10628, 10684, 10650, 10542, 10368, 10161, 9937, 9730, 9561, 9447, 9372, 9304, 9196, 8981, 8587, 7946, 7021, 5796, 4299, 2597, 772, -1089, -2900, -4590, -6119, -7456, -8592, -9551, -10371, -11084, -11720, -12272, -12730, -13071, -13292, -13406, -13449, -13459, -13476, -13521, -13611, -13756, -13955, -14195, -14422, -14572, -14575, -14366, -13917, -13234, -12355, -11336, -10242, -9128, -8050, -7061, -6197, -5494, -4957, -4566, -4284, -4061, -3873, -3714, -3603, -3580, -3682, -3900, -4210, -4547, -4854, -5064, -5124, -4993, -4649, -4099, -3392, -2621, -1903, -1342, -1005, -908, -1019, -1271, -1598, -1934, -2227, -2430, -2495, -2394, -2103, -1644, -1060, -378};