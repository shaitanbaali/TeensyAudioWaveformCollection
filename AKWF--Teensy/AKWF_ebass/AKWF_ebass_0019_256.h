/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_ebass_0019 256 samples */
 
const int16_t AKWF_ebass_0019_256_DATA [256] = 
{1162, 2905, 4577, 6216, 7809, 9355, 10852, 12288, 13665, 14981, 16227, 17407, 18518, 19555, 20522, 21417, 22238, 22989, 23669, 24278, 24821, 25297, 25707, 26057, 26344, 26573, 26748, 26867, 26935, 26955, 26929, 26859, 26749, 26601, 26418, 26202, 25956, 25682, 25382, 25059, 24715, 24351, 23970, 23572, 23157, 22728, 22282, 21824, 21354, 20871, 20377, 19876, 19364, 18847, 18324, 17797, 17267, 16739, 16210, 15683, 15160, 14638, 14122, 13609, 13099, 12594, 12094, 11597, 11109, 10624, 10144, 9671, 9203, 8741, 8287, 7839, 7400, 6971, 6551, 6140, 5741, 5351, 4971, 4602, 4244, 3896, 3561, 3234, 2917, 2609, 2307, 2013, 1725, 1442, 1164, 891, 622, 357, 94, -166, -423, -676, -925, -1167, -1405, -1636, -1860, -2078, -2290, -2497, -2699, -2897, -3090, -3280, -3465, -3646, -3824, -3998, -4167, -4335, -4499, -4658, -4816, -4970, -5121, -5267, -5408, -5543, -5672, -5789, -5895, -5987, -6065, -6128, -6175, -6208, -6228, -6237, -6239, -6235, -6229, -6221, -6213, -6208, -6205, -6203, -6200, -6194, -6183, -6162, -6129, -6079, -6010, -5918, -5803, -5662, -5495, -5302, -5085, -4845, -4584, -4306, -4013, -3708, -3395, -3076, -2753, -2431, -2111, -1792, -1479, -1171, -869, -573, -282, 2, 281, 553, 818, 1071, 1312, 1536, 1734, 1902, 2032, 2116, 2149, 2121, 2028, 1864, 1624, 1308, 910, 434, -122, -757, -1466, -2249, -3101, -4016, -4991, -6021, -7093, -8209, -9360, -10535, -11735, -12951, -14175, -15408, -16641, -17868, -19092, -20301, -21492, -22666, -23811, -24922, -25996, -27023, -27992, -28899, -29732, -30480, -31139, -31696, -32144, -32476, -32684, -32767, -32722, -32546, -32236, -31796, -31228, -30533, -29718, -28792, -27755, -26616, -25385, -24065, -22663, -21192, -19652, -18053, -16407, -14714, -12987, -11236, -9459, -7673, -5885, -4098, -2324, -532};