/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_23 256 samples */
 
const int16_t AKWF_R_asym_saw_23_256_DATA [256] = 
{15408, 27670, 31316, 32515, 32767, 32655, 32441, 32201, 31914, 31611, 31305, 30995, 30687, 30379, 30070, 29763, 29457, 29151, 28845, 28541, 28236, 27931, 27629, 27326, 27024, 26723, 26422, 26122, 25822, 25523, 25225, 24928, 24630, 24333, 24037, 23741, 23447, 23152, 22857, 22566, 22272, 21980, 21689, 21399, 21107, 20818, 20529, 20240, 19952, 19664, 19377, 19090, 18805, 18519, 18235, 17950, 17667, 17384, 17101, 16820, 16538, 16257, 15977, 15697, 15417, 15139, 14861, 14584, 14307, 14030, 13754, 13479, 13204, 12929, 12656, 12382, 12109, 11837, 11565, 11294, 11024, 10754, 10484, 10216, 9947, 9679, 9412, 9144, 8878, 8612, 8347, 8083, 7818, 7554, 7291, 7028, 6766, 6504, 6243, 5982, 5722, 5462, 5203, 4945, 4686, 4428, 4171, 3915, 3658, 3403, 3147, 2893, 2639, 2385, 2132, 1879, 1627, 1375, 1123, 873, 624, 374, 124, -123, -370, -619, -866, -1112, -1360, -1605, -1850, -2096, -2340, -2584, -2827, -3069, -3313, -3554, -3795, -4037, -4278, -4517, -4758, -4997, -5236, -5473, -5711, -5949, -6186, -6422, -6658, -6893, -7129, -7362, -7597, -7831, -8063, -8297, -8529, -8761, -8992, -9223, -9453, -9684, -9913, -10142, -10370, -10599, -10827, -11055, -11281, -11506, -11734, -11959, -12185, -12409, -12632, -12857, -13080, -13303, -13527, -13747, -13969, -14191, -14411, -14632, -14851, -15070, -15290, -15508, -15726, -15943, -16161, -16378, -16595, -16811, -17026, -17241, -17457, -17671, -17884, -18098, -18311, -18524, -18736, -18948, -19160, -19371, -19581, -19791, -20001, -20211, -20420, -20628, -20835, -21043, -21251, -21458, -21664, -21870, -22077, -22283, -22487, -22691, -22895, -23098, -23302, -23506, -23708, -23911, -24112, -24312, -24514, -24715, -24914, -25115, -25314, -25513, -25711, -25910, -26107, -26306, -26503, -26699, -26895, -27091, -27286, -27482, -27671, -27865, -28066, -28257, -28434, -28388, -30013, -14279};