/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_01 256 samples */
 
const int16_t AKWF_R_sym_saw_01_256_DATA [256] = 
{403, 1256, 2089, 2926, 3761, 4593, 5431, 6263, 7097, 7932, 8761, 9597, 10426, 11254, 12084, 12908, 13730, 14551, 15367, 16181, 16991, 17798, 18598, 19396, 20187, 20967, 21741, 22506, 23259, 24004, 24733, 25449, 26147, 26829, 27490, 28130, 28742, 29325, 29884, 30404, 30885, 31324, 31712, 32051, 32335, 32550, 32696, 32765, 32746, 32632, 32409, 32110, 31793, 31474, 31156, 30828, 30501, 30166, 29828, 29487, 29140, 28791, 28438, 28080, 27721, 27356, 26988, 26619, 26245, 25868, 25483, 25100, 24712, 24324, 23928, 23531, 23133, 22731, 22328, 21920, 21509, 21096, 20679, 20264, 19841, 19420, 18993, 18564, 18137, 17704, 17271, 16836, 16395, 15957, 15516, 15072, 14626, 14179, 13731, 13279, 12826, 12373, 11918, 11461, 11006, 10546, 10086, 9627, 9161, 8697, 8234, 7770, 7304, 6835, 6366, 5898, 5427, 4960, 4489, 4013, 3544, 3074, 2600, 2128, 1657, 1181, 711, 237, -238, -712, -1182, -1658, -2129, -2601, -3074, -3545, -4014, -4490, -4961, -5427, -5899, -6366, -6836, -7305, -7770, -8234, -8697, -9162, -9627, -10087, -10546, -11007, -11461, -11919, -12373, -12827, -13280, -13731, -14179, -14626, -15072, -15516, -15958, -16395, -16837, -17272, -17705, -18138, -18564, -18994, -19420, -19842, -20264, -20680, -21096, -21509, -21920, -22328, -22731, -23134, -23531, -23929, -24325, -24712, -25100, -25483, -25868, -26245, -26619, -26988, -27356, -27721, -28080, -28438, -28791, -29140, -29487, -29828, -30167, -30501, -30828, -31156, -31474, -31793, -32110, -32409, -32632, -32746, -32765, -32696, -32550, -32335, -32051, -31712, -31324, -30885, -30404, -29885, -29325, -28743, -28131, -27490, -26829, -26147, -25450, -24733, -24004, -23260, -22506, -21741, -20967, -20187, -19397, -18598, -17798, -16992, -16181, -15368, -14551, -13731, -12908, -12084, -11255, -10427, -9597, -8762, -7933, -7098, -6264, -5432, -4594, -3762, -2927, -2090, -1256, -404};