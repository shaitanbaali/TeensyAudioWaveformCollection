/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_18 256 samples */
 
const int16_t AKWF_R_sym_saw_18_256_DATA [256] = 
{7533, 21638, 27019, 29066, 30661, 31646, 32257, 32593, 32744, 32762, 32687, 32548, 32363, 32148, 31911, 31659, 31397, 31127, 30853, 30575, 30294, 30012, 29729, 29445, 29160, 28876, 28591, 28306, 28022, 27736, 27451, 27167, 26881, 26598, 26312, 26028, 25744, 25460, 25175, 24891, 24607, 24323, 24040, 23756, 23471, 23189, 22905, 22622, 22339, 22055, 21771, 21489, 21206, 20923, 20641, 20357, 20075, 19792, 19510, 19228, 18945, 18663, 18380, 18098, 17816, 17534, 17252, 16970, 16689, 16407, 16124, 15843, 15562, 15281, 14999, 14717, 14436, 14155, 13874, 13592, 13312, 13030, 12748, 12468, 12187, 11907, 11626, 11344, 11064, 10784, 10502, 10222, 9942, 9661, 9380, 9100, 8819, 8540, 8260, 7978, 7698, 7418, 7138, 6858, 6577, 6297, 6017, 5737, 5457, 5177, 4897, 4617, 4336, 4056, 3777, 3497, 3216, 2936, 2657, 2377, 2097, 1818, 1537, 1257, 978, 699, 420, 140, -141, -421, -700, -979, -1258, -1538, -1819, -2098, -2378, -2658, -2937, -3217, -3498, -3778, -4057, -4337, -4618, -4898, -5178, -5457, -5738, -6018, -6298, -6577, -6859, -7139, -7419, -7699, -7979, -8261, -8541, -8820, -9101, -9381, -9661, -9943, -10223, -10503, -10784, -11065, -11345, -11627, -11908, -12188, -12469, -12749, -13031, -13313, -13593, -13875, -14156, -14436, -14718, -15000, -15281, -15562, -15844, -16125, -16407, -16689, -16971, -17253, -17535, -17816, -18099, -18380, -18663, -18945, -19228, -19510, -19792, -20075, -20357, -20641, -20923, -21206, -21489, -21772, -22055, -22339, -22622, -22906, -23189, -23472, -23756, -24040, -24323, -24607, -24891, -25176, -25460, -25744, -26028, -26313, -26598, -26882, -27167, -27451, -27737, -28022, -28306, -28591, -28877, -29160, -29445, -29729, -30012, -30294, -30575, -30853, -31127, -31397, -31659, -31911, -32148, -32363, -32548, -32687, -32762, -32744, -32593, -32257, -31646, -30661, -29066, -27020, -21639, -7534};