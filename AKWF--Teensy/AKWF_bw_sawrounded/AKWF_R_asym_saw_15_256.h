/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_15 256 samples */
 
const int16_t AKWF_R_asym_saw_15_256_DATA [256] = 
{4381, 10735, 15669, 19637, 22811, 25335, 27326, 28874, 30069, 30976, 31646, 32127, 32453, 32652, 32749, 32764, 32712, 32603, 32451, 32263, 32046, 31806, 31545, 31270, 30984, 30686, 30380, 30070, 29754, 29432, 29109, 28783, 28455, 28126, 27796, 27464, 27134, 26802, 26470, 26139, 25808, 25476, 25146, 24816, 24486, 24157, 23827, 23499, 23171, 22844, 22517, 22192, 21866, 21540, 21217, 20893, 20569, 20248, 19927, 19605, 19284, 18964, 18645, 18327, 18008, 17691, 17375, 17058, 16742, 16428, 16113, 15800, 15487, 15173, 14862, 14550, 14240, 13930, 13620, 13310, 13003, 12695, 12388, 12082, 11776, 11471, 11166, 10862, 10558, 10256, 9953, 9652, 9351, 9050, 8750, 8451, 8151, 7854, 7557, 7259, 6963, 6667, 6372, 6078, 5783, 5490, 5197, 4904, 4613, 4321, 4030, 3740, 3450, 3161, 2874, 2585, 2298, 2011, 1726, 1439, 1154, 870, 586, 303, 21, -261, -541, -823, -1104, -1384, -1664, -1943, -2221, -2498, -2776, -3053, -3329, -3604, -3879, -4155, -4429, -4702, -4974, -5247, -5519, -5791, -6062, -6332, -6602, -6871, -7139, -7408, -7676, -7943, -8210, -8476, -8741, -9007, -9272, -9535, -9799, -10061, -10324, -10586, -10848, -11109, -11369, -11629, -11889, -12148, -12406, -12665, -12922, -13179, -13435, -13692, -13946, -14202, -14456, -14709, -14964, -15216, -15468, -15721, -15973, -16223, -16474, -16723, -16973, -17222, -17471, -17719, -17966, -18213, -18460, -18706, -18951, -19197, -19441, -19685, -19929, -20173, -20415, -20658, -20899, -21141, -21381, -21621, -21861, -22101, -22340, -22579, -22817, -23054, -23291, -23529, -23764, -24000, -24235, -24470, -24704, -24938, -25172, -25405, -25637, -25869, -26101, -26332, -26562, -26793, -27023, -27252, -27481, -27709, -27937, -28165, -28393, -28619, -28845, -29071, -29296, -29522, -29747, -29970, -30194, -30417, -30637, -30860, -31082, -31303, -31489, -31764, -31632, -24334, -12697, -3097};