/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_06 256 samples */
 
const int16_t AKWF_R_sym_saw_06_256_DATA [256] = 
{888, 2751, 4581, 6422, 8270, 10130, 12007, 13891, 15794, 17713, 19637, 21568, 23494, 25384, 27214, 28917, 30394, 31484, 31973, 32137, 32284, 32410, 32514, 32601, 32668, 32717, 32750, 32766, 32766, 32751, 32722, 32677, 32619, 32546, 32460, 32364, 32253, 32131, 31998, 31854, 31699, 31533, 31359, 31174, 30980, 30778, 30566, 30345, 30118, 29882, 29639, 29389, 29129, 28865, 28595, 28317, 28033, 27744, 27447, 27147, 26841, 26529, 26213, 25891, 25566, 25236, 24901, 24561, 24219, 23871, 23521, 23168, 22809, 22447, 22084, 21715, 21343, 20971, 20595, 20216, 19835, 19449, 19062, 18673, 18282, 17888, 17493, 17095, 16695, 16294, 15889, 15486, 15078, 14670, 14259, 13849, 13435, 13021, 12607, 12190, 11773, 11353, 10933, 10512, 10090, 9667, 9243, 8819, 8392, 7968, 7541, 7111, 6684, 6255, 5827, 5397, 4966, 4535, 4105, 3674, 3243, 2810, 2378, 1946, 1514, 1080, 647, 215, -216, -648, -1081, -1515, -1947, -2379, -2811, -3243, -3675, -4106, -4536, -4967, -5398, -5827, -6256, -6685, -7112, -7541, -7969, -8393, -8819, -9244, -9667, -10090, -10513, -10934, -11354, -11774, -12191, -12607, -13021, -13436, -13850, -14260, -14671, -15079, -15486, -15890, -16294, -16695, -17095, -17494, -17888, -18282, -18674, -19062, -19449, -19836, -20216, -20596, -20972, -21344, -21716, -22084, -22447, -22809, -23168, -23521, -23872, -24219, -24561, -24901, -25237, -25566, -25892, -26213, -26530, -26841, -27148, -27447, -27744, -28033, -28317, -28595, -28865, -29130, -29389, -29639, -29882, -30118, -30345, -30566, -30778, -30980, -31174, -31359, -31534, -31699, -31854, -31998, -32132, -32253, -32364, -32460, -32546, -32619, -32677, -32722, -32751, -32766, -32766, -32750, -32717, -32668, -32601, -32514, -32410, -32284, -32137, -31973, -31484, -30394, -28917, -27214, -25384, -23494, -21569, -19637, -17713, -15795, -13892, -12007, -10131, -8270, -6422, -4582, -2752, -889};