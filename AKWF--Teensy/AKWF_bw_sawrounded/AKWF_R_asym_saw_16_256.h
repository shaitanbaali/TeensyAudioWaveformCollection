/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_16 256 samples */
 
const int16_t AKWF_R_asym_saw_16_256_DATA [256] = 
{2567, 10334, 16100, 20548, 23943, 26533, 28485, 29926, 30975, 31719, 32221, 32538, 32710, 32768, 32740, 32644, 32493, 32302, 32078, 31829, 31561, 31278, 30984, 30680, 30371, 30056, 29738, 29416, 29093, 28767, 28443, 28116, 27788, 27462, 27135, 26808, 26482, 26156, 25829, 25504, 25180, 24855, 24532, 24209, 23886, 23564, 23243, 22922, 22602, 22282, 21963, 21646, 21328, 21010, 20694, 20378, 20063, 19749, 19435, 19121, 18808, 18495, 18184, 17873, 17562, 17253, 16944, 16635, 16328, 16021, 15714, 15407, 15102, 14797, 14493, 14189, 13885, 13583, 13281, 12979, 12679, 12378, 12080, 11781, 11482, 11185, 10887, 10590, 10294, 9999, 9703, 9410, 9116, 8822, 8530, 8238, 7946, 7655, 7366, 7076, 6786, 6497, 6209, 5921, 5634, 5348, 5062, 4777, 4492, 4208, 3924, 3641, 3359, 3078, 2795, 2515, 2234, 1954, 1676, 1396, 1118, 842, 564, 288, 13, -262, -537, -811, -1085, -1358, -1630, -1903, -2175, -2446, -2717, -2987, -3255, -3525, -3793, -4061, -4329, -4596, -4862, -5129, -5392, -5658, -5923, -6186, -6449, -6712, -6975, -7236, -7497, -7758, -8019, -8278, -8537, -8796, -9054, -9311, -9569, -9825, -10081, -10337, -10592, -10847, -11102, -11354, -11608, -11860, -12112, -12364, -12616, -12866, -13116, -13367, -13615, -13865, -14112, -14360, -14608, -14854, -15100, -15346, -15592, -15836, -16081, -16325, -16568, -16812, -17054, -17296, -17537, -17778, -18019, -18260, -18499, -18738, -18977, -19215, -19453, -19690, -19927, -20164, -20399, -20635, -20870, -21104, -21337, -21572, -21805, -22038, -22270, -22502, -22733, -22965, -23195, -23424, -23654, -23884, -24112, -24341, -24568, -24795, -25023, -25249, -25475, -25700, -25925, -26150, -26375, -26598, -26821, -27045, -27266, -27489, -27710, -27932, -28153, -28373, -28592, -28812, -29031, -29250, -29467, -29685, -29903, -30118, -30334, -30550, -30765, -30918, -31323, -30304, -19914, -6860};