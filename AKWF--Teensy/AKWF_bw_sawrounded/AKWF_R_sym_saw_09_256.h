/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_09 256 samples */
 
const int16_t AKWF_R_sym_saw_09_256_DATA [256] = 
{1461, 4524, 7545, 10608, 13711, 16868, 20071, 23255, 26302, 28774, 29948, 30407, 30833, 31205, 31529, 31810, 32048, 32248, 32413, 32544, 32643, 32712, 32753, 32768, 32760, 32728, 32674, 32602, 32510, 32400, 32274, 32132, 31977, 31807, 31624, 31431, 31226, 31011, 30785, 30551, 30308, 30057, 29798, 29533, 29259, 28982, 28699, 28410, 28116, 27817, 27512, 27205, 26894, 26578, 26261, 25939, 25614, 25287, 24956, 24624, 24289, 23953, 23615, 23275, 22932, 22588, 22243, 21895, 21548, 21198, 20846, 20495, 20143, 19789, 19435, 19080, 18723, 18367, 18009, 17650, 17293, 16933, 16573, 16214, 15853, 15492, 15132, 14768, 14408, 14046, 13683, 13319, 12956, 12593, 12231, 11867, 11502, 11139, 10775, 10410, 10047, 9681, 9315, 8952, 8587, 8221, 7856, 7491, 7127, 6762, 6395, 6030, 5665, 5300, 4935, 4569, 4203, 3837, 3473, 3107, 2741, 2376, 2010, 1645, 1280, 912, 547, 182, -183, -548, -913, -1281, -1646, -2011, -2376, -2742, -3108, -3474, -3838, -4204, -4570, -4936, -5300, -5666, -6031, -6396, -6762, -7128, -7492, -7857, -8222, -8588, -8953, -9316, -9682, -10047, -10411, -10775, -11139, -11503, -11867, -12231, -12594, -12957, -13319, -13683, -14047, -14409, -14769, -15132, -15492, -15854, -16215, -16574, -16934, -17293, -17651, -18010, -18367, -18724, -19081, -19436, -19789, -20144, -20495, -20847, -21199, -21548, -21895, -22243, -22589, -22932, -23275, -23615, -23953, -24289, -24624, -24956, -25288, -25615, -25939, -26261, -26579, -26894, -27205, -27513, -27817, -28116, -28410, -28699, -28982, -29259, -29533, -29798, -30057, -30308, -30551, -30785, -31011, -31226, -31431, -31624, -31807, -31977, -32132, -32274, -32400, -32510, -32602, -32674, -32728, -32760, -32768, -32753, -32712, -32643, -32544, -32413, -32248, -32048, -31810, -31529, -31205, -30833, -30407, -29948, -28774, -26302, -23255, -20071, -16869, -13712, -10609, -7546, -4525, -1462};