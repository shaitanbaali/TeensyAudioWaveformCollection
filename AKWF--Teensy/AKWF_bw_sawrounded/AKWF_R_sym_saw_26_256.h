/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_26 256 samples */
 
const int16_t AKWF_R_sym_saw_26_256_DATA [256] = 
{23632, 33957, 32364, 32360, 32102, 31841, 31574, 31350, 31090, 30825, 30560, 30295, 30031, 29767, 29502, 29238, 28974, 28711, 28447, 28183, 27920, 27656, 27392, 27129, 26866, 26603, 26339, 26077, 25814, 25551, 25288, 25027, 24764, 24502, 24240, 23977, 23715, 23453, 23191, 22930, 22668, 22405, 22145, 21884, 21622, 21362, 21100, 20838, 20578, 20317, 20056, 19795, 19535, 19274, 19014, 18753, 18493, 18233, 17972, 17712, 17452, 17192, 16932, 16672, 16411, 16151, 15893, 15633, 15374, 15115, 14854, 14595, 14335, 14075, 13817, 13558, 13298, 13039, 12780, 12521, 12263, 12003, 11745, 11486, 11226, 10968, 10710, 10450, 10192, 9934, 9676, 9417, 9159, 8899, 8641, 8383, 8124, 7866, 7608, 7350, 7092, 6833, 6574, 6317, 6059, 5800, 5543, 5285, 5026, 4769, 4511, 4253, 3995, 3736, 3479, 3221, 2963, 2705, 2448, 2190, 1931, 1674, 1417, 1159, 902, 644, 385, 128, -129, -386, -645, -903, -1160, -1418, -1675, -1932, -2191, -2449, -2706, -2964, -3222, -3479, -3737, -3996, -4254, -4512, -4770, -5027, -5285, -5544, -5801, -6060, -6318, -6575, -6834, -7092, -7351, -7608, -7867, -8125, -8384, -8642, -8900, -9159, -9417, -9676, -9935, -10193, -10451, -10711, -10969, -11227, -11486, -11745, -12004, -12263, -12522, -12781, -13040, -13299, -13558, -13817, -14075, -14336, -14596, -14854, -15115, -15375, -15633, -15893, -16152, -16412, -16672, -16933, -17192, -17452, -17712, -17973, -18233, -18493, -18753, -19015, -19275, -19535, -19795, -20056, -20317, -20578, -20838, -21101, -21362, -21622, -21884, -22145, -22406, -22668, -22931, -23191, -23453, -23715, -23977, -24240, -24502, -24764, -25027, -25289, -25551, -25814, -26077, -26339, -26603, -26866, -27129, -27392, -27656, -27920, -28183, -28447, -28711, -28974, -29238, -29502, -29767, -30031, -30295, -30560, -30825, -31090, -31350, -31574, -31841, -32102, -32360, -32364, -33957, -23632};