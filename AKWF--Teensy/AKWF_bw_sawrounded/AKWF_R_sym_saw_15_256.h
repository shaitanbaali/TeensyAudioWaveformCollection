/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_15 256 samples */
 
const int16_t AKWF_R_sym_saw_15_256_DATA [256] = 
{3925, 12299, 20998, 26912, 28648, 29828, 30776, 31473, 31982, 32342, 32578, 32713, 32767, 32754, 32687, 32577, 32431, 32255, 32057, 31839, 31606, 31361, 31105, 30840, 30569, 30293, 30012, 29727, 29440, 29151, 28859, 28566, 28272, 27977, 27681, 27384, 27088, 26790, 26493, 26195, 25897, 25599, 25301, 25003, 24705, 24407, 24109, 23810, 23512, 23214, 22916, 22620, 22321, 22023, 21726, 21428, 21130, 20833, 20536, 20238, 19942, 19644, 19348, 19051, 18753, 18457, 18160, 17863, 17566, 17271, 16974, 16678, 16381, 16083, 15788, 15491, 15195, 14900, 14604, 14306, 14012, 13716, 13420, 13124, 12828, 12533, 12237, 11942, 11646, 11351, 11055, 10760, 10465, 10169, 9874, 9579, 9283, 8989, 8694, 8398, 8104, 7808, 7513, 7219, 6924, 6628, 6334, 6039, 5744, 5450, 5155, 4859, 4564, 4270, 3976, 3681, 3386, 3091, 2797, 2502, 2207, 1913, 1618, 1324, 1030, 736, 440, 146, -147, -441, -737, -1031, -1325, -1619, -1914, -2208, -2503, -2798, -3092, -3387, -3682, -3977, -4271, -4565, -4860, -5155, -5451, -5745, -6040, -6334, -6629, -6924, -7220, -7513, -7809, -8104, -8399, -8695, -8990, -9284, -9580, -9875, -10170, -10466, -10760, -11056, -11352, -11646, -11943, -12238, -12534, -12829, -13125, -13421, -13717, -14013, -14307, -14604, -14901, -15196, -15492, -15788, -16084, -16381, -16679, -16974, -17271, -17567, -17863, -18161, -18457, -18754, -19052, -19348, -19645, -19942, -20239, -20536, -20834, -21131, -21429, -21726, -22023, -22321, -22620, -22916, -23215, -23512, -23810, -24109, -24407, -24705, -25004, -25301, -25599, -25897, -26195, -26493, -26791, -27089, -27384, -27681, -27977, -28272, -28566, -28859, -29151, -29440, -29727, -30012, -30293, -30569, -30840, -31105, -31361, -31606, -31839, -32057, -32255, -32431, -32577, -32687, -32754, -32767, -32713, -32578, -32342, -31982, -31473, -30776, -29828, -28648, -26912, -20999, -12299, -3926};