/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_17 256 samples */
 
const int16_t AKWF_R_sym_saw_17_256_DATA [256] = 
{5979, 18850, 26131, 28255, 29903, 31043, 31814, 32307, 32598, 32740, 32767, 32713, 32598, 32437, 32243, 32023, 31784, 31533, 31271, 31002, 30727, 30449, 30168, 29883, 29598, 29313, 29025, 28737, 28449, 28161, 27872, 27584, 27294, 27005, 26717, 26428, 26139, 25850, 25561, 25273, 24984, 24696, 24409, 24121, 23833, 23544, 23257, 22969, 22682, 22394, 22106, 21820, 21532, 21244, 20957, 20670, 20383, 20096, 19809, 19523, 19236, 18948, 18663, 18377, 18089, 17804, 17517, 17231, 16946, 16659, 16373, 16087, 15801, 15515, 15230, 14944, 14657, 14373, 14087, 13801, 13516, 13231, 12945, 12660, 12375, 12089, 11804, 11519, 11234, 10950, 10664, 10379, 10094, 9809, 9525, 9240, 8955, 8670, 8386, 8101, 7816, 7532, 7248, 6963, 6678, 6393, 6109, 5825, 5540, 5257, 4971, 4687, 4404, 4119, 3835, 3551, 3267, 2982, 2699, 2414, 2128, 1845, 1561, 1278, 993, 710, 425, 141, -142, -426, -711, -994, -1279, -1562, -1846, -2129, -2415, -2700, -2983, -3267, -3551, -3836, -4120, -4405, -4688, -4972, -5258, -5541, -5826, -6110, -6394, -6679, -6964, -7248, -7533, -7817, -8101, -8387, -8671, -8956, -9241, -9526, -9810, -10095, -10380, -10665, -10950, -11234, -11520, -11805, -12090, -12375, -12661, -12946, -13231, -13517, -13802, -14088, -14373, -14658, -14945, -15230, -15516, -15802, -16087, -16373, -16659, -16946, -17231, -17518, -17804, -18089, -18377, -18663, -18948, -19236, -19524, -19810, -20096, -20383, -20671, -20958, -21245, -21532, -21820, -22106, -22394, -22682, -22970, -23257, -23545, -23833, -24121, -24409, -24697, -24984, -25274, -25562, -25850, -26139, -26428, -26717, -27005, -27294, -27584, -27872, -28161, -28449, -28737, -29025, -29313, -29598, -29884, -30168, -30449, -30727, -31002, -31271, -31533, -31784, -32023, -32243, -32437, -32598, -32713, -32767, -32740, -32598, -32307, -31814, -31044, -29903, -28256, -26131, -18851, -5980};