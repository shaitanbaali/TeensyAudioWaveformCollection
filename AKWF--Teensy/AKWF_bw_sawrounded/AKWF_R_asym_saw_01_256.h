/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_01 256 samples */
 
const int16_t AKWF_R_asym_saw_01_256_DATA [256] = 
{230, 883, 1511, 2128, 2731, 3323, 3909, 4475, 5034, 5582, 6115, 6642, 7155, 7656, 8145, 8623, 9089, 9546, 9991, 10424, 10844, 11256, 11658, 12049, 12428, 12797, 13153, 13500, 13837, 14166, 14480, 14785, 15080, 15367, 15643, 15912, 16167, 16410, 16651, 16877, 17093, 17303, 17499, 17688, 17871, 18040, 18202, 18356, 18501, 18636, 18761, 18879, 18988, 19085, 19178, 19260, 19340, 19405, 19463, 19514, 19557, 19592, 19616, 19634, 19645, 19648, 19642, 19633, 19613, 19586, 19549, 19506, 19458, 19403, 19339, 19265, 19186, 19103, 19014, 18914, 18806, 18694, 18577, 18453, 18317, 18181, 18036, 17882, 17728, 17561, 17392, 17217, 17031, 16846, 16651, 16449, 16241, 16030, 15813, 15588, 15358, 15122, 14882, 14636, 14386, 14128, 13865, 13598, 13324, 13046, 12761, 12472, 12181, 11881, 11574, 11269, 10953, 10637, 10313, 9983, 9651, 9314, 8972, 8625, 8278, 7919, 7560, 7193, 6824, 6451, 6076, 5693, 5307, 4918, 4521, 4125, 3724, 3314, 2904, 2493, 2073, 1649, 1225, 793, 359, -75, -514, -959, -1410, -1860, -2313, -2772, -3232, -3699, -4167, -4639, -5113, -5592, -6074, -6559, -7047, -7538, -8031, -8527, -9031, -9532, -10039, -10548, -11058, -11574, -12093, -12614, -13137, -13662, -14194, -14725, -15258, -15795, -16333, -16877, -17419, -17965, -18517, -19068, -19622, -20177, -20740, -21301, -21864, -22430, -22998, -23569, -24141, -24717, -25291, -25869, -26453, -27035, -27622, -28208, -28797, -29391, -29980, -30574, -31176, -31762, -32233, -32547, -32722, -32768, -32701, -32536, -32277, -31939, -31529, -31053, -30519, -29935, -29306, -28640, -27941, -27211, -26457, -25681, -24888, -24077, -23256, -22423, -21584, -20738, -19890, -19041, -18188, -17336, -16489, -15645, -14801, -13967, -13139, -12316, -11499, -10693, -9889, -9099, -8319, -7545, -6784, -6032, -5290, -4559, -3839, -3133, -2434, -1748, -1076, -400};