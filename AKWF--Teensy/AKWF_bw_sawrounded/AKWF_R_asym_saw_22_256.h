/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_22 256 samples */
 
const int16_t AKWF_R_asym_saw_22_256_DATA [256] = 
{10012, 23870, 29316, 31653, 32543, 32765, 32711, 32545, 32296, 32011, 31711, 31403, 31092, 30782, 30472, 30161, 29852, 29542, 29234, 28925, 28617, 28310, 28003, 27697, 27392, 27088, 26783, 26480, 26177, 25874, 25573, 25272, 24970, 24671, 24372, 24072, 23775, 23477, 23179, 22884, 22588, 22292, 21998, 21704, 21410, 21118, 20825, 20533, 20243, 19951, 19660, 19371, 19082, 18793, 18506, 18218, 17931, 17646, 17359, 17074, 16791, 16506, 16223, 15940, 15657, 15376, 15094, 14814, 14534, 14254, 13976, 13698, 13419, 13141, 12865, 12588, 12312, 12037, 11763, 11489, 11215, 10942, 10669, 10397, 10126, 9855, 9585, 9314, 9045, 8777, 8508, 8241, 7974, 7707, 7440, 7175, 6909, 6646, 6381, 6117, 5855, 5591, 5330, 5068, 4807, 4546, 4287, 4027, 3767, 3510, 3251, 2994, 2738, 2480, 2224, 1969, 1714, 1459, 1205, 952, 700, 447, 195, -56, -306, -557, -806, -1056, -1305, -1553, -1802, -2049, -2297, -2544, -2789, -3034, -3280, -3525, -3768, -4012, -4256, -4499, -4741, -4983, -5224, -5465, -5705, -5946, -6185, -6424, -6662, -6901, -7138, -7375, -7612, -7848, -8083, -8319, -8554, -8788, -9022, -9255, -9488, -9722, -9954, -10185, -10415, -10647, -10877, -11107, -11336, -11565, -11794, -12022, -12249, -12477, -12703, -12929, -13156, -13381, -13606, -13831, -14054, -14279, -14501, -14724, -14946, -15169, -15389, -15610, -15831, -16051, -16271, -16490, -16709, -16928, -17145, -17364, -17581, -17797, -18013, -18230, -18445, -18659, -18874, -19089, -19303, -19515, -19728, -19941, -20153, -20365, -20576, -20788, -20997, -21207, -21417, -21626, -21835, -22043, -22251, -22459, -22666, -22872, -23079, -23285, -23491, -23696, -23901, -24105, -24310, -24512, -24715, -24919, -25121, -25323, -25525, -25726, -25927, -26127, -26327, -26526, -26726, -26925, -27123, -27321, -27518, -27717, -27910, -28104, -28306, -28499, -28682, -28673, -30089, -17213};