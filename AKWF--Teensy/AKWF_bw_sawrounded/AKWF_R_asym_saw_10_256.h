/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_10 256 samples */
 
const int16_t AKWF_R_asym_saw_10_256_DATA [256] = 
{2046, 4959, 7554, 9930, 12094, 14065, 15859, 17481, 18953, 20286, 21483, 22561, 23529, 24392, 25163, 25845, 26445, 26972, 27430, 27823, 28159, 28440, 28671, 28858, 29000, 29105, 29173, 29207, 29211, 29187, 29136, 29063, 28967, 28850, 28714, 28562, 28394, 28211, 28014, 27806, 27585, 27354, 27114, 26865, 26608, 26343, 26073, 25794, 25512, 25224, 24930, 24634, 24332, 24027, 23718, 23407, 23093, 22778, 22458, 22139, 21817, 21494, 21168, 20841, 20514, 20186, 19857, 19526, 19196, 18865, 18533, 18202, 17869, 17536, 17204, 16871, 16537, 16206, 15873, 15541, 15210, 14877, 14545, 14214, 13882, 13552, 13222, 12891, 12561, 12232, 11902, 11574, 11246, 10917, 10591, 10265, 9939, 9612, 9288, 8962, 8638, 8315, 7992, 7670, 7348, 7027, 6707, 6386, 6066, 5748, 5429, 5111, 4794, 4478, 4161, 3846, 3531, 3216, 2904, 2590, 2277, 1966, 1654, 1343, 1034, 724, 415, 107, -200, -507, -813, -1120, -1425, -1730, -2034, -2337, -2641, -2944, -3245, -3546, -3847, -4147, -4447, -4745, -5043, -5342, -5640, -5935, -6232, -6528, -6821, -7116, -7410, -7702, -7995, -8288, -8579, -8870, -9160, -9450, -9739, -10027, -10316, -10604, -10889, -11176, -11463, -11748, -12032, -12317, -12600, -12883, -13166, -13448, -13729, -14010, -14290, -14571, -14849, -15128, -15407, -15684, -15960, -16237, -16513, -16789, -17063, -17337, -17611, -17884, -18157, -18429, -18701, -18972, -19243, -19513, -19782, -20051, -20320, -20587, -20855, -21123, -21388, -21655, -21920, -22184, -22448, -22713, -22975, -23238, -23501, -23762, -24024, -24284, -24544, -24804, -25063, -25322, -25581, -25837, -26095, -26352, -26608, -26863, -27118, -27373, -27627, -27882, -28134, -28387, -28639, -28891, -29142, -29393, -29642, -29892, -30142, -30390, -30639, -30886, -31133, -31380, -31625, -31872, -32117, -32351, -32612, -32709, -30552, -26123, -21272, -16582, -12203, -8156, -4450, -993};