/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_08 256 samples */
 
const int16_t AKWF_R_asym_saw_08_256_DATA [256] = 
{1082, 3128, 5003, 6766, 8419, 9967, 11417, 12769, 14034, 15214, 16309, 17331, 18280, 19158, 19973, 20726, 21417, 22056, 22641, 23176, 23663, 24106, 24504, 24865, 25186, 25471, 25722, 25940, 26126, 26284, 26415, 26519, 26598, 26653, 26687, 26699, 26691, 26665, 26620, 26558, 26480, 26386, 26280, 26158, 26026, 25880, 25722, 25554, 25375, 25187, 24990, 24784, 24569, 24346, 24117, 23881, 23638, 23389, 23135, 22875, 22610, 22339, 22065, 21786, 21502, 21216, 20926, 20631, 20335, 20037, 19733, 19429, 19120, 18811, 18500, 18186, 17870, 17552, 17234, 16914, 16593, 16270, 15946, 15621, 15295, 14968, 14642, 14313, 13983, 13654, 13324, 12993, 12662, 12331, 11999, 11668, 11336, 11004, 10671, 10339, 10006, 9674, 9342, 9011, 8678, 8346, 8013, 7683, 7350, 7019, 6688, 6357, 6027, 5697, 5367, 5037, 4708, 4380, 4051, 3722, 3395, 3069, 2741, 2415, 2089, 1764, 1438, 1114, 790, 466, 143, -179, -500, -822, -1143, -1464, -1784, -2103, -2422, -2741, -3059, -3375, -3693, -4009, -4324, -4640, -4954, -5267, -5582, -5895, -6206, -6519, -6830, -7140, -7451, -7760, -8068, -8378, -8685, -8992, -9299, -9606, -9910, -10216, -10520, -10823, -11128, -11430, -11732, -12034, -12335, -12635, -12935, -13234, -13532, -13830, -14128, -14425, -14721, -15017, -15314, -15607, -15901, -16196, -16488, -16780, -17072, -17363, -17654, -17945, -18233, -18522, -18812, -19100, -19386, -19674, -19959, -20245, -20530, -20815, -21099, -21382, -21665, -21948, -22229, -22511, -22792, -23072, -23350, -23630, -23910, -24186, -24464, -24742, -25018, -25293, -25569, -25844, -26117, -26392, -26665, -26937, -27210, -27481, -27752, -28023, -28292, -28562, -28831, -29099, -29368, -29634, -29901, -30168, -30433, -30699, -30963, -31227, -31491, -31754, -32015, -32275, -32533, -32788, -32041, -29700, -26641, -23362, -20085, -16914, -13876, -10998, -8280, -5714, -3304, -997};