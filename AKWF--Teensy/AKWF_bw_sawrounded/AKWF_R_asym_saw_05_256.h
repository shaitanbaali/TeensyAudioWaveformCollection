/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_05 256 samples */
 
const int16_t AKWF_R_asym_saw_05_256_DATA [256] = 
{382, 1535, 2620, 3669, 4679, 5650, 6587, 7483, 8346, 9175, 9969, 10730, 11462, 12160, 12830, 13469, 14078, 14662, 15219, 15747, 16253, 16732, 17187, 17619, 18028, 18413, 18777, 19120, 19443, 19745, 20028, 20292, 20537, 20764, 20974, 21168, 21343, 21502, 21649, 21777, 21891, 21992, 22078, 22150, 22210, 22256, 22289, 22311, 22322, 22320, 22306, 22282, 22248, 22202, 22148, 22084, 22009, 21926, 21834, 21734, 21625, 21507, 21382, 21248, 21109, 20961, 20805, 20645, 20476, 20301, 20120, 19932, 19739, 19540, 19336, 19125, 18910, 18689, 18464, 18234, 18000, 17760, 17517, 17269, 17017, 16760, 16501, 16238, 15970, 15699, 15424, 15147, 14867, 14584, 14297, 14007, 13715, 13420, 13123, 12822, 12520, 12215, 11907, 11598, 11287, 10972, 10657, 10340, 10020, 9699, 9377, 9051, 8727, 8399, 8070, 7739, 7409, 7076, 6741, 6405, 6069, 5732, 5393, 5054, 4713, 4371, 4029, 3685, 3342, 2996, 2652, 2306, 1960, 1612, 1264, 917, 567, 216, -132, -482, -832, -1182, -1534, -1885, -2236, -2589, -2941, -3293, -3646, -3998, -4351, -4704, -5058, -5410, -5763, -6117, -6469, -6824, -7177, -7528, -7882, -8235, -8588, -8941, -9293, -9646, -9998, -10350, -10702, -11054, -11405, -11756, -12108, -12457, -12810, -13160, -13510, -13859, -14210, -14558, -14907, -15256, -15604, -15952, -16300, -16646, -16994, -17340, -17685, -18032, -18376, -18722, -19068, -19411, -19754, -20097, -20441, -20783, -21125, -21466, -21807, -22149, -22488, -22828, -23167, -23505, -23844, -24183, -24519, -24856, -25193, -25528, -25864, -26199, -26533, -26868, -27201, -27533, -27866, -28198, -28529, -28860, -29190, -29520, -29849, -30177, -30505, -30835, -31160, -31486, -31813, -32135, -32464, -32753, -32580, -31768, -30538, -29048, -27390, -25640, -23850, -22046, -20252, -18488, -16754, -15063, -13420, -11820, -10271, -8773, -7321, -5919, -4566, -3257, -1997, -760};