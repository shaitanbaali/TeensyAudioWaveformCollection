/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_06 256 samples */
 
const int16_t AKWF_R_asym_saw_06_256_DATA [256] = 
{439, 1840, 3150, 4407, 5608, 6754, 7851, 8894, 9889, 10839, 11741, 12600, 13418, 14190, 14926, 15623, 16282, 16906, 17494, 18048, 18572, 19064, 19525, 19958, 20361, 20737, 21088, 21413, 21713, 21990, 22243, 22474, 22685, 22874, 23042, 23194, 23325, 23440, 23536, 23615, 23679, 23727, 23759, 23777, 23782, 23773, 23750, 23715, 23668, 23609, 23539, 23458, 23366, 23264, 23153, 23032, 22901, 22763, 22615, 22460, 22296, 22125, 21947, 21762, 21569, 21371, 21166, 20954, 20739, 20515, 20287, 20055, 19816, 19572, 19325, 19073, 18816, 18556, 18292, 18023, 17752, 17476, 17198, 16916, 16631, 16342, 16052, 15758, 15461, 15164, 14861, 14558, 14253, 13944, 13634, 13324, 13009, 12694, 12378, 12058, 11740, 11417, 11094, 10770, 10444, 10117, 9790, 9462, 9131, 8802, 8470, 8137, 7804, 7470, 7136, 6801, 6464, 6128, 5791, 5455, 5117, 4779, 4440, 4102, 3763, 3423, 3083, 2744, 2404, 2064, 1724, 1383, 1043, 703, 362, 22, -317, -658, -997, -1338, -1679, -2018, -2358, -2698, -3036, -3376, -3716, -4053, -4392, -4731, -5069, -5407, -5744, -6082, -6419, -6756, -7092, -7428, -7763, -8098, -8433, -8767, -9101, -9435, -9768, -10101, -10434, -10766, -11097, -11429, -11759, -12089, -12419, -12748, -13077, -13406, -13733, -14061, -14388, -14713, -15040, -15367, -15690, -16015, -16339, -16662, -16985, -17307, -17630, -17951, -18273, -18592, -18912, -19231, -19550, -19869, -20186, -20502, -20820, -21136, -21452, -21766, -22080, -22394, -22708, -23020, -23332, -23645, -23955, -24266, -24576, -24885, -25194, -25503, -25810, -26117, -26424, -26729, -27035, -27341, -27646, -27949, -28253, -28555, -28857, -29159, -29459, -29760, -30059, -30360, -30659, -30957, -31254, -31552, -31847, -32143, -32435, -32732, -32550, -31465, -29802, -27824, -25685, -23489, -21282, -19107, -16986, -14923, -12928, -11011, -9161, -7384, -5682, -4047, -2485, -959};