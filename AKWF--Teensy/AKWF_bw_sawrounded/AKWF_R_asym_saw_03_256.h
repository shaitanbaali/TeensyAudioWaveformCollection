/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_03 256 samples */
 
const int16_t AKWF_R_asym_saw_03_256_DATA [256] = 
{370, 1181, 1953, 2705, 3438, 4152, 4847, 5520, 6175, 6813, 7428, 8028, 8610, 9171, 9718, 10248, 10758, 11255, 11732, 12194, 12642, 13072, 13486, 13889, 14272, 14643, 15000, 15341, 15669, 15983, 16284, 16570, 16845, 17105, 17354, 17591, 17814, 18023, 18224, 18412, 18586, 18752, 18904, 19048, 19179, 19299, 19411, 19512, 19600, 19681, 19753, 19812, 19864, 19905, 19938, 19962, 19976, 19982, 19981, 19970, 19949, 19923, 19887, 19844, 19794, 19733, 19667, 19594, 19513, 19426, 19330, 19228, 19120, 19005, 18882, 18755, 18620, 18480, 18332, 18179, 18019, 17856, 17686, 17508, 17327, 17141, 16950, 16752, 16549, 16342, 16129, 15911, 15690, 15463, 15232, 14997, 14757, 14512, 14263, 14009, 13753, 13491, 13226, 12958, 12685, 12407, 12129, 11843, 11555, 11267, 10972, 10674, 10374, 10069, 9762, 9452, 9138, 8821, 8502, 8180, 7855, 7528, 7196, 6864, 6528, 6190, 5848, 5506, 5161, 4814, 4464, 4111, 3758, 3401, 3042, 2681, 2318, 1953, 1588, 1217, 848, 475, 101, -272, -649, -1029, -1411, -1791, -2174, -2560, -2945, -3335, -3724, -4113, -4507, -4899, -5293, -5690, -6087, -6483, -6884, -7284, -7685, -8087, -8489, -8894, -9300, -9706, -10112, -10521, -10929, -11339, -11749, -12159, -12572, -12985, -13399, -13812, -14228, -14642, -15058, -15475, -15891, -16308, -16727, -17145, -17563, -17983, -18403, -18823, -19243, -19666, -20087, -20509, -20930, -21353, -21775, -22199, -22622, -23045, -23469, -23894, -24317, -24741, -25166, -25590, -26014, -26440, -26865, -27290, -27716, -28140, -28566, -28991, -29415, -29841, -30267, -30691, -31117, -31542, -31964, -32395, -32722, -32734, -32443, -31917, -31209, -30358, -29397, -28353, -27244, -26093, -24911, -23706, -22498, -21281, -20069, -18866, -17673, -16490, -15330, -14185, -13060, -11958, -10875, -9811, -8774, -7757, -6763, -5794, -4844, -3916, -3016, -2135, -1276, -424};