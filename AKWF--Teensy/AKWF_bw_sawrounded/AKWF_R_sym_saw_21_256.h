/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_21 256 samples */
 
const int16_t AKWF_R_sym_saw_21_256_DATA [256] = 
{11181, 27708, 30833, 32013, 32609, 32765, 32731, 32586, 32382, 32143, 31885, 31619, 31347, 31074, 30800, 30525, 30249, 29974, 29699, 29423, 29148, 28874, 28598, 28323, 28048, 27774, 27499, 27224, 26951, 26676, 26402, 26129, 25854, 25581, 25306, 25032, 24759, 24485, 24212, 23939, 23666, 23393, 23121, 22847, 22574, 22302, 22029, 21755, 21484, 21212, 20938, 20667, 20395, 20122, 19850, 19579, 19306, 19035, 18764, 18491, 18220, 17948, 17677, 17406, 17133, 16863, 16592, 16321, 16050, 15780, 15508, 15237, 14967, 14695, 14425, 14155, 13883, 13613, 13343, 13073, 12803, 12532, 12262, 11992, 11721, 11451, 11181, 10911, 10641, 10372, 10101, 9831, 9562, 9291, 9022, 8752, 8482, 8213, 7943, 7673, 7404, 7134, 6865, 6596, 6325, 6056, 5788, 5517, 5248, 4979, 4709, 4440, 4172, 3902, 3632, 3363, 3094, 2824, 2555, 2286, 2017, 1747, 1478, 1210, 941, 672, 402, 133, -134, -403, -673, -942, -1211, -1479, -1748, -2018, -2287, -2556, -2825, -3095, -3364, -3633, -3903, -4172, -4441, -4710, -4980, -5249, -5518, -5788, -6057, -6326, -6596, -6865, -7135, -7405, -7674, -7944, -8214, -8483, -8752, -9022, -9292, -9562, -9831, -10102, -10373, -10642, -10911, -11182, -11452, -11722, -11993, -12262, -12532, -12803, -13073, -13344, -13614, -13884, -14155, -14426, -14696, -14967, -15238, -15508, -15780, -16051, -16322, -16593, -16863, -17134, -17406, -17678, -17949, -18220, -18492, -18765, -19036, -19307, -19580, -19851, -20122, -20395, -20667, -20939, -21212, -21484, -21756, -22029, -22302, -22575, -22847, -23121, -23394, -23666, -23939, -24212, -24486, -24760, -25033, -25307, -25581, -25854, -26129, -26403, -26676, -26951, -27225, -27499, -27774, -28048, -28323, -28598, -28874, -29148, -29423, -29699, -29974, -30249, -30525, -30800, -31074, -31347, -31619, -31885, -32143, -32382, -32586, -32731, -32765, -32609, -32013, -30833, -27709, -11182};