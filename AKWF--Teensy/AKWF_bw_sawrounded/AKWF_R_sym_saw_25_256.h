/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_25 256 samples */
 
const int16_t AKWF_R_sym_saw_25_256_DATA [256] = 
{21094, 32995, 32567, 32628, 32398, 32137, 31869, 31638, 31382, 31115, 30848, 30582, 30313, 30047, 29780, 29513, 29247, 28981, 28714, 28449, 28182, 27916, 27651, 27384, 27118, 26853, 26588, 26321, 26057, 25792, 25527, 25262, 24997, 24732, 24467, 24202, 23937, 23674, 23409, 23145, 22882, 22617, 22354, 22089, 21825, 21563, 21299, 21035, 20772, 20508, 20245, 19982, 19719, 19455, 19193, 18929, 18666, 18404, 18142, 17878, 17616, 17352, 17091, 16829, 16566, 16304, 16042, 15779, 15519, 15256, 14994, 14732, 14470, 14209, 13947, 13685, 13423, 13162, 12900, 12639, 12378, 12117, 11855, 11594, 11333, 11071, 10810, 10549, 10287, 10027, 9767, 9506, 9245, 8983, 8723, 8462, 8201, 7940, 7680, 7419, 7158, 6897, 6637, 6377, 6116, 5855, 5595, 5335, 5074, 4814, 4554, 4293, 4033, 3772, 3512, 3252, 2991, 2730, 2471, 2210, 1950, 1690, 1429, 1170, 909, 649, 389, 129, -130, -390, -650, -910, -1171, -1430, -1691, -1951, -2211, -2471, -2731, -2992, -3253, -3512, -3773, -4034, -4294, -4555, -4815, -5075, -5336, -5596, -5856, -6117, -6378, -6637, -6898, -7159, -7420, -7680, -7941, -8201, -8462, -8724, -8984, -9246, -9506, -9767, -10028, -10288, -10550, -10811, -11072, -11333, -11595, -11856, -12117, -12378, -12640, -12901, -13163, -13424, -13685, -13948, -14209, -14470, -14732, -14995, -15257, -15519, -15780, -16042, -16304, -16566, -16829, -17091, -17353, -17616, -17879, -18142, -18404, -18667, -18929, -19193, -19455, -19719, -19982, -20245, -20508, -20772, -21035, -21299, -21563, -21825, -22089, -22354, -22617, -22882, -23146, -23409, -23674, -23938, -24202, -24468, -24732, -24997, -25262, -25527, -25792, -26057, -26321, -26588, -26854, -27118, -27384, -27651, -27916, -28182, -28449, -28714, -28981, -29247, -29513, -29780, -30047, -30313, -30582, -30848, -31115, -31382, -31639, -31869, -32137, -32398, -32628, -32567, -32995, -21094};