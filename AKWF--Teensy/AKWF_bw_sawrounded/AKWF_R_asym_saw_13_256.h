/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_13 256 samples */
 
const int16_t AKWF_R_asym_saw_13_256_DATA [256] = 
{2263, 7228, 11365, 14927, 17973, 20569, 22775, 24634, 26202, 27513, 28598, 29494, 30223, 30805, 31264, 31613, 31867, 32040, 32143, 32184, 32172, 32115, 32017, 31886, 31724, 31537, 31328, 31099, 30855, 30595, 30324, 30042, 29750, 29453, 29147, 28835, 28521, 28201, 27877, 27551, 27222, 26891, 26560, 26225, 25890, 25556, 25218, 24881, 24544, 24207, 23870, 23533, 23195, 22858, 22521, 22184, 21848, 21513, 21176, 20842, 20508, 20174, 19840, 19507, 19175, 18844, 18512, 18180, 17851, 17522, 17192, 16865, 16536, 16209, 15883, 15557, 15232, 14907, 14583, 14260, 13937, 13615, 13294, 12973, 12653, 12333, 12014, 11696, 11378, 11062, 10744, 10428, 10114, 9799, 9485, 9171, 8858, 8546, 8234, 7923, 7613, 7303, 6994, 6685, 6378, 6070, 5764, 5458, 5152, 4846, 4542, 4239, 3936, 3633, 3331, 3030, 2728, 2428, 2128, 1829, 1530, 1233, 935, 639, 344, 48, -246, -539, -834, -1126, -1420, -1713, -2003, -2295, -2585, -2874, -3163, -3452, -3740, -4028, -4316, -4601, -4888, -5173, -5457, -5742, -6026, -6308, -6591, -6873, -7155, -7435, -7716, -7995, -8275, -8554, -8831, -9109, -9386, -9663, -9939, -10214, -10489, -10763, -11037, -11311, -11584, -11855, -12127, -12399, -12669, -12939, -13209, -13477, -13747, -14015, -14282, -14548, -14815, -15080, -15346, -15611, -15875, -16140, -16403, -16665, -16928, -17189, -17451, -17712, -17972, -18231, -18491, -18750, -19007, -19265, -19522, -19779, -20036, -20291, -20546, -20802, -21055, -21309, -21562, -21814, -22067, -22319, -22571, -22821, -23071, -23320, -23570, -23819, -24067, -24314, -24562, -24809, -25056, -25301, -25547, -25791, -26035, -26280, -26524, -26766, -27009, -27250, -27492, -27733, -27975, -28215, -28454, -28694, -28932, -29170, -29408, -29646, -29883, -30120, -30355, -30590, -30826, -31059, -31293, -31526, -31759, -31993, -32225, -32419, -32764, -32078, -25936, -17415, -9877, -3240};