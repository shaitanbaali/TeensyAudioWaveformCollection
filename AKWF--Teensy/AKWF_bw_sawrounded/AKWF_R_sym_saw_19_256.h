/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_19 256 samples */
 
const int16_t AKWF_R_sym_saw_19_256_DATA [256] = 
{7950, 23369, 28925, 30483, 31694, 32330, 32657, 32764, 32738, 32619, 32444, 32230, 31991, 31738, 31474, 31204, 30930, 30653, 30375, 30096, 29814, 29534, 29254, 28972, 28690, 28411, 28131, 27849, 27569, 27288, 27008, 26728, 26447, 26167, 25887, 25606, 25327, 25048, 24768, 24489, 24209, 23929, 23651, 23371, 23092, 22813, 22534, 22255, 21977, 21698, 21420, 21141, 20862, 20584, 20307, 20027, 19749, 19472, 19194, 18916, 18639, 18361, 18082, 17805, 17527, 17250, 16973, 16695, 16419, 16141, 15863, 15587, 15310, 15033, 14756, 14479, 14201, 13925, 13649, 13372, 13096, 12820, 12543, 12267, 11990, 11714, 11438, 11161, 10885, 10609, 10333, 10057, 9781, 9505, 9228, 8953, 8676, 8401, 8126, 7849, 7574, 7298, 7022, 6747, 6472, 6195, 5920, 5645, 5368, 5093, 4817, 4542, 4267, 3991, 3715, 3441, 3165, 2889, 2614, 2338, 2062, 1788, 1512, 1237, 963, 687, 413, 137, -138, -414, -688, -964, -1238, -1513, -1789, -2063, -2339, -2615, -2890, -3166, -3441, -3715, -3991, -4268, -4543, -4818, -5094, -5369, -5645, -5921, -6196, -6472, -6748, -7023, -7299, -7575, -7850, -8126, -8402, -8677, -8953, -9229, -9506, -9781, -10057, -10334, -10610, -10885, -11161, -11438, -11715, -11991, -12267, -12543, -12820, -13097, -13373, -13649, -13926, -14202, -14480, -14757, -15033, -15311, -15588, -15864, -16142, -16419, -16696, -16974, -17250, -17528, -17806, -18082, -18361, -18639, -18917, -19194, -19473, -19750, -20028, -20307, -20585, -20862, -21142, -21420, -21699, -21977, -22256, -22535, -22813, -23093, -23371, -23651, -23930, -24209, -24489, -24768, -25048, -25327, -25607, -25887, -26167, -26447, -26728, -27008, -27288, -27569, -27849, -28131, -28411, -28691, -28973, -29254, -29534, -29814, -30096, -30375, -30653, -30930, -31204, -31474, -31738, -31991, -32230, -32444, -32619, -32738, -32764, -32657, -32330, -31694, -30483, -28925, -23370, -7951};