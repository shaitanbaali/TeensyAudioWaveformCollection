/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_05 256 samples */
 
const int16_t AKWF_R_sym_saw_05_256_DATA [256] = 
{743, 2301, 3829, 5366, 6906, 8453, 10009, 11569, 13142, 14724, 16312, 17911, 19517, 21122, 22728, 24320, 25884, 27404, 28847, 30164, 31295, 32136, 32546, 32639, 32691, 32732, 32756, 32766, 32766, 32748, 32718, 32676, 32622, 32554, 32476, 32386, 32285, 32173, 32051, 31919, 31776, 31624, 31462, 31290, 31110, 30922, 30724, 30519, 30306, 30084, 29854, 29619, 29375, 29124, 28867, 28604, 28332, 28055, 27772, 27484, 27190, 26889, 26584, 26273, 25957, 25635, 25309, 24979, 24644, 24304, 23960, 23612, 23259, 22903, 22544, 22178, 21811, 21440, 21064, 20686, 20306, 19922, 19534, 19144, 18750, 18354, 17957, 17556, 17152, 16746, 16337, 15926, 15515, 15100, 14683, 14265, 13843, 13422, 12998, 12571, 12144, 11715, 11285, 10854, 10420, 9985, 9550, 9114, 8675, 8237, 7798, 7355, 6914, 6472, 6029, 5585, 5141, 4696, 4251, 3804, 3357, 2911, 2463, 2015, 1568, 1119, 672, 223, -224, -673, -1120, -1569, -2016, -2464, -2912, -3358, -3805, -4252, -4697, -5142, -5586, -6029, -6473, -6915, -7356, -7799, -8237, -8676, -9115, -9551, -9986, -10420, -10855, -11286, -11716, -12145, -12572, -12998, -13423, -13844, -14265, -14684, -15100, -15515, -15927, -16337, -16747, -17152, -17556, -17957, -18354, -18751, -19144, -19534, -19923, -20307, -20687, -21064, -21441, -21811, -22178, -22544, -22903, -23259, -23612, -23960, -24304, -24645, -24979, -25310, -25636, -25958, -26273, -26584, -26889, -27190, -27484, -27772, -28056, -28332, -28604, -28867, -29124, -29375, -29619, -29854, -30085, -30306, -30519, -30724, -30922, -31110, -31290, -31462, -31624, -31776, -31919, -32051, -32173, -32285, -32386, -32476, -32554, -32622, -32676, -32718, -32748, -32766, -32766, -32756, -32732, -32691, -32639, -32546, -32137, -31295, -30164, -28847, -27404, -25884, -24320, -22728, -21122, -19517, -17911, -16313, -14725, -13143, -11570, -10010, -8454, -6907, -5367, -3830, -2302, -744};