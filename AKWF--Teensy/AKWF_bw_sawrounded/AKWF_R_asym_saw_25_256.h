/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_25 256 samples */
 
const int16_t AKWF_R_asym_saw_25_256_DATA [256] = 
{17714, 31869, 32618, 32669, 32431, 32136, 31839, 31595, 31306, 31002, 30699, 30394, 30090, 29788, 29486, 29185, 28884, 28584, 28284, 27986, 27687, 27388, 27091, 26794, 26498, 26203, 25907, 25613, 25319, 25026, 24734, 24441, 24149, 23859, 23568, 23277, 22988, 22700, 22412, 22124, 21837, 21550, 21266, 20980, 20694, 20411, 20127, 19844, 19561, 19279, 18997, 18716, 18436, 18156, 17877, 17598, 17319, 17042, 16765, 16489, 16213, 15936, 15662, 15388, 15113, 14840, 14567, 14295, 14024, 13753, 13482, 13211, 12942, 12672, 12405, 12136, 11868, 11601, 11335, 11069, 10804, 10539, 10274, 10011, 9747, 9485, 9222, 8960, 8698, 8439, 8179, 7919, 7660, 7400, 7142, 6884, 6627, 6370, 6114, 5858, 5603, 5349, 5094, 4840, 4587, 4334, 4082, 3830, 3578, 3328, 3078, 2827, 2579, 2330, 2081, 1834, 1586, 1339, 1093, 847, 602, 357, 112, -130, -374, -617, -859, -1101, -1343, -1583, -1824, -2064, -2305, -2544, -2783, -3020, -3259, -3496, -3733, -3969, -4206, -4441, -4676, -4911, -5145, -5379, -5612, -5844, -6078, -6308, -6539, -6772, -7002, -7231, -7461, -7690, -7919, -8148, -8375, -8602, -8829, -9056, -9282, -9508, -9733, -9958, -10182, -10406, -10629, -10853, -11075, -11296, -11519, -11740, -11961, -12181, -12401, -12620, -12840, -13058, -13277, -13495, -13711, -13928, -14146, -14361, -14577, -14793, -15007, -15222, -15436, -15648, -15862, -16074, -16287, -16499, -16710, -16923, -17133, -17342, -17552, -17762, -17971, -18179, -18387, -18595, -18803, -19010, -19216, -19423, -19628, -19834, -20039, -20244, -20448, -20651, -20854, -21058, -21260, -21461, -21664, -21866, -22066, -22267, -22467, -22667, -22866, -23066, -23264, -23463, -23660, -23857, -24055, -24253, -24448, -24644, -24840, -25035, -25229, -25424, -25618, -25812, -26006, -26198, -26391, -26582, -26774, -26966, -27154, -27337, -27539, -27727, -27916, -27856, -29399, -21454};