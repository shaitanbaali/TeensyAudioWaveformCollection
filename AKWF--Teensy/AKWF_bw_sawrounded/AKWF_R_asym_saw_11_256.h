/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_11 256 samples */
 
const int16_t AKWF_R_asym_saw_11_256_DATA [256] = 
{1515, 5072, 8185, 10987, 13495, 15737, 17742, 19522, 21104, 22508, 23743, 24833, 25787, 26617, 27338, 27958, 28484, 28931, 29301, 29602, 29842, 30027, 30161, 30248, 30294, 30302, 30277, 30219, 30134, 30024, 29890, 29735, 29562, 29373, 29168, 28948, 28716, 28473, 28220, 27958, 27688, 27409, 27124, 26834, 26537, 26237, 25931, 25621, 25309, 24993, 24675, 24353, 24031, 23706, 23380, 23052, 22722, 22393, 22062, 21729, 21398, 21065, 20731, 20398, 20064, 19730, 19396, 19063, 18728, 18395, 18061, 17728, 17395, 17062, 16730, 16398, 16065, 15735, 15403, 15073, 14744, 14413, 14084, 13756, 13428, 13101, 12775, 12447, 12122, 11797, 11472, 11148, 10825, 10501, 10179, 9858, 9536, 9216, 8896, 8576, 8257, 7939, 7622, 7305, 6988, 6672, 6358, 6042, 5728, 5416, 5103, 4790, 4479, 4169, 3858, 3548, 3239, 2931, 2623, 2315, 2008, 1703, 1398, 1092, 788, 484, 181, -120, -423, -723, -1024, -1325, -1624, -1923, -2222, -2519, -2817, -3115, -3410, -3705, -4001, -4295, -4589, -4882, -5175, -5467, -5759, -6049, -6340, -6630, -6918, -7208, -7496, -7783, -8070, -8356, -8642, -8928, -9212, -9497, -9781, -10064, -10346, -10628, -10910, -11190, -11471, -11750, -12030, -12309, -12586, -12865, -13141, -13417, -13694, -13971, -14244, -14519, -14793, -15066, -15340, -15611, -15883, -16154, -16425, -16694, -16965, -17233, -17501, -17770, -18037, -18304, -18572, -18837, -19102, -19367, -19631, -19895, -20159, -20421, -20684, -20945, -21207, -21467, -21727, -21987, -22247, -22505, -22763, -23021, -23278, -23535, -23792, -24047, -24302, -24557, -24811, -25064, -25319, -25571, -25822, -26075, -26326, -26577, -26827, -27077, -27326, -27575, -27823, -28070, -28318, -28565, -28812, -29058, -29303, -29548, -29793, -30036, -30280, -30523, -30765, -31007, -31249, -31489, -31730, -31971, -32209, -32422, -32742, -32210, -28155, -22313, -16625, -11369, -6612, -2254};