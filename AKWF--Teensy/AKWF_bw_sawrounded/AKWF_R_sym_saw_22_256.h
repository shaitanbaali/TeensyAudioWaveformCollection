/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_22 256 samples */
 
const int16_t AKWF_R_sym_saw_22_256_DATA [256] = 
{14596, 28929, 31089, 32347, 32726, 32741, 32604, 32411, 32174, 31914, 31648, 31377, 31104, 30831, 30558, 30284, 30012, 29738, 29465, 29192, 28918, 28645, 28372, 28099, 27826, 27555, 27282, 27010, 26738, 26465, 26193, 25922, 25649, 25379, 25107, 24835, 24564, 24292, 24021, 23750, 23479, 23208, 22938, 22666, 22396, 22126, 21854, 21584, 21314, 21044, 20773, 20503, 20234, 19964, 19694, 19424, 19154, 18885, 18616, 18345, 18077, 17807, 17537, 17268, 16999, 16730, 16461, 16192, 15923, 15654, 15386, 15118, 14849, 14579, 14312, 14042, 13774, 13505, 13237, 12969, 12701, 12432, 12164, 11897, 11628, 11360, 11092, 10825, 10557, 10288, 10021, 9754, 9486, 9218, 8950, 8683, 8415, 8148, 7880, 7613, 7345, 7077, 6810, 6543, 6276, 6008, 5741, 5474, 5207, 4940, 4672, 4405, 4138, 3871, 3603, 3337, 3069, 2802, 2535, 2268, 2001, 1734, 1468, 1201, 934, 666, 398, 133, -134, -399, -667, -935, -1202, -1468, -1735, -2001, -2269, -2536, -2803, -3070, -3337, -3604, -3872, -4139, -4405, -4673, -4941, -5208, -5475, -5742, -6009, -6277, -6544, -6811, -7078, -7346, -7613, -7881, -8149, -8416, -8684, -8951, -9219, -9487, -9755, -10022, -10289, -10557, -10826, -11093, -11361, -11629, -11897, -12165, -12433, -12702, -12970, -13237, -13506, -13775, -14043, -14312, -14580, -14849, -15118, -15386, -15655, -15924, -16193, -16462, -16731, -17000, -17269, -17538, -17807, -18077, -18346, -18616, -18886, -19154, -19425, -19695, -19964, -20234, -20504, -20774, -21045, -21315, -21584, -21855, -22126, -22396, -22667, -22938, -23208, -23479, -23750, -24021, -24292, -24564, -24835, -25107, -25379, -25650, -25922, -26194, -26465, -26738, -27011, -27283, -27556, -27826, -28099, -28373, -28645, -28919, -29192, -29465, -29738, -30012, -30284, -30558, -30831, -31104, -31377, -31648, -31914, -32174, -32411, -32604, -32741, -32726, -32347, -31089, -28929, -14596};