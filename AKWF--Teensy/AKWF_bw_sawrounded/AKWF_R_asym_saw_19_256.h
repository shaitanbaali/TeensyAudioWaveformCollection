/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_19 256 samples */
 
const int16_t AKWF_R_asym_saw_19_256_DATA [256] = 
{8057, 17943, 23891, 27660, 29987, 31383, 32197, 32609, 32759, 32741, 32616, 32419, 32178, 31908, 31620, 31320, 31014, 30701, 30387, 30072, 29754, 29437, 29120, 28804, 28487, 28172, 27857, 27541, 27228, 26914, 26601, 26289, 25977, 25665, 25354, 25045, 24735, 24426, 24118, 23810, 23504, 23197, 22892, 22586, 22282, 21978, 21674, 21372, 21070, 20768, 20467, 20167, 19866, 19567, 19269, 18970, 18672, 18377, 18080, 17784, 17489, 17194, 16900, 16607, 16314, 16021, 15730, 15439, 15148, 14858, 14567, 14279, 13991, 13703, 13416, 13130, 12842, 12558, 12273, 11988, 11705, 11422, 11139, 10857, 10575, 10294, 10013, 9733, 9454, 9175, 8897, 8619, 8342, 8065, 7789, 7513, 7237, 6963, 6690, 6415, 6143, 5870, 5598, 5327, 5057, 4786, 4516, 4247, 3978, 3711, 3443, 3175, 2909, 2643, 2377, 2112, 1847, 1583, 1320, 1057, 794, 533, 271, 11, -249, -508, -767, -1026, -1285, -1543, -1800, -2058, -2313, -2570, -2825, -3079, -3334, -3588, -3840, -4094, -4346, -4597, -4849, -5101, -5351, -5601, -5850, -6100, -6348, -6596, -6843, -7090, -7337, -7583, -7828, -8073, -8318, -8562, -8806, -9048, -9291, -9533, -9775, -10017, -10258, -10498, -10738, -10977, -11216, -11455, -11692, -11930, -12167, -12404, -12640, -12876, -13111, -13346, -13580, -13814, -14047, -14280, -14512, -14744, -14976, -15207, -15438, -15668, -15897, -16126, -16355, -16584, -16812, -17040, -17267, -17493, -17720, -17945, -18170, -18395, -18619, -18844, -19067, -19290, -19513, -19735, -19956, -20178, -20399, -20619, -20840, -21060, -21278, -21497, -21715, -21933, -22151, -22368, -22585, -22801, -23016, -23232, -23447, -23662, -23876, -24090, -24302, -24515, -24728, -24940, -25151, -25362, -25574, -25785, -25994, -26203, -26412, -26621, -26830, -27038, -27245, -27453, -27659, -27865, -28071, -28276, -28482, -28685, -28886, -29093, -29297, -29498, -29553, -30396, -25918, -6864};