/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_03 256 samples */
 
const int16_t AKWF_R_sym_saw_03_256_DATA [256] = 
{522, 1615, 2687, 3761, 4836, 5915, 6996, 8077, 9160, 10249, 11336, 12430, 13525, 14619, 15718, 16820, 17918, 19022, 20122, 21216, 22307, 23390, 24458, 25514, 26544, 27545, 28509, 29420, 30267, 31034, 31697, 32231, 32603, 32767, 32716, 32588, 32457, 32315, 32166, 32011, 31846, 31675, 31496, 31311, 31117, 30917, 30711, 30497, 30276, 30049, 29818, 29578, 29332, 29080, 28823, 28560, 28291, 28016, 27737, 27452, 27161, 26865, 26564, 26258, 25948, 25631, 25311, 24987, 24657, 24323, 23986, 23643, 23297, 22946, 22592, 22236, 21872, 21508, 21138, 20765, 20387, 20009, 19625, 19240, 18850, 18458, 18064, 17665, 17265, 16862, 16454, 16045, 15635, 15222, 14806, 14388, 13966, 13545, 13120, 12693, 12265, 11835, 11402, 10970, 10534, 10095, 9658, 9217, 8777, 8336, 7891, 7445, 7000, 6554, 6106, 5658, 5207, 4756, 4305, 3853, 3401, 2949, 2495, 2042, 1589, 1134, 679, 226, -227, -680, -1135, -1590, -2043, -2496, -2950, -3402, -3854, -4306, -4757, -5208, -5659, -6107, -6555, -7001, -7445, -7892, -8337, -8778, -9218, -9659, -10096, -10534, -10970, -11402, -11835, -12266, -12693, -13121, -13546, -13966, -14388, -14806, -15222, -15636, -16045, -16455, -16862, -17266, -17666, -18064, -18458, -18851, -19240, -19626, -20009, -20388, -20765, -21138, -21508, -21873, -22236, -22593, -22947, -23298, -23644, -23986, -24323, -24657, -24987, -25311, -25631, -25949, -26258, -26564, -26865, -27161, -27452, -27737, -28016, -28291, -28560, -28823, -29081, -29332, -29578, -29818, -30049, -30276, -30497, -30711, -30917, -31117, -31311, -31496, -31675, -31846, -32011, -32166, -32315, -32457, -32588, -32716, -32767, -32603, -32231, -31697, -31034, -30267, -29420, -28509, -27545, -26544, -25515, -24458, -23390, -22307, -21216, -20122, -19022, -17919, -16820, -15718, -14619, -13525, -12431, -11336, -10250, -9161, -8078, -6997, -5916, -4837, -3762, -2688, -1616, -522};