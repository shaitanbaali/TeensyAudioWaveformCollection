/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_07 256 samples */
 
const int16_t AKWF_R_sym_saw_07_256_DATA [256] = 
{1059, 3276, 5457, 7653, 9864, 12096, 14351, 16624, 18918, 21225, 23514, 25752, 27854, 29663, 30864, 31319, 31561, 31796, 32001, 32176, 32327, 32455, 32560, 32640, 32702, 32743, 32763, 32767, 32752, 32719, 32670, 32606, 32528, 32435, 32327, 32206, 32074, 31927, 31769, 31602, 31424, 31234, 31035, 30826, 30609, 30385, 30150, 29908, 29659, 29402, 29137, 28867, 28590, 28307, 28018, 27722, 27423, 27118, 26807, 26494, 26175, 25851, 25523, 25192, 24857, 24517, 24175, 23828, 23480, 23128, 22771, 22414, 22054, 21690, 21324, 20957, 20586, 20215, 19840, 19463, 19086, 18706, 18323, 17940, 17554, 17169, 16781, 16391, 16000, 15609, 15216, 14822, 14428, 14031, 13633, 13235, 12835, 12435, 12035, 11634, 11232, 10827, 10425, 10021, 9615, 9209, 8805, 8397, 7990, 7584, 7176, 6766, 6359, 5951, 5541, 5131, 4722, 4312, 3902, 3491, 3080, 2670, 2259, 1849, 1439, 1027, 615, 204, -205, -616, -1028, -1440, -1850, -2260, -2671, -3081, -3492, -3902, -4313, -4723, -5132, -5541, -5951, -6360, -6767, -7176, -7584, -7990, -8398, -8805, -9209, -9616, -10022, -10425, -10828, -11232, -11634, -12035, -12436, -12835, -13235, -13633, -14031, -14428, -14822, -15216, -15609, -16001, -16392, -16782, -17169, -17555, -17940, -18323, -18706, -19086, -19464, -19840, -20215, -20587, -20957, -21325, -21690, -22055, -22415, -22772, -23128, -23480, -23828, -24175, -24517, -24857, -25192, -25523, -25851, -26175, -26494, -26808, -27119, -27423, -27723, -28018, -28308, -28590, -28867, -29137, -29402, -29659, -29908, -30150, -30385, -30609, -30826, -31035, -31234, -31424, -31602, -31769, -31927, -32074, -32206, -32327, -32435, -32528, -32606, -32670, -32719, -32752, -32767, -32763, -32743, -32702, -32640, -32560, -32455, -32327, -32176, -32001, -31796, -31561, -31319, -30864, -29663, -27854, -25753, -23514, -21225, -18919, -16625, -14352, -12097, -9864, -7654, -5458, -3277, -1060};