/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_21 256 samples */
 
const int16_t AKWF_R_asym_saw_21_256_DATA [256] = 
{12085, 23121, 28302, 30914, 32140, 32627, 32763, 32695, 32506, 32256, 31975, 31677, 31371, 31061, 30750, 30437, 30125, 29813, 29501, 29189, 28878, 28569, 28258, 27950, 27641, 27334, 27026, 26720, 26414, 26108, 25804, 25500, 25196, 24893, 24591, 24288, 23988, 23686, 23386, 23086, 22788, 22490, 22193, 21896, 21599, 21303, 21007, 20713, 20419, 20125, 19831, 19539, 19247, 18955, 18665, 18375, 18084, 17796, 17508, 17219, 16932, 16645, 16359, 16073, 15787, 15503, 15219, 14936, 14653, 14371, 14089, 13808, 13527, 13246, 12967, 12688, 12409, 12131, 11854, 11576, 11301, 11024, 10749, 10475, 10201, 9926, 9653, 9381, 9109, 8838, 8566, 8296, 8027, 7757, 7488, 7220, 6951, 6685, 6418, 6151, 5886, 5620, 5355, 5092, 4827, 4564, 4302, 4039, 3778, 3518, 3256, 2995, 2737, 2478, 2219, 1962, 1704, 1446, 1189, 934, 679, 423, 168, -84, -337, -590, -842, -1095, -1346, -1597, -1847, -2099, -2348, -2596, -2845, -3094, -3341, -3588, -3834, -4081, -4327, -4571, -4817, -5062, -5305, -5548, -5791, -6034, -6276, -6517, -6758, -6998, -7238, -7477, -7716, -7956, -8193, -8431, -8669, -8904, -9141, -9377, -9612, -9848, -10081, -10315, -10550, -10783, -11016, -11248, -11479, -11710, -11942, -12172, -12401, -12631, -12860, -13088, -13317, -13544, -13773, -13998, -14224, -14451, -14675, -14900, -15125, -15349, -15573, -15797, -16019, -16241, -16464, -16685, -16906, -17127, -17347, -17567, -17787, -18004, -18223, -18441, -18659, -18877, -19093, -19309, -19526, -19741, -19955, -20171, -20385, -20598, -20812, -21025, -21237, -21450, -21662, -21873, -22084, -22294, -22504, -22714, -22924, -23133, -23342, -23549, -23756, -23964, -24170, -24377, -24583, -24789, -24994, -25199, -25404, -25607, -25811, -26014, -26217, -26419, -26621, -26823, -27024, -27225, -27426, -27626, -27826, -28024, -28218, -28419, -28620, -28816, -28926, -29332, -28673, -8818};