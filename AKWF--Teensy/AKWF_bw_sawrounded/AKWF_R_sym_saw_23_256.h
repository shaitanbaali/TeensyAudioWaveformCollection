/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_23 256 samples */
 
const int16_t AKWF_R_sym_saw_23_256_DATA [256] = 
{15924, 30942, 32026, 32693, 32733, 32571, 32349, 32116, 31860, 31593, 31324, 31053, 30782, 30512, 30240, 29969, 29700, 29429, 29158, 28888, 28617, 28347, 28078, 27808, 27537, 27268, 26999, 26729, 26460, 26191, 25921, 25653, 25383, 25114, 24846, 24576, 24309, 24040, 23771, 23503, 23234, 22966, 22699, 22432, 22163, 21896, 21628, 21359, 21093, 20826, 20557, 20291, 20023, 19756, 19489, 19221, 18956, 18689, 18421, 18155, 17888, 17621, 17355, 17089, 16822, 16556, 16290, 16024, 15758, 15492, 15226, 14960, 14694, 14427, 14162, 13897, 13631, 13366, 13100, 12834, 12569, 12304, 12039, 11773, 11507, 11242, 10977, 10712, 10447, 10182, 9917, 9653, 9387, 9122, 8857, 8592, 8328, 8063, 7798, 7533, 7269, 7004, 6739, 6476, 6211, 5946, 5682, 5418, 5152, 4888, 4623, 4360, 4095, 3831, 3565, 3301, 3037, 2772, 2509, 2244, 1980, 1715, 1452, 1188, 925, 659, 395, 132, -133, -396, -660, -926, -1189, -1453, -1716, -1981, -2245, -2510, -2773, -3038, -3302, -3566, -3832, -4096, -4360, -4624, -4889, -5153, -5419, -5682, -5947, -6212, -6476, -6740, -7005, -7270, -7534, -7799, -8064, -8329, -8593, -8858, -9123, -9388, -9653, -9917, -10183, -10447, -10713, -10978, -11243, -11508, -11774, -12039, -12304, -12570, -12835, -13100, -13366, -13632, -13898, -14163, -14428, -14694, -14960, -15227, -15493, -15759, -16025, -16291, -16556, -16822, -17090, -17355, -17622, -17889, -18156, -18422, -18689, -18956, -19222, -19490, -19756, -20024, -20291, -20558, -20826, -21093, -21360, -21628, -21896, -22163, -22432, -22699, -22966, -23235, -23503, -23771, -24040, -24309, -24577, -24846, -25115, -25384, -25653, -25921, -26191, -26460, -26729, -26999, -27268, -27537, -27808, -28078, -28347, -28617, -28888, -29158, -29429, -29700, -29969, -30240, -30512, -30782, -31053, -31324, -31593, -31861, -32116, -32349, -32572, -32733, -32693, -32026, -30942, -15925};