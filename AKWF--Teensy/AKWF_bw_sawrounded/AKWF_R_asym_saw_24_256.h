/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_24 256 samples */
 
const int16_t AKWF_R_asym_saw_24_256_DATA [256] = 
{10973, 28610, 31886, 32704, 32710, 32485, 32204, 31956, 31670, 31366, 31061, 30753, 30448, 30143, 29837, 29533, 29230, 28926, 28623, 28321, 28020, 27718, 27418, 27118, 26819, 26520, 26223, 25925, 25629, 25332, 25037, 24741, 24446, 24153, 23860, 23567, 23275, 22983, 22691, 22402, 22111, 21821, 21534, 21245, 20957, 20671, 20384, 20097, 19812, 19527, 19243, 18959, 18676, 18393, 18111, 17829, 17548, 17267, 16988, 16709, 16430, 16152, 15874, 15597, 15320, 15044, 14768, 14494, 14219, 13945, 13672, 13399, 13126, 12855, 12584, 12313, 12042, 11773, 11504, 11235, 10967, 10699, 10432, 10166, 9900, 9634, 9370, 9105, 8840, 8577, 8314, 8052, 7792, 7529, 7269, 7008, 6748, 6489, 6230, 5971, 5714, 5456, 5199, 4944, 4689, 4431, 4178, 3923, 3669, 3416, 3164, 2911, 2659, 2408, 2157, 1907, 1657, 1407, 1158, 909, 663, 415, 168, -78, -323, -568, -813, -1057, -1301, -1545, -1788, -2031, -2273, -2516, -2757, -2996, -3236, -3477, -3715, -3954, -4193, -4432, -4668, -4906, -5142, -5378, -5614, -5849, -6084, -6318, -6551, -6785, -7017, -7250, -7482, -7713, -7943, -8175, -8405, -8634, -8863, -9092, -9321, -9548, -9777, -10003, -10230, -10456, -10681, -10907, -11131, -11355, -11580, -11803, -12026, -12249, -12471, -12692, -12915, -13136, -13355, -13575, -13795, -14014, -14233, -14451, -14669, -14886, -15102, -15320, -15536, -15751, -15967, -16182, -16396, -16611, -16824, -17038, -17250, -17462, -17674, -17886, -18097, -18307, -18518, -18728, -18938, -19146, -19355, -19563, -19772, -19978, -20186, -20392, -20597, -20804, -21009, -21215, -21419, -21623, -21827, -22031, -22234, -22437, -22639, -22840, -23042, -23243, -23443, -23644, -23844, -24042, -24241, -24442, -24639, -24837, -25034, -25232, -25428, -25625, -25821, -26017, -26212, -26407, -26601, -26795, -26988, -27182, -27374, -27559, -27760, -27951, -28142, -28142, -29375, -23327};