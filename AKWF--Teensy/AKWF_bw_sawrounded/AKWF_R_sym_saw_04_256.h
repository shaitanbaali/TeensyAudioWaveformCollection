/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_04 256 samples */
 
const int16_t AKWF_R_sym_saw_04_256_DATA [256] = 
{610, 1890, 3145, 4403, 5665, 6931, 8202, 9475, 10753, 12038, 13327, 14622, 15925, 17227, 18537, 19850, 21160, 22468, 23769, 25053, 26316, 27541, 28714, 29814, 30809, 31659, 32316, 32697, 32768, 32725, 32677, 32617, 32546, 32465, 32374, 32273, 32162, 32042, 31912, 31775, 31627, 31472, 31308, 31136, 30955, 30768, 30571, 30368, 30158, 29939, 29715, 29483, 29244, 28998, 28746, 28487, 28223, 27953, 27676, 27394, 27106, 26813, 26515, 26210, 25900, 25588, 25268, 24942, 24615, 24283, 23945, 23603, 23255, 22905, 22552, 22194, 21830, 21465, 21095, 20723, 20347, 19966, 19583, 19198, 18807, 18415, 18019, 17620, 17220, 16817, 16410, 16002, 15592, 15178, 14761, 14344, 13923, 13501, 13077, 12651, 12224, 11793, 11362, 10929, 10495, 10059, 9622, 9182, 8742, 8302, 7860, 7416, 6973, 6527, 6079, 5633, 5184, 4736, 4288, 3836, 3387, 2936, 2484, 2033, 1581, 1129, 677, 225, -226, -678, -1130, -1582, -2034, -2485, -2937, -3388, -3837, -4288, -4737, -5185, -5634, -6080, -6527, -6974, -7417, -7861, -8303, -8743, -9183, -9622, -10059, -10495, -10930, -11363, -11793, -12224, -12651, -13078, -13502, -13924, -14344, -14762, -15178, -15593, -16002, -16411, -16818, -17221, -17621, -18019, -18415, -18807, -19198, -19583, -19966, -20347, -20723, -21096, -21465, -21831, -22194, -22552, -22905, -23255, -23603, -23945, -24283, -24615, -24943, -25269, -25588, -25900, -26211, -26515, -26813, -27106, -27394, -27676, -27953, -28223, -28487, -28746, -28998, -29244, -29483, -29715, -29939, -30158, -30368, -30571, -30768, -30955, -31136, -31308, -31472, -31627, -31775, -31912, -32042, -32162, -32273, -32374, -32465, -32546, -32617, -32677, -32725, -32768, -32697, -32316, -31659, -30809, -29814, -28714, -27542, -26316, -25053, -23769, -22468, -21160, -19851, -18537, -17227, -15926, -14622, -13328, -12039, -10754, -9476, -8203, -6932, -5666, -4404, -3146, -1891, -611};