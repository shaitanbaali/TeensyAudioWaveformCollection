/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_12 256 samples */
 
const int16_t AKWF_R_sym_saw_12_256_DATA [256] = 
{2494, 7739, 12983, 18371, 23687, 27212, 28432, 29294, 30058, 30693, 31217, 31649, 31997, 32269, 32473, 32620, 32714, 32760, 32765, 32734, 32669, 32574, 32456, 32312, 32150, 31969, 31772, 31560, 31334, 31099, 30853, 30598, 30336, 30066, 29790, 29508, 29223, 28932, 28638, 28339, 28039, 27735, 27430, 27122, 26811, 26500, 26187, 25873, 25558, 25241, 24924, 24606, 24287, 23968, 23648, 23327, 23007, 22686, 22365, 22045, 21723, 21401, 21079, 20757, 20434, 20111, 19789, 19467, 19144, 18822, 18499, 18178, 17855, 17532, 17209, 16887, 16564, 16242, 15919, 15597, 15275, 14952, 14629, 14307, 13985, 13663, 13341, 13018, 12696, 12376, 12053, 11731, 11409, 11087, 10765, 10443, 10121, 9800, 9478, 9156, 8835, 8513, 8191, 7870, 7549, 7227, 6906, 6584, 6262, 5941, 5620, 5299, 4977, 4655, 4334, 4014, 3692, 3371, 3050, 2728, 2407, 2086, 1764, 1444, 1123, 801, 481, 160, -161, -482, -802, -1124, -1445, -1765, -2087, -2408, -2729, -3050, -3372, -3693, -4015, -4335, -4656, -4978, -5299, -5620, -5942, -6263, -6585, -6906, -7227, -7550, -7871, -8192, -8514, -8835, -9157, -9479, -9800, -10122, -10444, -10765, -11087, -11410, -11731, -12053, -12376, -12697, -13018, -13342, -13664, -13986, -14308, -14630, -14953, -15275, -15597, -15920, -16243, -16565, -16887, -17210, -17532, -17855, -18178, -18500, -18822, -19145, -19467, -19790, -20111, -20434, -20758, -21079, -21401, -21724, -22045, -22365, -22687, -23007, -23328, -23648, -23968, -24287, -24606, -24924, -25241, -25558, -25873, -26187, -26500, -26811, -27122, -27430, -27735, -28039, -28339, -28638, -28933, -29223, -29509, -29790, -30066, -30336, -30598, -30853, -31099, -31334, -31560, -31772, -31969, -32150, -32312, -32456, -32574, -32669, -32734, -32765, -32760, -32714, -32620, -32473, -32269, -31997, -31649, -31217, -30693, -30058, -29294, -28432, -27212, -23687, -18372, -12984, -7740, -2494};