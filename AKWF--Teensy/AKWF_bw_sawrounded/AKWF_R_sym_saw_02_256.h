/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_02 256 samples */
 
const int16_t AKWF_R_sym_saw_02_256_DATA [256] = 
{454, 1406, 2340, 3279, 4214, 5151, 6092, 7028, 7968, 8909, 9850, 10791, 11734, 12673, 13617, 14559, 15499, 16442, 17378, 18313, 19248, 20178, 21099, 22016, 22925, 23822, 24705, 25573, 26421, 27249, 28045, 28810, 29538, 30215, 30838, 31400, 31883, 32279, 32569, 32736, 32762, 32630, 32417, 32200, 31976, 31747, 31512, 31268, 31022, 30771, 30512, 30249, 29980, 29707, 29427, 29144, 28854, 28562, 28263, 27960, 27651, 27339, 27023, 26701, 26372, 26044, 25710, 25371, 25030, 24682, 24333, 23979, 23620, 23258, 22893, 22524, 22154, 21778, 21400, 21018, 20634, 20246, 19854, 19460, 19062, 18663, 18261, 17854, 17447, 17040, 16625, 16211, 15793, 15373, 14953, 14529, 14101, 13675, 13244, 12813, 12380, 11944, 11506, 11069, 10629, 10186, 9744, 9300, 8855, 8409, 7958, 7509, 7061, 6609, 6158, 5705, 5250, 4795, 4343, 3885, 3430, 2974, 2518, 2059, 1602, 1143, 686, 229, -230, -687, -1144, -1603, -2060, -2519, -2975, -3431, -3886, -4343, -4796, -5251, -5706, -6159, -6610, -7061, -7510, -7959, -8410, -8856, -9301, -9745, -10187, -10630, -11069, -11507, -11945, -12381, -12814, -13245, -13675, -14102, -14529, -14954, -15374, -15794, -16212, -16626, -17040, -17447, -17855, -18262, -18663, -19062, -19461, -19854, -20246, -20634, -21018, -21400, -21778, -22154, -22525, -22893, -23258, -23620, -23979, -24333, -24682, -25030, -25371, -25710, -26044, -26372, -26701, -27023, -27339, -27651, -27960, -28263, -28562, -28854, -29144, -29427, -29707, -29980, -30249, -30512, -30771, -31022, -31268, -31512, -31747, -31976, -32200, -32417, -32630, -32762, -32736, -32569, -32279, -31883, -31400, -30838, -30215, -29538, -28810, -28046, -27249, -26422, -25573, -24705, -23822, -22925, -22016, -21100, -20178, -19248, -18314, -17378, -16442, -15499, -14559, -13617, -12674, -11734, -10792, -9851, -8909, -7969, -7029, -6092, -5152, -4215, -3280, -2341, -1407, -455};