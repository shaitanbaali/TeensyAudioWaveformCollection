/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_18 256 samples */
 
const int16_t AKWF_R_asym_saw_18_256_DATA [256] = 
{3350, 13452, 20080, 24638, 27720, 29774, 31128, 31971, 32460, 32701, 32767, 32715, 32578, 32383, 32149, 31886, 31606, 31310, 31007, 30697, 30383, 30066, 29747, 29429, 29108, 28789, 28469, 28149, 27831, 27512, 27194, 26876, 26558, 26243, 25927, 25611, 25297, 24983, 24670, 24357, 24044, 23732, 23422, 23111, 22801, 22492, 22183, 21875, 21568, 21261, 20954, 20650, 20344, 20040, 19736, 19432, 19130, 18828, 18527, 18226, 17926, 17626, 17327, 17028, 16729, 16433, 16137, 15840, 15545, 15250, 14955, 14662, 14368, 14075, 13783, 13491, 13200, 12911, 12621, 12330, 12042, 11754, 11465, 11179, 10893, 10607, 10321, 10036, 9752, 9469, 9185, 8903, 8621, 8339, 8058, 7778, 7498, 7219, 6941, 6662, 6384, 6108, 5831, 5555, 5279, 5004, 4729, 4456, 4182, 3910, 3638, 3365, 3095, 2824, 2554, 2285, 2015, 1747, 1478, 1210, 943, 678, 411, 146, -117, -381, -644, -907, -1171, -1434, -1695, -1957, -2217, -2478, -2738, -2997, -3255, -3514, -3771, -4028, -4285, -4542, -4797, -5053, -5307, -5561, -5816, -6068, -6321, -6574, -6825, -7076, -7327, -7577, -7827, -8077, -8326, -8574, -8821, -9068, -9316, -9562, -9808, -10054, -10298, -10542, -10787, -11030, -11273, -11516, -11757, -11999, -12241, -12480, -12721, -12961, -13200, -13440, -13677, -13915, -14153, -14391, -14627, -14862, -15098, -15332, -15567, -15802, -16035, -16269, -16501, -16734, -16965, -17196, -17428, -17658, -17889, -18118, -18347, -18576, -18804, -19032, -19260, -19486, -19713, -19939, -20164, -20389, -20615, -20839, -21063, -21286, -21509, -21732, -21953, -22174, -22396, -22617, -22837, -23058, -23277, -23496, -23715, -23932, -24150, -24368, -24585, -24802, -25017, -25233, -25448, -25663, -25878, -26091, -26304, -26519, -26731, -26943, -27155, -27367, -27578, -27789, -27999, -28209, -28418, -28627, -28836, -29043, -29247, -29457, -29665, -29870, -29955, -30670, -27191, -10800};