/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_20 256 samples */
 
const int16_t AKWF_R_asym_saw_20_256_DATA [256] = 
{7190, 18927, 25287, 28949, 30984, 32049, 32570, 32757, 32733, 32587, 32371, 32111, 31826, 31529, 31222, 30912, 30599, 30285, 29970, 29656, 29341, 29028, 28715, 28401, 28089, 27778, 27467, 27156, 26847, 26536, 26228, 25920, 25613, 25306, 25000, 24693, 24389, 24084, 23780, 23477, 23174, 22872, 22571, 22270, 21970, 21670, 21370, 21072, 20775, 20476, 20180, 19884, 19587, 19292, 18999, 18704, 18411, 18119, 17826, 17534, 17244, 16953, 16663, 16374, 16085, 15796, 15508, 15222, 14936, 14649, 14363, 14078, 13795, 13510, 13228, 12945, 12662, 12381, 12100, 11819, 11540, 11260, 10982, 10704, 10425, 10149, 9872, 9595, 9320, 9045, 8771, 8497, 8224, 7951, 7678, 7407, 7135, 6865, 6594, 6324, 6056, 5787, 5519, 5252, 4985, 4718, 4452, 4186, 3921, 3657, 3393, 3130, 2868, 2604, 2342, 2081, 1820, 1559, 1300, 1041, 781, 523, 266, 9, -246, -503, -758, -1013, -1269, -1522, -1777, -2030, -2282, -2535, -2787, -3037, -3289, -3539, -3788, -4038, -4287, -4535, -4783, -5032, -5278, -5525, -5770, -6016, -6261, -6505, -6750, -6993, -7236, -7478, -7720, -7962, -8204, -8445, -8685, -8924, -9164, -9402, -9640, -9879, -10116, -10353, -10590, -10826, -11062, -11297, -11531, -11765, -11999, -12232, -12465, -12697, -12930, -13161, -13393, -13623, -13853, -14083, -14311, -14541, -14769, -14997, -15224, -15451, -15677, -15903, -16129, -16355, -16579, -16803, -17027, -17251, -17474, -17696, -17919, -18141, -18361, -18582, -18803, -19023, -19242, -19462, -19681, -19899, -20115, -20334, -20551, -20767, -20984, -21199, -21415, -21629, -21844, -22058, -22271, -22485, -22697, -22910, -23122, -23334, -23545, -23754, -23965, -24175, -24385, -24594, -24803, -25011, -25218, -25427, -25632, -25840, -26046, -26251, -26457, -26662, -26866, -27071, -27275, -27479, -27681, -27884, -28086, -28288, -28485, -28688, -28890, -29090, -29220, -29565, -29203, -12447};