/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_12 256 samples */
 
const int16_t AKWF_R_asym_saw_12_256_DATA [256] = 
{1380, 5648, 9307, 12536, 15365, 17841, 20005, 21881, 23511, 24920, 26129, 27165, 28046, 28786, 29404, 29913, 30326, 30651, 30900, 31081, 31203, 31271, 31291, 31268, 31209, 31117, 30995, 30846, 30675, 30484, 30274, 30048, 29808, 29556, 29292, 29019, 28737, 28447, 28151, 27850, 27544, 27231, 26917, 26598, 26275, 25952, 25626, 25296, 24967, 24636, 24304, 23971, 23637, 23302, 22967, 22631, 22296, 21961, 21626, 21291, 20956, 20620, 20285, 19950, 19615, 19281, 18948, 18615, 18282, 17949, 17617, 17287, 16956, 16624, 16295, 15966, 15637, 15309, 14982, 14655, 14329, 14002, 13677, 13353, 13029, 12705, 12383, 12060, 11739, 11419, 11098, 10778, 10459, 10140, 9823, 9506, 9188, 8873, 8558, 8242, 7929, 7615, 7301, 6990, 6678, 6366, 6056, 5746, 5436, 5128, 4820, 4512, 4206, 3899, 3593, 3288, 2984, 2680, 2377, 2074, 1772, 1471, 1169, 869, 570, 270, -27, -324, -623, -919, -1215, -1512, -1806, -2100, -2394, -2688, -2981, -3273, -3565, -3856, -4147, -4436, -4726, -5015, -5304, -5591, -5878, -6164, -6451, -6736, -7020, -7306, -7589, -7872, -8155, -8437, -8718, -9000, -9280, -9559, -9839, -10118, -10396, -10674, -10951, -11228, -11504, -11779, -12054, -12329, -12603, -12876, -13149, -13421, -13694, -13965, -14235, -14506, -14776, -15045, -15314, -15582, -15849, -16117, -16384, -16649, -16915, -17180, -17443, -17708, -17971, -18235, -18497, -18759, -19020, -19281, -19541, -19801, -20061, -20319, -20577, -20835, -21092, -21349, -21606, -21862, -22117, -22372, -22627, -22880, -23134, -23386, -23639, -23891, -24141, -24393, -24643, -24893, -25143, -25391, -25639, -25888, -26135, -26382, -26629, -26875, -27120, -27365, -27610, -27854, -28097, -28340, -28583, -28825, -29067, -29309, -29550, -29789, -30029, -30269, -30507, -30745, -30984, -31221, -31457, -31694, -31930, -32165, -32378, -32658, -32562, -28509, -21494, -14743, -8689, -3241};