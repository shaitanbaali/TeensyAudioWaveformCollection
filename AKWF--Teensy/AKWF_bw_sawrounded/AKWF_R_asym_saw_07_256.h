/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_07 256 samples */
 
const int16_t AKWF_R_asym_saw_07_256_DATA [256] = 
{561, 2268, 3848, 5350, 6771, 8119, 9397, 10599, 11737, 12813, 13823, 14777, 15673, 16515, 17307, 18047, 18739, 19388, 19993, 20554, 21077, 21561, 22008, 22420, 22798, 23144, 23459, 23745, 24003, 24233, 24437, 24615, 24772, 24905, 25016, 25107, 25177, 25228, 25260, 25276, 25274, 25257, 25224, 25176, 25115, 25041, 24952, 24853, 24741, 24618, 24485, 24342, 24188, 24025, 23853, 23672, 23483, 23288, 23085, 22874, 22656, 22433, 22202, 21967, 21725, 21478, 21226, 20969, 20709, 20442, 20171, 19898, 19621, 19339, 19054, 18766, 18476, 18182, 17886, 17585, 17283, 16980, 16674, 16365, 16053, 15741, 15428, 15110, 14793, 14475, 14155, 13833, 13511, 13186, 12862, 12535, 12208, 11880, 11551, 11222, 10893, 10561, 10230, 9900, 9566, 9233, 8902, 8568, 8234, 7900, 7566, 7231, 6897, 6563, 6228, 5894, 5560, 5224, 4890, 4555, 4220, 3887, 3553, 3218, 2885, 2551, 2217, 1884, 1552, 1219, 886, 553, 222, -108, -440, -770, -1101, -1431, -1760, -2090, -2419, -2747, -3076, -3403, -3729, -4057, -4383, -4708, -5034, -5360, -5683, -6008, -6332, -6654, -6977, -7299, -7621, -7941, -8262, -8581, -8902, -9219, -9538, -9857, -10173, -10491, -10807, -11122, -11438, -11752, -12066, -12379, -12692, -13004, -13317, -13628, -13938, -14249, -14559, -14867, -15176, -15483, -15791, -16099, -16405, -16710, -17016, -17320, -17624, -17929, -18230, -18533, -18835, -19136, -19436, -19737, -20036, -20334, -20634, -20931, -21227, -21526, -21821, -22117, -22412, -22706, -23001, -23294, -23587, -23878, -24171, -24460, -24751, -25041, -25331, -25620, -25907, -26195, -26483, -26770, -27055, -27341, -27626, -27910, -28194, -28477, -28760, -29043, -29325, -29605, -29886, -30167, -30445, -30725, -31003, -31280, -31559, -31835, -32111, -32379, -32677, -32682, -31528, -29439, -26932, -24261, -21564, -18903, -16326, -13849, -11472, -9204, -7046, -4991, -3041, -1155};