/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_02 256 samples */
 
const int16_t AKWF_R_asym_saw_02_256_DATA [256] = 
{219, 931, 1612, 2283, 2937, 3574, 4200, 4808, 5402, 5983, 6547, 7097, 7634, 8155, 8665, 9160, 9641, 10110, 10563, 11005, 11434, 11848, 12252, 12640, 13020, 13385, 13739, 14079, 14408, 14727, 15032, 15327, 15612, 15882, 16142, 16394, 16633, 16862, 17080, 17285, 17484, 17672, 17849, 18015, 18173, 18320, 18458, 18586, 18705, 18816, 18916, 19007, 19091, 19165, 19229, 19287, 19335, 19376, 19407, 19430, 19445, 19452, 19451, 19442, 19424, 19403, 19371, 19333, 19287, 19232, 19172, 19105, 19030, 18948, 18860, 18764, 18664, 18556, 18440, 18320, 18192, 18060, 17917, 17772, 17620, 17463, 17299, 17130, 16954, 16776, 16589, 16397, 16200, 15997, 15790, 15577, 15359, 15137, 14908, 14675, 14439, 14194, 13948, 13694, 13440, 13177, 12913, 12642, 12368, 12090, 11806, 11517, 11227, 10932, 10633, 10329, 10020, 9709, 9397, 9076, 8754, 8429, 8100, 7766, 7430, 7087, 6745, 6400, 6049, 5695, 5338, 4979, 4617, 4249, 3881, 3510, 3134, 2755, 2375, 1992, 1605, 1217, 825, 430, 34, -363, -768, -1172, -1577, -1987, -2399, -2812, -3229, -3646, -4069, -4492, -4917, -5343, -5773, -6203, -6639, -7075, -7509, -7948, -8390, -8832, -9278, -9723, -10171, -10623, -11073, -11527, -11984, -12439, -12896, -13357, -13816, -14280, -14744, -15210, -15676, -16144, -16614, -17086, -17558, -18032, -18506, -18983, -19460, -19938, -20419, -20899, -21382, -21865, -22349, -22834, -23321, -23809, -24297, -24784, -25274, -25764, -26256, -26748, -27243, -27736, -28233, -28727, -29224, -29722, -30221, -30717, -31218, -31717, -32218, -32609, -32767, -32718, -32492, -32116, -31615, -31009, -30317, -29552, -28723, -27850, -26936, -25990, -25022, -24035, -23038, -22032, -21023, -20010, -19004, -17997, -16997, -16009, -15030, -14057, -13101, -12156, -11223, -10307, -9403, -8514, -7641, -6782, -5939, -5115, -4303, -3509, -2731, -1967, -1221, -477};