/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_14 256 samples */
 
const int16_t AKWF_R_sym_saw_14_256_DATA [256] = 
{3481, 10840, 18410, 24960, 27602, 28783, 29857, 30685, 31334, 31832, 32203, 32467, 32639, 32735, 32768, 32747, 32682, 32576, 32438, 32275, 32088, 31882, 31660, 31424, 31177, 30921, 30655, 30384, 30107, 29824, 29538, 29250, 28958, 28663, 28366, 28068, 27769, 27468, 27167, 26865, 26562, 26258, 25955, 25651, 25346, 25042, 24736, 24431, 24126, 23821, 23516, 23210, 22906, 22600, 22295, 21991, 21685, 21381, 21075, 20770, 20465, 20160, 19856, 19552, 19246, 18941, 18637, 18332, 18028, 17724, 17419, 17116, 16811, 16506, 16203, 15899, 15595, 15292, 14988, 14684, 14381, 14077, 13773, 13470, 13166, 12863, 12559, 12257, 11953, 11649, 11346, 11043, 10740, 10436, 10134, 9831, 9527, 9226, 8922, 8619, 8316, 8014, 7710, 7409, 7106, 6803, 6500, 6197, 5896, 5593, 5290, 4987, 4686, 4383, 4079, 3778, 3475, 3172, 2871, 2568, 2267, 1964, 1661, 1359, 1057, 754, 453, 151, -152, -454, -755, -1058, -1360, -1662, -1965, -2268, -2569, -2871, -3173, -3476, -3779, -4080, -4383, -4687, -4988, -5291, -5594, -5896, -6198, -6501, -6803, -7107, -7410, -7711, -8014, -8317, -8619, -8923, -9226, -9528, -9832, -10134, -10437, -10741, -11044, -11347, -11650, -11953, -12257, -12560, -12863, -13167, -13471, -13773, -14077, -14381, -14684, -14989, -15293, -15596, -15900, -16204, -16507, -16812, -17116, -17420, -17724, -18028, -18333, -18638, -18942, -19246, -19552, -19856, -20160, -20465, -20771, -21076, -21381, -21685, -21991, -22296, -22600, -22907, -23211, -23516, -23821, -24127, -24432, -24736, -25042, -25346, -25651, -25955, -26258, -26562, -26865, -27167, -27468, -27769, -28069, -28366, -28663, -28958, -29250, -29538, -29824, -30107, -30384, -30655, -30921, -31177, -31424, -31660, -31882, -32088, -32275, -32438, -32576, -32682, -32747, -32768, -32735, -32639, -32467, -32203, -31832, -31334, -30685, -29858, -28783, -27602, -24960, -18411, -10840, -3482};