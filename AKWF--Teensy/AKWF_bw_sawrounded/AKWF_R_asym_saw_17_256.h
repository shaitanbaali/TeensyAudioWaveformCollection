/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_17 256 samples */
 
const int16_t AKWF_R_asym_saw_17_256_DATA [256] = 
{3305, 12076, 18233, 22742, 25999, 28340, 30005, 31145, 31906, 32383, 32649, 32759, 32754, 32665, 32512, 32313, 32079, 31821, 31543, 31252, 30951, 30643, 30331, 30013, 29694, 29374, 29051, 28728, 28406, 28082, 27759, 27437, 27114, 26792, 26471, 26149, 25829, 25509, 25189, 24871, 24553, 24235, 23918, 23602, 23286, 22971, 22657, 22343, 22030, 21717, 21404, 21094, 20783, 20472, 20163, 19854, 19545, 19237, 18930, 18623, 18318, 18011, 17707, 17403, 17099, 16796, 16495, 16192, 15891, 15591, 15290, 14991, 14692, 14394, 14096, 13799, 13502, 13206, 12911, 12616, 12322, 12028, 11735, 11442, 11150, 10858, 10568, 10278, 9988, 9699, 9410, 9123, 8835, 8549, 8262, 7977, 7691, 7406, 7122, 6839, 6556, 6273, 5992, 5711, 5430, 5149, 4870, 4591, 4312, 4035, 3757, 3479, 3204, 2928, 2652, 2377, 2104, 1830, 1557, 1284, 1011, 741, 470, 200, -69, -339, -608, -877, -1144, -1411, -1677, -1944, -2210, -2475, -2739, -3003, -3268, -3531, -3793, -4056, -4318, -4579, -4839, -5100, -5359, -5618, -5876, -6134, -6392, -6649, -6905, -7162, -7417, -7672, -7927, -8181, -8433, -8688, -8940, -9191, -9443, -9695, -9945, -10195, -10444, -10694, -10943, -11191, -11439, -11686, -11932, -12179, -12425, -12669, -12914, -13160, -13403, -13647, -13889, -14131, -14373, -14615, -14856, -15096, -15337, -15576, -15815, -16054, -16291, -16529, -16767, -17003, -17240, -17475, -17711, -17946, -18181, -18414, -18648, -18880, -19114, -19346, -19577, -19808, -20040, -20269, -20499, -20730, -20958, -21187, -21415, -21642, -21870, -22097, -22323, -22548, -22774, -22999, -23224, -23448, -23671, -23895, -24118, -24340, -24562, -24784, -25005, -25225, -25446, -25665, -25884, -26103, -26322, -26540, -26758, -26975, -27192, -27408, -27624, -27839, -28055, -28270, -28484, -28698, -28911, -29124, -29336, -29546, -29758, -29970, -30181, -30373, -30525, -31028, -23461, -7967};