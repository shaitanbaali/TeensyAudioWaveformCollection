/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_04 256 samples */
 
const int16_t AKWF_R_asym_saw_04_256_DATA [256] = 
{659, 1606, 2504, 3375, 4219, 5037, 5829, 6592, 7330, 8044, 8734, 9399, 10041, 10657, 11254, 11828, 12379, 12909, 13419, 13908, 14377, 14827, 15257, 15670, 16063, 16437, 16797, 17137, 17459, 17768, 18059, 18335, 18595, 18839, 19068, 19284, 19484, 19672, 19845, 20004, 20152, 20286, 20408, 20518, 20614, 20700, 20774, 20838, 20890, 20932, 20963, 20983, 20993, 20994, 20985, 20966, 20938, 20901, 20856, 20801, 20739, 20668, 20590, 20502, 20408, 20306, 20196, 20079, 19956, 19825, 19688, 19545, 19393, 19237, 19073, 18905, 18730, 18549, 18364, 18172, 17975, 17774, 17566, 17354, 17136, 16916, 16688, 16456, 16222, 15982, 15738, 15489, 15239, 14982, 14722, 14458, 14190, 13920, 13645, 13367, 13087, 12802, 12515, 12226, 11931, 11635, 11336, 11034, 10729, 10422, 10113, 9801, 9487, 9170, 8850, 8529, 8205, 7880, 7553, 7222, 6891, 6558, 6222, 5884, 5545, 5205, 4863, 4520, 4175, 3828, 3480, 3129, 2780, 2428, 2074, 1720, 1365, 1006, 650, 291, -71, -430, -793, -1156, -1519, -1884, -2250, -2615, -2982, -3351, -3718, -4087, -4457, -4827, -5198, -5570, -5942, -6314, -6687, -7061, -7435, -7809, -8184, -8560, -8934, -9309, -9685, -10061, -10438, -10815, -11191, -11568, -11947, -12322, -12700, -13080, -13456, -13833, -14212, -14590, -14969, -15347, -15723, -16101, -16480, -16858, -17236, -17613, -17990, -18370, -18747, -19123, -19502, -19878, -20255, -20632, -21009, -21385, -21762, -22137, -22513, -22890, -23264, -23640, -24016, -24389, -24764, -25138, -25512, -25885, -26259, -26631, -27003, -27376, -27747, -28120, -28492, -28861, -29232, -29602, -29972, -30341, -30710, -31078, -31447, -31814, -32179, -32553, -32767, -32524, -31881, -30959, -29834, -28567, -27208, -25787, -24330, -22858, -21383, -19917, -18468, -17039, -15636, -14264, -12919, -11608, -10330, -9083, -7870, -6691, -5543, -4429, -3347, -2297, -1280, -275};