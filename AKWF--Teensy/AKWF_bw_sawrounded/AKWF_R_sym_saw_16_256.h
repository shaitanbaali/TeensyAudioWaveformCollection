/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_16 256 samples */
 
const int16_t AKWF_R_sym_saw_16_256_DATA [256] = 
{4980, 15984, 24521, 27411, 28991, 30278, 31196, 31843, 32284, 32563, 32714, 32766, 32742, 32657, 32527, 32360, 32164, 31947, 31711, 31463, 31204, 30937, 30665, 30386, 30105, 29820, 29533, 29245, 28955, 28663, 28372, 28081, 27787, 27495, 27202, 26907, 26615, 26321, 26027, 25735, 25441, 25147, 24855, 24560, 24267, 23975, 23682, 23388, 23096, 22804, 22510, 22219, 21926, 21632, 21340, 21048, 20755, 20464, 20172, 19880, 19588, 19295, 19003, 18712, 18420, 18129, 17838, 17546, 17255, 16963, 16672, 16381, 16089, 15798, 15508, 15217, 14925, 14635, 14344, 14053, 13763, 13472, 13182, 12891, 12601, 12311, 12020, 11730, 11439, 11150, 10859, 10569, 10279, 9988, 9698, 9409, 9119, 8829, 8539, 8250, 7960, 7670, 7379, 7090, 6801, 6511, 6221, 5932, 5642, 5353, 5063, 4773, 4484, 4194, 3905, 3615, 3326, 3036, 2747, 2458, 2169, 1880, 1589, 1300, 1011, 722, 433, 145, -146, -434, -723, -1012, -1301, -1590, -1881, -2170, -2459, -2748, -3037, -3327, -3616, -3906, -4195, -4485, -4774, -5064, -5354, -5642, -5932, -6222, -6512, -6802, -7091, -7380, -7670, -7960, -8251, -8540, -8830, -9119, -9410, -9699, -9989, -10280, -10570, -10860, -11151, -11439, -11730, -12021, -12311, -12602, -12892, -13182, -13473, -13764, -14054, -14345, -14636, -14926, -15217, -15509, -15799, -16090, -16381, -16672, -16964, -17255, -17546, -17838, -18129, -18420, -18712, -19004, -19295, -19588, -19880, -20172, -20464, -20756, -21048, -21341, -21632, -21926, -22219, -22511, -22804, -23096, -23388, -23682, -23975, -24268, -24561, -24855, -25147, -25441, -25735, -26027, -26322, -26616, -26908, -27202, -27496, -27787, -28081, -28372, -28664, -28955, -29245, -29533, -29821, -30105, -30386, -30665, -30937, -31204, -31463, -31711, -31947, -32164, -32360, -32527, -32657, -32742, -32766, -32714, -32563, -32284, -31843, -31196, -30278, -28991, -27411, -24522, -15985, -4981};