/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_11 256 samples */
 
const int16_t AKWF_R_sym_saw_11_256_DATA [256] = 
{2078, 6445, 10786, 15231, 19753, 24212, 27555, 28831, 29527, 30184, 30734, 31202, 31596, 31921, 32185, 32394, 32551, 32663, 32733, 32765, 32762, 32728, 32667, 32580, 32469, 32337, 32186, 32018, 31835, 31637, 31426, 31202, 30969, 30726, 30474, 30213, 29947, 29674, 29393, 29110, 28820, 28526, 28228, 27927, 27622, 27314, 27004, 26691, 26375, 26059, 25740, 25419, 25099, 24776, 24451, 24126, 23800, 23473, 23145, 22816, 22487, 22157, 21827, 21496, 21165, 20833, 20501, 20170, 19837, 19505, 19172, 18840, 18507, 18173, 17840, 17507, 17173, 16840, 16506, 16172, 15840, 15505, 15171, 14837, 14504, 14170, 13837, 13502, 13167, 12835, 12500, 12167, 11834, 11499, 11165, 10833, 10499, 10165, 9831, 9497, 9164, 8831, 8497, 8164, 7831, 7496, 7164, 6829, 6496, 6164, 5830, 5496, 5163, 4831, 4497, 4163, 3829, 3498, 3164, 2830, 2497, 2165, 1831, 1498, 1165, 831, 498, 166, -167, -499, -832, -1166, -1499, -1832, -2166, -2498, -2831, -3165, -3499, -3830, -4164, -4498, -4832, -5164, -5497, -5831, -6165, -6497, -6830, -7164, -7497, -7831, -8165, -8497, -8831, -9165, -9498, -9832, -10165, -10500, -10834, -11166, -11499, -11834, -12167, -12501, -12836, -13168, -13503, -13838, -14170, -14504, -14838, -15171, -15506, -15840, -16172, -16506, -16841, -17173, -17507, -17841, -18174, -18508, -18840, -19172, -19505, -19838, -20170, -20502, -20834, -21166, -21497, -21827, -22157, -22488, -22816, -23145, -23473, -23800, -24127, -24451, -24776, -25099, -25420, -25740, -26059, -26376, -26691, -27004, -27314, -27622, -27927, -28228, -28526, -28820, -29110, -29394, -29674, -29947, -30213, -30474, -30726, -30969, -31202, -31426, -31637, -31835, -32018, -32186, -32337, -32469, -32580, -32667, -32728, -32762, -32765, -32733, -32663, -32551, -32394, -32185, -31921, -31596, -31202, -30734, -30185, -29527, -28831, -27555, -24212, -19753, -15231, -10786, -6446, -2079};