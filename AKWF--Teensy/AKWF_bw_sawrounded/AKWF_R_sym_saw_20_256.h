/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_20 256 samples */
 
const int16_t AKWF_R_sym_saw_20_256_DATA [256] = 
{10500, 25737, 29331, 31104, 32123, 32586, 32755, 32747, 32629, 32444, 32220, 31972, 31712, 31444, 31171, 30896, 30620, 30342, 30063, 29785, 29506, 29228, 28951, 28672, 28393, 28117, 27838, 27560, 27282, 27004, 26726, 26450, 26173, 25896, 25619, 25340, 25065, 24787, 24510, 24234, 23958, 23681, 23405, 23129, 22852, 22576, 22300, 22024, 21748, 21472, 21198, 20921, 20645, 20370, 20094, 19819, 19544, 19270, 18994, 18719, 18445, 18169, 17895, 17620, 17346, 17071, 16796, 16522, 16248, 15973, 15699, 15425, 15151, 14877, 14603, 14329, 14055, 13782, 13507, 13233, 12960, 12686, 12412, 12139, 11865, 11591, 11319, 11045, 10771, 10498, 10226, 9953, 9679, 9406, 9132, 8860, 8586, 8314, 8041, 7768, 7495, 7221, 6949, 6677, 6404, 6131, 5858, 5585, 5313, 5040, 4767, 4495, 4223, 3949, 3677, 3405, 3132, 2859, 2587, 2315, 2041, 1769, 1497, 1225, 953, 680, 407, 135, -136, -408, -681, -954, -1226, -1498, -1770, -2041, -2315, -2588, -2859, -3133, -3406, -3677, -3950, -4224, -4496, -4768, -5041, -5313, -5586, -5859, -6132, -6405, -6678, -6950, -7222, -7495, -7768, -8042, -8315, -8587, -8861, -9133, -9406, -9680, -9953, -10227, -10499, -10772, -11046, -11320, -11592, -11866, -12139, -12412, -12686, -12960, -13234, -13508, -13782, -14055, -14329, -14603, -14877, -15151, -15425, -15699, -15974, -16249, -16522, -16797, -17071, -17346, -17621, -17896, -18170, -18445, -18720, -18994, -19270, -19544, -19820, -20095, -20370, -20646, -20922, -21198, -21473, -21748, -22024, -22300, -22576, -22852, -23129, -23405, -23681, -23958, -24234, -24511, -24787, -25065, -25340, -25619, -25896, -26173, -26450, -26726, -27005, -27283, -27560, -27838, -28117, -28394, -28672, -28951, -29228, -29506, -29785, -30063, -30342, -30620, -30896, -31171, -31445, -31712, -31972, -32220, -32444, -32629, -32747, -32755, -32586, -32123, -31104, -29331, -25737, -10501};