/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_13 256 samples */
 
const int16_t AKWF_R_sym_saw_13_256_DATA [256] = 
{2907, 9041, 15213, 21601, 26458, 28192, 29176, 30057, 30763, 31332, 31783, 32134, 32394, 32579, 32698, 32757, 32767, 32733, 32663, 32559, 32426, 32270, 32092, 31896, 31685, 31459, 31220, 30972, 30715, 30450, 30178, 29902, 29618, 29332, 29041, 28747, 28451, 28152, 27850, 27548, 27243, 26937, 26631, 26322, 26014, 25704, 25394, 25083, 24773, 24461, 24149, 23838, 23525, 23213, 22901, 22588, 22276, 21963, 21649, 21337, 21025, 20711, 20399, 20086, 19773, 19461, 19148, 18835, 18522, 18210, 17897, 17585, 17273, 16960, 16648, 16335, 16023, 15711, 15399, 15087, 14775, 14463, 14151, 13839, 13528, 13215, 12904, 12593, 12280, 11970, 11658, 11347, 11036, 10724, 10412, 10101, 9790, 9479, 9167, 8856, 8545, 8233, 7922, 7612, 7301, 6990, 6679, 6368, 6056, 5746, 5436, 5124, 4814, 4503, 4192, 3882, 3571, 3260, 2949, 2638, 2327, 2017, 1707, 1396, 1086, 775, 464, 155, -156, -465, -776, -1087, -1397, -1708, -2018, -2328, -2638, -2950, -3261, -3571, -3883, -4193, -4504, -4815, -5125, -5437, -5747, -6057, -6369, -6680, -6991, -7302, -7613, -7923, -8234, -8546, -8857, -9168, -9480, -9790, -10102, -10413, -10725, -11036, -11347, -11659, -11971, -12281, -12593, -12905, -13216, -13528, -13840, -14151, -14464, -14776, -15088, -15399, -15711, -16024, -16336, -16648, -16960, -17273, -17586, -17898, -18211, -18523, -18835, -19148, -19461, -19774, -20086, -20399, -20711, -21025, -21337, -21649, -21964, -22276, -22588, -22901, -23213, -23526, -23838, -24149, -24461, -24773, -25084, -25394, -25705, -26014, -26322, -26631, -26937, -27243, -27549, -27850, -28152, -28451, -28747, -29041, -29332, -29619, -29902, -30178, -30450, -30715, -30972, -31220, -31459, -31685, -31896, -32092, -32270, -32426, -32559, -32663, -32733, -32767, -32757, -32698, -32579, -32394, -32134, -31783, -31332, -30763, -30057, -29176, -28193, -26458, -21601, -15213, -9042, -2908};