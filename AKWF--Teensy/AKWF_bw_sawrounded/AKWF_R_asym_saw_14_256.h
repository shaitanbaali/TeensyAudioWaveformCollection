/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_14 256 samples */
 
const int16_t AKWF_R_asym_saw_14_256_DATA [256] = 
{2338, 8182, 12902, 16840, 20111, 22815, 25038, 26848, 28318, 29501, 30437, 31170, 31732, 32146, 32441, 32632, 32737, 32769, 32740, 32659, 32536, 32376, 32187, 31971, 31735, 31480, 31210, 30928, 30636, 30334, 30027, 29713, 29394, 29070, 28743, 28415, 28083, 27751, 27416, 27082, 26746, 26408, 26072, 25736, 25398, 25062, 24724, 24388, 24051, 23716, 23380, 23045, 22711, 22376, 22043, 21710, 21377, 21046, 20715, 20385, 20054, 19725, 19396, 19068, 18740, 18413, 18088, 17761, 17436, 17112, 16787, 16464, 16142, 15819, 15499, 15178, 14857, 14539, 14219, 13900, 13584, 13267, 12950, 12635, 12319, 12005, 11692, 11378, 11065, 10754, 10442, 10130, 9821, 9510, 9202, 8894, 8585, 8279, 7972, 7665, 7361, 7056, 6751, 6448, 6145, 5842, 5541, 5239, 4938, 4639, 4339, 4040, 3742, 3444, 3146, 2851, 2554, 2259, 1965, 1670, 1377, 1085, 791, 499, 209, -82, -372, -661, -951, -1239, -1527, -1815, -2101, -2388, -2674, -2959, -3244, -3527, -3810, -4094, -4376, -4657, -4939, -5221, -5499, -5780, -6059, -6337, -6615, -6893, -7169, -7446, -7722, -7997, -8272, -8546, -8819, -9093, -9366, -9637, -9909, -10180, -10450, -10721, -10990, -11259, -11527, -11795, -12063, -12329, -12596, -12861, -13127, -13391, -13655, -13920, -14183, -14445, -14708, -14969, -15230, -15491, -15751, -16011, -16269, -16528, -16786, -17043, -17300, -17557, -17813, -18068, -18324, -18578, -18832, -19086, -19339, -19591, -19844, -20095, -20347, -20597, -20847, -21097, -21346, -21594, -21842, -22091, -22338, -22584, -22831, -23076, -23321, -23566, -23810, -24054, -24298, -24541, -24782, -25025, -25266, -25507, -25748, -25987, -26227, -26466, -26704, -26944, -27181, -27418, -27655, -27891, -28127, -28363, -28597, -28832, -29066, -29299, -29532, -29766, -29997, -30229, -30461, -30691, -30921, -31151, -31378, -31608, -31838, -32064, -32231, -32676, -30897, -22309, -12550, -4321};