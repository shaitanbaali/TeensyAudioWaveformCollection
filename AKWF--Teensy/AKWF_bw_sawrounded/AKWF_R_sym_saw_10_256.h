/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_10 256 samples */
 
const int16_t AKWF_R_sym_saw_10_256_DATA [256] = 
{1714, 5308, 8862, 12485, 16177, 19935, 23683, 27098, 29145, 29842, 30370, 30847, 31255, 31602, 31899, 32144, 32343, 32500, 32619, 32701, 32749, 32767, 32756, 32720, 32659, 32576, 32472, 32349, 32209, 32051, 31879, 31694, 31496, 31286, 31065, 30834, 30594, 30346, 30089, 29826, 29555, 29278, 28996, 28708, 28416, 28120, 27819, 27513, 27205, 26894, 26579, 26263, 25943, 25620, 25297, 24970, 24641, 24313, 23981, 23648, 23316, 22981, 22644, 22307, 21969, 21631, 21291, 20950, 20609, 20268, 19927, 19583, 19241, 18897, 18553, 18209, 17863, 17519, 17174, 16828, 16484, 16137, 15791, 15446, 15100, 14753, 14407, 14059, 13713, 13367, 13019, 12673, 12326, 11978, 11631, 11285, 10937, 10590, 10243, 9895, 9548, 9200, 8854, 8507, 8159, 7812, 7464, 7117, 6770, 6423, 6076, 5728, 5380, 5034, 4686, 4339, 3991, 3644, 3298, 2950, 2602, 2256, 1908, 1560, 1214, 866, 520, 172, -173, -521, -867, -1215, -1561, -1909, -2257, -2602, -2951, -3299, -3644, -3992, -4340, -4687, -5035, -5381, -5729, -6077, -6424, -6770, -7118, -7465, -7813, -8160, -8508, -8855, -9201, -9549, -9896, -10243, -10590, -10938, -11285, -11631, -11979, -12327, -12673, -13020, -13367, -13714, -14060, -14408, -14753, -15100, -15446, -15792, -16138, -16485, -16829, -17175, -17520, -17864, -18209, -18554, -18897, -19241, -19584, -19927, -20268, -20609, -20951, -21291, -21631, -21969, -22308, -22645, -22981, -23316, -23649, -23981, -24313, -24641, -24970, -25297, -25620, -25943, -26263, -26579, -26895, -27206, -27513, -27819, -28120, -28416, -28708, -28996, -29278, -29555, -29826, -30089, -30346, -30594, -30834, -31065, -31286, -31496, -31694, -31879, -32051, -32209, -32349, -32472, -32576, -32659, -32720, -32756, -32767, -32749, -32701, -32619, -32500, -32343, -32144, -31899, -31602, -31255, -30847, -30370, -29842, -29145, -27098, -23683, -19935, -16177, -12486, -8863, -5309, -1715};