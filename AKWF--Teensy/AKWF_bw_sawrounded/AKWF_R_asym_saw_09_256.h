/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_09 256 samples */
 
const int16_t AKWF_R_asym_saw_09_256_DATA [256] = 
{1507, 3957, 6174, 8234, 10139, 11902, 13531, 15029, 16412, 17684, 18848, 19918, 20895, 21785, 22596, 23334, 23998, 24598, 25137, 25616, 26043, 26419, 26747, 27030, 27273, 27477, 27643, 27777, 27878, 27949, 27993, 28010, 28004, 27973, 27922, 27851, 27762, 27654, 27531, 27393, 27240, 27073, 26896, 26705, 26503, 26292, 26073, 25844, 25606, 25362, 25110, 24851, 24587, 24315, 24041, 23760, 23475, 23186, 22892, 22594, 22295, 21991, 21685, 21377, 21065, 20751, 20436, 20118, 19798, 19478, 19155, 18832, 18507, 18181, 17854, 17526, 17198, 16869, 16539, 16208, 15879, 15547, 15216, 14885, 14553, 14222, 13890, 13557, 13225, 12894, 12562, 12229, 11898, 11567, 11237, 10905, 10574, 10244, 9914, 9584, 9256, 8926, 8597, 8270, 7943, 7614, 7287, 6962, 6635, 6310, 5985, 5660, 5337, 5013, 4691, 4369, 4046, 3724, 3404, 3084, 2764, 2445, 2127, 1809, 1491, 1173, 857, 541, 225, -88, -402, -716, -1028, -1340, -1653, -1963, -2274, -2585, -2893, -3202, -3511, -3818, -4126, -4433, -4739, -5043, -5349, -5653, -5956, -6260, -6561, -6864, -7165, -7466, -7767, -8066, -8364, -8663, -8961, -9258, -9555, -9851, -10147, -10442, -10735, -11030, -11324, -11617, -11908, -12200, -12490, -12781, -13071, -13360, -13649, -13937, -14224, -14512, -14798, -15084, -15370, -15655, -15938, -16223, -16506, -16787, -17071, -17353, -17632, -17914, -18193, -18472, -18751, -19030, -19307, -19584, -19861, -20137, -20413, -20687, -20961, -21236, -21509, -21781, -22054, -22326, -22597, -22868, -23137, -23408, -23677, -23944, -24213, -24480, -24748, -25014, -25281, -25546, -25811, -26075, -26339, -26603, -26866, -27127, -27390, -27650, -27912, -28172, -28432, -28691, -28950, -29208, -29466, -29724, -29980, -30237, -30493, -30747, -31002, -31256, -31510, -31763, -32015, -32265, -32506, -32785, -31926, -28935, -25065, -21073, -17182, -13501, -10056, -6836, -3844, -1014};