/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_24 256 samples */
 
const int16_t AKWF_R_sym_saw_24_256_DATA [256] = 
{18457, 31202, 32302, 32741, 32642, 32419, 32159, 31926, 31669, 31401, 31133, 30863, 30593, 30325, 30055, 29786, 29518, 29248, 28979, 28711, 28443, 28174, 27906, 27637, 27369, 27101, 26833, 26565, 26298, 26030, 25763, 25495, 25227, 24961, 24693, 24426, 24159, 23893, 23626, 23359, 23093, 22825, 22560, 22294, 22027, 21762, 21495, 21229, 20963, 20697, 20432, 20166, 19900, 19635, 19370, 19105, 18839, 18574, 18309, 18044, 17779, 17514, 17249, 16984, 16719, 16454, 16190, 15926, 15661, 15397, 15133, 14868, 14604, 14340, 14076, 13811, 13548, 13284, 13020, 12756, 12491, 12228, 11964, 11701, 11437, 11173, 10910, 10647, 10382, 10119, 9856, 9594, 9331, 9067, 8803, 8540, 8276, 8014, 7751, 7487, 7225, 6961, 6698, 6436, 6173, 5909, 5647, 5384, 5121, 4858, 4596, 4332, 4070, 3807, 3544, 3282, 3019, 2756, 2493, 2230, 1968, 1706, 1443, 1180, 917, 655, 393, 131, -132, -394, -656, -918, -1181, -1444, -1707, -1969, -2231, -2494, -2757, -3020, -3283, -3545, -3808, -4070, -4333, -4597, -4859, -5122, -5385, -5648, -5909, -6173, -6436, -6699, -6962, -7225, -7488, -7751, -8015, -8277, -8541, -8804, -9067, -9331, -9594, -9857, -10120, -10383, -10647, -10911, -11174, -11438, -11702, -11965, -12229, -12492, -12756, -13021, -13285, -13548, -13812, -14077, -14340, -14604, -14869, -15133, -15398, -15662, -15927, -16191, -16455, -16719, -16984, -17250, -17514, -17779, -18044, -18310, -18574, -18839, -19105, -19371, -19636, -19901, -20167, -20432, -20698, -20964, -21229, -21496, -21763, -22027, -22294, -22561, -22826, -23093, -23359, -23626, -23893, -24160, -24426, -24694, -24961, -25228, -25496, -25763, -26030, -26298, -26565, -26833, -27101, -27369, -27637, -27906, -28174, -28443, -28711, -28979, -29248, -29518, -29786, -30055, -30325, -30594, -30863, -31133, -31401, -31669, -31926, -32159, -32419, -32642, -32741, -32302, -31202, -18457};