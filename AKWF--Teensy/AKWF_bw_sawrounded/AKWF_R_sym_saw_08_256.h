/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_sym_saw_08 256 samples */
 
const int16_t AKWF_R_sym_saw_08_256_DATA [256] = 
{1241, 3842, 6403, 8989, 11601, 14246, 16927, 19631, 22344, 25009, 27491, 29502, 30514, 30886, 31219, 31513, 31771, 31995, 32188, 32350, 32482, 32588, 32668, 32724, 32756, 32768, 32756, 32726, 32678, 32611, 32527, 32428, 32313, 32184, 32041, 31885, 31718, 31539, 31348, 31147, 30936, 30715, 30486, 30248, 30003, 29750, 29488, 29221, 28948, 28668, 28384, 28091, 27794, 27493, 27186, 26876, 26561, 26243, 25920, 25594, 25264, 24931, 24597, 24258, 23915, 23571, 23226, 22876, 22525, 22172, 21817, 21460, 21101, 20740, 20379, 20016, 19650, 19284, 18917, 18548, 18177, 17807, 17435, 17062, 16688, 16314, 15939, 15562, 15184, 14807, 14428, 14049, 13669, 13290, 12909, 12528, 12146, 11764, 11382, 10998, 10615, 10231, 9848, 9464, 9080, 8694, 8309, 7925, 7538, 7153, 6767, 6381, 5996, 5610, 5223, 4836, 4451, 4063, 3676, 3289, 2902, 2516, 2128, 1741, 1354, 968, 580, 193, -194, -581, -969, -1355, -1742, -2129, -2516, -2903, -3290, -3677, -4064, -4452, -4837, -5223, -5611, -5997, -6382, -6768, -7154, -7539, -7926, -8310, -8695, -9080, -9465, -9848, -10232, -10616, -10999, -11383, -11764, -12146, -12528, -12910, -13290, -13669, -14049, -14428, -14808, -15184, -15563, -15939, -16314, -16689, -17063, -17435, -17807, -18178, -18548, -18917, -19284, -19651, -20017, -20380, -20741, -21101, -21460, -21817, -22173, -22526, -22876, -23226, -23572, -23915, -24258, -24597, -24931, -25265, -25594, -25920, -26243, -26561, -26876, -27186, -27493, -27795, -28091, -28384, -28668, -28948, -29221, -29489, -29750, -30003, -30248, -30486, -30715, -30936, -31147, -31348, -31539, -31718, -31885, -32041, -32184, -32313, -32428, -32527, -32611, -32678, -32726, -32756, -32768, -32756, -32724, -32668, -32588, -32482, -32350, -32188, -31995, -31771, -31513, -31219, -30886, -30514, -29502, -27491, -25009, -22344, -19631, -16928, -14246, -11601, -8990, -6404, -3843, -1242};