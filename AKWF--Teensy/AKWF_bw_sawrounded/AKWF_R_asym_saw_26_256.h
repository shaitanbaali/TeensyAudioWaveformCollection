/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_R_asym_saw_26 256 samples */
 
const int16_t AKWF_R_asym_saw_26_256_DATA [256] = 
{25143, 33377, 32447, 32289, 31999, 31697, 31407, 31173, 30877, 30575, 30274, 29974, 29674, 29376, 29077, 28780, 28483, 28187, 27890, 27595, 27300, 27005, 26711, 26418, 26125, 25834, 25542, 25251, 24962, 24671, 24382, 24094, 23805, 23518, 23231, 22944, 22659, 22374, 22089, 21804, 21521, 21238, 20956, 20675, 20392, 20112, 19832, 19552, 19273, 18994, 18715, 18438, 18161, 17885, 17609, 17334, 17059, 16784, 16511, 16238, 15965, 15693, 15421, 15151, 14879, 14609, 14340, 14071, 13804, 13536, 13267, 13001, 12734, 12467, 12203, 11938, 11674, 11410, 11147, 10884, 10622, 10360, 10099, 9838, 9578, 9319, 9060, 8800, 8543, 8286, 8029, 7772, 7516, 7260, 7005, 6751, 6495, 6242, 5989, 5737, 5485, 5233, 4981, 4731, 4481, 4231, 3983, 3733, 3485, 3238, 2990, 2743, 2497, 2251, 2005, 1761, 1517, 1273, 1030, 786, 544, 302, 61, -179, -418, -658, -899, -1137, -1377, -1614, -1852, -2090, -2327, -2563, -2799, -3034, -3269, -3504, -3738, -3970, -4205, -4437, -4669, -4901, -5133, -5364, -5594, -5824, -6053, -6282, -6510, -6740, -6967, -7194, -7421, -7647, -7873, -8099, -8323, -8548, -8772, -8996, -9219, -9443, -9665, -9887, -10108, -10330, -10550, -10771, -10991, -11209, -11429, -11648, -11866, -12083, -12300, -12517, -12734, -12950, -13166, -13380, -13595, -13810, -14023, -14237, -14450, -14663, -14875, -15087, -15297, -15509, -15719, -15929, -16139, -16349, -16558, -16766, -16975, -17182, -17389, -17596, -17803, -18008, -18214, -18420, -18625, -18829, -19032, -19237, -19441, -19642, -19845, -20047, -20248, -20450, -20652, -20852, -21052, -21251, -21451, -21650, -21848, -22046, -22245, -22441, -22639, -22836, -23031, -23228, -23424, -23618, -23812, -24007, -24201, -24395, -24588, -24780, -24973, -25165, -25356, -25549, -25739, -25929, -26120, -26309, -26499, -26689, -26873, -27055, -27258, -27439, -27628, -27476, -29497, -18614};