/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0004 256 samples */
 
const int16_t AKWF_blended_0004_256_DATA [256] = 
{315, 889, 1451, 2019, 2586, 3154, 3724, 4295, 4866, 5439, 6011, 6586, 7161, 7735, 8313, 8890, 9466, 10044, 10622, 11200, 11780, 12359, 12940, 13520, 14102, 14683, 15264, 15845, 16427, 17011, 17592, 18175, 18758, 19341, 19925, 20508, 21092, 21675, 22260, 22843, 23428, 24012, 24595, 25180, 25765, 26349, 26934, 27520, 28103, 28688, 29275, 29858, 30443, 31029, 31564, 32330, 31714, 26234, 18929, 13857, 10944, 9234, 8259, 7735, 7487, 7411, 7445, 7552, 7707, 7899, 8118, 8357, 8616, 8891, 9180, 9483, 9800, 10128, 10468, 10820, 11180, 11554, 11935, 12327, 12729, 13138, 13556, 13984, 14419, 14860, 15311, 15767, 16229, 16699, 17175, 17656, 18144, 18635, 19132, 19635, 20142, 20653, 21169, 21688, 22211, 22739, 23269, 23803, 24341, 24878, 25379, 26122, 25648, 21899, 17101, 9981, 3736, -1767, -5992, -9185, -11608, -13448, -14840, -15880, -16645, -17199, -17584, -17839, -17991, -18060, -18062, -18012, -17920, -17793, -17638, -17459, -17260, -17044, -16814, -16570, -16315, -16050, -15775, -15493, -15201, -14901, -14596, -14282, -13961, -13636, -13303, -12964, -12621, -12272, -11916, -11555, -11189, -10817, -10442, -10061, -9674, -9283, -8889, -8489, -8086, -7676, -7263, -6846, -6425, -6000, -5571, -5138, -4700, -4261, -3817, -3368, -2917, -2463, -2004, -1544, -1079, -610, -192, 461, -264, -5849, -13258, -18430, -21438, -23244, -24311, -24924, -25262, -25424, -25472, -25446, -25369, -25253, -25110, -24942, -24754, -24546, -24325, -24084, -23831, -23563, -23283, -22988, -22682, -22365, -22035, -21693, -21341, -20979, -20609, -20226, -19834, -19436, -19026, -18610, -18186, -17753, -17313, -16868, -16413, -15955, -15490, -15016, -14540, -14057, -13569, -13077, -12580, -12077, -11572, -11061, -10547, -10029, -9507, -8982, -8456, -7923, -7389, -6853, -6313, -5771, -5228, -4681, -4131, -3581, -3028, -2473, -1917, -1360, -801, -231};