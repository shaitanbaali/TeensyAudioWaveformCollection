/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0080 256 samples */
 
const int16_t AKWF_blended_0080_256_DATA [256] = 
{16596, 18730, 18526, 18800, 19003, 19197, 19393, 19582, 19767, 19948, 20124, 20295, 20461, 20618, 20769, 20912, 21046, 21175, 21292, 21401, 21500, 21589, 21667, 21734, 21791, 21836, 21869, 21887, 22037, 22260, 22462, 22653, 22829, 22994, 23142, 23288, 23349, 23239, 23116, 22977, 22821, 22654, 22474, 22277, 22066, 22021, 22060, 22072, 22073, 22059, 22029, 21987, 21931, 21859, 21774, 21675, 21560, 21432, 21290, 21135, 20964, 20828, 20437, 20926, 31050, 32448, 31811, 31621, 31340, 31044, 30737, 30415, 30079, 29730, 29368, 28990, 28600, 28196, 27776, 27346, 26899, 26438, 25976, 25353, 24573, 23796, 23001, 22190, 21368, 20534, 19685, 18818, 18085, 17423, 16739, 16045, 15336, 14616, 13880, 13144, 12325, 11338, 10336, 9324, 8298, 7262, 6218, 5161, 4093, 3018, 1932, 837, -265, -1376, -2497, -3623, -4757, -5897, -7043, -8195, -9351, -10511, -11679, -12844, -14013, -14946, -17308, -13019, 15249, 16873, 14988, 13980, 12810, 11640, 10469, 9306, 8147, 6989, 5841, 4695, 3553, 2423, 1297, 179, -927, -2030, -3123, -4204, -5281, -6343, -7394, -8437, -9468, -10486, -11495, -12492, -13335, -14075, -14815, -15538, -16252, -16950, -17637, -18300, -19016, -19876, -20729, -21562, -22382, -23192, -23981, -24760, -25528, -26097, -26553, -27011, -27450, -27877, -28289, -28686, -29069, -29438, -29792, -30134, -30459, -30771, -31069, -31354, -31624, -31833, -32268, -31799, -21662, -20230, -20806, -20904, -21063, -21209, -21340, -21458, -21562, -21652, -21730, -21794, -21844, -21879, -21900, -21908, -21903, -21887, -21844, -21934, -22152, -22343, -22522, -22686, -22839, -22978, -23102, -23218, -23176, -23031, -22885, -22725, -22552, -22365, -22168, -21948, -21786, -21768, -21743, -21704, -21652, -21591, -21519, -21438, -21347, -21244, -21134, -21013, -20884, -20747, -20601, -20450, -20292, -20124, -19952, -19775, -19594, -19406, -19215, -19023, -18828, -18479, -19085, -14685};