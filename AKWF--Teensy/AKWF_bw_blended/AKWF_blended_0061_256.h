/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0061 256 samples */
 
const int16_t AKWF_blended_0061_256_DATA [256] = 
{260, 722, 1174, 1628, 2081, 2535, 2990, 3442, 3896, 4350, 4804, 5257, 5712, 6164, 6618, 7073, 7526, 7980, 8435, 8887, 9341, 9796, 10249, 10703, 11157, 11611, 12065, 12519, 12971, 13426, 13879, 14332, 14787, 15240, 15694, 16149, 16601, 17055, 17510, 17962, 18417, 18871, 19324, 19778, 20233, 20686, 21140, 21594, 22047, 22501, 22955, 23408, 23862, 24316, 24769, 25224, 25677, 26130, 26585, 27039, 27493, 27948, 28398, 28418, 31291, 20776, -15282, -13555, -13234, -12835, -12379, -11925, -11471, -11017, -10565, -10110, -9656, -9202, -8748, -8294, -7841, -7387, -6933, -6480, -6026, -5572, -5119, -4665, -4211, -3758, -3304, -2850, -2397, -1942, -1488, -1035, -581, -127, 326, 780, 1233, 1687, 2141, 2594, 3048, 3503, 3955, 4409, 4864, 5316, 5770, 6225, 6678, 7132, 7586, 8039, 8493, 8948, 9383, 9718, 11061, -11530, -17305, -15418, -15220, -14765, -14312, -13859, -13404, -12951, -12498, -12043, -11590, -11136, -10682, -10228, -9775, -9320, -8867, -8413, -7959, -7506, -7051, -6597, -6145, -5691, -5237, -4784, -4329, -3875, -3423, -2968, -2514, -2061, -1606, -1153, -700, -245, 207, 661, 1115, 1569, 2023, 2477, 2930, 3383, 3838, 4291, 4744, 5199, 5652, 6106, 6560, 7013, 7467, 7921, 8375, 8829, 9283, 9736, 10190, 10643, 11097, 11552, 12005, 12459, 12912, 13366, 13820, 14275, 14726, 14746, 17619, 7104, -28953, -27226, -26905, -26507, -26051, -25597, -25142, -24689, -24236, -23782, -23328, -22874, -22421, -21967, -21514, -21059, -20605, -20152, -19698, -19244, -18791, -18336, -17882, -17429, -16974, -16521, -16068, -15613, -15160, -14707, -14252, -13799, -13346, -12891, -12439, -11984, -11530, -11077, -10623, -10168, -9716, -9262, -8807, -8354, -7900, -7446, -6993, -6539, -6085, -5631, -5177, -4724, -4271, -3817, -3363, -2910, -2456, -2002, -1548, -1094, -642, -180};