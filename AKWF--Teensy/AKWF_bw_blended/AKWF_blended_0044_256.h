/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0044 256 samples */
 
const int16_t AKWF_blended_0044_256_DATA [256] = 
{9027, 9125, 9223, 9320, 9418, 9515, 9614, 9710, 9809, 9906, 10004, 10101, 10198, 10296, 10393, 10491, 10588, 10686, 10783, 10881, 10978, 11077, 11174, 11272, 11369, 11467, 11564, 11662, 11759, 11857, 11955, 12052, 12150, 12247, 12345, 12442, 12540, 12637, 12735, 12832, 12930, 13027, 13125, 13223, 13320, 13418, 13516, 13613, 13711, 13808, 13906, 14003, 14101, 14198, 14295, 14394, 14491, 14588, 14686, 14783, 14881, 14979, 15076, 15174, 15271, 15369, 15466, 15564, 15662, 15759, 15857, 15955, 16052, 16149, 16248, 16345, 16443, 16540, 16638, 16735, 16833, 16930, 17028, 17125, 17222, 17320, 17418, 17516, 17613, 17711, 17808, 17906, 18003, 18101, 18198, 18296, 18393, 18491, 18588, 18686, 18783, 18881, 18979, 19077, 19174, 19272, 19369, 19467, 19565, 19661, 19759, 19857, 19955, 20051, 20150, 20247, 20345, 20442, 20540, 20637, 20735, 20832, 20930, 21028, 21125, 20788, 23184, 11640, -19468, -18907, -18767, -18753, -18655, -18558, -18460, -18363, -18265, -18167, -18070, -17972, -17875, -17777, -17680, -17582, -17485, -17387, -17289, -17192, -17095, -16997, -16900, -16802, -16704, -16607, -16509, -16412, -16314, -16217, -16118, -16022, -15923, -15827, -15729, -15631, -15533, -15436, -15338, -15241, -15143, -15046, -14948, -14850, -14752, -14655, -14558, -14460, -14363, -14265, -14168, -14070, -13973, -13875, -13778, -13680, -13583, -13485, -13387, -13289, -13192, -13094, -12997, -12899, -12802, -12704, -12607, -12509, -12411, -12314, -12216, -12119, -12021, -11924, -11826, -11729, -11631, -11534, -11436, -11339, -11241, -11143, -11046, -10948, -10851, -10753, -10655, -10558, -10460, -10363, -10265, -10167, -10071, -9973, -9875, -9778, -9680, -9583, -9485, -9387, -9290, -9193, -9094, -8997, -8899, -8802, -8704, -8607, -8509, -8412, -8314, -8217, -8119, -8422, -6150, -17078, -34557, -32187, -32509, -32411, -32314, -32216, -32118, -32021, -31923, -31474, -33269, -23021};