/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0042 256 samples */
 
const int16_t AKWF_blended_0042_256_DATA [256] = 
{19974, 20073, 20171, 20268, 20366, 20463, 20561, 20658, 20756, 20853, 20951, 21048, 21146, 21243, 21342, 21439, 21537, 21634, 21732, 21829, 21926, 22024, 22121, 22219, 22316, 22414, 22511, 22610, 22707, 22805, 22902, 23000, 23097, 23195, 23292, 23390, 23487, 23585, 23683, 23780, 23878, 23975, 24073, 24170, 24268, 24365, 24463, 24560, 24658, 24756, 24853, 24950, 25049, 25146, 25244, 25341, 25439, 25536, 25634, 25731, 25829, 25927, 26024, 26121, 26219, 26317, 26414, 26512, 26609, 26707, 26804, 26902, 27000, 27097, 27195, 27292, 27390, 27488, 27585, 27682, 27780, 27878, 27976, 28072, 28171, 28268, 28366, 28463, 28561, 28658, 28755, 28853, 28950, 29049, 29146, 29244, 29341, 29439, 29536, 29634, 29731, 29829, 29926, 30024, 30121, 30219, 30317, 30414, 30512, 30609, 30707, 30805, 30902, 31000, 31097, 31194, 31292, 31390, 31488, 31584, 31683, 31780, 31878, 31975, 32073, 31735, 34132, 22588, -8520, -8403, -5880, -22519, -34553, -32159, -32488, -32390, -32293, -32194, -32098, -32000, -31902, -31805, -31708, -31609, -31513, -31414, -31317, -31220, -31122, -31024, -30927, -30830, -30732, -30634, -30536, -30439, -30341, -30244, -30146, -30049, -29951, -29854, -29756, -29659, -29561, -29463, -29366, -29268, -29171, -29073, -28976, -28878, -28780, -28683, -28586, -28488, -28391, -28292, -28195, -28098, -28000, -27903, -27805, -27708, -27610, -27513, -27415, -27317, -27220, -27122, -27024, -26928, -26829, -26732, -26634, -26537, -26439, -26342, -26243, -26147, -26048, -25951, -25854, -25756, -25659, -25561, -25464, -25366, -25269, -25171, -25074, -24975, -24878, -24780, -24683, -24585, -24488, -24390, -24293, -24195, -24098, -24000, -23903, -23805, -23707, -23610, -23512, -23415, -23317, -23220, -23122, -23025, -22927, -22830, -22732, -22635, -22536, -22439, -22341, -22244, -22146, -22049, -21951, -21854, -21757, -21659, -21562, -21464, -21367, -21269, -21171, -21073, -20976, -20527, -22322, -12074};