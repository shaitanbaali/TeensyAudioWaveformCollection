/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0015 256 samples */
 
const int16_t AKWF_blended_0015_256_DATA [256] = 
{16500, 16631, 16758, 16887, 17015, 17143, 17271, 17400, 17528, 17656, 17784, 17912, 18040, 18169, 18298, 18425, 18554, 18681, 18810, 18938, 19066, 19194, 19323, 19451, 19580, 19708, 19836, 19964, 20092, 20220, 20348, 20477, 20605, 20734, 20862, 20990, 21118, 21246, 21374, 21502, 21630, 21759, 21887, 22016, 22143, 22272, 22400, 22528, 22656, 22785, 22913, 23041, 23170, 23297, 23426, 23554, 23682, 23810, 23939, 24066, 24195, 24323, 24451, 24579, 24708, 24836, 24964, 25093, 25220, 25349, 25477, 25605, 25734, 25862, 25990, 26118, 26247, 26374, 26502, 26631, 26759, 26888, 27016, 27144, 27272, 27401, 27528, 27657, 27785, 27913, 28042, 28170, 28298, 28426, 28555, 28682, 28811, 28939, 29067, 29195, 29324, 29452, 29580, 29708, 29836, 29965, 30093, 30221, 30349, 30478, 30605, 30734, 30862, 30991, 31119, 31247, 31375, 31503, 31631, 31759, 31888, 32016, 32145, 32273, 32400, 31608, 36658, 10941, -35647, -31980, -32407, -32346, -32218, -32090, -31961, -31833, -31705, -31576, -31448, -31320, -31192, -31064, -30936, -30808, -30679, -30551, -30423, -30295, -30166, -30038, -29910, -29782, -29654, -29525, -29398, -29268, -29141, -29012, -28884, -28756, -28628, -28500, -28372, -28244, -28116, -27987, -27859, -27730, -27602, -27474, -27346, -27217, -27090, -26962, -26833, -26704, -26576, -26448, -26320, -26192, -26064, -25936, -25808, -25679, -25551, -25423, -25294, -25166, -25038, -24910, -24782, -24654, -24525, -24397, -24269, -24140, -24012, -23884, -23756, -23628, -23500, -23371, -23243, -23116, -22986, -22859, -22730, -22602, -22474, -22346, -22217, -22089, -21961, -21833, -21705, -21576, -21448, -21320, -21191, -21063, -20936, -20807, -20679, -20551, -20422, -20294, -20166, -20038, -19909, -19782, -19653, -19525, -19397, -19268, -19140, -19012, -18884, -18755, -18628, -18499, -18371, -18243, -18114, -17986, -17858, -17730, -17602, -17474, -17345, -17217, -17089, -16961, -16833, -16419, -17823, -9480};