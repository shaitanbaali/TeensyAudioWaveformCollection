/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0029 256 samples */
 
const int16_t AKWF_blended_0029_256_DATA [256] = 
{226, 618, 1001, 1387, 1772, 2157, 2543, 2927, 3313, 3698, 4083, 4468, 4853, 5332, 5204, 7792, 19120, 19658, 19969, 20380, 20766, 21151, 21535, 21921, 22307, 22691, 23077, 23462, 23847, 24233, 24618, 25003, 25389, 25774, 26159, 26545, 26929, 27315, 27700, 28085, 28470, 28855, 29241, 29627, 30012, 30288, 31244, 29271, 13795, 13317, 13952, 14277, 14662, 15048, 15433, 15819, 16204, 16588, 16974, 17359, 17744, 18130, 18515, 18900, 19286, 19670, 20056, 20441, 20826, 21211, 21597, 21982, 22367, 22753, 23137, 23523, 23909, 23754, 27176, 13987, -27181, -24295, -24321, -23951, -23566, -23180, -22796, -22409, -22024, -21639, -21254, -20869, -20485, -20099, -19713, -19328, -18942, -18558, -18172, -17787, -17402, -17017, -16631, -16246, -15860, -15476, -15090, -14705, -14320, -14043, -13087, -15061, -30536, -31015, -30380, -30055, -29669, -29283, -28898, -28513, -28128, -27744, -27357, -26972, -26587, -26201, -25816, -25431, -25046, -24661, -24276, -23890, -23505, -23120, -22734, -22350, -21964, -21578, -21194, -20809, -20423, -19945, -20074, -17485, -6157, -5619, -5309, -4897, -4511, -4126, -3742, -3356, -2971, -2586, -2201, -1815, -1430, -1045, -660, -275, 111, 496, 880, 1266, 1650, 2036, 2422, 2806, 3192, 3577, 3962, 4348, 4733, 5010, 5965, 3992, -11483, -11962, -11326, -11001, -10616, -10230, -9844, -9458, -9073, -8689, -8304, -7919, -7534, -7147, -6762, -6378, -5992, -5607, -5222, -4836, -4451, -4066, -3681, -3295, -2910, -2525, -2140, -1755, -1369, -984, -599, -213, 170, 555, 942, 1327, 1711, 2097, 2481, 2867, 3253, 3638, 4023, 4408, 4793, 5179, 5564, 5949, 6335, 6719, 7105, 7490, 7875, 8260, 8646, 9031, 9417, 9802, 10186, 10572, 10958, 11234, 12190, 10216, -5258, -5737, -5102, -4777, -4391, -4005, -3620, -3235, -2850, -2465, -2079, -1694, -1309, -924, -540, -148};