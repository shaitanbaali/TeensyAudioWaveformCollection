/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0036 256 samples */
 
const int16_t AKWF_blended_0036_256_DATA [256] = 
{156, 505, 846, 1190, 1533, 1876, 2220, 2564, 2907, 3251, 3594, 3936, 4281, 4623, 4973, 5299, 5727, 6802, 8014, 9198, 10391, 11583, 12772, 13965, 15155, 16346, 17539, 18729, 19918, 21112, 22298, 23508, 24591, 25152, 25653, 26168, 26677, 27187, 27699, 28210, 28720, 29231, 29741, 30254, 30764, 31274, 31780, 32308, 32733, 32513, 32154, 31823, 31485, 31149, 30812, 30475, 30138, 29801, 29464, 29127, 28790, 28452, 28107, 27812, 27207, 26002, 24814, 23623, 22433, 21242, 20050, 18859, 17669, 16476, 15286, 14095, 12902, 11714, 10526, 9317, 8213, 7751, 7430, 7081, 6737, 6394, 6052, 5707, 5364, 5021, 4677, 4335, 3991, 3648, 3309, 2946, 2712, 2996, 3345, 3679, 4016, 4353, 4691, 5026, 5363, 5701, 6038, 6375, 6712, 7049, 7381, 7735, 7986, 7592, 7060, 6556, 6044, 5533, 5022, 4512, 4002, 3491, 2980, 2469, 1958, 1447, 937, 426, -84, -595, -1105, -1617, -2126, -2637, -3148, -3658, -4169, -4681, -5190, -5700, -6212, -6722, -7230, -7756, -8181, -7961, -7603, -7272, -6935, -6598, -6261, -5923, -5586, -5251, -4912, -4575, -4238, -3901, -3570, -3213, -2986, -3277, -3632, -3971, -4314, -4657, -5000, -5345, -5687, -6032, -6373, -6718, -7061, -7404, -7752, -8080, -8508, -9583, -10796, -11979, -13171, -14364, -15552, -16745, -17936, -19128, -20320, -21509, -22701, -23892, -25074, -26306, -27232, -27554, -27892, -28231, -28568, -28905, -29242, -29578, -29917, -30253, -30589, -30927, -31263, -31601, -31932, -32287, -32538, -32144, -31612, -31108, -30597, -30085, -29575, -29064, -28553, -28043, -27531, -27021, -26511, -25999, -25484, -24994, -24373, -23234, -22033, -20843, -19653, -18463, -17270, -16080, -14889, -13695, -12507, -11315, -10123, -8933, -7746, -6539, -5434, -4974, -4650, -4302, -3959, -3615, -3272, -2928, -2584, -2241, -1898, -1555, -1212, -869, -526, -178};