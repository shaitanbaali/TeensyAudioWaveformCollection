/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0048 256 samples */
 
const int16_t AKWF_blended_0048_256_DATA [256] = 
{23926, 35416, 16357, 6347, 8120, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7710, 7752, 8230, -22757, -35739, -16274, -6348, -8121, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793};