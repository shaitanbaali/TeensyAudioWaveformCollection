/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0018 256 samples */
 
const int16_t AKWF_blended_0018_256_DATA [256] = 
{3967, 8087, 8439, 9492, 10435, 11379, 12324, 13267, 14209, 15152, 16092, 17033, 17975, 18913, 19839, 20841, 21202, 20692, 20226, 19754, 19277, 18800, 18324, 17845, 17364, 16884, 16401, 15917, 15431, 14944, 14456, 13967, 13474, 12981, 12486, 11989, 11491, 10992, 10489, 9986, 9480, 8972, 8463, 7951, 7437, 6922, 6419, 5835, 5889, 6812, 7688, 8566, 9446, 10322, 11195, 12068, 12938, 13804, 14670, 15534, 16393, 17252, 18109, 18961, 19814, 20662, 21508, 22354, 23196, 24036, 24875, 25710, 26542, 27375, 28202, 29028, 29854, 30675, 31481, 32363, 32603, 31971, 31379, 30782, 30180, 29577, 28972, 28364, 27753, 27144, 26530, 25915, 25298, 24680, 24060, 23438, 22814, 22190, 21563, 20933, 20304, 19673, 19040, 18407, 17772, 17134, 16497, 15858, 15218, 14577, 13950, 13243, 13175, 13976, 14733, 15493, 16255, 17016, 17776, 18538, 19296, 20055, 20814, 21573, 22331, 22910, 24431, 22573, -19570, -25197, -22973, -22503, -21746, -20987, -20227, -19470, -18710, -17949, -17191, -16429, -15667, -14906, -14157, -13330, -13141, -13822, -14458, -15097, -15737, -16377, -17014, -17652, -18287, -18921, -19556, -20187, -20816, -21446, -22073, -22699, -23324, -23946, -24567, -25187, -25804, -26419, -27033, -27645, -28256, -28864, -29469, -30074, -30678, -31276, -31861, -32521, -32540, -31684, -30872, -30054, -29230, -28404, -27577, -26746, -25913, -25079, -24242, -23404, -22563, -21718, -20873, -20025, -19174, -18322, -17467, -16609, -15750, -14888, -14023, -13158, -12289, -11417, -10545, -9669, -8791, -7912, -7044, -6096, -5787, -6345, -6856, -7370, -7884, -8396, -8906, -9416, -9922, -10426, -10930, -11429, -11929, -12427, -12923, -13416, -13908, -14398, -14887, -15376, -15862, -16346, -16830, -17311, -17792, -18271, -18749, -19226, -19702, -20177, -20637, -21173, -21069, -20093, -19161, -18225, -17285, -16343, -15403, -14460, -13517, -12576, -11631, -10688, -9745, -8802, -7860, -6900};