/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0025 256 samples */
 
const int16_t AKWF_blended_0025_256_DATA [256] = 
{11506, 11676, 11844, 12011, 12178, 12345, 12514, 12681, 12849, 13016, 13184, 13352, 13519, 13686, 13854, 14022, 14189, 14357, 14525, 14691, 14859, 15027, 15195, 15363, 15530, 15698, 15865, 16033, 16200, 16368, 16536, 16703, 16871, 17039, 17206, 17374, 17541, 17709, 17876, 18044, 18211, 18379, 18546, 18714, 18882, 19049, 19217, 19384, 19552, 19719, 19887, 20054, 20222, 20390, 20557, 20725, 20893, 21059, 21228, 21395, 21562, 21730, 21898, 22065, 22233, 22401, 22568, 22736, 22903, 23071, 23239, 23406, 23573, 23742, 23909, 24076, 24244, 24412, 24579, 24747, 24914, 25082, 25250, 25417, 25585, 25753, 25920, 26087, 26255, 26423, 26590, 26758, 26926, 27093, 27260, 27427, 27596, 27763, 27931, 28098, 28266, 28434, 28601, 28768, 28937, 29104, 29271, 29439, 29607, 29774, 29941, 30109, 30277, 30445, 30612, 30780, 30948, 31115, 31282, 31450, 31618, 31785, 31953, 32121, 32287, 31468, 36928, 9091, -36322, -31758, -32337, -32216, -32049, -31881, -31714, -31547, -31378, -31210, -31044, -30876, -30708, -30541, -30373, -30206, -30038, -29870, -29703, -29536, -29368, -29200, -29033, -28865, -28697, -28530, -28363, -28195, -28027, -27859, -27692, -27524, -27356, -27189, -27022, -26854, -26686, -26519, -26352, -26183, -26016, -25849, -25682, -25513, -25346, -25178, -25011, -24842, -24676, -24508, -24340, -24173, -24005, -23838, -23670, -23502, -23335, -23168, -23000, -22832, -22665, -22497, -22329, -22162, -21994, -21827, -21659, -21491, -21324, -21157, -20988, -20822, -20654, -20486, -20319, -20151, -19983, -19816, -19648, -19481, -19314, -19145, -18978, -18810, -18643, -18475, -18308, -18140, -17973, -17805, -17637, -17470, -17303, -17135, -16967, -16800, -16632, -16465, -16297, -16129, -15962, -15795, -15626, -15459, -15292, -15124, -14956, -14788, -14621, -14454, -14286, -14118, -13951, -13783, -13615, -13448, -13281, -13113, -12945, -12778, -12610, -12443, -12275, -12108, -11941, -11575, -12471, -6601};