/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0067 256 samples */
 
const int16_t AKWF_blended_0067_256_DATA [256] = 
{68, 251, 438, 635, 842, 1056, 1279, 1510, 1748, 1998, 2254, 2518, 2793, 3075, 3366, 3665, 3973, 4288, 4614, 4947, 5289, 5638, 5995, 6360, 6735, 7117, 7508, 7905, 8310, 8725, 9144, 9573, 10009, 10452, 10903, 11360, 11824, 12296, 12773, 13257, 13748, 14245, 14748, 15257, 15772, 16291, 16818, 17350, 17886, 18428, 18975, 19524, 20081, 20642, 21204, 21774, 22345, 22919, 23501, 24080, 24665, 25254, 25844, 26435, 27032, 27628, 28226, 28826, 29429, 30030, 30635, 31231, 31161, 35661, -16729, -35612, -30728, -30886, -30282, -29678, -29078, -28477, -27880, -27283, -26687, -26094, -25505, -24916, -24332, -23750, -23170, -22594, -22023, -21454, -20892, -20331, -19774, -19223, -18677, -18134, -17597, -17067, -16539, -16020, -15504, -14994, -14491, -13994, -13503, -13019, -12540, -12069, -11605, -11147, -10696, -10252, -9816, -9387, -8967, -8551, -8146, -7749, -7358, -6976, -6601, -6234, -5877, -5527, -5184, -4851, -4527, -4209, -3901, -3602, -3311, -3027, -2753, -2487, -2231, -1983, -1742, -1512, -1288, -1074, -867, -670, -480, -301, -128, 35, 191, 339, 479, 611, 734, 850, 958, 1058, 1152, 1237, 1316, 1385, 1448, 1506, 1555, 1597, 1633, 1663, 1687, 1703, 1712, 1717, 1716, 1711, 1698, 1679, 1656, 1629, 1595, 1559, 1517, 1471, 1420, 1366, 1309, 1247, 1182, 1113, 1043, 968, 893, 813, 732, 648, 565, 477, 390, 301, 210, 119, 29, -60, -153, -244, -335, -426, -516, -605, -693, -779, -865, -948, -1030, -1109, -1184, -1260, -1330, -1398, -1464, -1526, -1583, -1638, -1688, -1735, -1777, -1813, -1847, -1876, -1898, -1917, -1930, -1937, -1937, -1934, -1923, -1908, -1884, -1854, -1820, -1777, -1728, -1671, -1609, -1539, -1460, -1376, -1284, -1184, -1077, -960, -838, -706, -567, -420, -265, -98};