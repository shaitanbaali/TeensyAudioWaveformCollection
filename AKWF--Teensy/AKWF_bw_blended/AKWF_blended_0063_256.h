/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0063 256 samples */
 
const int16_t AKWF_blended_0063_256_DATA [256] = 
{7506, 14357, 13572, 14209, 14623, 15037, 15450, 15860, 16270, 16679, 17085, 17490, 17892, 18292, 18690, 19087, 19477, 19867, 20254, 20635, 21015, 21390, 21761, 22129, 22494, 22852, 23207, 23556, 23901, 24242, 24577, 24906, 25231, 25550, 25863, 26170, 26472, 26768, 27057, 27340, 27617, 27888, 28151, 28409, 28660, 28903, 29140, 29369, 29591, 29808, 30015, 30216, 30409, 30596, 30774, 30945, 31109, 31264, 31413, 31553, 31685, 31811, 31929, 32038, 32140, 32234, 32321, 32401, 32472, 32534, 32590, 32639, 32679, 32712, 32737, 32755, 32766, 32768, 32764, 32753, 32734, 32708, 32675, 32635, 32588, 32535, 32474, 32407, 32334, 32254, 32168, 32076, 31977, 31873, 31763, 31647, 31525, 31399, 31267, 31130, 30987, 30840, 30688, 30532, 30370, 30206, 30037, 29862, 29686, 29506, 29322, 29134, 28945, 28751, 28555, 28357, 28157, 27953, 27749, 27541, 27333, 27123, 26911, 26699, 26486, 26115, 26440, 24629, -18078, -27555, -25801, -26395, -26608, -26821, -27033, -27243, -27453, -27661, -27866, -28070, -28272, -28470, -28668, -28863, -29054, -29242, -29428, -29610, -29788, -29963, -30134, -30300, -30464, -30622, -30776, -30925, -31069, -31209, -31344, -31472, -31596, -31714, -31827, -31933, -32034, -32130, -32218, -32300, -32377, -32446, -32510, -32566, -32616, -32659, -32695, -32724, -32745, -32760, -32767, -32767, -32761, -32746, -32723, -32694, -32657, -32612, -32559, -32500, -32432, -32356, -32272, -32181, -32082, -31976, -31863, -31740, -31610, -31473, -31329, -31176, -31016, -30848, -30673, -30490, -30299, -30102, -29897, -29685, -29465, -29239, -29005, -28765, -28517, -28262, -28002, -27734, -27460, -27179, -26892, -26599, -26300, -25995, -25685, -25368, -25046, -24718, -24386, -24047, -23704, -23357, -23004, -22648, -22286, -21919, -21549, -21175, -20798, -20418, -20033, -19644, -19254, -18860, -18462, -18064, -17662, -17258, -16853, -16445, -16036, -15626, -15213, -14800, -14387, -13972, -13559, -13136};