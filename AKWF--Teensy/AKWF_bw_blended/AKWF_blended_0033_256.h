/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0033 256 samples */
 
const int16_t AKWF_blended_0033_256_DATA [256] = 
{575, 1437, 2281, 3127, 3970, 4812, 5654, 6491, 7326, 8157, 8984, 9809, 10629, 11441, 12251, 13055, 13853, 14645, 15430, 16206, 16979, 17743, 18497, 19244, 19983, 20711, 21433, 22143, 22840, 23300, 25262, 19734, 5868, 7583, 8045, 8656, 9268, 9868, 10456, 11029, 11590, 12140, 12674, 13196, 13704, 14197, 14677, 15143, 15593, 16030, 16451, 16858, 17250, 17628, 17988, 18336, 18667, 18982, 19282, 19568, 19837, 20241, 19658, 23997, 32098, 31505, 31818, 31983, 32126, 32255, 32368, 32466, 32549, 32616, 32668, 32704, 32726, 32733, 32725, 32703, 32666, 32614, 32549, 32469, 32376, 32268, 32148, 32014, 31867, 31708, 31535, 31350, 31151, 30710, 31772, 25342, 10573, 11388, 10949, 10660, 10377, 10082, 9778, 9465, 9142, 8812, 8474, 8128, 7773, 7413, 7045, 6670, 6291, 5904, 5513, 5118, 4715, 4310, 3901, 3488, 3072, 2654, 2233, 1809, 1385, 958, 531, 105, -322, -750, -1176, -1603, -2025, -2448, -2869, -3286, -3701, -4112, -4519, -4924, -5323, -5716, -6106, -6490, -6867, -7239, -7604, -7961, -8312, -8655, -8990, -9317, -9635, -9945, -10244, -10535, -10818, -11321, -10298, -16745, -31509, -30668, -31057, -31275, -31465, -31645, -31812, -31967, -32108, -32237, -32351, -32453, -32540, -32614, -32673, -32718, -32750, -32766, -32767, -32754, -32725, -32682, -32624, -32551, -32461, -32357, -32238, -32102, -31950, -31634, -32275, -27959, -19852, -20406, -20023, -19759, -19484, -19192, -18885, -18563, -18225, -17872, -17504, -17120, -16722, -16310, -15881, -15438, -14982, -14509, -14024, -13525, -13011, -12483, -11943, -11389, -10821, -10242, -9649, -9044, -8430, -8032, -6109, -11656, -25516, -23774, -23264, -22582, -21876, -21161, -20436, -19705, -18962, -18212, -17453, -16687, -15911, -15132, -14344, -13549, -12749, -11943, -11130, -10315, -9494, -8668, -7839, -7006, -6169, -5332, -4489, -3646, -2802, -1955, -1112, -249};