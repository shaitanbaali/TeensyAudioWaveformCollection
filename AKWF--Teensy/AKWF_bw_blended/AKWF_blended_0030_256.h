/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0030 256 samples */
 
const int16_t AKWF_blended_0030_256_DATA [256] = 
{25503, 30176, 28995, 29040, 28903, 28762, 28620, 28478, 28336, 28195, 28054, 27912, 27770, 27628, 27488, 27346, 27205, 27063, 26921, 26780, 26638, 26496, 26356, 26214, 26072, 25931, 25789, 25648, 25507, 25351, 25213, 25180, 18383, 16471, 16728, 16514, 16371, 16229, 16089, 15946, 15805, 15663, 15522, 15380, 15239, 15097, 14956, 14814, 14673, 14531, 14390, 14249, 14107, 13965, 13824, 13682, 13541, 13399, 13258, 13116, 12974, 12730, 13090, 11106, -11201, -13186, -12826, -13071, -13212, -13353, -13495, -13636, -13778, -13919, -14061, -14203, -14344, -14486, -14627, -14769, -14910, -15052, -15193, -15335, -15476, -15617, -15759, -15901, -16042, -16184, -16326, -16467, -16607, -16764, -16902, -16935, -23731, -25642, -25387, -25600, -25743, -25884, -26026, -26168, -26309, -26450, -26592, -26733, -26876, -27016, -27158, -27300, -27441, -27583, -27724, -27865, -28007, -28149, -28290, -28432, -28574, -28714, -28855, -28998, -29142, -29169, -29599, -29173, 10507, 18320, 16311, 16512, 16375, 16234, 16091, 15950, 15808, 15667, 15526, 15384, 15242, 15101, 14960, 14818, 14676, 14535, 14393, 14252, 14110, 13969, 13827, 13686, 13544, 13403, 13261, 13119, 12978, 12823, 12684, 12652, 5855, 3944, 4199, 3985, 3843, 3702, 3560, 3418, 3277, 3135, 2994, 2852, 2711, 2570, 2428, 2287, 2145, 2003, 1862, 1721, 1579, 1437, 1296, 1154, 1013, 871, 729, 588, 447, 305, 163, 23, -118, -260, -401, -543, -684, -825, -967, -1109, -1250, -1392, -1533, -1675, -1817, -1958, -2099, -2241, -2382, -2524, -2666, -2807, -2949, -3090, -3232, -3374, -3515, -3657, -3798, -3939, -4081, -4236, -4374, -4407, -11204, -13115, -12860, -13074, -13215, -13357, -13499, -13640, -13781, -13923, -14064, -14207, -14348, -14489, -14631, -14772, -14914, -15055, -15197, -15338, -15479, -15621, -15762, -15904, -16046, -16187, -16328, -16470, -16615, -16798, -16686, -17893};