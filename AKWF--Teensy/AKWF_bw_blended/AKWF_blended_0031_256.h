/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0031 256 samples */
 
const int16_t AKWF_blended_0031_256_DATA [256] = 
{134, 367, 597, 827, 1056, 1287, 1516, 1746, 1976, 2205, 2435, 2665, 2895, 3125, 3354, 3584, 3815, 4044, 4275, 4504, 4734, 4964, 5193, 5423, 5653, 5882, 6113, 6344, 6571, 6725, 7377, 5569, 1020, 1601, 1773, 1998, 2229, 2459, 2689, 2919, 3148, 3379, 3608, 3838, 4068, 4297, 4527, 4757, 4986, 5217, 5447, 5676, 5906, 6136, 6366, 6595, 6826, 7056, 7285, 7515, 7747, 8196, 7221, 13488, 25293, 24375, 24808, 25043, 25272, 25502, 25732, 25961, 26191, 26421, 26651, 26881, 27111, 27340, 27570, 27800, 28030, 28260, 28489, 28719, 28949, 29179, 29409, 29639, 29868, 30098, 30329, 30559, 30787, 30941, 31592, 29784, 25235, 25816, 25989, 26215, 26444, 26674, 26905, 27133, 27364, 27594, 27824, 28053, 28283, 28513, 28742, 28973, 29203, 29432, 29663, 29892, 30122, 30352, 30581, 30812, 31041, 31271, 31501, 31731, 31960, 31055, 37395, 4855, -37743, -31199, -32145, -31915, -31685, -31455, -31225, -30996, -30765, -30536, -30307, -30076, -29846, -29616, -29386, -29157, -28927, -28697, -28467, -28238, -28008, -27778, -27548, -27318, -27088, -26859, -26628, -26399, -26170, -26015, -25364, -27172, -31721, -31141, -30968, -30742, -30513, -30282, -30052, -29822, -29594, -29363, -29134, -28904, -28673, -28444, -28215, -27984, -27755, -27525, -27294, -27066, -26835, -26605, -26376, -26145, -25916, -25687, -25456, -25226, -24995, -24545, -25520, -19254, -7448, -8367, -7935, -7699, -7470, -7240, -7011, -6780, -6551, -6320, -6091, -5861, -5631, -5402, -5172, -4941, -4713, -4482, -4252, -4023, -3793, -3563, -3333, -3103, -2874, -2644, -2413, -2184, -1954, -1801, -1149, -2958, -7507, -6925, -6753, -6528, -6298, -6068, -5837, -5609, -5379, -5148, -4919, -4689, -4459, -4229, -3999, -3769, -3539, -3310, -3080, -2850, -2621, -2390, -2161, -1930, -1701, -1471, -1241, -1011, -782, -552, -323, -89};