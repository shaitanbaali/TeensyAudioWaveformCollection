/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0006 256 samples */
 
const int16_t AKWF_blended_0006_256_DATA [256] = 
{3721, 11217, 16138, 19711, 22366, 24390, 25964, 27204, 28195, 28995, 29643, 30173, 30610, 30968, 31264, 31511, 31715, 31885, 32027, 32146, 32245, 32328, 32398, 32456, 32506, 32547, 32582, 32610, 32633, 32599, 32892, 30304, 25584, 23373, 22244, 21671, 21385, 21243, 21174, 21140, 21124, 21117, 21115, 21114, 21115, 21115, 21116, 21117, 21118, 21118, 21119, 21119, 21120, 21120, 21120, 21121, 21121, 21121, 21121, 21116, 21087, 21304, 18351, 16025, 17337, 17125, 16528, 15877, 15296, 14824, 14458, 14183, 13982, 13834, 13727, 13651, 13596, 13557, 13529, 13508, 13494, 13485, 13477, 13472, 13469, 13466, 13464, 13464, 13463, 13462, 13462, 13461, 13459, 13403, 13680, 11077, 6345, 4124, 2987, 2405, 2113, 1966, 1893, 1856, 1836, 1827, 1822, 1820, 1819, 1818, 1817, 1818, 1819, 1817, 1818, 1818, 1818, 1818, 1818, 1818, 1817, 1802, 1834, 1609, -1443, -6360, -8114, -4092, 1088, 3244, 4013, 4052, 3725, 3233, 2687, 2145, 1633, 1166, 749, 381, 61, -216, -456, -662, -837, -988, -1116, -1224, -1317, -1395, -1461, -1517, -1564, -1604, -1638, -1665, -1692, -1767, -1509, -4126, -8869, -11100, -12246, -12836, -13133, -13285, -13364, -13405, -13426, -13438, -13446, -13449, -13452, -13454, -13456, -13457, -13457, -13459, -13459, -13458, -13460, -13460, -13460, -13461, -13460, -13460, -13460, -13466, -13496, -13278, -16231, -18558, -17245, -17457, -18054, -18706, -19286, -19758, -20125, -20399, -20600, -20749, -20855, -20932, -20986, -21025, -21054, -21073, -21087, -21097, -21104, -21110, -21113, -21116, -21118, -21119, -21119, -21121, -21121, -21121, -21123, -21178, -20902, -23505, -28237, -30458, -31596, -32177, -32468, -32616, -32689, -32726, -32746, -32755, -32759, -32762, -32763, -32763, -32763, -32764, -32763, -32764, -32765, -32764, -32764, -32764, -32765, -32764, -32764, -32749, -32779, -32545, -29427, -24742, -18194, -7027};