/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0009 256 samples */
 
const int16_t AKWF_blended_0009_256_DATA [256] = 
{1031, 3604, 6073, 8517, 10907, 13232, 15479, 17627, 19668, 21595, 23385, 25041, 26551, 27901, 29094, 30122, 30981, 31672, 32193, 32546, 32734, 32758, 32627, 32345, 31921, 31364, 30681, 29887, 28991, 28003, 26940, 25813, 24633, 23419, 22182, 20933, 19690, 18464, 17265, 16109, 15005, 13963, 12996, 12109, 11308, 10605, 10001, 9500, 9107, 8822, 8643, 8573, 8607, 8741, 8972, 9293, 9696, 10173, 10718, 11319, 11963, 12645, 13349, 14063, 14865, 15591, 16264, 16906, 17497, 18030, 18492, 18874, 19166, 19362, 19453, 19432, 19296, 19040, 18660, 18157, 17531, 16780, 15906, 14920, 13818, 12610, 11307, 9908, 8431, 6886, 5277, 3624, 1936, 224, -1492, -3204, -4899, -6556, -8167, -9720, -11194, -12584, -13876, -15055, -16115, -17046, -17836, -18482, -18977, -19315, -19492, -19509, -19363, -19055, -18588, -17966, -17191, -16271, -15216, -14030, -12726, -11317, -9809, -8219, -6561, -4844, -3090, -1310, 657, 2482, 4237, 5971, 7648, 9261, 10798, 12239, 13578, 14804, 15900, 16864, 17686, 18357, 18875, 19234, 19430, 19465, 19339, 19053, 18606, 18008, 17262, 16373, 15354, 14211, 12952, 11592, 10142, 8610, 7017, 5371, 3684, 1976, 258, -1460, -3157, -4824, -6451, -8018, -9520, -10947, -12282, -13523, -14661, -15685, -16598, -17390, -18056, -18600, -19020, -19315, -19489, -19546, -19490, -19327, -19064, -18709, -18271, -17758, -17183, -16554, -15885, -15190, -14387, -13645, -12937, -12243, -11582, -10962, -10394, -9891, -9459, -9106, -8842, -8672, -8600, -8631, -8769, -9015, -9368, -9830, -10395, -11061, -11825, -12680, -13616, -14631, -15710, -16843, -18024, -19238, -20472, -21715, -22952, -24170, -25357, -26496, -27576, -28586, -29508, -30333, -31048, -31642, -32107, -32432, -32608, -32630, -32493, -32190, -31720, -31081, -30274, -29297, -28154, -26853, -25390, -23779, -22030, -20144, -18137, -16023, -13803, -11502, -9132, -6704, -4238, -1702};