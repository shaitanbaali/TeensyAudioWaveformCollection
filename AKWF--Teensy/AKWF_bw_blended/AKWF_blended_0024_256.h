/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0024 256 samples */
 
const int16_t AKWF_blended_0024_256_DATA [256] = 
{4408, 8396, 7887, 8215, 8412, 8611, 8808, 9005, 9203, 9401, 9598, 9795, 9993, 10191, 10389, 10586, 10783, 10981, 11178, 11376, 11574, 11771, 11968, 12167, 12365, 12561, 12759, 12957, 13154, 13351, 13549, 13747, 13945, 14141, 14340, 14537, 14735, 14931, 15130, 15328, 15524, 15722, 15920, 16118, 16314, 16512, 16711, 16908, 17104, 17303, 17501, 17698, 17895, 18093, 18291, 18488, 18685, 18883, 19081, 19278, 19475, 19674, 19871, 20068, 20265, 20464, 20661, 20859, 21057, 21253, 21451, 21649, 21847, 22044, 22241, 22439, 22637, 22834, 23031, 23230, 23427, 23624, 23822, 24020, 24217, 24415, 24612, 24811, 25007, 25205, 25402, 25600, 25798, 25995, 26193, 26390, 26588, 26785, 26983, 27181, 27378, 27575, 27774, 27971, 28167, 28365, 28564, 28761, 28959, 29156, 29354, 29552, 29748, 29946, 30144, 30341, 30539, 30736, 30934, 31132, 31329, 31527, 31724, 31922, 32119, 32079, 33304, 29953, -26232, -34098, -32032, -32203, -32006, -31808, -31611, -31413, -31216, -31019, -30821, -30623, -30426, -30228, -30031, -29832, -29636, -29438, -29240, -29043, -28845, -28648, -28450, -28252, -28055, -27858, -27660, -27462, -27265, -27068, -26869, -26673, -26474, -26278, -26079, -25882, -25685, -25487, -25289, -25092, -24895, -24697, -24499, -24302, -24104, -23907, -23709, -23511, -23315, -23116, -22919, -22721, -22524, -22326, -22128, -21931, -21734, -21536, -21338, -21141, -20944, -20745, -20548, -20351, -20152, -19955, -19758, -19560, -19362, -19165, -18968, -18770, -18572, -18375, -18178, -17980, -17782, -17586, -17387, -17189, -16992, -16795, -16597, -16399, -16202, -16005, -15807, -15609, -15412, -15215, -15016, -14819, -14623, -14424, -14226, -14029, -13833, -13634, -13436, -13239, -13042, -12844, -12645, -12450, -12252, -12053, -11856, -11659, -11461, -11263, -11066, -10869, -10671, -10474, -10276, -10079, -9880, -9683, -9486, -9288, -9090, -8893, -8696, -8498, -8300, -8103, -7906, -7705};