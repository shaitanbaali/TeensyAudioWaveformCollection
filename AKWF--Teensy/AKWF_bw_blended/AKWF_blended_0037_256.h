/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0037 256 samples */
 
const int16_t AKWF_blended_0037_256_DATA [256] = 
{37, 108, 178, 249, 320, 390, 461, 531, 602, 673, 743, 814, 884, 955, 1025, 1098, 1168, 1231, 1869, 2839, 3764, 4697, 5626, 6559, 7490, 8422, 9356, 10286, 11216, 12150, 13082, 14014, 14945, 15877, 16808, 17742, 18672, 19603, 20537, 21467, 22400, 23332, 24262, 25194, 26127, 27057, 27989, 28922, 29850, 30791, 31156, 31187, 31266, 31337, 31407, 31478, 31549, 31620, 31690, 31761, 31831, 31902, 31972, 31952, 32512, 30360, 22562, 21992, 21175, 20367, 19569, 18775, 17976, 17180, 16383, 15585, 14788, 13990, 13194, 12398, 11603, 10797, 10568, 10671, 10726, 10791, 10856, 10919, 10983, 11046, 11112, 11175, 11239, 11303, 11368, 11432, 11495, 11560, 11624, 11689, 11752, 11816, 11881, 11945, 12010, 12073, 12136, 12201, 12265, 12329, 12394, 12456, 12519, 12591, 12087, 11252, 10464, 9666, 8869, 8073, 7275, 6479, 5682, 4884, 4088, 3289, 2493, 1696, 898, 102, -694, -1490, -2288, -3083, -3882, -4678, -5475, -6273, -7068, -7867, -8664, -9460, -10258, -11054, -11849, -12654, -12883, -12781, -12725, -12662, -12596, -12532, -12470, -12405, -12340, -12276, -12213, -12148, -12085, -12021, -11956, -11892, -11827, -11763, -11700, -11635, -11571, -11507, -11443, -11378, -11315, -11250, -11187, -11122, -11057, -10995, -10933, -10861, -11365, -12199, -12989, -13786, -14581, -15379, -16177, -16972, -17770, -18568, -19364, -20162, -20958, -21834, -22183, -25015, -32118, -31783, -31743, -31684, -31613, -31543, -31471, -31400, -31331, -31259, -31189, -31118, -31048, -30975, -30905, -30842, -30201, -29233, -28309, -27376, -26447, -25515, -24582, -23652, -22720, -21788, -20856, -19924, -18993, -18062, -17129, -16196, -15266, -14334, -13403, -12471, -11537, -10608, -9675, -8741, -7811, -6879, -5947, -5017, -4084, -3152, -2224, -1283, -919, -888, -808, -738, -666, -596, -526, -455, -384, -314, -244, -173, -102, -30};