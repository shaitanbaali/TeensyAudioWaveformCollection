/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0069 256 samples */
 
const int16_t AKWF_blended_0069_256_DATA [256] = 
{155, 697, 1227, 1759, 2289, 2817, 3347, 3872, 4395, 4916, 5433, 5948, 6459, 6966, 7469, 7968, 8461, 8950, 9433, 9910, 10383, 10848, 11306, 11759, 12204, 12641, 13071, 13494, 13908, 14314, 14710, 15099, 15479, 15848, 16208, 16558, 16899, 17229, 17549, 17859, 18157, 18445, 18721, 18987, 19241, 19483, 19714, 19933, 20139, 20335, 20516, 20686, 20844, 20989, 21121, 21241, 21348, 21441, 21521, 21591, 21646, 21687, 21716, 21733, 21735, 21725, 21701, 21665, 21616, 21553, 21477, 21390, 21288, 21173, 21047, 20907, 20754, 20590, 20414, 20224, 20022, 19809, 19582, 19346, 19096, 18836, 18565, 18281, 17987, 17682, 17366, 17041, 16705, 16357, 16001, 15636, 15260, 14876, 14482, 14080, 13670, 13252, 12824, 12390, 11948, 11498, 11043, 10579, 10110, 9635, 9154, 8667, 8177, 7679, 7176, 6673, 6162, 5648, 5132, 4612, 4089, 3565, 3037, 2507, 1978, 1409, 745, 1193, -17168, -33073, -31491, -27816, -23831, -20190, -17028, -14348, -12095, -10222, -8695, -7463, -6492, -5753, -5214, -4850, -4639, -4559, -4594, -4725, -4940, -5226, -5570, -5965, -6401, -6868, -7363, -7878, -8406, -8946, -9490, -10039, -10586, -11130, -11668, -12199, -12721, -13231, -13730, -14215, -14686, -15143, -15582, -16007, -16414, -16805, -17177, -17533, -17871, -18192, -18495, -18778, -19045, -19295, -19525, -19739, -19936, -20113, -20274, -20418, -20545, -20655, -20747, -20823, -20882, -20926, -20953, -20964, -20959, -20938, -20902, -20851, -20784, -20702, -20607, -20495, -20370, -20231, -20077, -19911, -19730, -19535, -19327, -19108, -18874, -18628, -18371, -18100, -17818, -17525, -17220, -16905, -16578, -16239, -15891, -15533, -15165, -14788, -14400, -14003, -13599, -13185, -12762, -12333, -11895, -11448, -10996, -10536, -10070, -9599, -9120, -8635, -8147, -7651, -7151, -6649, -6139, -5628, -5113, -4595, -4073, -3550, -3023, -2495, -1966, -1435, -905, -363};