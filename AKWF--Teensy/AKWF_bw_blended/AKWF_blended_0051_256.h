/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0051 256 samples */
 
const int16_t AKWF_blended_0051_256_DATA [256] = 
{167, 505, 835, 1167, 1498, 1831, 2162, 2493, 2825, 3157, 3489, 3820, 4153, 4483, 4815, 5148, 5479, 5811, 6143, 6473, 6805, 7137, 7469, 7801, 8133, 8464, 8796, 9127, 9459, 9791, 10123, 10454, 10786, 11117, 11449, 11782, 12113, 12444, 12776, 13108, 13439, 13771, 14103, 14435, 14766, 15097, 15429, 15761, 16092, 16425, 16756, 17087, 17419, 17751, 18083, 18415, 18747, 19078, 19410, 19741, 20072, 20405, 20737, 21067, 21400, 21731, 22063, 22394, 22727, 23058, 23390, 23721, 24053, 24385, 24716, 25048, 25380, 25711, 26043, 26376, 26707, 27038, 27370, 27701, 28032, 28364, 28696, 29029, 29359, 29691, 30023, 30355, 30686, 31018, 31349, 31680, 31778, 33284, 29207, -16940, -19946, -18684, -18547, -18216, -17885, -17553, -17222, -16890, -16558, -16226, -15894, -15563, -15232, -14900, -14568, -14237, -13904, -13573, -13241, -12910, -12578, -12246, -11915, -11583, -11252, -10919, -10588, -10257, -9924, -9593, -9261, -8929, -8598, -8266, -7935, -7603, -7271, -6939, -6608, -6277, -5944, -5613, -5281, -4949, -4618, -4286, -3955, -3623, -3291, -2959, -2628, -2296, -1964, -1634, -1301, -969, -638, -306, 25, 356, 688, 1020, 1352, 1683, 2014, 2347, 2678, 3010, 3341, 3673, 4005, 4336, 4077, 7569, -10623, -29270, -25768, -26028, -25697, -25366, -25034, -24703, -24371, -24039, -23707, -23376, -23044, -22713, -22382, -22048, -21717, -21386, -21054, -20723, -20391, -20059, -19727, -19396, -19063, -18733, -18401, -18068, -17738, -17406, -17074, -16743, -16411, -16079, -15747, -15415, -15083, -14752, -14421, -14089, -13758, -13425, -13094, -12762, -12431, -12099, -11768, -11435, -11104, -10773, -10440, -10109, -9778, -9445, -9114, -8782, -8450, -8119, -7788, -7456, -7124, -6792, -6460, -6129, -5797, -5465, -5134, -4802, -4470, -4139, -3808, -3475, -3144, -2812, -2480, -2149, -1817, -1485, -1154, -822, -491, -154};