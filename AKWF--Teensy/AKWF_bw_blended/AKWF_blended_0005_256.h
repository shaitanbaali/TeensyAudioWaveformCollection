/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0005 256 samples */
 
const int16_t AKWF_blended_0005_256_DATA [256] = 
{1174, 3595, 5727, 7665, 9425, 11030, 12497, 13837, 15069, 16203, 17246, 18211, 19106, 19932, 20703, 21421, 22087, 22712, 23296, 23841, 24354, 24835, 25286, 25712, 26112, 26486, 26839, 27187, 26551, 25180, 24017, 23056, 22267, 21628, 21114, 20703, 20380, 20127, 19935, 19794, 19692, 19624, 19584, 19566, 19567, 19582, 19610, 19646, 19690, 19739, 19792, 19848, 19906, 19959, 20045, 19884, 18911, 17611, 16318, 15086, 14911, 15544, 16039, 16398, 16641, 16790, 16863, 16877, 16845, 16777, 16683, 16572, 16446, 16312, 16173, 16034, 15894, 15757, 15623, 15494, 15371, 15253, 15142, 15037, 14938, 14846, 14760, 14678, 14604, 14532, 14464, 14417, 13410, 11688, 10196, 8922, 7840, 6925, 6150, 5492, 4936, 4464, 4063, 3725, 3437, 3194, 2987, 2811, 2659, 2541, 2243, 1459, 361, -872, -2151, -3426, -4677, -5880, -7069, -7969, -8011, -7672, -7301, -6978, -5743, -3842, -2217, -856, 277, 1211, 1974, 2594, 3091, 3482, 3786, 4012, 4175, 4284, 4347, 4370, 4362, 4325, 4265, 4187, 4094, 3988, 3871, 3747, 3616, 3480, 3342, 3200, 3057, 2911, 2764, 2634, 1541, -271, -1854, -3220, -4395, -5405, -6274, -7027, -7677, -8242, -8735, -9165, -9542, -9875, -10168, -10428, -10662, -10869, -11056, -11225, -11377, -11517, -11645, -11762, -11870, -11977, -12043, -12351, -13463, -14897, -16319, -17675, -17968, -17449, -17063, -16808, -16664, -16612, -16630, -16705, -16822, -16970, -17141, -17328, -17524, -17726, -17930, -18133, -18334, -18528, -18716, -18899, -19073, -19239, -19397, -19547, -19689, -19823, -19949, -20067, -20178, -20285, -20385, -20465, -21503, -23255, -24775, -26074, -27182, -28123, -28921, -29601, -30180, -30672, -31092, -31450, -31756, -32019, -32241, -32433, -32594, -32743, -32675, -32087, -31155, -30065, -28909, -27740, -26581, -25442, -24371, -23087, -21033, -18687, -16384, -14210, -11203, -7602, -4353, -1387};