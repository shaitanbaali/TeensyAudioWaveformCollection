/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0050 256 samples */
 
const int16_t AKWF_blended_0050_256_DATA [256] = 
{112, 391, 664, 937, 1212, 1486, 1760, 2033, 2308, 2582, 2855, 3129, 3404, 3677, 3951, 4226, 4499, 4773, 5047, 5321, 5595, 5869, 6143, 6417, 6691, 6965, 7239, 7513, 7786, 8061, 8335, 8609, 8882, 9156, 9431, 9705, 9979, 10253, 10527, 10801, 11073, 11349, 11622, 11896, 12170, 12444, 12718, 12992, 13266, 13540, 13815, 14088, 14362, 14636, 14910, 15184, 15459, 15732, 16006, 16279, 16554, 16827, 17101, 17375, 17650, 17923, 18197, 18471, 18746, 19019, 19294, 19567, 19841, 20116, 20389, 20664, 20937, 21210, 21485, 21760, 22033, 22307, 22581, 22855, 23128, 23403, 23676, 23951, 24225, 24499, 24773, 25046, 25321, 25594, 25869, 26142, 26417, 26691, 26964, 27239, 27512, 27786, 28061, 28334, 28609, 28882, 29156, 29430, 29704, 29977, 30252, 30526, 30800, 31074, 31348, 31622, 31896, 31856, 33851, 27016, -10414, -10222, -9796, -9592, -9319, -9045, -8772, -8497, -8223, -7950, -7675, -7401, -7128, -6854, -6579, -6305, -6031, -5757, -5757, -3945, -10480, -32371, -30918, -30831, -30566, -30293, -30019, -29745, -29470, -29197, -28923, -28649, -28374, -28101, -27827, -27553, -27279, -27005, -26731, -26457, -26183, -25910, -25635, -25360, -25088, -24814, -24539, -24265, -23992, -23717, -23444, -23170, -22896, -22622, -22348, -22074, -21800, -21526, -21252, -20978, -20704, -20430, -20156, -19882, -19608, -19335, -19060, -18786, -18512, -18238, -17964, -17691, -17416, -17143, -16869, -16594, -16320, -16047, -15772, -15499, -15225, -14951, -14677, -14403, -14129, -13854, -13582, -13307, -13034, -12759, -12485, -12211, -11938, -11663, -11390, -11115, -10841, -10568, -10294, -10020, -9746, -9472, -9197, -8924, -8649, -8377, -8103, -7827, -7554, -7280, -7006, -6732, -6458, -6185, -5910, -5636, -5362, -5089, -4814, -4540, -4267, -3992, -3718, -3445, -3171, -2896, -2623, -2349, -2075, -1801, -1527, -1253, -979, -706, -433, -154};