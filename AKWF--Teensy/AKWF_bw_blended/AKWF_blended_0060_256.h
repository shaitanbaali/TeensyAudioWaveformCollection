/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0060 256 samples */
 
const int16_t AKWF_blended_0060_256_DATA [256] = 
{240, 686, 1124, 1563, 2002, 2440, 2880, 3319, 3758, 4198, 4636, 5075, 5515, 5953, 6392, 6832, 7270, 7709, 8149, 8587, 9026, 9466, 9905, 10344, 10783, 11222, 11661, 12100, 12539, 12978, 13417, 13857, 14296, 14735, 15174, 15613, 16052, 16491, 16931, 17368, 17808, 18248, 18686, 19125, 19564, 20002, 20442, 20881, 21320, 21759, 22199, 22637, 23077, 23517, 23953, 24391, 24837, 24581, 28782, 897, -19439, -15251, -15509, -15062, -14623, -14185, -13747, -13307, -12867, -12429, -11989, -11550, -11111, -10672, -10234, -9794, -9355, -8917, -8477, -8037, -7599, -7160, -6721, -6283, -5843, -5403, -4965, -4526, -4087, -3648, -3208, -2770, -2331, -1892, -1452, -1014, -574, -136, 303, 742, 1180, 1620, 2059, 2497, 2937, 3377, 3815, 4254, 4694, 5131, 5571, 6011, 6449, 6889, 7328, 7766, 8206, 8646, 9083, 9523, 9962, 10400, 10840, 11280, 11718, 12157, 12596, 13035, 13475, 13914, 14353, 14792, 15231, 15670, 16110, 16548, 16987, 17427, 17865, 18247, 18877, 18842, -3886, -7142, -5788, -5518, -5079, -4641, -4201, -3762, -3324, -2884, -2445, -2007, -1567, -1128, -690, -249, 188, 627, 1067, 1505, 1944, 2384, 2823, 3261, 3701, 4140, 4579, 5019, 5457, 5896, 6335, 6774, 7213, 7652, 8091, 8530, 8969, 9409, 9847, 10287, 10724, 11164, 11608, 11352, 15554, -12333, -32667, -28481, -28737, -28291, -27852, -27414, -26976, -26535, -26097, -25658, -25218, -24779, -24341, -23901, -23463, -23024, -22584, -22145, -21706, -21267, -20828, -20390, -19950, -19511, -19071, -18633, -18194, -17754, -17315, -16877, -16437, -15998, -15560, -15119, -14681, -14243, -13803, -13364, -12926, -12486, -12047, -11608, -11169, -10730, -10291, -9852, -9413, -8974, -8534, -8096, -7657, -7217, -6778, -6339, -5900, -5462, -5022, -4583, -4145, -3705, -3266, -2827, -2388, -1949, -1510, -1071, -634, -187};