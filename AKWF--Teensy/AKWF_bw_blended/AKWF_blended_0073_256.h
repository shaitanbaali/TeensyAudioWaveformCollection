/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0073 256 samples */
 
const int16_t AKWF_blended_0073_256_DATA [256] = 
{14850, 22475, 22066, 23150, 23993, 24830, 25657, 26474, 27278, 28069, 28844, 29602, 30343, 31057, 31608, 33191, 18770, 14473, 16177, 16554, 17100, 17617, 18101, 18557, 18981, 19369, 19727, 20051, 20340, 20596, 20816, 21002, 21153, 21268, 21349, 21395, 21407, 21385, 21327, 21238, 21115, 20960, 20774, 20557, 20310, 20036, 19732, 19402, 19047, 18668, 18264, 17840, 17395, 16930, 16449, 15951, 15438, 14913, 14376, 13830, 13277, 12715, 12150, 11581, 11011, 10443, 9876, 9313, 8756, 8207, 7665, 7136, 6617, 6113, 5625, 5153, 4698, 4266, 3854, 3462, 3098, 2757, 2441, 2154, 1896, 1666, 1466, 1298, 1162, 1058, 987, 950, 947, 978, 1044, 1146, 1281, 1452, 1657, 1899, 2172, 2482, 2826, 3201, 3611, 4053, 4524, 5028, 5562, 6123, 6712, 7330, 7970, 8637, 9327, 10038, 10770, 11521, 12288, 13073, 13873, 14683, 15508, 16341, 17181, 17974, 18853, 20016, 101, -6792, -4410, -3849, -3006, -2170, -1341, -526, 278, 1070, 1844, 2602, 3344, 4058, 4607, 6191, -8230, -12526, -10822, -10444, -9899, -9382, -8896, -8441, -8019, -7629, -7271, -6948, -6658, -6403, -6183, -5996, -5845, -5730, -5650, -5603, -5592, -5614, -5672, -5761, -5883, -6039, -6224, -6441, -6688, -6963, -7267, -7596, -7951, -8331, -8734, -9158, -9604, -10069, -10550, -11048, -11560, -12085, -12622, -13169, -13723, -14284, -14849, -15417, -15987, -16555, -17121, -17686, -18243, -18792, -19333, -19863, -20380, -20886, -21374, -21845, -22300, -22732, -23145, -23535, -23901, -24243, -24557, -24843, -25103, -25333, -25532, -25700, -25836, -25941, -26010, -26047, -26051, -26020, -25954, -25853, -25717, -25546, -25340, -25099, -24826, -24516, -24173, -23796, -23387, -22946, -22474, -21970, -21436, -20876, -20285, -19669, -19029, -18360, -17672, -16961, -16228, -15478, -14710, -13924, -13125, -12315, -11491, -10657, -9818, -8971, -8122, -7252};