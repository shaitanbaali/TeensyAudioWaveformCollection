/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0038 256 samples */
 
const int16_t AKWF_blended_0038_256_DATA [256] = 
{9312, 17730, 16649, 17336, 17746, 18155, 18563, 18968, 19374, 19777, 20176, 20574, 20969, 21361, 21748, 22135, 22516, 22893, 23267, 23634, 24000, 24360, 24713, 25063, 25407, 25745, 26077, 26403, 26722, 27037, 27342, 27642, 27936, 28222, 28499, 28770, 29033, 29288, 29536, 29774, 30005, 30227, 30440, 30646, 30841, 31029, 31207, 31375, 31535, 31685, 31827, 31957, 32078, 32191, 32293, 32386, 32469, 32541, 32603, 32656, 32698, 32730, 32753, 32765, 32767, 32759, 32741, 32713, 32675, 32627, 32568, 32501, 32422, 32334, 32236, 32127, 32010, 31884, 31747, 31601, 31445, 31280, 31106, 30922, 30730, 30529, 30319, 30100, 29874, 29638, 29394, 29143, 28883, 28616, 28341, 28059, 27768, 27471, 27168, 26857, 26540, 26216, 25887, 25553, 25210, 24863, 24511, 24154, 23791, 23424, 23053, 22677, 22299, 21913, 21527, 21138, 20742, 20346, 19947, 19546, 19141, 18737, 18330, 17921, 17511, 17035, 16658, 16611, -8397, -17983, -16584, -17337, -17747, -18156, -18564, -18969, -19374, -19777, -20176, -20574, -20970, -21362, -21749, -22135, -22517, -22894, -23267, -23635, -24000, -24360, -24713, -25063, -25407, -25746, -26077, -26403, -26723, -27037, -27342, -27642, -27936, -28222, -28500, -28770, -29033, -29288, -29536, -29774, -30005, -30227, -30440, -30646, -30841, -31029, -31207, -31375, -31535, -31686, -31827, -31957, -32078, -32191, -32293, -32386, -32469, -32541, -32603, -32656, -32698, -32730, -32753, -32765, -32767, -32759, -32741, -32713, -32675, -32627, -32568, -32501, -32422, -32334, -32236, -32127, -32010, -31884, -31747, -31601, -31445, -31280, -31106, -30922, -30730, -30529, -30319, -30100, -29874, -29639, -29395, -29143, -28883, -28616, -28341, -28059, -27768, -27471, -27168, -26857, -26540, -26217, -25888, -25553, -25211, -24863, -24512, -24154, -23791, -23425, -23054, -22678, -22299, -21913, -21527, -21138, -20743, -20346, -19948, -19546, -19142, -18737, -18330, -17922, -17512, -17102, -16692, -16273};