/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0001 256 samples */
 
const int16_t AKWF_blended_0001_256_DATA [256] = 
{16987, 20674, 19903, 20017, 19994, 19967, 19929, 19947, 19897, 19843, 19781, 19716, 19645, 19568, 19486, 19400, 19309, 19213, 19112, 19005, 18895, 18780, 18661, 18537, 18408, 18277, 18141, 18000, 17857, 17709, 17557, 17402, 17243, 17079, 16913, 16743, 16569, 16392, 16210, 16023, 15835, 15641, 15444, 15243, 15045, 14852, 14662, 14480, 14303, 14131, 13964, 13805, 13652, 13505, 13365, 13230, 13102, 12983, 12869, 12761, 12660, 12568, 12481, 12400, 12329, 12263, 12203, 12152, 12107, 12070, 12039, 12016, 12000, 11991, 11991, 11997, 12012, 12034, 12063, 12100, 12144, 12198, 12259, 12328, 12404, 12489, 12581, 12678, 12775, 12873, 12970, 13068, 13166, 13263, 13359, 13455, 13549, 13643, 13735, 13825, 13915, 14002, 14087, 14171, 14201, 14304, 14613, -4827, -10317, -8319, -8262, -7905, -7579, -7283, -7014, -6769, -6546, -6345, -6165, -6003, -5859, -5733, -5623, -5527, -5444, -5373, -5312, -5255, -5206, -5163, -5127, -5098, -5074, -5057, -5046, -5040, -5040, -5046, -5058, -5074, -5098, -5126, -5159, -5197, -5240, -5290, -5341, -5400, -5463, -5529, -5600, -5678, -5758, -5843, -5932, -6025, -6122, -6224, -6329, -6437, -6548, -6665, -6786, -6909, -7037, -7169, -7304, -7444, -7586, -7735, -7887, -8041, -8195, -8342, -8486, -8622, -8755, -8883, -9003, -9118, -9226, -9329, -9423, -9513, -9596, -9673, -9744, -9805, -9862, -9911, -9953, -9989, -10019, -10041, -10057, -10064, -10066, -10060, -10046, -10026, -9999, -9965, -9923, -9873, -9816, -9752, -9679, -9600, -9513, -9416, -9315, -9204, -9084, -8957, -8822, -8685, -8546, -8407, -8267, -8127, -7989, -7851, -7713, -7576, -7440, -7305, -7172, -7041, -6911, -6784, -6657, -6532, -6462, -6319, -5969, -25370, -30819, -28782, -28684, -28288, -27921, -27586, -27276, -26991, -26729, -26489, -26269, -26069, -25885, -25711, -25577, -25434, -25312, -25091, -25633, -22524};