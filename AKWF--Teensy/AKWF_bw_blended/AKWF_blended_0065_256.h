/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0065 256 samples */
 
const int16_t AKWF_blended_0065_256_DATA [256] = 
{60, 245, 429, 615, 800, 987, 1177, 1365, 1553, 1742, 1932, 2120, 2310, 2502, 2695, 2888, 3085, 3282, 3481, 3679, 3881, 4084, 4284, 4490, 4698, 4903, 5110, 5320, 5530, 5741, 5954, 6169, 6383, 6601, 6818, 7035, 7254, 7476, 7699, 7920, 8145, 8371, 8595, 8823, 9054, 9283, 9513, 9746, 9978, 10212, 10447, 10684, 10921, 11160, 11399, 11640, 11881, 12124, 12370, 12614, 12859, 13107, 13356, 13604, 13856, 14108, 14361, 14614, 14870, 15125, 15382, 15641, 15901, 16161, 16423, 16688, 16950, 17215, 17484, 17750, 18018, 18289, 18560, 18831, 19104, 19380, 19657, 19932, 20208, 20482, 20755, 21028, 21302, 21572, 21839, 22107, 22371, 22629, 22889, 23147, 23400, 23652, 23902, 24149, 24392, 24636, 24876, 25112, 25348, 25581, 25810, 26038, 26263, 26487, 26707, 26924, 27141, 27353, 27563, 27773, 27980, 28181, 28383, 28583, 28777, 28972, 29165, 29351, 29286, 30548, 23556, -8425, -16996, -11078, -11915, -11830, -11007, -11661, -24825, -32847, -29555, -29146, -29000, -28364, -27910, -27458, -26998, -26557, -26127, -25705, -25291, -24888, -24492, -24106, -23727, -23357, -22996, -22640, -22293, -21954, -21619, -21292, -20972, -20658, -20351, -20049, -19753, -19461, -19173, -18888, -18606, -18329, -18055, -17783, -17512, -17246, -16983, -16718, -16457, -16197, -15938, -15681, -15426, -15172, -14918, -14669, -14420, -14172, -13925, -13680, -13437, -13194, -12954, -12716, -12478, -12241, -12007, -11773, -11540, -11309, -11080, -10851, -10625, -10399, -10176, -9951, -9731, -9510, -9290, -9072, -8856, -8640, -8426, -8214, -8001, -7789, -7580, -7372, -7163, -6958, -6753, -6548, -6345, -6144, -5942, -5742, -5545, -5347, -5149, -4953, -4759, -4565, -4370, -4179, -3989, -3796, -3606, -3418, -3231, -3042, -2858, -2671, -2485, -2301, -2118, -1935, -1752, -1569, -1387, -1204, -1023, -843, -662, -480, -300, -115};