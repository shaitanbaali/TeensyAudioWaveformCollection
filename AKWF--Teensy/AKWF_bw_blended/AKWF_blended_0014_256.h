/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0014 256 samples */
 
const int16_t AKWF_blended_0014_256_DATA [256] = 
{253, 772, 1280, 1790, 2299, 2811, 3320, 3831, 4342, 4853, 5361, 5873, 6384, 6893, 7403, 7916, 8425, 8935, 9445, 9956, 10467, 10977, 11486, 11998, 12508, 13017, 13529, 14039, 14549, 15060, 15570, 16081, 16592, 17100, 17611, 18124, 18632, 19142, 19654, 20165, 20674, 21185, 21695, 22207, 22715, 23225, 23737, 24248, 24756, 25268, 25779, 26288, 26798, 27311, 27820, 28331, 28840, 29351, 29862, 30372, 30881, 31391, 31901, 32419, 32564, 32516, 32501, 32479, 32458, 32436, 32413, 32391, 32370, 32347, 32327, 32304, 32284, 32261, 32240, 32218, 32195, 32175, 32152, 32132, 32109, 32087, 32066, 32044, 32023, 32001, 31978, 31958, 31935, 31915, 31892, 31872, 31849, 31826, 31806, 31782, 31761, 31740, 31719, 31697, 31674, 31653, 31632, 31611, 31589, 31565, 31545, 31522, 31502, 31479, 31457, 31437, 31413, 31393, 31370, 31349, 31327, 31306, 31285, 31262, 31240, 30963, 32192, 27571, -27787, -32410, -31179, -31458, -31480, -31501, -31524, -31544, -31568, -31588, -31610, -31632, -31654, -31676, -31698, -31719, -31741, -31762, -31784, -31805, -31828, -31850, -31871, -31894, -31914, -31937, -31957, -31980, -32001, -32022, -32045, -32066, -32088, -32111, -32131, -32154, -32174, -32197, -32219, -32240, -32264, -32284, -32306, -32328, -32349, -32371, -32392, -32415, -32437, -32458, -32480, -32500, -32524, -32543, -32567, -32590, -32610, -32633, -32653, -32676, -32697, -32718, -32738, -32768, -32423, -31889, -31384, -30872, -30362, -29853, -29342, -28832, -28321, -27810, -27301, -26789, -26279, -25771, -25259, -24746, -24238, -23728, -23217, -22706, -22197, -21686, -21176, -20664, -20156, -19646, -19134, -18623, -18114, -17604, -17092, -16582, -16072, -15562, -15051, -14541, -14032, -13521, -13009, -12500, -11989, -11478, -10968, -10459, -9948, -9438, -8926, -8417, -7907, -7396, -6884, -6376, -5864, -5354, -4844, -4333, -3823, -3313, -2803, -2292, -1781, -1271, -764, -245};