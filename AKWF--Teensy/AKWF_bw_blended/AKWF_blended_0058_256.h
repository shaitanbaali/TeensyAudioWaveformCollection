/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0058 256 samples */
 
const int16_t AKWF_blended_0058_256_DATA [256] = 
{129, 531, 923, 1318, 1712, 2106, 2502, 2895, 3290, 3685, 4079, 4474, 4869, 5263, 5658, 6052, 6446, 6841, 7236, 7630, 8025, 8419, 8813, 9209, 9603, 9997, 10392, 10786, 11181, 11576, 11970, 12364, 12759, 13153, 13548, 13943, 14337, 14731, 15126, 15521, 15915, 16309, 16705, 17099, 17493, 17888, 18282, 18677, 19072, 19467, 19861, 20255, 20650, 21045, 21439, 21833, 22228, 22622, 23017, 23411, 23806, 24201, 24595, 24989, 25384, 25779, 26173, 26568, 26962, 27356, 27751, 28146, 28541, 28936, 29062, 30913, 25136, -7541, -7905, -7221, -6915, -6521, -6125, -5743, -5483, -4175, -23662, -29002, -27300, -27138, -26743, -26348, -25954, -25559, -25165, -24771, -24376, -23981, -23587, -23192, -22798, -22404, -22009, -21615, -21220, -20825, -20431, -20037, -19642, -19248, -18853, -18458, -18065, -17670, -17275, -16881, -16486, -16091, -15697, -15302, -14908, -14514, -14118, -13724, -13330, -12935, -12541, -12146, -11752, -11358, -10962, -10568, -10174, -9779, -9384, -8990, -8596, -8201, -7807, -7412, -7017, -6624, -6229, -5834, -5440, -5045, -4650, -4256, -3861, -3466, -3073, -2678, -2283, -1889, -1494, -1099, -705, -311, 83, 477, 872, 1267, 1661, 2056, 2450, 2845, 3239, 3633, 4028, 4423, 4817, 5211, 5606, 6000, 6395, 6790, 7184, 7579, 7974, 8367, 8762, 9157, 9550, 9947, 10341, 10735, 11130, 11524, 11919, 12314, 12708, 13102, 13497, 13891, 14286, 14681, 15075, 15468, 15864, 16258, 16654, 17049, 17175, 19026, 13249, -19427, -19792, -19107, -18802, -18408, -18012, -17618, -17223, -16829, -16435, -16040, -15645, -15251, -14856, -14461, -14068, -13672, -13278, -12884, -12489, -12095, -11700, -11306, -10911, -10517, -10122, -9728, -9333, -8938, -8545, -8150, -7755, -7361, -6966, -6572, -6177, -5782, -5387, -4994, -4599, -4204, -3810, -3415, -3021, -2627, -2231, -1837, -1443, -1049, -655, -254};