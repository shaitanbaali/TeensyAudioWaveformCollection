/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0072 256 samples */
 
const int16_t AKWF_blended_0072_256_DATA [256] = 
{15400, 22415, 22113, 23171, 24008, 24840, 25665, 26476, 27279, 28068, 28840, 29597, 30338, 31052, 31576, 33328, 16160, 10972, 12881, 13230, 13784, 14310, 14806, 15274, 15709, 16115, 16489, 16832, 17140, 17417, 17660, 17870, 18046, 18189, 18299, 18376, 18419, 18429, 18408, 18356, 18271, 18155, 18010, 17836, 17631, 17402, 17144, 16862, 16555, 16224, 15870, 15498, 15105, 14693, 14265, 13822, 13364, 12896, 12415, 11925, 11429, 10925, 10417, 9906, 9394, 8884, 8375, 7868, 7369, 6876, 6391, 5917, 5454, 5004, 4570, 4152, 3750, 3368, 3007, 2667, 2350, 2057, 1788, 1546, 1331, 1144, 986, 858, 760, 693, 658, 655, 684, 747, 843, 971, 1134, 1330, 1558, 1821, 2116, 2443, 2805, 3196, 3620, 4075, 4558, 5072, 5614, 6183, 6779, 7401, 8046, 8716, 9408, 10120, 10852, 11603, 12368, 13150, 13947, 14754, 15574, 16403, 17238, 18031, 18903, 20032, 1975, -4229, -1989, -1407, -569, 261, 1086, 1897, 2700, 3489, 4261, 5019, 5759, 6473, 6997, 8749, -8417, -13606, -11697, -11348, -10793, -10268, -9772, -9304, -8867, -8462, -8088, -7746, -7437, -7160, -6918, -6708, -6531, -6388, -6278, -6201, -6158, -6148, -6170, -6222, -6306, -6423, -6567, -6742, -6947, -7176, -7433, -7716, -8023, -8354, -8707, -9080, -9473, -9884, -10312, -10756, -11213, -11681, -12162, -12652, -13149, -13653, -14161, -14670, -15183, -15694, -16203, -16709, -17208, -17701, -18187, -18661, -19123, -19573, -20007, -20425, -20827, -21208, -21570, -21911, -22227, -22520, -22789, -23031, -23246, -23433, -23591, -23719, -23817, -23884, -23919, -23922, -23893, -23830, -23734, -23606, -23443, -23248, -23018, -22756, -22461, -22133, -21772, -21380, -20957, -20503, -20019, -19505, -18963, -18394, -17798, -17176, -16530, -15861, -15169, -14458, -13726, -12975, -12210, -11426, -10630, -9823, -9003, -8174, -7339, -6498, -5654, -4789};