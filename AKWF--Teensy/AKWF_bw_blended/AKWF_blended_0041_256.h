/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0041 256 samples */
 
const int16_t AKWF_blended_0041_256_DATA [256] = 
{11773, 11873, 11970, 12068, 12165, 12263, 12360, 12458, 12556, 12653, 12751, 12848, 12946, 13043, 13141, 13238, 13336, 13433, 13532, 13628, 13727, 13824, 13922, 14019, 14116, 14214, 14311, 14409, 14506, 14604, 14701, 14799, 14896, 14994, 15092, 15190, 15287, 15385, 15482, 15580, 15677, 15775, 15872, 15970, 16068, 16165, 16263, 16360, 16458, 16555, 16653, 16750, 16848, 16946, 17043, 17141, 17238, 17336, 17434, 17531, 17629, 17726, 17824, 17921, 18019, 18117, 18213, 18312, 18409, 18507, 18604, 18702, 18799, 18897, 18994, 19092, 19189, 19287, 19385, 19482, 19580, 19677, 19775, 19872, 19970, 20067, 20165, 20263, 20361, 20457, 20556, 20653, 20751, 20848, 20946, 21043, 21141, 21238, 21336, 21434, 21532, 21629, 21727, 21824, 21921, 22019, 22116, 22214, 22311, 22409, 22506, 22604, 22702, 22799, 22897, 22995, 23092, 23190, 23287, 23385, 23482, 23580, 23677, 23775, 23873, 23535, 25931, 14387, -16721, -16160, -16020, -16006, -15908, -15811, -15713, -15616, -15518, -15420, -15323, -15226, -15128, -15030, -14932, -14835, -14737, -14640, -14542, -14445, -14347, -14249, -14152, -14054, -13957, -13859, -13762, -13664, -13567, -13469, -13372, -13274, -13177, -13078, -12982, -12884, -12786, -12689, -12591, -12494, -12396, -12299, -12201, -12104, -12006, -11909, -11810, -11713, -11616, -11518, -11420, -11323, -11225, -11128, -11030, -10933, -10835, -10738, -10639, -10542, -10445, -10347, -10250, -10152, -10055, -9957, -9860, -9762, -9665, -9568, -9469, -9372, -9274, -9177, -9079, -8981, -8884, -8786, -8689, -8591, -8493, -8396, -8298, -8201, -8103, -8464, -5918, -21158, -34648, -32140, -32493, -32395, -32298, -32200, -32103, -32005, -31908, -31810, -31713, -31614, -31518, -31420, -31322, -31225, -31127, -31030, -30932, -30835, -30737, -30639, -30542, -30444, -30346, -30249, -30151, -30054, -29956, -29859, -29762, -29664, -29566, -29469, -29371, -29273, -29176, -28727, -30522, -20274};