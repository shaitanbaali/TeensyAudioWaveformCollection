/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0062 256 samples */
 
const int16_t AKWF_blended_0062_256_DATA [256] = 
{153, 567, 972, 1379, 1786, 2193, 2600, 3006, 3413, 3820, 4226, 4634, 5040, 5447, 5854, 6261, 6667, 7074, 7482, 7887, 8295, 8702, 9108, 9516, 9923, 10328, 10736, 11142, 11549, 11957, 12363, 12770, 13177, 13584, 13990, 14397, 14804, 15210, 15618, 16024, 16432, 16838, 17245, 17652, 18059, 18466, 18872, 19280, 19686, 20093, 20500, 20906, 21314, 21720, 22127, 22534, 22940, 23347, 23754, 24161, 24567, 24975, 25381, 25788, 26196, 26602, 27008, 27417, 27822, 28228, 28635, 29048, 28882, 32401, 4263, -11751, -8157, -8333, -7922, -7516, -7111, -6703, -6296, -5890, -5482, -5076, -4670, -4262, -3856, -3449, -3041, -2635, -2562, -309, -18764, -27023, -24785, -24709, -24302, -23895, -23489, -23082, -22675, -22269, -21862, -21454, -21048, -20641, -20234, -19828, -19421, -19014, -18607, -18200, -17793, -17386, -16980, -16572, -16167, -15760, -15352, -14946, -14538, -14132, -13725, -13318, -12911, -12505, -12098, -11691, -11284, -10877, -10471, -10064, -9657, -9251, -8844, -8436, -8031, -7623, -7215, -6810, -6403, -5995, -5590, -5182, -4775, -4369, -3962, -3554, -3148, -2741, -2334, -1929, -1521, -1114, -708, -300, 106, 512, 919, 1325, 1732, 2140, 2546, 2953, 3361, 3766, 4174, 4580, 4987, 5394, 5801, 6207, 6615, 7022, 7428, 7835, 8242, 8648, 9055, 9462, 9869, 10276, 10683, 11089, 11496, 11904, 12310, 12716, 13123, 13530, 13937, 14344, 14751, 15158, 15565, 15970, 16377, 16790, 16624, 20143, -7994, -24008, -20414, -20591, -20179, -19773, -19368, -18961, -18553, -18148, -17740, -17333, -16927, -16520, -16112, -15707, -15299, -14892, -14486, -14079, -13672, -13266, -12858, -12452, -12045, -11637, -11231, -10825, -10418, -10012, -9604, -9197, -8790, -8383, -7976, -7570, -7163, -6756, -6350, -5943, -5536, -5130, -4722, -4315, -3909, -3502, -3095, -2689, -2281, -1874, -1468, -1061, -656, -242};