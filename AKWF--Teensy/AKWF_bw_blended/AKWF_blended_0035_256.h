/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0035 256 samples */
 
const int16_t AKWF_blended_0035_256_DATA [256] = 
{826, 2449, 4039, 5633, 7227, 8822, 10420, 12013, 13609, 15206, 16800, 18392, 19997, 21554, 22434, 23086, 23776, 24461, 25145, 25827, 26513, 27196, 27879, 28563, 29248, 29931, 30615, 31294, 31980, 32654, 32058, 30841, 29718, 28579, 27441, 26300, 25161, 24022, 22880, 21743, 20603, 19462, 18324, 17180, 16052, 14851, 13288, 11683, 10093, 8497, 6899, 5307, 3710, 2113, 520, -1076, -2671, -4265, -5862, -7453, -9050, -10638, -10952, -10646, -10436, -10208, -9980, -9752, -9524, -9296, -9068, -8841, -8612, -8384, -8157, -7926, -7705, -7441, -6498, -5325, -4195, -3055, -1914, -777, 364, 1504, 2642, 3782, 4922, 6060, 7201, 8336, 9478, 10609, 10467, 9706, 9040, 8357, 7673, 6989, 6306, 5622, 4937, 4254, 3570, 2886, 2203, 1519, 835, 152, -531, -1215, -1898, -2582, -3267, -3949, -4634, -5317, -6000, -6685, -7369, -8052, -8736, -9415, -10101, -10776, -10179, -8962, -7839, -6701, -5562, -4420, -3282, -2143, -1003, 135, 1275, 2416, 3553, 4691, 5838, 6941, 7365, 7560, 7796, 8024, 8252, 8480, 8707, 8936, 9163, 9392, 9620, 9847, 10075, 10298, 10530, 10748, 9695, 8023, 6444, 4850, 3255, 1657, 64, -1531, -3128, -4722, -6317, -7914, -9506, -11100, -12710, -14238, -15410, -16543, -17683, -18824, -19965, -21103, -22243, -23384, -24521, -25662, -26802, -27939, -29082, -30215, -31357, -32488, -32347, -31586, -30919, -30237, -29553, -28868, -28185, -27501, -26817, -26134, -25450, -24765, -24083, -23396, -22718, -22001, -20601, -18971, -17386, -15789, -14193, -12600, -11003, -9407, -7814, -6217, -4621, -3029, -1430, 160, 1756, 3344, 3658, 3353, 3142, 2914, 2687, 2459, 2231, 2003, 1774, 1547, 1320, 1091, 863, 635, 407, 179, -49, -276, -504, -732, -960, -1188, -1416, -1643, -1872, -2099, -2328, -2555, -2783, -3007, -3237, -3459, -2410, -710};