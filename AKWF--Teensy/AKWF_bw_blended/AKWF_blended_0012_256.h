/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0012 256 samples */
 
const int16_t AKWF_blended_0012_256_DATA [256] = 
{868, 3904, 5755, 6556, 7341, 8138, 8920, 9691, 10451, 11198, 11928, 12642, 13340, 14016, 14676, 15315, 15932, 16530, 17112, 17672, 18207, 18728, 19229, 19710, 20171, 20619, 21045, 21459, 21852, 22229, 22591, 22938, 23270, 23585, 23886, 24170, 24445, 24706, 24955, 25197, 25421, 25639, 25845, 26038, 26221, 26396, 26562, 26719, 26864, 27005, 27136, 27259, 27374, 27482, 27580, 27672, 27761, 27844, 27918, 27988, 28052, 28111, 28163, 28209, 28252, 28289, 28323, 28351, 28372, 28393, 28410, 28422, 28429, 28431, 28432, 28429, 28421, 28412, 28397, 28379, 28358, 28334, 28306, 28274, 28240, 28200, 28157, 28111, 28060, 28007, 27947, 27882, 27813, 27737, 27655, 27567, 27471, 27367, 27256, 27133, 27002, 26855, 26698, 26529, 26341, 26133, 25910, 25659, 25385, 25084, 24752, 24383, 23977, 23524, 23018, 22450, 21866, 20756, 18145, 14948, 11831, 8710, 6372, 784, -13835, -17519, -20723, -24001, -27223, -30203, -31834, -32269, -32545, -32703, -32764, -32740, -32645, -32492, -32287, -32040, -31758, -31450, -31120, -30772, -30413, -30046, -29670, -29294, -28919, -28541, -28169, -27803, -27442, -27085, -26736, -26396, -26067, -25746, -25432, -25131, -24839, -24558, -24288, -24032, -23783, -23542, -23312, -23088, -22877, -22675, -22481, -22298, -22125, -21958, -21801, -21649, -21508, -21373, -21246, -21129, -21016, -20911, -20815, -20723, -20637, -20555, -20481, -20411, -20346, -20287, -20235, -20189, -20144, -20104, -20069, -20039, -20010, -19986, -19966, -19949, -19935, -19927, -19917, -19913, -19910, -19909, -19911, -19913, -19918, -19923, -19932, -19941, -19948, -19960, -19967, -19977, -19986, -19993, -19998, -20004, -20006, -20004, -20002, -19994, -19983, -19965, -19939, -19910, -19869, -19819, -19758, -19683, -19595, -19491, -19367, -19224, -19055, -18859, -18631, -18370, -18068, -17724, -17331, -16871, -16395, -15396, -12900, -9810, -6805, -4018, -595, -528, -9517, -7500, -4879, -2091};