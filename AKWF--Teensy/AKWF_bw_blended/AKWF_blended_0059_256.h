/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0059 256 samples */
 
const int16_t AKWF_blended_0059_256_DATA [256] = 
{144, 555, 958, 1362, 1765, 2170, 2575, 2978, 3383, 3787, 4191, 4596, 5000, 5404, 5808, 6213, 6617, 7022, 7426, 7829, 8235, 8638, 9043, 9447, 9851, 10255, 10660, 11064, 11467, 11873, 12277, 12681, 13086, 13490, 13893, 14299, 14703, 15106, 15511, 15915, 16319, 16724, 17127, 17532, 17937, 18341, 18745, 19149, 19553, 19958, 20363, 20766, 21171, 21576, 21979, 22383, 22788, 23191, 23596, 24000, 24405, 24810, 25213, 25304, 27454, 8880, 1023, 3190, 3278, 3682, 4087, 4490, 4894, 5299, 5702, 6108, 6512, 6915, 7320, 7723, 8129, 8036, 11191, -18005, -32232, -28879, -29010, -28603, -28200, -27797, -27392, -26987, -26583, -26179, -25775, -25372, -24967, -24562, -24159, -23754, -23350, -22946, -22541, -22137, -21733, -21328, -20924, -20519, -20115, -19712, -19307, -18903, -18499, -18094, -17690, -17286, -16882, -16477, -16073, -15669, -15264, -14861, -14456, -14051, -13647, -13243, -12839, -12435, -12031, -11626, -11222, -10818, -10414, -10009, -9605, -9201, -8796, -8391, -7988, -7583, -7179, -6776, -6371, -5966, -5563, -5158, -4754, -4351, -3945, -3541, -3138, -2733, -2328, -1925, -1519, -1115, -712, -307, 97, 500, 905, 1309, 1712, 2118, 2521, 2925, 3330, 3734, 4139, 4543, 4947, 5351, 5756, 6160, 6564, 6969, 7372, 7778, 8182, 8585, 8990, 9394, 9798, 10203, 10607, 11011, 11416, 11820, 12224, 12628, 13033, 13437, 13841, 14246, 14649, 15054, 15458, 15862, 16266, 16670, 17074, 17480, 17884, 18288, 18693, 19096, 19499, 19905, 20310, 20216, 23372, -5825, -20052, -16698, -16829, -16422, -16019, -15616, -15212, -14807, -14404, -13999, -13594, -13191, -12786, -12381, -11978, -11573, -11169, -10765, -10361, -9956, -9553, -9148, -8744, -8340, -7935, -7531, -7127, -6722, -6319, -5914, -5510, -5105, -4701, -4297, -3893, -3488, -3084, -2680, -2276, -1872, -1467, -1064, -661, -249};