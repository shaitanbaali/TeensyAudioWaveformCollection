/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0046 256 samples */
 
const int16_t AKWF_blended_0046_256_DATA [256] = 
{24159, 34308, 32416, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32624, 33318, 30343, 9821, 7320, 7922, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7793, 7710, 7752, 8215, -22990, -34631, -32333, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32624, -33318, -30343, -9822, -7320, -7923, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793, -7793};