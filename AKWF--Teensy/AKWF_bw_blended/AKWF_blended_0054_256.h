/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0054 256 samples */
 
const int16_t AKWF_blended_0054_256_DATA [256] = 
{101, 375, 644, 914, 1183, 1453, 1722, 1992, 2262, 2531, 2801, 3071, 3341, 3610, 3880, 4150, 4419, 4689, 4959, 5229, 5498, 5769, 6038, 6308, 6577, 6848, 7117, 7387, 7655, 7926, 8196, 8465, 8735, 9005, 9274, 9544, 9814, 10084, 10354, 10623, 10893, 11162, 11432, 11702, 11972, 12241, 12511, 12781, 13050, 13321, 13590, 13859, 14130, 14399, 14668, 14938, 15209, 15478, 15748, 16017, 16287, 16557, 16826, 17096, 17366, 17636, 17905, 18175, 18445, 18714, 18985, 19254, 19523, 19793, 20062, 20333, 20602, 20872, 21142, 21412, 21681, 21951, 22221, 22490, 22760, 23030, 23299, 23569, 23839, 24109, 24379, 24648, 24918, 25188, 25457, 25727, 25997, 26266, 26536, 26806, 27075, 27345, 27615, 27884, 28154, 28424, 28693, 28964, 29234, 29503, 29772, 30042, 30312, 30582, 30852, 30715, 33204, 14054, 3870, 6277, 6157, 6427, 6697, 6966, 7236, 7506, 7776, 8045, 8315, 8585, 8854, 9125, 8649, 12941, -15820, -35678, -31544, -31990, -31720, -31450, -31180, -30911, -30641, -30371, -30102, -29832, -29562, -29292, -29023, -28753, -28483, -28213, -27944, -27675, -27404, -27135, -26866, -26595, -26325, -26056, -25786, -25517, -25247, -24977, -24707, -24438, -24168, -23898, -23628, -23359, -23089, -22819, -22550, -22280, -22010, -21741, -21471, -21201, -20931, -20663, -20392, -20122, -19853, -19583, -19313, -19044, -18774, -18504, -18235, -17964, -17695, -17425, -17155, -16886, -16617, -16346, -16077, -15807, -15537, -15268, -14998, -14728, -14459, -14189, -13919, -13650, -13380, -13110, -12841, -12571, -12300, -12032, -11761, -11491, -11222, -10952, -10683, -10413, -10143, -9874, -9604, -9335, -9065, -8795, -8525, -8255, -7986, -7716, -7447, -7177, -6906, -6637, -6368, -6098, -5828, -5559, -5288, -5019, -4750, -4480, -4210, -3940, -3670, -3401, -3131, -2861, -2592, -2322, -2052, -1783, -1513, -1243, -974, -704, -435, -161};