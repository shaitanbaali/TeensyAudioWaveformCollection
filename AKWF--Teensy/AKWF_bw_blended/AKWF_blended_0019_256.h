/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0019 256 samples */
 
const int16_t AKWF_blended_0019_256_DATA [256] = 
{3535, 7363, 7911, 9069, 10129, 11190, 12251, 13309, 14365, 15421, 16471, 17521, 18569, 19611, 20641, 21734, 22268, 22041, 21850, 21649, 21442, 21230, 21014, 20793, 20566, 20334, 20096, 19852, 19602, 19345, 19083, 18814, 18537, 18254, 17964, 17666, 17362, 17049, 16728, 16399, 16063, 15717, 15365, 15003, 14633, 14256, 13880, 13428, 13523, 14366, 15160, 15948, 16730, 17504, 18266, 19020, 19764, 20497, 21222, 21938, 22642, 23337, 24022, 24699, 25295, 25842, 26386, 26919, 27442, 27956, 28460, 28954, 29439, 29914, 30379, 30835, 31281, 31717, 32133, 32607, 32515, 31659, 30832, 29993, 29142, 28282, 27416, 26539, 25655, 24764, 23862, 22955, 22039, 21115, 20184, 19247, 18301, 17350, 16391, 15425, 14454, 13477, 12492, 11504, 10508, 9506, 8503, 7492, 6475, 5456, 4444, 3359, 2829, 3049, 3227, 3406, 3585, 3761, 3933, 4104, 4273, 4440, 4605, 4769, 4931, 5070, 5243, 5529, -2752, -5740, -4957, -4914, -4751, -4589, -4424, -4258, -4090, -3920, -3748, -3574, -3396, -3216, -3046, -2804, -3113, -4178, -5197, -6217, -7236, -8248, -9255, -10258, -11256, -12247, -13234, -14214, -15188, -16157, -17118, -18072, -19021, -19961, -20895, -21822, -22741, -23652, -24556, -25451, -26339, -27220, -28089, -28952, -29807, -30651, -31476, -32359, -32677, -32230, -31812, -31382, -30939, -30487, -30026, -29555, -29074, -28585, -28085, -27575, -27057, -26526, -25988, -25442, -24811, -24135, -23456, -22764, -22063, -21353, -20632, -19902, -19163, -18413, -17655, -16886, -16107, -15322, -14538, -13677, -13362, -13795, -14180, -14562, -14935, -15300, -15656, -16005, -16345, -16676, -17001, -17318, -17625, -17926, -18220, -18505, -18784, -19057, -19322, -19582, -19834, -20081, -20322, -20556, -20785, -21009, -21226, -21441, -21649, -21853, -22040, -22291, -21983, -20913, -19879, -18840, -17793, -16744, -15694, -14639, -13584, -12528, -11468, -10407, -9347, -8285, -7225, -6144};