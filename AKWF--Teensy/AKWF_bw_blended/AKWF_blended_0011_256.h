/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0011 256 samples */
 
const int16_t AKWF_blended_0011_256_DATA [256] = 
{595, 1282, 2002, 2714, 3423, 4130, 4836, 5538, 6236, 6932, 7621, 8306, 8986, 9659, 10327, 10989, 11644, 12291, 12933, 13565, 14193, 14812, 15422, 16026, 16622, 17208, 17788, 18357, 18917, 19469, 20011, 20543, 21065, 21578, 22080, 22572, 23053, 23524, 23982, 24431, 24866, 25291, 25704, 26105, 26494, 26869, 27233, 27582, 27918, 28240, 28549, 28843, 29125, 29393, 29646, 29886, 30111, 30321, 30519, 30702, 30873, 30773, 32266, 22690, 14092, 15538, 15321, 15340, 15364, 15374, 15367, 15346, 15312, 15267, 15214, 15153, 15087, 15011, 14927, 14837, 14739, 14634, 14518, 14395, 14262, 14120, 13968, 13804, 13630, 13447, 13252, 13046, 12830, 12606, 12369, 12122, 11863, 11595, 11320, 11032, 10736, 10430, 10114, 9793, 9460, 9120, 8772, 8417, 8056, 7687, 7312, 6931, 6545, 6153, 5756, 5356, 4950, 4540, 4128, 3712, 3294, 2875, 2451, 2029, 1605, 1179, 766, 286, -46, -476, -892, -1309, -1727, -2143, -2560, -2975, -3387, -3797, -4206, -4614, -5019, -5420, -5819, -6215, -6606, -6995, -7378, -7755, -8129, -8496, -8855, -9210, -9557, -9895, -10226, -10551, -10865, -11172, -11468, -11756, -12035, -12303, -12562, -12811, -13048, -13274, -13491, -13696, -13888, -14070, -14239, -14396, -14541, -14675, -14798, -14907, -15005, -15092, -15164, -15224, -15272, -15308, -15329, -15337, -15333, -15316, -15286, -15243, -15182, -15367, -13931, -23534, -32132, -30660, -30819, -30719, -30583, -30435, -30277, -30105, -29920, -29715, -29495, -29254, -28992, -28713, -28415, -28099, -27766, -27412, -27042, -26657, -26257, -25842, -25414, -24971, -24517, -24049, -23569, -23078, -22577, -22062, -21540, -21006, -20463, -19911, -19350, -18778, -18200, -17615, -17019, -16417, -15808, -15191, -14567, -13937, -13299, -12658, -12008, -11354, -10695, -10029, -9359, -8686, -8007, -7323, -6638, -5948, -5255, -4559, -3860, -3159, -2456, -1752, -1032, -388};