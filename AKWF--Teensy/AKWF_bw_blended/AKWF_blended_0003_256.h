/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0003 256 samples */
 
const int16_t AKWF_blended_0003_256_DATA [256] = 
{41, 106, 170, 235, 299, 365, 432, 500, 568, 638, 709, 782, 856, 931, 1009, 1089, 1170, 1253, 1340, 1428, 1518, 1612, 1707, 1803, 1905, 2009, 2117, 2226, 2340, 2455, 2574, 2697, 2823, 2954, 3087, 3224, 3365, 3510, 3659, 3810, 3968, 4129, 4294, 4463, 4636, 4814, 4996, 5184, 5374, 5570, 5770, 5975, 6183, 6399, 6615, 6839, 7068, 7300, 7538, 7779, 8027, 8277, 8533, 8794, 9061, 9331, 9606, 9886, 10170, 10460, 10755, 11053, 11357, 11665, 11977, 12294, 12617, 12942, 13272, 13607, 13946, 14290, 14637, 14989, 15345, 15705, 16068, 16437, 16809, 17183, 17563, 17946, 18331, 18722, 19114, 19511, 19912, 20315, 20721, 21131, 21542, 21957, 22374, 22795, 23217, 23643, 24069, 24498, 24931, 25363, 25799, 26236, 26675, 27116, 27558, 28000, 28446, 28890, 29336, 29784, 30233, 30681, 31131, 31581, 31137, 36532, -13564, -36342, -30987, -31421, -30973, -30523, -30075, -29627, -29180, -28736, -28291, -27846, -27405, -26965, -26525, -26088, -25653, -25219, -24787, -24357, -23929, -23505, -23081, -22661, -22243, -21828, -21415, -21005, -20599, -20196, -19795, -19398, -19004, -18614, -18227, -17844, -17463, -17087, -16715, -16346, -15982, -15623, -15265, -14912, -14565, -14221, -13881, -13544, -13213, -12887, -12565, -12247, -11933, -11625, -11321, -11022, -10728, -10436, -10151, -9870, -9595, -9324, -9058, -8794, -8538, -8285, -8037, -7795, -7558, -7324, -7096, -6872, -6651, -6439, -6228, -6022, -5822, -5626, -5433, -5246, -5063, -4885, -4710, -4540, -4374, -4213, -4056, -3903, -3753, -3608, -3465, -3328, -3195, -3063, -2937, -2813, -2693, -2577, -2464, -2353, -2246, -2141, -2041, -1942, -1846, -1752, -1662, -1574, -1486, -1403, -1322, -1243, -1164, -1088, -1014, -942, -869, -800, -731, -662, -596, -529, -464, -399, -335, -273, -209, -146, -83, -20};