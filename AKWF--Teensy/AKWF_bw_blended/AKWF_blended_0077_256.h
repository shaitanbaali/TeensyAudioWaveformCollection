/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0077 256 samples */
 
const int16_t AKWF_blended_0077_256_DATA [256] = 
{8544, 11114, 11818, 12896, 13907, 14909, 15898, 16870, 17825, 18762, 19673, 20562, 21424, 22254, 23057, 23827, 24559, 25258, 25917, 26535, 27112, 27648, 28137, 28580, 28978, 29326, 29627, 29872, 30289, 30798, 31235, 31623, 31959, 32241, 32467, 32656, 32684, 32415, 32087, 31710, 31279, 30798, 30268, 29688, 29059, 28384, 27663, 26898, 26091, 25241, 24349, 23422, 22454, 21452, 20420, 19353, 18256, 17133, 15983, 14810, 13617, 12476, 10944, 10793, 25753, 27048, 25165, 23998, 22713, 21424, 20132, 18849, 17566, 16289, 15024, 13767, 12524, 11298, 10086, 8893, 7722, 6570, 5442, 4342, 3264, 2217, 1199, 210, -747, -1670, -2560, -3424, -4024, -4451, -4859, -5228, -5560, -5853, -6115, -6321, -6600, -7086, -7542, -7960, -8342, -8690, -9003, -9283, -9530, -9744, -9928, -10083, -10209, -10309, -10382, -10429, -10457, -10461, -10446, -10414, -10364, -10301, -10225, -10138, -10042, -9864, -10057, -8851, 7482, 10157, 9661, 9887, 9987, 10078, 10159, 10228, 10284, 10324, 10346, 10349, 10332, 10294, 10232, 10144, 10030, 9887, 9715, 9514, 9280, 9015, 8717, 8384, 8015, 7614, 7175, 6695, 6403, 6213, 5968, 5689, 5373, 5019, 4626, 4214, 3658, 2819, 1941, 1033, 89, -885, -1890, -2925, -3992, -5081, -6198, -7340, -8502, -9688, -10892, -12110, -13349, -14600, -15860, -17134, -18413, -19696, -20985, -22275, -23563, -24777, -26358, -26535, -11581, -10268, -12112, -13215, -14415, -15598, -16758, -17891, -19001, -20081, -21128, -22143, -23127, -24070, -24978, -25844, -26670, -27455, -28195, -28889, -29538, -30138, -30688, -31191, -31643, -32043, -32391, -32694, -32718, -32548, -32346, -32085, -31772, -31407, -30993, -30508, -30082, -29849, -29572, -29243, -28866, -28442, -27972, -27456, -26897, -26296, -25654, -24972, -24255, -23499, -22711, -21893, -21044, -20166, -19264, -18337, -17390, -16425, -15442, -14447, -13440, -12411, -11457, -10074};