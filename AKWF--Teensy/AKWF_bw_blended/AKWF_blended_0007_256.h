/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0007 256 samples */
 
const int16_t AKWF_blended_0007_256_DATA [256] = 
{6544, 14565, 18435, 21797, 23046, 24008, 24872, 25618, 26277, 26867, 27397, 27883, 28327, 28739, 29128, 29495, 29843, 30178, 30498, 30805, 31101, 31383, 31651, 31904, 32134, 32341, 32518, 32654, 32743, 32769, 32722, 32577, 32314, 31900, 31326, 30696, 30065, 29425, 28778, 28129, 27470, 26807, 26140, 25466, 24785, 24103, 23413, 22718, 22020, 21313, 20604, 19890, 19171, 18446, 17718, 16985, 16246, 15504, 14760, 14009, 13255, 12547, 11701, 11953, 23330, 26925, 25628, 24976, 24197, 23410, 22623, 21830, 21037, 20239, 19441, 18638, 17833, 17028, 16218, 15405, 14592, 13777, 12958, 12138, 11315, 10491, 9665, 8835, 8006, 7174, 6340, 5504, 4668, 3830, 2990, 2150, 1306, 466, -376, -1223, -2065, -2908, -3753, -4593, -5434, -6274, -7107, -7938, -8763, -9579, -10390, -11189, -11972, -12740, -13487, -14207, -14899, -15552, -16156, -16705, -17184, -17577, -17865, -18025, -18076, -16356, -13311, -9336, 5688, 12976, 15604, 17887, 18022, 17865, 17607, 17233, 16771, 16235, 15643, 14998, 14314, 13601, 12858, 12095, 11316, 10519, 9711, 8897, 8073, 7242, 6411, 5572, 4731, 3891, 3047, 2204, 1362, 516, -326, -1166, -2009, -2850, -3689, -4527, -5362, -6198, -7034, -7865, -8694, -9524, -10348, -11173, -11996, -12816, -13634, -14451, -15264, -16076, -16886, -17691, -18497, -19298, -20095, -20894, -21687, -22479, -23268, -24053, -24835, -25564, -26424, -26180, -14803, -11202, -12484, -13115, -13865, -14616, -15361, -16104, -16842, -17576, -18302, -19028, -19748, -20462, -21171, -21876, -22575, -23270, -23961, -24643, -25324, -25998, -26665, -27329, -27985, -28636, -29282, -29923, -30554, -31186, -31757, -32173, -32437, -32580, -32628, -32602, -32513, -32377, -32201, -31995, -31765, -31514, -31246, -30965, -30671, -30366, -30049, -29716, -29371, -29009, -28626, -28219, -27782, -27306, -26788, -26211, -25568, -24843, -24010, -23049, -21984, -19187, -14991, -9797};