/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0026 256 samples */
 
const int16_t AKWF_blended_0026_256_DATA [256] = 
{16320, 16452, 16582, 16711, 16840, 16970, 17100, 17229, 17359, 17489, 17618, 17747, 17878, 18007, 18137, 18266, 18396, 18526, 18655, 18785, 18915, 19045, 19174, 19304, 19434, 19563, 19692, 19822, 19952, 20081, 20211, 20341, 20471, 20600, 20730, 20860, 20989, 21118, 21248, 21378, 21508, 21637, 21767, 21897, 22027, 22156, 22286, 22415, 22545, 22674, 22804, 22934, 23063, 23193, 23323, 23452, 23582, 23711, 23842, 23971, 24100, 24230, 24360, 24489, 24619, 24749, 24879, 25008, 25138, 25268, 25397, 25527, 25656, 25786, 25915, 26045, 26175, 26305, 26434, 26564, 26693, 26823, 26953, 27082, 27212, 27342, 27471, 27601, 27731, 27860, 27990, 28120, 28249, 28379, 28508, 28638, 28767, 28897, 29027, 29157, 29286, 29416, 29546, 29675, 29805, 29934, 30064, 30194, 30323, 30453, 30583, 30712, 30842, 30972, 31101, 31231, 31360, 31490, 31620, 31749, 31879, 32009, 32139, 32268, 32397, 31604, 36669, 10875, -35673, -31973, -32406, -32342, -32213, -32084, -31953, -31824, -31694, -31565, -31435, -31305, -31176, -31046, -30916, -30786, -30657, -30528, -30398, -30268, -30138, -30009, -29879, -29749, -29620, -29491, -29360, -29231, -29102, -28971, -28842, -28712, -28583, -28453, -28324, -28194, -28065, -27935, -27805, -27676, -27546, -27416, -27287, -27157, -27027, -26898, -26768, -26638, -26509, -26379, -26249, -26120, -25990, -25860, -25731, -25601, -25472, -25342, -25212, -25083, -24953, -24824, -24694, -24563, -24434, -24305, -24175, -24045, -23916, -23787, -23656, -23527, -23398, -23267, -23138, -23008, -22879, -22749, -22619, -22490, -22360, -22231, -22101, -21972, -21842, -21712, -21582, -21453, -21323, -21193, -21064, -20935, -20805, -20675, -20545, -20416, -20286, -20156, -20027, -19897, -19767, -19638, -19508, -19379, -19249, -19119, -18990, -18859, -18730, -18600, -18471, -18341, -18212, -18082, -17953, -17823, -17693, -17563, -17434, -17304, -17174, -17045, -16915, -16785, -16656, -16246, -17630, -9377};