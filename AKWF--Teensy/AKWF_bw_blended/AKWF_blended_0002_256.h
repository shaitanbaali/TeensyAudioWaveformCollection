/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0002 256 samples */
 
const int16_t AKWF_blended_0002_256_DATA [256] = 
{24781, 29177, 28402, 28667, 28778, 28896, 29009, 29194, 29301, 29388, 29469, 29550, 29627, 29703, 29778, 29849, 29921, 29992, 30063, 30130, 30195, 30261, 30326, 30389, 30454, 30517, 30579, 30641, 30701, 30762, 30823, 30882, 30940, 30999, 31057, 31116, 31174, 31231, 31287, 31344, 31402, 31457, 31513, 31570, 31626, 31680, 31736, 31792, 31847, 31901, 31956, 32009, 31925, 32742, 22926, 16528, 15313, 13610, 12173, 10874, 9676, 8568, 7546, 6598, 5720, 4908, 4157, 3459, 2815, 2218, 1665, 1154, 681, 245, -156, -528, -869, -1183, -1471, -1738, -1979, -2201, -2401, -2585, -2751, -2900, -3032, -3151, -3257, -3351, -3430, -3499, -3558, -3607, -3646, -3675, -3698, -3709, -3714, -3709, -3702, -3685, -3662, -3633, -3600, -3557, -3511, -3460, -3402, -3339, -3271, -3198, -3120, -3038, -2951, -2859, -2760, -2641, -2507, -2370, -2227, -2084, -1936, -1786, -1633, -1476, -1322, -1162, -1001, -838, -675, -509, -343, -174, -5, 168, 330, 474, 613, 751, 883, 1015, 1147, 1275, 1401, 1528, 1655, 1775, 1898, 2019, 2140, 2260, 2378, 2495, 2613, 2729, 2843, 2960, 3074, 3188, 3300, 3413, 3526, 3638, 3750, 3859, 3971, 4081, 4191, 4300, 4410, 4519, 4628, 4735, 4844, 4953, 5059, 5165, 5273, 5378, 5346, 6215, -3547, -9893, -11056, -12708, -14095, -15341, -16487, -17545, -18516, -19412, -20239, -21002, -21701, -22348, -22944, -23489, -23993, -24453, -24875, -25262, -25614, -25934, -26227, -26492, -26730, -26946, -27139, -27311, -27463, -27598, -27714, -27814, -27898, -27969, -28025, -28071, -28103, -28122, -28133, -28135, -28125, -28107, -28080, -28046, -28003, -27951, -27895, -27832, -27760, -27685, -27604, -27515, -27422, -27324, -27219, -27110, -26996, -26877, -26752, -26624, -26490, -26353, -26208, -26043, -25863, -25681, -25490, -25290, -25115, -24913, -24713, -24381, -24927, -21222};