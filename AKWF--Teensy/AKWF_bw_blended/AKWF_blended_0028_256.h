/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0028 256 samples */
 
const int16_t AKWF_blended_0028_256_DATA [256] = 
{26755, 30608, 29617, 29639, 29510, 29378, 29246, 29113, 28982, 28849, 28719, 28586, 28453, 28321, 28188, 28057, 27926, 27792, 27661, 27529, 27396, 27265, 27133, 27000, 26868, 26737, 26605, 26471, 26340, 26208, 26076, 25943, 25812, 25680, 25548, 25416, 25284, 25151, 25019, 24888, 24755, 24622, 24491, 24359, 24226, 24094, 23963, 23830, 23698, 23566, 23434, 23302, 23170, 23038, 22906, 22774, 22642, 22510, 22376, 22245, 22114, 21803, 22538, 19217, -19289, -22613, -21876, -22186, -22319, -22450, -22582, -22715, -22847, -22978, -23110, -23243, -23375, -23506, -23639, -23772, -23903, -24035, -24168, -24299, -24431, -24564, -24695, -24827, -24960, -25092, -25223, -25356, -25489, -25621, -25752, -25884, -26017, -26148, -26280, -26414, -26545, -26677, -26809, -26941, -27073, -27205, -27338, -27469, -27601, -27734, -27866, -27997, -28130, -28263, -28394, -28526, -28658, -28790, -28922, -29055, -29186, -29318, -29449, -29582, -29717, -29754, -30125, -29789, 3026, 9477, 7799, 7950, 7822, 7691, 7559, 7426, 7294, 7161, 7029, 6897, 6765, 6634, 6502, 6369, 6237, 6105, 5973, 5840, 5709, 5577, 5444, 5313, 5181, 5048, 4915, 4784, 4652, 4519, 4387, 4256, 4123, 3990, 3860, 3727, 3595, 3464, 3331, 3198, 3067, 2935, 2802, 2670, 2539, 2407, 2274, 2141, 2011, 1878, 1746, 1614, 1482, 1349, 1218, 1086, 953, 821, 690, 557, 424, 293, 161, 29, -102, -234, -367, -499, -630, -763, -895, -1027, -1158, -1291, -1423, -1554, -1687, -1820, -1952, -2083, -2216, -2349, -2479, -2612, -2744, -2875, -3008, -3141, -3271, -3404, -3537, -3669, -3800, -3933, -4066, -4197, -4329, -4461, -4594, -4726, -4857, -4990, -5121, -5253, -5386, -5517, -5649, -5782, -5915, -6046, -6178, -6311, -6443, -6574, -6707, -6838, -6971, -7103, -7235, -7368, -7500, -7631, -7763, -7895, -8030, -8197, -8118, -9132};