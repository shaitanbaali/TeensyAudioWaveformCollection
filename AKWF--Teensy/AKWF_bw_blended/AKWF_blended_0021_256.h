/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0021 256 samples */
 
const int16_t AKWF_blended_0021_256_DATA [256] = 
{16947, 17763, 18561, 19354, 20141, 20919, 21687, 22440, 23179, 23904, 24608, 25293, 25959, 26598, 27215, 27806, 28367, 28902, 29405, 29877, 30317, 30724, 31095, 31431, 31731, 31993, 32220, 32407, 32555, 32665, 32735, 32766, 32758, 32710, 32623, 32496, 32331, 32127, 31886, 31607, 31292, 30940, 30554, 30133, 29678, 29194, 28677, 28130, 27556, 26955, 26327, 25677, 25003, 24309, 23596, 22865, 22119, 21360, 20587, 19805, 19015, 18217, 17417, 16614, 15809, 15007, 14207, 13413, 12626, 11848, 11080, 10327, 9588, 8863, 8159, 7473, 6808, 6169, 5552, 4961, 4400, 3866, 3361, 2890, 2450, 2043, 1673, 1335, 1035, 774, 547, 360, 212, 102, 32, 1, 9, 57, 144, 271, 435, 639, 881, 1160, 1475, 1827, 2213, 2634, 3087, 3573, 4090, 4636, 5210, 5812, 6440, 7090, 7764, 8458, 9170, 9901, 10648, 11407, 12180, 12962, 13751, 14198, 16855, 8254, -16151, -14974, -14141, -13413, -12627, -11849, -11081, -10327, -9588, -8864, -8160, -7474, -6809, -6170, -5553, -4962, -4401, -3866, -3362, -2891, -2451, -2044, -1674, -1336, -1036, -775, -548, -361, -213, -103, -33, -2, -10, -58, -145, -272, -436, -640, -882, -1161, -1476, -1828, -2214, -2635, -3088, -3574, -4091, -4637, -5211, -5813, -6441, -7091, -7764, -8459, -9171, -9902, -10648, -11408, -12180, -12962, -13752, -14550, -15350, -16153, -16958, -17760, -18560, -19355, -20141, -20919, -21687, -22440, -23179, -23904, -24608, -25294, -25959, -26598, -27215, -27806, -28367, -28902, -29405, -29877, -30317, -30724, -31095, -31431, -31731, -31993, -32220, -32407, -32555, -32665, -32735, -32766, -32758, -32710, -32623, -32496, -32331, -32128, -31886, -31607, -31292, -30940, -30554, -30133, -29678, -29194, -28677, -28130, -27556, -26955, -26327, -25677, -25004, -24309, -23597, -22866, -22119, -21360, -20587, -19806, -19016, -17935, -18665, -9650};