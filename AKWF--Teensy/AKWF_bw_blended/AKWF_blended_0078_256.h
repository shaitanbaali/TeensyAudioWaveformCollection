/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0078 256 samples */
 
const int16_t AKWF_blended_0078_256_DATA [256] = 
{28621, 31666, 30618, 30404, 30062, 29717, 29370, 29021, 28671, 28317, 27961, 27602, 27238, 26872, 26500, 26127, 25748, 25363, 24972, 24577, 24177, 23769, 23358, 22938, 22511, 22078, 21638, 21183, 20974, 20914, 20822, 20728, 20623, 20510, 20385, 20268, 20021, 19489, 18940, 18386, 17818, 17240, 16653, 16056, 15441, 15135, 14992, 14812, 14624, 14425, 14215, 13993, 13758, 13512, 13253, 12983, 12699, 12405, 12096, 11776, 11444, 11180, 10486, 11337, 29092, 31567, 30479, 30192, 29761, 29315, 28856, 28386, 27903, 27407, 26900, 26381, 25848, 25306, 24749, 24181, 23603, 23007, 22424, 21572, 20457, 19358, 18245, 17118, 15982, 14837, 13678, 12505, 11577, 10792, 9979, 9160, 8330, 7492, 6644, 5803, 4835, 3584, 2317, 1048, -230, -1516, -2806, -4105, -5412, -6720, -8036, -9358, -10682, -12014, -13351, -14688, -16033, -17381, -18729, -20083, -21440, -22795, -24159, -25520, -26881, -27818, -31265, -23064, 27176, 30723, 28109, 27037, 25676, 24315, 22952, 21593, 20238, 18882, 17532, 16183, 14837, 13497, 12159, 10825, 9500, 8175, 6855, 5545, 4236, 2934, 1641, 352, -929, -2200, -3468, -4735, -5738, -6580, -7434, -8274, -9108, -9930, -10747, -11538, -12440, -13605, -14769, -15917, -17058, -18191, -19306, -20416, -21519, -22289, -22875, -23477, -24061, -24633, -25195, -25742, -26280, -26804, -27316, -27818, -28307, -28781, -29246, -29696, -30134, -30478, -31228, -30407, -12658, -10165, -11207, -11424, -11761, -12086, -12400, -12699, -12986, -13264, -13528, -13779, -14019, -14246, -14463, -14665, -14857, -15043, -15192, -15589, -16225, -16824, -17416, -17997, -18570, -19129, -19681, -20227, -20511, -20630, -20759, -20876, -20985, -21083, -21178, -21244, -21424, -21871, -22317, -22751, -23182, -23604, -24019, -24428, -24834, -25229, -25621, -26009, -26390, -26767, -27139, -27507, -27872, -28233, -28590, -28945, -29297, -29645, -29993, -30339, -30682, -30763, -32517, -25520};