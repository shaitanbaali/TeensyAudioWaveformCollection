/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0013 256 samples */
 
const int16_t AKWF_blended_0013_256_DATA [256] = 
{9944, 17483, 16251, 16747, 16979, 17211, 17439, 17669, 17897, 18127, 18358, 18588, 18816, 19045, 19276, 19505, 19734, 19964, 20193, 20423, 20652, 20883, 21111, 21341, 21571, 21800, 22030, 22259, 22489, 22718, 22948, 23178, 23408, 23637, 23866, 24097, 24325, 24554, 24784, 25013, 25244, 25473, 25703, 25932, 26162, 26391, 26620, 26850, 27079, 27309, 27539, 27768, 27998, 28227, 28456, 28687, 28915, 29144, 29374, 29606, 29837, 30021, 30143, 31347, 6105, -2535, -437, -548, -322, -94, 135, 365, 596, 824, 1055, 1284, 1513, 1743, 1973, 2203, 2431, 2662, 2891, 3120, 3349, 3578, 3809, 4038, 4268, 4497, 4727, 4957, 5185, 5416, 5645, 5874, 6104, 6334, 6563, 6793, 7023, 7252, 7482, 7711, 7939, 8171, 8399, 8630, 8860, 9088, 9318, 9548, 9777, 10006, 10236, 10465, 10696, 10925, 11154, 11385, 11613, 11843, 12074, 12302, 12528, 12565, 14076, 9009, -17278, -12500, -12963, -12634, -12400, -12170, -11942, -11712, -11483, -11254, -11023, -10794, -10565, -10334, -10105, -9875, -9646, -9417, -9186, -8958, -8729, -8498, -8270, -8038, -7809, -7581, -7351, -7121, -6892, -6662, -6433, -6204, -5973, -5744, -5514, -5284, -5055, -4826, -4596, -4367, -4137, -3908, -3678, -3448, -3219, -2990, -2760, -2530, -2302, -2071, -1842, -1612, -1383, -1154, -924, -693, -465, -235, -5, 223, 454, 639, 761, 1966, -23273, -31915, -29818, -29930, -29704, -29474, -29243, -29013, -28784, -28555, -28325, -28096, -27866, -27637, -27407, -27178, -26948, -26719, -26489, -26260, -26030, -25800, -25571, -25342, -25112, -24882, -24652, -24423, -24195, -23964, -23735, -23506, -23276, -23046, -22817, -22587, -22358, -22128, -21898, -21669, -21439, -21210, -20981, -20751, -20520, -20292, -20061, -19832, -19603, -19374, -19144, -18914, -18685, -18457, -18226, -17995, -17767, -17537, -17307, -17078, -16850, -16650, -16247, -16746};