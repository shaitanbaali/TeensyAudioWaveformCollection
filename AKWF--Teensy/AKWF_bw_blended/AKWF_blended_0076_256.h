/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0076 256 samples */
 
const int16_t AKWF_blended_0076_256_DATA [256] = 
{691, 3252, 5739, 8198, 10604, 12947, 15212, 17377, 19439, 21384, 23195, 24871, 26400, 27769, 28982, 30030, 30906, 31615, 32153, 32521, 32723, 32762, 32643, 32372, 31959, 31410, 30735, 29947, 29057, 28073, 27013, 25889, 24711, 23497, 22259, 21009, 19766, 18538, 17336, 16179, 15072, 14027, 13058, 12167, 11364, 10661, 10053, 9552, 9158, 8872, 8694, 8624, 8659, 8795, 9028, 9352, 9758, 10240, 10788, 11393, 12044, 12732, 13441, 14162, 14885, 15594, 16278, 16927, 17527, 18069, 18541, 18932, 19235, 19440, 19541, 19530, 19402, 19155, 18784, 18287, 17668, 16923, 16055, 15072, 13973, 12768, 11464, 10066, 8588, 7040, 5428, 3769, 2076, 359, -1365, -3084, -4787, -6453, -8073, -9635, -11120, -12518, -13821, -15009, -16079, -17019, -17817, -18473, -18974, -19318, -19502, -19523, -19381, -19077, -18611, -17990, -17215, -16295, -15239, -14050, -12743, -11331, -9816, -8221, -6557, -4833, -3070, -1283, 519, 2315, 4089, 5832, 7521, 9148, 10700, 12156, 13509, 14750, 15863, 16842, 17680, 18366, 18899, 19272, 19483, 19531, 19415, 19139, 18703, 18113, 17374, 16493, 15478, 14339, 13082, 11725, 10275, 8742, 7147, 5499, 3807, 2095, 372, -1352, -3054, -4730, -6364, -7938, -9449, -10883, -12224, -13474, -14619, -15651, -16569, -17366, -18039, -18589, -19012, -19311, -19490, -19549, -19495, -19334, -19071, -18716, -18276, -17764, -17188, -16557, -15887, -15188, -14468, -13746, -13029, -12331, -11664, -11039, -10465, -9954, -9514, -9155, -8882, -8705, -8626, -8652, -8783, -9024, -9373, -9828, -10391, -11054, -11816, -12671, -13607, -14622, -15704, -16840, -18026, -19244, -20482, -21732, -22975, -24201, -25397, -26544, -27633, -28652, -29582, -30416, -31141, -31743, -32215, -32548, -32732, -32760, -32629, -32332, -31865, -31230, -30424, -29448, -28304, -27002, -25538, -23925, -22171, -20279, -18267, -16145, -13918, -11609, -9229, -6790, -4316, -1762};