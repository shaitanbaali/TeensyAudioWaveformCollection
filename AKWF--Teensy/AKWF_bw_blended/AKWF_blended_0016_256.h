/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0016 256 samples */
 
const int16_t AKWF_blended_0016_256_DATA [256] = 
{3808, 7765, 8064, 9044, 9915, 10786, 11658, 12525, 13392, 14257, 15117, 15977, 16835, 17685, 18527, 19408, 19935, 19986, 20057, 20119, 20177, 20229, 20275, 20316, 20350, 20379, 20402, 20416, 20426, 20428, 20423, 20410, 20390, 20362, 20327, 20283, 20231, 20170, 20101, 20023, 19937, 19840, 19735, 19620, 19496, 19362, 19226, 19038, 19188, 19802, 20381, 20951, 21514, 22066, 22605, 23137, 23657, 24166, 24664, 25153, 25628, 26094, 26549, 26993, 27428, 27850, 28261, 28662, 29052, 29431, 29800, 30157, 30504, 30840, 31165, 31480, 31785, 32078, 32355, 32663, 32614, 32080, 31561, 31030, 30488, 29935, 29375, 28803, 28224, 27636, 27038, 26431, 25817, 25193, 24562, 23924, 23276, 22622, 21959, 21288, 20613, 19930, 19239, 18544, 17840, 17131, 16417, 15697, 14971, 14242, 13515, 12739, 12309, 12348, 12358, 12368, 12375, 12379, 12380, 12379, 12376, 12371, 12363, 12355, 12345, 12258, 12504, 11730, -8560, -12993, -12065, -12258, -12269, -12278, -12287, -12292, -12297, -12299, -12298, -12295, -12290, -12281, -12276, -12224, -12517, -13279, -14012, -14742, -15471, -16194, -16909, -17622, -18327, -19025, -19719, -20405, -21084, -21757, -22422, -23080, -23731, -24373, -25007, -25634, -26252, -26862, -27464, -28056, -28639, -29214, -29779, -30335, -30883, -31418, -31937, -32490, -32683, -32394, -32117, -31829, -31529, -31219, -30898, -30566, -30223, -29870, -29506, -29133, -28748, -28351, -27944, -27527, -27098, -26659, -26208, -25746, -25274, -24792, -24297, -23793, -23278, -22751, -22216, -21669, -21111, -20543, -19973, -19349, -19064, -19242, -19386, -19523, -19651, -19770, -19880, -19979, -20070, -20151, -20224, -20288, -20345, -20392, -20431, -20462, -20485, -20501, -20510, -20511, -20504, -20492, -20472, -20446, -20414, -20376, -20332, -20283, -20228, -20168, -20096, -20061, -19674, -18810, -17965, -17116, -16261, -15402, -14543, -13679, -12813, -11947, -11076, -10206, -9334, -8461, -7591, -6701};