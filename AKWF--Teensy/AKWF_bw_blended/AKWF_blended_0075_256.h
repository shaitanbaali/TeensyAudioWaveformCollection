/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0075 256 samples */
 
const int16_t AKWF_blended_0075_256_DATA [256] = 
{10042, 17286, 16118, 16517, 16671, 16823, 16976, 17127, 17279, 17429, 17580, 17730, 17879, 18028, 18121, 18588, 16446, 14133, 14754, 14830, 15007, 15175, 15342, 15509, 15674, 15838, 16002, 16165, 16328, 16490, 16652, 16813, 16975, 17135, 17296, 17458, 17619, 17781, 17943, 18104, 18267, 18430, 18592, 18756, 18920, 19084, 19248, 19412, 19577, 19742, 19909, 20074, 20241, 20408, 20576, 20745, 20913, 21083, 21253, 21424, 21595, 21768, 21941, 22087, 22222, 22968, 688, -4222, -933, 282, 1483, 2461, 3270, 3948, 4521, 5019, 5461, 5862, 6241, 6609, 7103, 7621, 7945, 8230, 8488, 8727, 8953, 9169, 9376, 9576, 9771, 9962, 10150, 10333, 10515, 10695, 10872, 11046, 11219, 11391, 11562, 11732, 11901, 12068, 12235, 12401, 12565, 12729, 12894, 13057, 13218, 13380, 13541, 13701, 13861, 14021, 14180, 14338, 14496, 14654, 14812, 14968, 15124, 15281, 15436, 15534, 15718, 16196, -5443, -13420, -11661, -11811, -11657, -11504, -11352, -11200, -11049, -10899, -10748, -10598, -10448, -10300, -10206, -9740, -11882, -14194, -13573, -13498, -13320, -13152, -12986, -12818, -12654, -12490, -12325, -12162, -12000, -11837, -11676, -11514, -11353, -11193, -11032, -10870, -10709, -10547, -10385, -10224, -10061, -9898, -9735, -9572, -9408, -9245, -9080, -8915, -8750, -8585, -8420, -8254, -8086, -7919, -7752, -7584, -7415, -7246, -7075, -6904, -6733, -6560, -6387, -6242, -6106, -5360, -27640, -32550, -29261, -28044, -26844, -25866, -25057, -24380, -23806, -23307, -22866, -22466, -22087, -21719, -21225, -20707, -20382, -20097, -19840, -19601, -19375, -19159, -18952, -18752, -18556, -18365, -18178, -17993, -17812, -17634, -17457, -17281, -17108, -16935, -16765, -16596, -16427, -16260, -16092, -15927, -15762, -15598, -15434, -15271, -15109, -14948, -14786, -14626, -14467, -14307, -14148, -13989, -13832, -13673, -13516, -13359, -13203, -13047, -12891, -12736, -12581, -12424};