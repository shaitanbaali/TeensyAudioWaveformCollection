/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0056 256 samples */
 
const int16_t AKWF_blended_0056_256_DATA [256] = 
{168, 438, 701, 967, 1231, 1496, 1761, 2026, 2291, 2557, 2821, 3086, 3352, 3616, 3881, 4146, 4410, 4677, 4941, 5206, 5471, 5736, 6001, 6265, 6531, 6796, 7061, 7326, 7591, 7856, 8120, 8386, 8651, 8916, 9181, 9446, 9710, 9975, 10241, 10505, 10770, 11035, 11301, 11566, 11831, 12095, 12360, 12625, 12890, 13156, 13421, 13685, 13950, 14215, 14480, 14745, 15010, 15275, 15540, 15804, 16069, 16336, 16600, 16865, 17130, 17394, 17660, 17924, 18190, 18454, 18720, 18985, 19250, 19515, 19780, 20045, 20310, 20575, 20840, 21104, 21369, 21635, 21900, 22164, 22429, 22694, 22959, 23225, 23489, 23754, 24019, 24284, 24549, 24814, 25079, 25344, 25609, 25874, 26138, 26404, 26669, 26934, 27199, 27464, 27729, 27993, 28258, 28524, 28789, 29053, 29319, 29584, 29848, 30114, 30379, 30644, 30909, 31174, 31438, 31704, 31969, 31708, 34909, 21540, -11293, -8180, -8423, -8159, -7893, -7628, -7364, -7223, -6320, -8498, -31076, -32201, -31536, -31358, -31094, -30829, -30563, -30298, -30034, -29769, -29505, -29239, -28974, -28709, -28444, -28179, -27914, -27650, -27383, -27119, -26854, -26589, -26325, -26059, -25794, -25529, -25264, -24999, -24734, -24469, -24205, -23939, -23674, -23409, -23145, -22880, -22615, -22350, -22085, -21820, -21555, -21289, -21025, -20760, -20495, -20230, -19965, -19700, -19435, -19170, -18905, -18640, -18375, -18110, -17846, -17580, -17315, -17050, -16785, -16521, -16256, -15990, -15726, -15461, -15195, -14931, -14666, -14400, -14136, -13871, -13606, -13341, -13075, -12811, -12546, -12281, -12016, -11751, -11486, -11221, -10957, -10691, -10426, -10161, -9896, -9631, -9367, -9101, -8836, -8571, -8306, -8041, -7777, -7511, -7247, -6982, -6716, -6452, -6187, -5922, -5657, -5391, -5126, -4863, -4597, -4332, -4067, -3802, -3536, -3272, -3007, -2742, -2477, -2212, -1947, -1682, -1417, -1152, -888, -623, -358, -89};