/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0068 256 samples */
 
const int16_t AKWF_blended_0068_256_DATA [256] = 
{168, 638, 1111, 1598, 2097, 2607, 3129, 3661, 4206, 4761, 5326, 5903, 6492, 7086, 7695, 8312, 8937, 9573, 10220, 10872, 11536, 12207, 12884, 13572, 14268, 14969, 15677, 16394, 17116, 17845, 18580, 19320, 20066, 20818, 21573, 22334, 23097, 23866, 24638, 25413, 26191, 26973, 27756, 28542, 29330, 30116, 30746, 32140, 31194, -25773, -33400, -30499, -30104, -29317, -28531, -27746, -26962, -26183, -25405, -24630, -23860, -23092, -22330, -21570, -20816, -20067, -19322, -18583, -17850, -17124, -16403, -15690, -14982, -14282, -13591, -12905, -12228, -11560, -10900, -10249, -9608, -8973, -8350, -7737, -7132, -6538, -5953, -5381, -4816, -4265, -3724, -3194, -2677, -2170, -1674, -1191, -719, -260, 188, 622, 1044, 1453, 1852, 2237, 2609, 2968, 3314, 3647, 3967, 4274, 4568, 4850, 5117, 5373, 5615, 5843, 6060, 6262, 6451, 6628, 6792, 6942, 7080, 7205, 7318, 7418, 7505, 7581, 7645, 7694, 7733, 7760, 7775, 7778, 7770, 7751, 7721, 7679, 7627, 7563, 7492, 7408, 7314, 7211, 7098, 6976, 6844, 6705, 6555, 6398, 6233, 6059, 5879, 5691, 5495, 5293, 5085, 4870, 4649, 4423, 4189, 3953, 3711, 3463, 3214, 2959, 2699, 2439, 2174, 1906, 1637, 1365, 1091, 817, 540, 264, -11, -288, -566, -843, -1118, -1393, -1665, -1936, -2205, -2471, -2735, -2997, -3253, -3508, -3756, -4002, -4244, -4479, -4710, -4934, -5153, -5367, -5573, -5774, -5967, -6153, -6332, -6503, -6665, -6821, -6967, -7104, -7232, -7352, -7462, -7562, -7653, -7733, -7803, -7863, -7913, -7951, -7978, -7994, -7999, -7992, -7974, -7942, -7900, -7847, -7780, -7702, -7610, -7507, -7390, -7260, -7120, -6965, -6798, -6617, -6424, -6217, -5998, -5766, -5519, -5260, -4989, -4704, -4406, -4094, -3771, -3433, -3083, -2721, -2345, -1956, -1555, -1142, -718, -271};