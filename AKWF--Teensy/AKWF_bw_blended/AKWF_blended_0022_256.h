/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0022 256 samples */
 
const int16_t AKWF_blended_0022_256_DATA [256] = 
{512, 1896, 3249, 4600, 5942, 7275, 8596, 9899, 11185, 12454, 13696, 14916, 16110, 17273, 18407, 19509, 20575, 21605, 22598, 23549, 24461, 25330, 26154, 26935, 27669, 28354, 28993, 29584, 30124, 30616, 31056, 31445, 31786, 32075, 32313, 32500, 32639, 32727, 32766, 32757, 32701, 32598, 32449, 32256, 32020, 31744, 31424, 31068, 30675, 30245, 29783, 29289, 28765, 28213, 27637, 27037, 26415, 25777, 25119, 24450, 23769, 23075, 22377, 21687, 20528, 19137, 17787, 16434, 15093, 13760, 12438, 11136, 9849, 8580, 7338, 6117, 4923, 3761, 2626, 1524, 460, -570, -1563, -2514, -3426, -4295, -5118, -5900, -6633, -7319, -7959, -8548, -9088, -9580, -10021, -10410, -10750, -11039, -11277, -11466, -11603, -11690, -11730, -11722, -11665, -11562, -11414, -11221, -10984, -10707, -10389, -10032, -9639, -9209, -8747, -8254, -7730, -7178, -6602, -6001, -5380, -4742, -4084, -3414, -2733, -2042, -1344, -642, 61, 765, 1464, 2160, 2844, 3520, 4183, 4829, 5459, 6067, 6654, 7216, 7753, 8259, 8735, 9180, 9588, 9961, 10296, 10590, 10845, 11057, 11224, 11346, 11423, 11451, 11433, 11366, 11249, 11082, 10866, 10598, 10280, 9912, 9493, 9023, 8504, 7935, 7316, 6651, 5937, 5175, 4371, 3520, 2626, 1692, 716, -298, -1348, -2435, -3556, -4704, -5887, -7096, -8328, -9588, -10866, -12162, -13476, -14804, -16142, -17491, -18843, -20213, -21124, -21793, -22500, -23196, -23881, -24556, -25219, -25866, -26495, -27105, -27691, -28253, -28789, -29296, -29772, -30216, -30624, -30998, -31333, -31627, -31881, -32092, -32260, -32382, -32458, -32488, -32469, -32402, -32286, -32119, -31901, -31634, -31316, -30948, -30529, -30059, -29540, -28971, -28352, -27687, -26972, -26212, -25407, -24556, -23663, -22728, -21752, -20737, -19688, -18601, -17480, -16331, -15148, -13939, -12706, -11447, -10169, -8873, -7559, -6231, -4895, -3546, -2195, -812};