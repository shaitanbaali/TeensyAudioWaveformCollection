/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0066 256 samples */
 
const int16_t AKWF_blended_0066_256_DATA [256] = 
{1433, 3390, 4962, 6300, 7458, 8486, 9416, 10271, 11074, 11840, 12574, 13289, 13991, 14678, 15362, 16038, 16709, 17383, 18054, 18724, 19395, 20066, 20736, 21409, 22082, 22752, 23423, 24092, 24759, 25422, 26081, 26730, 27372, 27999, 28607, 29195, 29753, 30274, 30749, 31165, 31510, 31763, 31905, 31985, 32060, 32132, 32199, 32262, 32322, 32378, 32431, 32479, 32524, 32564, 32602, 32636, 32665, 32691, 32712, 32731, 32746, 32758, 32764, 32767, 32767, 32764, 32758, 32746, 32731, 32712, 32691, 32665, 32636, 32602, 32564, 32524, 32479, 32431, 32378, 32323, 32262, 32199, 32132, 32060, 31985, 31905, 31763, 31510, 31166, 30749, 30274, 29753, 29195, 28607, 27999, 27372, 26731, 26081, 25424, 24760, 24093, 23425, 22754, 22085, 21413, 20743, 20075, 19406, 18739, 18076, 17412, 16750, 16092, 15435, 14778, 14124, 13471, 12819, 12169, 11518, 10871, 10225, 9578, 8913, 8343, 7046, 3870, 861, -1470, -3377, -4959, -6301, -7459, -8486, -9417, -10272, -11075, -11841, -12575, -13290, -13992, -14679, -15362, -16039, -16710, -17383, -18055, -18724, -19396, -20067, -20737, -21409, -22082, -22752, -23424, -24092, -24759, -25423, -26081, -26731, -27372, -27999, -28607, -29195, -29753, -30274, -30749, -31166, -31510, -31763, -31905, -31985, -32061, -32132, -32199, -32262, -32323, -32378, -32431, -32479, -32524, -32564, -32602, -32636, -32665, -32691, -32712, -32731, -32746, -32758, -32764, -32767, -32767, -32764, -32758, -32746, -32731, -32712, -32691, -32665, -32636, -32602, -32564, -32524, -32479, -32431, -32378, -32322, -32262, -32199, -32132, -32061, -31985, -31905, -31763, -31510, -31165, -30749, -30274, -29753, -29195, -28607, -27999, -27372, -26731, -26081, -25424, -24760, -24093, -23425, -22754, -22085, -21414, -20743, -20075, -19407, -18740, -18076, -17412, -16751, -16093, -15436, -14778, -14124, -13471, -12819, -12170, -11519, -10872, -10225, -9579, -8913, -8344, -7051, -3879, -836};