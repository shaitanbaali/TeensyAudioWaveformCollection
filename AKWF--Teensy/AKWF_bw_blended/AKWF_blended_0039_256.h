/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0039 256 samples */
 
const int16_t AKWF_blended_0039_256_DATA [256] = 
{9367, 16601, 15618, 16254, 16641, 17024, 17407, 17787, 18166, 18544, 18919, 19292, 19663, 20030, 20394, 20755, 21113, 21467, 21817, 22162, 22504, 22841, 23174, 23501, 23823, 24141, 24452, 24757, 25057, 25352, 25638, 25919, 26195, 26463, 26723, 26977, 27224, 27463, 27694, 27918, 28135, 28343, 28543, 28736, 28919, 29095, 29262, 29421, 29570, 29710, 29843, 29966, 30080, 30185, 30280, 30368, 30444, 30512, 30571, 30620, 30662, 30650, 30571, 31494, 7629, -686, 1045, 700, 661, 616, 561, 497, 425, 342, 250, 149, 39, -80, -209, -346, -491, -646, -809, -981, -1162, -1350, -1547, -1751, -1965, -2186, -2414, -2649, -2894, -3145, -3402, -3666, -3940, -4217, -4502, -4794, -5091, -5394, -5703, -6017, -6337, -6663, -6993, -7328, -7668, -8011, -8359, -8713, -9068, -9427, -9791, -10156, -10526, -10898, -11271, -11649, -12027, -12406, -12789, -13171, -13557, -13900, -14186, -15483, 7996, 15918, 13783, 13716, 13334, 12953, 12569, 12188, 11810, 11431, 11056, 10684, 10313, 9946, 9582, 9220, 8864, 8509, 8158, 7814, 7471, 7134, 6802, 6474, 6152, 5836, 5524, 5219, 4919, 4624, 4337, 4057, 3781, 3513, 3253, 2999, 2752, 2513, 2281, 2058, 1840, 1632, 1432, 1240, 1056, 880, 713, 555, 406, 265, 132, 10, -104, -209, -305, -391, -468, -536, -596, -644, -682, -755, -876, 23, -23845, -32145, -30379, -30672, -30638, -30594, -30539, -30474, -30401, -30319, -30227, -30126, -30016, -29897, -29768, -29631, -29485, -29331, -29168, -28995, -28815, -28626, -28429, -28225, -28012, -27791, -27563, -27327, -27083, -26832, -26575, -26311, -26038, -25759, -25475, -25184, -24886, -24583, -24274, -23960, -23639, -23314, -22984, -22649, -22309, -21965, -21617, -21265, -20909, -20548, -20185, -19820, -19451, -19078, -18705, -18328, -17950, -17570, -17187, -16804, -16423, -16065, -15517, -15810};