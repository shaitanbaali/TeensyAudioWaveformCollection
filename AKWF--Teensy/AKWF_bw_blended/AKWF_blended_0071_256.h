/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0071 256 samples */
 
const int16_t AKWF_blended_0071_256_DATA [256] = 
{19351, 27091, 26188, 26894, 27347, 27802, 28257, 28711, 29166, 29620, 30074, 30529, 30984, 31430, 31648, 33541, 10089, 2734, 4936, 5080, 5534, 5989, 6443, 6898, 7352, 7806, 8262, 8716, 9169, 9624, 10079, 10533, 10988, 11442, 11896, 12352, 12805, 13259, 13714, 14169, 14623, 15078, 15532, 15986, 16441, 16895, 17350, 17805, 18259, 18713, 19168, 19622, 20077, 20531, 20985, 21440, 21895, 22348, 22804, 23258, 23712, 24048, 25084, 23398, -1877, -3563, -2526, -2190, -1736, -1282, -827, -373, 81, 536, 989, 1444, 1899, 2353, 2808, 3263, 3716, 4171, 4626, 5080, 5534, 5989, 6443, 6898, 7352, 7806, 8262, 8716, 9169, 9624, 10079, 10533, 10988, 11442, 11896, 12352, 12805, 13259, 13714, 14169, 14623, 15078, 15532, 15986, 16441, 16895, 17350, 17805, 18258, 18713, 19168, 19622, 20077, 20531, 20985, 21440, 21895, 22348, 22804, 23258, 23712, 24107, 24592, 25378, 3457, -4436, -2334, -2190, -1736, -1282, -827, -373, 81, 536, 989, 1444, 1899, 2345, 2563, 4456, -18995, -26349, -24147, -24004, -23549, -23094, -22640, -22185, -21731, -21277, -20822, -20368, -19914, -19459, -19004, -18551, -18096, -17641, -17187, -16732, -16278, -15824, -15368, -14915, -14461, -14006, -13551, -13097, -12642, -12188, -11734, -11278, -10825, -10370, -9916, -9461, -9007, -8553, -8099, -7643, -7189, -6736, -6280, -5826, -5372, -5036, -4000, -5685, -30960, -32647, -31610, -31274, -30820, -30366, -29910, -29457, -29003, -28548, -28094, -27639, -27184, -26731, -26276, -25821, -25367, -24912, -24458, -24004, -23549, -23094, -22640, -22185, -21731, -21277, -20822, -20368, -19914, -19459, -19004, -18550, -18095, -17641, -17187, -16732, -16278, -15824, -15368, -14915, -14461, -14006, -13551, -13097, -12642, -12188, -11734, -11278, -10825, -10370, -9916, -9461, -9007, -8553, -8099, -7643, -7189, -6736, -6280, -5826, -5372, -4918, -4465, -4002};