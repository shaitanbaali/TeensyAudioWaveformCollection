/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0053 256 samples */
 
const int16_t AKWF_blended_0053_256_DATA [256] = 
{245, 662, 1070, 1479, 1888, 2298, 2707, 3116, 3526, 3937, 4345, 4755, 5165, 5573, 5983, 6393, 6802, 7212, 7622, 8029, 8440, 8850, 9258, 9669, 10078, 10486, 10896, 11305, 11715, 12125, 12535, 12943, 13354, 13762, 14171, 14583, 14991, 15401, 15810, 16220, 16629, 17039, 17447, 17858, 18266, 18675, 19085, 19495, 19904, 20314, 20723, 21133, 21542, 21952, 22361, 22771, 23181, 23589, 24000, 24408, 24817, 25227, 25638, 26046, 26456, 26866, 27275, 27684, 28093, 28502, 28913, 29321, 29732, 30141, 30550, 30819, 31695, 30945, -25450, -34103, -31450, -31456, -31047, -30637, -30227, -29817, -29410, -29000, -28589, -28181, -27771, -27361, -26953, -26543, -26134, -25724, -25314, -24905, -24496, -24086, -23677, -23268, -22857, -22448, -22039, -21629, -21220, -20811, -20401, -19991, -19582, -19173, -18763, -18355, -17944, -17536, -17126, -16716, -16308, -15898, -15488, -15079, -14669, -14259, -13850, -13441, -13031, -12622, -12212, -11802, -11395, -10984, -10574, -10165, -9756, -9347, -8938, -8528, -8119, -7709, -7299, -6890, -6480, -6070, -5662, -5252, -4842, -4434, -4023, -3614, -3205, -2795, -2386, -1977, -1567, -1157, -749, -339, 70, 478, 889, 1298, 1707, 2117, 2526, 2936, 3346, 3755, 4164, 4574, 4983, 5393, 5802, 6212, 6621, 7031, 7438, 7849, 8259, 8668, 9077, 9487, 9896, 10306, 10715, 11125, 11535, 11943, 12353, 12763, 13172, 13581, 13992, 14401, 14810, 15219, 15629, 16039, 16448, 16857, 17267, 17675, 18085, 18494, 18905, 19303, 19387, 21772, -10649, -20964, -18156, -18173, -17763, -17353, -16945, -16535, -16126, -15717, -15308, -14897, -14488, -14078, -13669, -13260, -12850, -12441, -12031, -11622, -11212, -10803, -10393, -9984, -9575, -9165, -8756, -8347, -7936, -7529, -7118, -6708, -6300, -5890, -5480, -5071, -4662, -4252, -3843, -3433, -3023, -2614, -2205, -1795, -1387, -976, -570, -152};