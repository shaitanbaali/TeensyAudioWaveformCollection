/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0064 256 samples */
 
const int16_t AKWF_blended_0064_256_DATA [256] = 
{13873, 18012, 20576, 25547, 30362, 32753, 31675, 28042, 23857, 21101, 20506, 21387, 22346, 22213, 20704, 18445, 16428, 15345, 15254, 15637, 15819, 15394, 14420, 13295, 12464, 12139, 12216, 12392, 12376, 12059, 11548, 11053, 10753, 10690, 10762, 10817, 10746, 10541, 10277, 10060, 9952, 9941, 9963, 9951, 9871, 9738, 9596, 9494, 9444, 9427, 9415, 9379, 9309, 9223, 9144, 9087, 9054, 9033, 9010, 8971, 8919, 8867, 8819, 8787, 8764, 8747, 8723, 8695, 8665, 8633, 8608, 8593, 8581, 8569, 8559, 8545, 8529, 8520, 8515, 8512, 8511, 8515, 8515, 8517, 8521, 8530, 8539, 8549, 8567, 8581, 8598, 8618, 8639, 8660, 8685, 8710, 8733, 8757, 8781, 8806, 8828, 8853, 8878, 8902, 8925, 8950, 8974, 8996, 9020, 9045, 9067, 9089, 9114, 9136, 9156, 9179, 9202, 9222, 9243, 9264, 9285, 9302, 9321, 9339, 9358, 9377, 9395, 9412, 9426, 9444, 9457, 9471, 9485, 9500, 9512, 9443, 9688, 8536, -7766, -17876, -14329, -14255, -14489, -14130, -13981, -13829, -13662, -13512, -13370, -13233, -13101, -12977, -12858, -12744, -12637, -12534, -12438, -12346, -12260, -12178, -12100, -12029, -11960, -11895, -11837, -11782, -11728, -11680, -11636, -11596, -11558, -11523, -11494, -11465, -11440, -11418, -11397, -11378, -11361, -11346, -11330, -11315, -11303, -11293, -11283, -11275, -11270, -11263, -11258, -11256, -11254, -11255, -11256, -11258, -11262, -11267, -11274, -11280, -11289, -11300, -11310, -11321, -11335, -11350, -11364, -11382, -11401, -11419, -11440, -11461, -11484, -11507, -11532, -11557, -11583, -11611, -11640, -11671, -11700, -11733, -11767, -11799, -11833, -11871, -11908, -11945, -11985, -12023, -12064, -12106, -12150, -12192, -12235, -12282, -12328, -12374, -12422, -12472, -12521, -12571, -12624, -12675, -12728, -12782, -12837, -12891, -12948, -13006, -13062, -13114, -13183, -13238, -13296, -13287, -13757, -11907};