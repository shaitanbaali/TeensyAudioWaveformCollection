/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0057 256 samples */
 
const int16_t AKWF_blended_0057_256_DATA [256] = 
{128, 564, 990, 1418, 1845, 2272, 2700, 3127, 3554, 3983, 4410, 4839, 5266, 5693, 6122, 6549, 6976, 7405, 7832, 8259, 8688, 9115, 9543, 9971, 10398, 10825, 11254, 11680, 12108, 12537, 12964, 13392, 13820, 14247, 14675, 15103, 15530, 15958, 16386, 16814, 17242, 17669, 18096, 18525, 18952, 19380, 19807, 20235, 20663, 21091, 21518, 21946, 22373, 22801, 23229, 23656, 24084, 24512, 24939, 25367, 25795, 26222, 26650, 27078, 27507, 27933, 28359, 28788, 28511, 32768, 9389, -14477, -10215, -10509, -10073, -9644, -9218, -8791, -8363, -7935, -7508, -7080, -6651, -6224, -5797, -5369, -4942, -4513, -4086, -3659, -3230, -2804, -2376, -1947, -1520, -1093, -664, -237, 190, 618, 1045, 1472, 1901, 2327, 2706, 3272, 3448, -18606, -22085, -20701, -20450, -20021, -19594, -19167, -18738, -18312, -17884, -17455, -17028, -16601, -16172, -15746, -15317, -14889, -14463, -14035, -13606, -13179, -12751, -12323, -11896, -11468, -11040, -10613, -10185, -9757, -9330, -8902, -8474, -8047, -7618, -7192, -6764, -6335, -5909, -5481, -5052, -4626, -4198, -3770, -3343, -2914, -2487, -2060, -1632, -1204, -776, -348, 78, 505, 933, 1361, 1789, 2216, 2644, 3072, 3500, 3927, 4355, 4783, 5210, 5638, 6066, 6493, 6922, 7349, 7776, 8204, 8632, 9058, 9487, 9915, 10342, 10770, 11198, 11625, 12053, 12481, 12908, 13336, 13764, 14191, 14620, 15046, 15473, 15901, 15624, 19881, -3497, -27363, -23101, -23394, -22960, -22531, -22103, -21678, -21249, -20821, -20394, -19966, -19538, -19111, -18683, -18254, -17828, -17399, -16972, -16546, -16117, -15688, -15262, -14834, -14405, -13978, -13551, -13123, -12696, -12268, -11840, -11413, -10984, -10557, -10129, -9701, -9274, -8847, -8418, -7991, -7563, -7135, -6709, -6280, -5852, -5426, -4997, -4570, -4143, -3714, -3287, -2860, -2431, -2004, -1576, -1148, -723, -288};