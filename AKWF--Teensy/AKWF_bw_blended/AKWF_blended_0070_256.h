/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0070 256 samples */
 
const int16_t AKWF_blended_0070_256_DATA [256] = 
{448, 1190, 1919, 2649, 3378, 4107, 4838, 5568, 6298, 7028, 7758, 8488, 9219, 9947, 10678, 11409, 12138, 12868, 13599, 14328, 15059, 15789, 16517, 17249, 17979, 18708, 19439, 20170, 20899, 21629, 22359, 23089, 23820, 24549, 25279, 26010, 26739, 27469, 28200, 28929, 29660, 30390, 30492, 34623, 9049, -6724, -2739, -2607, -1878, -1148, -417, 311, 1041, 1772, 2500, 3232, 3962, 4691, 4784, 8951, -8475, -32668, -28373, -28305, -27574, -26845, -26116, -25384, -24654, -23925, -23194, -22465, -21735, -21004, -20275, -19544, -18814, -18085, -17354, -16623, -15895, -15164, -14434, -13705, -12974, -12244, -11515, -10784, -10054, -9325, -8594, -7864, -7134, -6403, -5674, -4944, -4214, -3484, -2754, -2023, -1293, -564, 166, 895, 1626, 2357, 2458, 6589, -18984, -34757, -30773, -30639, -29911, -29181, -28451, -27721, -26990, -26260, -25531, -24800, -24070, -23341, -22610, -21881, -21151, -20420, -19690, -18961, -18230, -17501, -16771, -16040, -15310, -14580, -13850, -13121, -12391, -11659, -10930, -10200, -9469, -8740, -8010, -7279, -6551, -5820, -5089, -4361, -3630, -2899, -2170, -1439, -709, 19, 750, 1480, 2209, 2940, 3670, 4399, 5130, 5859, 6590, 7321, 8050, 8779, 9511, 10240, 10970, 11701, 12430, 13160, 13891, 14620, 15351, 16082, 16810, 17541, 18271, 19001, 19731, 20461, 21190, 21922, 22652, 23380, 23474, 27641, 10214, -13980, -9684, -9616, -8886, -8157, -7426, -6695, -5966, -5237, -4505, -3776, -3045, -2315, -1586, -856, -125, 603, 1334, 2065, 2793, 3524, 4254, 4984, 5714, 6444, 7173, 7905, 8634, 9363, 10094, 10826, 11554, 12284, 13014, 13745, 14475, 15204, 15934, 16666, 17394, 18124, 18855, 19585, 20315, 21045, 21147, 25279, -296, -16068, -12083, -11951, -11222, -10492, -9761, -9032, -8302, -7571, -6843, -6111, -5381, -4653, -3922, -3191, -2462, -1733, -1005, -262};