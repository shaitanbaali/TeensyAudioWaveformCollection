/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0008 256 samples */
 
const int16_t AKWF_blended_0008_256_DATA [256] = 
{1923, 7009, 12212, 16455, 18721, 20700, 22566, 24282, 25867, 27307, 28566, 29607, 30324, 30722, 31042, 31334, 31589, 31819, 32020, 32199, 32354, 32487, 32597, 32682, 32739, 32767, 32760, 32709, 32607, 32441, 32201, 31865, 31413, 30815, 30062, 29255, 28451, 27642, 26830, 26022, 25212, 24403, 23600, 22797, 21998, 21208, 20422, 19644, 18875, 18115, 17368, 16631, 16105, 15890, 15875, 15993, 16195, 16450, 16739, 17045, 17360, 17680, 17999, 18316, 18634, 18944, 19250, 19553, 19842, 20118, 20374, 20593, 20761, 20849, 20816, 20601, 20099, 19313, 18467, 17609, 16732, 15841, 14932, 14014, 13079, 12133, 11179, 10210, 9235, 8251, 7257, 6259, 5258, 4248, 3237, 2223, 1205, 192, -824, -1840, -2850, -3857, -4860, -5855, -6843, -7825, -8789, -9745, -10684, -11604, -12508, -13388, -14238, -15059, -15844, -16587, -17085, -17229, -17124, -16826, -16372, -15780, -15044, -14161, -13164, -10477, -6367, -2425, 1448, 5357, 9484, 12647, 13826, 14714, 15489, 16115, 16606, 16949, 17115, 17054, 16673, 15973, 15193, 14383, 13541, 12667, 11770, 10855, 9921, 8969, 8007, 7031, 6044, 5052, 4050, 3044, 2036, 1020, 6, -1007, -2025, -3038, -4050, -5060, -6062, -7062, -8056, -9042, -10020, -10990, -11947, -12897, -13835, -14757, -15669, -16564, -17445, -18308, -19155, -19980, -20590, -20879, -20962, -20907, -20759, -20554, -20306, -20035, -19748, -19448, -19142, -18833, -18515, -18197, -17877, -17555, -17238, -16928, -16629, -16362, -16139, -15989, -15955, -16092, -16511, -17211, -17957, -18712, -19476, -20250, -21032, -21818, -22614, -23414, -24214, -25022, -25829, -26636, -27445, -28254, -29057, -29862, -30614, -31213, -31667, -32001, -32242, -32409, -32512, -32566, -32575, -32549, -32496, -32412, -32307, -32178, -32028, -31855, -31659, -31436, -31189, -30907, -30592, -30238, -29636, -28680, -27481, -26087, -24541, -22857, -21029, -19057, -16971, -13205, -8019, -2900};