/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0017 256 samples */
 
const int16_t AKWF_blended_0017_256_DATA [256] = 
{2775, 5922, 6566, 7674, 8708, 9744, 10782, 11816, 12851, 13887, 14919, 15953, 16987, 18019, 19036, 20139, 20517, 19914, 19363, 18804, 18240, 17676, 17112, 16545, 15979, 15411, 14842, 14272, 13700, 13126, 12554, 11979, 11401, 10824, 10244, 9662, 9081, 8496, 7910, 7325, 6736, 6144, 5553, 4959, 4363, 3766, 3183, 2510, 2558, 3587, 4563, 5541, 6522, 7501, 8475, 9451, 10424, 11392, 12362, 13329, 14292, 15256, 16217, 17175, 18132, 19087, 20039, 20991, 21939, 22886, 23832, 24774, 25717, 26656, 27591, 28528, 29462, 30392, 31306, 32307, 32582, 31873, 31214, 30549, 29877, 29204, 28529, 27854, 27176, 26497, 25814, 25133, 24450, 23763, 23076, 22387, 21698, 21007, 20314, 19619, 18925, 18229, 17530, 16832, 16132, 15430, 14729, 14026, 13321, 12617, 11928, 11149, 11091, 12016, 12889, 13767, 14648, 15527, 16405, 17284, 18163, 19039, 19917, 20794, 21670, 22361, 24072, 22005, -20104, -24668, -22492, -21873, -20997, -20121, -19243, -18366, -17488, -16609, -15731, -14852, -13971, -13093, -12228, -11274, -11042, -11791, -12489, -13192, -13897, -14601, -15302, -16005, -16705, -17404, -18102, -18800, -19495, -20190, -20883, -21573, -22265, -22954, -23641, -24328, -25012, -25696, -26378, -27057, -27736, -28413, -29088, -29760, -30433, -31102, -31755, -32493, -32508, -31538, -30617, -29689, -28756, -27820, -26886, -25946, -25005, -24064, -23119, -22173, -21226, -20275, -19322, -18370, -17412, -16456, -15495, -14533, -13571, -12604, -11635, -10668, -9695, -8720, -7747, -6768, -5789, -4810, -3843, -2785, -2449, -3093, -3685, -4280, -4877, -5472, -6064, -6655, -7245, -7832, -8419, -9004, -9586, -10168, -10748, -11326, -11905, -12479, -13054, -13628, -14200, -14770, -15340, -15908, -16475, -17043, -17606, -18170, -18734, -19296, -19842, -20473, -20384, -19309, -18286, -17257, -16223, -15190, -14158, -13122, -12087, -11052, -10016, -8980, -7946, -6909, -5876, -4823};