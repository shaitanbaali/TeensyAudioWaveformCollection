/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0032 256 samples */
 
const int16_t AKWF_blended_0032_256_DATA [256] = 
{178, 589, 992, 1396, 1800, 2205, 2610, 3013, 3418, 3822, 4226, 4630, 5034, 5525, 5453, 7901, 18457, 19004, 19340, 19768, 20173, 20577, 20980, 21386, 21790, 22193, 22598, 23003, 23406, 23811, 24215, 24619, 25024, 25428, 25832, 26237, 26640, 27045, 27450, 27854, 28258, 28663, 29067, 29472, 29876, 30166, 31171, 29092, 12797, 12292, 12958, 13300, 13705, 14110, 14514, 14918, 15322, 15726, 16131, 16535, 16939, 17344, 17748, 18152, 18558, 18960, 19365, 19771, 20173, 20578, 20982, 21386, 21791, 22196, 22600, 23004, 23409, 23282, 26671, 13735, -26700, -23838, -23838, -23448, -23043, -22639, -22234, -21830, -21427, -21022, -20618, -20213, -19810, -19404, -19000, -18596, -18192, -17788, -17383, -16979, -16575, -16171, -15766, -15363, -14958, -14553, -14149, -13745, -13341, -13050, -12045, -14124, -30418, -30923, -30256, -29914, -29511, -29106, -28702, -28297, -27893, -27489, -27084, -26680, -26276, -25872, -25467, -25063, -24659, -24254, -23850, -23445, -23042, -22637, -22233, -21829, -21425, -21020, -20616, -20212, -19807, -19317, -19390, -16941, -6385, -5839, -5504, -5075, -4670, -4266, -3862, -3457, -3054, -2650, -2244, -1840, -1437, -1032, -628, -223, 180, 584, 988, 1393, 1797, 2201, 2606, 3010, 3414, 3819, 4222, 4628, 5033, 5322, 6326, 4248, -12046, -12551, -11884, -11542, -11138, -10733, -10329, -9924, -9520, -9116, -8711, -8307, -7903, -7499, -7095, -6691, -6285, -5882, -5477, -5073, -4669, -4265, -3860, -3456, -3052, -2647, -2244, -1838, -1434, -1030, -626, -222, 181, 586, 991, 1394, 1799, 2204, 2607, 3012, 3416, 3820, 4225, 4629, 5033, 5438, 5842, 6245, 6650, 7054, 7459, 7863, 8267, 8672, 9077, 9480, 9885, 10289, 10693, 11098, 11503, 11793, 12797, 10718, -5576, -6080, -5413, -5072, -4668, -4263, -3858, -3454, -3049, -2646, -2241, -1837, -1434, -1029, -627, -215};