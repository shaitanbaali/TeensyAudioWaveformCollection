/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0079 256 samples */
 
const int16_t AKWF_blended_0079_256_DATA [256] = 
{30286, 31723, 30654, 30096, 29463, 28826, 28189, 27554, 26918, 26280, 25645, 25009, 24372, 23736, 23100, 22463, 21829, 21192, 20554, 19919, 19282, 18646, 18011, 17373, 16738, 16103, 15466, 14826, 14342, 13953, 13551, 13152, 12752, 12353, 11952, 11561, 11096, 10464, 9826, 9191, 8554, 7917, 7283, 6647, 6008, 5565, 5230, 4878, 4530, 4181, 3832, 3484, 3134, 2787, 2438, 2088, 1740, 1392, 1043, 695, 346, 49, -506, -104, 10687, 12101, 11336, 11068, 10721, 10372, 10023, 9675, 9326, 8978, 8630, 8281, 7932, 7583, 7235, 6886, 6537, 6187, 5849, 5354, 4705, 4071, 3437, 2800, 2163, 1528, 891, 252, -231, -621, -1022, -1422, -1822, -2221, -2622, -3012, -3477, -4110, -4748, -5381, -6019, -6656, -7290, -7928, -8565, -9199, -9836, -10473, -11108, -11744, -12385, -12964, -13483, -14009, -14533, -15058, -15582, -16106, -16632, -17155, -17679, -17941, -19743, -14391, 16783, 19275, 17984, 17641, 17118, 16594, 16068, 15544, 15020, 14495, 13971, 13451, 12886, 12248, 11612, 10975, 10340, 9703, 9067, 8431, 7794, 7158, 6522, 5885, 5249, 4614, 3977, 3338, 2854, 2464, 2062, 1664, 1263, 864, 463, 73, -390, -1023, -1662, -2296, -2933, -3570, -4204, -4841, -5480, -5922, -6258, -6609, -6958, -7306, -7655, -8003, -8353, -8701, -9048, -9398, -9747, -10095, -10444, -10792, -11140, -11439, -11994, -11591, -801, 612, -152, -418, -766, -1115, -1464, -1812, -2161, -2510, -2858, -3206, -3554, -3903, -4252, -4601, -4949, -5300, -5638, -6132, -6782, -7415, -8050, -8687, -9324, -9959, -10595, -11236, -11720, -12109, -12510, -12909, -13310, -13709, -14110, -14500, -14965, -15597, -16235, -16870, -17506, -18143, -18778, -19415, -20052, -20688, -21324, -21961, -22596, -23233, -23870, -24505, -25142, -25778, -26413, -27050, -27686, -28322, -28959, -29595, -30217, -30672, -32433, -17545};