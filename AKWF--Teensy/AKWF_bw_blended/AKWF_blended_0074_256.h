/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0074 256 samples */
 
const int16_t AKWF_blended_0074_256_DATA [256] = 
{230, 777, 1330, 1891, 2366, 2884, 3387, 3883, 4373, 4855, 5330, 5798, 6258, 6710, 7157, 7596, 8027, 8453, 8871, 9281, 9612, 10435, 7605, 4870, 5930, 6247, 6692, 7119, 7534, 7940, 8338, 8726, 9106, 9477, 9839, 10194, 10542, 10883, 11217, 11541, 11861, 12174, 12481, 12783, 13079, 13370, 13656, 13936, 14212, 14482, 14747, 15008, 15265, 15515, 15761, 16003, 16240, 16472, 16699, 16922, 17140, 17354, 17563, 17769, 17968, 18164, 18356, 18542, 18725, 18904, 19078, 19249, 19416, 19578, 19737, 19893, 20044, 20192, 20335, 20465, 20159, 22772, 2132, -14509, -10980, -10565, -9683, -8811, -7947, -7095, -6249, -5413, -4588, -3769, -2960, -2161, -1368, -586, 186, 953, 1708, 2455, 3196, 3926, 4649, 5364, 6070, 6769, 7463, 8145, 8821, 9490, 10151, 10805, 11452, 12090, 12723, 13348, 13966, 14576, 15181, 15777, 16368, 16931, 17486, 18213, 11670, 1625, -3238, -5659, -6956, -7700, -8235, -8544, -8763, -8908, -8998, -9042, -9047, -9020, -8961, -8874, -8764, -8632, -8482, -8312, -8130, -7937, -7802, -7159, -10153, -13040, -12118, -11928, -11598, -11278, -10958, -10640, -10324, -10011, -9700, -9389, -9083, -8780, -8479, -8182, -7889, -7601, -7314, -7032, -6753, -6476, -6203, -5934, -5668, -5406, -5146, -4890, -4639, -4392, -4147, -3906, -3670, -3437, -3208, -2983, -2762, -2546, -2333, -2124, -1920, -1718, -1522, -1331, -1143, -960, -779, -603, -432, -262, -98, 62, 221, 373, 524, 669, 812, 942, 634, 3246, -17394, -34035, -30506, -30093, -29212, -28339, -27476, -26624, -25780, -24944, -24119, -23301, -22492, -21693, -20901, -20119, -19346, -18580, -17824, -17077, -16337, -15607, -14884, -14168, -13463, -12763, -12070, -11388, -10711, -10044, -9382, -8728, -8082, -7443, -6811, -6185, -5569, -4957, -4354, -3757, -3166, -2582, -2006, -1435, -872, -305};