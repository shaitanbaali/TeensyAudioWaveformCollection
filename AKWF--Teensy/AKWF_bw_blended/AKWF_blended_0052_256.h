/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_blended_0052 256 samples */
 
const int16_t AKWF_blended_0052_256_DATA [256] = 
{126, 502, 872, 1243, 1614, 1984, 2355, 2726, 3096, 3467, 3837, 4209, 4579, 4949, 5321, 5691, 6062, 6433, 6804, 7174, 7544, 7917, 8286, 8658, 9028, 9398, 9770, 10140, 10511, 10882, 11253, 11623, 11994, 12365, 12734, 13106, 13476, 13847, 14218, 14588, 14960, 15331, 15701, 16071, 16443, 16813, 17184, 17555, 17926, 18297, 18667, 19038, 19409, 19779, 20150, 20522, 20891, 21261, 21633, 22003, 22374, 22745, 23116, 23486, 23857, 24228, 24598, 24970, 25340, 25711, 26082, 26452, 26823, 27194, 27565, 27935, 28306, 28676, 29046, 29419, 29788, 30159, 30530, 30900, 31272, 31642, 31304, 35642, 17774, -28691, -24579, -24867, -24500, -24129, -23759, -23388, -23017, -22646, -22276, -21904, -21534, -21164, -20793, -20423, -20052, -19681, -19311, -18939, -18568, -18198, -17827, -17456, -17086, -16715, -16344, -15973, -15602, -15232, -14861, -14490, -14119, -13750, -13379, -13008, -12637, -12267, -11896, -11525, -11154, -10784, -10413, -10042, -9672, -9301, -8929, -8559, -8188, -7817, -7448, -7076, -6705, -6334, -5964, -5592, -5224, -4853, -4481, -4111, -3740, -3369, -2999, -2628, -2258, -1886, -1515, -1145, -775, -403, -33, 336, 709, 1079, 1450, 1820, 2190, 2561, 2932, 3303, 3674, 4044, 4415, 4785, 5157, 5527, 5898, 6269, 6639, 7010, 7381, 7752, 8123, 8494, 8863, 9235, 9606, 9975, 10347, 10719, 11087, 10832, 14577, -3151, -26432, -22575, -22854, -22481, -22112, -21741, -21369, -20999, -20629, -20258, -19888, -19517, -19145, -18776, -18405, -18033, -17663, -17293, -16922, -16552, -16180, -15810, -15439, -15068, -14697, -14327, -13956, -13585, -13215, -12843, -12473, -12102, -11732, -11362, -10990, -10619, -10249, -9879, -9507, -9137, -8767, -8394, -8025, -7654, -7283, -6913, -6542, -6171, -5800, -5429, -5058, -4688, -4317, -3946, -3577, -3205, -2834, -2464, -2093, -1723, -1352, -981, -612, -235};