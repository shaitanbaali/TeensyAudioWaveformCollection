/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0160 256 samples */
 
const int16_t AKWF_0160_256_DATA [256] = 
{327, 1117, 2185, 3447, 4836, 6326, 7881, 9455, 11027, 12569, 14050, 15425, 16746, 17973, 19111, 20154, 21089, 21943, 22722, 23409, 24041, 24622, 25139, 25610, 26051, 26445, 26816, 27178, 27528, 27841, 28142, 28447, 28719, 28983, 29255, 29506, 29730, 29971, 30196, 30387, 30591, 30800, 30982, 31145, 31324, 31490, 31621, 31766, 31907, 32009, 32127, 32240, 32320, 32397, 32487, 32557, 32595, 32652, 32703, 32717, 32733, 32759, 32757, 32732, 32727, 32708, 32652, 32608, 32568, 32495, 32408, 32341, 32238, 32124, 32027, 31910, 31758, 31626, 31490, 31317, 31144, 30981, 30794, 30579, 30385, 30181, 29937, 29702, 29472, 29207, 28921, 28646, 28350, 28007, 27660, 27290, 26859, 26396, 25912, 25365, 24747, 24100, 23394, 22601, 21756, 20868, 19914, 18870, 17792, 16659, 15452, 14224, 12975, 11681, 10376, 9093, 7811, 6541, 5327, 4190, 3113, 2091, 1184, 434, -204, -980, -1881, -2870, -3930, -5031, -6170, -7338, -8497, -9642, -10807, -11947, -13064, -14145, -15186, -16192, -17149, -18051, -18917, -19736, -20492, -21214, -21875, -22492, -23078, -23637, -24157, -24624, -25076, -25502, -25883, -26237, -26586, -26889, -27174, -27454, -27695, -27911, -28135, -28343, -28511, -28676, -28841, -28976, -29086, -29208, -29313, -29380, -29456, -29523, -29547, -29587, -29623, -29624, -29614, -29614, -29591, -29535, -29494, -29442, -29352, -29260, -29176, -29060, -28900, -29985, -30438, -30984, -31237, -31366, -31424, -31319, -31163, -30994, -30854, -30758, -30656, -30524, -30413, -30299, -30147, -29991, -29845, -29680, -29498, -29355, -29226, -29085, -28978, -28896, -28799, -28691, -28597, -28482, -28320, -28162, -27992, -27779, -27554, -27340, -27104, -26839, -26596, -26349, -26062, -25770, -25475, -25137, -24757, -24366, -23929, -23415, -22867, -22267, -21577, -20811, -19991, -19091, -18071, -16985, -15810, -14526, -13173, -11760, -10281, -8756, -7232, -5720, -4238, -2840, -1585, -494};