/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0142 256 samples */
 
const int16_t AKWF_0142_256_DATA [256] = 
{1009, 2738, 4415, 6073, 7697, 9282, 10821, 12304, 13733, 15101, 16402, 17640, 18812, 19912, 20948, 21915, 22814, 23650, 24423, 25131, 25783, 26378, 26917, 27406, 27845, 28237, 28586, 28895, 29164, 29399, 29600, 29770, 29912, 30028, 30119, 30189, 30239, 30270, 30284, 30284, 30269, 30243, 30205, 30158, 30102, 30037, 29966, 29889, 29807, 29720, 29628, 29533, 29435, 29334, 29231, 29125, 29018, 28909, 28799, 28687, 28574, 28460, 28345, 28230, 28112, 27994, 27875, 27755, 27634, 27511, 27387, 27262, 27136, 27008, 26879, 26748, 26615, 26481, 26345, 26207, 26067, 25926, 25782, 25637, 25489, 25339, 25187, 25033, 24877, 24719, 24559, 24397, 24233, 24067, 23899, 23729, 23558, 23384, 23209, 23032, 22854, 22674, 22492, 22310, 22126, 21940, 21754, 21567, 21376, 21163, 20874, 20446, 19858, 19149, 18376, 17554, 16647, 15620, 14463, 13188, 11824, 10388, 8885, 7323, 5712, 4054, 2371, 672, -1035, -2731, -4413, -6074, -7698, -9282, -10822, -12305, -13733, -15102, -16403, -17641, -18812, -19913, -20948, -21916, -22814, -23651, -24423, -25132, -25784, -26378, -26917, -27406, -27845, -28237, -28587, -28895, -29165, -29399, -29600, -29770, -29912, -30028, -30120, -30189, -30239, -30270, -30285, -30284, -30270, -30243, -30205, -30158, -30102, -30038, -29967, -29889, -29807, -29720, -29629, -29534, -29436, -29334, -29231, -29126, -29019, -28910, -28799, -28688, -28575, -28461, -28346, -28230, -28113, -27995, -27876, -27755, -27634, -27512, -27388, -27263, -27137, -27008, -26880, -26748, -26616, -26482, -26346, -26208, -26068, -25926, -25783, -25637, -25489, -25339, -25188, -25034, -24878, -24720, -24560, -24398, -24234, -24067, -23900, -23730, -23558, -23385, -23210, -23033, -22855, -22675, -22493, -22311, -22127, -21941, -21755, -21568, -21377, -21164, -20875, -20446, -19859, -19150, -18376, -17555, -16648, -15621, -14464, -13189, -11825, -10389, -8886, -7324, -5713, -4058, -2379, -650};