/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0111 256 samples */
 
const int16_t AKWF_0111_256_DATA [256] = 
{-2127, -9044, -14582, -19020, -22483, -25142, -27157, -28661, -29778, -30602, -31204, -31643, -31961, -32190, -32355, -32474, -32558, -32618, -32661, -32691, -32713, -32728, -32739, -32746, -32752, -32756, -32758, -32760, -32761, -32762, -32763, -32764, -32764, -32764, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32764, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32764, -32744, -32802, -32038, -28436, -22130, -14053, -5599, 2249, 9003, 14568, 19019, 22483, 25142, 27157, 28660, 29778, 30603, 31204, 31643, 31961, 32190, 32355, 32474, 32558, 32618, 32661, 32691, 32713, 32728, 32739, 32747, 32751, 32756, 32758, 32760, 32761, 32762, 32763, 32764, 32764, 32764, 32764, 32764, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32764, 32765, 32764, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32764, 32744, 32802, 32038, 28436, 22143, 14081, 5500};