/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0155 256 samples */
 
const int16_t AKWF_0155_256_DATA [256] = 
{2402, 7322, 12596, 17374, 20938, 22935, 23431, 22850, 21803, 20863, 20381, 20390, 20642, 20745, 20354, 19348, 17919, 16535, 15805, 16261, 18159, 21336, 25222, 28988, 31738, 32797, 31903, 29282, 25579, 21662, 18386, 16323, 15621, 16007, 16890, 17598, 17597, 16679, 15015, 13088, 11504, 10785, 11177, 12571, 14534, 16464, 17812, 18251, 17807, 16833, 15883, 15500, 16012, 17391, 19235, 20894, 21666, 21049, 18913, 15589, 11781, 8360, 6144, 5611, 6787, 9221, 12140, 14670, 16085, 16015, 14517, 12016, 9131, 6458, 4391, 2989, 2032, 1138, -55, -1694, -3616, -5388, -6413, -6164, -4374, -1190, 2832, 6866, 9996, 11515, 11117, 8980, 5713, 2166, -812, -2636, -3138, -2577, -1535, -698, -617, -1529, -3286, -5411, -7294, -8385, -8399, -7407, -5810, -4192, -3106, -2890, -3542, -4723, -5886, -6475, -6138, -4872, -3048, -1300, -330, -661, -2448, -5396, -8828, -11881, -13739, -13904, -12333, -9462, -6062, -3026, -1114, -734, -1871, -4122, -6883, -9544, -11692, -13240, -14390, -15511, -16977, -18946, -21275, -23546, -25158, -25562, -24460, -21945, -18532, -15017, -12295, -11074, -11673, -13931, -17249, -20775, -23641, -25234, -25351, -24225, -22424, -20638, -19448, -19118, -19534, -20252, -20663, -20217, -18619, -15920, -12517, -9010, -5970, -3785, -2501, -1816, -1218, -164, 1710, 4421, 7610, 10663, 12866, 13681, 12930, 10877, 8185, 5719, 4310, 4491, 6347, 9477, 13130, 16426, 18590, 19197, 18244, 16120, 13437, 10823, 8723, 7255, 6241, 5318, 4107, 2420, 367, -1658, -3078, -3342, -2140, 454, 3942, 7538, 10339, 11609, 10991, 8609, 5030, 1087, -2348, -4641, -5566, -5328, -4481, -3715, -3616, -4475, -6189, -8315, -10234, -11366, -11363, -10239, -8346, -6253, -4535, -3576, -3443, -3849, -4279, -4177, -3158, -1170, 1467, 4150, 6176, 6987, 6379, 4580, 2223, 156, -802, -2};