/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0148 256 samples */
 
const int16_t AKWF_0148_256_DATA [256] = 
{-55, 215, 609, 833, 1241, 1840, 2510, 3242, 3599, 3974, 4736, 5296, 5613, 6089, 6641, 7267, 7807, 8179, 8568, 8500, 7994, 7459, 6914, 6215, 5127, 3814, 2585, 1683, 1151, 994, 912, 778, 869, 1325, 1989, 2962, 3774, 4365, 4720, 4816, 4928, 5561, 6207, 6491, 6996, 8027, 9072, 10322, 11683, 13033, 14588, 16067, 17496, 18874, 19905, 20506, 20782, 20728, 20646, 20317, 19368, 18416, 17279, 15713, 14042, 12389, 10711, 8942, 7339, 5734, 4325, 3184, 2038, 810, -335, -1353, -2062, -2201, -1739, -1117, -391, 540, 1505, 2641, 3717, 4757, 5778, 6499, 7117, 8154, 9556, 11294, 13370, 15387, 17587, 20182, 23086, 26141, 28994, 31080, 32179, 32623, 32719, 31935, 30398, 27898, 24140, 19534, 14560, 9465, 4133, -1036, -5772, -10302, -14608, -18813, -22804, -25845, -27842, -28889, -29612, -29844, -29617, -28828, -27643, -26227, -24189, -21838, -19442, -16701, -13546, -10111, -6608, -2761, 1352, 5188, 8867, 12718, 16544, 19826, 22174, 23670, 24614, 24895, 24636, 24151, 23289, 21947, 20070, 17865, 15376, 12493, 9110, 5171, 732, -3829, -7803, -11548, -15157, -18248, -20938, -23591, -25839, -27484, -28655, -29415, -29901, -29607, -28325, -26298, -23968, -21356, -18115, -14516, -11141, -8193, -5440, -2500, 441, 2748, 4614, 6473, 8011, 8912, 9538, 10266, 10670, 10691, 10808, 11103, 11513, 11898, 11973, 11507, 10506, 9449, 8391, 6973, 4731, 1951, -817, -3422, -6047, -9103, -12184, -14987, -17531, -20099, -22500, -24805, -26979, -28829, -29996, -30409, -30059, -29673, -29279, -28580, -27937, -27258, -26341, -25302, -24221, -23154, -22173, -21445, -20548, -19309, -17633, -15777, -14016, -11936, -9591, -7500, -5804, -4349, -3278, -2479, -2031, -1551, -827, -314, -39, 114, 8, -180, -229, -133, -99, 46, 90, -46, -143, -73, 70, 71};