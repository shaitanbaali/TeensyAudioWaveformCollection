/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0176 256 samples */
 
const int16_t AKWF_0176_256_DATA [256] = 
{420, 1214, 1993, 2774, 3554, 4335, 5120, 5652, 6027, 6422, 6812, 7203, 7594, 7984, 8375, 8765, 9156, 9547, 9937, 10333, 10698, 11207, 12002, 12781, 13563, 14343, 15126, 15906, 16687, 17469, 18250, 19030, 19813, 20591, 21385, 21971, 22348, 22741, 23133, 23523, 23914, 24305, 24695, 25086, 25477, 25867, 26259, 26637, 27094, 27330, 27298, 27305, 27304, 27305, 27304, 27304, 27305, 27305, 27304, 27305, 27304, 27305, 27304, 27305, 27304, 27304, 27305, 27304, 27305, 27304, 27305, 27305, 27305, 27305, 27304, 27300, 27320, 27130, 26719, 26333, 25943, 25551, 25161, 24771, 24380, 23989, 23598, 23207, 22817, 22425, 22041, 21685, 21294, 20903, 20512, 20122, 19731, 19340, 18950, 18559, 18169, 17778, 17384, 17006, 16548, 15797, 15011, 14231, 13449, 12670, 11887, 11105, 10326, 9543, 8761, 7981, 7200, 6412, 5668, 4940, 4151, 3373, 2590, 1808, 1029, 246, -535, -1315, -2098, -2879, -3658, -4447, -5198, -5920, -6708, -7487, -8269, -9051, -9831, -10612, -11395, -12174, -12956, -13738, -14518, -15304, -16064, -16780, -17566, -18347, -19127, -19909, -20691, -21471, -22253, -23034, -23815, -24597, -25377, -26157, -26945, -27487, -27861, -28255, -28645, -29036, -29428, -29818, -30208, -30599, -30989, -31380, -31772, -32150, -32614, -32789, -32759, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32762, -32777, -32539, -32128, -31742, -31351, -30960, -30570, -30180, -29788, -29399, -29008, -28617, -28227, -27833, -27455, -27096, -26702, -26312, -25922, -25531, -25141, -24750, -24358, -23969, -23578, -23187, -22793, -22418, -21923, -21152, -20369, -19588, -18808, -18026, -17243, -16464, -15682, -14900, -14120, -13338, -12557, -11770, -11035, -10298, -9510, -8729, -7948, -7167, -6385, -5604, -4812, -4084, -3079, -430};