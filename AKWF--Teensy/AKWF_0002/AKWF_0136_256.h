/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0136 256 samples */
 
const int16_t AKWF_0136_256_DATA [256] = 
{1133, 3187, 5402, 7765, 10161, 12514, 14794, 16990, 19107, 21126, 23014, 24757, 26334, 27733, 28959, 30008, 30876, 31574, 32103, 32469, 32687, 32767, 32719, 32558, 32295, 31944, 31517, 31025, 30482, 29896, 29281, 28643, 27990, 27331, 26674, 26021, 25381, 24754, 24146, 23561, 22997, 22457, 21946, 21459, 20998, 20566, 20157, 19775, 19418, 19083, 18772, 18483, 18213, 17962, 17730, 17513, 17313, 17126, 16952, 16791, 16641, 16501, 16369, 16244, 16128, 16018, 15913, 15812, 15716, 15624, 15534, 15446, 15361, 15277, 15193, 15110, 15026, 14944, 14859, 14774, 14688, 14601, 14512, 14421, 14329, 14234, 14137, 14038, 13937, 13834, 13729, 13621, 13511, 13399, 13285, 13169, 13051, 12931, 12809, 12685, 12560, 12434, 12306, 12177, 12047, 11916, 11784, 11652, 11519, 11385, 11252, 11118, 10984, 10850, 10716, 10583, 10450, 10317, 10185, 10048, 9842, 9414, 8615, 7434, 5958, 4284, 2518, 716, -1158, -3179, -5398, -7764, -10161, -12513, -14794, -16990, -19106, -21125, -23014, -24757, -26334, -27733, -28959, -30007, -30876, -31574, -32102, -32469, -32688, -32766, -32719, -32558, -32295, -31945, -31517, -31025, -30483, -29897, -29281, -28643, -27990, -27332, -26674, -26022, -25381, -24755, -24147, -23561, -22997, -22458, -21946, -21459, -20999, -20566, -20158, -19775, -19419, -19084, -18773, -18483, -18213, -17963, -17730, -17514, -17313, -17127, -16953, -16792, -16641, -16501, -16369, -16245, -16128, -16018, -15913, -15813, -15717, -15624, -15535, -15447, -15361, -15277, -15193, -15110, -15027, -14944, -14859, -14775, -14688, -14602, -14513, -14422, -14330, -14235, -14138, -14039, -13938, -13835, -13730, -13622, -13512, -13400, -13286, -13170, -13051, -12931, -12809, -12686, -12561, -12434, -12307, -12178, -12047, -11917, -11785, -11652, -11519, -11386, -11252, -11118, -10985, -10851, -10717, -10584, -10451, -10318, -10185, -10048, -9842, -9414, -8616, -7435, -5958, -4287, -2528, -690};