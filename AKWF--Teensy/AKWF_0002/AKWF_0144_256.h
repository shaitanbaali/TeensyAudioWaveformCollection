/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0144 256 samples */
 
const int16_t AKWF_0144_256_DATA [256] = 
{240, 920, 1567, 2198, 2809, 3403, 3979, 4536, 5073, 5594, 6094, 6578, 7043, 7489, 7918, 8330, 8723, 9101, 9461, 9803, 10130, 10440, 10733, 11012, 11274, 11521, 11753, 11970, 12171, 12361, 12539, 12709, 12870, 13023, 13171, 13315, 13457, 13600, 13743, 13888, 14038, 14193, 14353, 14521, 14696, 14878, 15069, 15267, 15473, 15687, 15909, 16136, 16370, 16610, 16854, 17103, 17354, 17607, 17861, 18116, 18370, 18624, 18874, 19123, 19368, 19610, 19849, 20084, 20316, 20546, 20777, 21010, 21249, 21506, 21799, 22116, 23064, 24290, 24719, 25222, 25834, 26464, 27055, 27567, 27985, 28298, 28503, 28605, 28604, 28510, 28325, 28057, 27714, 27299, 26820, 26283, 25693, 25056, 24376, 23656, 22905, 22124, 21316, 20490, 19643, 18780, 17908, 17026, 16136, 15245, 14350, 13455, 12566, 11679, 10797, 9925, 9060, 8206, 7364, 6533, 5716, 4915, 4127, 3355, 2600, 1861, 1140, 436, -250, -918, -1567, -2198, -2811, -3404, -3980, -4536, -5074, -5595, -6095, -6579, -7044, -7490, -7919, -8331, -8724, -9101, -9461, -9804, -10130, -10440, -10734, -11012, -11275, -11522, -11753, -11970, -12172, -12361, -12540, -12709, -12871, -13024, -13171, -13316, -13458, -13600, -13743, -13889, -14039, -14194, -14354, -14522, -14696, -14879, -15069, -15268, -15473, -15688, -15909, -16136, -16371, -16611, -16854, -17103, -17354, -17607, -17862, -18117, -18370, -18624, -18875, -19123, -19369, -19611, -19849, -20084, -20316, -20546, -20778, -21009, -21250, -21507, -21800, -22116, -23064, -24290, -24719, -25222, -25834, -26464, -27055, -27567, -27985, -28298, -28504, -28604, -28604, -28510, -28325, -28057, -27714, -27299, -26820, -26283, -25693, -25056, -24376, -23656, -22905, -22125, -21317, -20490, -19643, -18781, -17909, -17026, -16137, -15246, -14350, -13456, -12567, -11679, -10797, -9926, -9061, -8206, -7365, -6534, -5717, -4916, -4127, -3356, -2601, -1863, -1144, -428};