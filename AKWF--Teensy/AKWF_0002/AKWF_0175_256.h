/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0175 256 samples */
 
const int16_t AKWF_0175_256_DATA [256] = 
{10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 11122, 10051, 16609, 22707, 21645, 21844, 21844, 21844, 21843, 21844, 21843, 21844, 21844, 21402, 23848, 12265, -12943, -10478, -10922, -10922, -10923, -10923, -10923, -10923, -10922, -10922, -10922, -10923, -10923, -10922, -10923, -10923, -10923, -10922, -10744, -11714, -6730, 825, -188, -1, 0, -1, -1, -1, 0, 0, -1, 0, -1, 0, -1, -1, 0, 0, -1, 0, -1, 0, -1, 0, -1, 70, -309, 1217, 10781, 10977, 10898, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10350, 13436, -8826, -24259, -21296, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21760, -22222, -20297, -10856, -10919, -10938, -10922, -10922, -10923, -10922, -10923, -10922, -10922, -10923, -10923, -10922, -10922, -10923, -10923, -10922, -10923, -10744, -11716, -3902, 759, -171, -1, 0, -1, -1, -1, 0, -1, 0, -1, -1, 0, -1, -1, -1, -1, -292, 1342, -5690, -33504, -32643, -32740, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32767, -32766, -32692, -33097, -31441, -21913, -21807, -21865, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21737, -22338, -19703, -10570, -10991, -10928, -10923, -10923, -10922, -10923, -10923, -10923, -10923, -10922, -10922, -10923, -10922, -10923, -10922, -10923, -10922, -10923, -10922, -10922, -10922, -10923, -10923, -10923, -10923, -10922, -10904, -10942, -10923, -1435, 354, -79, -1, 0, 0, -1, 0, 0, -1, -1, 0, -1, -1, 0, -1, 0, -1, -1, 0, -1, 0, -1, -1};