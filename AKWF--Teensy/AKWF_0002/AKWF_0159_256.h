/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0159 256 samples */
 
const int16_t AKWF_0159_256_DATA [256] = 
{255, 663, 1060, 1460, 1865, 2277, 2700, 3132, 3575, 4028, 4488, 4951, 5441, 5709, 5256, 4417, 3694, 3678, 3606, 3188, 2795, 2524, 2405, 2434, 2590, 2853, 3192, 3615, 5483, 9400, 13855, 18009, 21575, 24472, 26752, 28505, 29821, 30795, 31501, 32001, 32343, 32566, 32698, 32759, 32767, 32733, 32664, 32568, 32449, 32311, 32154, 31983, 31798, 31598, 31387, 31162, 30927, 30679, 30421, 30152, 29873, 29583, 29284, 28974, 28655, 28327, 27990, 27643, 27289, 26927, 26556, 26177, 25791, 25398, 24998, 24591, 24177, 23759, 23333, 22901, 22466, 22024, 21577, 21127, 20670, 20210, 19747, 19280, 18809, 18336, 17859, 17379, 16898, 16413, 15927, 15440, 14950, 14459, 13969, 13475, 12982, 12489, 11994, 11501, 11007, 10513, 10019, 9517, 8999, 8463, 7898, 7307, 6689, 6041, 5367, 4672, 3954, 3221, 2475, 1718, 956, 193, -572, -1332, -2086, -2834, -3570, -4292, -5003, -5698, -6376, -7038, -7680, -8304, -8911, -9497, -10067, -10617, -11148, -11657, -12168, -12436, -11963, -11085, -10313, -9854, -8639, -6814, -5074, -3636, -2566, -1844, -1424, -1259, -1262, -1575, -3745, -7778, -12131, -16125, -19523, -22270, -24427, -26084, -27330, -28253, -28926, -29405, -29737, -29958, -30092, -30162, -30181, -30159, -30106, -30028, -29927, -29808, -29672, -29522, -29358, -29181, -28992, -28792, -28581, -28359, -28126, -27882, -27630, -27367, -27095, -26814, -26523, -26224, -25916, -25600, -25276, -24944, -24603, -24257, -23903, -23541, -23174, -22800, -22419, -22034, -21642, -21245, -20843, -20436, -20024, -19607, -19187, -18763, -18335, -17903, -17467, -17030, -16589, -16146, -15700, -15252, -14802, -14351, -13897, -13443, -12988, -12531, -12075, -11617, -11159, -10702, -10244, -9785, -9329, -8873, -8417, -7963, -7509, -7057, -6607, -6158, -5711, -5267, -4824, -4384, -3947, -3511, -3079, -2651, -2224, -1801, -1382, -966, -556, -140};