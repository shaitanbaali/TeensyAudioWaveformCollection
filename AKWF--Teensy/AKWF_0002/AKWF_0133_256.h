/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0133 256 samples */
 
const int16_t AKWF_0133_256_DATA [256] = 
{960, 2932, 4847, 6745, 8609, 10439, 12228, 13963, 15647, 17273, 18829, 20320, 21741, 23080, 24344, 25526, 26620, 27631, 28552, 29382, 30123, 30773, 31329, 31796, 32169, 32451, 32645, 32749, 32765, 32695, 32541, 32306, 31990, 31598, 31131, 30591, 29985, 29312, 28576, 27783, 26933, 26031, 25084, 24089, 23054, 21985, 20880, 19746, 18589, 17408, 16208, 14999, 13775, 12546, 11316, 10083, 8855, 7638, 6427, 5232, 4056, 2895, 1761, 652, -431, -1480, -2498, -3481, -4426, -5331, -6198, -7018, -7796, -8528, -9211, -9846, -10433, -10966, -11449, -11879, -12253, -12572, -12833, -13030, -13164, -13148, -13046, -12957, -12732, -12453, -12140, -11788, -11397, -10970, -10517, -10047, -9562, -9069, -8571, -8068, -7565, -7062, -6558, -6058, -5563, -5071, -4587, -4110, -3643, -3187, -2744, -2314, -1899, -1499, -1116, -752, -404, -76, 233, 523, 794, 1044, 1275, 1486, 1677, 1849, 2002, 2135, 2251, 2348, 2428, 2491, 2537, 2568, 2583, 2584, 2571, 2544, 2504, 2453, 2390, 2316, 2233, 2139, 2038, 1929, 1813, 1690, 1561, 1428, 1290, 1148, 1002, 855, 705, 554, 402, 251, 98, -52, -202, -349, -495, -638, -777, -913, -1046, -1174, -1297, -1416, -1529, -1637, -1740, -1837, -1927, -2012, -2090, -2162, -2228, -2287, -2339, -2385, -2424, -2457, -2483, -2502, -2516, -2522, -2522, -2517, -2505, -2488, -2466, -2437, -2403, -2364, -2320, -2272, -2219, -2162, -2101, -2036, -1969, -1897, -1823, -1749, -1660, -1640, -1983, -2282, -2914, -3889, -5269, -6549, -8164, -9962, -11790, -13660, -15564, -17452, -19285, -21029, -22652, -24133, -25465, -26635, -27642, -28487, -29170, -29694, -30063, -30277, -30342, -30258, -30031, -29663, -29157, -28519, -27750, -26856, -25844, -24716, -23480, -22146, -20712, -19193, -17597, -15925, -14191, -12404, -10564, -8689, -6784, -4856, -2919, -937};