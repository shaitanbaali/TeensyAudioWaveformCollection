/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0164 256 samples */
 
const int16_t AKWF_0164_256_DATA [256] = 
{279, 867, 1422, 1962, 2491, 3017, 3543, 4052, 4519, 4881, 5069, 5102, 5014, 4844, 4675, 4610, 4697, 4931, 5294, 5762, 6319, 6963, 7722, 8611, 9616, 10719, 11895, 13090, 14257, 15365, 16399, 17386, 18380, 19410, 20494, 21624, 22754, 23852, 24891, 25850, 26731, 27535, 28262, 28920, 29515, 30047, 30524, 30948, 31321, 31645, 31925, 32159, 32353, 32507, 32624, 32705, 32752, 32767, 32748, 32690, 32585, 32429, 32222, 31966, 31667, 31335, 30977, 30601, 30211, 29811, 29403, 28992, 28581, 28179, 27806, 27460, 27134, 26821, 26506, 26177, 25821, 25426, 24986, 24500, 23961, 23376, 22744, 22065, 21346, 20590, 19784, 18908, 17935, 16845, 15640, 14325, 12898, 11378, 9791, 8165, 6540, 4936, 3377, 1884, 466, -869, -2110, -3264, -4328, -5300, -6188, -6993, -7718, -8371, -8958, -9482, -9955, -10381, -10764, -11115, -11436, -11733, -12012, -12283, -12558, -12843, -13141, -13453, -13780, -14120, -14470, -14825, -15175, -15517, -15845, -16173, -16528, -16973, -17574, -18313, -19157, -20062, -20950, -21716, -22312, -22750, -23048, -23235, -23341, -23376, -23324, -23181, -22962, -22684, -22360, -22004, -21640, -21326, -21112, -21021, -21068, -21245, -21520, -21848, -22178, -22459, -22658, -22757, -22751, -22639, -22435, -22151, -21803, -21409, -20979, -20530, -20071, -19611, -19157, -18713, -18284, -17869, -17472, -17088, -16720, -16365, -16024, -15704, -15409, -15146, -14912, -14706, -14519, -14343, -14169, -13987, -13796, -13588, -13363, -13117, -12844, -12536, -12177, -11762, -11303, -10810, -10291, -9765, -9245, -8740, -8259, -7808, -7388, -6998, -6638, -6305, -5995, -5709, -5464, -5304, -5266, -5364, -5590, -5926, -6364, -6886, -7459, -8051, -8628, -9164, -9638, -10035, -10345, -10563, -10687, -10719, -10662, -10520, -10298, -10002, -9639, -9213, -8732, -8204, -7633, -7026, -6391, -5730, -5051, -4357, -3653, -2952, -2262, -1591, -943, -307};