/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0200 256 samples */
 
const int16_t AKWF_0200_256_DATA [256] = 
{191, 615, 1019, 1411, 1790, 2158, 2516, 2863, 3201, 3528, 3844, 4150, 4443, 4725, 4995, 5253, 5499, 5735, 5959, 6172, 6376, 6570, 6755, 6932, 7101, 7263, 7418, 7568, 7713, 7854, 7991, 8125, 8257, 8387, 8517, 8647, 8776, 8908, 9041, 9177, 9316, 9460, 9607, 9759, 9918, 10082, 10254, 10432, 10618, 10813, 11016, 11228, 11450, 11681, 11922, 12173, 12434, 12706, 12988, 13281, 13584, 13898, 14221, 14554, 14898, 15250, 15611, 15982, 16360, 16746, 17139, 17538, 17943, 18353, 18767, 19184, 19606, 20027, 20449, 20873, 21291, 21703, 22113, 22520, 22923, 23320, 23591, 24478, 16246, 16890, 19341, 17417, 19484, 19161, 18220, 17793, 17404, 17056, 16695, 16315, 15913, 15494, 15066, 14632, 14196, 13761, 13329, 12899, 12475, 12051, 11658, 11104, 10150, 9300, 8564, 7865, 7224, 6582, 5855, 5108, 4358, 3611, 2850, 2143, 1699, 1273, 794, 320, -143, -589, -1022, -1444, -1855, -2256, -2649, -3032, -3407, -3773, -4131, -4479, -4821, -5153, -5479, -5797, -6108, -6413, -6712, -7004, -7293, -7576, -7854, -8128, -8397, -8662, -8924, -9181, -9435, -9684, -9929, -10170, -10408, -10640, -10867, -11090, -11308, -11520, -11727, -11927, -12121, -12310, -12490, -12665, -12833, -12991, -13144, -13289, -13424, -13553, -13672, -13784, -13886, -13980, -14066, -14142, -14210, -14270, -14320, -14362, -14396, -14421, -14437, -14447, -14447, -14441, -14426, -14405, -14377, -14341, -14300, -14253, -14198, -14139, -14075, -14005, -13930, -13851, -13768, -13681, -13590, -13496, -13398, -13298, -13194, -13089, -12980, -12870, -12755, -12631, -12506, -12378, -12245, -12109, -11969, -11826, -11678, -11526, -11372, -11212, -11050, -10883, -10713, -10538, -10360, -10178, -9992, -9802, -9608, -9409, -9203, -9007, -8589, -7944, -7389, -6858, -6326, -5798, -5308, -4799, -4199, -3569, -2923, -2263, -1574, -939, -577, -213};