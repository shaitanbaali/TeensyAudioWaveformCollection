/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0169 256 samples */
 
const int16_t AKWF_0169_256_DATA [256] = 
{2598, 6865, 10931, 14768, 18269, 21381, 24087, 26385, 28305, 29869, 31081, 31942, 32424, 32478, 32045, 31069, 29522, 27420, 24827, 21818, 18443, 14784, 10911, 6860, 2697, -1527, -5730, -9602, -12784, -15229, -17179, -18793, -20148, -21286, -22243, -23048, -23715, -24263, -24704, -25037, -25253, -25208, -24712, -23666, -22022, -19822, -17124, -13989, -10490, -6686, -2670, 1459, 5628, 9727, 13652, 17328, 20658, 23591, 26121, 28238, 29952, 31275, 32195, 32692, 32729, 32261, 31247, 29673, 27579, 25015, 22037, 18727, 15157, 11422, 7640, 3914, 388, -2778, -5434, -7468, -8850, -9588, -9662, -9061, -7833, -6078, -3907, -1430, 1221, 3917, 6543, 8972, 11100, 12844, 14126, 14895, 15121, 14790, 13912, 12510, 10637, 8342, 5694, 2785, -310, -3499, -6656, -9599, -12142, -14185, -15788, -17083, -18150, -19032, -19748, -20312, -20732, -21016, -21102, -20781, -19853, -18236, -16015, -13344, -10327, -7029, -3524, 131, 3893, 7686, 11453, 15127, 18611, 21824, 24669, 27038, 28884, 30190, 30958, 31206, 30960, 30263, 29167, 27738, 26046, 24103, 21878, 19328, 16413, 13144, 9557, 5686, 1612, -2547, -6471, -9707, -12203, -14248, -15994, -17516, -18861, -20047, -21090, -21998, -22771, -23411, -23918, -24290, -24529, -24636, -24607, -24161, -22871, -20691, -17848, -14559, -10957, -7112, -3110, 973, 5096, 9176, 13130, 16879, 20305, 23316, 25841, 27831, 29290, 30234, 30672, 30617, 30079, 29089, 27694, 25943, 23821, 21233, 18092, 14388, 10168, 5563, 764, -3942, -7976, -10969, -13155, -14831, -16128, -17137, -17910, -18492, -18883, -18894, -18341, -17218, -15690, -13970, -12215, -10556, -9096, -7911, -7065, -6597, -6529, -6861, -7575, -8652, -10063, -11780, -13768, -15959, -18241, -20433, -22352, -23896, -25109, -26093, -26905, -27573, -28114, -28546, -28880, -29110, -29112, -28718, -27855, -26516, -24720, -22493, -19837, -16785, -13373, -9650, -5699, -1498};