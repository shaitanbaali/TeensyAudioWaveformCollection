/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0181 256 samples */
 
const int16_t AKWF_0181_256_DATA [256] = 
{10970, 10725, 11642, 21302, 21995, 21802, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21760, 22212, 20255, 11101, 1744, 196, -7458, -12219, -21115, -21822, -22519, -32224, -32918, -32724, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32681, -33143, -31032, -22398, -18215, -3952, 646, -193};