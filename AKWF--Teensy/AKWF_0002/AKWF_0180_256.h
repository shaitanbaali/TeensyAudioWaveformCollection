/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0180 256 samples */
 
const int16_t AKWF_0180_256_DATA [256] = 
{6286, 11751, 10732, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 11039, 10383, 13315, 22292, 21752, 21841, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21643, 22714, 16308, 10055, 11122, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10735, 11747, 4192, -791, 178, 0, -1, 0, -1, 0, 0, -1, -1, 0, 0, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0, -191, 837, -6583, -11728, -10740, -10922, -10922, -10923, -10923, -10923, -10922, -10923, -10923, -10922, -10923, -10922, -10923, -10922, -10923, -10922, -11006, -10545, -12469, -21910, -21848, -21829, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -22044, -20852, -27942, -31111, -21152, -21947, -21846, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21722, -22406, -19322, -10431, -11025, -10924, -10923, -10922, -10922, -10922, -10922, -10922, -10923, -10923, -10923, -10923, -10922, -10923, -10922, -10922, -10923, -10922, -10922, -10923, -10922, -10923, -10740, -11733, -4046, 775, -175, 0, -1, -1, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0};