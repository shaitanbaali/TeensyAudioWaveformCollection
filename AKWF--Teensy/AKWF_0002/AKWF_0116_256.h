/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0116 256 samples */
 
const int16_t AKWF_0116_256_DATA [256] = 
{1759, 5317, 8359, 11045, 13413, 15495, 17315, 18896, 20273, 21458, 22459, 23306, 24100, 24166, 23069, 23302, 22762, 20538, 19015, 17970, 16596, 15499, 15207, 15572, 16172, 17049, 18126, 19214, 20212, 21097, 21856, 22489, 22759, 22450, 21569, 19998, 17691, 14682, 11113, 7410, 3689, 72, -3263, -6268, -8936, -11284, -13354, -15165, -16732, -18077, -19176, -19544, -18881, -17072, -14155, -10741, -6884, -2870, 970, 4468, 7593, 10379, 12850, 15043, 16995, 18720, 20242, 21585, 22759, 23782, 24671, 25432, 26081, 26628, 27078, 27442, 27727, 27941, 28093, 28192, 28250, 28277, 28286, 28288, 28295, 28313, 28349, 28403, 28476, 28563, 28663, 28768, 28874, 28975, 29067, 29144, 29204, 29243, 29259, 29249, 29214, 29152, 29063, 28948, 28807, 28644, 28461, 28264, 28056, 27860, 27692, 27558, 27478, 27458, 27503, 27608, 27769, 27977, 28217, 28466, 28731, 29094, 29474, 29811, 30176, 30558, 30894, 31193, 31472, 31720, 31933, 32113, 32266, 32391, 32485, 32551, 32592, 32605, 32592, 32553, 32490, 32402, 32291, 32158, 32009, 31842, 31664, 31480, 31293, 31108, 30928, 30755, 30588, 30424, 30260, 30090, 29905, 29691, 29451, 28811, 27344, 25027, 21651, 17615, 13291, 8750, 4330, 264, -3401, -6672, -9575, -12166, -14478, -16531, -18363, -19990, -21427, -22699, -23814, -24783, -25622, -26337, -26938, -27436, -27840, -28159, -28403, -28584, -28711, -28795, -28849, -28883, -28906, -28930, -28961, -29004, -29063, -29142, -29238, -29353, -29486, -29633, -29793, -29964, -30142, -30323, -30506, -30687, -30861, -31029, -31186, -31331, -31460, -31573, -31667, -31745, -31804, -31847, -31876, -31894, -31905, -31910, -31914, -31919, -31928, -31941, -31962, -31982, -32009, -32075, -32151, -32210, -32291, -32389, -32470, -32545, -32617, -32678, -32724, -32754, -32767, -32759, -32724, -32660, -32564, -32429, -32240, -32018, -31788, -29100, -25145, -21400, -16621, -11447, -6567, -2084};