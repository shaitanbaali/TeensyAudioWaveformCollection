/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0128 256 samples */
 
const int16_t AKWF_0128_256_DATA [256] = 
{5088, 21218, 28297, 25025, 15367, 6350, 3982, 9737, 19816, 27533, 27441, 18719, 5823, -4006, -4976, 3863, 17920, 29647, 32729, 25665, 12485, 360, -4615, -915, 7701, 14565, 14224, 5831, -6210, -14749, -14063, -3310, 12835, 26666, 31783, 26571, 14980, 4076, -119, 3892, 12314, 18475, 16946, 6908, -7173, -18043, -19912, -11819, 1646, 12936, 15737, 8545, -4610, -16562, -21222, -17073, -7881, -325, 135, -7362, -18423, -25909, -24115, -12212, 5118, 20145, 26459, 22435, 12000, 2214, -915, 4093, 13438, 20434, 19643, 10238, -3321, -13790, -15377, -7130, 6362, 17551, 20125, 12582, -1044, -13583, -18937, -15583, -7277, -688, -1267, -9861, -22063, -30727, -30126, -19420, -3283, 10578, 15764, 10660, -785, -11505, -15477, -11208, -2491, 4001, 2837, -6801, -20448, -30854, -32227, -23609, -9592, 2280, 5687, -875, -13375, -24653, -28621, -23759, -13839, -5542, -4327, -11058, -21346, -28049, -25469, -12776, 5345, 21163, 28265, 25026, 15367, 6350, 3982, 9737, 19816, 27533, 27441, 18719, 5823, -4006, -4976, 3863, 17920, 29647, 32729, 25664, 12484, 360, -4614, -915, 7702, 14566, 14223, 5830, -6210, -14749, -14063, -3310, 12835, 26666, 31783, 26572, 14980, 4076, -119, 3892, 12314, 18475, 16946, 6907, -7173, -18043, -19911, -11819, 1646, 12936, 15737, 8545, -4610, -16562, -21222, -17073, -7880, -325, 135, -7362, -18423, -25909, -24115, -12211, 5118, 20145, 26459, 22435, 12000, 2214, -915, 4094, 13438, 20435, 19643, 10238, -3322, -13790, -15377, -7130, 6362, 17552, 20125, 12582, -1044, -13583, -18936, -15583, -7277, -688, -1267, -9861, -22063, -30727, -30126, -19420, -3283, 10578, 15764, 10660, -785, -11505, -15477, -11208, -2491, 4001, 2837, -6802, -20449, -30855, -32227, -23609, -9591, 2280, 5686, -876, -13376, -24653, -28621, -23759, -13839, -5542, -4326, -11058, -21346, -28081, -25545, -12472};