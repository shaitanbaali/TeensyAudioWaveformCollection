/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0177 256 samples */
 
const int16_t AKWF_0177_256_DATA [256] = 
{245, 1053, 1844, 2638, 3427, 4231, 5093, 5755, 6203, 6604, 6999, 7395, 7792, 8187, 8585, 8983, 9378, 9775, 10173, 10568, 10950, 11328, 11719, 12116, 12513, 12909, 13307, 13704, 14100, 14497, 14894, 15290, 15689, 16082, 16491, 17079, 17829, 18620, 19416, 20209, 21003, 21798, 22589, 23383, 24178, 24970, 25755, 26569, 27162, 26186, 23786, 21035, 18243, 15459, 12685, 9904, 7126, 4352, 1571, -1208, -3962, -6826, -9535, -10563, -10404, -10011, -9604, -9203, -8806, -8410, -8012, -7616, -7219, -6822, -6424, -6033, -5603, -4977, -4211, -3417, -2623, -1829, -1034, -242, 552, 1346, 2138, 2933, 3725, 4521, 5242, 5768, 6185, 6581, 6977, 7373, 7771, 8167, 8564, 8961, 9357, 9754, 10151, 10548, 10929, 11308, 11698, 12095, 12492, 12888, 13286, 13682, 14079, 14475, 14873, 15268, 15654, 16091, 15993, 14459, 12195, 9814, 7422, 5040, 2661, 278, -2102, -4480, -6864, -9242, -11614, -14015, -15811, -16225, -15942, -15542, -15138, -14738, -14343, -13945, -13548, -13152, -12755, -12358, -11961, -11566, -11187, -10807, -10414, -10017, -9621, -9224, -8827, -8431, -8033, -7637, -7240, -6843, -6447, -6051, -5671, -5292, -4899, -4503, -4106, -3710, -3312, -2916, -2519, -2122, -1726, -1328, -941, -519, -371, -1537, -3690, -6064, -8455, -10835, -13219, -15601, -17977, -20361, -22742, -25121, -27483, -29965, -32147, -32787, -32540, -32141, -31735, -31336, -30940, -30542, -30146, -29749, -29351, -28956, -28557, -28166, -27719, -27065, -26291, -25498, -24703, -23909, -23116, -22323, -21528, -20736, -19941, -19147, -18356, -17561, -16863, -16360, -15948, -15552, -15157, -14759, -14363, -13967, -13570, -13173, -12776, -12379, -11983, -11586, -11207, -10828, -10435, -10038, -9642, -9245, -8848, -8452, -8055, -7658, -7262, -6864, -6469, -6056, -5590, -5154, -4752, -4354, -3957, -3561, -3164, -2765, -2376, -1951, -1089, -245};