/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0141 256 samples */
 
const int16_t AKWF_0141_256_DATA [256] = 
{4971, 12064, 15318, 17942, 20037, 21789, 22533, 23701, 24200, 25584, 25727, 27475, 27723, 30017, 32533, 32629, 32787, 32762, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32758, 32827, 32469, 31345, 31520, 30407, 30679, 29914, 28641, 27655, 25782, 24355, 21864, 19039, 15780, 11280, -3785, -13967, -18074, -22359, -25355, -27776, -30346, -32622, -32796, -32755, -32767, -32767, -32767, -32767, -32767, -32738, -32883, -32055, -29664, -26574, -23262, -20810, -18082, -15350, -13976, -11976, -10260, -9613, -8307, -5886, -6487, -3264, -5775, -9948, -12391, -15382, -18558, -21275, -23816, -24823, -25839, -25556, -24602, -24262, -23286, -22164, -21536, -20233, -19734, -19044, -19047, -18071, -18227, -16957, -16983, -16061, -15508, -15327, -15652, -15473, -17634, -19074, -21194, -22942, -25999, -27121, -29445, -29304, -31014, -30343, -29984, -29343, -27295, -25713, -23213, -20127, -16869, -13558, -7627, 5522, 9236, 12033, 12741, 12141, 12762, 13320, 13717, 16454, 18783, 21574, 24724, 27246, 28617, 29405, 29737, 29126, 29787, 30301, 30641, 31454, 32376, 32851, 32749, 32745, 32854, 30529, 29230, 27674, 27964, 28039, 30891, 31937, 32813, 32751, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32736, 32812, 32472, 26309, 20246, 14553, 4693, -12695, -17732, -21473, -24924, -26854, -29237, -31709, -32943, -32726, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32762, -32747, -32844, -30034, -26437, -23708, -20877, -18917, -17064, -15102, -12416, -9720, 1655, 8427, 10667, 11222, 11816, 12051, 10177, 10046, 7997, 6694, 2054, -5665, -5682, -5751, 1221, 9722, 10760, 13241, 13917, 14014, 12282, 11357, 1882, -8948, -12400, -15032, -16153, -16305, -17028, -14933, -13454, -8083};