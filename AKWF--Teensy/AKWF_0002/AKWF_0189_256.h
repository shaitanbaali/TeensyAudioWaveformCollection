/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0189 256 samples */
 
const int16_t AKWF_0189_256_DATA [256] = 
{9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9267, 9302, 9138, 9726, 17923, 18700, 18493, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18534, 18535, 18534, 18535, 18535, 18535, 18535, 18535, 18534, 18534, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18534, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18534, 18535, 18535, 18535, 18535, 18535, 18535, 18535, 18479, 18875, 16987, 12125, 15543, 8538, 9416, 9159, 9762, 7016, -453, 95, 0, 0, -1, -168, 732, -5208, -9981, -9105, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9427, -8568, -14978, -19206, -18383, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18660, -17968, -21244, -28374, -27676, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27803, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27802, -27747, -28044, -26858, -18717, -18473, -18558, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18372, -19248, -14475, -8535, -9436, -9268, -9268, -9268, -9268, -9267, -9268, -9268, -9268, -9265, -9190, -9648, -2031, 457, -99, -1, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, -1, 0};