/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0146 256 samples */
 
const int16_t AKWF_0146_256_DATA [256] = 
{641, 1567, 2454, 3325, 4177, 5007, 5819, 6606, 7371, 8113, 8827, 9520, 10187, 10826, 11442, 12033, 12597, 13138, 13654, 14146, 14616, 15062, 15487, 15892, 16278, 16644, 16995, 17329, 17650, 18071, 18624, 19228, 19945, 20829, 21863, 23294, 25889, 28297, 30141, 31830, 32559, 32707, 32750, 32761, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32765, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32765, 32764, 32764, 32764, 32762, 32763, 32747, 32251, 31228, 30044, 28766, 27386, 25882, 24236, 22423, 20423, 17487, 13912, 11001, 8230, 5283, 2222, -841, -3834, -6687, -9358, -11813, -13997, -15882, -17449, -18691, -19594, -20027, -19205, -17966, -17247, -16406, -15257, -13888, -12421, -10942, -9509, -8167, -6929, -5807, -4810, -3932, -3170, -2523, -1981, -1539, -1192, -930, -749, -642, -601, -621, -695, -817, -980, -1178, -1408, -1662, -1937, -2228, -2532, -2844, -3164, -3487, -3813, -4140, -4466, -4791, -5114, -5433, -5751, -6065, -6375, -6683, -6988, -7287, -7583, -7876, -8161, -8442, -8715, -8976, -9226, -9463, -9684, -9886, -10070, -10234, -10376, -10499, -10601, -10678, -10731, -10766, -10781, -10775, -10753, -10717, -10667, -10605, -10533, -10453, -10366, -10274, -10179, -10081, -9981, -9880, -9779, -9679, -9580, -9482, -9387, -9294, -9202, -9113, -9026, -8940, -8856, -8772, -8687, -8603, -8518, -8431, -8343, -8253, -8162, -8070, -7979, -7907, -7888, -7945, -8106, -8385, -8790, -9361, -10107, -11631, -14043, -15808, -17307, -18975, -20766, -22581, -24322, -25923, -27358, -28604, -29654, -30514, -31187, -31681, -32008, -32177, -32198, -32083, -31841, -31484, -31020, -30461, -29814, -29088, -28294, -27439, -26527, -25573, -24579, -23550, -22498, -21423, -20331, -19230, -18119, -17004, -15891, -14778, -13669, -12570, -11475, -10391, -9320, -8258, -7209, -6176, -5153, -4147, -3156, -2180, -1222, -262};