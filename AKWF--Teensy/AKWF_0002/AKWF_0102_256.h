/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0102 256 samples */
 
const int16_t AKWF_0102_256_DATA [256] = 
{4420, 11312, 16678, 20399, 22715, 24081, 24889, 25381, 25697, 25905, 26042, 26131, 26188, 26225, 26248, 26262, 26272, 26278, 26281, 26284, 26286, 26286, 26287, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26289, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26289, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26289, 26288, 26288, 26288, 26288, 26288, 26289, 26288, 26288, 26288, 26289, 26288, 26289, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26289, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26289, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26288, 26287, 26223, 26518, 24098, 18042, 11173, 2965, -4534, -11275, -16665, -20400, -22715, -24082, -24889, -25382, -25697, -25905, -26042, -26131, -26189, -26225, -26248, -26262, -26272, -26278, -26282, -26284, -26286, -26287, -26287, -26288, -26288, -26288, -26288, -26288, -26288, -26288, -26288, -26289, -26288, -26289, -26289, -26289, -26289, -26288, -26288, -26288, -26289, -26288, -26289, -26289, -26288, -26289, -26288, -26289, -26288, -26288, -26289, -26289, -26288, -26288, -26289, -26289, -26288, -26288, -26288, -26288, -26289, -26288, -26288, -26289, -26288, -26289, -26289, -26288, -26288, -26288, -26289, -26289, -26289, -26288, -26289, -26289, -26288, -26288, -26288, -26289, -26289, -26288, -26289, -26289, -26289, -26288, -26289, -26289, -26289, -26289, -26288, -26289, -26288, -26289, -26289, -26288, -26289, -26289, -26289, -26289, -26289, -26289, -26288, -26289, -26288, -26289, -26288, -26289, -26288, -26289, -26289, -26289, -26289, -26289, -26288, -26289, -26288, -26289, -26289, -26288, -26289, -26287, -26223, -26519, -24098, -18056, -11203, -2865};