/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0101 256 samples */
 
const int16_t AKWF_0101_256_DATA [256] = 
{-163, -506, -837, -1167, -1493, -1817, -2141, -2463, -2785, -3110, -3434, -3763, -4097, -4438, -4795, -5144, -5824, -7082, -8341, -9764, -11459, -12949, -14310, -15805, -17168, -18436, -19621, -20379, -20868, -21097, -20895, -20639, -20251, -19653, -18961, -18295, -17673, -16974, -16283, -15648, -15051, -14491, -13973, -13488, -13054, -12772, -12570, -12430, -12411, -12509, -12728, -13073, -13561, -14201, -15009, -15948, -16653, -17360, -18173, -18895, -19547, -20170, -20758, -21293, -21765, -22175, -22531, -22842, -23112, -23346, -23545, -23710, -23841, -23938, -24001, -24030, -24025, -23985, -23912, -23806, -23669, -23500, -23301, -23073, -22818, -22537, -22232, -21903, -21553, -21184, -20794, -20389, -19967, -19531, -19082, -18624, -18159, -17688, -17210, -16729, -16246, -15759, -15271, -14781, -14290, -13795, -13300, -12801, -12300, -11797, -11290, -10782, -10273, -9762, -9251, -8743, -8234, -7729, -7229, -6730, -6238, -5752, -5270, -4795, -4325, -3861, -3404, -2952, -2505, -2065, -1631, -1202, -780, -363, 47, 452, 850, 1244, 1631, 2013, 2392, 2765, 3136, 3506, 3874, 4246, 4621, 5004, 5795, 6883, 8046, 9248, 9936, 10833, 11892, 12817, 13750, 14774, 15862, 16890, 17857, 18767, 19457, 20002, 20715, 21380, 21961, 22537, 23104, 23628, 24096, 24515, 24904, 25300, 25708, 26122, 26456, 26733, 27019, 27258, 27450, 27609, 27739, 27838, 27901, 27929, 27922, 27883, 27814, 27715, 27589, 27435, 27254, 27048, 26818, 26562, 26286, 25986, 25667, 25328, 24971, 24597, 24207, 23802, 23383, 22953, 22509, 22056, 21594, 21123, 20644, 20159, 19667, 19170, 18669, 18162, 17653, 17142, 16628, 16114, 15600, 15086, 14574, 14064, 13555, 13051, 12550, 12051, 11559, 11070, 10585, 10106, 9631, 9160, 8695, 8234, 7778, 7327, 6881, 6438, 6003, 5572, 5146, 4728, 4313, 3905, 3504, 3108, 2719, 2338, 1961, 1591, 1228, 871, 521, 169};