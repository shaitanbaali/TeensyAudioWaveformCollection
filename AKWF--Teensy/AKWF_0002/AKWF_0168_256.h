/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0168 256 samples */
 
const int16_t AKWF_0168_256_DATA [256] = 
{487, 1454, 2503, 3631, 4839, 6097, 7389, 8681, 9953, 11186, 12344, 13415, 14370, 15188, 15853, 16346, 16653, 16764, 16671, 16374, 15868, 15160, 14261, 13180, 11937, 10553, 9049, 7458, 5808, 4136, 2487, 919, -507, -2006, -3501, -4881, -6180, -7331, -8313, -9085, -9622, -9909, -9929, -9677, -9152, -8359, -7303, -6007, -4502, -2821, -1044, 742, 2848, 5187, 7614, 10198, 12838, 15498, 18126, 20659, 23057, 25278, 27268, 29001, 30439, 31550, 32313, 32710, 32727, 32361, 31610, 30485, 28996, 27162, 25022, 22599, 19938, 17096, 14112, 11047, 8013, 4598, 1433, 208, -19, 758, 2482, 4653, 6967, 9111, 10903, 12227, 13037, 13329, 13123, 12454, 11365, 9911, 8150, 6142, 3972, 1727, -439, -2815, -5447, -8062, -10739, -13387, -15955, -18378, -20615, -22626, -24370, -25826, -26976, -27798, -28289, -28442, -28260, -27751, -26932, -25821, -24439, -22820, -20992, -18988, -16858, -14633, -12354, -10072, -7823, -5643, -3593, -1703, -70, 1448, 2972, 4293, 5462, 6454, 7237, 7800, 8132, 8234, 8111, 7773, 7238, 6524, 5649, 4644, 3537, 2358, 1153, -1, -1199, -2522, -3814, -5113, -6377, -7577, -8696, -9698, -10575, -11313, -11894, -12319, -12585, -12686, -12630, -12418, -12065, -11576, -10971, -10262, -9465, -8600, -7685, -6739, -5781, -4830, -3900, -3011, -2174, -1406, -716, -131, 376, 856, 1253, 1576, 1829, 2001, 2100, 2125, 2083, 1981, 1830, 1638, 1415, 1174, 925, 675, 438, 221, 35, -120, -255, -352, -408, -423, -396, -327, -218, -77, 88, 295, 529, 782, 1050, 1323, 1593, 1849, 2082, 2283, 2444, 2559, 2620, 2624, 2567, 2448, 2267, 2026, 1732, 1388, 1007, 595, 177, -240, -705, -1179, -1643, -2097, -2520, -2897, -3212, -3454, -3608, -3667, -3622, -3467, -3198, -2815, -2322, -1725, -1042, -283};