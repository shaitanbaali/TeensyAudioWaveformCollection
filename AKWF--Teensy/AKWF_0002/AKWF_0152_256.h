/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0152 256 samples */
 
const int16_t AKWF_0152_256_DATA [256] = 
{583, 1448, 2283, 3105, 3912, 4704, 5482, 6240, 6983, 7709, 8416, 9108, 9781, 10436, 11074, 11696, 12299, 12888, 13461, 14015, 14557, 15082, 15592, 16090, 16572, 17042, 17499, 17943, 18375, 18797, 19207, 19605, 19995, 20374, 20743, 21104, 21455, 21798, 22133, 22460, 22779, 23092, 23396, 23695, 23987, 24271, 24551, 24824, 25091, 25353, 25610, 25861, 26108, 26349, 26585, 26817, 27045, 27268, 27487, 27702, 27912, 28119, 28322, 28520, 28716, 28907, 29095, 29280, 29460, 29639, 29813, 29984, 30152, 30318, 30479, 30638, 30794, 30947, 31098, 31245, 31390, 31532, 31672, 31809, 31943, 32075, 32204, 32332, 32456, 32552, 32752, 32537, 27200, 25044, 24108, 24077, 23674, 20632, 18915, 16114, 14297, 12062, 10026, 8321, 6980, 5683, 4348, 2966, 1591, 271, -1004, -2235, -3435, -4608, -5754, -6864, -7942, -8981, -9979, -10939, -11856, -12730, -13563, -14354, -15102, -15813, -16484, -17117, -17717, -18282, -18814, -19317, -19790, -20237, -20659, -21056, -21431, -21787, -22122, -22439, -22739, -23023, -23292, -23548, -23791, -24022, -24242, -24451, -24651, -24841, -25023, -25197, -25364, -25523, -25676, -25821, -25962, -26096, -26225, -26348, -26467, -26581, -26689, -26794, -26893, -26989, -27081, -27167, -27250, -27329, -27403, -27474, -27540, -27603, -27661, -27716, -27766, -27812, -27855, -27893, -27928, -27957, -27982, -28004, -28020, -28033, -28041, -28045, -28044, -28039, -28029, -28013, -27993, -27967, -27937, -27902, -27861, -27816, -27764, -27706, -27643, -27573, -27497, -27415, -27327, -27231, -27128, -27018, -26901, -26775, -26641, -26499, -26347, -26186, -26015, -25834, -25641, -25438, -25222, -24992, -24749, -24492, -24219, -23929, -23621, -23294, -22946, -22574, -22180, -21758, -21306, -20824, -20305, -19747, -19147, -18497, -17793, -17028, -16192, -15293, -14356, -13386, -12406, -11426, -10447, -9477, -8518, -7565, -6620, -5685, -4755, -3837, -2930, -2033, -1149, -259};