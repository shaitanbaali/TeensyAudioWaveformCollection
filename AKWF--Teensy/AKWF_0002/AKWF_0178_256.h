/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0178 256 samples */
 
const int16_t AKWF_0178_256_DATA [256] = 
{-1681, -4525, -7188, -9524, -11806, -14310, -17050, -19859, -22583, -25155, -27570, -29913, -31985, -32794, -32503, -31768, -31048, -30513, -29923, -29045, -27864, -26528, -25189, -23906, -22679, -21477, -20273, -18998, -17662, -16341, -15085, -13908, -12781, -11683, -10605, -9559, -8563, -7619, -6722, -5871, -5065, -4304, -3578, -2885, -2226, -1606, -1020, -466, 56, 553, 1023, 1465, 1883, 2279, 2663, 2915, 3041, 3109, 3167, 3240, 3307, 3341, 3338, 3312, 3279, 3247, 3216, 3180, 3157, 3239, 3412, 3613, 3803, 3968, 4128, 4308, 4507, 4713, 4913, 5100, 5277, 5445, 5599, 5742, 5884, 6020, 6149, 6268, 6376, 6476, 6569, 6657, 6738, 6813, 6880, 6943, 6986, 6922, 6759, 6560, 6367, 6196, 6028, 5838, 5626, 5403, 5184, 4975, 4775, 4579, 4417, 4380, 4424, 4498, 4560, 4605, 4657, 4736, 4839, 4950, 5058, 5158, 5252, 5343, 5421, 5496, 5571, 5645, 5715, 5777, 5831, 5880, 5926, 5969, 6007, 6041, 6070, 6098, 6096, 5977, 5774, 5546, 5331, 5139, 4946, 4730, 4494, 4253, 4018, 3795, 3582, 3374, 3183, 3105, 3129, 3193, 3254, 3296, 3339, 3408, 3502, 3609, 3717, 3817, 3910, 4004, 4130, 4245, 4335, 4405, 4464, 4527, 4591, 4653, 4704, 4746, 4783, 4815, 4845, 4874, 4857, 4717, 4508, 4280, 4071, 3883, 3688, 3471, 3236, 2997, 2767, 2549, 2342, 2137, 1964, 1915, 1953, 2024, 2086, 2130, 2182, 2261, 2363, 2477, 2588, 2692, 2790, 2888, 2954, 2905, 2770, 2610, 2460, 2330, 2196, 2037, 1857, 1670, 1487, 1313, 1149, 985, 876, 893, 977, 1080, 1167, 1239, 1324, 1436, 1568, 1706, 1838, 1962, 2080, 2194, 2294, 2394, 2493, 2589, 2681, 2764, 2840, 2910, 2977, 3041, 3100, 3155, 3195, 3291, 2882, 2075, 1686, 1259, 537, 1117};