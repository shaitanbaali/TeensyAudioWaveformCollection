/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0138 256 samples */
 
const int16_t AKWF_0138_256_DATA [256] = 
{667, 2711, 4678, 6607, 8482, 10298, 12050, 13726, 15328, 16854, 18295, 19658, 20939, 22135, 23253, 24292, 25250, 26137, 26950, 27692, 28370, 28983, 29535, 30032, 30475, 30867, 31213, 31516, 31778, 32002, 32191, 32349, 32478, 32579, 32657, 32712, 32747, 32765, 32766, 32752, 32725, 32687, 32639, 32581, 32515, 32442, 32364, 32280, 32192, 32081, 31853, 31393, 30700, 29886, 29039, 28137, 27105, 25893, 24504, 22981, 21360, 19649, 17861, 15997, 14063, 12084, 10072, 8040, 6010, 3988, 1983, 15, -1913, -3792, -5606, -7358, -9042, -10645, -12173, -13623, -14986, -16271, -17474, -18593, -19636, -20600, -21488, -22305, -23051, -23730, -24347, -24903, -25402, -25849, -26244, -26587, -26829, -26882, -26681, -26260, -25712, -25085, -24351, -23454, -22361, -21091, -19683, -18158, -16535, -14827, -13033, -11169, -9258, -7310, -5344, -3381, -1420, 516, 2416, 4277, 6081, 7822, 9500, 11103, 12627, 14075, 15437, 16715, 17912, 19023, 20051, 21001, 21869, 22662, 23382, 24029, 24610, 25129, 25584, 25984, 26330, 26627, 26878, 27086, 27254, 27385, 27484, 27553, 27594, 27610, 27604, 27578, 27532, 27431, 27176, 26684, 25981, 25165, 24302, 23364, 22280, 21019, 19590, 18030, 16373, 14631, 12807, 10916, 8962, 6960, 4937, 2900, 863, -1153, -3148, -5107, -7013, -8867, -10657, -12373, -14018, -15583, -17064, -18465, -19779, -21007, -22153, -23214, -24193, -25094, -25917, -26665, -27345, -27954, -28500, -28987, -29414, -29789, -30114, -30391, -30626, -30821, -30979, -31104, -31197, -31263, -31304, -31322, -31319, -31298, -31260, -31209, -31144, -31068, -30983, -30890, -30790, -30683, -30572, -30457, -30339, -30217, -30095, -29970, -29845, -29720, -29593, -29467, -29342, -29217, -29092, -28968, -28844, -28720, -28596, -28452, -28237, -27882, -27339, -26626, -25804, -24907, -23923, -22809, -21531, -20100, -18544, -16882, -15135, -13312, -11413, -9456, -7457, -5428, -3391, -1312};