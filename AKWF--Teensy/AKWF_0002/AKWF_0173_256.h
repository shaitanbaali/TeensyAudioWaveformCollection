/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0173 256 samples */
 
const int16_t AKWF_0173_256_DATA [256] = 
{10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 11119, 10058, 16156, 22714, 21642, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21693, 22303, 20382, -27709, -34076, -32458, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32590, -33540, -28719, -21032, -22027, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21844, -21843, -21653, -22673, -17208, -10065, -11118, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10921, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10852, -11230, -9704, -141, 54, -24, 0, -1, 0, -1, 0, -1, -1, 0, -1, 0, -1, 0, -1, -1, 0, -1, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, -1, 0, -1, -1, 0, -1, 0, 0, -1, 0};