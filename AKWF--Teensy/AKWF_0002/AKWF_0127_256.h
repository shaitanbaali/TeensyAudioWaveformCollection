/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0127 256 samples */
 
const int16_t AKWF_0127_256_DATA [256] = 
{608, 1631, 2614, 3584, 4536, 5470, 6385, 7278, 8151, 9004, 9832, 10639, 11423, 12182, 12918, 13631, 14317, 14980, 15618, 16228, 16816, 17378, 17913, 18423, 18909, 19367, 19801, 20210, 20592, 20951, 21283, 21591, 21875, 22133, 22368, 22579, 22767, 22935, 23084, 23216, 23335, 23440, 23537, 23627, 23711, 23792, 23873, 23953, 24035, 24119, 24207, 24297, 24393, 24494, 24600, 24713, 24831, 24959, 25093, 25236, 25388, 25551, 25724, 25908, 26106, 26315, 26539, 26778, 27032, 27302, 27590, 27895, 28220, 28566, 28929, 29314, 29713, 30120, 30526, 30923, 31298, 31647, 31959, 32227, 32447, 32613, 32720, 32767, 32751, 32672, 32526, 32318, 32046, 31710, 31314, 30859, 30346, 29779, 29160, 28489, 27775, 27015, 26213, 25375, 24500, 23591, 22656, 21691, 20702, 19694, 18664, 17618, 16561, 15489, 14407, 13322, 12228, 11132, 10037, 8940, 7846, 6758, 5673, 4597, 3532, 2473, 1428, 396, -624, -1627, -2613, -3585, -4537, -5471, -6386, -7279, -8152, -9004, -9832, -10640, -11424, -12182, -12919, -13631, -14317, -14980, -15618, -16229, -16817, -17378, -17913, -18424, -18909, -19368, -19802, -20210, -20593, -20951, -21284, -21591, -21875, -22134, -22368, -22580, -22768, -22935, -23084, -23216, -23334, -23441, -23538, -23627, -23711, -23793, -23873, -23954, -24036, -24120, -24206, -24298, -24393, -24495, -24601, -24713, -24832, -24959, -25094, -25236, -25389, -25552, -25725, -25909, -26106, -26316, -26539, -26778, -27032, -27302, -27590, -27895, -28221, -28566, -28930, -29314, -29713, -30120, -30526, -30923, -31298, -31647, -31959, -32227, -32448, -32613, -32720, -32767, -32752, -32671, -32527, -32318, -32046, -31710, -31314, -30859, -30346, -29779, -29159, -28490, -27775, -27015, -26213, -25375, -24500, -23592, -22656, -21692, -20702, -19694, -18665, -17618, -16561, -15489, -14408, -13322, -12229, -11132, -10038, -8940, -7846, -6759, -5674, -4598, -3533, -2476, -1433, -383};