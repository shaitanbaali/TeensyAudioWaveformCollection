/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0182 256 samples */
 
const int16_t AKWF_0182_256_DATA [256] = 
{10922, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 11063, 10273, 13976, 22485, 21702, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21842, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21790, 22060, 21028, 11377, 10789, 10958, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10922, 10722, 11789, 4934, -850, 194, -1, -1, -1, 0, 0, 0, -1, 0, -1, -1, -1, 0, -1, -2, -103, 491, -8400, -11484, -10800, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -11014, -10498, -12699, -22032, -21816, -21832, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21844, -21843, -21843, -21844, -21843, -21843, -21843, -21843, -21843, -21843, -21844, -21843, -21843, -21843, -21843, -22041, -20979, -27980, -33605, -32573, -32765, -32765, -32766, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32712, -32982, -31950, -22299, -21711, -21880, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21644, -22711, -15857, -10072, -11117, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10739, -11732, -4046, 775, -175, -1, 0, -1, 0, -1, 0, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1};