/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0126 256 samples */
 
const int16_t AKWF_0126_256_DATA [256] = 
{577, 1600, 2591, 3563, 4499, 5403, 6281, 7119, 7920, 8692, 9431, 10136, 10812, 11461, 12082, 12677, 13248, 13799, 14327, 14835, 15329, 15801, 16258, 16702, 17132, 17546, 17949, 18341, 18720, 19091, 19452, 19803, 20145, 20479, 20805, 21124, 21435, 21740, 22038, 22330, 22617, 22898, 23172, 23443, 23708, 23967, 24223, 24474, 24720, 24962, 25200, 25434, 25665, 25890, 26113, 26332, 26548, 26759, 26968, 27173, 27374, 27574, 27769, 27961, 28152, 28338, 28522, 28702, 28880, 29055, 29228, 29397, 29563, 29728, 29889, 30048, 30204, 30357, 30509, 30658, 30803, 30945, 31077, 31206, 31337, 31467, 31591, 31707, 31817, 31919, 32013, 32099, 32179, 32251, 32316, 32376, 32429, 32476, 32520, 32559, 32593, 32623, 32651, 32675, 32697, 32717, 32734, 32749, 32764, 32757, 32675, 32513, 32263, 31693, 30656, 29230, 27457, 25360, 22998, 20408, 17574, 14509, 11249, 7927, 4666, 1466, -1637, -4549, -7262, -9802, -12145, -14267, -16202, -17973, -19561, -20982, -22274, -23433, -24457, -25382, -26213, -26945, -27600, -28188, -28709, -29171, -29585, -29952, -30275, -30562, -30816, -31035, -31222, -31383, -31519, -31628, -31717, -31787, -31835, -31866, -31882, -31882, -31868, -31843, -31806, -31757, -31699, -31633, -31557, -31474, -31385, -31289, -31186, -31078, -30965, -30845, -30722, -30594, -30462, -30325, -30184, -30040, -29892, -29741, -29586, -29428, -29265, -29100, -28932, -28760, -28586, -28408, -28226, -28042, -27854, -27663, -27469, -27272, -27071, -26867, -26660, -26449, -26236, -26017, -25797, -25573, -25344, -25112, -24878, -24637, -24393, -24147, -23895, -23639, -23378, -23114, -22844, -22570, -22291, -22007, -21717, -21422, -21122, -20815, -20501, -20183, -19857, -19522, -19182, -18833, -18474, -18108, -17732, -17343, -16944, -16532, -16084, -15594, -15065, -14497, -13880, -13219, -12523, -11788, -11015, -10212, -9374, -8491, -7572, -6621, -5627, -4597, -3543, -2484, -1441, -391};