/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0192 256 samples */
 
const int16_t AKWF_0192_256_DATA [256] = 
{112, 455, 807, 980, 2194, 6081, 8415, 9569, 10774, 12207, 13736, 14466, 14758, 15049, 15279, 15474, 15638, 15774, 15884, 15969, 16031, 16074, 16103, 16115, 16106, 17182, 18454, 18886, 19184, 19561, 19993, 20439, 20835, 21149, 21387, 21553, 21685, 21777, 21811, 21825, 21801, 21755, 21687, 21573, 21439, 21300, 21152, 20989, 20817, 20636, 20462, 20204, 20619, 21791, 22197, 22319, 22492, 22747, 23039, 23304, 23501, 23625, 23689, 23709, 23692, 23641, 23555, 23435, 23288, 23118, 22927, 22723, 22504, 22273, 22034, 21788, 21534, 21279, 21018, 20757, 20496, 20236, 19962, 20246, 20676, 20675, 20609, 20586, 20610, 20648, 20665, 20646, 20590, 20504, 20398, 20275, 20133, 19975, 19800, 19611, 19413, 19206, 18992, 18772, 18547, 18320, 18089, 17855, 17622, 17388, 17154, 16920, 16688, 16456, 16225, 15997, 15770, 15545, 15323, 15102, 14883, 14667, 14445, 14259, 13755, 12944, 12193, 11442, 10716, 10017, 9327, 8655, 7996, 7372, 6747, 6146, 5546, 4973, 4422, 3875, 3336, 2822, 2318, 1833, 1355, 885, 425, -8, -440, -871, -1279, -1687, -2074, -2458, -2839, -3293, -3069, -11465, -19358, -20772, -21975, -23228, -24723, -26307, -27770, -29003, -29990, -30775, -31410, -31919, -32305, -32570, -32720, -32769, -32733, -32628, -32462, -32242, -31976, -31672, -31332, -30966, -30579, -30172, -29750, -29319, -28878, -28432, -27984, -27533, -27085, -26637, -26192, -25753, -25320, -24891, -24472, -24060, -23655, -23260, -22873, -22494, -22128, -21768, -21418, -21078, -20747, -20424, -20112, -19807, -19512, -19225, -18945, -18673, -18410, -18153, -17903, -17661, -17424, -17193, -16969, -16750, -16535, -16326, -16120, -15930, -15653, -15234, -14932, -14684, -14443, -14135, -13274, -12266, -11349, -10480, -9676, -8923, -8211, -7536, -6910, -6313, -5746, -5209, -4698, -4204, -3737, -3298, -2865, -2447, -2050, -1664, -1281, -915, -558, -216};