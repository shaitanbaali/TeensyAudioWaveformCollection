/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0165 256 samples */
 
const int16_t AKWF_0165_256_DATA [256] = 
{223, 866, 1503, 2149, 2797, 3451, 4108, 4766, 5427, 6089, 6748, 7408, 8066, 8719, 9370, 10009, 10598, 11087, 11356, 11365, 11158, 10778, 10302, 9869, 9597, 9505, 9574, 9772, 10066, 10440, 10916, 11533, 12290, 13165, 14134, 15170, 16248, 17348, 18455, 19550, 20628, 21682, 22701, 23681, 24616, 25500, 26337, 27121, 27850, 28527, 29150, 29718, 30236, 30701, 31115, 31481, 31798, 32067, 32291, 32470, 32606, 32700, 32753, 32767, 32741, 32679, 32579, 32443, 32274, 32072, 31836, 31570, 31273, 30947, 30594, 30215, 29810, 29384, 28935, 28466, 27983, 27486, 26994, 26527, 26075, 25635, 25199, 24753, 24284, 23780, 23233, 22639, 21997, 21306, 20572, 19799, 18989, 18150, 17287, 16402, 15505, 14596, 13679, 12761, 11842, 10926, 10017, 9114, 8221, 7341, 6471, 5615, 4777, 3950, 3141, 2349, 1573, 814, 75, -649, -1354, -2040, -2709, -3359, -3990, -4605, -5200, -5778, -6340, -6882, -7407, -7915, -8406, -8879, -9337, -9778, -10202, -10612, -11005, -11384, -11748, -12096, -12431, -12759, -13116, -13556, -14195, -15072, -16146, -17371, -18668, -19902, -20953, -21796, -22459, -22967, -23353, -23637, -23793, -23782, -23605, -23283, -22842, -22308, -21701, -21105, -20782, -20825, -21105, -21580, -22244, -23089, -24076, -25118, -26118, -26993, -27686, -28180, -28475, -28588, -28545, -28375, -28107, -27764, -27370, -26944, -26500, -26051, -25606, -25170, -24751, -24350, -23968, -23606, -23265, -22942, -22637, -22348, -22072, -21809, -21554, -21307, -21066, -20826, -20587, -20347, -20103, -19853, -19594, -19320, -19017, -18664, -18267, -17836, -17377, -16902, -16427, -15965, -15523, -15107, -14719, -14358, -14023, -13709, -13413, -13132, -12860, -12593, -12328, -12061, -11789, -11509, -11220, -10918, -10604, -10274, -9929, -9569, -9190, -8795, -8384, -7954, -7508, -7046, -6567, -6072, -5563, -5038, -4499, -3948, -3382, -2806, -2218, -1620, -1014, -386};