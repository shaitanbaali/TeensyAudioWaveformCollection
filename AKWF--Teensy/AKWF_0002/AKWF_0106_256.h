/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0106 256 samples */
 
const int16_t AKWF_0106_256_DATA [256] = 
{224, 1001, 1773, 2554, 3343, 4138, 4942, 5747, 6559, 7374, 8190, 9008, 9828, 10644, 11461, 12276, 13086, 13894, 14695, 15489, 16278, 17058, 17828, 18589, 19339, 20075, 20801, 21512, 22208, 22889, 23553, 24198, 24828, 25437, 26026, 26596, 27143, 27669, 28172, 28652, 29108, 29540, 29946, 30326, 30681, 31009, 31310, 31584, 31829, 32047, 32236, 32397, 32529, 32632, 32706, 32750, 32767, 32753, 32709, 32637, 32536, 32406, 32247, 32059, 31844, 31600, 31328, 31029, 30704, 30351, 29973, 29569, 29140, 28686, 28209, 27708, 27184, 26639, 26072, 25484, 24877, 24249, 23604, 22942, 22262, 21565, 20857, 20130, 19392, 18641, 17878, 17104, 16322, 15528, 14728, 13921, 13106, 12288, 11464, 10637, 9808, 8976, 8143, 7311, 6479, 5648, 4822, 3998, 3176, 2362, 1552, 747, -49, -838, -1620, -2391, -3155, -3908, -4649, -5382, -6102, -6809, -7506, -8189, -8859, -9516, -10159, -10787, -11403, -12001, -12586, -13156, -13709, -14247, -14770, -15275, -15764, -16239, -16693, -17132, -17553, -17955, -18341, -18709, -19058, -19388, -19700, -19992, -20267, -20521, -20756, -20972, -21169, -21347, -21506, -21646, -21766, -21868, -21952, -22019, -22067, -22100, -22115, -22117, -22103, -22076, -22037, -21986, -21924, -21853, -21775, -21689, -21598, -21502, -21403, -21303, -21202, -21101, -21001, -20905, -20810, -20720, -20634, -20552, -20475, -20404, -20338, -20277, -20220, -20167, -20118, -20073, -20031, -19990, -19952, -19913, -19875, -19836, -19795, -19754, -19709, -19661, -19610, -19554, -19493, -19427, -19355, -19277, -19193, -19101, -19001, -18894, -18778, -18653, -18520, -18375, -18220, -18056, -17879, -17690, -17489, -17275, -17049, -16807, -16552, -16282, -15997, -15696, -15380, -15048, -14698, -14332, -13949, -13548, -13131, -12695, -12243, -11773, -11285, -10779, -10257, -9717, -9159, -8585, -7995, -7388, -6766, -6127, -5473, -4806, -4124, -3428, -2720, -2000, -1269, -511};