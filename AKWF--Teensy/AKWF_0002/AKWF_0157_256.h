/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0157 256 samples */
 
const int16_t AKWF_0157_256_DATA [256] = 
{543, 1507, 2422, 3313, 4180, 5027, 5857, 6666, 7462, 8242, 9007, 9760, 10499, 11223, 11935, 12635, 13319, 13992, 14651, 15295, 15926, 16543, 17144, 17733, 18306, 18864, 19408, 19937, 20451, 20951, 21435, 21905, 22360, 22800, 23226, 23640, 24037, 24422, 24793, 25151, 25496, 25829, 26147, 26456, 26751, 27035, 27308, 27571, 27821, 28063, 28295, 28516, 28728, 28932, 29125, 29312, 29490, 29660, 29823, 29979, 30127, 30269, 30404, 30533, 30656, 30774, 30886, 30992, 31094, 31191, 31283, 31371, 31454, 31534, 31610, 31682, 31751, 31815, 31878, 31937, 31992, 32045, 32096, 32144, 32190, 32233, 32274, 32313, 32350, 32385, 32418, 32450, 32480, 32509, 32535, 32561, 32585, 32608, 32630, 32651, 32670, 32689, 32706, 32723, 32733, 32745, 32779, 31145, 28840, 27358, 25811, 24113, 22307, 20443, 18575, 16746, 14972, 13274, 11661, 10127, 8677, 7310, 6013, 4785, 3619, 2506, 1444, 425, -557, -1504, -2421, -3314, -4181, -5027, -5857, -6667, -7462, -8243, -9008, -9760, -10500, -11223, -11936, -12636, -13320, -13993, -14652, -15296, -15927, -16543, -17145, -17733, -18307, -18864, -19409, -19937, -20451, -20951, -21435, -21905, -22360, -22801, -23227, -23640, -24038, -24422, -24794, -25151, -25496, -25829, -26148, -26456, -26751, -27035, -27308, -27571, -27822, -28063, -28294, -28516, -28728, -28932, -29126, -29312, -29490, -29660, -29823, -29979, -30127, -30269, -30404, -30533, -30656, -30774, -30886, -30993, -31094, -31191, -31283, -31371, -31455, -31535, -31610, -31682, -31751, -31815, -31878, -31936, -31992, -32046, -32096, -32144, -32190, -32233, -32274, -32313, -32350, -32385, -32419, -32450, -32480, -32509, -32535, -32561, -32585, -32609, -32630, -32651, -32670, -32689, -32706, -32723, -32733, -32746, -32779, -31145, -28840, -27358, -25812, -24113, -22308, -20443, -18576, -16747, -14972, -13274, -11661, -10127, -8678, -7311, -6013, -4785, -3620, -2509, -1449, -413};