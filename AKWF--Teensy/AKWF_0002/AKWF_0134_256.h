/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0134 256 samples */
 
const int16_t AKWF_0134_256_DATA [256] = 
{1879, 4748, 7300, 9718, 12068, 14359, 16559, 18628, 20555, 22318, 23909, 25334, 26599, 27700, 28644, 29430, 30057, 30535, 30873, 31071, 31133, 31075, 30897, 30599, 30194, 29689, 29084, 28395, 27618, 26764, 25838, 24853, 23807, 22717, 21581, 20405, 19200, 17965, 16708, 15439, 14158, 12877, 11600, 10323, 9059, 7811, 6575, 5362, 4179, 3023, 1902, 816, -240, -1251, -2222, -3149, -4032, -4864, -5648, -6385, -7069, -7713, -8302, -8838, -9326, -9764, -10155, -10496, -10790, -11036, -11235, -11395, -11508, -11574, -11603, -11592, -11547, -11419, -11007, -10156, -8962, -7691, -6512, -5403, -4195, -2754, -972, 1512, 4100, 6293, 8304, 10213, 12070, 13896, 15685, 17441, 19154, 20795, 22351, 23802, 25103, 26237, 27169, 27881, 28307, 27863, 25776, 22163, 18218, 15039, 12761, 10819, 8665, 6138, 3346, 454, -2437, -5238, -7911, -10448, -12816, -15025, -17079, -18963, -20684, -22243, -23638, -24872, -25958, -26892, -27673, -28309, -28799, -29149, -29372, -29467, -29441, -29299, -29048, -28690, -28235, -27686, -27048, -26330, -25545, -24687, -23764, -22791, -21762, -20694, -19594, -18453, -17290, -16111, -14912, -13701, -12486, -11270, -10063, -8856, -7664, -6491, -5340, -4216, -3113, -2037, -998, 8, 976, 1907, 2795, 3639, 4442, 5195, 5908, 6571, 7190, 7759, 8281, 8757, 9187, 9568, 9902, 10191, 10439, 10639, 10791, 10904, 10985, 11021, 11021, 10986, 10914, 10812, 10681, 10517, 10323, 10109, 9872, 9615, 9334, 9033, 8716, 8385, 8048, 7685, 7319, 6957, 6578, 6196, 5813, 5426, 5039, 4653, 4270, 3892, 3518, 3149, 2790, 2431, 2088, 1753, 1427, 1117, 806, 29, -2579, -8328, -14741, -19437, -22398, -24259, -25813, -27386, -28942, -30342, -31476, -32263, -32687, -32743, -32440, -31808, -30857, -29622, -28130, -26408, -24483, -22376, -20125, -17762, -15297, -12764, -10170, -7396, -4364, -1124};