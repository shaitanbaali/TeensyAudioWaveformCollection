/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0132 256 samples */
 
const int16_t AKWF_0132_256_DATA [256] = 
{1073, 2904, 4615, 6559, 8610, 10667, 12720, 14742, 16714, 18600, 20358, 21965, 23394, 24621, 25637, 26430, 26992, 27323, 27421, 27289, 26930, 26353, 25565, 24572, 23387, 22023, 20486, 18797, 16967, 15005, 12935, 10769, 8517, 6206, 3845, 1448, -959, -3368, -5765, -8124, -10441, -12699, -14875, -16967, -18957, -20825, -22564, -24155, -25577, -26823, -27877, -28727, -29371, -29801, -30018, -30024, -29824, -29427, -28841, -28079, -27156, -26083, -24882, -23568, -22153, -20662, -19106, -17500, -15866, -14213, -12553, -10908, -9281, -7686, -6138, -4639, -3199, -1832, -535, 682, 1812, 2856, 3809, 4665, 5425, 6083, 6622, 6959, 7245, 7445, 7506, 7508, 7464, 7379, 7264, 7134, 7004, 6890, 6803, 6755, 6755, 6821, 7047, 7298, 7597, 8006, 8452, 8924, 9416, 9916, 10414, 10891, 11331, 11724, 12058, 12323, 12513, 12622, 12646, 12581, 12428, 12185, 11850, 11427, 10915, 10312, 9622, 8844, 7901, 6831, 5762, 4553, 3284, 1991, 678, -636, -1941, -3217, -4441, -5604, -6689, -7682, -8578, -9371, -10050, -10618, -11071, -11406, -11626, -11730, -11720, -11596, -11359, -11013, -10496, -9827, -9139, -8304, -7388, -6432, -5442, -4432, -3418, -2416, -1448, -531, 325, 1098, 1782, 2346, 2686, 2972, 3132, 3126, 3024, 2835, 2563, 2217, 1813, 1369, 899, 417, -60, -526, -967, -1376, -1748, -2076, -2353, -2579, -2748, -2858, -2909, -2897, -2825, -2691, -2496, -2242, -1930, -1565, -1147, -680, -171, 380, 965, 1578, 2214, 2864, 3511, 4135, 4716, 5239, 5693, 6058, 6327, 6492, 6551, 6499, 6336, 6064, 5688, 5216, 4655, 4017, 3309, 2548, 1741, 898, 37, -836, -1709, -2569, -3407, -4214, -4975, -5687, -6339, -6920, -7427, -7851, -8184, -8422, -8561, -8596, -8524, -8342, -8049, -7645, -7128, -6502, -5763, -4916, -3963, -2902, -1735, -414};