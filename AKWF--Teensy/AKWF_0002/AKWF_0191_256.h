/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0191 256 samples */
 
const int16_t AKWF_0191_256_DATA [256] = 
{-10923, -10922, -10922, -10922, -10923, -10923, -10922, -10922, -10923, -10923, -10923, -10922, -10923, -10922, -10922, -10922, -10922, -10922, -10923, -10923, -10922, -10922, -10922, -10923, -10923, -10922, -10922, -10923, -10923, -10922, -10923, -10922, -10923, -10923, -10923, -10923, -10922, -10923, -10922, -10922, -10923, -10923, -10922, -10923, -10922, -10922, -10923, -10922, -10923, -10923, -10923, -10923, -10922, -10922, -10923, -10922, -10923, -10923, -10922, -10922, -10922, -10923, -10923, -10923, -10923, -10923, -10923, -10922, -10922, -10923, -10922, -11110, -10097, -17850, -21772, -26900, -33638, -32566, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32725, -32919, -32225, -22565, -21648, -21893, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21737, -22338, -19703, -10570, -10991, -10928, -10923, -10922, -10923, -10923, -10922, -10923, -10922, -10923, -10922, -10922, -10922, -10724, -11790, -4935, 849, -195, 0, -1, 0, -1, 0, -1, 0, -1, -1, -1, 0, -1, -1, 0, -1, 0, -1, 0, -1, -1, -1, 0, 0, 179, -791, 4192, 11747, 10734, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10820, 11393, 8904, -301, 54, 6, 0, -1, -1, -1, -1, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, -1, 0, 0, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, 0, -1, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1};