/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0161 256 samples */
 
const int16_t AKWF_0161_256_DATA [256] = 
{1381, 3874, 6125, 8214, 10110, 11791, 13256, 14529, 15596, 16526, 17395, 18178, 18895, 19575, 20225, 20833, 21418, 21994, 22531, 23051, 23566, 24051, 24483, 24934, 25374, 25769, 26166, 26556, 26910, 27244, 27588, 27894, 28182, 28479, 28756, 28991, 29230, 29474, 29678, 29876, 30084, 30251, 30412, 30579, 30710, 30793, 30868, 30890, 30817, 30681, 30479, 30169, 29764, 29313, 28799, 28213, 27646, 27109, 26596, 26174, 25968, 25377, 24141, 22855, 21753, 20876, 20147, 19489, 18862, 18270, 17752, 17280, 16824, 16429, 16077, 15728, 15414, 15133, 14844, 14546, 14275, 14009, 13721, 13442, 13173, 12891, 12595, 12316, 12033, 11731, 11449, 11166, 10875, 10546, 10142, 9713, 9286, 8913, 8563, 8197, 7848, 7543, 7247, 6925, 6572, 6158, 5705, 5260, 4842, 4436, 4035, 3647, 3259, 2868, 2513, 2208, 1963, 1816, 1772, 1848, 2048, 2383, 2826, 3323, 3793, 4618, 5665, 6457, 7249, 7946, 8560, 9133, 9629, 9988, 10203, 10291, 10256, 10117, 9920, 9676, 9390, 9102, 8807, 8497, 8196, 7906, 7613, 7318, 7039, 6767, 6487, 6222, 5968, 5713, 5460, 5225, 4998, 4744, 4379, 3924, 3362, 2644, 1731, 218, -1635, -3491, -5546, -7588, -9442, -11032, -12355, -13413, -14315, -15086, -15758, -16379, -16978, -17580, -18204, -18869, -19569, -20287, -21029, -21763, -22440, -23070, -23519, -24621, -25429, -26321, -27753, -28970, -29982, -30617, -31022, -31383, -31725, -32007, -32239, -32440, -32571, -32657, -32727, -32761, -32746, -32733, -32702, -32626, -32538, -32451, -32318, -32178, -32039, -31875, -31679, -31498, -31303, -31067, -30835, -30604, -30332, -30069, -29896, -29720, -29491, -29246, -28975, -28664, -28336, -27985, -27591, -27184, -26831, -26509, -26170, -25829, -25467, -25054, -24611, -24172, -23702, -23178, -22630, -22025, -21310, -20480, -19532, -18411, -17088, -15593, -13879, -11764, -9572, -6979, -4007, -1218};