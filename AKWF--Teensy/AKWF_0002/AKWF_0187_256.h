/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0187 256 samples */
 
const int16_t AKWF_0187_256_DATA [256] = 
{10922, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10922, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 11078, 10214, 14393, 22571, 21681, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21731, 22359, 19577, 10519, 11001, 10925, 10921, 10921, 10720, 11792, 5235, -863, 198, -183, 804, -4340, -11760, -10731, -10922, -10922, -11118, -10065, -17207, -22673, -21654, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21844, -21843, -21844, -21843, -21843, -21843, -21843, -21844, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21844, -21843, -21843, -21843, -21843, -21843, -21843, -21843, -21844, -21843, -21843, -21843, -21843, -22000, -21136, -25315, -33493, -32603, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32703, -33027, -31754, -22135, -21751, -21874, -21843, -21843, -21813, -21936, -21551, -11933, -10660, -10821, -11650, -3472, 706, -157, -1, 0, 0, -1, -1};