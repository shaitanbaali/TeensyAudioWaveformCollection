/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0105 256 samples */
 
const int16_t AKWF_0105_256_DATA [256] = 
{286, 963, 1627, 2294, 2961, 3627, 4295, 4959, 5622, 6283, 6939, 7594, 8245, 8889, 9530, 10166, 10794, 11417, 12033, 12641, 13242, 13835, 14418, 14993, 15558, 16113, 16659, 17192, 17715, 18228, 18728, 19215, 19692, 20155, 20605, 21042, 21465, 21875, 22271, 22652, 23019, 23371, 23708, 24029, 24336, 24627, 24902, 25161, 25404, 25631, 25841, 26035, 26212, 26372, 26515, 26642, 26750, 26842, 26916, 26973, 27012, 27033, 27037, 27023, 26992, 26943, 26876, 26791, 26690, 26570, 26433, 26279, 26106, 25917, 25711, 25488, 25247, 24991, 24718, 24428, 24122, 23800, 23462, 23110, 22741, 22357, 21960, 21546, 21119, 20679, 20224, 19756, 19276, 18782, 18277, 17760, 17230, 16691, 16140, 15578, 15007, 14427, 13836, 13239, 12632, 12016, 11395, 10767, 10130, 9491, 8844, 8191, 7536, 6876, 6211, 5546, 4876, 4205, 3533, 2859, 2185, 1512, 837, 165, -505, -1175, -1841, -2504, -3164, -3819, -4469, -5116, -5755, -6389, -7018, -7637, -8250, -8856, -9452, -10040, -10619, -11187, -11746, -12295, -12831, -13357, -13871, -14372, -14862, -15338, -15801, -16251, -16687, -17108, -17516, -17908, -18285, -18648, -18994, -19325, -19641, -19939, -20222, -20488, -20738, -20971, -21187, -21386, -21568, -21732, -21880, -22010, -22123, -22218, -22296, -22357, -22401, -22427, -22436, -22428, -22403, -22361, -22302, -22226, -22134, -22025, -21931, -21619, -22337, -24177, -24629, -25498, -25552, -25613, -25467, -25102, -24721, -24430, -24212, -24022, -23832, -23637, -23448, -23270, -23107, -22954, -22806, -22655, -22496, -22324, -22135, -21928, -21701, -21455, -21191, -20908, -20609, -20294, -19964, -19619, -19262, -18891, -18509, -18115, -17708, -17292, -16864, -16424, -15974, -15514, -15042, -14562, -14069, -13566, -13054, -12531, -11998, -11456, -10904, -10341, -9772, -9192, -8603, -8009, -7404, -6793, -6176, -5550, -4919, -4283, -3640, -2994, -2343, -1689, -1033, -360};