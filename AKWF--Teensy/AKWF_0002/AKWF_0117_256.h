/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0117 256 samples */
 
const int16_t AKWF_0117_256_DATA [256] = 
{636, 2360, 4028, 5676, 7294, 8883, 10441, 11958, 13440, 14885, 16283, 17637, 18944, 20195, 21393, 22530, 23602, 24609, 25546, 26409, 27200, 27917, 28557, 29126, 29622, 30049, 30412, 30712, 30957, 31151, 31299, 31409, 31484, 31532, 31557, 31567, 31565, 31556, 31545, 31534, 31527, 31527, 31535, 31551, 31578, 31615, 31662, 31717, 31781, 31852, 31928, 32009, 32092, 32175, 32257, 32338, 32414, 32484, 32549, 32606, 32656, 32696, 32727, 32750, 32762, 32766, 32761, 32747, 32725, 32696, 32660, 32617, 32570, 32517, 32460, 32399, 32335, 32270, 32201, 32131, 32060, 31986, 31911, 31834, 31756, 31674, 31590, 31502, 31410, 31312, 31207, 31095, 30973, 30839, 30693, 30532, 30354, 30158, 29939, 29695, 29425, 29124, 28789, 28418, 28005, 27548, 27042, 26482, 25865, 25187, 24441, 23624, 22734, 21764, 20714, 19584, 18369, 17074, 15703, 14256, 12743, 11173, 9549, 7888, 6199, 4487, 2769, 1052, -660, -2353, -4026, -5677, -7295, -8884, -10442, -11959, -13441, -14886, -16283, -17637, -18945, -20195, -21393, -22531, -23602, -24609, -25546, -26409, -27200, -27916, -28557, -29126, -29622, -30049, -30411, -30712, -30957, -31151, -31299, -31408, -31484, -31532, -31558, -31567, -31565, -31556, -31545, -31534, -31527, -31527, -31535, -31551, -31578, -31615, -31661, -31718, -31781, -31852, -31929, -32009, -32092, -32175, -32257, -32338, -32414, -32484, -32549, -32606, -32655, -32696, -32727, -32749, -32762, -32766, -32760, -32747, -32725, -32696, -32660, -32618, -32570, -32517, -32460, -32400, -32336, -32270, -32201, -32131, -32059, -31986, -31911, -31834, -31755, -31674, -31590, -31502, -31410, -31312, -31207, -31095, -30973, -30839, -30693, -30533, -30354, -30158, -29939, -29695, -29425, -29124, -28789, -28418, -28006, -27548, -27042, -26483, -25865, -25187, -24441, -23624, -22734, -21764, -20714, -19584, -18370, -17074, -15704, -14256, -12743, -11174, -9550, -7888, -6199, -4490, -2778, -1030};