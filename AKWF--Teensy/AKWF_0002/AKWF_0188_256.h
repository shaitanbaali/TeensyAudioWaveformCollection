/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0188 256 samples */
 
const int16_t AKWF_0188_256_DATA [256] = 
{10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10921, 10922, 10922, 10921, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10839, 11299, 9375, -66, -5, 15, 0, -1, 0, -1, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, -1, 0, -1, -1, 0, -1, -1, -1, 0, -1, 0, -1, 0, 0, -1, 0, 0, -1, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, -1, 0, -1, 0, 0, -1, -137, 626, -2920, -11531, -10790, -11119, -10065, -17208, -22674, -21655, -21844, -21844, -21844, -21844, -22031, -21019, -28574, -33557, -32587, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32714, -32984, -31951, -22299, -21712, -21881, -21844, -21844, -21844, -21844, -21844, -21844, -21774, -22152, -20626, -11063, -10867, -10946, -10722, -11793, -5085, 856, -197, 0, -1, 0, -1, 0, 0};