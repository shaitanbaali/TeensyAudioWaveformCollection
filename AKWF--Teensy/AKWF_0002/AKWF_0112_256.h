/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0112 256 samples */
 
const int16_t AKWF_0112_256_DATA [256] = 
{5130, 11940, 17124, 21138, 24188, 26480, 28188, 29443, 30367, 31040, 31526, 31880, 32134, 32315, 32445, 32538, 32605, 32651, 32685, 32708, 32725, 32736, 32745, 32751, 32755, 32758, 32759, 32761, 32762, 32763, 32763, 32764, 32764, 32764, 32764, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32764, 32765, 32765, 32764, 32764, 32765, 32765, 32764, 32765, 32765, 32764, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32759, 32712, 32901, 29726, 21870, 12573, 2912, -5259, -11895, -17111, -21138, -24188, -26480, -28188, -29444, -30367, -31040, -31527, -31880, -32133, -32315, -32445, -32538, -32605, -32651, -32685, -32708, -32725, -32737, -32745, -32750, -32755, -32758, -32759, -32761, -32762, -32763, -32763, -32764, -32764, -32764, -32765, -32764, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32764, -32764, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32759, -32712, -32902, -29726, -21884, -12601, -2819};