/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0198 256 samples */
 
const int16_t AKWF_0198_256_DATA [256] = 
{304, 1140, 1949, 2691, 3377, 4042, 4688, 5315, 5928, 6526, 7108, 7679, 8240, 8787, 9325, 9853, 10371, 10883, 11385, 11880, 12369, 12852, 13329, 13802, 14272, 14736, 15198, 15657, 16113, 16570, 17024, 17477, 17932, 18385, 18840, 19297, 19753, 20212, 20673, 21136, 21600, 22069, 22538, 23012, 23488, 23967, 24449, 24934, 25420, 25910, 26404, 26897, 27393, 27897, 28328, 28796, 29204, 29611, 29996, 30357, 30701, 31030, 31278, 31474, 31661, 31833, 31992, 32137, 32268, 32385, 32487, 32573, 32645, 32699, 32738, 32761, 32768, 32759, 32734, 32694, 32640, 32569, 32486, 32389, 32278, 32154, 32019, 31871, 31713, 31542, 31363, 31172, 30911, 30610, 30302, 29980, 29646, 29302, 28949, 28584, 28211, 27829, 27437, 27037, 26628, 26211, 25787, 25354, 24913, 24465, 24009, 23545, 23075, 22595, 22108, 21615, 21111, 20600, 20081, 19552, 19017, 18472, 17917, 17354, 16781, 16198, 15605, 15002, 14389, 13765, 13131, 12484, 11828, 11161, 10479, 9787, 9082, 8363, 7633, 6886, 6126, 5350, 4557, 3741, 2909, 2019, 1039, 56, -936, -1933, -2860, -3733, -4593, -5439, -6279, -7109, -7930, -8746, -9554, -10353, -11149, -11934, -12711, -13482, -14243, -14995, -15739, -16472, -17195, -17909, -18610, -19300, -19980, -20646, -21300, -21942, -22569, -23185, -23786, -24373, -24947, -25509, -26022, -26532, -27004, -27451, -27876, -28271, -28639, -28984, -29299, -29586, -29844, -30074, -30275, -30449, -30593, -30709, -30794, -30850, -30876, -30871, -30835, -30769, -30672, -30546, -30388, -30201, -29987, -29741, -29469, -29169, -28841, -28486, -28106, -27701, -27272, -26819, -26343, -25847, -25328, -24789, -24232, -23657, -23064, -22455, -21831, -21192, -20541, -19876, -19200, -18513, -17818, -17113, -16402, -15681, -14955, -14225, -13490, -12749, -12008, -11263, -10516, -9768, -9019, -8268, -7519, -6767, -6015, -5264, -4509, -3751, -2992, -2211, -1368, -506};