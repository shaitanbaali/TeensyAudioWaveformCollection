/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0140 256 samples */
 
const int16_t AKWF_0140_256_DATA [256] = 
{1214, 3295, 5291, 7243, 9134, 10960, 12717, 14393, 15992, 17510, 18940, 20287, 21550, 22726, 23821, 24836, 25769, 26628, 27414, 28128, 28777, 29361, 29886, 30354, 30768, 31133, 31453, 31729, 31965, 32164, 32330, 32465, 32572, 32653, 32710, 32747, 32765, 32765, 32751, 32722, 32682, 32631, 32571, 32502, 32428, 32345, 32259, 32167, 32072, 31973, 31866, 31681, 31289, 30642, 29830, 28958, 28051, 27039, 25848, 24471, 22942, 21295, 19559, 17739, 15835, 13862, 11832, 9758, 7667, 5567, 3469, 1394, -655, -2667, -4622, -6523, -8359, -10119, -11807, -13415, -14936, -16378, -17734, -19002, -20190, -21293, -22314, -23259, -24126, -24918, -25643, -26300, -26893, -27427, -27903, -28327, -28702, -29030, -29315, -29561, -29771, -29946, -30092, -30209, -30295, -30308, -30144, -29725, -29090, -28346, -27544, -26651, -25599, -24352, -22933, -21382, -19721, -17970, -16138, -14223, -12244, -10222, -8164, -6097, -4033, -1977, 51, 2039, 3985, 5869, 7689, 9441, 11113, 12707, 14218, 15641, 16980, 18233, 19396, 20478, 21476, 22392, 23231, 23995, 24684, 25307, 25864, 26359, 26796, 27179, 27511, 27796, 28038, 28238, 28403, 28534, 28634, 28705, 28752, 28775, 28778, 28752, 28614, 28246, 27621, 26836, 25992, 25100, 24083, 22879, 21492, 19950, 18295, 16553, 14722, 12811, 10835, 8800, 6730, 4645, 2552, 469, -1587, -3617, -5600, -7525, -9393, -11189, -12908, -14551, -16109, -17581, -18969, -20266, -21477, -22603, -23642, -24600, -25478, -26276, -27002, -27657, -28244, -28766, -29230, -29636, -29989, -30293, -30552, -30768, -30945, -31086, -31195, -31275, -31326, -31354, -31360, -31347, -31316, -31269, -31210, -31138, -31056, -30965, -30867, -30762, -30652, -30538, -30420, -30299, -30177, -30053, -29928, -29803, -29675, -29521, -29270, -28830, -28174, -27362, -26480, -25535, -24482, -23269, -21878, -20339, -18688, -16939, -15107, -13200, -11219, -9186, -7118, -5026, -2934, -806};