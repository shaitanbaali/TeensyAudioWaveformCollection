/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0121 256 samples */
 
const int16_t AKWF_0121_256_DATA [256] = 
{1027, 3417, 5676, 7849, 9919, 11883, 13738, 15474, 17098, 18611, 20008, 21302, 22492, 23580, 24578, 25487, 26311, 27060, 27736, 28345, 28895, 29387, 29828, 30223, 30575, 30887, 31165, 31412, 31630, 31822, 31989, 32138, 32266, 32377, 32473, 32553, 32619, 32672, 32713, 32742, 32760, 32767, 32764, 32751, 32727, 32695, 32652, 32600, 32538, 32465, 32381, 32285, 32179, 32059, 31926, 31780, 31620, 31446, 31256, 31053, 30835, 30603, 30357, 30099, 29827, 29545, 29254, 28954, 28648, 28338, 28026, 27715, 27406, 27102, 26807, 26523, 26252, 26000, 25768, 25559, 25380, 25234, 25130, 25076, 25075, 25131, 25239, 25394, 25584, 25800, 26033, 26273, 26512, 26744, 26962, 27163, 27344, 27502, 27637, 27745, 27824, 27874, 27890, 27869, 27809, 27707, 27559, 27360, 27105, 26791, 26410, 25956, 25419, 24788, 24051, 23196, 22205, 21072, 19791, 18355, 16773, 15053, 13199, 11233, 9170, 7022, 4816, 2570, 293, -1963, -4161, -6290, -8331, -10284, -12142, -13893, -15545, -17094, -18536, -19880, -21126, -22273, -23332, -24304, -25191, -26003, -26743, -27413, -28022, -28571, -29067, -29514, -29915, -30274, -30596, -30883, -31137, -31364, -31563, -31738, -31891, -32022, -32134, -32229, -32306, -32367, -32413, -32446, -32466, -32474, -32469, -32455, -32430, -32394, -32349, -32294, -32230, -32156, -32072, -31980, -31877, -31765, -31643, -31511, -31371, -31223, -31065, -30900, -30728, -30549, -30365, -30177, -29985, -29791, -29596, -29402, -29211, -29023, -28841, -28665, -28498, -28340, -28195, -28063, -27945, -27846, -27765, -27709, -27679, -27681, -27719, -27791, -27896, -28027, -28180, -28347, -28522, -28698, -28872, -29038, -29192, -29334, -29459, -29566, -29656, -29726, -29775, -29801, -29801, -29774, -29717, -29628, -29504, -29339, -29131, -28874, -28563, -28193, -27752, -27232, -26623, -25907, -25070, -24098, -22969, -21681, -20229, -18610, -16835, -14918, -12865, -10703, -8451, -6126, -3759, -1313};