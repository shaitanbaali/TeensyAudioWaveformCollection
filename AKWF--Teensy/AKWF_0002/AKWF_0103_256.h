/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0103 256 samples */
 
const int16_t AKWF_0103_256_DATA [256] = 
{-2921, -9824, -15333, -19192, -21555, -22872, -23562, -23898, -24037, -24058, -24002, -23894, -23751, -23586, -23406, -23216, -23021, -22822, -22621, -22419, -22215, -22010, -21806, -21601, -21396, -21191, -20985, -20780, -20575, -20369, -20164, -19959, -19753, -19548, -19343, -19137, -18932, -18727, -18521, -18316, -18111, -17905, -17700, -17494, -17289, -17084, -16878, -16673, -16468, -16262, -16056, -15852, -15646, -15440, -15235, -15030, -14824, -14619, -14414, -14208, -14003, -13798, -13592, -13387, -13181, -12976, -12771, -12565, -12360, -12155, -11949, -11744, -11538, -11333, -11128, -10922, -10717, -10512, -10306, -10101, -9896, -9690, -9485, -9280, -9074, -8868, -8663, -8458, -8252, -8047, -7842, -7636, -7431, -7225, -7020, -6815, -6609, -6404, -6199, -5993, -5788, -5583, -5377, -5172, -4967, -4761, -4556, -4350, -4145, -3940, -3734, -3529, -3324, -3118, -2912, -2708, -2502, -2296, -2091, -1886, -1680, -1475, -1270, -1064, -859, -654, -448, -243, -37, 168, 373, 579, 784, 989, 1195, 1400, 1605, 1811, 2016, 2222, 2427, 2632, 2838, 3043, 3248, 3454, 3660, 3864, 4070, 4276, 4481, 4686, 4892, 5097, 5303, 5508, 5713, 5919, 6124, 6329, 6535, 6740, 6945, 7151, 7356, 7562, 7767, 7972, 8178, 8384, 8588, 8794, 8999, 9205, 9410, 9616, 9821, 10026, 10232, 10437, 10642, 10848, 11053, 11259, 11464, 11669, 11875, 12080, 12285, 12491, 12696, 12902, 13107, 13312, 13518, 13723, 13928, 14134, 14339, 14545, 14750, 14956, 15161, 15366, 15572, 15777, 15982, 16188, 16393, 16599, 16804, 17009, 17215, 17420, 17625, 17831, 18036, 18241, 18447, 18652, 18857, 19063, 19268, 19474, 19679, 19884, 20090, 20296, 20501, 20706, 20912, 21117, 21322, 21528, 21733, 21938, 22144, 22349, 22555, 22760, 22965, 23171, 23376, 23581, 23787, 23992, 24197, 24403, 24608, 24814, 24965, 25404, 24396, 18673, 12490, 4299};