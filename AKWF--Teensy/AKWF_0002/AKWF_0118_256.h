/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0118 256 samples */
 
const int16_t AKWF_0118_256_DATA [256] = 
{1714, 4287, 6570, 8592, 10381, 11967, 13382, 14653, 15813, 16883, 17877, 18812, 19694, 20527, 21320, 22075, 22793, 23476, 24127, 24745, 25335, 25893, 26422, 26923, 27398, 27844, 28265, 28661, 29033, 29383, 29709, 30013, 30299, 30563, 30808, 31035, 31245, 31438, 31615, 31777, 31924, 32058, 32178, 32286, 32381, 32464, 32537, 32599, 32651, 32692, 32725, 32748, 32762, 32768, 32764, 32754, 32735, 32708, 32674, 32634, 32585, 32530, 32468, 32400, 32325, 32244, 32157, 32065, 31966, 31863, 31753, 31639, 31520, 31396, 31269, 31135, 30999, 30859, 30714, 30567, 30418, 30264, 30108, 29950, 29790, 29629, 29467, 29302, 29138, 28972, 28807, 28641, 28475, 28309, 28145, 27980, 27817, 27655, 27494, 27334, 27177, 27021, 26866, 26714, 26563, 26415, 26269, 26125, 25982, 25842, 25704, 25568, 25434, 25301, 25171, 25043, 24917, 24792, 24670, 24548, 24428, 24310, 24193, 24078, 23964, 23850, 23738, 23626, 23515, 23405, 23295, 23186, 23078, 22970, 22863, 22756, 22648, 22541, 22434, 22326, 22219, 22112, 22004, 21897, 21789, 21680, 21571, 21462, 21351, 21241, 21130, 21020, 20908, 20795, 20683, 20569, 20454, 20340, 20212, 19846, 19228, 18416, 17270, 15728, 13148, 9407, 5678, 1525, -2776, -6783, -10255, -13165, -15557, -17505, -19105, -20424, -21517, -22435, -23210, -23865, -24426, -24906, -25316, -25669, -25972, -26229, -26448, -26634, -26787, -26914, -27016, -27096, -27155, -27196, -27220, -27228, -27222, -27203, -27171, -27128, -27075, -27011, -26939, -26857, -26768, -26672, -26568, -26457, -26338, -26215, -26084, -25948, -25807, -25659, -25507, -25349, -25185, -25015, -24840, -24658, -24471, -24276, -24074, -23866, -23649, -23425, -23192, -22950, -22697, -22434, -22159, -21871, -21570, -21253, -20921, -20571, -20202, -19813, -19400, -18961, -18496, -18001, -17471, -16907, -16302, -15655, -14950, -14172, -13316, -12357, -11256, -9991, -8165, -5827, -3506, -876};