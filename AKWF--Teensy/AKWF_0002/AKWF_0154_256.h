/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0154 256 samples */
 
const int16_t AKWF_0154_256_DATA [256] = 
{141, 441, 737, 1035, 1334, 1635, 1939, 2246, 2554, 2866, 3180, 3497, 3817, 4140, 4466, 4796, 5127, 5463, 5800, 6140, 6483, 6829, 7176, 7527, 7878, 8232, 8588, 8946, 9304, 9665, 10027, 10389, 10754, 11119, 11484, 11851, 12217, 12584, 12951, 13318, 13685, 14052, 14418, 14784, 15150, 15514, 15878, 16241, 16602, 16962, 17322, 17678, 18035, 18389, 18741, 19092, 19441, 19787, 20131, 20473, 20812, 21149, 21483, 21814, 22143, 22469, 22791, 23111, 23427, 23739, 24049, 24355, 24657, 24956, 25251, 25543, 25830, 26112, 26392, 26668, 26938, 27205, 27468, 27725, 27979, 28227, 28471, 28711, 28946, 29175, 29400, 29620, 29835, 30045, 30250, 30449, 30643, 30833, 31016, 31195, 31368, 31535, 31698, 31854, 32005, 32150, 32290, 32424, 32505, 32766, 32214, 24178, 17028, 14673, 13222, 12130, 11497, 11188, 10885, 10347, 9506, 8397, 7067, 5555, 3884, 2070, 162, -1800, -3778, -5729, -7633, -9475, -11233, -12905, -14485, -15961, -17339, -18617, -19794, -20876, -21866, -22765, -23582, -24319, -24979, -25571, -26096, -26559, -26965, -27319, -27622, -27881, -28097, -28273, -28414, -28520, -28597, -28643, -28664, -28659, -28633, -28585, -28517, -28430, -28327, -28208, -28074, -27926, -27766, -27593, -27410, -27214, -27010, -26796, -26573, -26341, -26103, -25856, -25601, -25341, -25074, -24800, -24522, -24237, -23947, -23653, -23352, -23048, -22740, -22427, -22110, -21790, -21465, -21137, -20806, -20471, -20135, -19794, -19451, -19106, -18759, -18408, -18056, -17702, -17345, -16988, -16628, -16267, -15905, -15542, -15177, -14812, -14446, -14079, -13712, -13345, -12977, -12610, -12242, -11874, -11508, -11141, -10776, -10412, -10048, -9687, -9327, -8969, -8613, -8259, -7907, -7560, -7215, -6874, -6537, -6205, -5878, -5559, -5248, -4950, -4659, -4364, -4065, -3763, -3459, -3153, -2847, -2541, -2237, -1936, -1634, -1335, -1038, -742, -447, -146};