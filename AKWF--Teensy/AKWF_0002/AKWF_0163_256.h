/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0163 256 samples */
 
const int16_t AKWF_0163_256_DATA [256] = 
{1019, 2723, 4271, 5686, 6979, 8169, 9272, 10300, 11270, 12194, 13075, 13926, 14749, 15544, 16317, 17069, 17799, 18510, 19202, 19873, 20527, 21161, 21775, 22371, 22949, 23507, 24048, 24569, 25073, 25560, 26028, 26479, 26914, 27330, 27731, 28114, 28482, 28833, 29169, 29488, 29792, 30081, 30354, 30613, 30856, 31084, 31298, 31497, 31681, 31850, 32006, 32146, 32273, 32385, 32482, 32564, 32634, 32688, 32729, 32754, 32766, 32764, 32748, 32718, 32674, 32616, 32545, 32460, 32361, 32251, 32125, 31987, 31837, 31674, 31498, 31310, 31110, 30898, 30675, 30441, 30195, 29939, 29672, 29396, 29108, 28812, 28507, 28192, 27869, 27539, 27200, 26854, 26501, 26141, 25774, 25401, 25023, 24640, 24251, 23856, 23459, 23057, 22652, 22242, 21831, 21415, 20999, 20579, 20158, 19735, 19312, 18887, 18462, 18035, 17609, 17183, 16758, 16333, 15910, 15487, 15065, 14647, 14229, 13814, 13370, 12912, 12443, 11968, 11492, 11017, 10546, 10079, 9620, 9163, 8709, 8259, 7811, 7365, 6923, 6482, 6044, 5610, 5176, 4745, 4317, 3892, 3468, 3050, 2634, 2222, 1816, 1413, 1015, 623, 235, -147, -522, -892, -1262, -1744, -2343, -3032, -3878, -4916, -6458, -8569, -10667, -12966, -15331, -17542, -19478, -21127, -22510, -23662, -24634, -25457, -26158, -26762, -27286, -27740, -28137, -28484, -28786, -29050, -29279, -29473, -29640, -29778, -29890, -29978, -30043, -30087, -30109, -30111, -30095, -30060, -30008, -29938, -29852, -29749, -29632, -29499, -29350, -29188, -29011, -28822, -28618, -28401, -28172, -27930, -27676, -27410, -27132, -26842, -26543, -26231, -25908, -25576, -25232, -24878, -24514, -24139, -23755, -23360, -22955, -22541, -22116, -21681, -21237, -20782, -20316, -19840, -19353, -18854, -18346, -17825, -17291, -16745, -16185, -15609, -15020, -14414, -13789, -13148, -12484, -11801, -11088, -10340, -9554, -8717, -7812, -6825, -5533, -3972, -2408, -676};