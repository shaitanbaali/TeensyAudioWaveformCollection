/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0171 256 samples */
 
const int16_t AKWF_0171_256_DATA [256] = 
{10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 11064, 10274, 13977, 22486, 21703, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21559, 23042, 17285, -30905, -33325, -32599, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32767, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32742, -32821, -32626, -23062, -21536, -21914, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21841, -21752, -22292, -13315, -10383, -11039, -10922, -10923, -10922, -10923, -10923, -10922, -10922, -10923, -10923, -10923, -10923, -10922, -10923, -10922, -10923, -10771, -11610, -7591, 702, -156, 0, 0, -1, 0, 0, -1, 0, 0, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, -1, -1, 0, -1};