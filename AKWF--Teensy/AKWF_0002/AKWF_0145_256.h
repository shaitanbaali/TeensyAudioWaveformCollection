/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0145 256 samples */
 
const int16_t AKWF_0145_256_DATA [256] = 
{761, 2078, 3425, 4810, 6706, 9532, 11360, 12972, 14796, 16677, 18519, 20271, 21895, 23369, 24694, 25864, 26881, 27755, 28487, 29088, 29564, 29921, 30166, 30306, 30347, 30298, 30162, 29944, 29651, 29286, 28857, 28366, 27817, 27216, 26565, 25869, 25133, 24357, 23545, 22703, 21830, 20930, 20009, 19064, 18101, 17124, 16130, 15124, 14110, 13085, 12052, 11018, 9977, 8934, 7892, 6846, 5800, 4755, 3709, 2659, 1599, 592, -910, -3951, -6427, -8645, -10905, -13194, -15511, -17842, -20130, -22295, -24288, -26078, -27646, -29000, -30141, -31069, -31792, -32313, -32634, -32764, -32706, -32468, -32053, -31470, -30726, -29822, -28764, -27553, -26158, -24543, -22555, -18717, -15432, -13205, -10519, -7605, -4614, -1664, 1156, 3817, 6295, 8572, 10657, 12549, 14246, 15760, 17097, 18259, 19258, 20101, 20790, 21340, 21752, 22037, 22199, 22246, 22185, 22021, 21761, 21412, 20976, 20463, 19876, 19219, 18501, 17724, 16891, 16011, 15085, 14114, 13110, 12068, 10994, 9895, 8766, 7611, 6436, 5232, 4001, 2744, 1443, 74, -1328, -3637, -6329, -7971, -9699, -11582, -13496, -15363, -17125, -18751, -20233, -21560, -22731, -23755, -24634, -25375, -25986, -26471, -26841, -27101, -27258, -27319, -27288, -27173, -26978, -26708, -26368, -25938, -25390, -24719, -23948, -23099, -22174, -21130, -19919, -18478, -15284, -12290, -10447, -8218, -5743, -3167, -590, 1908, 4288, 6536, 8631, 10573, 12366, 14003, 15488, 16825, 18011, 19048, 19903, 20487, 20760, 20781, 20652, 20417, 20031, 19422, 18538, 17435, 15584, 12012, 9748, 7831, 5490, 2965, 397, -2124, -4524, -6766, -8838, -10723, -12420, -13938, -15273, -16432, -17427, -18260, -18939, -19475, -19872, -20139, -20283, -20310, -20227, -20041, -19759, -19386, -18927, -18391, -17783, -17104, -16364, -15565, -14712, -13813, -12867, -11881, -10862, -9805, -8721, -7611, -6474, -5317, -4139, -2943, -1729, -469};