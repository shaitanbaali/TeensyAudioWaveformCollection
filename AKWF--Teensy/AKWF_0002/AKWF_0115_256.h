/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0115 256 samples */
 
const int16_t AKWF_0115_256_DATA [256] = 
{-1013, -2616, -4238, -5887, -7546, -9201, -10830, -12416, -13930, -15343, -16621, -17747, -18668, -19365, -19793, -19893, -19627, -18982, -18032, -16858, -15544, -14184, -12857, -11606, -10487, -9522, -8724, -8122, -7722, -7518, -7512, -7694, -8041, -8537, -9174, -9933, -10803, -11779, -12849, -13991, -15188, -16414, -17629, -18794, -19873, -20826, -21635, -22269, -22721, -22974, -23013, -22824, -22425, -21903, -21332, -20778, -20299, -19921, -19676, -19581, -19625, -19806, -20095, -20437, -21072, -21635, -21166, -22413, -27471, -27876, -25518, -27882, -29427, -28675, -28314, -28433, -28008, -26970, -25755, -24490, -22810, -20656, -18375, -16023, -13434, -10616, -9624, -6061, 4028, 6355, 3653, 7351, 10896, 10770, 11063, 12440, 13140, 12952, 12722, 12800, 12532, 11751, 11045, 10455, 9382, 8141, 8105, 7058, 1806, 416, 3212, 1515, -694, 260, 1077, 1003, 1348, 2229, 3131, 3521, 3906, 4479, 4639, 4413, 4159, 3705, 3013, 2201, 1352, 481, -421, -1321, -2176, -2996, -3768, -4460, -5061, -5552, -5912, -6110, -6128, -5945, -5539, -4896, -4005, -2875, -1508, 50, 1759, 3559, 5383, 7179, 8883, 10471, 11923, 13205, 14306, 15196, 15848, 16233, 16361, 16259, 15975, 15522, 14916, 14169, 13306, 12359, 11351, 10317, 9309, 8357, 7501, 6787, 6233, 5859, 5680, 5699, 5901, 6262, 6744, 7308, 7897, 8464, 8972, 9386, 9674, 9820, 9803, 9632, 9311, 8866, 8334, 7741, 7112, 6465, 5821, 5188, 4590, 4041, 3563, 3174, 2906, 2793, 2862, 3140, 3665, 4456, 5513, 6832, 8375, 10065, 11782, 13309, 13140, 16068, 28403, 30462, 26016, 29490, 32899, 31772, 31241, 32050, 32059, 31083, 30111, 29500, 28539, 27060, 25670, 24350, 22775, 21065, 19439, 17857, 16270, 14766, 13432, 12267, 11255, 10437, 9824, 9365, 9000, 8695, 8393, 8031, 7575, 6997, 6287, 5417, 4388, 3214, 1911, 460};