/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0130 256 samples */
 
const int16_t AKWF_0130_256_DATA [256] = 
{426, 1351, 2650, 3135, 2862, 3051, 3453, 3529, 5030, 6581, 8390, 10591, 12398, 13329, 13858, 14090, 13771, 14014, 14431, 14467, 14946, 15390, 16253, 16401, 16494, 15681, 14628, 13895, 12906, 13006, 12974, 14500, 15138, 16610, 17034, 17977, 17884, 18771, 18738, 19351, 19510, 20427, 20946, 22372, 23586, 24332, 24974, 25409, 25101, 24663, 23309, 21766, 19181, 16201, 12539, 8221, 4599, 846, -2627, -5769, -8203, -10847, -12061, -13647, -15048, -16303, -17121, -19254, -21069, -23603, -26289, -28537, -30107, -31631, -32167, -32340, -31850, -31047, -30267, -29061, -28275, -27079, -25880, -25067, -24008, -22858, -21313, -19656, -17045, -14574, -12301, -10431, -8427, -7030, -5804, -4615, -3214, -1747, -22, 968, 2057, 2402, 2594, 2831, 2025, 1859, 1297, 659, 257, -365, -518, -470, 74, 1375, 2120, 3261, 3746, 3856, 3092, 2309, 542, -1052, -2777, -4238, -5064, -5105, -5653, -4552, -3561, -1612, 298, 2379, 4386, 5971, 7483, 8677, 9305, 10050, 10446, 11371, 11476, 12604, 12811, 14022, 15240, 16068, 17058, 17246, 18235, 18379, 18948, 19392, 19626, 20094, 20010, 20229, 19900, 19351, 19119, 18042, 17880, 16881, 15941, 15951, 14911, 15066, 14491, 14553, 14283, 13506, 12951, 11738, 10784, 9117, 7263, 5122, 2689, -301, -3063, -6055, -8808, -11134, -12673, -14191, -15725, -16421, -17021, -17647, -17922, -18285, -18599, -18286, -17707, -16970, -15363, -14228, -12444, -10106, -8399, -6527, -4828, -3799, -3015, -1914, -1854, -1182, -732, -595, -583, -566, -1608, -2759, -4366, -6367, -8203, -10091, -10832, -11594, -11487, -10886, -10546, -10034, -9133, -8762, -7843, -7469, -6974, -7002, -6325, -6471, -5628, -5643, -5069, -4750, -4522, -4820, -4573, -5845, -6819, -8250, -9394, -11548, -12321, -13819, -13812, -14661, -14531, -14177, -14010, -12722, -11719, -10100, -7954, -5868, -3708, -1577};