/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0114 256 samples */
 
const int16_t AKWF_0114_256_DATA [256] = 
{-1525, -4362, -6794, -8923, -10786, -12365, -13646, -14669, -15473, -16061, -16447, -16667, -16740, -16678, -16495, -16213, -15845, -15399, -14885, -14316, -13698, -13038, -12342, -11656, -11187, -11026, -11014, -11068, -11212, -11422, -11606, -11735, -11825, -11859, -11809, -11677, -11475, -11203, -10855, -10441, -9971, -9447, -8872, -8253, -7597, -6909, -6189, -5443, -4677, -3890, -3085, -2268, -1437, -599, 253, 944, 771, -515, -2345, -4448, -6908, -9621, -12257, -14735, -17107, -19298, -21211, -22863, -24288, -25478, -26419, -27141, -27679, -28037, -28224, -28270, -28192, -28001, -27708, -27330, -26881, -26364, -25791, -25172, -24510, -23813, -23085, -22372, -21881, -21701, -21672, -21712, -21845, -22044, -22220, -22342, -22426, -22455, -22401, -22264, -22060, -21785, -21434, -21019, -20547, -20021, -19445, -18826, -18169, -17481, -16759, -16012, -15246, -14459, -13654, -12837, -12005, -11163, -10315, -9455, -8590, -7720, -6844, -5965, -5082, -4195, -3306, -2417, -1523, -630, 265, 1163, 2060, 2958, 3858, 4756, 5656, 6558, 7457, 8359, 9261, 10162, 11063, 11967, 12867, 13769, 14672, 15573, 16476, 17378, 18280, 19141, 19759, 20046, 20165, 20203, 20135, 19991, 19863, 19781, 19732, 19730, 19808, 19966, 20187, 20476, 20840, 21266, 21746, 22281, 22862, 23487, 24149, 24841, 25565, 26315, 27083, 27873, 28680, 29498, 30331, 31169, 32021, 32714, 32541, 31257, 29427, 27325, 24865, 22152, 19516, 17038, 14667, 12476, 10563, 8911, 7486, 6296, 5354, 4633, 4095, 3737, 3550, 3504, 3582, 3773, 4066, 4443, 4893, 5410, 5983, 6603, 7265, 7962, 8689, 9402, 9894, 10074, 10102, 10062, 9930, 9730, 9555, 9433, 9348, 9320, 9374, 9510, 9714, 9989, 10340, 10755, 11227, 11754, 12329, 12949, 13606, 14294, 15015, 15762, 16528, 17316, 18121, 18938, 19769, 20606, 21458, 22057, 21522, 19693, 17279, 14536, 11356, 7914, 4598, 1405};