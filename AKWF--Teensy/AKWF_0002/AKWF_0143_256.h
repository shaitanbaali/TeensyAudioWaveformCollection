/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0143 256 samples */
 
const int16_t AKWF_0143_256_DATA [256] = 
{1300, 3329, 5272, 7171, 9013, 10797, 12518, 14167, 15750, 17261, 18694, 20054, 21339, 22544, 23674, 24727, 25703, 26606, 27434, 28190, 28878, 29499, 30054, 30549, 30984, 31363, 31691, 31967, 32198, 32385, 32531, 32639, 32714, 32756, 32769, 32755, 32717, 32656, 32577, 32481, 32368, 32242, 32105, 31957, 31801, 31638, 31469, 31294, 31117, 30936, 30754, 30571, 30388, 30205, 30023, 29842, 29663, 29487, 29312, 29141, 28972, 28806, 28643, 28483, 28326, 28172, 28021, 27872, 27726, 27582, 27441, 27302, 27164, 27030, 26896, 26763, 26631, 26501, 26371, 26242, 26113, 25984, 25856, 25726, 25597, 25467, 25337, 25205, 25073, 24940, 24805, 24670, 24534, 24395, 24256, 24115, 23973, 23830, 23685, 23539, 23392, 23242, 23091, 22940, 22786, 22632, 22475, 22314, 22094, 21722, 21167, 20534, 19904, 19209, 18352, 17304, 16068, 14670, 12779, 10558, 8775, 6970, 5013, 2982, 933, -1104, -3100, -5046, -6940, -8767, -10530, -12227, -13848, -15397, -16873, -18270, -19590, -20835, -21999, -23088, -24099, -25033, -25896, -26685, -27402, -28054, -28640, -29162, -29625, -30032, -30384, -30686, -30941, -31150, -31319, -31448, -31543, -31604, -31635, -31640, -31619, -31576, -31513, -31432, -31335, -31223, -31099, -30966, -30822, -30671, -30515, -30353, -30186, -30018, -29846, -29674, -29501, -29329, -29157, -28987, -28818, -28651, -28487, -28324, -28164, -28008, -27855, -27703, -27555, -27411, -27268, -27128, -26992, -26857, -26725, -26594, -26466, -26340, -26214, -26090, -25968, -25846, -25725, -25604, -25484, -25364, -25243, -25123, -25002, -24880, -24757, -24635, -24511, -24385, -24259, -24131, -24002, -23873, -23740, -23607, -23472, -23336, -23199, -23060, -22919, -22777, -22634, -22489, -22342, -22195, -22045, -21895, -21745, -21592, -21438, -21283, -21128, -20972, -20814, -20647, -20408, -20001, -19418, -18777, -18132, -17403, -16495, -15373, -14060, -12315, -10114, -8344, -6617, -4719, -2731, -668};