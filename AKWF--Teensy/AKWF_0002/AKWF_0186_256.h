/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0186 256 samples */
 
const int16_t AKWF_0186_256_DATA [256] = 
{10921, 10921, 10921, 10922, 10921, 10921, 10921, 11108, 10096, 17651, 22634, 21664, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21842, 21843, 21842, 21843, 21843, 21843, 21843, 21842, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21841, 21740, 22335, 13443, 10359, 11043, 10921, 10921, 10921, 10916, 10853, 11274, 2140, -494, 106, -9, -42, 245, -9025, -11369, -10825, -10935, -10934, -10793, -20182, -22244, -21755, -21843, -21843, -21843, -22005, -21118, -25456, -33517, -32597, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32766, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32566, -33632, -27379, -20973, -22043, -21843, -21843, -21843, -21664, -22634, -17651, -10097, -11109, -10766, -11624, -3332, 687, -153, 0, -1};