/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0104 256 samples */
 
const int16_t AKWF_0104_256_DATA [256] = 
{433, 1087, 1731, 2379, 3028, 3679, 4331, 4981, 5631, 6280, 6924, 7567, 8207, 8841, 9472, 10097, 10714, 11326, 11930, 12525, 13113, 13692, 14259, 14818, 15366, 15901, 16426, 16938, 17437, 17923, 18395, 18853, 19296, 19724, 20137, 20534, 20915, 21280, 21628, 21958, 22271, 22567, 22845, 23104, 23346, 23569, 23773, 23959, 24125, 24273, 24401, 24510, 24600, 24671, 24722, 24754, 24767, 24760, 24734, 24690, 24626, 24543, 24441, 24321, 24182, 24025, 23850, 23657, 23446, 23218, 22972, 22711, 22432, 22136, 21826, 21499, 21156, 20800, 20428, 20042, 19643, 19229, 18803, 18365, 17914, 17451, 16978, 16493, 15998, 15494, 14979, 14456, 13926, 13386, 12839, 12286, 11725, 11160, 10589, 10012, 9433, 8849, 8261, 7672, 7079, 6485, 5891, 5295, 4698, 4104, 3509, 2915, 2325, 1736, 1150, 569, -11, -585, -1153, -1717, -2276, -2826, -3372, -3910, -4440, -4963, -5477, -5982, -6478, -6965, -7441, -7908, -8363, -8808, -9242, -9663, -10073, -10471, -10855, -11228, -11588, -11934, -12266, -12586, -12891, -13182, -13460, -13722, -13971, -14204, -14423, -14627, -14816, -14990, -15149, -15293, -15421, -15535, -15633, -15716, -15784, -15837, -15875, -15898, -15906, -15899, -15877, -15841, -15790, -15724, -15645, -15552, -15444, -15323, -15189, -15041, -14880, -14706, -14520, -14322, -14158, -13673, -14763, -17904, -18691, -20222, -20407, -20610, -20497, -20028, -19540, -19212, -19022, -18892, -18776, -18667, -18579, -18524, -18505, -18516, -18548, -18588, -18626, -18654, -18667, -18661, -18634, -18586, -18517, -18429, -18322, -18199, -18060, -17907, -17740, -17559, -17367, -17163, -16947, -16718, -16479, -16227, -15963, -15687, -15397, -15096, -14781, -14452, -14111, -13755, -13386, -13004, -12607, -12196, -11772, -11334, -10882, -10419, -9941, -9450, -8948, -8432, -7905, -7367, -6817, -6257, -5689, -5108, -4520, -3924, -3319, -2707, -2089, -1464, -836, -189};