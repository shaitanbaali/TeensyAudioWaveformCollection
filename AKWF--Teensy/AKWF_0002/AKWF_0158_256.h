/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0158 256 samples */
 
const int16_t AKWF_0158_256_DATA [256] = 
{372, 1621, 2789, 3834, 4742, 5527, 6213, 6820, 7375, 7893, 8386, 8864, 9331, 9788, 10238, 10682, 11117, 11545, 11965, 12375, 12778, 13170, 13553, 13927, 14290, 14642, 14984, 15314, 15633, 15941, 16236, 16519, 16790, 17047, 17292, 17524, 17743, 17948, 18139, 18316, 18480, 18629, 18764, 18884, 18991, 19082, 19158, 19220, 19267, 19299, 19316, 19318, 19305, 19277, 19234, 19218, 18909, 20027, 22952, 23668, 26541, 27719, 28825, 29195, 28833, 28110, 27298, 26534, 25873, 25320, 24861, 24473, 24128, 23807, 23492, 23173, 22839, 22490, 22120, 21729, 21319, 20886, 20434, 19963, 19472, 18963, 18437, 17892, 17331, 16754, 16161, 15553, 14932, 14296, 13648, 12988, 12316, 11633, 10941, 10237, 9528, 8809, 8083, 7352, 6614, 5871, 5126, 4375, 3622, 2870, 2114, 1358, 605, -149, -901, -1647, -2393, -3134, -3843, -4703, -4807, -2157, -2218, 117, 873, 1500, 1500, 751, -388, -1619, -2788, -3835, -4743, -5528, -6213, -6821, -7375, -7894, -8387, -8865, -9332, -9788, -10239, -10682, -11117, -11545, -11965, -12375, -12778, -13171, -13553, -13927, -14290, -14642, -14984, -15315, -15633, -15941, -16236, -16519, -16790, -17048, -17293, -17525, -17743, -17948, -18139, -18317, -18480, -18629, -18764, -18885, -18991, -19082, -19158, -19220, -19267, -19299, -19316, -19318, -19305, -19277, -19234, -19218, -18909, -20028, -22952, -23668, -26541, -27719, -28826, -29195, -28834, -28110, -27298, -26534, -25873, -25321, -24861, -24473, -24128, -23807, -23493, -23173, -22840, -22490, -22120, -21729, -21319, -20887, -20434, -19963, -19472, -18963, -18437, -17892, -17331, -16755, -16162, -15554, -14933, -14297, -13649, -12989, -12316, -11634, -10941, -10238, -9529, -8810, -8084, -7353, -6615, -5871, -5126, -4376, -3623, -2871, -2115, -1359, -606, 148, 900, 1647, 2392, 3133, 3842, 4703, 4806, 2156, 2217, -118, -874, -1503, -1507, -734};