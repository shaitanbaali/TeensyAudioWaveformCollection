/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0113 256 samples */
 
const int16_t AKWF_0113_256_DATA [256] = 
{157, 393, 623, 854, 1085, 1316, 1547, 1778, 2009, 2240, 2470, 2702, 2933, 3164, 3395, 3626, 3857, 4088, 4319, 4550, 4781, 5012, 5243, 5474, 5705, 5936, 6167, 6398, 6629, 6860, 7091, 7322, 7553, 7784, 8015, 8246, 8477, 8708, 8939, 9170, 9401, 9632, 9862, 10094, 10325, 10556, 10787, 11018, 11249, 11480, 11711, 11942, 12173, 12404, 12635, 12866, 13097, 13328, 13559, 13790, 14020, 14252, 14483, 14714, 14945, 15176, 15407, 15638, 15869, 16100, 16331, 16562, 16793, 17024, 17255, 17486, 17717, 17948, 18179, 18410, 18641, 18872, 19103, 19334, 19565, 19796, 20027, 20258, 20489, 20719, 20951, 21182, 21413, 21644, 21875, 22106, 22337, 22568, 22799, 23030, 23261, 23492, 23723, 23954, 24185, 24416, 24647, 24878, 25109, 25340, 25571, 25802, 26033, 26264, 26495, 26726, 26957, 27188, 27418, 27650, 27876, 28056, 28519, 25539, 18484, 10215, 1752, -5282, -10957, -15349, -18676, -21149, -22942, -24216, -25096, -25677, -26039, -26238, -26318, -26310, -26239, -26123, -25974, -25801, -25611, -25410, -25199, -24983, -24762, -24538, -24313, -24085, -23857, -23628, -23398, -23167, -22937, -22706, -22476, -22245, -22014, -21784, -21553, -21321, -21091, -20860, -20628, -20398, -20167, -19935, -19705, -19474, -19243, -19012, -18781, -18549, -18319, -18088, -17857, -17626, -17395, -17164, -16933, -16702, -16471, -16240, -16009, -15778, -15547, -15316, -15085, -14854, -14623, -14392, -14161, -13930, -13699, -13468, -13237, -13006, -12775, -12544, -12313, -12082, -11850, -11620, -11389, -11158, -10927, -10696, -10465, -10234, -10003, -9772, -9541, -9310, -9079, -8849, -8617, -8386, -8155, -7924, -7693, -7462, -7231, -7000, -6769, -6538, -6307, -6076, -5845, -5614, -5383, -5152, -4921, -4690, -4459, -4228, -3997, -3766, -3535, -3304, -3073, -2842, -2611, -2380, -2149, -1918, -1687, -1456, -1225, -994, -763, -533, -302, -67};