/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0183 256 samples */
 
const int16_t AKWF_0183_256_DATA [256] = 
{10922, 10922, 11054, 10313, 18924, 22471, 21707, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21814, 21936, 21552, 11933, 10660, 10984, 10922, 10922, 10785, 11549, 8002, -609, 131, 0, -1, 0, -1, 0, -1, 0, -1, -1, 0, 0, -1, -184, 810, -6876, -11698, -10748, -10923, -10927, -11003, -10521, -19578, -22361, -21733, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21795, -22039, -21123, -11463, -10770, -10963, -10923, -10922, -10922, -10923, -10923, -10923, -10923, -10922, -10923, -11123, -10053, -16459, -22711, -21644, -21844, -21844, -21844, -21844, -21844, -21844, -21845, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21847, -21936, -21396, -30373, -33306, -32650, -32766, -32766, -32766, -32766, -32766, -32766, -32629, -33393, -29847, -21235, -21976, -21844, -21697, -22512, -18651, -10097, -11759, -7591, 702, -156, -1, 0, 198, -864, 5235, 11793, 10721, 10922, 10721, 11792, 5386, -868, 199, 0, -1, -1, -1, -1, -137, 626, -2722, -12394, -4653, 840, -193, 0, 0, 0, 0, -1, -1, -1, 0, -1, 0, 0, -1, -200, 867, -5386, -11793, -10722, -10922, -10923, -10922, -10922, -10922, -10923, -10923, -10923, -10923, -10923, -10922, -10923, -10922, -10727, -11779, -4636, 829, -190, 0, 0, 122, -573, 8136, 11528, 10790, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10892, 11014, 10630, 1011, -263, 61, -1, -1, -1, 0, 0, 0, -1, 0, -1, 0, 0, -1, -1, -1, 0, -1, 0, -1, -1, 0, 0, -1, -1, 0, -1, 0, -1, 0, -1, 0, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, -1};