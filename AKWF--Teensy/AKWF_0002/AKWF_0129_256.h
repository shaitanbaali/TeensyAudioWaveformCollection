/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0129 256 samples */
 
const int16_t AKWF_0129_256_DATA [256] = 
{938, 2373, 3771, 5177, 6585, 7993, 9395, 10775, 12129, 13449, 14722, 15948, 17121, 18233, 19289, 20286, 21222, 22100, 22920, 23683, 24397, 25058, 25671, 26241, 26766, 27250, 27699, 28112, 28492, 28844, 29166, 29462, 29734, 29985, 30214, 30425, 30620, 30798, 30963, 31113, 31251, 31377, 31492, 31599, 31696, 31786, 31868, 31943, 32011, 32075, 32133, 32186, 32234, 32279, 32320, 32357, 32391, 32423, 32452, 32478, 32503, 32525, 32545, 32564, 32581, 32596, 32612, 32625, 32636, 32648, 32657, 32667, 32675, 32683, 32690, 32697, 32703, 32708, 32713, 32719, 32722, 32727, 32730, 32733, 32736, 32739, 32741, 32743, 32746, 32747, 32749, 32751, 32752, 32754, 32755, 32756, 32757, 32758, 32759, 32760, 32760, 32761, 32762, 32763, 32763, 32763, 32764, 32764, 32765, 32765, 32765, 32765, 32766, 32761, 32766, 32714, 31631, 29431, 26595, 23105, 18500, 13960, 10470, 7729, 5507, 3633, 1989, 481, -959, -2368, -3770, -5179, -6586, -7994, -9396, -10775, -12130, -13449, -14723, -15949, -17122, -18234, -19290, -20286, -21222, -22100, -22920, -23684, -24397, -25059, -25671, -26241, -26766, -27251, -27699, -28112, -28492, -28844, -29166, -29462, -29735, -29985, -30214, -30426, -30620, -30798, -30963, -31113, -31251, -31377, -31493, -31599, -31697, -31785, -31868, -31943, -32012, -32075, -32133, -32186, -32235, -32279, -32320, -32357, -32392, -32423, -32452, -32478, -32503, -32525, -32545, -32564, -32581, -32596, -32611, -32625, -32637, -32648, -32658, -32667, -32675, -32683, -32690, -32696, -32702, -32708, -32713, -32719, -32722, -32727, -32730, -32733, -32736, -32739, -32741, -32744, -32746, -32747, -32749, -32751, -32752, -32754, -32755, -32756, -32757, -32758, -32759, -32760, -32760, -32761, -32762, -32763, -32763, -32763, -32764, -32764, -32764, -32765, -32765, -32766, -32765, -32761, -32765, -32714, -31630, -29431, -26596, -23105, -18501, -13961, -10470, -7730, -5508, -3636, -1996, -462};