/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0125 256 samples */
 
const int16_t AKWF_0125_256_DATA [256] = 
{48, 204, 380, 575, 784, 1006, 1239, 1479, 1729, 1985, 2247, 2516, 2790, 3068, 3352, 3640, 3931, 4227, 4526, 4828, 5134, 5442, 5752, 6066, 6382, 6698, 7019, 7341, 7663, 7989, 8315, 8643, 8972, 9302, 9632, 9965, 10297, 10630, 10964, 11299, 11633, 11969, 12303, 12638, 12973, 13308, 13642, 13977, 14310, 14644, 14977, 15308, 15640, 15971, 16300, 16629, 16957, 17283, 17607, 17931, 18253, 18575, 18894, 19212, 19528, 19842, 20155, 20466, 20774, 21080, 21385, 21687, 21987, 22286, 22580, 22874, 23164, 23452, 23737, 24020, 24299, 24577, 24851, 25122, 25390, 25656, 25918, 26177, 26433, 26685, 26935, 27181, 27423, 27662, 27898, 28129, 28359, 28583, 28805, 29022, 29235, 29446, 29651, 29853, 30052, 30246, 30436, 30622, 30804, 30982, 31156, 31325, 31490, 31651, 31808, 31961, 32108, 32252, 32391, 32517, 32600, 32950, 29371, 20908, 15736, 10803, 4597, -1936, -8868, -15073, -19988, -23622, -26186, -27960, -29171, -29986, -30530, -30884, -31105, -31229, -31285, -31287, -31250, -31182, -31089, -30975, -30846, -30703, -30548, -30384, -30211, -30030, -29843, -29650, -29450, -29247, -29037, -28823, -28605, -28383, -28156, -27926, -27692, -27453, -27213, -26967, -26718, -26467, -26211, -25953, -25691, -25427, -25158, -24888, -24615, -24337, -24058, -23776, -23491, -23204, -22914, -22621, -22326, -22028, -21729, -21427, -21122, -20816, -20508, -20197, -19886, -19572, -19255, -18938, -18619, -18298, -17976, -17653, -17327, -17002, -16675, -16345, -16016, -15686, -15354, -15023, -14690, -14356, -14023, -13689, -13354, -13020, -12684, -12349, -12015, -11680, -11345, -11011, -10677, -10343, -10011, -9679, -9348, -9018, -8688, -8360, -8034, -7708, -7385, -7064, -6743, -6426, -6109, -5795, -5485, -5176, -4870, -4568, -4268, -3971, -3680, -3391, -3107, -2829, -2553, -2284, -2021, -1763, -1513, -1271, -1037, -813, -602, -405, -228, -83};