/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0184 256 samples */
 
const int16_t AKWF_0184_256_DATA [256] = 
{10921, 10921, 10921, 10921, 10921, 10921, 10978, 10575, 12327, 19330, 10680, 10956, 10926, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10921, 10727, 11770, 4487, -1009, 1024, -6583, -11728, -10852, -10388, -19190, -22428, -21717, -21844, -21844, -21843, -21844, -21814, -21936, -21552, -11899, -10771, -10611, -912, 323, -435, 1546, 10987, 10925, 10906, 10921, 10921, 11113, 10081, 15706, 22706, 21645, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21844, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21844, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21843, 21844, 21756, 22244, 20182, 10792, 10786, 11602, 7728, -826, 836, -3332, -11624, -10963, -10065, -16007, -22714, -21643, -21843, -21844, -22022, -21050, -28864, -33525, -32594, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32686, -33119, -31294, -21976, -21368, -11569, -11522, -6488, 848, -194, -1};