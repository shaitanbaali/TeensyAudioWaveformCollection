/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0196 256 samples */
 
const int16_t AKWF_0196_256_DATA [256] = 
{491, 1956, 3327, 4642, 5685, 8364, 10346, 11215, 13264, 14936, 16776, 19879, 20421, 21408, 22597, 23646, 24590, 25442, 26207, 26891, 27508, 28062, 28558, 29004, 29405, 29765, 30088, 30378, 30639, 30873, 31082, 31271, 31441, 31592, 31729, 31852, 31962, 32061, 32150, 32230, 32301, 32365, 32423, 32475, 32522, 32564, 32602, 32635, 32665, 32693, 32717, 32733, 32784, 32579, 32083, 31721, 31320, 30877, 30394, 29878, 29339, 28776, 28197, 27607, 27007, 26401, 25792, 25180, 24571, 23963, 23358, 22762, 22169, 21585, 21007, 20438, 19876, 19326, 18785, 18251, 17728, 17213, 16708, 16213, 15725, 15248, 14780, 14317, 13866, 13422, 12984, 12555, 12134, 11720, 11310, 10909, 10513, 10124, 9739, 9359, 8987, 8618, 8253, 7893, 7539, 7184, 6837, 6491, 6111, 6009, 3185, 1642, 1498, -275, -1714, -2912, -4108, -5330, -6529, -7673, -8738, -9718, -10625, -11452, -12200, -12879, -13484, -14019, -14491, -14896, -15245, -15539, -15779, -15974, -16124, -16234, -16305, -16345, -16354, -16335, -16290, -16225, -16140, -16036, -15918, -15786, -15642, -15489, -15328, -15159, -14987, -14808, -14626, -14444, -14257, -14071, -13886, -13702, -13516, -13335, -13155, -12976, -12802, -12629, -12460, -12295, -12131, -11974, -11816, -11664, -11515, -11370, -11235, -11095, -10921, -12743, -13090, -13193, -14225, -15449, -18036, -18581, -19980, -21880, -23191, -23713, -24575, -25428, -26190, -26878, -27496, -28049, -28549, -28995, -29396, -29758, -30081, -30372, -30634, -30867, -31078, -31268, -31437, -31590, -31727, -31849, -31960, -32059, -32148, -32228, -32300, -32364, -32422, -32474, -32521, -32556, -32626, -32341, -31809, -31412, -30956, -30447, -29891, -29297, -28669, -28017, -27341, -26648, -25944, -25226, -24506, -23783, -23058, -22333, -21614, -20899, -20189, -19490, -18795, -18111, -17439, -16775, -16123, -15481, -14852, -14233, -13625, -12996, -12609, -10365, -8379, -7583, -5474, -3838, -2398, -934};