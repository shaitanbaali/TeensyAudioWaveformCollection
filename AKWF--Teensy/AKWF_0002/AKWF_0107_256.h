/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0107 256 samples */
 
const int16_t AKWF_0107_256_DATA [256] = 
{-289, -1039, -1771, -2505, -3236, -3964, -4690, -5410, -6126, -6837, -7540, -8238, -8928, -9609, -10283, -10947, -11600, -12244, -12877, -13497, -14106, -14702, -15284, -15854, -16409, -16949, -17475, -17984, -18477, -18956, -19416, -19859, -20286, -20694, -21083, -21456, -21808, -22142, -22458, -22753, -23028, -23285, -23520, -23737, -23932, -24107, -24262, -24397, -24511, -24604, -24677, -24729, -24761, -24772, -24763, -24733, -24684, -24614, -24524, -24414, -24317, -23998, -24959, -26629, -27192, -27970, -28021, -28053, -27862, -27461, -27052, -26733, -26484, -26257, -26027, -25793, -25561, -25342, -25134, -24935, -24738, -24536, -24324, -24096, -23850, -23583, -23296, -22987, -22659, -22311, -21944, -21561, -21162, -20747, -20318, -19876, -19421, -18954, -18475, -17983, -17482, -16969, -16444, -15910, -15365, -14809, -14244, -13669, -13083, -12489, -11885, -11272, -10652, -10022, -9384, -8741, -8088, -7429, -6765, -6094, -5418, -4739, -4053, -3365, -2674, -1980, -1284, -587, 112, 809, 1507, 2204, 2899, 3591, 4282, 4967, 5649, 6328, 6999, 7665, 8326, 8977, 9622, 10260, 10886, 11505, 12114, 12711, 13298, 13873, 14436, 14987, 15525, 16049, 16560, 17055, 17536, 18003, 18453, 18888, 19307, 19708, 20093, 20461, 20811, 21142, 21457, 21753, 22031, 22289, 22529, 22750, 22953, 23135, 23298, 23442, 23567, 23671, 23757, 23822, 23868, 23895, 23902, 23892, 23882, 23700, 25378, 26665, 27487, 28132, 28260, 28357, 28194, 27873, 27584, 27386, 27245, 27115, 26979, 26838, 26703, 26577, 26462, 26353, 26243, 26124, 25992, 25841, 25669, 25475, 25257, 25018, 24755, 24472, 24168, 23845, 23504, 23146, 22771, 22381, 21975, 21554, 21120, 20671, 20208, 19732, 19242, 18739, 18223, 17694, 17151, 16597, 16030, 15450, 14860, 14257, 13642, 13018, 12382, 11735, 11081, 10416, 9742, 9061, 8370, 7673, 6971, 6260, 5545, 4826, 4101, 3373, 2643, 1910, 1177, 428};