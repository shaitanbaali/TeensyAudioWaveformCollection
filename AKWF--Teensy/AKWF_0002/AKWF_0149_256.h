/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0149 256 samples */
 
const int16_t AKWF_0149_256_DATA [256] = 
{418, 1503, 2541, 3559, 4552, 5521, 6466, 7383, 8275, 9142, 9980, 10793, 11579, 12338, 13070, 13775, 14451, 15102, 15725, 16320, 16890, 17433, 17947, 18437, 18899, 19335, 19747, 20132, 20490, 20826, 21136, 21421, 21683, 21920, 22134, 22327, 22495, 22641, 22767, 22871, 22954, 23016, 23059, 23083, 23088, 23074, 23043, 22994, 22928, 22846, 22749, 22636, 22509, 22368, 22213, 22046, 21866, 21676, 21474, 21261, 21040, 20809, 20571, 20325, 20071, 19813, 19549, 19282, 19012, 18739, 18467, 18197, 17930, 17668, 17420, 17188, 16969, 16869, 17091, 17203, 17164, 17153, 17180, 17222, 17253, 17257, 17222, 17146, 17025, 16858, 16650, 16402, 16116, 15796, 15442, 15060, 14649, 14216, 13761, 13286, 12793, 12286, 11765, 11234, 10692, 10142, 9586, 9024, 8458, 7891, 7321, 6750, 6182, 5613, 5047, 4486, 3927, 3373, 2825, 2282, 1746, 1218, 696, 184, -320, -816, -1302, -1778, -2246, -2701, -3147, -3583, -4006, -4419, -4821, -5210, -5589, -5956, -6310, -6653, -6985, -7303, -7610, -7904, -8187, -8458, -8716, -8963, -9197, -9420, -9630, -9828, -10015, -10191, -10355, -10507, -10649, -10779, -10898, -11007, -11105, -11192, -11269, -11336, -11393, -11439, -11477, -11505, -11525, -11535, -11536, -11528, -11513, -11488, -11456, -11417, -11370, -11315, -11254, -11186, -11111, -11030, -10943, -10850, -10751, -10647, -10538, -10423, -10305, -10181, -10053, -9921, -9785, -9646, -9503, -9357, -9208, -9057, -8903, -8754, -8845, -9292, -9762, -10299, -11425, -14089, -16637, -18509, -20462, -22599, -24809, -26966, -28982, -30826, -32188, -32636, -32729, -32757, -32764, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32762, -32776, -32566, -31841, -30884, -29844, -28745, -27603, -26429, -25224, -23995, -22752, -21491, -20221, -18946, -17665, -16384, -15108, -13833, -12566, -11311, -10062, -8828, -7610, -6403, -5216, -4047, -2897, -1770, -642};