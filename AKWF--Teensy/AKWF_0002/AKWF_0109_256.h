/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0109 256 samples */
 
const int16_t AKWF_0109_256_DATA [256] = 
{282, 946, 1592, 2235, 2873, 3506, 4135, 4756, 5372, 5983, 6585, 7182, 7773, 8355, 8932, 9501, 10062, 10617, 11163, 11701, 12233, 12756, 13270, 13778, 14277, 14767, 15250, 15725, 16190, 16648, 17097, 17537, 17971, 18394, 18809, 19216, 19614, 20004, 20386, 20758, 21123, 21479, 21826, 22165, 22496, 22817, 23130, 23435, 23731, 24018, 24297, 24566, 24827, 25079, 25321, 25555, 25779, 25993, 26197, 26391, 26574, 26747, 26907, 27057, 27193, 27316, 27426, 27520, 27598, 27659, 27702, 27723, 27722, 27696, 27646, 27570, 27468, 27340, 27185, 27004, 26797, 26564, 26306, 26024, 25717, 25387, 25034, 24659, 24263, 23847, 23410, 22955, 22482, 21992, 21485, 20964, 20426, 19876, 19313, 18736, 18149, 17551, 16942, 16325, 15699, 15065, 14425, 13777, 13123, 12466, 11803, 11135, 10467, 9793, 9118, 8442, 7764, 7085, 6408, 5729, 5051, 4376, 3700, 3028, 2358, 1690, 1026, 366, -292, -944, -1592, -2236, -2874, -3507, -4135, -4757, -5373, -5983, -6586, -7183, -7774, -8356, -8933, -9502, -10063, -10617, -11164, -11702, -12233, -12757, -13271, -13779, -14278, -14768, -15251, -15725, -16191, -16648, -17098, -17538, -17971, -18394, -18809, -19217, -19615, -20005, -20386, -20759, -21123, -21480, -21826, -22165, -22496, -22817, -23131, -23435, -23731, -24018, -24297, -24566, -24827, -25079, -25322, -25555, -25779, -25993, -26198, -26391, -26574, -26747, -26908, -27057, -27193, -27316, -27426, -27520, -27599, -27660, -27702, -27723, -27722, -27697, -27646, -27570, -27468, -27340, -27185, -27004, -26797, -26564, -26306, -26024, -25717, -25386, -25034, -24659, -24263, -23847, -23410, -22955, -22483, -21992, -21486, -20964, -20427, -19877, -19313, -18736, -18149, -17551, -16942, -16326, -15700, -15065, -14425, -13778, -13124, -12467, -11804, -11136, -10468, -9794, -9118, -8443, -7765, -7086, -6409, -5729, -5052, -4377, -3701, -3029, -2359, -1692, -1030, -358};