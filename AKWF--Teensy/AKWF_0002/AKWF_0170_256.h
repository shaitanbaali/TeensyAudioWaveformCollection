/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0170 256 samples */
 
const int16_t AKWF_0170_256_DATA [256] = 
{436, 436, 436, 436, 436, 435, 436, 499, 157, 2715, 4402, 4073, 4134, 4135, 4165, 3984, 6974, 7950, 7756, 7664, 8197, 11259, 11293, 11274, 11281, 11281, 11282, 11309, 11159, 11790, 14662, 14619, 14619, 14623, 14666, 14427, 15574, 17942, 17696, 17741, 17742, 17793, 17516, 19111, 20826, 20545, 20598, 20598, 20639, 20415, 22281, 23339, 23126, 23163, 23166, 23175, 23102, 25001, 25514, 25396, 25418, 25425, 25387, 25528, 27228, 27371, 27331, 27339, 27340, 27339, 27339, 27367, 27219, 28323, 29051, 28909, 28935, 28936, 28936, 28935, 28936, 28939, 28925, 28969, 30094, 30242, 30204, 30211, 30211, 30225, 30149, 30885, 31252, 31125, 31675, 31922, 31871, 31879, 31880, 31879, 31879, 31879, 31882, 31869, 31918, 32323, 32344, 32338, 32339, 32341, 32326, 32397, 32616, 32605, 32596, 32651, 32735, 32724, 32726, 32727, 32727, 32727, 32727, 32726, 32724, 32746, 32765, 32762, 32762, 32761, 31969, 36413, -15247, -36527, -31943, -32767, -32750, -32732, -32735, -32735, -32734, -32735, -32734, -32734, -32737, -32721, -32620, -32618, -32619, -32619, -32616, -32633, -32553, -32349, -32366, -32363, -32362, -32354, -32396, -32173, -31880, -31924, -31915, -31915, -31904, -31967, -31504, -31183, -31244, -31233, -31233, -31224, -31275, -30499, -30229, -30289, -30278, -30276, -30288, -30244, -29139, -28993, -29030, -29023, -29023, -29023, -29017, -29045, -28945, -27551, -27419, -27454, -27448, -27447, -27448, -27447, -27448, -27426, -27548, -26027, -25435, -25564, -25541, -25541, -25540, -25505, -25703, -24089, -23224, -23059, -20795, -20750, -20767, -20763, -20762, -20762, -20762, -20762, -20714, -20975, -19595, -17698, -17969, -17919, -17919, -17891, -18046, -17380, -14715, -14971, -14204, -11396, -11504, -11489, -11488, -11487, -11487, -11488, -11488, -11423, -11766, -9710, -7703, -8045, -7982, -7982, -7928, -8224, -5506, -4118, -4406, -4354, -4349, -4345, -4417, -1258};