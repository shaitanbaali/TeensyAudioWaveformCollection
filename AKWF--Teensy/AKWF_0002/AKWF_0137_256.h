/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0137 256 samples */
 
const int16_t AKWF_0137_256_DATA [256] = 
{681, 2453, 4159, 5881, 7604, 9299, 10936, 12494, 13977, 15386, 16714, 17963, 19126, 20198, 21184, 22082, 22893, 23624, 24274, 24843, 25339, 25761, 26113, 26401, 26626, 26792, 26905, 26966, 26980, 26950, 26881, 26775, 26637, 26469, 26275, 26058, 25822, 25568, 25300, 25020, 24730, 24433, 24132, 23826, 23519, 23212, 22906, 22603, 22304, 22008, 21719, 21436, 21160, 20890, 20629, 20376, 20129, 19890, 19663, 19187, 17888, 15820, 13853, 12600, 11763, 10660, 8950, 6872, 4805, 2910, 1148, -578, -2338, -4122, -5877, -7568, -9177, -10699, -12148, -13521, -14808, -16010, -17119, -18135, -19063, -19905, -20660, -21335, -21929, -22444, -22886, -23257, -23561, -23802, -23984, -24109, -24184, -24210, -24192, -24134, -24040, -23912, -23754, -23570, -23360, -23025, -22216, -20651, -18638, -16862, -15598, -14499, -13065, -11142, -8970, -6836, -4835, -2933, -1053, 852, 2757, 4618, 6410, 8112, 9726, 11260, 12706, 14060, 15320, 16478, 17537, 18503, 19372, 20150, 20840, 21442, 21961, 22401, 22763, 23055, 23279, 23439, 23539, 23585, 23579, 23527, 23432, 23299, 23131, 22932, 22706, 22456, 22186, 21898, 21597, 21284, 20963, 20634, 20303, 19969, 19633, 19301, 18921, 18151, 16589, 14465, 12557, 11271, 10251, 8906, 7034, 4879, 2757, 805, -1035, -2849, -4679, -6519, -8319, -10041, -11677, -13226, -14688, -16070, -17362, -18556, -19657, -20660, -21567, -22386, -23115, -23757, -24317, -24794, -25195, -25524, -25783, -25977, -26111, -26188, -26212, -26187, -26118, -26008, -25861, -25683, -25474, -25240, -24983, -24707, -24415, -24111, -23795, -23471, -23142, -22808, -22473, -22139, -21805, -21475, -21150, -20829, -20516, -20210, -19912, -19622, -19341, -19070, -18808, -18556, -18314, -18081, -17859, -17645, -17441, -17246, -17059, -16881, -16711, -16548, -16393, -16244, -16100, -15963, -15802, -15456, -14676, -13343, -11688, -10148, -8946, -7885, -6605, -4948, -3050, -1097};