/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0147 256 samples */
 
const int16_t AKWF_0147_256_DATA [256] = 
{2845, 6004, 10370, 8485, 7254, 7870, 14079, 15416, 16392, 13667, 8573, 6117, 9621, 15975, 22820, 27753, 24775, 17580, 7323, -2008, -3130, 1540, 13867, 23476, 30084, 32561, 30479, 24170, 15218, 4278, -1802, -3928, -2170, -1309, 2370, 5617, 6908, 6295, 1084, -701, -2324, -3592, 775, -2719, -2754, -6121, -7122, -4913, -4457, -3515, -3903, -5081, -3390, -2387, -3635, 341, -1155, -1822, -3630, -4688, -1443, 2391, 7656, 11159, 8696, 2615, -4706, -11218, -13784, -13945, -4758, 1783, 10201, 9055, 2213, -8811, -18166, -22928, -18237, -9849, 3606, 10829, 14103, 10811, 8116, 2090, 2463, 2713, 1385, 1704, -4998, -8996, -12538, -10967, -5162, -3566, 1708, -3434, -9748, -21023, -28567, -26753, -15607, -1951, 6593, 9618, -4, -9013, -20951, -26782, -26017, -20226, -13589, -7368, -1023, 1601, 1104, 119, -2201, -6736, -4837, -1114, 1902, 5695, 7032, 4710, 6287, 3367, -320, -978, -2676, 1712, 3311, 3080, 5681, 10572, 16844, 22600, 23175, 18689, 14738, 10665, 6424, 6393, 10791, 12577, 14644, 9935, 3015, 1999, 39, 3460, 7114, 12408, 15841, 15104, 13470, 8255, 890, -999, 2260, 4226, 5258, 2146, -3292, -10671, -17032, -19826, -18235, -12094, -1588, 2119, 3733, 14, -4780, -10615, -10550, -9712, -3176, 3508, 6606, 10595, 10162, 5101, 1345, -1333, 2420, 9268, 12794, 20145, 17400, 16593, 14014, 12172, 8250, 9279, 8337, 7020, 7293, 3010, -4218, -7926, -15309, -18059, -16452, -12229, -965, 10851, 19299, 15742, 11475, -1478, -11310, -13273, -12448, -5007, -417, 2861, 1883, -992, -7383, -16681, -18777, -17588, -15948, -10663, -12085, -11448, -13092, -15047, -16696, -17918, -16115, -9893, -5892, -8959, -10875, -13503, -12107, -9837, -7287, -7520, -11419, -14141, -16355, -13352, -8722, -2916, 2502, 2550, -3119, -10523, -15251, -13894, -9984, -4860};