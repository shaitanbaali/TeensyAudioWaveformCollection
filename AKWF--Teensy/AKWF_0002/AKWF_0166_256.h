/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0166 256 samples */
 
const int16_t AKWF_0166_256_DATA [256] = 
{1190, 3214, 5327, 7544, 9820, 12120, 14405, 16623, 18748, 20750, 22594, 24271, 25768, 27071, 28179, 29076, 29745, 30175, 30354, 30285, 29978, 29457, 28750, 27889, 26910, 25848, 24734, 23612, 22521, 21491, 20547, 19700, 18944, 18267, 17646, 17053, 16465, 15855, 15205, 14512, 13774, 12974, 12096, 11114, 10005, 8761, 7365, 5824, 4155, 2369, 490, -1451, -3443, -5456, -7468, -9473, -11449, -13382, -15272, -17102, -18866, -20555, -22143, -23608, -24929, -26084, -27068, -27887, -28548, -29072, -29481, -29796, -30040, -30232, -30382, -30504, -30601, -30679, -30741, -30800, -30870, -30969, -31112, -31299, -31529, -31786, -32053, -32307, -32525, -32686, -32765, -32735, -32567, -32237, -31731, -31048, -30195, -29197, -28077, -26863, -25592, -24288, -22975, -21691, -20464, -19323, -18296, -17396, -16630, -15990, -15452, -14989, -14572, -14164, -13731, -13247, -12693, -12061, -11354, -10576, -9754, -8900, -8018, -7121, -6219, -5312, -4397, -3460, -2481, -1457, -378, 752, 1914, 3097, 4277, 5431, 6546, 7603, 8590, 9503, 10338, 11092, 11767, 12353, 12835, 13204, 13447, 13566, 13571, 13481, 13321, 13120, 12906, 12709, 12558, 12487, 12528, 12709, 13043, 13536, 14176, 14941, 15802, 16729, 17683, 18638, 19567, 20457, 21306, 22091, 22783, 23358, 23789, 24052, 24139, 24048, 23787, 23369, 22815, 22147, 21382, 20540, 19642, 18696, 17720, 16722, 15709, 14691, 13675, 12669, 11699, 10787, 9954, 9221, 8594, 8069, 7636, 7278, 6972, 6698, 6436, 6168, 5883, 5570, 5226, 4850, 4438, 3979, 3461, 2865, 2184, 1416, 563, -356, -1319, -2306, -3290, -4246, -5153, -5975, -6683, -7254, -7670, -7926, -8033, -8006, -7873, -7659, -7395, -7108, -6820, -6561, -6366, -6258, -6261, -6393, -6655, -7034, -7507, -8036, -8580, -9099, -9548, -9887, -10086, -10121, -9981, -9658, -9150, -8460, -7584, -6524, -5289, -3893, -2350, -614};