/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0135 256 samples */
 
const int16_t AKWF_0135_256_DATA [256] = 
{1442, 3094, 4387, 5551, 6647, 7738, 8841, 9916, 10932, 11899, 12843, 13784, 14721, 15644, 16551, 17431, 18277, 19096, 19890, 20669, 21443, 22202, 22937, 23643, 24317, 24969, 25606, 26224, 26818, 27386, 27924, 28430, 28901, 29343, 29756, 30141, 30499, 30830, 31139, 31421, 31671, 31890, 32078, 32244, 32384, 32500, 32596, 32677, 32740, 32768, 32752, 32703, 32635, 32546, 32433, 32289, 32114, 31908, 31676, 31419, 31140, 30845, 30537, 30213, 29862, 29483, 29082, 28669, 28245, 27801, 27337, 26855, 26355, 25838, 25305, 24759, 24199, 23639, 23141, 22829, 22760, 22814, 22793, 22647, 22493, 22448, 22499, 22563, 22577, 22491, 22225, 21728, 21014, 20164, 19281, 18402, 17480, 16433, 15218, 13884, 12516, 11161, 9809, 8440, 7024, 5519, 3900, 1989, -543, -2664, -4201, -5573, -6849, -8052, -9174, -10212, -11183, -12092, -12951, -13750, -14380, -14688, -14691, -14633, -14707, -14846, -14851, -14656, -14340, -13994, -13668, -13405, -13220, -13088, -12980, -12881, -12776, -12668, -12605, -12642, -12782, -12969, -13160, -13354, -13575, -13839, -14143, -14481, -14840, -15190, -15519, -15844, -16185, -16545, -16915, -17272, -17614, -17950, -18281, -18609, -18937, -19259, -19552, -19804, -20023, -20240, -20466, -20691, -20898, -21070, -21198, -21294, -21390, -21501, -21614, -21705, -21770, -21822, -21870, -21915, -21961, -22004, -22041, -22067, -22084, -22094, -22105, -22111, -22111, -22100, -22082, -22057, -22022, -21980, -21930, -21871, -21801, -21719, -21629, -21528, -21416, -21295, -21163, -21018, -20863, -20696, -20516, -20328, -20144, -20088, -20361, -20883, -21321, -21519, -21650, -21940, -22377, -22821, -23208, -23529, -23762, -23901, -23975, -23997, -23985, -23982, -23969, -23868, -23638, -23314, -22962, -22604, -22203, -21740, -21214, -20624, -19974, -19283, -18574, -17864, -17142, -16361, -15508, -14614, -13704, -12780, -11827, -10830, -9788, -8700, -7558, -6390, -5211, -3981, -2627, -712};