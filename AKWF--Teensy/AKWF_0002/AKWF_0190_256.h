/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0190 256 samples */
 
const int16_t AKWF_0190_256_DATA [256] = 
{6286, 11752, 10733, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10921, 10922, 10922, 10922, 10952, 10829, 11214, 20833, 22106, 21782, 21844, 21760, 22221, 20297, 10856, 10918, 10938, 10922, 10922, 10922, 10922, 10922, 10922, 10731, 11760, 4339, -618, -643, 6729, 11713, 10743, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10766, 11624, 3331, -688, 152, 92, -425, 1777, 11111, 10895, 10858, 11140, 10107, 455, -132, 37, -1, -112, 517, -2267, -11324, -10843, -10918, -10923, -10747, -11698, -6877, 810, -184, -1, 0, 0, -1, -187, 817, -4487, -11771, -10729, -10922, -10923, -10922, -10923, -10923, -10923, -10922, -10922, -10923, -10923, -10923, -10923, -10922, -10922, -10923, -10922, -10923, -10922, -10923, -10922, -10923, -10923, -10923, -10923, -10922, -10923, -11078, -10220, -18512, -22390, -22340, -18789, -10281, -11063, -10922, -10923, -10922, -10923, -10922, -11119, -10065, -16007, -22714, -21644, -21844, -21844, -21960, -21305, -24237, -33210, -32593, -33165, -24110, -21148, -22746, -17659, -10152, -10809, -19826, -22355, -21590, -22385, -32000, -33135, -32088, -22474, -21670, -21889, -21844, -21844, -21844, -21844, -21844, -21683, -22569, -18231, -10170, -11091, -10923, -10923, -10722, -11793, -5386, 867, -200, 178, -791, 4060, 12353, 7949, -573, 123, 0, -1, 189, -830, 4636, 11779, 10726, 10922, 10922, 10731, 11760, 4339, -805, 182, 0, 0, -1, -200, 867, -5386, -11793, -10722, -10892, -11015, -10630, -1012, 261, -62, 0, -1, -137, 626, -2920, -11531, -10790, -10923, -10923, -10922, -10922, -10922, -10922, -10922, -10923, -10922, -10923, -10923, -10922, -10923, -10922, -10922, -10922, -10923, -10922, -10922, -10893, -11015, -10631, -1012, 262, -62, 0, -1, -9, -42, 333, -9427, -9709, 225, -12};