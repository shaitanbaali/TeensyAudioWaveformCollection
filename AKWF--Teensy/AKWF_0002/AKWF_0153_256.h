/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0153 256 samples */
 
const int16_t AKWF_0153_256_DATA [256] = 
{283, 1045, 1794, 2547, 3302, 4060, 4825, 5589, 6359, 7132, 7907, 8686, 9468, 10250, 11036, 11823, 12608, 13395, 14181, 14964, 15746, 16524, 17297, 18068, 18832, 19588, 20340, 21082, 21815, 22540, 23254, 23956, 24647, 25325, 25990, 26641, 27276, 27896, 28500, 29086, 29655, 30208, 30739, 31252, 31739, 32154, 32916, 29473, 22484, 19883, 19073, 18577, 18428, 18616, 18911, 19073, 18990, 18665, 18144, 17465, 16649, 15713, 14689, 13609, 12508, 11419, 10363, 9350, 8388, 7475, 6642, 5918, 5296, 4775, 4354, 4024, 3781, 3617, 3526, 3503, 3543, 3640, 3793, 3995, 4245, 4538, 4872, 5245, 5654, 6097, 6572, 7075, 7604, 8160, 8738, 9338, 9957, 10593, 11245, 11912, 12590, 13279, 13978, 14683, 15395, 16113, 16831, 17554, 18270, 18923, 20007, 16191, 8152, 5152, 4225, 3663, 3512, 3766, 4160, 4415, 4396, 4106, 3590, 2892, 2034, 1034, -72, -1247, -2449, -3640, -4793, -5890, -6914, -7856, -8711, -9471, -10135, -10703, -11175, -11554, -11845, -12051, -12176, -12226, -12205, -12120, -11975, -11776, -11527, -11236, -10907, -10546, -10158, -9755, -9349, -8929, -8469, -7968, -7435, -6870, -6278, -5667, -5038, -4395, -3743, -3081, -2412, -1737, -1056, -369, 323, 1021, 1721, 2372, 3401, 241, -6606, -9227, -10102, -10672, -10895, -10769, -10513, -10369, -10449, -10760, -11261, -11921, -12719, -13646, -14671, -15762, -16888, -18011, -19110, -20172, -21176, -22119, -22992, -23787, -24503, -25139, -25692, -26166, -26560, -26877, -27120, -27293, -27397, -27436, -27413, -27333, -27198, -27010, -26774, -26492, -26167, -25802, -25399, -24960, -24491, -23989, -23460, -22905, -22326, -21726, -21106, -20467, -19812, -19144, -18461, -17771, -17071, -16363, -15653, -14940, -14228, -13522, -12822, -12143, -11486, -10815, -10122, -9414, -8690, -7954, -7210, -6460, -5707, -4955, -4202, -3450, -2701, -1953, -1207, -446};