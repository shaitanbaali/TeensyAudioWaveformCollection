/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0193 256 samples */
 
const int16_t AKWF_0193_256_DATA [256] = 
{853, 2364, 3282, 4296, 5377, 6463, 7522, 8528, 9485, 10396, 11265, 12095, 12888, 13633, 14342, 15008, 15634, 16224, 16777, 17298, 17784, 18242, 18667, 19067, 19441, 19868, 19731, 22943, 25864, 24669, 25526, 26240, 26902, 27500, 28037, 28521, 28954, 29344, 29693, 30006, 30289, 30542, 30769, 30973, 31157, 31321, 31469, 31602, 31721, 31828, 31924, 32011, 32088, 32158, 32220, 32276, 32327, 32372, 32413, 32449, 32482, 32512, 32538, 32562, 32583, 32602, 32619, 32634, 32648, 32661, 32672, 32682, 32691, 32699, 32706, 32713, 32719, 32725, 32729, 32733, 32737, 32740, 32743, 32746, 32749, 32751, 32753, 32755, 32756, 32758, 32759, 32760, 32761, 32763, 32764, 32764, 32764, 32761, 32783, 32372, 31794, 31342, 30824, 30249, 29628, 28964, 28265, 27531, 26771, 25990, 25183, 24371, 23498, 22062, 20872, 19919, 18804, 17587, 16310, 14980, 13600, 12199, 10353, 8165, 6925, 5510, 4091, 2721, 1400, 142, -1069, -2315, -2857, -8627, -15328, -13973, -15429, -17201, -18773, -20200, -21484, -22633, -23668, -24597, -25429, -26179, -26852, -27455, -27997, -28484, -28921, -29314, -29667, -29983, -30268, -30523, -30752, -30958, -31143, -31309, -31458, -31592, -31712, -31820, -31917, -32004, -32083, -32153, -32215, -32272, -32323, -32369, -32410, -32446, -32479, -32509, -32536, -32560, -32581, -32601, -32618, -32633, -32648, -32660, -32671, -32681, -32690, -32699, -32706, -32713, -32719, -32724, -32728, -32732, -32737, -32740, -32743, -32746, -32749, -32751, -32753, -32755, -32756, -32757, -32759, -32760, -32761, -32762, -32763, -32764, -32765, -32765, -32766, -32763, -32775, -32723, -32216, -31788, -31374, -30905, -30391, -29834, -29241, -28621, -27971, -27301, -26611, -25901, -25181, -24447, -23700, -22946, -22185, -21415, -20644, -19862, -19074, -18290, -17495, -16693, -15893, -15031, -14130, -13291, -12418, -11519, -10579, -9583, -8573, -7077, -5608, -4717, -3651, -2602, -1578, -567};