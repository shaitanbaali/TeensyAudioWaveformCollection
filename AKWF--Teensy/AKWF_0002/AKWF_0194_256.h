/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0194 256 samples */
 
const int16_t AKWF_0194_256_DATA [256] = 
{-1336, -3936, -6110, -8796, -11179, -13332, -15270, -17005, -18566, -19970, -21226, -22357, -23373, -24283, -25101, -25837, -26496, -27090, -27622, -28099, -28529, -28914, -29260, -29571, -29850, -30100, -30325, -30528, -30709, -30872, -31018, -31150, -31268, -31374, -31469, -31554, -31631, -31700, -31762, -31817, -31867, -31912, -31952, -31987, -32028, -32016, -31806, -31646, -31417, -31500, -32344, -31935, -31963, -31993, -32024, -32053, -32079, -32102, -32123, -32142, -32158, -32173, -32187, -32199, -32210, -32220, -32229, -32237, -32244, -32250, -32256, -32262, -32266, -32270, -32274, -32278, -32280, -32283, -32285, -32287, -32289, -32291, -32293, -32294, -32296, -32297, -32298, -32299, -32300, -32300, -32301, -32301, -32302, -32302, -32303, -32303, -32303, -32304, -32304, -32304, -32304, -32305, -32305, -32298, -32334, -32060, -31546, -31175, -30748, -30281, -29771, -29229, -28659, -28064, -27451, -26820, -26177, -25525, -24863, -24194, -23520, -22854, -22142, -21668, -21583, -21058, -20568, -20148, -19771, -19435, -19100, -18757, -18405, -18044, -17674, -17300, -16912, -16508, -16091, -15655, -15205, -14735, -14255, -13692, -13105, -12559, -11977, -11366, -10724, -10059, -9368, -8647, -7884, -7079, -6022, -4595, -2921, -1690, -827, 242, 1374, 2499, 3583, 4617, 5595, 6528, 7416, 8263, 9064, 9824, 10613, 10842, 14005, 20406, 18916, 19863, 21134, 22262, 23285, 24204, 25031, 25774, 26439, 27039, 27576, 28058, 28492, 28881, 29230, 29544, 29826, 30079, 30306, 30510, 30693, 30858, 31006, 31138, 31258, 31365, 31461, 31547, 31625, 31694, 31757, 31812, 31863, 31909, 31949, 31986, 32018, 32048, 32074, 32098, 32119, 32138, 32155, 32171, 32185, 32197, 32208, 32218, 32228, 32235, 32243, 32249, 32255, 32261, 32265, 32269, 32273, 32277, 32280, 32282, 32285, 32287, 32289, 32291, 32293, 32294, 32296, 32296, 32297, 32298, 32299, 32300, 32301, 32195, 32738, 29763, 23074, 21433, 16349, 11478, 7630, 2982};