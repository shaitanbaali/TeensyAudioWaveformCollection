/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0172 256 samples */
 
const int16_t AKWF_0172_256_DATA [256] = 
{10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10921, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 11090, 10169, 18230, 22569, 21682, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21843, 21844, 21844, 21844, 21844, 21844, 21844, 21844, 21774, 22151, 20626, 11062, 10867, 10945, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10921, 10732, 11760, 4339, -805, 182, -1, 0, -1, -1, -1, -1, 0, 0, -31, 92, -293, -9912, -11185, -10861, -10923, -10922, -10922, -10923, -10922, -10922, -10923, -10923, -10922, -10922, -10922, -10923, -10922, -10923, -10923, -11119, -10065, -16007, -22714, -21644, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21885, -21691, -22385, -32045, -32962, -32717, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32767, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32592, -33540, -25600, -21101, -22010, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21844, -21703, -22486, -13978, -10275, -11064, -10923, -10922, -10922, -10923, -10922, -10923, -10923, -10922, -10923, -10923, -10922, -10923, -10923, -10922, -10922, -10923, -10923, -10923, -10923, -10923, -10922, -10922, -10737, -11741, -6435, 848, -194, 0};