/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0110 256 samples */
 
const int16_t AKWF_0110_256_DATA [256] = 
{779, 1991, 2722, 3172, 3472, 3659, 3750, 3791, 3804, 3778, 3725, 3681, 3603, 3533, 3452, 3370, 3273, 3198, 3095, 3015, 2934, 2830, 2760, 2682, 2616, 2539, 2457, 2380, 2321, 2265, 2197, 2133, 2089, 2039, 1981, 1934, 1892, 1847, 1813, 1769, 1730, 1700, 1674, 1652, 1608, 1588, 1567, 1545, 1528, 1504, 1502, 1495, 1492, 1488, 1488, 1488, 1511, 1522, 1530, 1556, 1590, 1620, 1676, 1715, 1782, 1865, 1955, 2055, 2173, 2307, 2417, 2536, 2662, 2779, 2882, 2976, 3048, 3121, 3177, 3213, 3251, 3264, 3292, 3287, 3256, 3257, 3212, 3189, 3157, 3107, 3063, 2992, 2956, 2899, 2828, 2781, 2715, 2660, 2591, 2548, 2499, 2431, 2382, 2344, 2303, 2274, 2236, 2212, 2201, 2196, 2219, 2228, 2266, 2320, 2400, 2524, 2684, 2896, 3206, 3627, 4330, 5468, 7223, 21420, 19393, 9355, 4301, 1098, -811, -1976, -2719, -3173, -3473, -3661, -3751, -3792, -3805, -3779, -3726, -3682, -3604, -3534, -3453, -3371, -3274, -3199, -3096, -3016, -2935, -2831, -2761, -2683, -2616, -2540, -2458, -2381, -2322, -2266, -2199, -2135, -2090, -2040, -1982, -1934, -1893, -1847, -1814, -1770, -1731, -1701, -1675, -1653, -1609, -1589, -1567, -1545, -1529, -1505, -1503, -1496, -1493, -1489, -1489, -1489, -1511, -1523, -1531, -1557, -1591, -1621, -1677, -1716, -1783, -1866, -1956, -2056, -2173, -2308, -2418, -2537, -2662, -2780, -2883, -2977, -3049, -3122, -3178, -3214, -3252, -3265, -3293, -3287, -3257, -3258, -3213, -3190, -3159, -3107, -3065, -2993, -2957, -2900, -2828, -2782, -2716, -2661, -2592, -2549, -2500, -2432, -2383, -2345, -2304, -2276, -2237, -2212, -2202, -2196, -2220, -2228, -2267, -2321, -2401, -2525, -2685, -2897, -3207, -3629, -4331, -5469, -7224, -21420, -19394, -9359, -4306, -1083};