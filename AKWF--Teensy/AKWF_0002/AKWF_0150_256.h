/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0150 256 samples */
 
const int16_t AKWF_0150_256_DATA [256] = 
{979, 2479, 3689, 4655, 5483, 6278, 7045, 7772, 8483, 9187, 9873, 10540, 11191, 11822, 12438, 13039, 13629, 14213, 14793, 15373, 15957, 16545, 17136, 17692, 18133, 18443, 18661, 18819, 18952, 19110, 19328, 19611, 19951, 20333, 20749, 21203, 21714, 22309, 22981, 23708, 24470, 25243, 26010, 26761, 27486, 28173, 28827, 29446, 30028, 30574, 31080, 31545, 31969, 32350, 32666, 32747, 32296, 31276, 29834, 28092, 26138, 23756, 21236, 18854, 16526, 14453, 12564, 10864, 9409, 8175, 7131, 6275, 5606, 5118, 4802, 4649, 4651, 4789, 5047, 5407, 5849, 6356, 6910, 7502, 8123, 8765, 9412, 10024, 10512, 10857, 11102, 11275, 11371, 11386, 11338, 11261, 11185, 11137, 11123, 11131, 11134, 11123, 11108, 11108, 11144, 11228, 11368, 11572, 11840, 12156, 12496, 12852, 13184, 13390, 13425, 13286, 12991, 12580, 12095, 11555, 10998, 10281, 8468, 6090, 3430, 238, -3017, -6090, -8846, -11015, -12611, -13789, -14601, -15089, -15351, -15464, -15469, -15391, -15264, -15109, -14935, -14751, -14561, -14368, -14170, -13962, -13745, -13513, -13265, -12999, -12716, -12455, -12299, -12265, -12313, -12410, -12521, -12597, -12598, -12521, -12371, -12168, -11918, -11621, -11248, -10780, -10218, -9581, -8895, -8183, -7464, -6746, -6040, -5358, -4697, -4061, -3450, -2862, -2297, -1758, -1241, -745, -257, -204, -982, -2425, -4294, -6353, -8521, -11083, -13738, -16182, -18516, -20554, -22382, -23996, -25346, -26464, -27391, -28132, -28690, -29080, -29315, -29404, -29359, -29191, -28917, -28549, -28102, -27586, -27018, -26409, -25762, -25089, -24400, -23732, -23170, -22733, -22380, -22088, -21862, -21704, -21599, -21516, -21422, -21298, -21132, -20940, -20744, -20555, -20363, -20150, -19895, -19587, -19218, -18774, -18248, -17638, -16941, -16163, -15303, -14360, -13337, -12237, -11052, -9779, -8411, -7135, -6303, -5931, -5853, -5877, -5491, -4312, -2782, -855};