/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0108 256 samples */
 
const int16_t AKWF_0108_256_DATA [256] = 
{331, 1174, 1992, 2801, 3600, 4394, 5183, 5965, 6742, 7515, 8280, 9042, 9800, 10550, 11299, 12042, 12778, 13511, 14237, 14954, 15665, 16368, 17061, 17745, 18419, 19082, 19734, 20375, 21003, 21620, 22223, 22812, 23390, 23952, 24500, 25034, 25553, 26055, 26543, 27013, 27468, 27907, 28327, 28731, 29117, 29484, 29835, 30166, 30477, 30770, 31045, 31298, 31533, 31747, 31942, 32116, 32270, 32403, 32516, 32607, 32677, 32727, 32756, 32763, 32750, 32715, 32660, 32583, 32486, 32368, 32228, 32069, 31889, 31688, 31468, 31227, 30966, 30687, 30389, 30070, 29734, 29378, 29005, 28615, 28206, 27780, 27338, 26880, 26405, 25916, 25411, 24891, 24359, 23811, 23250, 22677, 22091, 21495, 20887, 20266, 19638, 18999, 18352, 17696, 17031, 16359, 15682, 14997, 14306, 13612, 12913, 12209, 11504, 10792, 10081, 9369, 8654, 7940, 7226, 6513, 5800, 5092, 4384, 3677, 2916, 2126, 1312, 486, -343, -1171, -1991, -2802, -3600, -4395, -5184, -5965, -6743, -7516, -8281, -9043, -9800, -10551, -11299, -12043, -12779, -13511, -14238, -14955, -15666, -16369, -17061, -17746, -18420, -19082, -19735, -20375, -21003, -21620, -22223, -22813, -23390, -23952, -24500, -25034, -25552, -26055, -26543, -27013, -27468, -27907, -28327, -28731, -29117, -29484, -29834, -30166, -30477, -30771, -31045, -31299, -31533, -31748, -31942, -32116, -32270, -32403, -32516, -32607, -32678, -32727, -32756, -32764, -32750, -32715, -32659, -32583, -32486, -32367, -32228, -32069, -31889, -31689, -31468, -31227, -30967, -30688, -30388, -30070, -29734, -29378, -29005, -28614, -28206, -27780, -27339, -26880, -26405, -25916, -25410, -24891, -24359, -23811, -23251, -22677, -22091, -21495, -20887, -20267, -19638, -19000, -18351, -17696, -17032, -16360, -15682, -14998, -14307, -13613, -12913, -12209, -11504, -10793, -10081, -9369, -8655, -7941, -7227, -6514, -5801, -5092, -4385, -3678, -2916, -2129, -1316, -476};