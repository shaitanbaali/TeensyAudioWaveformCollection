/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0197 256 samples */
 
const int16_t AKWF_0197_256_DATA [256] = 
{9879, 8426, 10168, 11149, 12266, 13367, 14449, 15504, 16534, 17536, 18500, 19429, 20320, 21166, 21971, 22730, 23440, 24100, 24710, 25268, 25773, 26224, 26620, 26963, 27250, 27482, 27660, 27786, 27856, 27875, 27842, 27760, 27629, 27452, 27230, 26964, 26661, 26318, 25939, 25527, 25084, 24613, 24119, 23602, 23068, 22520, 21961, 21390, 20815, 20236, 19659, 19086, 18518, 17961, 17418, 16890, 16381, 15891, 15424, 14982, 14568, 14182, 13828, 13507, 13219, 12968, 12750, 12571, 12431, 12328, 12265, 12243, 12260, 12316, 12413, 12550, 12727, 12942, 13197, 13490, 13819, 14185, 14586, 15020, 15484, 15980, 16505, 17056, 17632, 18229, 18848, 19482, 20129, 20790, 21455, 22129, 22808, 23484, 24158, 24826, 25483, 26128, 26759, 27368, 27959, 28525, 29065, 29577, 30057, 30503, 30915, 31289, 31623, 31917, 32169, 32378, 32543, 32664, 32739, 32769, 32752, 32691, 32584, 31955, 34750, 21722, -11029, -9170, -9381, -9287, -9829, -10120, -10419, -10673, -10871, -11020, -11122, -11180, -11197, -11177, -11123, -11041, -10934, -10802, -10651, -10486, -10308, -10123, -9933, -9741, -9551, -9367, -9189, -9022, -8866, -8727, -8605, -8502, -8421, -8363, -8331, -8325, -8346, -8397, -8478, -8590, -8734, -8911, -9121, -9364, -9641, -9951, -10296, -10672, -11084, -11528, -12002, -12508, -13042, -13604, -14191, -14804, -15439, -16097, -16772, -17462, -18168, -18883, -19606, -20336, -21064, -21794, -22523, -23243, -23954, -24654, -25336, -26001, -26645, -27263, -27856, -28420, -28952, -29451, -29915, -30340, -30727, -31072, -31375, -31633, -31849, -32017, -32141, -32218, -32248, -32232, -32169, -32060, -31908, -31711, -31470, -31186, -30862, -30500, -30099, -29664, -29196, -28695, -28170, -27618, -27040, -26444, -25830, -25200, -24561, -23911, -23256, -22602, -21948, -21294, -20651, -20014, -19391, -18785, -18195, -17626, -17081, -16562, -16070, -15607, -15174, -14629, -15228, -10922, 7742, 6678};