/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0123 256 samples */
 
const int16_t AKWF_0123_256_DATA [256] = 
{831, 2553, 4140, 5642, 7056, 8388, 9643, 10819, 11923, 12959, 13927, 14833, 15678, 16465, 17197, 17878, 18506, 19089, 19625, 20117, 20569, 20981, 21355, 21694, 21999, 22271, 22514, 22726, 22911, 23071, 23204, 23313, 23401, 23467, 23513, 23541, 23549, 23542, 23517, 23478, 23425, 23358, 23278, 23186, 23083, 22970, 22846, 22713, 22572, 22423, 22266, 22103, 21932, 21756, 21574, 21387, 21196, 21000, 20800, 20597, 20390, 20180, 19968, 19754, 19538, 19319, 19100, 18878, 18656, 18434, 18210, 17986, 17762, 17537, 17313, 17089, 16865, 16643, 16420, 16198, 15978, 15757, 15538, 15321, 15105, 14889, 14676, 14464, 14253, 14045, 13837, 13631, 13428, 13226, 13026, 12828, 12632, 12437, 12246, 12055, 11867, 11681, 11496, 11315, 11135, 10957, 10782, 10608, 10437, 10268, 10100, 9936, 9773, 9612, 9453, 9297, 9142, 8990, 8841, 8692, 8546, 8403, 8260, 8121, 7983, 7847, 7714, 7582, 7452, 7324, 7198, 7074, 6952, 6832, 6713, 6596, 6481, 6368, 6257, 6148, 6039, 5934, 5829, 5726, 5626, 5526, 5428, 5332, 5237, 5144, 5053, 4962, 4874, 4787, 4701, 4617, 4534, 4452, 4371, 4290, 4213, 3782, 2446, 403, -1872, -4139, -6315, -8369, -10308, -12136, -13848, -15461, -16974, -18388, -19713, -20952, -22105, -23181, -24181, -25107, -25967, -26759, -27489, -28160, -28774, -29333, -29842, -30300, -30712, -31081, -31407, -31692, -31940, -32152, -32329, -32474, -32588, -32673, -32730, -32761, -32768, -32750, -32711, -32652, -32572, -32474, -32358, -32227, -32079, -31918, -31743, -31555, -31355, -31145, -30924, -30694, -30455, -30208, -29953, -29691, -29423, -29149, -28869, -28586, -28296, -28004, -27709, -27409, -27108, -26803, -26497, -26189, -25880, -25569, -25258, -24946, -24634, -24323, -24010, -23699, -23387, -23077, -22753, -22327, -21664, -20689, -19389, -17774, -15874, -13728, -11438, -9147, -6936, -4827, -2832, -912};