/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0179 256 samples */
 
const int16_t AKWF_0179_256_DATA [256] = 
{5139, 6219, 8825, 10990, 12592, 13769, 14475, 14918, 15266, 15574, 15834, 16034, 16174, 16264, 16318, 16351, 16091, 17646, 6898, -2021, -6694, -14761, -19809, -23876, -26426, -27952, -29064, -30025, -30860, -31526, -32005, -32321, -32517, -32634, -32697, -32692, -32982, -28389, -26575, -24351, -22000, -20366, -19129, -18376, -17910, -17557, -17244, -16977, -16770, -16623, -16528, -16469, -16435, -16415, -16404, -16397, -16394, -16392, -16391, -16391, -16391, -16392, -16391, -16392, -16391, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16391, -16392, -16392, -16392, -16392, -16392, -16392, -16391, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16392, -16299, -16814, -13229, -10255, -8697, -6008, -4325, -2970, -2119, -1611, -1240, -920, -642, -419, -260, -155, -89, -50, -27, -15, -7, -3, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 0, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, -1, 0, 0, -1, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, 0, -1, 0, -1, -1, 0, -1, 0, 0, -1, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, 0, 0, 0, -1, 0, -1, -1, 0, -1};