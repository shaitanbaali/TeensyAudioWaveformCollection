/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0120 256 samples */
 
const int16_t AKWF_0120_256_DATA [256] = 
{1101, 3006, 4888, 6767, 8621, 10441, 12218, 13935, 15593, 17185, 18701, 20134, 21468, 22692, 23805, 24801, 25676, 26437, 27085, 27624, 28061, 28401, 28648, 28809, 28889, 28894, 28830, 28701, 28513, 28270, 27976, 27636, 27252, 26828, 26368, 25873, 25347, 24792, 24210, 23604, 22976, 22325, 21658, 20966, 20241, 19480, 18673, 17819, 16918, 15965, 14965, 13923, 12835, 11710, 10551, 9356, 8134, 6887, 5613, 4320, 3006, 1665, 282, -1150, -2624, -4127, -5646, -7171, -8680, -10166, -11621, -13030, -14395, -15712, -16970, -18177, -19329, -20422, -21463, -22451, -23385, -24268, -25086, -25830, -26495, -27074, -27563, -27962, -28271, -28492, -28630, -28688, -28669, -28578, -28418, -28196, -27913, -27577, -27190, -26757, -26281, -25766, -25215, -24632, -24018, -23376, -22711, -22023, -21313, -20587, -19842, -19083, -18311, -17508, -16668, -15786, -14848, -13855, -12805, -11693, -10525, -9304, -8028, -6704, -5332, -3908, -2426, -860, 778, 2472, 4210, 5975, 7741, 9495, 11225, 12911, 14550, 16135, 17653, 19105, 20484, 21783, 23007, 24152, 25211, 26181, 27055, 27826, 28496, 29062, 29526, 29892, 30163, 30343, 30438, 30452, 30391, 30258, 30060, 29800, 29483, 29115, 28698, 28235, 27733, 27193, 26617, 26011, 25372, 24696, 23980, 23220, 22413, 21561, 20662, 19716, 18731, 17703, 16638, 15540, 14408, 13247, 12064, 10854, 9627, 8384, 7124, 5852, 4571, 3274, 1969, 645, -724, -2133, -3580, -5062, -6561, -8074, -9591, -11094, -12583, -14049, -15481, -16879, -18235, -19538, -20790, -21985, -23117, -24178, -25155, -26037, -26825, -27510, -28092, -28575, -28959, -29248, -29448, -29563, -29596, -29554, -29441, -29262, -29022, -28726, -28377, -27980, -27540, -27058, -26539, -25986, -25401, -24786, -24146, -23480, -22792, -22086, -21352, -20582, -19774, -18916, -18009, -17051, -16037, -14967, -13846, -12664, -11427, -10132, -8772, -7348, -5833, -4213, -2510, -692};