/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0199 256 samples */
 
const int16_t AKWF_0199_256_DATA [256] = 
{19, 101, 190, 283, 379, 476, 574, 671, 769, 866, 961, 1054, 1146, 1235, 1321, 1406, 1487, 1565, 1640, 1712, 1781, 1847, 1908, 1967, 2023, 2076, 2126, 2173, 2217, 2259, 2299, 2337, 2374, 2409, 2444, 2478, 2511, 2545, 2580, 2615, 2651, 2690, 2730, 2774, 2820, 2869, 2923, 2980, 3042, 3110, 3183, 3262, 3347, 3438, 3536, 3641, 3754, 3875, 4003, 4139, 4284, 4438, 4599, 4769, 4947, 5134, 5329, 5533, 5744, 5964, 6190, 6424, 6665, 6912, 7165, 7423, 7687, 7954, 8226, 8500, 8776, 9054, 9333, 9612, 9890, 10167, 10440, 10712, 10978, 11241, 11498, 11749, 11992, 12228, 12456, 12646, 13424, 11293, 6721, 7579, 7361, 6664, 5613, 5360, 4987, 4649, 4304, 3965, 3636, 3319, 3014, 2721, 2442, 2177, 1925, 1688, 1465, 1257, 1062, 881, 713, 558, 416, 285, 168, 64, -19, -105, -199, -293, -389, -483, -577, -671, -764, -856, -949, -1042, -1136, -1230, -1325, -1421, -1519, -1618, -1718, -1821, -1925, -2031, -2139, -2249, -2361, -2475, -2590, -2707, -2825, -2945, -3066, -3187, -3309, -3433, -3555, -3678, -3798, -3920, -4039, -4157, -4273, -4387, -4498, -4606, -4711, -4812, -4909, -5002, -5091, -5174, -5253, -5326, -5394, -5456, -5512, -5562, -5606, -5644, -5676, -5701, -5720, -5732, -5739, -5739, -5732, -5720, -5702, -5678, -5649, -5613, -5573, -5529, -5478, -5425, -5366, -5304, -5238, -5168, -5095, -5019, -4941, -4861, -4778, -4694, -4608, -4521, -4433, -4344, -4254, -4164, -4073, -3982, -3891, -3801, -3711, -3621, -3532, -3442, -3353, -3267, -3174, -3077, -2979, -2880, -2779, -2677, -2573, -2467, -2361, -2252, -2142, -2032, -1919, -1805, -1691, -1577, -1461, -1345, -1229, -1114, -998, -884, -770, -659, -549, -441, -338, -237, -142, -53};