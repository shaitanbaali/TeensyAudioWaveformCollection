/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0124 256 samples */
 
const int16_t AKWF_0124_256_DATA [256] = 
{1306, 4200, 6768, 9112, 11245, 13186, 14955, 16561, 18023, 19355, 20563, 21666, 22668, 23579, 24407, 25163, 25848, 26472, 27041, 27557, 28027, 28455, 28844, 29198, 29520, 29813, 30080, 30322, 30542, 30744, 30926, 31092, 31243, 31381, 31506, 31620, 31723, 31817, 31903, 31981, 32051, 32116, 32175, 32228, 32276, 32321, 32361, 32398, 32431, 32461, 32489, 32514, 32537, 32557, 32576, 32593, 32609, 32623, 32636, 32648, 32658, 32668, 32677, 32685, 32693, 32699, 32705, 32711, 32716, 32720, 32725, 32728, 32732, 32735, 32738, 32740, 32743, 32745, 32747, 32748, 32750, 32751, 32753, 32754, 32755, 32756, 32757, 32759, 32759, 32759, 32760, 32761, 32761, 32762, 32762, 32762, 32763, 32763, 32764, 32763, 32764, 32764, 32764, 32764, 32765, 32765, 32765, 32765, 32765, 32764, 32763, 32761, 32488, 31709, 30508, 28765, 25724, 21969, 18124, 14186, 10176, 6309, 2778, -429, -3343, -6002, -8416, -10612, -12614, -14431, -16085, -17592, -18960, -20206, -21341, -22371, -23309, -24164, -24938, -25645, -26288, -26872, -27405, -27889, -28328, -28729, -29094, -29424, -29727, -30001, -30250, -30477, -30684, -30871, -31043, -31199, -31340, -31468, -31586, -31693, -31790, -31878, -31958, -32031, -32097, -32157, -32212, -32262, -32308, -32349, -32387, -32421, -32452, -32481, -32506, -32530, -32551, -32571, -32589, -32605, -32619, -32632, -32644, -32655, -32665, -32674, -32683, -32690, -32697, -32704, -32709, -32714, -32719, -32723, -32727, -32730, -32734, -32737, -32740, -32742, -32744, -32746, -32748, -32749, -32751, -32753, -32753, -32755, -32756, -32756, -32758, -32758, -32759, -32760, -32760, -32761, -32761, -32762, -32762, -32762, -32763, -32763, -32764, -32763, -32764, -32764, -32764, -32765, -32765, -32765, -32766, -32765, -32765, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32766, -32764, -32768, -32726, -32301, -31383, -30064, -27980, -24599, -20801, -16923, -12968, -8965, -5201, -1729};