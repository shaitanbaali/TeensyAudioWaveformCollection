/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0185 256 samples */
 
const int16_t AKWF_0185_256_DATA [256] = 
{5333, 9971, 9106, 9267, 9267, 9267, 9267, 9267, 9285, 9235, 9326, 17410, 18816, 18471, 18535, 18535, 18535, 18535, 18534, 18535, 18535, 18534, 18535, 18534, 18535, 18535, 18535, 18535, 18535, 18534, 18535, 18535, 18535, 18535, 18535, 18534, 18534, 18534, 18535, 18376, 19235, 12824, 8596, 9419, 9267, 9267, 9267, 9267, 9263, 9199, 9608, 1922, -439, 94, -7, -47, 254, -7556, -9667, -9181, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9437, -8532, -13837, -19273, -18365, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18494, -18701, -17923, -9727, -9138, -9302, -9268, -9268, -9268, -9268, -9268, -9268, -9268, -9265, -9190, -9648, -2031, 458, -100, -1, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, 0, -1, -1, -1, 0, 0, -1, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, -104, 476, -2140, -9685, -9180, -9266, -9268, -9268, -9268, -9268, -9268, -9436, -8535, -14475, -19248, -18372, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18595, -18274, -19568, -27683, -27849, -27782, -27802, -27802, -27802, -27802, -27686, -28334, -25325, -18019, -18647, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18535, -18532, -18457, -18915, -11298, -8810, -9367, -9268, -9268, -9201, -9568, -8050, -1, 17, -16, 0, -1, 0, -1, 0};