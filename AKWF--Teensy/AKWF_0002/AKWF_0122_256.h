/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0122 256 samples */
 
const int16_t AKWF_0122_256_DATA [256] = 
{1061, 3146, 5032, 6761, 8335, 9766, 11068, 12247, 13320, 14297, 15182, 15988, 16721, 17384, 17986, 18529, 19019, 19457, 19850, 20196, 20499, 20762, 20986, 21173, 21325, 21443, 21528, 21581, 21604, 21599, 21566, 21506, 21422, 21314, 21182, 21029, 20856, 20664, 20453, 20226, 19984, 19727, 19457, 19176, 18884, 18584, 18276, 17961, 17642, 17318, 16994, 16669, 16344, 16022, 15704, 15393, 15106, 14877, 14742, 14720, 14810, 14993, 15240, 15532, 15862, 16221, 16604, 17002, 17403, 17799, 18191, 18600, 19066, 19617, 20260, 20995, 21793, 22626, 23479, 24341, 25202, 26056, 26887, 27683, 28438, 29140, 29782, 30365, 30882, 31335, 31722, 32046, 32307, 32508, 32650, 32737, 32769, 32752, 32686, 32574, 32418, 32221, 31985, 31712, 31402, 31060, 30687, 30282, 29844, 29359, 28803, 28159, 27420, 26581, 25655, 24657, 23589, 22457, 21259, 19981, 18613, 17106, 15538, 12235, 8308, 6480, 4549, 2357, 113, -2047, -4067, -5927, -7620, -9161, -10564, -11834, -12991, -14042, -14995, -15863, -16654, -17368, -18017, -18605, -19134, -19610, -20035, -20412, -20745, -21034, -21282, -21491, -21662, -21798, -21899, -21966, -22002, -22007, -21984, -21931, -21852, -21748, -21619, -21467, -21293, -21099, -20886, -20654, -20406, -20142, -19865, -19573, -19270, -18959, -18637, -18308, -17974, -17634, -17291, -16947, -16603, -16260, -15926, -15617, -15374, -15221, -15171, -15224, -15366, -15573, -15824, -16112, -16430, -16769, -17122, -17481, -17835, -18192, -18581, -19032, -19566, -20190, -20897, -21669, -22480, -23306, -24144, -24983, -25809, -26616, -27389, -28118, -28798, -29422, -29984, -30486, -30926, -31304, -31621, -31878, -32078, -32225, -32316, -32357, -32351, -32299, -32202, -32063, -31886, -31670, -31418, -31133, -30816, -30467, -30088, -29672, -29203, -28663, -28035, -27315, -26503, -25605, -24635, -23602, -22505, -21345, -20119, -18813, -17399, -15884, -13781, -9633, -6991, -5317, -3270, -1045};