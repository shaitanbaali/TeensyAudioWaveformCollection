/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0167 256 samples */
 
const int16_t AKWF_0167_256_DATA [256] = 
{716, 1940, 3056, 4059, 4906, 5535, 5883, 5904, 5600, 5029, 4289, 3487, 2717, 2038, 1475, 1033, 717, 514, 402, 367, 414, 567, 869, 1395, 2237, 3490, 5250, 7524, 10218, 13176, 16218, 19220, 22071, 24639, 26800, 28440, 29453, 29781, 29402, 28344, 26664, 24457, 21840, 18899, 15706, 12305, 8684, 4848, 828, -3330, -7471, -11546, -15557, -19315, -22669, -25540, -27869, -29662, -30974, -31869, -32425, -32709, -32767, -32637, -32352, -31947, -31467, -30958, -30477, -30093, -29877, -29875, -30083, -30438, -30834, -31148, -31271, -31127, -30677, -29918, -28872, -27564, -26026, -24278, -22320, -20157, -17782, -15184, -12417, -9577, -6754, -4009, -1335, 1304, 3927, 6561, 9200, 11772, 14194, 16370, 18231, 19784, 21026, 21973, 22691, 23253, 23734, 24190, 24637, 25048, 25364, 25508, 25420, 25073, 24490, 23739, 22900, 22065, 21315, 20713, 20297, 20069, 19993, 20013, 20070, 20117, 20130, 20095, 20005, 19849, 19608, 19254, 18752, 18044, 17069, 15797, 14229, 12424, 10488, 8509, 6571, 4734, 2996, 1331, -280, -1881, -3511, -5205, -7010, -8920, -10877, -12800, -14561, -15999, -16952, -17327, -17150, -16513, -15515, -14225, -12711, -11069, -9399, -7808, -6392, -5207, -4280, -3608, -3145, -2827, -2579, -2342, -2085, -1816, -1569, -1392, -1314, -1335, -1412, -1470, -1413, -1153, -615, 243, 1398, 2852, 4620, 6589, 8649, 10714, 12711, 14593, 16320, 17843, 19119, 20097, 20719, 20919, 20632, 19822, 18499, 16736, 14664, 12418, 10133, 7911, 5801, 3828, 1999, 296, -1281, -2723, -4025, -5160, -6102, -6841, -7398, -7841, -8246, -8639, -8995, -9284, -9472, -9522, -9433, -9247, -9028, -8848, -8771, -8826, -9023, -9340, -9716, -10071, -10327, -10439, -10393, -10227, -10005, -9807, -9697, -9703, -9816, -9980, -10120, -10154, -10002, -9608, -8947, -8038, -6933, -5713, -4450, -3148, -1832, -511};