/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0119 256 samples */
 
const int16_t AKWF_0119_256_DATA [256] = 
{646, 2400, 4030, 5568, 7034, 8448, 9816, 11128, 12391, 13608, 14783, 15937, 17066, 18181, 19285, 20380, 21459, 22524, 23566, 24577, 25556, 26495, 27385, 28228, 29014, 29739, 30401, 30989, 31501, 31931, 32273, 32526, 32689, 32761, 32746, 32646, 32464, 32205, 31871, 31465, 30991, 30452, 29851, 29188, 28466, 27689, 26855, 25967, 25028, 24034, 22988, 21892, 20739, 19536, 18283, 16969, 15601, 14172, 12660, 11064, 9137, 6829, 4716, 2581, 615, -1161, -2730, -4073, -5203, -6151, -6939, -7570, -8057, -8414, -8661, -8813, -8887, -8896, -8848, -8750, -8613, -8438, -8231, -7994, -7731, -7441, -7131, -6798, -6448, -6083, -5707, -5323, -4935, -4540, -4154, -3780, -3431, -3118, -2852, -2646, -2508, -2448, -2466, -2567, -2743, -2991, -3319, -3720, -4193, -4740, -5349, -6019, -6734, -7490, -8275, -9075, -9889, -10701, -11498, -12272, -12995, -13662, -14251, -14747, -15147, -15441, -15635, -15730, -15736, -15659, -15510, -15294, -15023, -14701, -14330, -13920, -13473, -12988, -12472, -11919, -11332, -10709, -10049, -9348, -8600, -7796, -6918, -5889, -4546, -3203, -1863, -546, 682, 1825, 2871, 3817, 4679, 5472, 6188, 6829, 7395, 7887, 8312, 8673, 8974, 9218, 9409, 9546, 9634, 9672, 9660, 9601, 9494, 9339, 9137, 8885, 8583, 8228, 7818, 7344, 6798, 6162, 5389, 4256, 3005, 1739, 398, -907, -2198, -3459, -4678, -5873, -7050, -8198, -9315, -10393, -11427, -12420, -13372, -14282, -15151, -15983, -16773, -17526, -18239, -18913, -19551, -20151, -20711, -21234, -21721, -22167, -22577, -22948, -23279, -23573, -23825, -24037, -24210, -24341, -24432, -24483, -24491, -24460, -24388, -24276, -24124, -23934, -23704, -23436, -23131, -22788, -22409, -21995, -21546, -21062, -20544, -19994, -19410, -18793, -18147, -17466, -16752, -16008, -15228, -14412, -13559, -12659, -11706, -10691, -9585, -8354, -6669, -4804, -3006, -1096};