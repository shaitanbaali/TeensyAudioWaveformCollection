/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0162 256 samples */
 
const int16_t AKWF_0162_256_DATA [256] = 
{433, 1254, 2047, 2830, 3601, 4357, 5100, 5825, 6536, 7193, 7622, 7677, 7299, 6441, 5128, 3747, 2551, 1516, 629, -124, -757, -1299, -1598, -1021, 670, 3260, 6457, 9947, 13473, 16864, 19987, 22777, 25206, 27256, 28940, 30279, 31291, 32014, 32481, 32719, 32761, 32633, 32364, 31976, 31490, 30929, 30307, 29638, 28939, 28218, 27484, 26747, 26013, 25287, 24575, 23876, 23199, 22541, 21903, 21289, 20698, 20128, 19582, 19057, 18550, 18066, 17585, 17078, 16550, 16005, 15445, 14877, 14302, 13723, 13145, 12568, 11994, 11426, 10864, 10310, 9767, 9232, 8707, 8194, 7690, 7203, 6487, 5176, 3150, 452, -2577, -5573, -8351, -10843, -13016, -14879, -16447, -17733, -18761, -19551, -20123, -20496, -20691, -20722, -20608, -20364, -20006, -19545, -18995, -18368, -17673, -16918, -16116, -15270, -14389, -13481, -12550, -11603, -10647, -9682, -8713, -7746, -6779, -5820, -4871, -3930, -3004, -2093, -1197, -322, 536, 1372, 2185, 2978, 3751, 4499, 5227, 5934, 6618, 7281, 7927, 8554, 9112, 9551, 9877, 10108, 10253, 10321, 10324, 10256, 9660, 7980, 5211, 1605, -2505, -6780, -10969, -14909, -18474, -21581, -24197, -26358, -28120, -29530, -30624, -31426, -31924, -32133, -32085, -31807, -31330, -30676, -29869, -28934, -27886, -26745, -25529, -24248, -22918, -21554, -20158, -18747, -17329, -15904, -14487, -13085, -11694, -10326, -8983, -7663, -6377, -5123, -3901, -2719, -1575, -468, 595, 1620, 2602, 3538, 4434, 5289, 6100, 6870, 7601, 8288, 8936, 9545, 10113, 10617, 10982, 11145, 11137, 10929, 10005, 8296, 5929, 3039, 61, -2585, -4850, -6788, -8423, -9793, -10929, -11852, -12591, -13166, -13595, -13896, -14086, -14176, -14181, -14111, -13976, -13785, -13546, -13255, -12882, -12428, -11904, -11320, -10684, -10004, -9286, -8538, -7766, -6971, -6163, -5344, -4515, -3683, -2852, -2020, -1195, -360};