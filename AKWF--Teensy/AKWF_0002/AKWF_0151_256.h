/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0151 256 samples */
 
const int16_t AKWF_0151_256_DATA [256] = 
{1723, 4273, 6640, 8870, 10945, 12863, 14624, 16224, 17682, 19007, 20209, 21303, 22294, 23179, 23970, 24674, 25300, 25864, 26372, 26828, 27232, 27586, 27894, 28179, 28462, 28772, 29128, 29535, 29983, 30449, 30906, 31329, 31706, 32028, 32294, 32505, 32656, 32745, 32767, 32722, 32614, 32451, 32240, 31985, 31688, 31350, 30973, 30561, 30128, 29680, 29226, 28766, 28295, 27804, 27283, 26717, 26099, 25425, 24692, 23902, 23056, 22153, 21203, 20221, 19227, 18252, 17317, 16436, 15614, 14841, 14103, 13391, 12694, 12009, 11337, 10668, 9992, 9296, 8539, 7726, 6908, 6115, 5364, 4658, 3989, 3355, 2767, 2246, 1848, 1669, 1724, 1959, 2322, 2766, 3248, 3732, 4200, 4641, 5053, 5432, 5774, 6071, 6317, 6508, 6645, 6728, 6755, 6714, 6583, 6324, 5848, 5141, 4279, 3309, 2258, 1146, -24, -1230, -2435, -3592, -4631, -5487, -6114, -6482, -6600, -6498, -6226, -5850, -5446, -5088, -4813, -4638, -4568, -4600, -4729, -4944, -5231, -5572, -5952, -6363, -6801, -7262, -7744, -8240, -8737, -9226, -9700, -10157, -10600, -11031, -11444, -11821, -12138, -12369, -12496, -12513, -12436, -12290, -12113, -11932, -11769, -11635, -11533, -11466, -11436, -11449, -11507, -11610, -11751, -11923, -12116, -12326, -12553, -12794, -13051, -13316, -13582, -13840, -14083, -14312, -14535, -14761, -15003, -15278, -15591, -15947, -16348, -16793, -17277, -17801, -18352, -18918, -19479, -20010, -20496, -20929, -21306, -21635, -21929, -22196, -22445, -22679, -22901, -23117, -23337, -23566, -23812, -24075, -24349, -24632, -24919, -25209, -25507, -25814, -26121, -26412, -26659, -26836, -26921, -26909, -26808, -26637, -26425, -26190, -25947, -25702, -25454, -25207, -24961, -24724, -24497, -24283, -24078, -23874, -23667, -23449, -23221, -22981, -22727, -22449, -22139, -21782, -21372, -20906, -20382, -19795, -19116, -18286, -17182, -15619, -13627, -11338, -8842, -6211, -3533, -816};