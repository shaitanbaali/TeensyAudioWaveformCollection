/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0131 256 samples */
 
const int16_t AKWF_0131_256_DATA [256] = 
{167, 734, 1292, 1856, 2422, 2986, 3547, 4099, 4644, 5181, 5707, 6223, 6728, 7219, 7699, 8169, 8626, 9072, 9507, 9931, 10346, 10752, 11147, 11533, 11911, 12280, 12642, 12996, 13343, 13684, 14017, 14345, 14667, 14983, 15293, 15600, 15901, 16198, 16490, 16778, 17062, 17342, 17619, 17892, 18162, 18428, 18692, 18954, 19212, 19467, 19720, 19970, 20219, 20465, 20708, 20950, 21190, 21428, 21664, 21898, 22131, 22362, 22591, 22819, 23045, 23270, 23493, 23715, 23937, 24156, 24374, 24591, 24807, 25023, 25235, 25448, 25660, 25871, 26081, 26290, 26497, 26704, 26910, 27115, 27320, 27524, 27727, 27929, 28131, 28331, 28531, 28730, 28928, 29126, 29323, 29520, 29716, 29911, 30106, 30301, 30494, 30687, 30880, 31071, 31263, 31454, 31644, 31834, 32024, 32212, 32399, 32576, 32801, 32148, 30060, 27233, 23654, 18999, 14059, 10267, 7340, 5005, 3068, 1399, -106, -1527, -2905, -4269, -5636, -7005, -8372, -9734, -11072, -12384, -13660, -14886, -16060, -17176, -18228, -19217, -20142, -20997, -21790, -22520, -23186, -23795, -24348, -24845, -25292, -25693, -26046, -26358, -26632, -26869, -27071, -27240, -27381, -27495, -27584, -27649, -27692, -27717, -27722, -27711, -27684, -27642, -27587, -27519, -27441, -27352, -27252, -27145, -27028, -26904, -26774, -26635, -26492, -26342, -26187, -26027, -25863, -25694, -25522, -25345, -25164, -24980, -24794, -24604, -24411, -24215, -24017, -23816, -23612, -23407, -23200, -22989, -22777, -22563, -22346, -22128, -21907, -21684, -21461, -21233, -21005, -20773, -20541, -20305, -20069, -19830, -19588, -19345, -19099, -18851, -18601, -18346, -18091, -17833, -17571, -17307, -17040, -16769, -16495, -16219, -15938, -15653, -15364, -15070, -14773, -14471, -14162, -13848, -13529, -13202, -12869, -12526, -12174, -11813, -11441, -11056, -10654, -10234, -9791, -9322, -8809, -8242, -7523, -6320, -5051, -4070, -3280, -2616, -2023, -1465, -923, -368};