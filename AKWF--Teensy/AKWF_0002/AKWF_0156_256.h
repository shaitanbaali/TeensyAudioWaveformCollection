/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0156 256 samples */
 
const int16_t AKWF_0156_256_DATA [256] = 
{40, 120, 284, 449, 607, 778, 967, 1158, 1353, 1555, 1764, 1977, 2194, 2414, 2640, 2869, 3101, 3337, 3576, 3817, 4062, 4310, 4560, 4813, 5068, 5325, 5586, 5848, 6112, 6379, 6647, 6917, 7189, 7463, 7739, 8017, 8296, 8576, 8859, 9142, 9427, 9714, 10002, 10291, 10582, 10874, 11167, 11462, 11756, 12053, 12351, 12649, 12949, 13250, 13551, 13854, 14158, 14461, 14767, 15073, 15379, 15687, 15995, 16304, 16614, 16924, 17235, 17547, 17858, 18171, 18485, 18798, 19112, 19427, 19741, 20057, 20373, 20689, 21006, 21323, 21640, 21957, 22276, 22593, 22912, 23230, 23548, 23867, 24187, 24506, 24826, 25145, 25464, 25784, 26103, 26422, 26742, 27061, 27381, 27701, 28020, 28339, 28658, 28977, 29296, 29615, 29933, 30252, 30570, 30887, 31205, 31523, 31824, 32193, 32172, 30217, 27588, 25281, 22971, 20469, 17978, 15557, 13090, 10557, 8015, 5506, 3103, 871, -630, -1897, -4697, -7577, -10175, -12845, -15610, -18213, -20595, -22804, -24813, -26584, -28109, -29398, -30464, -31308, -31941, -32385, -32653, -32763, -32732, -32579, -32321, -31974, -31555, -31078, -30558, -30007, -29438, -28858, -28278, -27705, -27142, -26598, -26074, -25573, -25096, -24643, -24214, -23811, -23428, -23066, -22723, -22398, -22085, -21786, -21496, -21215, -20940, -20668, -20398, -20131, -19863, -19594, -19323, -19048, -18771, -18491, -18206, -17918, -17627, -17332, -17034, -16733, -16429, -16124, -15816, -15507, -15198, -14887, -14576, -14265, -13955, -13645, -13337, -13030, -12722, -12418, -12114, -11812, -11513, -11214, -10917, -10623, -10330, -10038, -9749, -9462, -9176, -8893, -8610, -8330, -8052, -7774, -7500, -7226, -6955, -6686, -6418, -6152, -5888, -5627, -5366, -5110, -4854, -4601, -4351, -4103, -3858, -3616, -3376, -3140, -2908, -2678, -2452, -2230, -2012, -1799, -1590, -1387, -1188, -997, -812, -635, -466, -309, -166, -40};