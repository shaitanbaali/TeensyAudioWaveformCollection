/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0195 256 samples */
 
const int16_t AKWF_0195_256_DATA [256] = 
{261, 768, 1251, 1721, 2177, 2635, 3122, 3537, 3967, 4395, 4804, 5202, 5573, 6026, 6816, 7149, 7713, 7820, 11292, 15994, 15817, 18829, 19555, 20536, 21804, 22918, 23927, 24832, 25644, 26375, 27030, 27619, 28149, 28623, 29049, 29433, 29776, 30085, 30363, 30611, 30835, 31036, 31216, 31378, 31524, 31654, 31772, 31877, 31972, 32056, 32133, 32201, 32263, 32318, 32368, 32412, 32452, 32488, 32520, 32549, 32575, 32598, 32619, 32638, 32655, 32670, 32684, 32696, 32707, 32717, 32726, 32734, 32741, 32747, 32754, 32751, 32788, 32620, 32019, 31591, 31132, 30624, 30072, 29485, 28869, 28225, 27567, 26892, 26204, 25510, 24809, 24105, 23401, 22695, 21993, 21294, 20597, 19905, 19221, 18538, 17865, 17199, 16537, 15884, 15235, 14595, 13962, 13334, 12712, 12099, 11487, 10882, 10285, 9689, 9098, 8513, 7927, 7345, 6759, 6173, 5579, 4980, 4311, 3587, 3017, 2429, 1847, 1274, 714, 169, -369, -845, -1638, -2433, -2855, -3562, -4236, -4841, -5428, -6096, -6180, -10517, -14485, -14520, -17900, -18773, -19728, -21084, -22272, -23346, -24309, -25176, -25955, -26652, -27280, -27844, -28349, -28804, -29212, -29578, -29908, -30203, -30468, -30707, -30921, -31113, -31285, -31440, -31579, -31704, -31816, -31918, -32007, -32089, -32161, -32227, -32286, -32339, -32386, -32429, -32467, -32501, -32532, -32560, -32585, -32607, -32627, -32646, -32662, -32676, -32689, -32701, -32711, -32720, -32729, -32737, -32743, -32750, -32755, -32756, -32781, -32678, -32116, -31681, -31247, -30761, -30233, -29668, -29075, -28457, -27820, -27170, -26505, -25832, -25155, -24473, -23791, -23109, -22425, -21747, -21073, -20401, -19735, -19074, -18419, -17772, -17128, -16494, -15864, -15243, -14625, -14017, -13413, -12814, -12225, -11637, -11057, -10481, -9911, -9344, -8782, -8220, -7661, -7106, -6548, -5989, -5425, -4852, -4235, -3528, -2965, -2411, -1850, -1303, -768, -234};