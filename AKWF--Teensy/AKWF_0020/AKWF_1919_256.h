/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1919 256 samples */
 
const int16_t AKWF_1919_256_DATA [256] = 
{345, 1267, 2267, 3369, 4572, 5885, 7299, 8787, 10355, 11973, 13617, 15273, 16907, 18506, 20059, 21534, 22914, 24190, 25358, 26449, 27456, 28375, 29197, 29937, 30590, 31152, 31630, 32021, 32330, 32561, 32718, 32769, 32758, 32658, 32452, 32170, 31829, 31437, 31010, 30566, 30108, 29657, 29223, 28815, 28446, 28116, 27821, 27557, 27321, 27104, 26897, 26693, 26480, 26250, 25994, 25703, 25372, 24990, 24556, 24080, 23567, 23022, 22445, 21846, 21225, 20594, 19957, 19321, 18689, 18068, 17462, 16883, 16310, 15739, 15176, 14624, 14087, 13571, 13076, 12608, 12174, 11774, 11415, 11092, 10811, 10575, 10399, 10276, 10195, 10139, 10097, 10049, 9981, 9875, 9716, 9488, 9176, 8771, 8266, 7657, 6955, 6164, 5293, 4353, 3358, 2311, 1230, 126, -990, -2099, -3196, -4275, -5327, -6377, -7420, -8444, -9458, -10451, -11417, -12354, -13252, -14106, -14925, -15693, -16413, -17079, -17686, -18228, -18711, -19142, -19525, -19869, -20184, -20477, -20757, -21031, -21305, -21590, -21887, -22200, -22527, -22864, -23206, -23544, -23873, -24184, -24469, -24717, -24924, -25079, -25176, -25210, -25175, -25080, -24928, -24721, -24464, -24154, -23799, -23399, -22954, -22473, -21956, -21408, -20835, -20236, -19612, -18958, -18278, -17578, -16863, -16134, -15401, -14672, -13951, -13239, -12548, -11880, -11242, -10642, -10063, -9508, -8985, -8493, -8039, -7632, -7265, -6952, -6693, -6491, -6350, -6273, -6257, -6308, -6427, -6608, -6846, -7139, -7478, -7857, -8269, -8705, -9159, -9627, -10096, -10564, -11024, -11487, -11960, -12431, -12897, -13347, -13777, -14177, -14543, -14868, -15144, -15365, -15527, -15629, -15661, -15623, -15518, -15350, -15127, -14856, -14542, -14195, -13825, -13433, -13031, -12627, -12223, -11827, -11426, -11015, -10597, -10171, -9735, -9294, -8842, -8378, -7903, -7416, -6914, -6397, -5863, -5318, -4782, -4249, -3708, -3144, -2551, -1915, -1229, -458};