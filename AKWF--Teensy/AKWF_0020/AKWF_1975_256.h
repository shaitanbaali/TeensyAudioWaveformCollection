/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1975 256 samples */
 
const int16_t AKWF_1975_256_DATA [256] = 
{1690, 7122, 12501, 17664, 19869, 21264, 22825, 24351, 25877, 27405, 28929, 30426, 32089, 32415, 31024, 29729, 28423, 27110, 25798, 24488, 23180, 21854, 20612, 19945, 19436, 18900, 18370, 17837, 17307, 16775, 16240, 15726, 15011, 14064, 13130, 12194, 11257, 10322, 9383, 8450, 7508, 6600, 5942, 5338, 4722, 4111, 3498, 2884, 2272, 1665, 1026, 668, 602, 509, 422, 335, 249, 160, 74, -14, -89, -90, -77, -66, -55, -43, -31, -21, -9, 3, 8, 7, 7, 8, 8, 8, 8, 8, 7, 8, 7, 5, 4, 3, 1, -1, -3, -4, -6, -7, -6, -6, -7, -6, -4, -5, -5, -4, -5, -3, -2, 1, 2, 3, 4, 5, 7, 8, 7, 5, 3, 0, -3, -4, -7, -9, -13, -14, -12, -8, -5, -3, 0, 4, 6, 9, 12, 12, 9, 5, 3, 0, -4, -6, -10, -13, -14, -12, -9, -7, -3, 0, 2, 5, 8, 11, 11, 8, 5, 3, 1, -3, -5, -7, -10, -13, -10, -8, -7, -5, -3, -2, 1, 3, 4, 3, 4, 3, 4, 2, 1, 2, 1, 2, 1, -1, 0, 0, 0, 0, 0, -1, 0, -1, -3, -5, -8, -12, -14, -17, -20, -22, -25, -23, -8, 6, 21, 36, 51, 66, 81, 96, 110, 62, -15, -88, -162, -237, -311, -384, -465, -515, -731, -1286, -1837, -2389, -2941, -3491, -4044, -4598, -5147, -5707, -6564, -7548, -8513, -9481, -10449, -11419, -12386, -13349, -14338, -15150, -15654, -16157, -16660, -17162, -17665, -18167, -18672, -19168, -19701, -20826, -22186, -23505, -24834, -26163, -27490, -28818, -30081, -31703, -30677, -25207, -19876, -14535, -9198, -3750};