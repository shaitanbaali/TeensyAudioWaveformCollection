/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1972 256 samples */
 
const int16_t AKWF_1972_256_DATA [256] = 
{171, 641, 1000, 1366, 1731, 2095, 2462, 2826, 3191, 3557, 3924, 4335, 4757, 5177, 5597, 6018, 6437, 6858, 7279, 7699, 8109, 8501, 8893, 9287, 9679, 10072, 10465, 10857, 11251, 11644, 12042, 12443, 12843, 13242, 13641, 14041, 14442, 14841, 15242, 15628, 15995, 16364, 16731, 17101, 17469, 17837, 18205, 18574, 18942, 19310, 19677, 20043, 20411, 20777, 21143, 21511, 21878, 22246, 22593, 22914, 23234, 23557, 23879, 24202, 24524, 24844, 25167, 25487, 25789, 26086, 26384, 26683, 26980, 27280, 27578, 27876, 28178, 28452, 28702, 28955, 29206, 29458, 29710, 29961, 30213, 30467, 30705, 30856, 30993, 31132, 31272, 31411, 31551, 31690, 31829, 31970, 32077, 32155, 32236, 32315, 32394, 32475, 32555, 32631, 32719, 32749, 32543, 32300, 32064, 31828, 31591, 31352, 31116, 30878, 30645, 30331, 29948, 29576, 29201, 28827, 28452, 28078, 27682, 27386, 26599, 23900, 21009, 18165, 15302, 12446, 9590, 6726, 3870, 1021, -2060, -5303, -8532, -11768, -14994, -18227, -21461, -24664, -27995, -30610, -30986, -31121, -31310, -31485, -31660, -31834, -32009, -32184, -32362, -32431, -32426, -32431, -32433, -32436, -32439, -32442, -32444, -32451, -32423, -32279, -32129, -31981, -31833, -31685, -31536, -31386, -31238, -31092, -30866, -30597, -30332, -30065, -29800, -29535, -29268, -29003, -28738, -28473, -28215, -27955, -27695, -27437, -27177, -26917, -26659, -26400, -26140, -25817, -25456, -25101, -24745, -24389, -24033, -23677, -23321, -22965, -22612, -22276, -21939, -21602, -21264, -20926, -20590, -20252, -19916, -19578, -19207, -18818, -18432, -18046, -17660, -17272, -16887, -16501, -16113, -15726, -15339, -14949, -14561, -14174, -13784, -13396, -13008, -12619, -12230, -11835, -11435, -11037, -10638, -10239, -9841, -9441, -9042, -8645, -8241, -7826, -7413, -6997, -6583, -6171, -5756, -5342, -4929, -4512, -4016, -3492, -2972, -2451, -1931, -1412, -892, -363};