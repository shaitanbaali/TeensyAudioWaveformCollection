/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1989 256 samples */
 
const int16_t AKWF_1989_256_DATA [256] = 
{838, 2145, 3426, 4711, 5995, 7279, 8566, 9849, 11132, 12426, 13669, 14735, 15786, 16837, 17888, 18941, 19990, 21042, 22095, 23143, 24196, 25248, 26298, 27350, 28402, 29453, 30500, 31560, 32567, 32532, 32071, 31683, 31281, 30881, 30479, 30077, 29675, 29275, 28872, 28471, 28070, 27669, 27267, 26865, 26463, 26059, 25671, 25033, 24154, 23293, 22430, 21568, 20704, 19841, 18979, 18116, 17252, 16390, 15526, 14664, 13802, 12937, 12075, 11220, 10321, 9715, 9743, 9797, 9844, 9894, 9943, 9993, 10042, 10093, 10142, 10191, 10241, 10291, 10341, 10391, 10439, 10490, 10539, 10593, 10685, 10787, 10887, 10988, 11089, 11189, 11290, 11390, 11490, 11592, 11692, 11792, 11893, 11993, 12094, 12195, 12295, 12394, 12561, 12770, 12973, 13176, 13380, 13585, 13790, 13994, 14197, 14401, 14606, 14810, 15015, 15217, 15422, 15627, 15812, 16102, 15663, 14141, 12674, 11201, 9728, 8251, 6777, 5302, 3827, 2353, 879, -597, -2070, -3545, -5021, -6494, -7965, -9459, -10833, -11719, -12553, -13396, -14239, -15081, -15921, -16763, -17605, -18446, -19288, -20131, -20971, -21814, -22656, -23497, -24336, -25183, -25997, -25901, -25417, -24999, -24566, -24134, -23702, -23271, -22840, -22408, -21976, -21545, -21113, -20680, -20249, -19818, -19386, -18959, -18508, -18348, -18485, -18596, -18710, -18825, -18941, -19056, -19170, -19286, -19401, -19516, -19632, -19748, -19862, -19977, -20093, -20205, -20334, -20348, -20091, -19819, -19553, -19284, -19016, -18748, -18480, -18211, -17943, -17674, -17407, -17139, -16870, -16602, -16334, -16067, -15794, -15554, -15555, -15622, -15677, -15734, -15791, -15849, -15906, -15963, -16020, -16077, -16135, -16194, -16251, -16307, -16365, -16422, -16477, -16544, -16340, -15959, -15600, -15237, -14874, -14511, -14147, -13785, -13422, -13058, -12695, -12332, -11968, -11605, -11242, -10879, -10506, -10188, -9484, -8180, -6898, -5614, -4331, -3046, -1765, -459};