/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1929 256 samples */
 
const int16_t AKWF_1929_256_DATA [256] = 
{1523, 4066, 6513, 8904, 11217, 13440, 15562, 17562, 19437, 21176, 22765, 24206, 25489, 26608, 27565, 28357, 28983, 29447, 29751, 29900, 29899, 29754, 29473, 29063, 28535, 27898, 27160, 26335, 25431, 24459, 23433, 22363, 21257, 20131, 18991, 17848, 16716, 15598, 14505, 13449, 12433, 11463, 10550, 9696, 8906, 8185, 7536, 6961, 6463, 6041, 5697, 5432, 5244, 5131, 5094, 5126, 5228, 5395, 5623, 5906, 6242, 6625, 7049, 7508, 7997, 8508, 9035, 9573, 10113, 10647, 11172, 11676, 12156, 12603, 13010, 13370, 13678, 13924, 14107, 14218, 14251, 14203, 14070, 13847, 13532, 13122, 12617, 12013, 11313, 10518, 9627, 8646, 7578, 6424, 5196, 3897, 2532, 1115, -348, -1849, -3373, -4912, -6456, -7985, -9493, -10967, -12389, -13750, -15038, -16236, -17335, -18325, -19189, -19922, -20513, -20953, -21236, -21356, -21308, -21089, -20698, -20137, -19402, -18502, -17442, -16222, -14858, -13358, -11727, -9987, -8146, -6218, -4225, -2180, -98, 1994, 4086, 6158, 8184, 10154, 12048, 13841, 15527, 17084, 18495, 19752, 20842, 21752, 22476, 23006, 23337, 23466, 23395, 23122, 22649, 21986, 21137, 20109, 18919, 17576, 16090, 14484, 12769, 10963, 9090, 7162, 5199, 3228, 1260, -684, -2579, -4416, -6175, -7834, -9387, -10818, -12111, -13263, -14262, -15100, -15778, -16292, -16640, -16828, -16856, -16733, -16466, -16064, -15540, -14905, -14173, -13362, -12484, -11559, -10603, -9634, -8671, -7730, -6826, -5982, -5208, -4521, -3935, -3460, -3110, -2891, -2813, -2879, -3093, -3458, -3972, -4631, -5435, -6373, -7438, -8623, -9913, -11293, -12754, -14276, -15842, -17439, -19044, -20639, -22210, -23731, -25189, -26567, -27841, -29001, -30030, -30911, -31636, -32190, -32563, -32750, -32744, -32540, -32135, -31529, -30727, -29726, -28535, -27164, -25614, -23901, -22040, -20033, -17903, -15667, -13331, -10922, -8456, -5947, -3422, -839};