/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1945 256 samples */
 
const int16_t AKWF_1945_256_DATA [256] = 
{656, 2615, 4534, 6458, 8382, 10307, 12235, 14158, 16083, 18011, 19933, 21860, 23787, 25709, 27636, 29533, 31584, 32547, 31456, 30390, 29325, 28256, 27188, 26118, 25048, 23980, 22910, 21841, 20773, 19703, 18634, 17565, 16494, 15426, 14358, 13287, 12219, 11151, 10089, 8987, 8102, 8201, 8474, 8712, 8958, 9203, 9450, 9696, 9942, 10187, 10433, 10679, 10925, 11171, 11416, 11663, 11908, 12154, 12400, 12646, 12892, 13135, 13383, 13625, 13205, 12481, 11809, 11124, 10443, 9760, 9075, 8394, 7711, 7027, 6345, 5662, 4978, 4297, 3614, 2929, 2248, 1565, 880, 200, -483, -1168, -1845, -2598, -3429, -4253, -5080, -5906, -6731, -7559, -8384, -9209, -10035, -10861, -11687, -12513, -13339, -14165, -14991, -15817, -16642, -17469, -18295, -19121, -19928, -20836, -21175, -20104, -19019, -17942, -16859, -15779, -14698, -13616, -12536, -11453, -10372, -9292, -8209, -7128, -6048, -4965, -3884, -2804, -1720, -641, 440, 1520, 2608, 3642, 4316, 4898, 5497, 6093, 6688, 7284, 7881, 8475, 9071, 9668, 10263, 10858, 11455, 12050, 12646, 13242, 13836, 14433, 15029, 15623, 16217, 16805, 17447, 16709, 15184, 13779, 12349, 10923, 9496, 8066, 6640, 5213, 3783, 2357, 929, -499, -1926, -3353, -4783, -6208, -7637, -9066, -10491, -11919, -13331, -14833, -15454, -14927, -14455, -13975, -13492, -13010, -12528, -12046, -11563, -11081, -10600, -10117, -9634, -9153, -8671, -8188, -7706, -7224, -6742, -6259, -5777, -5309, -4772, -4591, -5514, -6509, -7488, -8474, -9455, -10441, -11425, -12407, -13393, -14377, -15360, -16346, -17329, -18313, -19298, -20281, -21264, -22250, -23233, -24216, -25195, -26197, -27082, -26764, -26049, -25404, -24743, -24085, -23426, -22765, -22108, -21448, -20788, -20129, -19469, -18809, -18151, -17491, -16831, -16173, -15513, -14853, -14195, -13533, -12867, -12246, -10836, -8857, -6946, -5022, -3103, -1143};