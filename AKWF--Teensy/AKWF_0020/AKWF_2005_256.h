/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2005 256 samples */
 
const int16_t AKWF_2005_256_DATA [256] = 
{1281, 3382, 5371, 7290, 9118, 10850, 12474, 13991, 15444, 16839, 18167, 19433, 20633, 21763, 22826, 23820, 24741, 25593, 26374, 27083, 27723, 28291, 28787, 29217, 29576, 29867, 30092, 30250, 30345, 30377, 30347, 30258, 30111, 29884, 29552, 29123, 28604, 28004, 27327, 26587, 25790, 24946, 24069, 23164, 22245, 21325, 20409, 19511, 18643, 17811, 17030, 16306, 15649, 15067, 14569, 14160, 13848, 13637, 13532, 13541, 13661, 13888, 14213, 14628, 15127, 15697, 16329, 17013, 17736, 18487, 19255, 20026, 20789, 21532, 22240, 22906, 23517, 24059, 24525, 24904, 25187, 25367, 25436, 25389, 25225, 24954, 24581, 24110, 23547, 22897, 22167, 21365, 20500, 19576, 18607, 17600, 16562, 15507, 14442, 13374, 12317, 11277, 10261, 9284, 8349, 7462, 6635, 5870, 5174, 4554, 3993, 3484, 3030, 2624, 2267, 1954, 1683, 1451, 1254, 1088, 947, 830, 729, 643, 565, 490, 417, 338, 250, 149, 31, -108, -272, -462, -684, -932, -1191, -1459, -1738, -2027, -2328, -2641, -2967, -3307, -3658, -4026, -4408, -4804, -5217, -5646, -6089, -6550, -7027, -7519, -8030, -8554, -9094, -9653, -10223, -10809, -11410, -12036, -12697, -13394, -14119, -14868, -15638, -16422, -17216, -18015, -18810, -19598, -20373, -21126, -21856, -22553, -23211, -23827, -24394, -24907, -25362, -25754, -26078, -26332, -26512, -26617, -26641, -26566, -26392, -26123, -25770, -25338, -24836, -24275, -23664, -23012, -22333, -21637, -20933, -20236, -19554, -18900, -18287, -17722, -17215, -16780, -16422, -16151, -15974, -15898, -15929, -16069, -16332, -16726, -17245, -17879, -18617, -19446, -20356, -21329, -22350, -23408, -24482, -25557, -26618, -27644, -28621, -29533, -30360, -31091, -31707, -32195, -32541, -32733, -32760, -32610, -32276, -31753, -31045, -30162, -29113, -27901, -26538, -25037, -23402, -21650, -19797, -17847, -15822, -13738, -11599, -9430, -7246, -5056, -2883, -694};