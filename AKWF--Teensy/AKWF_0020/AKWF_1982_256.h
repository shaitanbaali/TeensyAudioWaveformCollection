/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1982 256 samples */
 
const int16_t AKWF_1982_256_DATA [256] = 
{96, 241, 307, 382, 457, 531, 606, 680, 756, 827, 922, 1072, 1222, 1373, 1524, 1674, 1824, 1976, 2127, 2278, 2529, 2827, 3118, 3410, 3703, 3995, 4287, 4580, 4867, 5199, 5629, 6058, 6488, 6915, 7345, 7775, 8204, 8632, 9065, 9641, 10280, 10910, 11541, 12172, 12803, 13432, 14065, 14693, 15349, 16059, 16770, 17479, 18190, 18900, 19607, 20319, 21028, 21747, 22655, 23640, 24609, 25585, 26558, 27531, 28505, 29468, 30491, 31097, 30982, 30897, 30809, 30719, 30628, 30539, 30444, 30364, 30232, 29313, 28128, 26988, 25843, 24694, 23545, 22400, 21255, 20088, 19112, 18409, 17698, 16991, 16281, 15573, 14865, 14156, 13447, 12747, 12150, 11587, 11018, 10449, 9881, 9313, 8744, 8177, 7601, 7101, 6708, 6307, 5907, 5510, 5110, 4710, 4312, 3910, 3520, 3235, 2974, 2710, 2446, 2182, 1917, 1654, 1391, 1122, 905, 751, 594, 436, 278, 122, -33, -190, -349, -498, -588, -661, -738, -815, -890, -967, -1043, -1120, -1191, -1334, -1560, -1780, -2001, -2222, -2443, -2664, -2884, -3104, -3335, -3649, -3978, -4304, -4630, -4956, -5282, -5608, -5938, -6255, -6682, -7218, -7742, -8270, -8798, -9325, -9852, -10381, -10906, -11449, -12081, -12726, -13371, -14015, -14659, -15304, -15948, -16593, -17233, -17982, -18831, -19674, -20520, -21362, -22206, -23051, -23894, -24740, -25572, -26344, -27109, -27874, -28640, -29406, -30171, -30935, -31689, -32513, -32451, -31672, -30977, -30267, -29556, -28846, -28136, -27422, -26724, -25954, -24937, -23892, -22849, -21805, -20764, -19720, -18676, -17636, -16585, -15802, -15224, -14623, -14027, -13432, -12835, -12239, -11644, -11045, -10462, -9928, -9398, -8869, -8339, -7808, -7279, -6749, -6221, -5684, -5280, -4966, -4640, -4315, -3991, -3666, -3341, -3018, -2692, -2378, -2101, -1828, -1554, -1279, -1005, -732, -459, -181};