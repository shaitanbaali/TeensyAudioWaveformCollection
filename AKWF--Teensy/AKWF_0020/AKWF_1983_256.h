/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1983 256 samples */
 
const int16_t AKWF_1983_256_DATA [256] = 
{659, 1635, 2401, 3168, 3936, 4704, 5472, 6239, 7007, 7777, 8540, 9222, 9872, 10524, 11177, 11830, 12481, 13135, 13787, 14445, 15042, 15533, 16024, 16518, 17010, 17501, 17994, 18486, 18978, 19471, 19957, 20440, 20925, 21409, 21892, 22377, 22860, 23343, 23832, 24277, 24657, 25039, 25419, 25801, 26182, 26563, 26944, 27326, 27707, 28105, 28507, 28908, 29310, 29712, 30113, 30515, 30914, 31327, 31619, 31740, 31870, 31999, 32128, 32256, 32385, 32512, 32648, 32743, 32423, 31996, 31590, 31180, 30770, 30358, 29949, 29538, 29130, 28698, 28236, 27776, 27316, 26856, 26396, 25936, 25474, 25014, 24558, 24122, 23695, 23265, 22836, 22407, 21978, 21548, 21119, 20693, 20232, 19736, 19243, 18750, 18256, 17762, 17267, 16773, 16280, 15782, 15266, 14744, 14224, 13705, 13184, 12662, 12143, 11620, 11106, 10517, 9851, 9194, 8535, 7876, 7216, 6558, 5896, 5244, 4553, 3671, 2757, 1850, 939, 31, -877, -1788, -2695, -3608, -4453, -5231, -6015, -6801, -7584, -8369, -9153, -9935, -10725, -11475, -12051, -12601, -13156, -13710, -14265, -14819, -15372, -15926, -16483, -17006, -17503, -18004, -18503, -19004, -19503, -20001, -20502, -21004, -21493, -21936, -22372, -22811, -23250, -23686, -24124, -24563, -25000, -25438, -25846, -26228, -26613, -26997, -27381, -27764, -28149, -28534, -28918, -29297, -29655, -30013, -30371, -30727, -31085, -31441, -31798, -32154, -32521, -32600, -32479, -32384, -32284, -32184, -32084, -31985, -31881, -31797, -31615, -31131, -30631, -30133, -29636, -29139, -28642, -28143, -27647, -27148, -26704, -26294, -25879, -25465, -25051, -24637, -24224, -23810, -23397, -22968, -22501, -22027, -21557, -21086, -20614, -20143, -19672, -19199, -18728, -18246, -17756, -17268, -16779, -16290, -15802, -15312, -14821, -14337, -13828, -13257, -12688, -12118, -11547, -10978, -10408, -9835, -9267, -8695, -7790, -6723, -5675, -4626, -3577, -2529, -1483, -415};