/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1968 256 samples */
 
const int16_t AKWF_1968_256_DATA [256] = 
{291, 994, 1659, 2491, 3575, 4646, 5721, 6793, 7866, 8941, 10013, 11088, 12158, 13152, 14125, 15104, 16080, 17057, 18033, 19008, 19982, 20977, 21793, 22376, 22968, 23557, 24148, 24738, 25327, 25916, 26510, 27077, 27440, 27742, 28054, 28365, 28675, 28985, 29297, 29606, 29922, 30172, 30335, 30504, 30672, 30839, 31008, 31176, 31344, 31513, 31677, 31800, 31914, 32029, 32142, 32257, 32372, 32487, 32600, 32725, 32726, 32591, 32465, 32337, 32210, 32082, 31955, 31824, 31705, 31530, 31052, 30508, 29976, 29440, 28906, 28371, 27835, 27298, 26776, 26036, 25071, 24123, 23172, 22223, 21272, 20321, 19371, 18422, 17454, 16373, 15269, 14170, 13073, 11974, 10875, 9778, 8680, 7572, 6590, 5722, 4844, 3967, 3089, 2214, 1336, 462, -425, -1236, -1720, -2154, -2598, -3041, -3481, -3924, -4365, -4804, -5255, -5534, -5666, -5814, -5959, -6104, -6249, -6395, -6540, -6684, -6832, -6982, -7133, -7285, -7436, -7588, -7737, -7889, -8042, -8184, -8479, -8888, -9281, -9678, -10073, -10469, -10866, -11265, -11654, -12086, -12661, -13247, -13832, -14416, -15001, -15587, -16172, -16755, -17342, -17940, -18546, -19152, -19758, -20365, -20973, -21578, -22182, -22794, -23366, -23822, -24270, -24718, -25166, -25616, -26063, -26511, -26959, -27413, -27672, -27809, -27964, -28116, -28268, -28419, -28571, -28720, -28884, -28967, -28837, -28698, -28561, -28423, -28286, -28147, -28009, -27871, -27734, -27484, -27172, -26867, -26562, -26258, -25951, -25646, -25342, -25035, -24736, -24455, -24173, -23892, -23612, -23331, -23050, -22768, -22488, -22208, -21967, -21747, -21525, -21301, -21079, -20857, -20634, -20411, -20190, -19959, -19709, -19459, -19207, -18957, -18707, -18455, -18204, -17955, -17698, -17187, -16560, -15951, -15339, -14727, -14113, -13503, -12888, -12281, -11615, -10832, -10046, -9263, -8478, -7693, -6910, -6125, -5339, -4558, -3846, -3163, -2476, -1789, -1104, -407};