/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1947 256 samples */
 
const int16_t AKWF_1947_256_DATA [256] = 
{1510, 4309, 7007, 9648, 12202, 14653, 16988, 19176, 21214, 23086, 24774, 26277, 27585, 28687, 29588, 30282, 30769, 31056, 31144, 31043, 30759, 30303, 29689, 28926, 28031, 27022, 25908, 24712, 23449, 22133, 20787, 19424, 18059, 16714, 15399, 14127, 12917, 11776, 10715, 9746, 8874, 8104, 7445, 6895, 6459, 6134, 5921, 5814, 5811, 5905, 6088, 6354, 6693, 7097, 7552, 8052, 8582, 9131, 9691, 10247, 10788, 11306, 11790, 12228, 12613, 12936, 13191, 13371, 13469, 13481, 13405, 13238, 12978, 12624, 12179, 11641, 11015, 10305, 9511, 8641, 7701, 6693, 5627, 4511, 3346, 2144, 914, -341, -1610, -2885, -4163, -5432, -6685, -7919, -9123, -10291, -11422, -12503, -13532, -14506, -15415, -16259, -17034, -17733, -18356, -18898, -19356, -19729, -20015, -20210, -20315, -20327, -20247, -20072, -19803, -19440, -18984, -18435, -17795, -17063, -16243, -15340, -14352, -13286, -12145, -10932, -9655, -8318, -6925, -5488, -4011, -2499, -967, 580, 2135, 3682, 5217, 6730, 8203, 9634, 11011, 12318, 13552, 14700, 15749, 16695, 17528, 18237, 18822, 19272, 19582, 19749, 19771, 19645, 19371, 18950, 18386, 17679, 16837, 15866, 14771, 13565, 12256, 10851, 9371, 7822, 6216, 4576, 2908, 1229, -439, -2090, -3708, -5271, -6773, -8199, -9532, -10766, -11888, -12889, -13764, -14506, -15107, -15569, -15889, -16069, -16109, -16015, -15793, -15450, -14995, -14440, -13795, -13074, -12291, -11459, -10597, -9720, -8841, -7982, -7156, -6377, -5665, -5031, -4489, -4054, -3733, -3538, -3477, -3556, -3778, -4147, -4663, -5324, -6124, -7062, -8127, -9308, -10600, -11983, -13444, -14972, -16542, -18140, -19751, -21346, -22911, -24428, -25870, -27224, -28471, -29587, -30559, -31373, -32011, -32463, -32718, -32765, -32600, -32216, -31614, -30790, -29747, -28494, -27030, -25369, -23524, -21500, -19319, -16997, -14544, -11988, -9349, -6642, -3900, -1080};