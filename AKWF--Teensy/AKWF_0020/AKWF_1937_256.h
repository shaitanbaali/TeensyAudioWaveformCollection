/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1937 256 samples */
 
const int16_t AKWF_1937_256_DATA [256] = 
{1137, 3966, 6747, 9516, 12236, 14886, 17439, 19862, 22139, 24245, 26151, 27846, 29310, 30521, 31474, 32161, 32586, 32762, 32699, 32412, 31916, 31228, 30369, 29356, 28216, 26970, 25636, 24244, 22816, 21370, 19936, 18535, 17184, 15911, 14728, 13655, 12710, 11906, 11241, 10682, 10216, 9842, 9556, 9355, 9231, 9180, 9192, 9262, 9380, 9539, 9730, 9941, 10167, 10399, 10625, 10837, 11028, 11189, 11313, 11394, 11423, 11402, 11367, 11335, 11303, 11266, 11218, 11157, 11077, 10972, 10838, 10671, 10464, 10213, 9915, 9563, 9153, 8684, 8150, 7548, 6878, 6136, 5321, 4434, 3473, 2409, 1220, -84, -1487, -2973, -4533, -6140, -7777, -9430, -11073, -12685, -14251, -15745, -17146, -18439, -19598, -20610, -21456, -22117, -22580, -22834, -22865, -22665, -22226, -21553, -20653, -19537, -18224, -16722, -15053, -13240, -11292, -9238, -7102, -4896, -2650, -391, 1871, 4102, 6285, 8403, 10427, 12344, 14137, 15785, 17277, 18614, 19841, 20975, 22012, 22945, 23777, 24506, 25127, 25642, 26051, 26353, 26549, 26637, 26622, 26503, 26281, 25960, 25540, 25025, 24418, 23718, 22931, 22062, 21107, 20027, 18800, 17437, 15954, 14363, 12674, 10912, 9087, 7215, 5321, 3417, 1520, -343, -2163, -3922, -5595, -7175, -8645, -9984, -11186, -12238, -13125, -13846, -14389, -14749, -14937, -14963, -14837, -14573, -14186, -13692, -13107, -12448, -11737, -10987, -10222, -9458, -8713, -8007, -7357, -6779, -6290, -5905, -5636, -5495, -5494, -5628, -5871, -6218, -6665, -7204, -7831, -8538, -9313, -10154, -11048, -11983, -12953, -13945, -14947, -15954, -16949, -17923, -18869, -19774, -20628, -21425, -22155, -22808, -23391, -23947, -24494, -25021, -25521, -25986, -26411, -26784, -27098, -27344, -27514, -27599, -27591, -27481, -27260, -26924, -26465, -25874, -25148, -24285, -23275, -22118, -20817, -19362, -17721, -15875, -13834, -11623, -9261, -6766, -4170, -1431};