/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1909 256 samples */
 
const int16_t AKWF_1909_256_DATA [256] = 
{350, 869, 1378, 1895, 2414, 2935, 3460, 3976, 4490, 5009, 5530, 6060, 6605, 7159, 7739, 8343, 8973, 9635, 10328, 11052, 11809, 12563, 13311, 14065, 14823, 15601, 16404, 17238, 18106, 19016, 19975, 20982, 22041, 23143, 24298, 25613, 27076, 28632, 30206, 31807, 32771, 32757, 32752, 32748, 32741, 32735, 32708, 32774, 32277, 29857, 26689, 23014, 18833, 14305, 9551, 4670, -156, -4838, -9265, -13289, -16805, -19730, -21960, -23531, -24488, -24868, -24716, -24095, -23068, -21707, -20089, -18300, -16412, -14514, -12660, -10923, -9362, -7970, -6659, -5414, -4236, -3120, -2062, -1057, -77, 874, 1813, 2757, 3705, 4676, 5688, 6724, 7747, 8749, 9728, 10699, 11658, 12610, 13559, 14506, 15458, 16422, 17399, 18384, 19387, 20399, 21430, 22474, 23523, 24564, 25588, 26588, 27552, 28470, 29330, 30117, 30821, 31439, 31953, 32376, 32602, 32595, 32588, 32582, 32574, 32563, 32574, 32364, 31806, 31105, 30236, 29202, 27995, 26607, 25027, 23250, 21285, 19172, 16919, 14558, 12124, 9653, 7177, 4726, 2323, 2, -2212, -4289, -6220, -8043, -9744, -11337, -12816, -14179, -15443, -16615, -17694, -18696, -19622, -20476, -21279, -22026, -22724, -23357, -23918, -24409, -24835, -25193, -25488, -25718, -25890, -25972, -25966, -25960, -25957, -25891, -25737, -25528, -25260, -24942, -24580, -24187, -23772, -23340, -22908, -22484, -22076, -21695, -21346, -21040, -20779, -20573, -20418, -20311, -20245, -20213, -20207, -20216, -20231, -20242, -20240, -20214, -20158, -20062, -19919, -19731, -19502, -19238, -18941, -18612, -18259, -17888, -17499, -17105, -16707, -16308, -15917, -15537, -15171, -14824, -14486, -14158, -13840, -13526, -13220, -12915, -12608, -12300, -11987, -11664, -11336, -10991, -10633, -10261, -9876, -9478, -9071, -8651, -8221, -7783, -7339, -6886, -6427, -5965, -5495, -5028, -4557, -4083, -3606, -3125, -2638, -2151, -1656, -1157, -657, -142};