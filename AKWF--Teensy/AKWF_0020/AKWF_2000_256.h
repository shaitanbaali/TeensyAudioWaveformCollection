/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2000 256 samples */
 
const int16_t AKWF_2000_256_DATA [256] = 
{559, 1706, 2830, 3958, 5073, 6328, 7697, 9050, 10406, 11764, 13118, 14474, 15829, 17182, 18537, 19891, 21244, 22598, 23953, 25303, 26656, 27990, 29425, 30221, 29696, 29187, 28681, 28172, 27662, 27150, 26640, 26130, 25619, 25108, 24598, 24087, 23576, 23065, 22554, 22038, 21547, 20922, 19490, 17887, 16320, 14749, 13174, 11599, 10029, 8456, 6881, 5313, 3739, 2166, 598, -975, -2546, -4110, -5683, -7254, -7864, -7914, -8041, -8154, -8266, -8379, -8491, -8602, -8713, -8825, -8936, -9047, -9158, -9268, -9379, -9490, -9591, -9742, -9422, -8483, -7572, -6656, -5739, -4824, -3907, -2991, -2076, -1158, -243, 671, 1588, 2503, 3417, 4333, 5248, 6165, 7063, 7895, 8719, 9547, 10372, 11197, 12023, 12847, 13673, 14498, 15322, 16147, 16971, 17794, 18618, 19442, 20264, 21089, 21903, 22546, 23128, 23718, 24307, 24896, 25484, 26072, 26661, 27248, 27835, 28423, 29010, 29597, 30185, 30771, 31356, 31927, 32588, 32200, 30893, 29687, 28461, 27234, 26009, 24783, 23555, 22332, 21105, 19878, 18655, 17428, 16203, 14981, 13754, 12520, 11338, 9862, 7747, 5640, 3532, 1424, -681, -2791, -4898, -7003, -9112, -11217, -13321, -15429, -17531, -19635, -21741, -23830, -25972, -27868, -28053, -27875, -27771, -27651, -27529, -27409, -27289, -27167, -27045, -26923, -26801, -26680, -26557, -26434, -26312, -26189, -26066, -25945, -25608, -25139, -24688, -24233, -23777, -23323, -22868, -22412, -21958, -21504, -21048, -20594, -20139, -19685, -19230, -18776, -18330, -17841, -17734, -18153, -18554, -18957, -19362, -19764, -20169, -20574, -20978, -21383, -21786, -22190, -22594, -22998, -23401, -23806, -24202, -24635, -24861, -24391, -23835, -23297, -22755, -22212, -21668, -21128, -20586, -20042, -19500, -18959, -18416, -17876, -17333, -16790, -16248, -15710, -15148, -14164, -13012, -11886, -10758, -9628, -8496, -7369, -6238, -5110, -3981, -2852, -1728, -581};