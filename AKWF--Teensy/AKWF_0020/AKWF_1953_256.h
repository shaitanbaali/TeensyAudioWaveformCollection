/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1953 256 samples */
 
const int16_t AKWF_1953_256_DATA [256] = 
{1372, 4075, 6534, 8813, 10908, 12836, 14624, 16288, 17865, 19380, 20847, 22288, 23708, 25096, 26448, 27738, 28941, 30030, 30972, 31736, 32302, 32650, 32770, 32663, 32335, 31805, 31096, 30236, 29260, 28195, 27076, 25931, 24777, 23638, 22520, 21427, 20364, 19322, 18297, 17288, 16285, 15289, 14307, 13338, 12399, 11507, 10673, 9921, 9272, 8738, 8338, 8080, 7969, 8005, 8178, 8479, 8890, 9392, 9966, 10589, 11243, 11909, 12576, 13229, 13866, 14479, 15066, 15631, 16170, 16683, 17170, 17622, 18034, 18396, 18693, 18911, 19035, 19048, 18936, 18687, 18293, 17749, 17054, 16216, 15238, 14134, 12923, 11612, 10226, 8778, 7278, 5746, 4191, 2617, 1035, -551, -2140, -3722, -5294, -6851, -8379, -9870, -11309, -12677, -13961, -15143, -16200, -17119, -17888, -18491, -18924, -19182, -19264, -19174, -18918, -18506, -17946, -17250, -16428, -15488, -14440, -13292, -12046, -10710, -9289, -7782, -6203, -4556, -2847, -1098, 682, 2479, 4264, 6022, 7731, 9365, 10908, 12342, 13647, 14818, 15843, 16714, 17436, 18008, 18430, 18709, 18848, 18850, 18720, 18458, 18067, 17544, 16888, 16100, 15176, 14121, 12940, 11633, 10218, 8704, 7104, 5445, 3740, 2009, 283, -1429, -3106, -4728, -6288, -7777, -9182, -10507, -11750, -12904, -13975, -14962, -15860, -16672, -17388, -18002, -18512, -18906, -19179, -19326, -19342, -19228, -18987, -18628, -18162, -17603, -16970, -16282, -15560, -14825, -14095, -13385, -12710, -12078, -11495, -10966, -10489, -10062, -9687, -9359, -9081, -8855, -8687, -8585, -8563, -8632, -8806, -9098, -9520, -10079, -10777, -11615, -12578, -13653, -14824, -16061, -17338, -18631, -19908, -21145, -22327, -23434, -24461, -25407, -26273, -27071, -27811, -28502, -29158, -29785, -30378, -30935, -31439, -31865, -32186, -32363, -32355, -32124, -31631, -30847, -29741, -28304, -26541, -24454, -22080, -19458, -16626, -13654, -10600, -7524, -4490, -1490};