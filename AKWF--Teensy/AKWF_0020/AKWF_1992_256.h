/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1992 256 samples */
 
const int16_t AKWF_1992_256_DATA [256] = 
{626, 1549, 2454, 3359, 4256, 5194, 5916, 5829, 5625, 5446, 5260, 5076, 4891, 4705, 4521, 4334, 4149, 3964, 3778, 3591, 3406, 3221, 3035, 2848, 2669, 2687, 2791, 2880, 2975, 3067, 3161, 3253, 3346, 3439, 3532, 3624, 3717, 3811, 3903, 3996, 4088, 4180, 4278, 4296, 4230, 4170, 4111, 4051, 3990, 3930, 3870, 3810, 3750, 3689, 3629, 3569, 3509, 3448, 3389, 3329, 3264, 3233, 3280, 3327, 3374, 3423, 3471, 3520, 3569, 3617, 3665, 3714, 3762, 3809, 3858, 3907, 3954, 4003, 4053, 4095, 4055, 3995, 3940, 3885, 3829, 3773, 3717, 3661, 3606, 3550, 3493, 3438, 3382, 3326, 3270, 3215, 3159, 3100, 3122, 3199, 3267, 3337, 3407, 3477, 3547, 3618, 3688, 3758, 3828, 3898, 3967, 4039, 4109, 4178, 4248, 4324, 4334, 4237, 4143, 4049, 3954, 3860, 3765, 3670, 3576, 3481, 3386, 3292, 3198, 3103, 3009, 2914, 2821, 2721, 2659, 2757, 2878, 2993, 3109, 3226, 3344, 3461, 3577, 3693, 3810, 3928, 4045, 4161, 4278, 4394, 4510, 4628, 4738, 4668, 4512, 4371, 4227, 4081, 3935, 3789, 3644, 3501, 3353, 3208, 3064, 2919, 2775, 2629, 2484, 2341, 2184, 2172, 2311, 2439, 2569, 2699, 2830, 2959, 3088, 3219, 3349, 3478, 3610, 3739, 3869, 3999, 4128, 4255, 4396, 4460, 4329, 4189, 4050, 3910, 3771, 3631, 3492, 3352, 3212, 3072, 2933, 2793, 2654, 2514, 2375, 2228, 2112, 1873, 273, -1685, -3574, -5472, -7376, -9279, -11177, -13079, -14981, -16878, -18782, -20680, -22579, -24480, -26378, -28271, -30151, -32147, -32188, -30815, -29637, -28422, -27206, -25994, -24778, -23563, -22349, -21134, -19917, -18706, -17489, -16274, -15062, -13846, -12635, -11409, -10300, -9393, -8484, -7574, -6664, -5756, -4845, -3937, -3029, -2121, -1216, -292};