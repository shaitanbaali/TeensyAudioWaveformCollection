/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2003 256 samples */
 
const int16_t AKWF_2003_256_DATA [256] = 
{518, 1785, 2973, 4106, 5176, 6178, 7144, 8082, 8990, 9866, 10704, 11505, 12267, 12984, 13657, 14284, 14860, 15386, 15859, 16277, 16638, 16942, 17187, 17372, 17496, 17558, 17560, 17500, 17378, 17195, 16953, 16638, 16221, 15705, 15100, 14412, 13653, 12832, 11960, 11050, 10112, 9159, 8207, 7263, 6343, 5460, 4625, 3850, 3150, 2533, 2010, 1594, 1290, 1110, 1059, 1145, 1371, 1741, 2251, 2894, 3662, 4552, 5549, 6644, 7831, 9093, 10418, 11800, 13217, 14661, 16120, 17574, 19019, 20436, 21810, 23135, 24397, 25580, 26678, 27681, 28576, 29360, 30033, 30627, 31155, 31609, 31989, 32295, 32525, 32680, 32758, 32759, 32684, 32531, 32302, 31998, 31617, 31164, 30636, 30036, 29366, 28626, 27817, 26945, 26006, 25005, 23946, 22830, 21635, 20349, 18969, 17506, 15970, 14362, 12695, 10983, 9225, 7437, 5633, 3812, 1994, 191, -1597, -3352, -5063, -6727, -8328, -9860, -11316, -12682, -13956, -15133, -16201, -17161, -18020, -18782, -19450, -20025, -20508, -20906, -21220, -21455, -21615, -21705, -21729, -21694, -21605, -21466, -21284, -21066, -20815, -20537, -20239, -19926, -19601, -19272, -18942, -18614, -18294, -17976, -17641, -17290, -16926, -16548, -16160, -15764, -15360, -14952, -14540, -14127, -13714, -13304, -12897, -12497, -12103, -11718, -11346, -10983, -10635, -10303, -9987, -9689, -9410, -9149, -8911, -8688, -8475, -8276, -8090, -7920, -7767, -7632, -7518, -7424, -7354, -7308, -7288, -7296, -7332, -7398, -7495, -7624, -7785, -7980, -8209, -8472, -8770, -9102, -9468, -9867, -10305, -10801, -11356, -11964, -12618, -13311, -14037, -14785, -15550, -16323, -17092, -17852, -18590, -19299, -19971, -20594, -21160, -21663, -22092, -22440, -22700, -22865, -22929, -22887, -22734, -22466, -22082, -21585, -20977, -20264, -19455, -18550, -17558, -16491, -15350, -14148, -12895, -11593, -10257, -8897, -7517, -6132, -4751, -3379, -2030, -684};