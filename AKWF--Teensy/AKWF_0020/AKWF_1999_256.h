/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1999 256 samples */
 
const int16_t AKWF_1999_256_DATA [256] = 
{48, 170, 370, 665, 955, 1245, 1537, 1827, 2117, 2408, 2697, 2988, 3279, 3568, 3859, 4149, 4439, 4730, 5018, 5310, 5583, 5799, 6010, 6221, 6433, 6645, 6856, 7067, 7278, 7490, 7701, 7912, 8123, 8333, 8545, 8756, 8967, 9176, 9392, 9680, 9993, 10301, 10609, 10918, 11226, 11534, 11843, 12152, 12459, 12768, 13077, 13384, 13692, 14000, 14307, 14615, 14925, 15199, 15445, 15693, 15942, 16190, 16437, 16686, 16934, 17182, 17430, 17678, 17925, 18173, 18420, 18667, 18915, 19163, 19411, 19646, 19852, 20058, 20265, 20471, 20677, 20884, 21090, 21297, 21502, 21709, 21914, 22120, 22326, 22532, 22738, 22945, 23145, 23383, 23819, 24296, 24766, 25236, 25706, 26178, 26647, 27117, 27588, 28057, 28527, 28997, 29466, 29937, 30406, 30868, 31341, 31798, 30360, 27859, 25501, 23124, 20739, 18355, 15977, 13592, 11210, 8833, 6448, 4068, 1691, -691, -3069, -5444, -7815, -10241, -12094, -13237, -14409, -15578, -16746, -17910, -19077, -20244, -21407, -22573, -23739, -24901, -26066, -27230, -28391, -29555, -30701, -31928, -32701, -32072, -31318, -30591, -29855, -29121, -28385, -27650, -26916, -26179, -25443, -24709, -23972, -23237, -22503, -21766, -21034, -20294, -19583, -19423, -19449, -19440, -19438, -19436, -19436, -19435, -19433, -19432, -19432, -19429, -19427, -19428, -19427, -19425, -19424, -19420, -19438, -19195, -18729, -18292, -17849, -17406, -16963, -16522, -16079, -15637, -15195, -14752, -14310, -13868, -13426, -12984, -12541, -12102, -11649, -11292, -11133, -10975, -10814, -10655, -10497, -10336, -10178, -10019, -9860, -9701, -9542, -9384, -9225, -9068, -8910, -8750, -8595, -8415, -8094, -7742, -7395, -7047, -6701, -6353, -6006, -5658, -5311, -4964, -4617, -4269, -3923, -3576, -3229, -2884, -2537, -2189, -1987, -1868, -1737, -1610, -1483, -1354, -1228, -1099, -973, -846, -718, -591, -464, -337, -210, -81};