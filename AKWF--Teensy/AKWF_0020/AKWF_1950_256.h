/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1950 256 samples */
 
const int16_t AKWF_1950_256_DATA [256] = 
{2747, 7311, 11356, 14836, 17626, 19657, 20916, 21434, 21296, 20622, 19568, 18297, 16984, 15792, 14853, 14273, 14109, 14372, 15022, 15972, 17097, 18238, 19221, 19871, 20022, 19536, 18314, 16311, 13535, 10042, 5971, 1491, -3195, -7827, -12163, -15958, -18972, -21025, -21972, -21730, -20281, -17672, -14027, -9497, -4305, 1283, 7023, 12632, 17832, 22410, 26151, 28894, 30550, 31058, 30430, 28718, 26031, 22512, 18319, 13660, 8737, 3737, -1117, -5648, -9699, -13108, -15767, -17593, -18521, -18531, -17629, -15856, -13277, -9987, -6124, -1816, 2766, 7427, 12002, 16291, 20100, 23280, 25670, 27149, 27640, 27096, 25521, 22955, 19497, 15283, 10467, 5264, -108, -5437, -10480, -15027, -18897, -21915, -23969, -24983, -24923, -23808, -21696, -18702, -14953, -10618, -5903, -985, 3922, 8605, 12893, 16605, 19586, 21728, 22932, 23141, 22336, 20532, 17785, 14169, 9813, 4875, -487, -6053, -11608, -16943, -21810, -25999, -29321, -31592, -32685, -32521, -31067, -28348, -24451, -19539, -13795, -7472, -878, 5711, 11976, 17591, 22312, 25889, 28144, 28978, 28350, 26309, 22962, 18507, 13198, 7301, 1161, -4888, -10548, -15497, -19482, -22314, -23844, -24009, -22816, -20345, -16729, -12155, -6874, -1132, 4805, 10639, 16136, 21065, 25212, 28441, 30641, 31743, 31743, 30666, 28587, 25599, 21837, 17465, 12627, 7517, 2323, -2800, -7657, -12084, -15947, -19096, -21426, -22860, -23334, -22832, -21361, -18979, -15768, -11843, -7376, -2534, 2483, 7438, 12132, 16348, 19874, 22559, 24261, 24890, 24410, 22830, 20226, 16701, 12427, 7613, 2464, -2756, -7798, -12441, -16450, -19638, -21874, -23049, -23123, -22105, -20061, -17105, -13381, -9099, -4465, 296, 4931, 9227, 12977, 15985, 18120, 19276, 19396, 18475, 16554, 13736, 10140, 5947, 1367, -3398, -8108, -12524, -16451, -19682, -22058, -23471, -23846, -23166, -21462, -18825, -15391, -11322, -6832, -2033};