/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1931 256 samples */
 
const int16_t AKWF_1931_256_DATA [256] = 
{1031, 2912, 4705, 6512, 8321, 10126, 11919, 13682, 15417, 17110, 18745, 20322, 21828, 23249, 24582, 25816, 26938, 27945, 28828, 29577, 30190, 30659, 30980, 31148, 31162, 31010, 30653, 30093, 29347, 28422, 27343, 26124, 24780, 23342, 21824, 20247, 18640, 17020, 15410, 13838, 12321, 10878, 9537, 8310, 7217, 6276, 5497, 4897, 4484, 4262, 4227, 4367, 4673, 5126, 5710, 6412, 7207, 8076, 9001, 9958, 10923, 11879, 12798, 13662, 14450, 15139, 15712, 16151, 16438, 16558, 16501, 16254, 15828, 15240, 14500, 13612, 12589, 11444, 10187, 8831, 7396, 5890, 4333, 2745, 1135, -476, -2069, -3635, -5152, -6606, -7984, -9269, -10451, -11520, -12461, -13289, -14054, -14754, -15385, -15947, -16433, -16842, -17170, -17416, -17575, -17649, -17632, -17523, -17322, -17026, -16635, -16150, -15571, -14895, -14125, -13265, -12309, -11268, -10133, -8847, -7411, -5843, -4151, -2358, -485, 1456, 3437, 5437, 7439, 9413, 11340, 13202, 14968, 16620, 18140, 19502, 20694, 21695, 22488, 23064, 23407, 23509, 23365, 22980, 22367, 21534, 20499, 19279, 17887, 16345, 14678, 12898, 11034, 9109, 7139, 5152, 3173, 1215, -691, -2528, -4281, -5923, -7443, -8829, -10058, -11159, -12172, -13088, -13914, -14650, -15293, -15849, -16319, -16704, -17010, -17240, -17398, -17488, -17516, -17484, -17399, -17266, -17089, -16874, -16625, -16348, -16045, -15726, -15372, -14934, -14415, -13823, -13167, -12461, -11717, -10944, -10161, -9377, -8606, -7866, -7165, -6521, -5948, -5455, -5055, -4763, -4586, -4535, -4618, -4841, -5212, -5735, -6439, -7323, -8370, -9571, -10903, -12346, -13888, -15500, -17161, -18851, -20542, -22210, -23837, -25392, -26853, -28202, -29412, -30463, -31338, -32018, -32489, -32734, -32744, -32536, -32128, -31528, -30739, -29773, -28640, -27349, -25914, -24351, -22667, -20881, -19013, -17067, -15067, -13030, -10962, -8887, -6820, -4771, -2761, -758};