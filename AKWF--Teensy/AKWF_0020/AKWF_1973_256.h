/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1973 256 samples */
 
const int16_t AKWF_1973_256_DATA [256] = 
{1639, 6928, 12248, 16803, 18756, 20391, 22098, 23783, 25470, 27160, 28840, 30519, 32253, 32482, 31612, 30874, 30113, 29350, 28589, 27828, 27071, 26288, 25652, 25508, 25397, 25278, 25161, 25045, 24928, 24811, 24692, 24582, 24275, 23844, 23431, 23012, 22595, 22177, 21760, 21344, 20922, 20534, 20244, 19960, 19675, 19389, 19105, 18819, 18535, 18249, 17964, 17652, 17323, 16996, 16669, 16342, 16015, 15688, 15361, 15034, 14707, 14378, 14049, 13720, 13393, 13063, 12735, 12406, 12077, 11749, 11430, 11118, 10805, 10491, 10178, 9865, 9550, 9238, 8924, 8607, 8284, 7961, 7637, 7313, 6991, 6667, 6342, 6018, 5695, 5367, 5034, 4703, 4372, 4039, 3709, 3377, 3046, 2711, 2406, 2158, 1911, 1664, 1417, 1171, 923, 677, 430, 185, 108, 101, 80, 62, 44, 26, 9, -8, -26, -35, -28, -19, -11, -4, 3, 11, 18, 27, 34, 30, 22, 15, 7, 0, -6, -14, -21, -29, -33, -26, -20, -14, -8, -3, 1, 7, 13, 18, 12, 3, -4, -12, -21, -29, -38, -50, -47, -141, -376, -603, -832, -1060, -1290, -1518, -1748, -1975, -2210, -2524, -2862, -3196, -3531, -3866, -4200, -4534, -4869, -5203, -5532, -5853, -6172, -6492, -6813, -7132, -7452, -7773, -8092, -8413, -8732, -9051, -9371, -9689, -10008, -10329, -10647, -10967, -11287, -11605, -11923, -12243, -12563, -12881, -13200, -13519, -13837, -14157, -14477, -14815, -15158, -15499, -15841, -16183, -16524, -16866, -17207, -17551, -17856, -18120, -18384, -18650, -18915, -19179, -19446, -19713, -19973, -20259, -20677, -21123, -21564, -22005, -22447, -22889, -23329, -23767, -24224, -24490, -24566, -24661, -24753, -24844, -24936, -25027, -25124, -25197, -25377, -26089, -26882, -27656, -28436, -29217, -29994, -30770, -31510, -32485, -30037, -24590, -19417, -14196, -8986, -3669};