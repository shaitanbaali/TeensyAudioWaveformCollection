/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1976 256 samples */
 
const int16_t AKWF_1976_256_DATA [256] = 
{2263, 5229, 7467, 9775, 12072, 14370, 16674, 18969, 21259, 23594, 25733, 26680, 27377, 28119, 28853, 29587, 30319, 31051, 31769, 32575, 32339, 31024, 29787, 28536, 27284, 26034, 24780, 23530, 22275, 21052, 20013, 19010, 17998, 16990, 15982, 14971, 13964, 12967, 11903, 11608, 12058, 12430, 12815, 13201, 13587, 13973, 14365, 14728, 15230, 16416, 17698, 18957, 20226, 21493, 22756, 24023, 25283, 26576, 27354, 27689, 28066, 28438, 28808, 29177, 29548, 29908, 30316, 30460, 29610, 28613, 27647, 26675, 25702, 24727, 23756, 22782, 21811, 20798, 19749, 18704, 17660, 16616, 15570, 14527, 13493, 12402, 11593, 11870, 12233, 12572, 12918, 13264, 13609, 13956, 14307, 14625, 15601, 17028, 18401, 19787, 21169, 22552, 23937, 25312, 26726, 27918, 28449, 28919, 29404, 29884, 30365, 30846, 31321, 31797, 32300, 31389, 29547, 27826, 26085, 24340, 22596, 20856, 19100, 17404, 15377, 12390, 9360, 6347, 3321, 303, -2716, -5739, -8755, -11791, -14133, -16076, -18080, -20074, -22064, -24058, -26052, -28021, -30102, -31510, -31332, -31073, -30836, -30591, -30345, -30101, -29853, -29610, -29355, -28333, -26894, -25516, -24129, -22737, -21349, -19961, -18577, -17155, -16005, -15460, -14930, -14393, -13858, -13326, -12792, -12260, -11726, -11186, -11713, -12712, -13629, -14563, -15495, -16430, -17364, -18297, -19224, -20202, -21272, -22347, -23420, -24492, -25567, -26639, -27707, -28790, -29824, -29968, -29729, -29547, -29355, -29162, -28971, -28777, -28575, -28426, -27880, -26628, -25385, -24142, -22893, -21651, -20404, -19159, -17912, -16681, -15960, -15425, -14853, -14289, -13725, -13161, -12596, -12048, -11413, -11377, -12282, -13159, -14037, -14916, -15799, -16678, -17561, -18437, -19341, -20571, -21913, -23232, -24558, -25885, -27209, -28535, -29846, -31240, -31887, -31455, -31057, -30658, -30253, -29851, -29448, -29032, -28666, -28082, -25233, -21724, -18335, -14927, -11520, -8111, -4712, -1242};