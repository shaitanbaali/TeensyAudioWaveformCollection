/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1951 256 samples */
 
const int16_t AKWF_1951_256_DATA [256] = 
{197, 696, 1134, 1499, 1773, 1940, 1991, 1929, 1759, 1504, 1194, 866, 565, 340, 239, 310, 593, 1124, 1919, 2986, 4320, 5896, 7675, 9616, 11660, 13740, 15804, 17781, 19616, 21273, 22705, 23899, 24848, 25556, 26046, 26346, 26497, 26540, 26519, 26479, 26455, 26478, 26570, 26744, 27002, 27335, 27732, 28172, 28631, 29086, 29514, 29892, 30209, 30452, 30618, 30711, 30736, 30705, 30634, 30535, 30424, 30316, 30219, 30140, 30081, 30039, 30011, 29989, 29961, 29919, 29852, 29751, 29612, 29429, 29203, 28937, 28634, 28300, 27944, 27570, 27190, 26805, 26420, 26040, 25660, 25281, 24899, 24508, 24103, 23681, 23236, 22767, 22271, 21748, 21202, 20635, 20050, 19454, 18850, 18238, 17627, 17014, 16402, 15790, 15173, 14549, 13917, 13271, 12608, 11929, 11230, 10514, 9784, 9038, 8284, 7527, 6766, 6010, 5260, 4516, 3780, 3052, 2328, 1607, 885, 156, -579, -1327, -2088, -2861, -3645, -4441, -5241, -6044, -6846, -7637, -8419, -9188, -9938, -10672, -11391, -12095, -12789, -13475, -14156, -14838, -15521, -16207, -16896, -17587, -18277, -18963, -19640, -20303, -20950, -21573, -22171, -22744, -23288, -23808, -24307, -24785, -25249, -25704, -26151, -26596, -27041, -27484, -27925, -28361, -28788, -29204, -29600, -29972, -30318, -30631, -30911, -31158, -31373, -31557, -31717, -31855, -31978, -32090, -32195, -32295, -32392, -32484, -32571, -32647, -32708, -32751, -32768, -32757, -32713, -32635, -32522, -32376, -32201, -32000, -31780, -31546, -31303, -31054, -30801, -30548, -30290, -30027, -29753, -29461, -29146, -28803, -28423, -28004, -27546, -27044, -26504, -25930, -25326, -24701, -24062, -23412, -22760, -22109, -21459, -20811, -20161, -19501, -18828, -18133, -17406, -16649, -15852, -15017, -14149, -13251, -12335, -11414, -10496, -9602, -8743, -7929, -7172, -6477, -5840, -5260, -4732, -4240, -3773, -3317, -2858, -2388, -1899, -1391, -868, -329};