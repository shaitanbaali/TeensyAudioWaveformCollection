/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1969 256 samples */
 
const int16_t AKWF_1969_256_DATA [256] = 
{2148, 6316, 9653, 11628, 13603, 15586, 17568, 19544, 21524, 23499, 25484, 27425, 28120, 28340, 28648, 28938, 29228, 29518, 29807, 30096, 30389, 30660, 30893, 31127, 31362, 31595, 31830, 32064, 32296, 32537, 32741, 32527, 32165, 31827, 31485, 31142, 30799, 30457, 30111, 29783, 29308, 28616, 27931, 27245, 26558, 25871, 25184, 24497, 23812, 23119, 22343, 21543, 20746, 19949, 19153, 18355, 17558, 16777, 15908, 15667, 16282, 16833, 17395, 17957, 18521, 19083, 19642, 20217, 20728, 20741, 20622, 20526, 20425, 20324, 20222, 20121, 20013, 19947, 19463, 18481, 17526, 16565, 15603, 14644, 13681, 12721, 11760, 10809, 9970, 9157, 8336, 7518, 6701, 5881, 5062, 4246, 3422, 2630, 1867, 1100, 334, -431, -1197, -1962, -2729, -3492, -4276, -5201, -6154, -7098, -8046, -8995, -9941, -10888, -11831, -12801, -13422, -13694, -13991, -14285, -14579, -14871, -15165, -15438, -15808, -15660, -13090, -10064, -7125, -4172, -1218, 1740, 4691, 7626, 10677, 12285, 12560, 12979, 13374, 13766, 14160, 14553, 14935, 15369, 15554, 14565, 13430, 12331, 11220, 10110, 9003, 7893, 6787, 5665, 4795, 4130, 3446, 2763, 2082, 1401, 719, 36, -638, -1354, -2211, -3085, -3957, -4828, -5700, -6574, -7444, -8317, -9189, -10072, -10967, -11860, -12752, -13647, -14540, -15432, -16323, -17231, -18041, -18504, -18940, -19383, -19826, -20266, -20706, -21148, -21584, -22052, -21785, -21035, -20345, -19642, -18942, -18240, -17538, -16848, -16100, -15693, -16235, -16859, -17466, -18074, -18686, -19297, -19907, -20519, -21128, -21834, -22601, -23360, -24118, -24879, -25639, -26397, -27155, -27928, -28609, -29049, -29477, -29908, -30340, -30771, -31201, -31631, -32060, -32500, -32501, -32271, -32076, -31873, -31671, -31469, -31267, -31066, -30862, -30667, -30489, -30310, -30132, -29955, -29778, -29600, -29411, -29245, -29016, -26183, -22007, -18027, -14016, -10001, -5998, -1912};