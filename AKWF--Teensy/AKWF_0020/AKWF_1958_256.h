/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1958 256 samples */
 
const int16_t AKWF_1958_256_DATA [256] = 
{1374, 3938, 6284, 8474, 10500, 12376, 14122, 15753, 17300, 18783, 20215, 21616, 22990, 24332, 25641, 26897, 28080, 29174, 30152, 30991, 31680, 32202, 32552, 32736, 32760, 32642, 32403, 32070, 31671, 31233, 30783, 30342, 29930, 29559, 29236, 28962, 28735, 28544, 28383, 28241, 28109, 27978, 27845, 27708, 27569, 27434, 27308, 27201, 27122, 27078, 27076, 27116, 27199, 27318, 27462, 27622, 27780, 27919, 28024, 28079, 28071, 27988, 27827, 27584, 27261, 26866, 26406, 25893, 25342, 24762, 24163, 23561, 22958, 22360, 21773, 21195, 20623, 20062, 19506, 18955, 18413, 17882, 17367, 16877, 16421, 16009, 15656, 15370, 15159, 15034, 14997, 15050, 15189, 15408, 15697, 16045, 16437, 16858, 17293, 17730, 18152, 18549, 18915, 19239, 19517, 19746, 19921, 20040, 20101, 20098, 20025, 19878, 19648, 19327, 18906, 18378, 17732, 16966, 16078, 15064, 13929, 12683, 11330, 9886, 8368, 6787, 5164, 3516, 1853, 198, -1441, -3058, -4635, -6172, -7664, -9097, -10477, -11797, -13046, -14224, -15322, -16329, -17243, -18051, -18745, -19324, -19780, -20111, -20323, -20417, -20403, -20291, -20094, -19825, -19504, -19142, -18758, -18361, -17967, -17585, -17220, -16880, -16567, -16283, -16032, -15813, -15631, -15487, -15384, -15330, -15329, -15387, -15512, -15707, -15978, -16324, -16745, -17239, -17797, -18409, -19065, -19752, -20451, -21153, -21842, -22506, -23136, -23726, -24270, -24770, -25225, -25640, -26017, -26361, -26677, -26966, -27229, -27466, -27673, -27847, -27981, -28072, -28115, -28108, -28052, -27948, -27806, -27633, -27444, -27256, -27084, -26943, -26850, -26818, -26857, -26969, -27156, -27408, -27722, -28079, -28463, -28859, -29247, -29615, -29949, -30242, -30490, -30696, -30862, -31001, -31120, -31230, -31338, -31451, -31563, -31670, -31754, -31794, -31762, -31624, -31343, -30883, -30208, -29292, -28108, -26645, -24904, -22888, -20625, -18149, -15492, -12712, -9860, -6983, -4143, -1325};