/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1957 256 samples */
 
const int16_t AKWF_1957_256_DATA [256] = 
{1832, 5070, 8033, 10785, 13308, 15607, 17700, 19596, 21324, 22905, 24350, 25679, 26895, 27990, 28960, 29786, 30442, 30911, 31166, 31188, 30962, 30484, 29759, 28799, 27629, 26284, 24799, 23226, 21610, 19996, 18437, 16966, 15617, 14418, 13384, 12521, 11835, 11318, 10961, 10753, 10683, 10739, 10911, 11194, 11587, 12085, 12693, 13412, 14239, 15178, 16222, 17358, 18578, 19856, 21166, 22486, 23776, 25006, 26146, 27161, 28026, 28721, 29231, 29547, 29670, 29605, 29359, 28949, 28395, 27712, 26919, 26040, 25084, 24070, 23011, 21914, 20790, 19651, 18504, 17359, 16235, 15139, 14094, 13123, 12243, 11480, 10856, 10388, 10099, 10000, 10099, 10399, 10896, 11581, 12438, 13448, 14588, 15831, 17149, 18520, 19910, 21299, 22667, 23985, 25241, 26420, 27499, 28469, 29315, 30017, 30564, 30938, 31119, 31093, 30841, 30352, 29611, 28612, 27354, 25833, 24062, 22056, 19826, 17403, 14815, 12082, 9251, 6347, 3396, 440, -2497, -5396, -8223, -10964, -13602, -16111, -18485, -20708, -22755, -24624, -26297, -27753, -28986, -29983, -30731, -31228, -31471, -31462, -31208, -30725, -30030, -29142, -28093, -26912, -25624, -24267, -22872, -21461, -20067, -18713, -17415, -16195, -15064, -14031, -13112, -12310, -11633, -11091, -10688, -10434, -10333, -10391, -10616, -11005, -11561, -12276, -13137, -14138, -15256, -16463, -17742, -19059, -20382, -21689, -22944, -24124, -25209, -26178, -27018, -27723, -28285, -28704, -28985, -29125, -29133, -29010, -28760, -28385, -27886, -27266, -26523, -25660, -24685, -23602, -22424, -21171, -19859, -18516, -17178, -15870, -14627, -13490, -12481, -11631, -10964, -10491, -10219, -10149, -10273, -10576, -11038, -11640, -12357, -13167, -14054, -15001, -15996, -17038, -18120, -19248, -20423, -21644, -22913, -24223, -25555, -26892, -28201, -29437, -30559, -31508, -32227, -32663, -32762, -32481, -31782, -30647, -29075, -27071, -24669, -21917, -18858, -15574, -12135, -8613, -5092, -1567};