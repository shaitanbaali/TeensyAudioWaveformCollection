/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1943 256 samples */
 
const int16_t AKWF_1943_256_DATA [256] = 
{606, 2664, 4732, 6839, 8964, 11094, 13217, 15304, 17348, 19333, 21233, 23040, 24739, 26306, 27735, 29009, 30113, 31040, 31777, 32315, 32650, 32768, 32643, 32280, 31694, 30902, 29918, 28764, 27463, 26032, 24500, 22890, 21222, 19528, 17831, 16151, 14521, 12958, 11486, 10130, 8906, 7831, 6929, 6205, 5674, 5328, 5153, 5144, 5288, 5575, 5989, 6514, 7136, 7835, 8593, 9393, 10214, 11034, 11838, 12604, 13313, 13949, 14493, 14928, 15243, 15421, 15452, 15324, 15059, 14680, 14189, 13594, 12896, 12103, 11226, 10268, 9238, 8150, 7007, 5822, 4607, 3367, 2116, 866, -379, -1606, -2802, -3964, -5082, -6146, -7149, -8111, -9077, -10048, -11010, -11959, -12887, -13780, -14634, -15438, -16179, -16852, -17444, -17946, -18351, -18648, -18829, -18887, -18815, -18606, -18255, -17757, -17111, -16313, -15352, -14191, -12826, -11276, -9563, -7697, -5708, -3618, -1445, 779, 3027, 5283, 7510, 9684, 11785, 13777, 15641, 17356, 18891, 20233, 21362, 22257, 22906, 23300, 23442, 23349, 23024, 22484, 21738, 20801, 19692, 18423, 17017, 15497, 13874, 12174, 10422, 8629, 6825, 5031, 3259, 1535, -122, -1700, -3178, -4544, -5788, -6932, -8020, -9050, -10016, -10920, -11760, -12533, -13240, -13881, -14454, -14960, -15401, -15775, -16086, -16332, -16516, -16639, -16704, -16713, -16667, -16567, -16418, -16223, -15964, -15601, -15132, -14572, -13930, -13217, -12449, -11637, -10794, -9940, -9087, -8247, -7443, -6685, -5987, -5368, -4837, -4410, -4098, -3912, -3861, -3955, -4200, -4603, -5175, -5916, -6815, -7853, -9022, -10303, -11677, -13131, -14640, -16184, -17748, -19306, -20836, -22325, -23744, -25076, -26305, -27406, -28367, -29174, -29806, -30256, -30512, -30603, -30551, -30356, -30021, -29550, -28946, -28216, -27363, -26394, -25318, -24138, -22864, -21506, -20066, -18557, -16988, -15363, -13693, -11990, -10254, -8498, -6732, -4960, -3158, -1230};