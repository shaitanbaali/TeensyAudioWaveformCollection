/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1915 256 samples */
 
const int16_t AKWF_1915_256_DATA [256] = 
{645, 1668, 2653, 3624, 4595, 5569, 6554, 7549, 8561, 9596, 10654, 11731, 12820, 13915, 15011, 16113, 17207, 18294, 19367, 20413, 21432, 22427, 23383, 24302, 25196, 26056, 26893, 27695, 28460, 29183, 29856, 30476, 31046, 31555, 32003, 32390, 32700, 32772, 32754, 32750, 32742, 32735, 32727, 32719, 32711, 32702, 32698, 32667, 32555, 32448, 32364, 32292, 32228, 32174, 32130, 32098, 32076, 32065, 32064, 32071, 32085, 32106, 32133, 32162, 32198, 32246, 32304, 32365, 32426, 32485, 32496, 32484, 32477, 32467, 32461, 32437, 32327, 32169, 31982, 31765, 31516, 31229, 30902, 30535, 30120, 29660, 29147, 28578, 27956, 27283, 26550, 25753, 24888, 23960, 22984, 21971, 20920, 19858, 18791, 17729, 16698, 15692, 14725, 13810, 12952, 12153, 11416, 10721, 10070, 9452, 8854, 8271, 7687, 7092, 6476, 5834, 5153, 4436, 3667, 2848, 1992, 1109, 214, -678, -1556, -2405, -3205, -3945, -4608, -5190, -5675, -6062, -6343, -6527, -6629, -6667, -6655, -6616, -6567, -6529, -6523, -6566, -6678, -6869, -7154, -7531, -7988, -8519, -9119, -9776, -10487, -11239, -12021, -12825, -13634, -14441, -15240, -16022, -16780, -17529, -18266, -18995, -19717, -20429, -21131, -21824, -22510, -23191, -23865, -24534, -25195, -25848, -26502, -27150, -27792, -28421, -29029, -29613, -30169, -30689, -31169, -31602, -31981, -32309, -32583, -32668, -32649, -32645, -32638, -32629, -32622, -32614, -32604, -32601, -32546, -32419, -32302, -32202, -32123, -32056, -31994, -31940, -31896, -31860, -31834, -31818, -31812, -31816, -31828, -31848, -31877, -31911, -31953, -32016, -32091, -32173, -32254, -32323, -32369, -32381, -32355, -32275, -32134, -31923, -31635, -31268, -30821, -30300, -29708, -29048, -28323, -27541, -26696, -25799, -24858, -23872, -22853, -21803, -20721, -19609, -18457, -17266, -16051, -14805, -13539, -12264, -10994, -9719, -8455, -7211, -5986, -4792, -3636, -2509, -1422, -348};