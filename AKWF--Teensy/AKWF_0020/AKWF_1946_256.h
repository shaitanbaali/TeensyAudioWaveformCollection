/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1946 256 samples */
 
const int16_t AKWF_1946_256_DATA [256] = 
{688, 3103, 5513, 7949, 10381, 12791, 15160, 17455, 19664, 21764, 23729, 25546, 27195, 28655, 29916, 30961, 31778, 32359, 32691, 32765, 32592, 32185, 31563, 30739, 29735, 28574, 27272, 25859, 24357, 22788, 21182, 19563, 17949, 16374, 14857, 13417, 12084, 10871, 9798, 8883, 8138, 7566, 7144, 6863, 6714, 6692, 6788, 6989, 7284, 7663, 8110, 8609, 9150, 9716, 10289, 10860, 11409, 11923, 12390, 12793, 13123, 13367, 13514, 13556, 13487, 13339, 13131, 12861, 12528, 12135, 11683, 11174, 10610, 9994, 9331, 8619, 7865, 7072, 6243, 5381, 4493, 3578, 2643, 1694, 730, -242, -1217, -2198, -3201, -4249, -5338, -6457, -7596, -8754, -9914, -11070, -12213, -13329, -14411, -15450, -16430, -17347, -18188, -18943, -19605, -20165, -20614, -20947, -21156, -21235, -21182, -20994, -20674, -20225, -19656, -18971, -18174, -17277, -16289, -15212, -14062, -12848, -11576, -10261, -8913, -7539, -6153, -4765, -3382, -2017, -678, 626, 1886, 3094, 4258, 5412, 6570, 7721, 8855, 9969, 11054, 12099, 13098, 14042, 14922, 15731, 16461, 17100, 17647, 18089, 18421, 18638, 18734, 18703, 18541, 18246, 17815, 17242, 16498, 15569, 14466, 13207, 11805, 10274, 8640, 6917, 5124, 3288, 1426, -441, -2286, -4094, -5843, -7505, -9070, -10517, -11821, -12977, -13966, -14774, -15395, -15816, -16040, -16076, -15936, -15634, -15183, -14604, -13915, -13132, -12279, -11377, -10446, -9509, -8589, -7704, -6879, -6132, -5481, -4948, -4547, -4293, -4200, -4279, -4531, -4938, -5488, -6177, -6991, -7923, -8958, -10079, -11276, -12533, -13828, -15154, -16487, -17809, -19109, -20366, -21562, -22687, -23722, -24651, -25467, -26151, -26696, -27103, -27413, -27643, -27787, -27844, -27812, -27689, -27475, -27168, -26767, -26273, -25683, -24999, -24223, -23352, -22388, -21335, -20190, -18957, -17640, -16238, -14756, -13200, -11564, -9812, -7916, -5890, -3757, -1477};