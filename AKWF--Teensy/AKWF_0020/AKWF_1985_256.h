/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1985 256 samples */
 
const int16_t AKWF_1985_256_DATA [256] = 
{458, 1641, 2801, 3964, 5125, 6289, 7455, 8617, 9780, 10945, 12093, 13320, 14021, 13907, 13839, 13764, 13689, 13614, 13538, 13464, 13388, 13312, 13237, 13162, 13086, 13010, 12934, 12860, 12782, 12714, 12592, 12242, 11862, 11491, 11117, 10742, 10369, 9994, 9621, 9247, 8872, 8499, 8125, 7751, 7376, 7003, 6632, 6253, 5902, 6230, 6859, 7437, 8028, 8616, 9204, 9794, 10384, 10972, 11561, 12150, 12739, 13329, 13918, 14505, 15096, 15684, 16276, 16823, 17323, 17828, 18332, 18835, 19339, 19843, 20346, 20850, 21355, 21857, 22362, 22865, 23368, 23873, 24376, 24873, 25404, 25731, 25588, 25419, 25257, 25092, 24929, 24763, 24598, 24434, 24270, 24105, 23941, 23776, 23611, 23447, 23282, 23120, 22948, 22823, 23088, 23459, 23809, 24165, 24520, 24873, 25229, 25584, 25939, 26294, 26650, 27003, 27358, 27713, 28068, 28422, 28769, 29161, 28672, 27591, 26587, 25567, 24549, 23532, 22511, 21492, 20474, 19453, 18436, 17418, 16398, 15380, 14360, 13340, 12308, 11357, 9871, 7515, 5201, 2879, 564, -1758, -4078, -6395, -8719, -11040, -13357, -15679, -17999, -20317, -22640, -24959, -27260, -29643, -31635, -31884, -31897, -31963, -32016, -32071, -32125, -32179, -32233, -32287, -32342, -32395, -32448, -32502, -32556, -32610, -32662, -32719, -32760, -32254, -31493, -30773, -30043, -29314, -28587, -27857, -27128, -26401, -25672, -24943, -24215, -23485, -22757, -22029, -21299, -20575, -19832, -19306, -19019, -18714, -18412, -18111, -17809, -17507, -17206, -16904, -16602, -16301, -15999, -15697, -15395, -15093, -14792, -14495, -14176, -13983, -14103, -14244, -14379, -14515, -14651, -14788, -14924, -15062, -15198, -15334, -15470, -15608, -15745, -15881, -16017, -16151, -16297, -16388, -16005, -15483, -14986, -14485, -13982, -13480, -12978, -12475, -11973, -11472, -10970, -10467, -9966, -9463, -8962, -8458, -7952, -7469, -6572, -5379, -4224, -3060, -1902, -717};