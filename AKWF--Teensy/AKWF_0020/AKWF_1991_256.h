/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1991 256 samples */
 
const int16_t AKWF_1991_256_DATA [256] = 
{739, 2733, 4687, 6646, 8604, 10562, 12522, 14489, 15722, 16529, 17397, 18254, 19112, 19967, 20825, 21683, 22538, 23396, 24254, 25109, 25968, 26825, 27681, 28538, 29387, 30284, 30701, 30469, 30268, 30063, 29856, 29650, 29443, 29237, 29031, 28825, 28618, 28412, 28206, 27999, 27793, 27586, 27383, 27166, 27028, 27143, 27288, 27426, 27566, 27705, 27844, 27985, 28124, 28264, 28403, 28542, 28682, 28823, 28962, 29101, 29239, 29382, 29510, 29440, 29295, 29162, 29027, 28891, 28756, 28620, 28485, 28351, 28214, 28080, 27943, 27809, 27672, 27538, 27404, 27270, 27124, 27151, 27328, 27492, 27658, 27826, 27992, 28158, 28325, 28491, 28659, 28825, 28991, 29159, 29324, 29490, 29658, 29820, 30005, 30055, 29819, 29583, 29347, 29111, 28874, 28638, 28401, 28164, 27928, 27691, 27455, 27219, 26982, 26745, 26509, 26276, 26029, 25843, 26148, 26550, 26932, 27316, 27702, 28088, 28472, 28858, 29243, 29628, 30014, 30399, 30784, 31170, 31555, 31938, 32320, 32726, 32180, 31050, 30009, 28949, 27889, 26831, 25773, 24714, 23656, 22596, 21537, 20480, 19420, 18360, 17305, 16244, 15173, 14167, 12600, 10247, 7929, 5601, 3276, 952, -1377, -3700, -6025, -8354, -10678, -13003, -15331, -17655, -19982, -22312, -24615, -27011, -28908, -29088, -29055, -29069, -29071, -29073, -29074, -29075, -29078, -29080, -29082, -29084, -29087, -29088, -29090, -29092, -29093, -29097, -29093, -28994, -28854, -28720, -28586, -28451, -28317, -28182, -28047, -27913, -27779, -27644, -27509, -27374, -27239, -27105, -26971, -26839, -26691, -26760, -27028, -27280, -27536, -27791, -28047, -28302, -28557, -28813, -29068, -29324, -29579, -29835, -30089, -30345, -30601, -30848, -31140, -31164, -30597, -30018, -29442, -28866, -28288, -27710, -27134, -26557, -25978, -25403, -24826, -24248, -23671, -23094, -22516, -21933, -21378, -20697, -18933, -16934, -14982, -13026, -11063, -9103, -7146, -5187, -3234, -1240};