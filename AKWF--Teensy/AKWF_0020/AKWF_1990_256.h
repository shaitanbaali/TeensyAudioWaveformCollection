/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1990 256 samples */
 
const int16_t AKWF_1990_256_DATA [256] = 
{882, 3119, 5352, 7370, 8185, 8756, 9381, 9993, 10605, 11217, 11828, 12440, 13053, 13663, 14277, 14890, 15501, 16114, 16726, 17336, 17949, 18560, 18764, 18742, 18752, 18755, 18758, 18763, 18767, 18769, 18773, 18777, 18779, 18783, 18787, 18791, 18794, 18799, 18803, 18797, 18898, 19129, 19354, 19579, 19805, 20032, 20257, 20484, 20709, 20935, 21162, 21388, 21614, 21841, 22066, 22293, 22518, 22749, 22950, 23064, 23169, 23275, 23380, 23487, 23594, 23701, 23806, 23913, 24020, 24127, 24232, 24339, 24444, 24551, 24658, 24765, 24871, 24988, 25107, 25226, 25348, 25467, 25586, 25705, 25825, 25944, 26064, 26184, 26303, 26423, 26542, 26663, 26782, 26903, 27015, 27225, 27519, 27803, 28086, 28372, 28658, 28943, 29227, 29513, 29797, 30082, 30368, 30653, 30939, 31223, 31508, 31769, 32159, 31727, 29579, 27442, 25307, 23166, 21032, 18890, 16751, 14615, 12474, 10335, 8197, 6056, 3918, 1781, -360, -2491, -4648, -6687, -7992, -9145, -10330, -11506, -12682, -13861, -15036, -16213, -17390, -18566, -19745, -20922, -22096, -23274, -24453, -25624, -26800, -27981, -27924, -27131, -26437, -25726, -25014, -24302, -23592, -22879, -22167, -21456, -20743, -20032, -19321, -18608, -17896, -17185, -16481, -15729, -15456, -15824, -16168, -16514, -16862, -17207, -17556, -17904, -18250, -18598, -18945, -19291, -19640, -19988, -20333, -20681, -21020, -21403, -21544, -20921, -20212, -19519, -18822, -18126, -17429, -16732, -16037, -15341, -14645, -13949, -13251, -12556, -11859, -11161, -10472, -9764, -9119, -9602, -10500, -11331, -12172, -13016, -13860, -14702, -15545, -16389, -17231, -18075, -18919, -19761, -20606, -21448, -22291, -23131, -23990, -24631, -25076, -25541, -26005, -26467, -26929, -27391, -27854, -28316, -28778, -29241, -29702, -30166, -30628, -31090, -31551, -31988, -32567, -32282, -30070, -27864, -25659, -23450, -21246, -19037, -16828, -14624, -12413, -10206, -8001, -5794, -3594, -1346};