/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1936 256 samples */
 
const int16_t AKWF_1936_256_DATA [256] = 
{766, 3095, 5379, 7668, 9956, 12247, 14540, 16828, 19120, 21414, 23700, 25992, 28266, 30618, 32560, 32128, 31149, 30275, 29377, 28483, 27584, 26687, 25792, 24894, 23997, 23102, 22204, 21307, 20411, 19513, 18617, 17721, 16823, 15927, 15031, 14134, 13240, 12331, 12033, 12065, 12048, 12040, 12032, 12024, 12016, 12008, 12001, 11993, 11985, 11977, 11969, 11961, 11953, 11945, 11937, 11929, 11921, 11914, 11906, 11895, 11900, 11740, 11375, 11022, 10668, 10313, 9958, 9602, 9247, 8892, 8538, 8183, 7827, 7472, 7118, 6762, 6408, 6053, 5697, 5342, 4988, 4632, 4270, 3946, 3408, 2272, 1102, -62, -1229, -2393, -3561, -4727, -5891, -7060, -8225, -9391, -10559, -11724, -12890, -14058, -15223, -16389, -17557, -18721, -19888, -21041, -22246, -23211, -21966, -20053, -18261, -16443, -14629, -12811, -10994, -9180, -7362, -5545, -3732, -1913, -96, 1716, 3535, 5351, 7165, 8985, 10800, 12615, 14432, 16239, 18094, 18897, 18974, 19138, 19286, 19435, 19582, 19731, 19878, 20026, 20174, 20322, 20470, 20619, 20765, 20914, 21062, 21210, 21357, 21506, 21653, 21802, 21932, 22154, 21660, 20051, 18483, 16909, 15333, 13759, 12181, 10607, 9033, 7454, 5881, 4306, 2728, 1154, -421, -1998, -3571, -5148, -6725, -8297, -9874, -11436, -13070, -14301, -14081, -13678, -13313, -12939, -12565, -12190, -11815, -11441, -11066, -10692, -10318, -9943, -9568, -9194, -8820, -8446, -8072, -7696, -7322, -6948, -6577, -6196, -5853, -6363, -7200, -7978, -8769, -9557, -10348, -11139, -11926, -12717, -13507, -14296, -15087, -15877, -16665, -17456, -18246, -19034, -19825, -20615, -21404, -22193, -22976, -23795, -24071, -23874, -23720, -23558, -23396, -23235, -23073, -22910, -22749, -22587, -22425, -22263, -22101, -21939, -21777, -21616, -21453, -21291, -21130, -20968, -20805, -20621, -20557, -19745, -17433, -15148, -12858, -10567, -8279, -5990, -3706, -1376};