/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1956 256 samples */
 
const int16_t AKWF_1956_256_DATA [256] = 
{3247, 9194, 14676, 19640, 23914, 27390, 30002, 31729, 32612, 32727, 32188, 31124, 29687, 28032, 26292, 24594, 23039, 21689, 20584, 19736, 19118, 18693, 18409, 18197, 17999, 17757, 17423, 16967, 16375, 15646, 14796, 13855, 12850, 11826, 10813, 9843, 8943, 8121, 7382, 6721, 6123, 5569, 5041, 4518, 3982, 3428, 2854, 2262, 1672, 1097, 563, 95, -290, -573, -744, -802, -755, -617, -412, -166, 88, 326, 519, 646, 697, 668, 563, 395, 185, -42, -265, -455, -593, -665, -665, -590, -450, -264, -49, 169, 369, 528, 629, 660, 621, 515, 354, 154, -60, -267, -445, -573, -641, -638, -567, -435, -256, -52, 156, 350, 503, 601, 634, 599, 499, 346, 156, -51, -252, -425, -553, -619, -619, -553, -426, -253, -53, 152, 341, 493, 592, 626, 592, 494, 342, 153, -53, -255, -430, -558, -627, -626, -558, -429, -252, -48, 162, 358, 515, 616, 651, 614, 511, 351, 151, -66, -279, -463, -598, -670, -668, -594, -454, -263, -40, 189, 401, 572, 681, 717, 675, 558, 378, 154, -91, -331, -538, -690, -768, -764, -675, -510, -284, -25, 244, 494, 694, 822, 864, 812, 668, 448, 172, -130, -427, -685, -876, -979, -978, -870, -663, -379, -45, 305, 633, 903, 1086, 1158, 1108, 940, 667, 316, -77, -473, -830, -1111, -1285, -1338, -1267, -1088, -830, -540, -271, -84, -38, -186, -566, -1203, -2098, -3230, -4556, -6018, -7536, -9029, -10417, -11619, -12578, -13255, -13637, -13744, -13624, -13349, -13011, -12719, -12584, -12706, -13171, -14035, -15326, -17023, -19062, -21353, -23753, -26094, -28206, -29895, -30986, -31326, -30793, -29316, -26862, -23471, -19228, -14263, -8767, -2809};