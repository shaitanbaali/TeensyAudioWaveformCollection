/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1923 256 samples */
 
const int16_t AKWF_1923_256_DATA [256] = 
{692, 3250, 5720, 8143, 10497, 12770, 14949, 17014, 18960, 20777, 22449, 23976, 25349, 26561, 27612, 28498, 29217, 29773, 30166, 30398, 30475, 30402, 30185, 29833, 29352, 28754, 28044, 27236, 26342, 25366, 24327, 23233, 22092, 20922, 19729, 18524, 17323, 16130, 14955, 13814, 12708, 11648, 10644, 9698, 8818, 8011, 7280, 6629, 6062, 5579, 5184, 4877, 4658, 4525, 4479, 4516, 4635, 4830, 5099, 5435, 5836, 6296, 6805, 7359, 7953, 8576, 9221, 9883, 10549, 11213, 11867, 12501, 13108, 13679, 14204, 14677, 15089, 15432, 15701, 15887, 15985, 15989, 15895, 15697, 15394, 14984, 14463, 13830, 13088, 12239, 11281, 10222, 9066, 7816, 6481, 5069, 3584, 2044, 453, -1178, -2831, -4500, -6170, -7824, -9453, -11043, -12572, -14036, -15419, -16701, -17877, -18931, -19852, -20632, -21258, -21724, -22023, -22148, -22097, -21866, -21455, -20865, -20096, -19155, -18048, -16778, -15360, -13803, -12113, -10314, -8414, -6426, -4377, -2276, -142, 1999, 4138, 6252, 8314, 10317, 12240, 14055, 15759, 17331, 18752, 20015, 21107, 22014, 22734, 23257, 23578, 23697, 23611, 23325, 22839, 22161, 21300, 20259, 19057, 17703, 16209, 14596, 12877, 11067, 9192, 7265, 5304, 3337, 1373, -564, -2453, -4282, -6033, -7685, -9232, -10656, -11943, -13091, -14088, -14926, -15607, -16125, -16480, -16677, -16717, -16609, -16358, -15976, -15474, -14861, -14155, -13370, -12518, -11621, -10693, -9751, -8815, -7900, -7021, -6198, -5444, -4773, -4201, -3737, -3393, -3179, -3099, -3162, -3367, -3719, -4217, -4858, -5639, -6555, -7591, -8747, -10006, -11355, -12786, -14276, -15812, -17380, -18959, -20531, -22082, -23587, -25032, -26403, -27675, -28838, -29876, -30771, -31515, -32096, -32501, -32723, -32758, -32599, -32244, -31691, -30944, -30001, -28868, -27557, -26067, -24411, -22604, -20650, -18569, -16377, -14080, -11703, -9263, -6773, -4258, -1676};