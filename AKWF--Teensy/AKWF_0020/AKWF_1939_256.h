/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1939 256 samples */
 
const int16_t AKWF_1939_256_DATA [256] = 
{630, 2340, 4018, 5692, 6910, 7910, 8943, 9968, 10994, 12022, 13046, 14072, 15099, 16123, 17150, 18177, 19201, 20228, 21254, 22279, 23306, 24333, 25356, 26383, 27410, 28415, 29529, 29544, 28355, 27270, 26170, 25071, 23967, 22866, 21766, 20663, 19562, 18461, 17358, 16259, 15157, 14054, 12955, 11853, 10750, 9651, 8548, 7446, 6361, 5196, 4519, 4979, 5499, 6002, 6511, 7021, 7530, 8039, 8548, 9058, 9566, 10075, 10585, 11092, 11602, 12112, 12620, 13131, 13639, 14147, 14658, 15157, 15694, 16064, 15023, 13652, 12349, 11034, 9718, 8400, 7086, 5769, 4451, 3138, 1820, 504, -810, -2127, -3444, -4758, -6076, -7392, -8706, -10024, -11337, -12651, -13978, -14288, -13969, -13730, -13476, -13222, -12967, -12713, -12458, -12204, -11951, -11696, -11442, -11188, -10934, -10679, -10426, -10170, -9917, -9663, -9407, -9154, -8886, -8689, -7986, -6587, -5240, -3886, -2531, -1175, 179, 1534, 2890, 4244, 5599, 6955, 8309, 9664, 11021, 12375, 13731, 15087, 16440, 17796, 19152, 20483, 21931, 22695, 21391, 19874, 18405, 16927, 15444, 13963, 12485, 11002, 9520, 8042, 6559, 5078, 3600, 2116, 637, -842, -2326, -3805, -5285, -6768, -8242, -9734, -11167, -11586, -11696, -11864, -12021, -12179, -12336, -12492, -12649, -12807, -12963, -13121, -13278, -13435, -13592, -13748, -13905, -14062, -14220, -14377, -14534, -14691, -14845, -15014, -14860, -14456, -14077, -13694, -13313, -12928, -12547, -12163, -11780, -11398, -11014, -10632, -10249, -9866, -9484, -9101, -8718, -8335, -7952, -7570, -7186, -6821, -6364, -6518, -7694, -8844, -9995, -11147, -12302, -13455, -14607, -15763, -16916, -18068, -19223, -20376, -21528, -22684, -23836, -24989, -26144, -27297, -28450, -29605, -30738, -31965, -32678, -31272, -29535, -27868, -26189, -24506, -22823, -21144, -19461, -17778, -16099, -14415, -12733, -11054, -9370, -7689, -6009, -4328, -2651, -941};