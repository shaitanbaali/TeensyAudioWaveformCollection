/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1955 256 samples */
 
const int16_t AKWF_1955_256_DATA [256] = 
{3507, 9221, 14453, 19170, 23222, 26523, 29028, 30726, 31671, 31941, 31645, 30913, 29884, 28697, 27473, 26321, 25326, 24536, 23978, 23650, 23524, 23558, 23697, 23880, 24049, 24154, 24156, 24034, 23781, 23402, 22921, 22368, 21779, 21192, 20640, 20151, 19745, 19427, 19196, 19038, 18932, 18852, 18772, 18663, 18505, 18283, 17989, 17627, 17205, 16739, 16253, 15769, 15307, 14892, 14532, 14238, 14008, 13834, 13703, 13594, 13488, 13361, 13195, 12976, 12692, 12347, 11942, 11490, 11009, 10520, 10042, 9597, 9199, 8861, 8588, 8376, 8216, 8095, 7993, 7889, 7765, 7599, 7381, 7102, 6760, 6360, 5914, 5437, 4950, 4471, 4019, 3611, 3258, 2964, 2728, 2544, 2400, 2278, 2163, 2037, 1886, 1700, 1473, 1208, 912, 597, 281, -18, -278, -486, -624, -688, -674, -587, -439, -250, -38, 174, 363, 510, 599, 624, 580, 476, 321, 132, -68, -258, -420, -534, -590, -580, -509, -383, -215, -27, 163, 335, 468, 548, 568, 526, 426, 279, 104, -80, -254, -397, -492, -533, -513, -441, -326, -187, -48, 65, 129, 122, 25, -168, -462, -847, -1308, -1823, -2361, -2896, -3401, -3848, -4223, -4514, -4721, -4854, -4929, -4970, -5006, -5065, -5174, -5357, -5626, -5987, -6435, -6956, -7526, -8117, -8697, -9232, -9698, -10072, -10341, -10507, -10579, -10578, -10534, -10483, -10462, -10506, -10646, -10901, -11282, -11782, -12387, -13068, -13783, -14493, -15151, -15716, -16156, -16450, -16591, -16588, -16466, -16265, -16032, -15822, -15690, -15685, -15844, -16192, -16734, -17451, -18310, -19263, -20241, -21178, -22003, -22651, -23077, -23251, -23171, -22856, -22354, -21737, -21089, -20510, -20096, -19935, -20101, -20636, -21555, -22832, -24400, -26168, -27998, -29736, -31223, -32284, -32761, -32524, -31470, -29547, -26733, -23080, -18678, -13655, -8195, -2361};