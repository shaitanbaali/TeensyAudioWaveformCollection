/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1907 256 samples */
 
const int16_t AKWF_1907_256_DATA [256] = 
{331, 985, 1683, 2431, 3216, 4032, 4881, 5746, 6628, 7542, 8483, 9455, 10446, 11439, 12430, 13403, 14344, 15256, 16121, 16928, 17674, 18348, 18952, 19488, 19960, 20377, 20747, 21077, 21386, 21681, 21970, 22266, 22576, 22909, 23268, 23639, 24015, 24401, 24795, 25200, 25614, 26037, 26468, 26903, 27346, 27792, 28240, 28694, 29163, 29638, 30118, 30586, 31037, 31456, 31834, 32162, 32429, 32622, 32738, 32768, 32710, 32571, 32352, 32054, 31686, 31251, 30752, 30196, 29594, 28945, 28262, 27544, 26797, 26021, 25216, 24382, 23517, 22619, 21685, 20716, 19713, 18676, 17597, 16482, 15326, 14133, 12903, 11632, 10324, 9000, 7664, 6332, 5025, 3737, 2491, 1296, 158, -906, -1893, -2814, -3663, -4447, -5168, -5840, -6466, -7059, -7621, -8162, -8693, -9218, -9747, -10278, -10802, -11318, -11828, -12329, -12821, -13303, -13766, -14215, -14647, -15059, -15454, -15825, -16171, -16499, -16807, -17099, -17378, -17647, -17909, -18171, -18434, -18701, -18977, -19261, -19557, -19867, -20189, -20520, -20856, -21190, -21524, -21848, -22159, -22450, -22718, -22957, -23166, -23341, -23486, -23605, -23694, -23757, -23791, -23800, -23779, -23735, -23664, -23568, -23447, -23306, -23142, -22949, -22731, -22489, -22227, -21951, -21660, -21358, -21052, -20743, -20435, -20133, -19835, -19543, -19256, -18966, -18683, -18404, -18128, -17858, -17592, -17333, -17082, -16834, -16591, -16354, -16129, -15926, -15738, -15556, -15370, -15174, -14956, -14709, -14420, -14084, -13691, -13237, -12719, -12129, -11465, -10741, -9969, -9172, -8351, -7528, -6725, -5951, -5229, -4565, -3972, -3463, -3029, -2663, -2368, -2128, -1942, -1802, -1699, -1623, -1568, -1524, -1482, -1438, -1388, -1336, -1282, -1230, -1182, -1140, -1107, -1087, -1082, -1093, -1126, -1179, -1254, -1354, -1482, -1631, -1792, -1954, -2105, -2235, -2331, -2382, -2375, -2304, -2155, -1925, -1613, -1229, -774, -241};