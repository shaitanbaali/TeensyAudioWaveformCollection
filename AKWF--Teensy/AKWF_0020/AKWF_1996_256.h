/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1996 256 samples */
 
const int16_t AKWF_1996_256_DATA [256] = 
{801, 2198, 3564, 4935, 6303, 7696, 9113, 10523, 11935, 13348, 14758, 16170, 17581, 18989, 20400, 21811, 23219, 24629, 26038, 27445, 28854, 30247, 31717, 32722, 32716, 32721, 32728, 32731, 32736, 32738, 32741, 32744, 32747, 32751, 32753, 32755, 32758, 32760, 32763, 32761, 32774, 32715, 32181, 31544, 30928, 30311, 29690, 29069, 28452, 27831, 27211, 26594, 25975, 25354, 24736, 24117, 23499, 22881, 22262, 21642, 21159, 20757, 20344, 19934, 19524, 19114, 18703, 18293, 17884, 17475, 17065, 16656, 16247, 15837, 15428, 15019, 14609, 14202, 13792, 13384, 12974, 12566, 12156, 11749, 11340, 10932, 10524, 10116, 9707, 9300, 8892, 8484, 8078, 7669, 7263, 6850, 6476, 6226, 5991, 5753, 5517, 5279, 5042, 4804, 4568, 4331, 4095, 3858, 3621, 3385, 3149, 2912, 2675, 2439, 2201, 1936, 1659, 1384, 1109, 833, 558, 283, 8, -266, -540, -815, -1091, -1365, -1639, -1914, -2189, -2463, -2738, -2993, -3230, -3466, -3704, -3941, -4177, -4415, -4653, -4889, -5125, -5362, -5599, -5835, -6072, -6308, -6545, -6782, -7017, -7260, -7523, -7786, -8049, -8313, -8574, -8837, -9101, -9363, -9625, -9888, -10149, -10413, -10675, -10936, -11199, -11462, -11721, -11993, -12353, -12733, -13110, -13485, -13862, -14239, -14614, -14992, -15368, -15743, -16119, -16495, -16870, -17247, -17622, -17997, -18374, -18749, -19086, -19400, -19716, -20030, -20346, -20663, -20977, -21292, -21606, -21923, -22238, -22551, -22867, -23182, -23496, -23810, -24126, -24435, -24799, -25244, -25685, -26127, -26569, -27009, -27451, -27892, -28333, -28774, -29217, -29657, -30098, -30539, -30978, -31420, -31851, -32328, -32546, -31854, -31041, -30252, -29459, -28665, -27870, -27077, -26283, -25488, -24696, -23902, -23107, -22315, -21522, -20728, -19933, -19143, -18333, -17108, -15710, -14340, -12967, -11590, -10216, -8843, -7467, -6093, -4722, -3349, -1981, -583};