/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2006 256 samples */
 
const int16_t AKWF_2006_256_DATA [256] = 
{895, 3338, 5670, 7932, 10100, 12161, 14102, 15903, 17559, 19060, 20428, 21695, 22855, 23907, 24858, 25706, 26452, 27103, 27660, 28125, 28506, 28804, 29023, 29171, 29252, 29269, 29228, 29135, 28995, 28812, 28593, 28341, 28062, 27760, 27439, 27093, 26682, 26202, 25657, 25057, 24407, 23712, 22984, 22230, 21455, 20673, 19889, 19112, 18352, 17617, 16915, 16254, 15643, 15089, 14601, 14182, 13840, 13583, 13410, 13330, 13343, 13465, 13707, 14065, 14531, 15093, 15742, 16468, 17257, 18098, 18978, 19879, 20792, 21701, 22589, 23446, 24257, 25004, 25679, 26267, 26754, 27132, 27387, 27511, 27497, 27336, 27025, 26559, 25947, 25196, 24310, 23302, 22183, 20961, 19652, 18267, 16817, 15321, 13790, 12236, 10682, 9134, 7608, 6124, 4689, 3316, 2025, 820, -285, -1278, -2156, -2907, -3534, -4059, -4482, -4808, -5042, -5188, -5250, -5235, -5150, -5000, -4794, -4539, -4242, -3911, -3556, -3183, -2800, -2418, -2040, -1677, -1336, -1023, -743, -505, -313, -171, -55, 51, 148, 230, 296, 343, 369, 371, 347, 294, 211, 94, -57, -247, -476, -747, -1060, -1418, -1822, -2274, -2773, -3321, -3918, -4563, -5257, -6008, -6836, -7745, -8729, -9777, -10885, -12044, -13241, -14472, -15723, -16982, -18245, -19498, -20725, -21923, -23079, -24178, -25218, -26184, -27066, -27861, -28556, -29144, -29621, -29981, -30219, -30323, -30282, -30104, -29797, -29371, -28836, -28202, -27487, -26699, -25852, -24964, -24046, -23115, -22186, -21271, -20388, -19551, -18772, -18065, -17444, -16918, -16500, -16199, -16023, -15979, -16073, -16320, -16716, -17252, -17917, -18695, -19573, -20538, -21569, -22650, -23766, -24892, -26014, -27112, -28162, -29149, -30055, -30858, -31542, -32091, -32486, -32716, -32763, -32619, -32271, -31711, -30937, -29954, -28772, -27407, -25858, -24146, -22284, -20282, -18160, -15938, -13624, -11245, -8819, -6360, -3895, -1386};