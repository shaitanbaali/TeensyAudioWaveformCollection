/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2009 256 samples */
 
const int16_t AKWF_2009_256_DATA [256] = 
{273, 1208, 2137, 3081, 4035, 5004, 5985, 6973, 7974, 8985, 10001, 11027, 12058, 13091, 14155, 15258, 16390, 17553, 18733, 19920, 21113, 22298, 23463, 24606, 25712, 26770, 27775, 28712, 29574, 30353, 31037, 31618, 32090, 32442, 32669, 32765, 32726, 32544, 32218, 31742, 31099, 30292, 29334, 28231, 26995, 25644, 24183, 22630, 21004, 19314, 17579, 15820, 14044, 12273, 10527, 8814, 7156, 5570, 4064, 2656, 1362, 189, -847, -1739, -2479, -3079, -3565, -3939, -4201, -4353, -4399, -4340, -4181, -3926, -3580, -3146, -2630, -2040, -1378, -651, 130, 967, 1849, 2768, 3724, 4706, 5708, 6726, 7754, 8783, 9820, 10905, 12050, 13252, 14497, 15776, 17083, 18403, 19727, 21049, 22350, 23621, 24854, 26032, 27146, 28187, 29139, 29996, 30746, 31377, 31884, 32258, 32489, 32573, 32502, 32274, 31879, 31313, 30579, 29684, 28637, 27451, 26128, 24688, 23141, 21495, 19769, 17976, 16125, 14238, 12325, 10397, 8476, 6570, 4692, 2861, 1084, -627, -2256, -3800, -5248, -6587, -7845, -9033, -10148, -11196, -12174, -13084, -13931, -14715, -15438, -16105, -16718, -17280, -17797, -18271, -18706, -19108, -19479, -19823, -20144, -20447, -20734, -21010, -21277, -21539, -21799, -22053, -22283, -22486, -22663, -22816, -22946, -23055, -23144, -23214, -23268, -23308, -23333, -23347, -23352, -23348, -23337, -23321, -23302, -23280, -23258, -23236, -23216, -23200, -23187, -23178, -23175, -23179, -23190, -23207, -23230, -23258, -23288, -23322, -23356, -23390, -23422, -23451, -23474, -23490, -23498, -23495, -23480, -23451, -23406, -23346, -23265, -23166, -23045, -22900, -22731, -22538, -22318, -22080, -21824, -21550, -21257, -20946, -20615, -20264, -19895, -19505, -19095, -18664, -18213, -17741, -17249, -16732, -16197, -15639, -15060, -14461, -13838, -13195, -12532, -11846, -11139, -10414, -9669, -8909, -8138, -7352, -6553, -5742, -4914, -4075, -3223, -2358, -1481, -572};