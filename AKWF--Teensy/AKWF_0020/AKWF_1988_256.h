/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1988 256 samples */
 
const int16_t AKWF_1988_256_DATA [256] = 
{1365, 3427, 5446, 7472, 9496, 11513, 13585, 15091, 16043, 17054, 18053, 19053, 20053, 21051, 22051, 23052, 24050, 25051, 26050, 27048, 28049, 29049, 30047, 31034, 32091, 32678, 32164, 31609, 31068, 30520, 29974, 29428, 28881, 28335, 27789, 27242, 26697, 26150, 25603, 25056, 24510, 23968, 23410, 22923, 22931, 23071, 23185, 23306, 23424, 23545, 23665, 23785, 23904, 24025, 24145, 24265, 24385, 24504, 24624, 24745, 24865, 24982, 25262, 25650, 26027, 26406, 26784, 27163, 27541, 27920, 28299, 28677, 29056, 29435, 29813, 30192, 30571, 30949, 31323, 31726, 31884, 31679, 31482, 31286, 31087, 30889, 30691, 30493, 30295, 30097, 29897, 29698, 29500, 29302, 29104, 28906, 28708, 28507, 28327, 28236, 28156, 28074, 27991, 27910, 27828, 27745, 27664, 27582, 27501, 27419, 27337, 27255, 27173, 27091, 27004, 26929, 26833, 25340, 23273, 21299, 19309, 17322, 15330, 13340, 11354, 9360, 7372, 5385, 3392, 1405, -584, -2577, -4563, -6544, -8576, -10144, -11236, -12379, -13509, -14641, -15776, -16906, -18040, -19173, -20304, -21437, -22571, -23701, -24834, -25967, -27098, -28221, -29399, -30226, -30172, -30083, -30005, -29921, -29839, -29758, -29674, -29592, -29510, -29427, -29344, -29263, -29180, -29097, -29015, -28934, -28848, -28785, -28902, -29069, -29226, -29387, -29546, -29706, -29867, -30027, -30187, -30347, -30507, -30667, -30827, -30986, -31147, -31305, -31463, -31635, -31311, -30636, -30001, -29360, -28719, -28075, -27434, -26792, -26150, -25509, -24867, -24225, -23584, -22941, -22298, -21658, -21028, -20333, -20139, -20731, -21313, -21893, -22477, -23061, -23642, -24226, -24809, -25392, -25976, -26559, -27140, -27725, -28308, -28890, -29466, -30078, -30506, -30159, -29699, -29261, -28819, -28376, -27933, -27489, -27048, -26604, -26161, -25719, -25276, -24833, -24391, -23948, -23500, -23062, -22611, -21022, -18931, -16918, -14891, -12869, -10839, -8813, -6789, -4763, -2743, -681};