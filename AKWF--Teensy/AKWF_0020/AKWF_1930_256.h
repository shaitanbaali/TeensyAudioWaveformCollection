/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1930 256 samples */
 
const int16_t AKWF_1930_256_DATA [256] = 
{724, 2318, 3727, 4923, 6123, 7323, 8527, 9725, 10926, 12129, 13328, 14529, 15732, 16931, 18132, 19334, 20533, 21735, 22937, 24136, 25338, 26539, 27739, 28921, 30200, 30997, 29970, 28799, 27665, 26519, 25376, 24231, 23086, 21942, 20798, 19653, 18509, 17366, 16219, 15077, 13932, 12786, 11644, 10499, 9353, 8211, 7072, 5912, 4845, 4964, 5527, 6015, 6519, 7024, 7526, 8030, 8534, 9037, 9541, 10045, 10547, 11052, 11555, 12058, 12562, 13065, 13569, 14074, 14577, 15078, 15568, 16142, 15662, 14331, 13103, 11854, 10605, 9359, 8109, 6859, 5613, 4364, 3115, 1869, 619, -629, -1876, -3126, -4374, -5621, -6870, -8118, -9365, -10603, -11904, -12711, -12626, -12537, -12451, -12363, -12276, -12188, -12101, -12013, -11925, -11837, -11750, -11662, -11575, -11487, -11399, -11311, -11224, -11136, -11048, -10961, -10863, -10811, -10539, -9203, -7703, -6240, -4764, -3291, -1819, -343, 1128, 2600, 4076, 5548, 7022, 8497, 9968, 11442, 12917, 14389, 15862, 17338, 18809, 20275, 21759, 23185, 22579, 21004, 19584, 18130, 16677, 15229, 13776, 12323, 10874, 9421, 7968, 6519, 5066, 3615, 2164, 711, -739, -2190, -3643, -5092, -6543, -7986, -9486, -10337, -10529, -10774, -11009, -11245, -11480, -11715, -11950, -12186, -12421, -12656, -12891, -13126, -13361, -13596, -13831, -14066, -14301, -14536, -14772, -15006, -15235, -15496, -15553, -15131, -14692, -14260, -13824, -13390, -12954, -12518, -12084, -11649, -11213, -10780, -10344, -9908, -9474, -9039, -8603, -8169, -7733, -7298, -6863, -6438, -5972, -5693, -6623, -7840, -9001, -10176, -11352, -12525, -13701, -14875, -16047, -17224, -18398, -19571, -20747, -21920, -23094, -24270, -25443, -26618, -27793, -28966, -30136, -31304, -32514, -31907, -30221, -28700, -27147, -25591, -24041, -22487, -20933, -19382, -17827, -16274, -14723, -13168, -11615, -10064, -8508, -6955, -5404, -3852, -2304, -724};