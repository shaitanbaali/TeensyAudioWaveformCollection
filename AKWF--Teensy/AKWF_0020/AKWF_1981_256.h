/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1981 256 samples */
 
const int16_t AKWF_1981_256_DATA [256] = 
{416, 988, 1467, 1960, 2450, 2940, 3432, 3922, 4413, 4901, 5417, 5989, 6564, 7136, 7711, 8285, 8857, 9431, 10006, 10577, 11133, 11682, 12229, 12779, 13327, 13875, 14424, 14974, 15521, 16076, 16642, 17209, 17777, 18343, 18910, 19477, 20043, 20611, 21177, 21729, 22276, 22826, 23374, 23922, 24472, 25018, 25567, 26116, 26668, 27232, 27795, 28356, 28919, 29481, 30043, 30604, 31172, 31706, 31873, 31909, 31968, 32023, 32076, 32131, 32186, 32235, 32309, 32191, 31783, 31389, 30992, 30596, 30199, 29802, 29406, 29010, 28610, 28153, 27680, 27210, 26741, 26270, 25799, 25329, 24857, 24390, 23889, 23341, 22796, 22252, 21706, 21160, 20615, 20069, 19524, 18979, 18430, 17881, 17332, 16783, 16234, 15684, 15135, 14587, 14038, 13484, 12925, 12367, 11807, 11250, 10691, 10131, 9574, 9015, 8456, 7899, 7339, 6779, 6220, 5661, 5102, 4544, 3984, 3424, 2867, 2312, 1757, 1202, 646, 92, -462, -1019, -1573, -2128, -2692, -3254, -3818, -4381, -4944, -5508, -6071, -6634, -7198, -7755, -8304, -8855, -9406, -9957, -10507, -11059, -11609, -12159, -12712, -13279, -13849, -14419, -14988, -15558, -16127, -16696, -17266, -17835, -18390, -18932, -19474, -20015, -20557, -21098, -21641, -22184, -22724, -23273, -23855, -24442, -25028, -25615, -26201, -26787, -27373, -27958, -28548, -29043, -29456, -29879, -30299, -30719, -31141, -31562, -31978, -32417, -32732, -32596, -32406, -32229, -32049, -31868, -31688, -31508, -31326, -31156, -30818, -30358, -29916, -29471, -29025, -28580, -28135, -27688, -27246, -26790, -26295, -25800, -25305, -24809, -24313, -23816, -23320, -22825, -22329, -21794, -21231, -20673, -20114, -19554, -18993, -18434, -17875, -17314, -16758, -16214, -15668, -15126, -14581, -14036, -13492, -12948, -12403, -11861, -11301, -10732, -10166, -9599, -9032, -8465, -7897, -7328, -6769, -6161, -5435, -4706, -3977, -3247, -2519, -1790, -1064, -321};