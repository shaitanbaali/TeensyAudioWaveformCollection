/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1979 256 samples */
 
const int16_t AKWF_1979_256_DATA [256] = 
{1001, 3565, 5462, 7344, 9232, 11119, 13009, 14894, 16779, 18672, 20546, 21946, 23121, 24326, 25527, 26728, 27928, 29130, 30319, 31571, 32401, 32368, 32343, 32320, 32296, 32271, 32246, 32220, 32197, 32167, 31926, 31600, 31288, 30973, 30658, 30343, 30028, 29715, 29392, 29143, 29015, 28886, 28757, 28628, 28500, 28371, 28243, 28113, 27994, 28034, 28136, 28228, 28321, 28415, 28509, 28603, 28692, 28800, 28778, 28544, 28317, 28089, 27863, 27635, 27406, 27179, 26954, 26712, 26184, 25568, 24967, 24366, 23763, 23160, 22559, 21956, 21349, 20784, 20276, 19767, 19259, 18749, 18239, 17732, 17224, 16707, 16240, 16191, 16269, 16326, 16386, 16447, 16508, 16569, 16633, 16681, 16876, 17267, 17647, 18029, 18410, 18792, 19175, 19555, 19944, 20291, 20256, 20126, 20017, 19904, 19790, 19677, 19564, 19441, 19373, 18809, 17665, 16563, 15459, 14349, 13240, 12135, 11022, 9924, 8759, 7180, 5506, 3850, 2187, 528, -1130, -2793, -4449, -6125, -7574, -8775, -9995, -11213, -12428, -13646, -14863, -16073, -17310, -18416, -18757, -18955, -19185, -19407, -19630, -19852, -20073, -20290, -20540, -20459, -20064, -19701, -19333, -18963, -18595, -18227, -17859, -17485, -17150, -16995, -16869, -16738, -16609, -16480, -16350, -16220, -16094, -15948, -16134, -16613, -17065, -17521, -17977, -18434, -18891, -19347, -19801, -20284, -20892, -21519, -22141, -22764, -23387, -24010, -24633, -25254, -25890, -26319, -26585, -26871, -27155, -27438, -27721, -28004, -28285, -28580, -28796, -28740, -28654, -28574, -28494, -28412, -28332, -28251, -28170, -28085, -28103, -28194, -28277, -28361, -28445, -28529, -28615, -28700, -28777, -28910, -29212, -29531, -29847, -30163, -30481, -30798, -31113, -31429, -31750, -31929, -32015, -32113, -32209, -32305, -32402, -32498, -32584, -32724, -32573, -31594, -30576, -29567, -28554, -27543, -26530, -25514, -24502, -23499, -21335, -18495, -15735, -12964, -10195, -7424, -4661, -1840};