/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1980 256 samples */
 
const int16_t AKWF_1980_256_DATA [256] = 
{2153, 5339, 7033, 8345, 9728, 11098, 12469, 13838, 15207, 16571, 17977, 18928, 19317, 19729, 20142, 20552, 20960, 21370, 21781, 22190, 22595, 22944, 23279, 23618, 23955, 24293, 24631, 24969, 25304, 25650, 25912, 26074, 26244, 26414, 26584, 26754, 26923, 27092, 27264, 27423, 27503, 27566, 27633, 27699, 27765, 27831, 27896, 27962, 28031, 28052, 28025, 28001, 27975, 27952, 27927, 27902, 27877, 27854, 27824, 27765, 27701, 27637, 27574, 27512, 27448, 27385, 27322, 27254, 27270, 27365, 27453, 27541, 27630, 27719, 27807, 27896, 27988, 28058, 28010, 27949, 27891, 27831, 27772, 27713, 27655, 27597, 27535, 27537, 27593, 27643, 27694, 27745, 27796, 27847, 27897, 27953, 27972, 27851, 27709, 27572, 27434, 27296, 27158, 27021, 26884, 26740, 26733, 26834, 26923, 27013, 27104, 27195, 27287, 27373, 27481, 27476, 27062, 26612, 26172, 25729, 25286, 24843, 24398, 23946, 23556, 21869, 19311, 16863, 14389, 11922, 9453, 6980, 4520, 2016, -241, -1780, -3258, -4751, -6237, -7725, -9215, -10698, -12186, -13681, -14651, -15288, -15969, -16641, -17312, -17986, -18656, -19328, -20001, -20670, -21333, -21995, -22657, -23320, -23981, -24643, -25303, -25964, -26632, -27044, -27314, -27605, -27894, -28181, -28468, -28756, -29043, -29333, -29607, -29844, -30081, -30318, -30554, -30791, -31028, -31264, -31502, -31737, -31819, -31821, -31836, -31848, -31860, -31872, -31884, -31896, -31906, -31936, -32010, -32084, -32157, -32232, -32306, -32380, -32454, -32529, -32603, -32634, -32647, -32664, -32680, -32696, -32712, -32727, -32742, -32760, -32754, -32702, -32648, -32593, -32541, -32486, -32432, -32379, -32325, -32269, -32177, -32070, -31964, -31859, -31753, -31648, -31543, -31435, -31339, -31158, -30832, -30509, -30185, -29860, -29537, -29213, -28888, -28564, -28241, -27924, -27610, -27294, -26979, -26666, -26351, -26037, -25690, -25519, -24115, -20790, -17535, -14276, -11016, -7754, -4501, -1181};