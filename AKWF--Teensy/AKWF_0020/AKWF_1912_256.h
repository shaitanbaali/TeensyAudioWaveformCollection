/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1912 256 samples */
 
const int16_t AKWF_1912_256_DATA [256] = 
{614, 2391, 4156, 5879, 7518, 9034, 10382, 11523, 12495, 13322, 14012, 14565, 14986, 15279, 15459, 15530, 15507, 15400, 15217, 14974, 14681, 14330, 13886, 13351, 12740, 12074, 11368, 10637, 9900, 9176, 8484, 7846, 7267, 6765, 6351, 6036, 5822, 5700, 5655, 5678, 5753, 5865, 5996, 6132, 6258, 6360, 6427, 6449, 6413, 6302, 6129, 5921, 5701, 5503, 5355, 5289, 5336, 5525, 5883, 6436, 7197, 8185, 9416, 10868, 12529, 14346, 16276, 18282, 20296, 22270, 24177, 25944, 27537, 28915, 30030, 30894, 31537, 31964, 32184, 32205, 32046, 31718, 31239, 30629, 29902, 29086, 28190, 27230, 26221, 25131, 23945, 22683, 21342, 19939, 18490, 17006, 15502, 13989, 12471, 10965, 9487, 8035, 6632, 5272, 3957, 2683, 1457, 258, -916, -2068, -3211, -4344, -5468, -6607, -7750, -8901, -10090, -11302, -12527, -13746, -14930, -16050, -17086, -18002, -18787, -19409, -19853, -20098, -20137, -19944, -19501, -18837, -17993, -17010, -15941, -14828, -13724, -12685, -11758, -10990, -10423, -10087, -10013, -10199, -10630, -11275, -12107, -13083, -14169, -15315, -16473, -17604, -18670, -19625, -20441, -21085, -21540, -21831, -21970, -21983, -21901, -21755, -21583, -21420, -21302, -21263, -21335, -21546, -21920, -22472, -23209, -24111, -25146, -26273, -27451, -28628, -29751, -30770, -31643, -32327, -32727, -32770, -32730, -32343, -31631, -30683, -29497, -28098, -26523, -24773, -22890, -20899, -18827, -16712, -14580, -12438, -10313, -8125, -5868, -3605, -1333, 903, 3062, 5114, 7020, 8735, 10254, 11535, 12554, 13295, 13733, 13858, 13697, 13282, 12658, 11865, 10949, 9959, 8942, 7945, 7019, 6192, 5503, 4974, 4597, 4355, 4232, 4201, 4233, 4301, 4371, 4411, 4390, 4278, 4048, 3679, 3156, 2463, 1599, 599, -495, -1648, -2806, -3923, -4956, -5853, -6565, -7055, -7284, -7224, -6854, -6179, -5223, -4028, -2627, -1021};