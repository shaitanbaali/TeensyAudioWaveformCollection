/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1926 256 samples */
 
const int16_t AKWF_1926_256_DATA [256] = 
{1573, 4292, 6935, 9546, 12095, 14568, 16947, 19204, 21333, 23315, 25131, 26776, 28236, 29499, 30563, 31421, 32067, 32505, 32732, 32754, 32575, 32202, 31646, 30914, 30021, 28983, 27810, 26523, 25139, 23671, 22145, 20577, 18982, 17387, 15806, 14254, 12757, 11324, 9971, 8717, 7569, 6540, 5641, 4876, 4252, 3773, 3440, 3253, 3210, 3305, 3534, 3888, 4359, 4934, 5602, 6350, 7161, 8021, 8917, 9828, 10738, 11635, 12497, 13310, 14061, 14731, 15308, 15781, 16137, 16366, 16461, 16414, 16221, 15877, 15384, 14739, 13945, 13009, 11933, 10725, 9399, 7957, 6416, 4792, 3092, 1335, -458, -2282, -4114, -5933, -7731, -9484, -11177, -12799, -14329, -15753, -17062, -18239, -19274, -20161, -20886, -21446, -21835, -22049, -22085, -21945, -21628, -21137, -20476, -19654, -18672, -17541, -16275, -14876, -13361, -11744, -10029, -8239, -6387, -4479, -2539, -579, 1391, 3353, 5292, 7200, 9058, 10856, 12587, 14231, 15785, 17241, 18584, 19813, 20921, 21899, 22749, 23465, 24043, 24484, 24788, 24956, 24990, 24889, 24661, 24307, 23832, 23244, 22544, 21742, 20847, 19859, 18791, 17653, 16445, 15183, 13873, 12520, 11138, 9733, 8312, 6888, 5465, 4050, 2657, 1289, -49, -1342, -2591, -3788, -4923, -5995, -6999, -7927, -8780, -9552, -10240, -10844, -11361, -11791, -12135, -12393, -12567, -12658, -12672, -12609, -12474, -12276, -12017, -11703, -11343, -10945, -10513, -10059, -9591, -9117, -8647, -8190, -7753, -7350, -6985, -6668, -6409, -6214, -6090, -6043, -6081, -6207, -6424, -6735, -7144, -7648, -8249, -8943, -9727, -10600, -11552, -12577, -13670, -14819, -16012, -17243, -18495, -19756, -21016, -22257, -23466, -24629, -25729, -26755, -27691, -28520, -29232, -29814, -30253, -30539, -30662, -30614, -30388, -29980, -29385, -28600, -27627, -26469, -25124, -23603, -21913, -20055, -18049, -15906, -13631, -11250, -8775, -6224, -3620, -922};