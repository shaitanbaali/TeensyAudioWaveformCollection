/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1961 256 samples */
 
const int16_t AKWF_1961_256_DATA [256] = 
{83, 266, 414, 532, 624, 693, 743, 781, 814, 846, 886, 939, 1009, 1102, 1220, 1366, 1536, 1732, 1952, 2192, 2449, 2720, 3000, 3288, 3579, 3874, 4171, 4472, 4777, 5092, 5418, 5758, 6121, 6506, 6918, 7364, 7840, 8349, 8893, 9462, 10060, 10678, 11310, 11955, 12602, 13248, 13892, 14529, 15159, 15787, 16416, 17049, 17700, 18374, 19079, 19828, 20623, 21470, 22372, 23327, 24324, 25358, 26407, 27454, 28478, 29449, 30340, 31129, 31783, 32282, 32608, 32744, 32683, 32423, 31970, 31334, 30532, 29587, 28527, 27377, 26172, 24935, 23700, 22491, 21325, 20221, 19190, 18237, 17362, 16565, 15833, 15160, 14536, 13942, 13373, 12817, 12262, 11706, 11142, 10569, 9990, 9409, 8827, 8256, 7696, 7156, 6640, 6153, 5697, 5273, 4879, 4514, 4177, 3859, 3561, 3276, 2998, 2727, 2460, 2194, 1932, 1672, 1415, 1164, 924, 694, 481, 283, 105, -52, -190, -308, -408, -492, -563, -625, -682, -738, -796, -863, -940, -1031, -1139, -1266, -1413, -1581, -1770, -1979, -2205, -2449, -2707, -2977, -3256, -3543, -3839, -4140, -4447, -4762, -5084, -5418, -5768, -6135, -6523, -6937, -7378, -7850, -8352, -8884, -9447, -10035, -10646, -11275, -11916, -12564, -13215, -13864, -14507, -15146, -15782, -16416, -17057, -17711, -18384, -19088, -19831, -20618, -21458, -22352, -23296, -24288, -25314, -26361, -27410, -28434, -29410, -30312, -31108, -31772, -32283, -32618, -32762, -32709, -32454, -32002, -31365, -30561, -29612, -28544, -27390, -26178, -24938, -23703, -22490, -21327, -20229, -19201, -18255, -17389, -16596, -15871, -15202, -14577, -13985, -13410, -12846, -12284, -11716, -11140, -10558, -9970, -9381, -8798, -8226, -7670, -7140, -6637, -6163, -5725, -5318, -4940, -4588, -4256, -3941, -3636, -3336, -3037, -2737, -2431, -2124, -1814, -1505, -1201, -907, -627, -367, -129};