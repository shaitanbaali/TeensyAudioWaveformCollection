/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1970 256 samples */
 
const int16_t AKWF_1970_256_DATA [256] = 
{2320, 5972, 8351, 10566, 12820, 15069, 17321, 19566, 21814, 24052, 26362, 27709, 28214, 28800, 29373, 29945, 30518, 31091, 31659, 32247, 32723, 32750, 32707, 32679, 32648, 32617, 32585, 32553, 32520, 32499, 32227, 31752, 31296, 30837, 30378, 29919, 29460, 28997, 28552, 28016, 27134, 26214, 25307, 24395, 23482, 22572, 21661, 20751, 19819, 19257, 18957, 18625, 18297, 17970, 17643, 17315, 16994, 16644, 16450, 16741, 17078, 17406, 17734, 18065, 18395, 18724, 19053, 19386, 19551, 19603, 19668, 19732, 19795, 19858, 19921, 19978, 20068, 19956, 19261, 18524, 17800, 17070, 16341, 15614, 14884, 14153, 13436, 12482, 11395, 10330, 9260, 8190, 7122, 6051, 4983, 3908, 2878, 1962, 1052, 140, -769, -1679, -2592, -3502, -4412, -5326, -6325, -7377, -8422, -9465, -10512, -11559, -12603, -13638, -14729, -15448, -15333, -15185, -15048, -14907, -14767, -14627, -14480, -14340, -14200, -12331, -9634, -7077, -4489, -1906, 676, 3264, 5826, 8497, 10525, 11231, 11938, 12652, 13359, 14068, 14777, 15478, 16196, 16863, 16297, 15189, 14161, 13120, 12077, 11035, 9995, 8953, 7903, 6914, 6024, 5137, 4250, 3361, 2473, 1586, 696, -189, -1082, -2109, -3186, -4256, -5329, -6399, -7470, -8542, -9609, -10693, -11683, -12511, -13349, -14185, -15019, -15855, -16692, -17523, -18368, -19170, -19433, -19511, -19619, -19722, -19826, -19929, -20032, -20130, -20252, -20170, -19788, -19413, -19037, -18660, -18284, -17907, -17534, -17150, -16808, -16869, -17058, -17223, -17394, -17564, -17734, -17905, -18082, -18218, -18667, -19544, -20391, -21242, -22094, -22946, -23800, -24649, -25505, -26341, -26989, -27589, -28199, -28806, -29413, -30020, -30627, -31230, -31861, -32208, -32214, -32239, -32260, -32280, -32301, -32323, -32341, -32367, -32358, -32124, -31833, -31554, -31272, -30990, -30707, -30424, -30110, -29973, -28068, -24163, -20420, -16655, -12890, -9123, -5367, -1533};