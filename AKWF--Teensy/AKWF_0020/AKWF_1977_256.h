/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1977 256 samples */
 
const int16_t AKWF_1977_256_DATA [256] = 
{1270, 3534, 5218, 6919, 8620, 10321, 12024, 13723, 15421, 17134, 18785, 19783, 20550, 21353, 22151, 22947, 23743, 24540, 25325, 26173, 26494, 26034, 25602, 25165, 24728, 24292, 23853, 23417, 22979, 22547, 22205, 21889, 21568, 21248, 20927, 20607, 20287, 19976, 19619, 19611, 20064, 20492, 20923, 21354, 21787, 22217, 22651, 23076, 23541, 24310, 25163, 25998, 26839, 27680, 28518, 29359, 30192, 31059, 31589, 31707, 31847, 31985, 32122, 32260, 32398, 32531, 32684, 32734, 32060, 31217, 30408, 29593, 28778, 27961, 27145, 26328, 25518, 24643, 23690, 22744, 21801, 20853, 19906, 18963, 18022, 17056, 16207, 15985, 15889, 15770, 15655, 15541, 15428, 15314, 15204, 15067, 15295, 15885, 16447, 17015, 17581, 18146, 18714, 19278, 19855, 20360, 20511, 20600, 20702, 20801, 20900, 21000, 21097, 21185, 21339, 20760, 19516, 18349, 17172, 15991, 14810, 13632, 12444, 11287, 9996, 8134, 6197, 4276, 2348, 425, -1500, -3427, -5348, -7289, -8880, -10179, -11510, -12837, -14159, -15486, -16811, -18125, -19487, -20583, -20720, -20733, -20774, -20808, -20841, -20876, -20909, -20938, -20990, -20664, -20055, -19483, -18905, -18325, -17746, -17167, -16593, -15994, -15524, -15493, -15495, -15489, -15486, -15482, -15478, -15476, -15475, -15457, -16004, -16922, -17798, -18683, -19565, -20449, -21334, -22216, -23100, -23985, -24874, -25765, -26656, -27545, -28437, -29326, -30214, -31103, -32002, -32312, -32260, -32259, -32248, -32237, -32226, -32215, -32196, -32219, -32020, -31222, -30411, -29603, -28793, -27985, -27175, -26365, -25558, -24746, -24127, -23613, -23083, -22555, -22030, -21502, -20975, -20457, -19899, -19587, -19818, -20074, -20323, -20575, -20827, -21077, -21328, -21580, -21835, -22246, -22740, -23219, -23701, -24184, -24666, -25149, -25622, -26149, -26319, -25729, -25138, -24550, -23959, -23370, -22779, -22183, -21601, -20991, -18989, -16402, -13904, -11392, -8882, -6370, -3866, -1309};