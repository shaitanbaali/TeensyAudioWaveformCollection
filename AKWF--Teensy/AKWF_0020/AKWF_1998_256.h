/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1998 256 samples */
 
const int16_t AKWF_1998_256_DATA [256] = 
{386, 1393, 2381, 3365, 4392, 5487, 6581, 7673, 8766, 9861, 10953, 12047, 13140, 14229, 15322, 16415, 17504, 18596, 19687, 20776, 21863, 22971, 23973, 24508, 24979, 25462, 25944, 26425, 26904, 27385, 27864, 28343, 28823, 29302, 29781, 30261, 30738, 31217, 31695, 32172, 32654, 32586, 32275, 32006, 31729, 31453, 31176, 30898, 30621, 30344, 30067, 29790, 29513, 29235, 28959, 28681, 28404, 28125, 27859, 27445, 26865, 26299, 25731, 25163, 24593, 24026, 23458, 22888, 22322, 21754, 21185, 20618, 20051, 19483, 18917, 18349, 17782, 17208, 16607, 16006, 15407, 14806, 14205, 13605, 13005, 12404, 11806, 11205, 10606, 10008, 9408, 8809, 8210, 7613, 7008, 6443, 6205, 6072, 5920, 5771, 5623, 5474, 5327, 5178, 5030, 4882, 4735, 4588, 4439, 4292, 4145, 3997, 3851, 3700, 3628, 3615, 3594, 3574, 3555, 3535, 3516, 3498, 3478, 3459, 3441, 3422, 3402, 3383, 3364, 3345, 3322, 3326, 3122, 2568, 2015, 1465, 913, 360, -190, -742, -1294, -1845, -2398, -2949, -3499, -4052, -4603, -5153, -5706, -6254, -6818, -7468, -8130, -8789, -9450, -10110, -10769, -11429, -12087, -12747, -13406, -14065, -14724, -15383, -16040, -16698, -17356, -18013, -18674, -19031, -19242, -19477, -19709, -19939, -20170, -20401, -20631, -20861, -21092, -21321, -21551, -21781, -22011, -22241, -22470, -22699, -22931, -23135, -23305, -23479, -23651, -23823, -23996, -24168, -24341, -24513, -24685, -24857, -25030, -25201, -25373, -25545, -25717, -25889, -26059, -26241, -26453, -26668, -26883, -27098, -27312, -27527, -27741, -27955, -28170, -28384, -28598, -28811, -29026, -29240, -29454, -29663, -29891, -30036, -29385, -28471, -27604, -26726, -25850, -24974, -24096, -23220, -22345, -21467, -20592, -19716, -18839, -17965, -17088, -16212, -15337, -14465, -13521, -12526, -11533, -10539, -9548, -8555, -7563, -6573, -5579, -4588, -3598, -2608, -1621, -613};