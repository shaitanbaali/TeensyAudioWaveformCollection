/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1940 256 samples */
 
const int16_t AKWF_1940_256_DATA [256] = 
{787, 2788, 4658, 6442, 8178, 9899, 11595, 13254, 14874, 16450, 17967, 19426, 20817, 22129, 23364, 24508, 25556, 26504, 27347, 28075, 28690, 29183, 29551, 29793, 29904, 29885, 29735, 29425, 28926, 28248, 27408, 26417, 25291, 24050, 22711, 21291, 19816, 18301, 16768, 15243, 13740, 12282, 10893, 9585, 8380, 7297, 6347, 5547, 4911, 4443, 4159, 4062, 4145, 4395, 4798, 5342, 6006, 6771, 7621, 8532, 9481, 10452, 11418, 12356, 13249, 14069, 14800, 15422, 15913, 16258, 16441, 16448, 16267, 15892, 15338, 14615, 13730, 12699, 11527, 10232, 8831, 7333, 5759, 4129, 2455, 758, -939, -2628, -4282, -5884, -7423, -8875, -10227, -11468, -12579, -13552, -14378, -15090, -15719, -16260, -16710, -17070, -17340, -17516, -17600, -17593, -17493, -17303, -17022, -16654, -16197, -15655, -15032, -14326, -13543, -12686, -11755, -10756, -9694, -8570, -7356, -6015, -4549, -2978, -1318, 421, 2213, 4044, 5899, 7747, 9575, 11366, 13089, 14732, 16275, 17693, 18973, 20097, 21045, 21807, 22368, 22716, 22842, 22738, 22397, 21826, 21038, 20049, 18868, 17516, 16012, 14372, 12620, 10779, 8864, 6905, 4923, 2934, 969, -954, -2817, -4595, -6273, -7835, -9259, -10538, -11661, -12666, -13572, -14380, -15084, -15693, -16207, -16628, -16961, -17210, -17379, -17474, -17500, -17463, -17367, -17221, -17029, -16797, -16533, -16240, -15926, -15596, -15256, -14908, -14517, -14049, -13513, -12920, -12280, -11601, -10897, -10179, -9459, -8752, -8068, -7419, -6822, -6286, -5822, -5445, -5164, -4989, -4929, -4992, -5187, -5517, -5986, -6613, -7419, -8398, -9530, -10801, -12196, -13691, -15264, -16899, -18565, -20242, -21910, -23535, -25100, -26581, -27951, -29189, -30276, -31188, -31907, -32420, -32707, -32759, -32570, -32161, -31541, -30718, -29703, -28504, -27135, -25615, -23948, -22156, -20261, -18266, -16201, -14081, -11918, -9737, -7554, -5383, -3247, -1116};