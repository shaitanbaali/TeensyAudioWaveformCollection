/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2002 256 samples */
 
const int16_t AKWF_2002_256_DATA [256] = 
{802, 3571, 6276, 8954, 11570, 14106, 16539, 18837, 20989, 22974, 24767, 26361, 27736, 28899, 29904, 30758, 31455, 32003, 32402, 32652, 32762, 32734, 32574, 32286, 31876, 31354, 30722, 29990, 29165, 28252, 27262, 26201, 25074, 23894, 22665, 21391, 20086, 18752, 17393, 15974, 14454, 12844, 11160, 9403, 7588, 5732, 3838, 1922, 6, -1911, -3809, -5668, -7488, -9247, -10930, -12534, -14038, -15431, -16710, -17856, -18860, -19722, -20427, -20970, -21348, -21547, -21571, -21427, -21124, -20671, -20079, -19362, -18529, -17594, -16576, -15483, -14333, -13144, -11925, -10695, -9471, -8263, -7087, -5962, -4894, -3899, -2989, -2172, -1460, -862, -367, 39, 360, 599, 761, 847, 865, 820, 717, 563, 365, 131, -134, -420, -721, -1031, -1339, -1640, -1926, -2189, -2426, -2628, -2790, -2906, -2975, -2991, -2967, -2910, -2821, -2701, -2552, -2378, -2182, -1965, -1732, -1484, -1228, -966, -701, -437, -179, 70, 307, 529, 731, 911, 1064, 1191, 1286, 1349, 1377, 1370, 1333, 1266, 1171, 1050, 905, 739, 553, 350, 134, -93, -329, -569, -812, -1054, -1292, -1523, -1744, -1951, -2144, -2318, -2470, -2602, -2707, -2786, -2838, -2868, -2883, -2883, -2868, -2837, -2791, -2729, -2652, -2560, -2452, -2329, -2192, -2041, -1874, -1695, -1503, -1298, -1082, -854, -615, -367, -110, 154, 425, 701, 991, 1316, 1685, 2090, 2525, 2983, 3457, 3938, 4421, 4896, 5353, 5786, 6185, 6542, 6849, 7096, 7274, 7379, 7403, 7336, 7176, 6916, 6550, 6075, 5488, 4791, 3953, 2951, 1796, 498, -923, -2453, -4077, -5769, -7512, -9290, -11072, -12843, -14581, -16257, -17855, -19355, -20727, -21959, -23028, -23915, -24604, -25078, -25324, -25330, -25085, -24580, -23809, -22777, -21501, -19987, -18258, -16333, -14222, -11956, -9556, -7042, -4446, -1729};