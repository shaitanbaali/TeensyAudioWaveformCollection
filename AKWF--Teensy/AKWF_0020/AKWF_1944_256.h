/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1944 256 samples */
 
const int16_t AKWF_1944_256_DATA [256] = 
{1384, 4021, 6584, 9115, 11589, 13991, 16309, 18516, 20607, 22568, 24377, 26033, 27522, 28833, 29964, 30907, 31657, 32216, 32580, 32752, 32737, 32538, 32162, 31616, 30912, 30061, 29074, 27965, 26751, 25442, 24061, 22620, 21135, 19627, 18112, 16602, 15123, 13683, 12298, 10987, 9758, 8625, 7600, 6690, 5901, 5244, 4718, 4329, 4077, 3959, 3974, 4118, 4383, 4763, 5245, 5825, 6485, 7213, 8000, 8825, 9676, 10538, 11392, 12224, 13019, 13760, 14433, 15023, 15517, 15905, 16172, 16313, 16315, 16175, 15888, 15449, 14857, 14115, 13222, 12184, 11009, 9698, 8267, 6727, 5084, 3357, 1563, -291, -2181, -4089, -6004, -7901, -9764, -11579, -13322, -14977, -16531, -17965, -19264, -20418, -21410, -22233, -22877, -23331, -23595, -23663, -23531, -23202, -22676, -21957, -21050, -19963, -18709, -17289, -15723, -14026, -12205, -10280, -8274, -6192, -4061, -1902, 277, 2448, 4592, 6700, 8743, 10707, 12582, 14342, 15979, 17481, 18831, 20021, 21044, 21888, 22552, 23031, 23319, 23420, 23332, 23058, 22602, 21969, 21170, 20209, 19097, 17848, 16467, 14972, 13379, 11694, 9937, 8125, 6266, 4384, 2490, 595, -1278, -3119, -4917, -6654, -8319, -9906, -11395, -12785, -14065, -15225, -16263, -17174, -17952, -18596, -19107, -19481, -19723, -19834, -19819, -19681, -19427, -19064, -18597, -18038, -17395, -16676, -15894, -15060, -14180, -13271, -12343, -11405, -10471, -9555, -8661, -7806, -6999, -6249, -5566, -4959, -4435, -4001, -3665, -3432, -3305, -3291, -3388, -3600, -3927, -4369, -4922, -5585, -6354, -7221, -8185, -9236, -10364, -11565, -12826, -14135, -15485, -16862, -18251, -19646, -21027, -22384, -23706, -24974, -26177, -27305, -28341, -29276, -30097, -30792, -31352, -31767, -32030, -32132, -32068, -31834, -31424, -30837, -30074, -29132, -28016, -26731, -25275, -23661, -21899, -19989, -17948, -15790, -13518, -11156, -8717, -6213, -3669, -1041};