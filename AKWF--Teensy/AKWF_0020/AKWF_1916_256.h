/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1916 256 samples */
 
const int16_t AKWF_1916_256_DATA [256] = 
{694, 1632, 2442, 3158, 3784, 4330, 4810, 5237, 5624, 5985, 6328, 6668, 7019, 7381, 7738, 8083, 8420, 8750, 9078, 9403, 9728, 10057, 10385, 10721, 11062, 11408, 11763, 12129, 12515, 12920, 13336, 13759, 14182, 14598, 15003, 15391, 15753, 16087, 16386, 16646, 16866, 17043, 17183, 17290, 17369, 17431, 17483, 17533, 17590, 17665, 17761, 17891, 18056, 18268, 18518, 18801, 19116, 19463, 19842, 20243, 20665, 21112, 21573, 22048, 22533, 23019, 23510, 24004, 24505, 25016, 25531, 26041, 26550, 27050, 27533, 27996, 28432, 28837, 29211, 29545, 29837, 30086, 30292, 30454, 30575, 30657, 30697, 30701, 30671, 30607, 30511, 30386, 30233, 30055, 29852, 29625, 29371, 29088, 28775, 28426, 28038, 27605, 27125, 26595, 26015, 25373, 24677, 23917, 23106, 22245, 21333, 20375, 19377, 18336, 17266, 16159, 15020, 13858, 12677, 11483, 10280, 9058, 7799, 6514, 5217, 3925, 2647, 1404, 210, -912, -1948, -2886, -3714, -4420, -4996, -5427, -5713, -5875, -5926, -5889, -5788, -5645, -5486, -5335, -5215, -5148, -5156, -5253, -5447, -5729, -6089, -6522, -7014, -7548, -8119, -8705, -9292, -9866, -10409, -10912, -11365, -11755, -12092, -12383, -12636, -12855, -13051, -13231, -13405, -13586, -13781, -13999, -14252, -14543, -14882, -15271, -15696, -16159, -16654, -17175, -17728, -18304, -18898, -19508, -20128, -20750, -21378, -22005, -22626, -23248, -23869, -24494, -25115, -25730, -26335, -26928, -27499, -28054, -28586, -29091, -29568, -30011, -30422, -30801, -31147, -31458, -31736, -31978, -32188, -32367, -32511, -32622, -32703, -32750, -32767, -32753, -32704, -32617, -32493, -32334, -32140, -31911, -31651, -31357, -31031, -30676, -30291, -29875, -29433, -28966, -28488, -27995, -27475, -26928, -26340, -25700, -25004, -24243, -23407, -22493, -21493, -20400, -19215, -17925, -16536, -15063, -13522, -11934, -10325, -8717, -7140, -5602, -4135, -2753, -1478, -308};