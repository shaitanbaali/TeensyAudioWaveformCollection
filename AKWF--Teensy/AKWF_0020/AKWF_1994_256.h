/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1994 256 samples */
 
const int16_t AKWF_1994_256_DATA [256] = 
{139, 488, 831, 1170, 1527, 1969, 2422, 2872, 3322, 3774, 4223, 4674, 5125, 5574, 6025, 6475, 6923, 7373, 7823, 8271, 8722, 9170, 9620, 10132, 10674, 11208, 11746, 12283, 12818, 13355, 13891, 14427, 14963, 15499, 16035, 16571, 17106, 17640, 18177, 18709, 19249, 19720, 20111, 20509, 20905, 21301, 21698, 22095, 22490, 22886, 23282, 23676, 24073, 24468, 24863, 25259, 25654, 26045, 26452, 26770, 26868, 26950, 27035, 27119, 27204, 27287, 27372, 27456, 27539, 27623, 27707, 27791, 27874, 27957, 28041, 28121, 28217, 28240, 27627, 26821, 26051, 25271, 24492, 23714, 22935, 22155, 21379, 20600, 19820, 19044, 18264, 17487, 16710, 15932, 15154, 14381, 13517, 12588, 11667, 10742, 9822, 8900, 7976, 7055, 6133, 5210, 4291, 3369, 2447, 1528, 607, -314, -1220, -2191, -2753, -2611, -2486, -2361, -2234, -2105, -1978, -1851, -1723, -1594, -1467, -1338, -1210, -1082, -954, -825, -697, -569, -441, -325, -210, -95, 20, 135, 250, 366, 481, 595, 711, 826, 941, 1057, 1171, 1287, 1399, 1514, 1628, 936, -155, -1180, -2220, -3259, -4296, -5336, -6373, -7411, -8450, -9487, -10523, -11563, -12600, -13636, -14674, -15708, -16751, -17705, -18546, -19397, -20248, -21095, -21945, -22795, -23642, -24491, -25339, -26186, -27034, -27882, -28727, -29575, -30422, -31258, -32144, -32726, -32480, -32166, -31867, -31565, -31262, -30959, -30655, -30353, -30049, -29745, -29442, -29140, -28835, -28532, -28230, -27924, -27624, -27302, -26757, -26137, -25530, -24920, -24311, -23702, -23093, -22484, -21876, -21266, -20657, -20050, -19441, -18832, -18225, -17616, -17008, -16402, -15785, -15162, -14539, -13916, -13295, -12672, -12050, -11430, -10807, -10184, -9564, -8943, -8321, -7700, -7080, -6458, -5842, -5209, -4679, -4337, -3992, -3646, -3302, -2959, -2614, -2271, -1927, -1583, -1240, -897, -555, -206};