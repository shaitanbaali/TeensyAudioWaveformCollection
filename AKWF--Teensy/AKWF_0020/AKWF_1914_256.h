/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1914 256 samples */
 
const int16_t AKWF_1914_256_DATA [256] = 
{1224, 5135, 8871, 12442, 15754, 18744, 21357, 23573, 25487, 27092, 28404, 29445, 30253, 30855, 31284, 31577, 31769, 31898, 31997, 32098, 32229, 32389, 32521, 32620, 32691, 32736, 32762, 32768, 32761, 32740, 32709, 32669, 32621, 32571, 32513, 32455, 32404, 32362, 32330, 32308, 32295, 32288, 32289, 32295, 32303, 32313, 32323, 32329, 32333, 32333, 32326, 32315, 32298, 32280, 32260, 32241, 32225, 32211, 32204, 32203, 32207, 32221, 32244, 32271, 32310, 32357, 32412, 32464, 32508, 32536, 32541, 32516, 32449, 32336, 32167, 31936, 31637, 31261, 30815, 30318, 29766, 29153, 28476, 27721, 26881, 25953, 24928, 23806, 22577, 21235, 19778, 18209, 16523, 14715, 12782, 10747, 8621, 6432, 4204, 1952, -306, -2544, -4742, -6872, -8910, -10860, -12692, -14441, -16114, -17692, -19174, -20563, -21834, -22991, -24016, -24914, -25677, -26299, -26774, -27105, -27288, -27309, -27155, -26845, -26392, -25817, -25139, -24377, -23557, -22701, -21832, -20970, -20135, -19343, -18612, -17949, -17346, -16796, -16301, -15853, -15446, -15075, -14732, -14406, -14092, -13781, -13467, -13148, -12814, -12460, -12069, -11651, -11225, -10812, -10428, -10102, -9854, -9709, -9688, -9812, -10098, -10563, -11217, -12072, -13140, -14424, -15886, -17490, -19190, -20965, -22754, -24523, -26223, -27802, -29229, -30470, -31516, -32146, -32161, -32151, -32147, -32140, -32133, -32121, -32130, -31713, -30897, -29996, -28985, -27877, -26703, -25462, -24118, -22634, -21032, -19341, -17611, -15850, -14106, -12423, -10829, -9369, -8071, -6960, -6067, -5414, -5016, -4881, -4988, -5316, -5838, -6520, -7328, -8226, -9180, -10153, -11105, -12000, -12821, -13530, -14111, -14570, -14911, -15155, -15321, -15425, -15495, -15554, -15627, -15740, -15914, -16171, -16531, -16999, -17593, -18360, -19297, -20351, -21478, -22612, -23705, -24689, -25504, -26083, -26368, -26307, -25853, -24963, -23610, -21762, -19440, -16672, -13534, -10091, -6427, -2543};