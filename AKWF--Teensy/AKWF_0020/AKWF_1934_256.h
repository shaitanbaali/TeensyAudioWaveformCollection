/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1934 256 samples */
 
const int16_t AKWF_1934_256_DATA [256] = 
{561, 2430, 4249, 6094, 7946, 9802, 11650, 13476, 15274, 17034, 18739, 20385, 21959, 23446, 24842, 26135, 27310, 28365, 29288, 30071, 30708, 31192, 31519, 31683, 31684, 31494, 31088, 30477, 29676, 28696, 27560, 26286, 24890, 23401, 21837, 20217, 18572, 16921, 15285, 13695, 12165, 10718, 9382, 8167, 7092, 6180, 5437, 4878, 4513, 4336, 4339, 4513, 4843, 5316, 5914, 6621, 7418, 8283, 9200, 10142, 11090, 12025, 12922, 13762, 14525, 15189, 15737, 16154, 16421, 16525, 16454, 16203, 15799, 15256, 14581, 13777, 12852, 11817, 10677, 9444, 8134, 6749, 5306, 3820, 2294, 749, -801, -2353, -3888, -5394, -6866, -8286, -9645, -10940, -12158, -13335, -14509, -15664, -16796, -17900, -18965, -19985, -20953, -21857, -22692, -23450, -24120, -24698, -25174, -25540, -25794, -25925, -25930, -25803, -25541, -25139, -24596, -23910, -23068, -22045, -20852, -19503, -18005, -16379, -14639, -12797, -10877, -8897, -6868, -4821, -2768, -726, 1275, 3227, 5110, 6898, 8584, 10150, 11577, 12858, 13979, 14938, 15767, 16473, 17053, 17513, 17852, 18074, 18184, 18183, 18079, 17875, 17579, 17194, 16728, 16186, 15577, 14904, 14177, 13401, 12580, 11725, 10839, 9928, 8994, 7993, 6906, 5748, 4524, 3243, 1922, 566, -812, -2194, -3577, -4944, -6277, -7575, -8819, -9994, -11096, -12110, -13026, -13837, -14534, -15108, -15555, -15871, -16030, -16018, -15846, -15525, -15070, -14497, -13823, -13064, -12244, -11379, -10490, -9601, -8729, -7895, -7123, -6429, -5832, -5354, -5006, -4807, -4767, -4901, -5218, -5724, -6426, -7313, -8367, -9579, -10926, -12388, -13949, -15581, -17262, -18972, -20680, -22364, -24002, -25562, -27026, -28372, -29573, -30610, -31465, -32116, -32552, -32756, -32727, -32493, -32065, -31454, -30662, -29699, -28577, -27301, -25889, -24354, -22701, -20951, -19122, -17217, -15260, -13265, -11240, -9207, -7178, -5164, -3184, -1208};