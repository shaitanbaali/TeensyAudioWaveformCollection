/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1993 256 samples */
 
const int16_t AKWF_1993_256_DATA [256] = 
{881, 2202, 3534, 4680, 4769, 4637, 4553, 4457, 4362, 4265, 4169, 4073, 3976, 3880, 3784, 3686, 3591, 3493, 3396, 3300, 3204, 3107, 3136, 3241, 3335, 3431, 3527, 3623, 3718, 3814, 3910, 4006, 4102, 4197, 4292, 4389, 4484, 4580, 4674, 4775, 4815, 4776, 4742, 4704, 4667, 4632, 4596, 4560, 4525, 4487, 4450, 4416, 4379, 4343, 4306, 4270, 4234, 4197, 4174, 4204, 4239, 4272, 4306, 4339, 4373, 4408, 4442, 4476, 4508, 4543, 4577, 4611, 4645, 4679, 4711, 4746, 4778, 4768, 4743, 4721, 4698, 4676, 4653, 4630, 4608, 4585, 4562, 4541, 4517, 4495, 4473, 4449, 4428, 4405, 4379, 4382, 4403, 4423, 4443, 4464, 4483, 4503, 4524, 4544, 4565, 4583, 4605, 4625, 4644, 4664, 4686, 4705, 4728, 4735, 4710, 4686, 4662, 4639, 4614, 4591, 4566, 4543, 4518, 4495, 4470, 4447, 4422, 4399, 4374, 4351, 4325, 4306, 4322, 4344, 4366, 4388, 4409, 4431, 4451, 4473, 4495, 4517, 4539, 4560, 4582, 4603, 4624, 4647, 4668, 4690, 4691, 4680, 4671, 4662, 4651, 4643, 4634, 4624, 4615, 4604, 4596, 4587, 4577, 4568, 4558, 4549, 4539, 4531, 4507, 4462, 4419, 4376, 4332, 4287, 4244, 4199, 4156, 4112, 4069, 4024, 3979, 3936, 3893, 3849, 3804, 3759, 3730, 3758, 3793, 3826, 3860, 3892, 3926, 3960, 3994, 4025, 4059, 4093, 4126, 4159, 4193, 4228, 4254, 4302, 4269, 2732, 622, -1397, -3428, -5464, -7500, -9531, -11568, -13602, -15633, -17669, -19703, -21732, -23767, -25799, -27826, -29831, -31986, -32552, -31677, -30953, -30205, -29452, -28701, -27949, -27197, -26446, -25694, -24941, -24191, -23438, -22686, -21935, -21183, -20424, -19699, -18793, -17481, -16172, -14862, -13550, -12241, -10930, -9621, -8313, -7001, -5692, -4386, -3078, -1772, -441};