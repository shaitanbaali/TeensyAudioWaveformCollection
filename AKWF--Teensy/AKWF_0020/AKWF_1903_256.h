/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1903 256 samples */
 
const int16_t AKWF_1903_256_DATA [256] = 
{75, 196, 310, 430, 568, 731, 927, 1151, 1399, 1668, 1950, 2238, 2529, 2813, 3090, 3362, 3627, 3892, 4155, 4415, 4677, 4940, 5204, 5469, 5734, 5998, 6264, 6528, 6791, 7056, 7320, 7584, 7848, 8111, 8375, 8638, 8902, 9166, 9429, 9692, 9956, 10220, 10482, 10747, 11009, 11272, 11536, 11799, 12061, 12324, 12586, 12848, 13111, 13374, 13636, 13898, 14161, 14422, 14686, 14948, 15209, 15471, 15734, 15996, 16258, 16519, 16781, 17044, 17304, 17566, 17828, 18087, 18349, 18610, 18871, 19132, 19391, 19652, 19913, 20174, 20435, 20695, 20956, 21216, 21477, 21738, 21997, 22256, 22514, 22770, 23029, 23290, 23550, 23813, 24082, 24360, 24648, 24934, 25211, 25475, 25713, 25927, 26096, 26174, 26193, 26206, 26265, 26427, 26739, 27233, 27950, 28918, 30045, 31186, 32233, 32770, 32746, 32779, 32208, 30761, 28828, 26432, 23644, 20553, 17257, 13826, 10286, 6595, 2782, -1063, -4848, -8544, -12046, -15296, -18261, -20938, -23324, -25425, -27204, -28673, -29827, -30667, -31194, -31364, -31217, -30825, -30269, -29634, -28988, -28409, -27937, -27557, -27260, -27028, -26838, -26668, -26490, -26279, -26030, -25769, -25503, -25232, -24958, -24682, -24406, -24131, -23858, -23586, -23316, -23043, -22771, -22499, -22227, -21957, -21684, -21412, -21142, -20870, -20598, -20329, -20057, -19785, -19514, -19242, -18972, -18702, -18430, -18159, -17888, -17617, -17347, -17076, -16805, -16535, -16264, -15993, -15724, -15453, -15183, -14913, -14643, -14374, -14104, -13834, -13563, -13294, -13025, -12756, -12486, -12216, -11947, -11679, -11409, -11139, -10871, -10601, -10333, -10065, -9796, -9527, -9259, -8990, -8724, -8456, -8186, -7918, -7649, -7381, -7114, -6846, -6577, -6310, -6041, -5774, -5507, -5239, -4970, -4703, -4436, -4172, -3909, -3645, -3380, -3115, -2846, -2572, -2295, -2007, -1713, -1424, -1142, -876, -629, -407, -217, -57};