/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1995 256 samples */
 
const int16_t AKWF_1995_256_DATA [256] = 
{970, 3188, 5358, 7535, 9709, 11887, 14052, 16281, 18081, 18917, 19736, 20563, 21389, 22209, 23032, 23855, 24675, 25499, 26321, 27140, 27961, 28782, 29601, 30421, 31230, 32085, 32704, 31755, 30429, 29173, 27906, 26639, 25368, 24100, 22833, 21563, 20296, 19027, 17756, 16491, 15223, 13952, 12691, 11426, 10150, 9620, 9564, 9448, 9341, 9238, 9131, 9028, 8923, 8818, 8716, 8611, 8506, 8402, 8299, 8194, 8090, 7987, 7887, 7739, 7521, 7304, 7088, 6872, 6655, 6438, 6222, 6005, 5791, 5574, 5358, 5142, 4925, 4710, 4493, 4279, 4060, 3861, 3741, 3631, 3518, 3406, 3293, 3181, 3069, 2957, 2845, 2734, 2622, 2510, 2397, 2286, 2175, 2063, 1950, 1840, 1767, 1708, 1649, 1588, 1528, 1469, 1410, 1350, 1289, 1230, 1170, 1109, 1051, 991, 930, 872, 810, 756, 632, 438, 252, 65, -123, -310, -498, -686, -873, -1060, -1247, -1434, -1622, -1809, -1996, -2184, -2371, -2560, -2729, -2853, -2972, -3093, -3214, -3335, -3456, -3577, -3698, -3818, -3939, -4060, -4180, -4302, -4422, -4542, -4662, -4784, -4896, -4936, -4957, -4981, -5004, -5027, -5050, -5074, -5097, -5122, -5145, -5168, -5191, -5215, -5238, -5261, -5284, -5308, -5331, -5421, -5559, -5693, -5826, -5960, -6093, -6226, -6360, -6493, -6626, -6760, -6893, -7025, -7159, -7293, -7426, -7558, -7695, -7799, -7856, -7914, -7971, -8030, -8088, -8145, -8202, -8259, -8318, -8376, -8433, -8490, -8548, -8606, -8664, -8726, -8761, -8943, -9668, -10469, -11256, -12045, -12834, -13624, -14413, -15201, -15991, -16780, -17569, -18358, -19146, -19934, -20723, -21508, -22300, -23073, -23227, -23124, -23061, -22990, -22919, -22848, -22778, -22706, -22636, -22564, -22492, -22420, -22350, -22277, -22206, -22134, -22040, -22068, -20953, -18677, -16516, -14338, -12156, -9975, -7797, -5618, -3447, -1229};