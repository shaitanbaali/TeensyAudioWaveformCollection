/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1927 256 samples */
 
const int16_t AKWF_1927_256_DATA [256] = 
{1046, 3309, 5525, 7748, 9969, 12193, 14404, 16684, 18586, 19012, 19235, 19501, 19757, 20012, 20267, 20522, 20778, 21033, 21289, 21545, 21801, 22056, 22311, 22568, 22823, 23077, 23333, 23589, 23844, 24097, 24357, 24587, 24038, 23168, 22352, 21525, 20699, 19873, 19045, 18220, 17394, 16567, 15742, 14915, 14088, 13263, 12437, 11609, 10784, 9957, 9131, 8305, 7480, 6661, 5794, 5614, 6060, 6453, 6854, 7256, 7658, 8060, 8463, 8864, 9266, 9669, 10071, 10473, 10874, 11277, 11679, 12081, 12484, 12886, 13287, 13690, 14080, 14532, 14585, 13788, 12992, 12198, 11402, 10608, 9811, 9014, 8221, 7424, 6628, 5832, 5036, 4241, 3445, 2648, 1854, 1058, 261, -534, -1328, -2124, -2922, -3703, -4392, -5058, -5731, -6403, -7072, -7744, -8416, -9086, -9757, -10429, -11099, -11771, -12442, -13112, -13784, -14455, -15125, -15798, -16469, -17139, -17805, -18473, -19173, -18127, -16195, -14412, -12597, -10787, -8975, -7160, -5350, -3538, -1723, 85, 1898, 3713, 5522, 7335, 9149, 10959, 12772, 14586, 16395, 18207, 19997, 21918, 22398, 21226, 20155, 19068, 17978, 16890, 15799, 14710, 13621, 12530, 11442, 10353, 9261, 8172, 7083, 5993, 4905, 3815, 2724, 1637, 547, -537, -1652, -2587, -3014, -3424, -3841, -4256, -4669, -5083, -5498, -5912, -6326, -6740, -7154, -7568, -7983, -8396, -8811, -9225, -9639, -10053, -10467, -10881, -11293, -11714, -12092, -12132, -12075, -12037, -11995, -11952, -11910, -11867, -11826, -11784, -11740, -11698, -11656, -11614, -11572, -11529, -11487, -11445, -11402, -11360, -11318, -11278, -11240, -11170, -11746, -12731, -13658, -14598, -15537, -16475, -17415, -18353, -19291, -20231, -21169, -22108, -23048, -23986, -24925, -25865, -26802, -27742, -28682, -29619, -30557, -31468, -32534, -32232, -29951, -27741, -25520, -23295, -21075, -18849, -16624, -14404, -12177, -9954, -7734, -5511, -3294, -1032};