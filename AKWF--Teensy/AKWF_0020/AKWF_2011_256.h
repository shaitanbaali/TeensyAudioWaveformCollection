/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2011 256 samples */
 
const int16_t AKWF_2011_256_DATA [256] = 
{760, 2047, 3281, 4490, 5667, 6810, 7923, 9000, 10045, 11061, 12040, 12989, 13909, 14796, 15655, 16487, 17289, 18069, 18825, 19555, 20266, 20957, 21627, 22282, 22919, 23540, 24148, 24742, 25321, 25890, 26444, 26992, 27541, 28085, 28622, 29150, 29660, 30149, 30614, 31047, 31445, 31800, 32109, 32366, 32563, 32697, 32763, 32755, 32669, 32498, 32240, 31893, 31449, 30909, 30271, 29529, 28685, 27732, 26666, 25497, 24233, 22873, 21431, 19915, 18327, 16684, 14991, 13255, 11493, 9708, 7910, 6116, 4328, 2557, 818, -885, -2546, -4147, -5690, -7165, -8560, -9876, -11114, -12289, -13405, -14459, -15449, -16379, -17246, -18050, -18795, -19479, -20102, -20669, -21176, -21628, -22027, -22373, -22666, -22911, -23108, -23260, -23365, -23429, -23451, -23434, -23378, -23286, -23150, -22968, -22739, -22465, -22147, -21784, -21379, -20933, -20445, -19917, -19351, -18747, -18107, -17433, -16723, -15982, -15211, -14408, -13580, -12724, -11842, -10938, -10014, -9066, -8104, -7121, -6110, -5074, -4015, -2934, -1840, -732, 385, 1503, 2624, 3742, 4846, 5941, 7017, 8069, 9097, 10093, 11052, 11975, 12853, 13682, 14464, 15189, 15856, 16466, 17010, 17500, 17948, 18349, 18703, 19008, 19261, 19461, 19607, 19696, 19726, 19698, 19607, 19453, 19235, 18953, 18602, 18185, 17700, 17145, 16520, 15828, 15065, 14233, 13335, 12366, 11330, 10211, 9000, 7708, 6342, 4903, 3406, 1856, 258, -1371, -3028, -4707, -6389, -8072, -9745, -11393, -13014, -14597, -16127, -17603, -19015, -20349, -21606, -22776, -23849, -24825, -25706, -26504, -27226, -27866, -28424, -28904, -29304, -29624, -29869, -30037, -30131, -30152, -30102, -29984, -29799, -29550, -29239, -28870, -28443, -27963, -27429, -26849, -26221, -25548, -24835, -24081, -23271, -22400, -21469, -20481, -19443, -18354, -17219, -16047, -14836, -13593, -12327, -11033, -9724, -8403, -7071, -5737, -4405, -3079, -1765, -439};