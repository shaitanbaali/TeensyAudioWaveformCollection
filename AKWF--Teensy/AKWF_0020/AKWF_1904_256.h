/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1904 256 samples */
 
const int16_t AKWF_1904_256_DATA [256] = 
{164, 524, 817, 1069, 1301, 1534, 1792, 2092, 2452, 2871, 3348, 3870, 4428, 5005, 5587, 6166, 6730, 7280, 7822, 8355, 8881, 9407, 9931, 10458, 10988, 11519, 12050, 12583, 13114, 13646, 14179, 14707, 15239, 15771, 16301, 16831, 17359, 17891, 18422, 18950, 19480, 20008, 20537, 21066, 21597, 22125, 22651, 23177, 23702, 24219, 24724, 25225, 25726, 26240, 26772, 27328, 27909, 28522, 29162, 29810, 30441, 31027, 31542, 31961, 32269, 32462, 32552, 32540, 32436, 32246, 31978, 31642, 31250, 30792, 30269, 29690, 29071, 28433, 27789, 27156, 26550, 25965, 25408, 24873, 24352, 23843, 23335, 22820, 22294, 21761, 21225, 20686, 20145, 19601, 19057, 18517, 17975, 17436, 16896, 16354, 15816, 15280, 14739, 14201, 13662, 13122, 12586, 12048, 11508, 10970, 10431, 9893, 9358, 8819, 8282, 7746, 7207, 6673, 6138, 5599, 5064, 4527, 3989, 3457, 2920, 2383, 1848, 1312, 777, 244, -290, -827, -1360, -1895, -2427, -2961, -3495, -4031, -4561, -5096, -5631, -6164, -6698, -7231, -7762, -8296, -8829, -9361, -9895, -10425, -10955, -11489, -12021, -12552, -13084, -13613, -14146, -14677, -15209, -15741, -16271, -16800, -17333, -17865, -18395, -18925, -19452, -19981, -20508, -21034, -21556, -22075, -22596, -23119, -23646, -24177, -24712, -25244, -25772, -26298, -26826, -27362, -27906, -28460, -29031, -29620, -30231, -30836, -31400, -31907, -32320, -32620, -32760, -32767, -32676, -32435, -32100, -31688, -31223, -30721, -30207, -29674, -29115, -28539, -27950, -27356, -26760, -26168, -25589, -25024, -24473, -23939, -23412, -22893, -22376, -21856, -21326, -20791, -20254, -19714, -19175, -18633, -18091, -17549, -17007, -16468, -15932, -15389, -14851, -14312, -13772, -13236, -12698, -12158, -11620, -11080, -10542, -10008, -9469, -8931, -8393, -7861, -7329, -6801, -6271, -5737, -5200, -4656, -4102, -3533, -2949, -2361, -1788, -1233, -715, -238};