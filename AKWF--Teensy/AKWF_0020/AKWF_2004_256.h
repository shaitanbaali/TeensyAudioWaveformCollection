/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2004 256 samples */
 
const int16_t AKWF_2004_256_DATA [256] = 
{429, 1583, 2694, 3791, 4871, 5936, 6986, 8018, 9038, 10045, 11034, 12013, 12982, 13936, 14881, 15815, 16736, 17651, 18555, 19446, 20329, 21208, 22088, 22968, 23841, 24703, 25553, 26381, 27182, 27955, 28690, 29382, 30027, 30616, 31146, 31612, 32005, 32321, 32558, 32707, 32767, 32732, 32600, 32366, 32029, 31589, 31038, 30369, 29582, 28680, 27671, 26567, 25368, 24088, 22738, 21322, 19856, 18349, 16807, 15249, 13682, 12112, 10559, 9029, 7529, 6075, 4674, 3332, 2064, 872, -237, -1252, -2182, -3038, -3818, -4529, -5169, -5740, -6246, -6690, -7074, -7403, -7681, -7910, -8096, -8244, -8356, -8439, -8496, -8533, -8553, -8561, -8561, -8557, -8553, -8552, -8557, -8570, -8576, -8565, -8538, -8498, -8444, -8380, -8305, -8221, -8130, -8032, -7930, -7824, -7716, -7608, -7500, -7394, -7290, -7190, -7095, -7005, -6922, -6847, -6779, -6719, -6665, -6626, -6614, -6628, -6666, -6724, -6799, -6886, -6983, -7083, -7183, -7277, -7360, -7428, -7476, -7497, -7489, -7446, -7363, -7237, -7063, -6838, -6558, -6221, -5824, -5366, -4844, -4251, -3582, -2838, -2031, -1166, -246, 715, 1711, 2735, 3773, 4817, 5861, 6889, 7894, 8868, 9796, 10672, 11487, 12228, 12892, 13467, 13946, 14323, 14592, 14747, 14786, 14723, 14567, 14316, 13975, 13545, 13028, 12431, 11757, 11007, 10189, 9307, 8366, 7371, 6329, 5241, 4118, 2963, 1780, 579, -636, -1865, -3095, -4325, -5554, -6767, -7986, -9237, -10511, -11809, -13124, -14443, -15768, -17088, -18392, -19680, -20940, -22163, -23346, -24478, -25551, -26561, -27498, -28356, -29129, -29811, -30396, -30878, -31252, -31515, -31663, -31694, -31603, -31391, -31062, -30619, -30065, -29409, -28656, -27809, -26881, -25872, -24792, -23653, -22456, -21213, -19933, -18620, -17283, -15935, -14575, -13216, -11867, -10527, -9208, -7917, -6653, -5421, -4208, -3009, -1830, -644};