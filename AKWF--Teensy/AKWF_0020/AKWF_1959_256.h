/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1959 256 samples */
 
const int16_t AKWF_1959_256_DATA [256] = 
{1916, 5191, 8076, 10604, 12732, 14459, 15796, 16777, 17458, 17903, 18180, 18357, 18501, 18666, 18892, 19207, 19619, 20128, 20716, 21356, 22021, 22674, 23284, 23826, 24281, 24637, 24895, 25065, 25162, 25208, 25228, 25246, 25287, 25365, 25493, 25674, 25905, 26175, 26470, 26770, 27054, 27307, 27509, 27650, 27727, 27739, 27693, 27601, 27479, 27343, 27211, 27097, 27013, 26966, 26956, 26982, 27035, 27103, 27172, 27229, 27264, 27265, 27229, 27154, 27049, 26920, 26782, 26650, 26540, 26464, 26435, 26460, 26537, 26665, 26832, 27023, 27222, 27410, 27567, 27680, 27734, 27725, 27654, 27528, 27357, 27161, 26960, 26774, 26624, 26526, 26491, 26522, 26617, 26767, 26951, 27152, 27345, 27503, 27604, 27632, 27574, 27428, 27201, 26907, 26569, 26218, 25883, 25599, 25395, 25295, 25314, 25457, 25717, 26072, 26490, 26927, 27335, 27658, 27837, 27821, 27560, 27020, 26170, 25004, 23522, 21738, 19690, 17416, 14963, 12396, 9767, 7130, 4552, 2066, -286, -2467, -4469, -6280, -7894, -9324, -10584, -11690, -12666, -13534, -14315, -15032, -15703, -16344, -16971, -17592, -18216, -18850, -19496, -20154, -20825, -21506, -22191, -22876, -23552, -24212, -24850, -25452, -26012, -26524, -26980, -27380, -27721, -28005, -28240, -28435, -28598, -28744, -28886, -29034, -29198, -29389, -29607, -29854, -30123, -30408, -30695, -30971, -31221, -31429, -31585, -31679, -31708, -31675, -31586, -31455, -31298, -31135, -30987, -30874, -30813, -30816, -30889, -31033, -31238, -31490, -31770, -32056, -32319, -32537, -32691, -32763, -32749, -32645, -32461, -32216, -31932, -31637, -31360, -31127, -30964, -30887, -30903, -31009, -31194, -31435, -31700, -31956, -32164, -32289, -32300, -32178, -31912, -31505, -30977, -30354, -29677, -28995, -28357, -27811, -27399, -27152, -27084, -27191, -27450, -27817, -28233, -28623, -28906, -28993, -28799, -28252, -27293, -25880, -24001, -21671, -18915, -15808, -12427, -8866, -5243, -1589};