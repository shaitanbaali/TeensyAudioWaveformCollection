/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1920 256 samples */
 
const int16_t AKWF_1920_256_DATA [256] = 
{581, 2063, 3551, 5055, 6550, 8018, 9439, 10781, 12049, 13211, 14252, 15162, 15926, 16527, 16958, 17226, 17346, 17341, 17229, 17034, 16779, 16487, 16182, 15884, 15610, 15376, 15196, 15086, 15034, 15017, 15007, 14976, 14893, 14723, 14438, 14005, 13397, 12585, 11552, 10285, 8775, 7011, 5043, 2895, 617, -1735, -4121, -6503, -8810, -11009, -13034, -14867, -16464, -17805, -18918, -19818, -20512, -21013, -21332, -21484, -21487, -21362, -21127, -20800, -20399, -19940, -19439, -18883, -18258, -17564, -16802, -15971, -15076, -14105, -13064, -11950, -10762, -9509, -8184, -6788, -5325, -3771, -2140, -471, 1243, 2962, 4661, 6320, 7904, 9386, 10763, 11997, 13075, 13986, 14714, 15275, 15680, 15940, 16073, 16101, 16044, 15925, 15764, 15584, 15408, 15252, 15135, 15055, 14994, 14950, 14919, 14902, 14899, 14904, 14917, 14933, 14949, 14961, 14968, 14965, 14952, 14935, 14921, 14910, 14900, 14894, 14887, 14882, 14878, 14875, 14871, 14866, 14860, 14852, 14839, 14805, 14756, 14695, 14628, 14564, 14506, 14464, 14439, 14442, 14475, 14542, 14645, 14785, 14985, 15248, 15550, 15871, 16181, 16452, 16660, 16773, 16763, 16604, 16275, 15753, 15017, 14073, 12938, 11625, 10153, 8518, 6746, 4860, 2870, 813, -1298, -3456, -5630, -7790, -9941, -12119, -14358, -16622, -18872, -21071, -23183, -25171, -27006, -28650, -30067, -31225, -32108, -32675, -32773, -32761, -32445, -31735, -30805, -29688, -28444, -27126, -25798, -24520, -23325, -22276, -21403, -20744, -20319, -20105, -20069, -20167, -20350, -20559, -20741, -20834, -20785, -20538, -20050, -19279, -18196, -16757, -14957, -12851, -10513, -7998, -5409, -2823, -341, 1941, 3950, 5609, 6838, 7585, 7801, 7488, 6680, 5440, 3837, 1951, -120, -2287, -4471, -6558, -8473, -10125, -11433, -12350, -12891, -13118, -13049, -12701, -12104, -11278, -10261, -9092, -7798, -6434, -5021, -3592, -2191, -791};