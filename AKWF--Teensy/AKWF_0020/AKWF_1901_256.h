/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1901 256 samples */
 
const int16_t AKWF_1901_256_DATA [256] = 
{3641, 9286, 14895, 20212, 24865, 28616, 31536, 32821, 32746, 32761, 32760, 32750, 32758, 32682, 31487, 29585, 27390, 24951, 22399, 19853, 17421, 15205, 13264, 11588, 10173, 9007, 8074, 7339, 6781, 6363, 6065, 5934, 5979, 6161, 6440, 6765, 7096, 7386, 7605, 7739, 7795, 7782, 7720, 7627, 7523, 7428, 7362, 7327, 7307, 7297, 7298, 7303, 7314, 7323, 7328, 7330, 7329, 7328, 7326, 7323, 7319, 7317, 7314, 7312, 7310, 7308, 7306, 7304, 7302, 7301, 7299, 7297, 7295, 7293, 7291, 7289, 7287, 7285, 7283, 7281, 7279, 7277, 7275, 7273, 7271, 7269, 7267, 7266, 7263, 7261, 7258, 7253, 7251, 7248, 7247, 7247, 7248, 7256, 7271, 7287, 7300, 7306, 7300, 7279, 7237, 7160, 7032, 6875, 6722, 6604, 6553, 6593, 6744, 7023, 7428, 7911, 8419, 8884, 9234, 9411, 9347, 9013, 8483, 7771, 6812, 5549, 3939, 1937, -487, -3321, -6686, -10531, -14662, -18892, -22980, -26713, -29948, -32346, -32763, -32692, -32707, -32702, -32681, -32747, -32122, -30386, -28436, -26138, -23555, -20825, -18085, -15426, -13003, -10921, -9253, -8029, -7205, -6725, -6519, -6505, -6595, -6710, -6780, -6831, -6907, -6992, -7081, -7170, -7257, -7337, -7410, -7465, -7489, -7485, -7458, -7417, -7371, -7328, -7298, -7280, -7269, -7263, -7261, -7262, -7265, -7269, -7271, -7270, -7268, -7268, -7266, -7262, -7261, -7258, -7256, -7254, -7252, -7250, -7248, -7246, -7243, -7242, -7240, -7237, -7236, -7234, -7232, -7230, -7228, -7226, -7224, -7222, -7221, -7218, -7216, -7214, -7212, -7211, -7208, -7206, -7205, -7201, -7198, -7194, -7190, -7188, -7186, -7187, -7189, -7198, -7219, -7241, -7261, -7274, -7269, -7242, -7192, -7084, -6861, -6571, -6282, -6058, -5965, -6061, -6382, -6992, -8015, -9323, -10665, -11792, -12434, -12336, -11294, -9146, -5816, -1337};