/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1935 256 samples */
 
const int16_t AKWF_1935_256_DATA [256] = 
{843, 3683, 6436, 9149, 11790, 14344, 16792, 19107, 21283, 23301, 25144, 26806, 28275, 29541, 30602, 31453, 32090, 32517, 32736, 32749, 32565, 32193, 31642, 30923, 30049, 29038, 27900, 26656, 25324, 23917, 22457, 20962, 19446, 17933, 16438, 14973, 13561, 12212, 10940, 9760, 8681, 7709, 6859, 6129, 5529, 5060, 4721, 4513, 4433, 4476, 4637, 4909, 5284, 5751, 6299, 6918, 7594, 8313, 9065, 9833, 10603, 11365, 12099, 12795, 13442, 14024, 14531, 14954, 15280, 15504, 15616, 15612, 15484, 15233, 14854, 14346, 13710, 12950, 12065, 11061, 9947, 8724, 7403, 5994, 4501, 2938, 1319, -353, -2060, -3789, -5535, -7280, -9011, -10723, -12396, -14020, -15589, -17086, -18504, -19835, -21067, -22193, -23209, -24102, -24870, -25511, -26016, -26385, -26616, -26706, -26656, -26466, -26138, -25673, -25075, -24349, -23497, -22524, -21440, -20246, -18952, -17567, -16095, -14547, -12935, -11261, -9542, -7786, -5998, -4197, -2388, -580, 1209, 2975, 4709, 6391, 8021, 9586, 11072, 12477, 13789, 14996, 16097, 17082, 17943, 18679, 19281, 19746, 20073, 20259, 20302, 20204, 19964, 19586, 19070, 18423, 17650, 16754, 15746, 14633, 13420, 12124, 10751, 9308, 7816, 6282, 4715, 3136, 1552, -25, -1574, -3093, -4566, -5976, -7318, -8581, -9752, -10828, -11797, -12652, -13391, -14011, -14504, -14875, -15121, -15245, -15250, -15140, -14922, -14602, -14190, -13694, -13126, -12498, -11820, -11107, -10373, -9630, -8893, -8177, -7496, -6861, -6288, -5788, -5371, -5052, -4835, -4732, -4748, -4890, -5160, -5559, -6090, -6749, -7533, -8439, -9458, -10581, -11803, -13106, -14478, -15911, -17381, -18876, -20384, -21877, -23342, -24764, -26118, -27391, -28565, -29620, -30542, -31318, -31929, -32368, -32621, -32679, -32536, -32185, -31623, -30849, -29864, -28674, -27277, -25683, -23906, -21948, -19828, -17563, -15159, -12642, -10032, -7342, -4604, -1771};