/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1966 256 samples */
 
const int16_t AKWF_1966_256_DATA [256] = 
{169, 306, 440, 574, 710, 844, 978, 1113, 1248, 1383, 1526, 1671, 1816, 1962, 2108, 2252, 2397, 2559, 2634, 3385, 5232, 7068, 8899, 10738, 12575, 14409, 16244, 18092, 19870, 20808, 21441, 22127, 22802, 23476, 24152, 24828, 25498, 26196, 26687, 26859, 27049, 27239, 27425, 27611, 27799, 27986, 28173, 28364, 28606, 28865, 29120, 29377, 29633, 29889, 30144, 30398, 30669, 30788, 30706, 30631, 30557, 30480, 30405, 30330, 30255, 30181, 30100, 29975, 29838, 29703, 29567, 29431, 29295, 29159, 29022, 28895, 28657, 28277, 27906, 27534, 27162, 26790, 26418, 26045, 25675, 25296, 24844, 24377, 23913, 23450, 22984, 22520, 22056, 21590, 21132, 20600, 19986, 19380, 18773, 18164, 17557, 16949, 16339, 15734, 15117, 14438, 13747, 13057, 12368, 11679, 10988, 10298, 9609, 8921, 8203, 7458, 6713, 5968, 5225, 4481, 3736, 2992, 2247, 1500, 736, -31, -798, -1563, -2331, -3098, -3864, -4631, -5398, -6158, -6911, -7663, -8417, -9171, -9923, -10676, -11430, -12184, -12927, -13622, -14307, -14996, -15684, -16371, -17060, -17748, -18433, -19125, -19752, -20323, -20902, -21480, -22055, -22633, -23211, -23787, -24368, -24923, -25377, -25820, -26265, -26710, -27154, -27598, -28043, -28486, -28936, -29287, -29565, -29852, -30138, -30425, -30710, -30997, -31281, -31572, -31822, -31935, -32034, -32137, -32238, -32340, -32442, -32543, -32643, -32747, -32742, -32663, -32593, -32521, -32449, -32377, -32305, -32232, -32166, -32055, -31812, -31556, -31305, -31052, -30800, -30547, -30295, -30041, -29794, -29413, -28951, -28503, -28051, -27600, -27149, -26697, -26243, -25802, -25301, -24657, -24006, -23356, -22706, -22056, -21405, -20755, -20105, -19454, -18692, -17869, -17052, -16236, -15419, -14601, -13785, -12968, -12146, -11352, -10615, -9879, -9145, -8409, -7674, -6940, -6204, -5468, -4734, -4167, -3686, -3191, -2697, -2205, -1714, -1221, -732, -230};