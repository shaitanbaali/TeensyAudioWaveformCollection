/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1913 256 samples */
 
const int16_t AKWF_1913_256_DATA [256] = 
{1309, 4297, 7209, 10034, 12736, 15278, 17611, 19703, 21599, 23303, 24833, 26192, 27386, 28424, 29323, 30095, 30761, 31332, 31822, 32245, 32622, 32775, 32755, 32753, 32746, 32740, 32733, 32723, 32723, 32613, 32406, 32211, 32028, 31868, 31739, 31639, 31565, 31518, 31494, 31491, 31503, 31529, 31562, 31597, 31632, 31660, 31677, 31682, 31679, 31674, 31669, 31664, 31658, 31651, 31643, 31635, 31625, 31614, 31602, 31590, 31576, 31560, 31530, 31486, 31432, 31374, 31316, 31263, 31222, 31197, 31194, 31215, 31265, 31345, 31456, 31604, 31784, 31987, 32208, 32305, 32288, 32281, 32273, 32264, 32256, 32247, 32236, 32241, 32008, 31521, 30986, 30371, 29655, 28822, 27859, 26746, 25472, 24022, 22373, 20522, 18472, 16210, 13706, 10924, 7915, 4727, 1456, -1881, -5208, -8440, -11525, -14395, -16973, -19239, -21193, -22317, -22340, -22334, -22337, -22336, -22333, -22330, -22328, -22325, -22316, -22335, -22150, -21707, -21400, -21181, -21018, -20911, -20858, -20851, -20882, -20942, -21023, -21112, -21198, -21274, -21328, -21354, -21353, -21349, -21344, -21339, -21334, -21329, -21322, -21317, -21311, -21304, -21298, -21292, -21286, -21281, -21275, -21269, -21264, -21259, -21253, -21247, -21242, -21236, -21230, -21224, -21219, -21213, -21207, -21201, -21196, -21191, -21185, -21179, -21174, -21168, -21162, -21156, -21151, -21145, -21140, -21134, -21128, -21122, -21116, -21112, -21106, -21100, -21094, -21088, -21083, -21077, -21072, -21066, -21061, -21055, -21049, -21044, -21038, -21034, -21029, -21023, -21018, -21013, -21007, -21001, -20995, -20990, -20983, -20975, -20963, -20946, -20926, -20904, -20882, -20862, -20844, -20831, -20825, -20828, -20839, -20861, -20895, -20932, -20964, -20992, -21016, -21035, -21051, -21066, -21078, -21089, -21097, -21104, -21104, -21097, -21084, -21104, -21160, -21223, -21267, -21264, -21178, -20977, -20631, -20107, -19379, -18418, -17216, -15742, -13981, -11932, -9622, -7102, -4411, -1517};