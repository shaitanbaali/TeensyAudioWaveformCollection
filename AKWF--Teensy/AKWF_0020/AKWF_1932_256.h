/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1932 256 samples */
 
const int16_t AKWF_1932_256_DATA [256] = 
{1752, 4448, 7060, 9633, 12138, 14565, 16896, 19107, 21191, 23136, 24920, 26542, 27990, 29251, 30325, 31207, 31889, 32378, 32670, 32769, 32679, 32407, 31962, 31350, 30584, 29677, 28640, 27489, 26240, 24906, 23506, 22057, 20572, 19075, 17578, 16097, 14653, 13255, 11920, 10664, 9496, 8427, 7470, 6627, 5909, 5321, 4863, 4539, 4347, 4286, 4351, 4538, 4840, 5248, 5751, 6342, 7005, 7728, 8499, 9300, 10120, 10942, 11750, 12529, 13267, 13945, 14551, 15074, 15499, 15817, 16017, 16090, 16031, 15832, 15493, 15008, 14377, 13603, 12687, 11635, 10455, 9149, 7730, 6212, 4601, 2913, 1165, -634, -2464, -4307, -6153, -7978, -9766, -11506, -13175, -14756, -16242, -17609, -18848, -19948, -20893, -21677, -22291, -22725, -22978, -23044, -22923, -22612, -22115, -21437, -20577, -19546, -18356, -17007, -15517, -13900, -12161, -10323, -8401, -6404, -4356, -2274, -169, 1933, 4019, 6075, 8076, 10009, 11863, 13615, 15254, 16772, 18148, 19378, 20452, 21358, 22094, 22653, 23031, 23228, 23241, 23073, 22727, 22205, 21516, 20661, 19653, 18501, 17212, 15799, 14279, 12654, 10946, 9170, 7332, 5454, 3552, 1631, -281, -2178, -4049, -5871, -7637, -9337, -10950, -12474, -13898, -15209, -16404, -17474, -18412, -19219, -19889, -20419, -20810, -21064, -21181, -21164, -21019, -20751, -20366, -19871, -19276, -18588, -17817, -16978, -16076, -15126, -14142, -13131, -12110, -11091, -10082, -9102, -8160, -7265, -6433, -5672, -4991, -4401, -3910, -3525, -3252, -3096, -3061, -3151, -3367, -3710, -4176, -4768, -5480, -6305, -7242, -8280, -9410, -10629, -11920, -13271, -14677, -16120, -17585, -19064, -20535, -21987, -23409, -24777, -26083, -27312, -28446, -29474, -30384, -31159, -31792, -32273, -32590, -32737, -32706, -32493, -32094, -31506, -30732, -29767, -28617, -27289, -25783, -24109, -22281, -20299, -18182, -15946, -13593, -11150, -8631, -6049, -3431, -733};