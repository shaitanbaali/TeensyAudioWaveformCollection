/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1933 256 samples */
 
const int16_t AKWF_1933_256_DATA [256] = 
{794, 2278, 3559, 4827, 6098, 7369, 8642, 9912, 11185, 12458, 13728, 15000, 16273, 17543, 18815, 20088, 21358, 22631, 23904, 25173, 26446, 27718, 28978, 30278, 31431, 30798, 29556, 28416, 27257, 26095, 24935, 23776, 22614, 21455, 20295, 19133, 17974, 16815, 15652, 14493, 13333, 12172, 11013, 9853, 8691, 7534, 6383, 5174, 4955, 5533, 6014, 6512, 7012, 7511, 8009, 8509, 9007, 9506, 10005, 10504, 11003, 11503, 12001, 12500, 13000, 13499, 13997, 14496, 14995, 15476, 16050, 15956, 14730, 13509, 12293, 11072, 9849, 8630, 7408, 6186, 4967, 3745, 2522, 1304, 82, -1140, -2359, -3581, -4803, -6022, -7245, -8466, -9680, -10921, -12043, -12610, -13103, -13610, -14114, -14619, -15122, -15626, -16131, -16634, -17139, -17644, -18147, -18650, -19156, -19659, -20163, -20668, -21171, -21676, -22181, -22676, -23193, -23646, -22597, -20870, -19245, -17603, -15956, -14312, -12670, -11023, -9380, -7737, -6090, -4447, -2804, -1157, 485, 2128, 3775, 5416, 7061, 8708, 10349, 11975, 13709, 14414, 14098, 13896, 13675, 13452, 13228, 13006, 12783, 12560, 12337, 12115, 11891, 11670, 11447, 11224, 11001, 10779, 10555, 10334, 10110, 9888, 9657, 9467, 9000, 7937, 6850, 5773, 4692, 3609, 2529, 1447, 364, -715, -1798, -2881, -3960, -5043, -6124, -7204, -8287, -9369, -10449, -11532, -12614, -13685, -14797, -15745, -15484, -14992, -14549, -14096, -13641, -13189, -12735, -12281, -11828, -11375, -10921, -10467, -10014, -9560, -9107, -8653, -8198, -7746, -7292, -6838, -6389, -5934, -5483, -6111, -7360, -8526, -9705, -10888, -12069, -13248, -14431, -15612, -16792, -17974, -19155, -20335, -21517, -22697, -23878, -25061, -26240, -27420, -28603, -29782, -30935, -32249, -32252, -30654, -29171, -27673, -26170, -24666, -23167, -21664, -20161, -18661, -17157, -15655, -14155, -12651, -11148, -9648, -8144, -6642, -5142, -3640, -2143, -615};