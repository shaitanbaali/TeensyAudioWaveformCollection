/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1965 256 samples */
 
const int16_t AKWF_1965_256_DATA [256] = 
{1992, 6022, 9972, 13902, 17967, 21361, 21274, 20457, 19780, 19071, 18365, 17656, 16949, 16252, 15500, 15463, 16142, 16759, 17387, 18014, 18642, 19271, 19871, 20597, 20686, 17492, 13768, 10164, 6538, 2903, -724, -4349, -7944, -11757, -13084, -12240, -11636, -10989, -10340, -9693, -9045, -8369, -7826, -6603, -2688, 1611, 5840, 10090, 14328, 18578, 22816, 27016, 31459, 31139, 26928, 23106, 19220, 15336, 11442, 7553, 3689, -285, -3686, -4983, -6038, -7147, -8242, -9340, -10434, -11526, -12580, -13887, -11789, -7247, -3063, 1192, 5449, 9696, 13952, 18152, 22626, 25594, 23805, 21586, 19462, 17311, 15165, 13012, 10859, 8711, 6573, 3667, 249, -3117, -6486, -9855, -13232, -16603, -19909, -23538, -25213, -21384, -17121, -12975, -8792, -4607, -432, 3744, 7914, 12167, 13615, 13387, 13410, 13388, 13367, 13344, 13323, 13253, 13434, 12206, 7385, 2433, -2489, -7420, -12346, -17284, -22195, -27134, -32049, -31131, -27065, -23419, -19703, -15981, -12255, -8537, -4826, -1053, 2312, 4795, 7243, 9696, 12150, 14605, 17052, 19487, 21953, 24354, 21413, 15842, 10701, 5466, 239, -4981, -10216, -15345, -20990, -23618, -19873, -16205, -12543, -8870, -5196, -1516, 2150, 5835, 9483, 11951, 13921, 15968, 17995, 20026, 22058, 24086, 26052, 28363, 28122, 23315, 18473, 13666, 8829, 3995, -829, -5647, -10516, -15159, -15977, -15251, -14786, -14269, -13753, -13238, -12720, -12167, -11817, -10090, -6022, -2047, 1942, 5927, 9917, 13913, 17867, 21932, 25615, 23480, 19404, 15661, 11861, 8052, 4242, 443, -3337, -7280, -9847, -10420, -11042, -11659, -12273, -12886, -13498, -14091, -14759, -15085, -12171, -8221, -4454, -643, 3158, 6963, 10772, 14502, 18630, 19485, 15820, 12418, 8979, 5541, 2094, -1353, -4776, -8267, -11521, -12403, -12702, -13114, -13504, -13894, -14283, -14672, -15020, -15599, -14058, -9983, -6058, -2032};