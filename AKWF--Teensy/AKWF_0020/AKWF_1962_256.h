/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1962 256 samples */
 
const int16_t AKWF_1962_256_DATA [256] = 
{402, 1422, 2369, 3266, 4106, 4894, 5637, 6339, 7013, 7669, 8311, 8951, 9594, 10241, 10895, 11555, 12215, 12874, 13523, 14154, 14767, 15354, 15910, 16438, 16938, 17411, 17865, 18306, 18737, 19170, 19606, 20051, 20511, 20984, 21469, 21966, 22466, 22967, 23462, 23941, 24404, 24845, 25259, 25649, 26017, 26363, 26696, 27023, 27348, 27681, 28026, 28388, 28771, 29174, 29593, 30024, 30459, 30887, 31299, 31679, 32018, 32305, 32528, 32681, 32758, 32758, 32681, 32528, 32306, 32020, 31681, 31298, 30878, 30431, 29967, 29491, 29009, 28529, 28050, 27575, 27108, 26646, 26192, 25743, 25298, 24858, 24424, 23993, 23566, 23143, 22720, 22299, 21881, 21459, 21035, 20607, 20170, 19725, 19270, 18802, 18324, 17831, 17327, 16815, 16295, 15769, 15243, 14716, 14193, 13675, 13161, 12651, 12147, 11639, 11129, 10612, 10079, 9527, 8950, 8341, 7699, 7022, 6302, 5547, 4753, 3922, 3062, 2179, 1272, 355, -570, -1498, -2418, -3328, -4226, -5102, -5957, -6789, -7594, -8373, -9125, -9845, -10541, -11209, -11849, -12464, -13054, -13621, -14170, -14700, -15214, -15717, -16211, -16699, -17186, -17672, -18161, -18654, -19151, -19649, -20152, -20654, -21153, -21648, -22132, -22604, -23064, -23506, -23931, -24340, -24731, -25110, -25479, -25840, -26198, -26559, -26924, -27298, -27683, -28077, -28484, -28901, -29322, -29745, -30164, -30569, -30959, -31322, -31653, -31944, -32189, -32383, -32520, -32598, -32615, -32568, -32458, -32287, -32056, -31768, -31427, -31038, -30609, -30143, -29649, -29135, -28606, -28072, -27541, -27019, -26512, -26026, -25561, -25121, -24706, -24312, -23936, -23573, -23216, -22858, -22490, -22106, -21702, -21271, -20811, -20323, -19809, -19272, -18719, -18158, -17597, -17046, -16510, -15998, -15514, -15058, -14629, -14223, -13831, -13443, -13045, -12623, -12164, -11655, -11083, -10439, -9719, -8918, -8041, -7095, -6086, -5033, -3949, -2851, -1757, -661};