/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1974 256 samples */
 
const int16_t AKWF_1974_256_DATA [256] = 
{3573, 8878, 14257, 17990, 19523, 21181, 22827, 24462, 26102, 27742, 29366, 31042, 32515, 32006, 31033, 30155, 29260, 28362, 27465, 26570, 25680, 24752, 24158, 23947, 23710, 23479, 23247, 23014, 22783, 22549, 22323, 22060, 21568, 21023, 20488, 19949, 19414, 18877, 18339, 17803, 17261, 16784, 16380, 15969, 15559, 15150, 14740, 14331, 13922, 13514, 13101, 12665, 12225, 11785, 11347, 10906, 10467, 10029, 9588, 9150, 8700, 8237, 7777, 7316, 6854, 6393, 5933, 5471, 5010, 4557, 4154, 3759, 3364, 2966, 2571, 2175, 1778, 1384, 979, 740, 648, 541, 438, 335, 231, 127, 25, -82, -165, -148, -117, -89, -59, -31, -2, 26, 54, 85, 87, 69, 53, 38, 21, 5, -9, -26, -42, -54, -47, -36, -27, -18, -9, 1, 10, 18, 29, 29, 21, 16, 10, 4, -1, -6, -12, -18, -22, -18, -13, -8, -4, 0, 5, 9, 13, 19, 17, 11, 6, 0, -5, -11, -16, -22, -28, -29, -21, -13, -5, 4, 12, 21, 29, 38, 46, 41, 25, 12, -2, -15, -30, -44, -58, -73, -78, -55, -30, -8, 16, 41, 64, 88, 112, 136, 90, 6, -71, -151, -231, -309, -388, -471, -536, -697, -1082, -1467, -1852, -2237, -2623, -3008, -3393, -3777, -4165, -4599, -5056, -5511, -5966, -6420, -6876, -7330, -7786, -8241, -8694, -9147, -9600, -10053, -10506, -10957, -11410, -11863, -12315, -12766, -13174, -13561, -13951, -14342, -14732, -15120, -15510, -15903, -16284, -16729, -17293, -17855, -18418, -18977, -19539, -20103, -20662, -21226, -21778, -22069, -22261, -22471, -22677, -22884, -23089, -23295, -23508, -23685, -24147, -25066, -25980, -26892, -27807, -28721, -29634, -30524, -31501, -32095, -28220, -22755, -17566, -12322, -7092, -1754};