/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2010 256 samples */
 
const int16_t AKWF_2010_256_DATA [256] = 
{349, 922, 1499, 2094, 2701, 3322, 3957, 4601, 5256, 5921, 6593, 7275, 7968, 8677, 9401, 10138, 10883, 11641, 12405, 13173, 13946, 14720, 15492, 16262, 17026, 17783, 18531, 19265, 19985, 20691, 21376, 22041, 22685, 23303, 23895, 24461, 24995, 25503, 25993, 26466, 26921, 27355, 27765, 28153, 28515, 28847, 29150, 29421, 29656, 29857, 30019, 30140, 30220, 30257, 30248, 30194, 30092, 29941, 29740, 29489, 29188, 28834, 28431, 27968, 27436, 26841, 26186, 25474, 24713, 23906, 23060, 22183, 21278, 20353, 19415, 18471, 17525, 16588, 15664, 14759, 13883, 13037, 12229, 11468, 10752, 10090, 9488, 8944, 8464, 8045, 7680, 7369, 7110, 6901, 6738, 6617, 6535, 6489, 6473, 6483, 6516, 6565, 6627, 6697, 6770, 6841, 6905, 6958, 6997, 7016, 7011, 6979, 6917, 6820, 6698, 6567, 6427, 6276, 6112, 5933, 5738, 5525, 5291, 5034, 4754, 4446, 4112, 3747, 3350, 2921, 2457, 1956, 1420, 845, 229, -424, -1119, -1856, -2630, -3448, -4317, -5239, -6214, -7237, -8299, -9402, -10537, -11695, -12877, -14073, -15274, -16480, -17680, -18866, -20037, -21182, -22294, -23373, -24404, -25388, -26319, -27188, -27993, -28732, -29396, -29990, -30524, -30999, -31418, -31778, -32080, -32327, -32519, -32654, -32737, -32768, -32749, -32680, -32564, -32404, -32200, -31954, -31670, -31347, -30989, -30600, -30178, -29727, -29251, -28747, -28221, -27662, -27053, -26402, -25711, -24981, -24220, -23430, -22614, -21782, -20934, -20074, -19212, -18348, -17488, -16641, -15806, -14988, -14198, -13433, -12701, -12006, -11348, -10733, -10165, -9643, -9171, -8752, -8381, -8059, -7785, -7552, -7360, -7204, -7081, -6986, -6916, -6866, -6832, -6809, -6792, -6777, -6758, -6733, -6696, -6642, -6568, -6469, -6343, -6185, -5994, -5765, -5503, -5220, -4915, -4588, -4240, -3869, -3478, -3066, -2632, -2178, -1705, -1212, -701, -161};