/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1941 256 samples */
 
const int16_t AKWF_1941_256_DATA [256] = 
{767, 3487, 6129, 8738, 11284, 13756, 16137, 18399, 20540, 22542, 24386, 26069, 27578, 28900, 30037, 30978, 31719, 32264, 32610, 32760, 32719, 32493, 32088, 31514, 30783, 29906, 28894, 27766, 26534, 25212, 23823, 22380, 20897, 19398, 17897, 16407, 14952, 13540, 12189, 10915, 9727, 8636, 7656, 6790, 6046, 5433, 4949, 4599, 4383, 4296, 4339, 4503, 4783, 5171, 5656, 6230, 6879, 7589, 8350, 9145, 9958, 10778, 11586, 12369, 13112, 13799, 14416, 14954, 15396, 15732, 15955, 16053, 16020, 15851, 15541, 15088, 14491, 13752, 12873, 11856, 10712, 9444, 8061, 6579, 5001, 3345, 1628, -143, -1948, -3768, -5596, -7406, -9183, -10917, -12584, -14170, -15663, -17045, -18302, -19426, -20402, -21220, -21874, -22354, -22657, -22778, -22714, -22466, -22034, -21423, -20634, -19674, -18555, -17279, -15860, -14314, -12645, -10872, -9014, -7075, -5082, -3048, -986, 1081, 3137, 5172, 7159, 9087, 10944, 12708, 14368, 15915, 17329, 18605, 19733, 20700, 21505, 22139, 22599, 22882, 22987, 22915, 22666, 22244, 21655, 20902, 19993, 18939, 17744, 16422, 14986, 13442, 11807, 10096, 8316, 6488, 4624, 2734, 840, -1048, -2920, -4754, -6542, -8273, -9930, -11505, -12991, -14370, -15642, -16797, -17824, -18725, -19494, -20125, -20621, -20980, -21200, -21287, -21243, -21072, -20779, -20371, -19857, -19241, -18537, -17754, -16899, -15988, -15030, -14036, -13023, -11999, -10977, -9972, -8996, -8057, -7173, -6351, -5602, -4937, -4364, -3892, -3530, -3280, -3151, -3145, -3266, -3513, -3889, -4391, -5018, -5764, -6627, -7598, -8669, -9836, -11085, -12403, -13785, -15213, -16673, -18157, -19643, -21119, -22573, -23984, -25339, -26626, -27824, -28922, -29909, -30766, -31486, -32056, -32462, -32702, -32764, -32644, -32336, -31837, -31148, -30267, -29195, -27941, -26502, -24889, -23116, -21182, -19106, -16904, -14577, -12152, -9645, -7066, -4445, -1735};