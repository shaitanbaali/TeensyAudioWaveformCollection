/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1910 256 samples */
 
const int16_t AKWF_1910_256_DATA [256] = 
{905, 3964, 6931, 9806, 12566, 15149, 17520, 19647, 21567, 23302, 24857, 26236, 27447, 28501, 29410, 30196, 30869, 31449, 31945, 32380, 32720, 32770, 32754, 32751, 32744, 32737, 32731, 32723, 32719, 32692, 32516, 32309, 32125, 31965, 31835, 31734, 31660, 31613, 31590, 31587, 31602, 31628, 31662, 31698, 31734, 31761, 31780, 31784, 31780, 31776, 31769, 31763, 31755, 31747, 31738, 31728, 31718, 31707, 31697, 31686, 31675, 31664, 31647, 31623, 31597, 31567, 31538, 31512, 31491, 31476, 31469, 31474, 31489, 31518, 31560, 31602, 31636, 31662, 31683, 31699, 31712, 31724, 31736, 31747, 31758, 31767, 31775, 31772, 31779, 31852, 31974, 32116, 32186, 32176, 32158, 31934, 31473, 30767, 29769, 28440, 26778, 24737, 22274, 19402, 16169, 12644, 8935, 5065, 1155, -2697, -6429, -9925, -13124, -15975, -18397, -20361, -21930, -23060, -23303, -23268, -23276, -23275, -23272, -23268, -23265, -23267, -23068, -22773, -22602, -22487, -22396, -22333, -22297, -22284, -22290, -22312, -22342, -22375, -22404, -22424, -22429, -22413, -22383, -22356, -22337, -22323, -22316, -22312, -22312, -22315, -22319, -22325, -22329, -22331, -22330, -22327, -22322, -22317, -22311, -22305, -22299, -22293, -22287, -22281, -22274, -22268, -22261, -22256, -22250, -22243, -22237, -22232, -22226, -22220, -22214, -22208, -22202, -22196, -22190, -22184, -22178, -22173, -22166, -22160, -22154, -22149, -22143, -22137, -22131, -22125, -22119, -22113, -22107, -22101, -22095, -22089, -22083, -22078, -22072, -22067, -22062, -22056, -22051, -22046, -22040, -22034, -22028, -22022, -22014, -22006, -21994, -21976, -21955, -21933, -21909, -21888, -21870, -21858, -21851, -21855, -21867, -21890, -21924, -21962, -21995, -22023, -22046, -22066, -22083, -22097, -22109, -22120, -22129, -22134, -22135, -22127, -22113, -22136, -22194, -22259, -22302, -22294, -22201, -21991, -21628, -21082, -20332, -19340, -18091, -16574, -14758, -12653, -10297, -7701, -4939, -1977};