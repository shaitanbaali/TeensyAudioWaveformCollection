/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1963 256 samples */
 
const int16_t AKWF_1963_256_DATA [256] = 
{1897, 4906, 7897, 10664, 12477, 14139, 15834, 17519, 19205, 20895, 22572, 24210, 26125, 23818, 17943, 12477, 6953, 1412, -4124, -9650, -15126, -20919, -25144, -22994, -20223, -17604, -14940, -12280, -9624, -6959, -4297, -1655, 1374, 4678, 7953, 11239, 14517, 17798, 21085, 24288, 27871, 29271, 23810, 17574, 11506, 5410, -701, -6814, -12896, -18977, -25230, -25915, -22737, -20051, -17280, -14502, -11726, -8954, -6168, -3418, -505, 2935, 6398, 9852, 13314, 16770, 20227, 23675, 27104, 30727, 28020, 21539, 15565, 9490, 3431, -2639, -8716, -14702, -21075, -25158, -23517, -21502, -19579, -17631, -15677, -13725, -11771, -9818, -7861, -4456, -214, 3908, 8047, 12197, 16339, 20478, 24534, 29070, 30595, 24869, 18963, 13125, 7248, 1389, -4478, -10337, -16197, -22112, -22626, -20561, -18911, -17182, -15458, -13729, -12000, -10252, -8627, -6153, -1958, 2285, 6511, 10737, 14975, 19206, 23402, 27690, 31686, 28636, 22330, 16522, 10619, 4704, -1192, -7095, -12938, -19145, -22648, -20990, -19334, -17700, -16047, -14399, -12747, -11086, -9449, -7763, -4111, 277, 4536, 8819, 13095, 17383, 21665, 25837, 30586, 31392, 25653, 20025, 14403, 8766, 3118, -2520, -8135, -13844, -19189, -20116, -19422, -18989, -18504, -18019, -17535, -17049, -16525, -16208, -14202, -9608, -5090, -559, 3978, 8504, 13044, 17543, 22165, 26258, 23368, 18322, 13681, 8963, 4251, -472, -5187, -9839, -14835, -17350, -16465, -15777, -15062, -14341, -13619, -12899, -12157, -11494, -10482, -6575, -1844, 2732, 7348, 11966, 16571, 21183, 25711, 30716, 30922, 25125, 19633, 14091, 8543, 3002, -2552, -8065, -13714, -18697, -18690, -17446, -16447, -15400, -14352, -13303, -12255, -11167, -10291, -7724, -3216, 1107, 5451, 9807, 14165, 18511, 22808, 27366, 30704, 26810, 21402, 16288, 11102, 5917, 744, -4437, -9558, -15022, -16193, -12963, -10052, -7094, -4136, -1118};