/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1942 256 samples */
 
const int16_t AKWF_1942_256_DATA [256] = 
{812, 2456, 4066, 5682, 7295, 8910, 10528, 12141, 13757, 15374, 16988, 18604, 20222, 21834, 23451, 25069, 26681, 28298, 29887, 31615, 32569, 31476, 30300, 29147, 27986, 26826, 25664, 24503, 23343, 22181, 21021, 19861, 18698, 17538, 16377, 15215, 14056, 12894, 11732, 10573, 9411, 8257, 7073, 6040, 6170, 6629, 7028, 7438, 7849, 8260, 8670, 9080, 9491, 9902, 10312, 10722, 11133, 11543, 11955, 12365, 12775, 13186, 13596, 14007, 14415, 14820, 15260, 14794, 13756, 12790, 11810, 10831, 9852, 8870, 7892, 6913, 5931, 4953, 3973, 2992, 2014, 1034, 55, -924, -1904, -2884, -3863, -4843, -5817, -6821, -7560, -7911, -8278, -8644, -9008, -9373, -9738, -10103, -10467, -10833, -11197, -11562, -11927, -12291, -12656, -13021, -13385, -13751, -14115, -14480, -14845, -15193, -15626, -15598, -14047, -12339, -10660, -8974, -7291, -5605, -3917, -2235, -548, 1137, 2820, 4508, 6192, 7876, 9565, 11249, 12933, 14621, 16304, 17990, 19666, 21373, 22941, 22349, 20983, 19756, 18500, 17248, 15993, 14737, 13486, 12230, 10975, 9722, 8466, 7211, 5959, 4703, 3449, 2197, 940, -313, -1566, -2821, -4070, -5346, -6146, -6559, -7010, -7455, -7898, -8344, -8788, -9232, -9677, -10122, -10565, -11010, -11455, -11898, -12343, -12787, -13231, -13675, -14120, -14564, -15008, -15443, -15929, -16063, -15545, -15042, -14537, -14031, -13526, -13018, -12513, -12008, -11501, -10995, -10489, -9983, -9478, -8972, -8464, -7959, -7453, -6946, -6442, -5935, -5440, -4891, -4625, -5572, -6726, -7843, -8967, -10090, -11215, -12340, -13463, -14589, -15714, -16836, -17963, -19086, -20209, -21336, -22459, -23583, -24709, -25832, -26956, -28076, -29202, -30322, -29827, -28615, -27527, -26415, -25306, -24194, -23082, -21973, -20862, -19750, -18641, -17529, -16417, -15308, -14196, -13085, -11976, -10863, -9753, -8643, -7530, -6416, -5324, -3964, -2337, -697};