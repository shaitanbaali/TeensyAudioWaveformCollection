/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1922 256 samples */
 
const int16_t AKWF_1922_256_DATA [256] = 
{1126, 3574, 5878, 8076, 10141, 12063, 13823, 15422, 16915, 18311, 19597, 20782, 21863, 22837, 23707, 24475, 25139, 25705, 26174, 26547, 26829, 27023, 27129, 27153, 27101, 26974, 26775, 26510, 26183, 25796, 25349, 24800, 24132, 23362, 22496, 21544, 20520, 19435, 18301, 17136, 15947, 14751, 13564, 12396, 11262, 10180, 9155, 8204, 7339, 6569, 5904, 5355, 4925, 4622, 4454, 4419, 4511, 4720, 5040, 5458, 5964, 6547, 7191, 7883, 8613, 9361, 10116, 10862, 11585, 12271, 12909, 13479, 13976, 14385, 14696, 14901, 14990, 14975, 14884, 14721, 14486, 14179, 13802, 13357, 12846, 12271, 11638, 10945, 10199, 9404, 8562, 7679, 6759, 5803, 4820, 3814, 2783, 1741, 686, -374, -1449, -2591, -3804, -5071, -6384, -7728, -9087, -10450, -11802, -13120, -14396, -15610, -16742, -17783, -18714, -19518, -20184, -20698, -21044, -21215, -21199, -20990, -20578, -19958, -19102, -18004, -16684, -15157, -13440, -11561, -9539, -7396, -5167, -2873, -539, 1797, 4117, 6393, 8586, 10682, 12652, 14464, 16107, 17552, 18780, 19779, 20531, 21046, 21349, 21443, 21337, 21040, 20565, 19925, 19132, 18204, 17158, 16004, 14767, 13463, 12106, 10720, 9318, 7917, 6538, 5193, 3898, 2669, 1515, 450, -538, -1497, -2427, -3323, -4185, -5013, -5799, -6549, -7257, -7922, -8547, -9127, -9662, -10155, -10603, -11006, -11367, -11684, -11958, -12190, -12382, -12532, -12646, -12714, -12697, -12590, -12403, -12144, -11822, -11450, -11037, -10596, -10142, -9685, -9239, -8818, -8433, -8098, -7826, -7627, -7513, -7494, -7579, -7777, -8093, -8535, -9106, -9834, -10730, -11774, -12953, -14252, -15648, -17120, -18652, -20212, -21781, -23337, -24848, -26296, -27656, -28898, -30007, -30956, -31724, -32294, -32648, -32769, -32643, -32260, -31620, -30729, -29599, -28246, -26679, -24917, -22984, -20889, -18662, -16325, -13892, -11395, -8859, -6301, -3756, -1188};