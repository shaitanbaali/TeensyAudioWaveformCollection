/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1938 256 samples */
 
const int16_t AKWF_1938_256_DATA [256] = 
{948, 3682, 6337, 8956, 11511, 13990, 16375, 18639, 20778, 22775, 24610, 26281, 27774, 29077, 30191, 31107, 31821, 32337, 32652, 32770, 32697, 32438, 32002, 31397, 30636, 29733, 28696, 27545, 26297, 24961, 23561, 22112, 20627, 19131, 17636, 16156, 14715, 13321, 11990, 10739, 9576, 8511, 7557, 6718, 6001, 5414, 4956, 4628, 4430, 4361, 4416, 4589, 4875, 5264, 5745, 6310, 6946, 7640, 8381, 9151, 9937, 10728, 11505, 12254, 12964, 13618, 14204, 14711, 15125, 15437, 15639, 15721, 15677, 15502, 15194, 14747, 14162, 13443, 12588, 11604, 10497, 9270, 7935, 6504, 4979, 3379, 1719, 4, -1744, -3513, -5291, -7057, -8796, -10499, -12143, -13716, -15206, -16595, -17872, -19028, -20045, -20918, -21639, -22196, -22586, -22804, -22846, -22710, -22395, -21904, -21236, -20398, -19396, -18231, -16915, -15460, -13868, -12154, -10336, -8416, -6415, -4348, -2220, -58, 2126, 4326, 6514, 8680, 10814, 12892, 14905, 16842, 18682, 20420, 22045, 23539, 24898, 26116, 27179, 28087, 28831, 29407, 29816, 30054, 30121, 30019, 29748, 29314, 28720, 27972, 27079, 26044, 24878, 23594, 22194, 20696, 19110, 17444, 15717, 13938, 12117, 10274, 8418, 6559, 4719, 2902, 1121, -604, -2272, -3869, -5381, -6805, -8133, -9350, -10459, -11453, -12324, -13072, -13696, -14193, -14568, -14820, -14952, -14969, -14878, -14682, -14391, -14011, -13555, -13029, -12445, -11815, -11150, -10462, -9763, -9064, -8381, -7723, -7101, -6531, -6020, -5578, -5217, -4945, -4768, -4694, -4729, -4876, -5137, -5517, -6012, -6623, -7348, -8182, -9117, -10152, -11274, -12473, -13744, -15070, -16439, -17841, -19257, -20674, -22081, -23455, -24785, -26057, -27248, -28348, -29346, -30220, -30961, -31558, -31996, -32269, -32366, -32282, -32009, -31545, -30888, -30037, -28992, -27762, -26343, -24748, -22986, -21061, -18989, -16786, -14457, -12027, -9510, -6921, -4288, -1565};