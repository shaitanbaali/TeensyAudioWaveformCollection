/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1967 256 samples */
 
const int16_t AKWF_1967_256_DATA [256] = 
{397, 980, 1550, 2125, 2986, 3997, 4988, 5982, 6977, 7972, 8965, 9959, 10959, 11913, 12775, 13633, 14491, 15351, 16209, 17065, 17924, 18783, 19638, 20389, 21088, 21795, 22501, 23207, 23912, 24618, 25320, 26037, 26671, 27132, 27597, 28062, 28526, 28991, 29455, 29917, 30384, 30842, 31105, 31287, 31482, 31675, 31867, 32061, 32253, 32443, 32644, 32765, 32750, 32735, 32721, 32706, 32691, 32675, 32660, 32646, 32624, 32468, 32262, 32063, 31863, 31663, 31463, 31263, 31062, 30868, 30623, 30299, 29976, 29653, 29331, 29009, 28685, 28361, 28039, 27711, 27303, 26867, 26434, 26001, 25569, 25135, 24703, 24269, 23840, 23371, 22844, 22318, 21794, 21267, 20742, 20217, 19690, 19167, 18635, 18040, 17426, 16815, 16203, 15593, 14982, 14369, 13758, 13149, 12505, 11816, 11127, 10438, 9750, 9062, 8372, 7686, 6997, 6306, 5601, 4890, 4179, 3470, 2759, 2049, 1340, 628, -83, -775, -1444, -2113, -2782, -3453, -4123, -4792, -5462, -6134, -6787, -7330, -7843, -8364, -8883, -9400, -9918, -10437, -10953, -11480, -11889, -12167, -12457, -12745, -13032, -13320, -13608, -13893, -14185, -14456, -14606, -14736, -14869, -15001, -15134, -15266, -15399, -15531, -15666, -15762, -15818, -15877, -15936, -15995, -16054, -16114, -16173, -16230, -16300, -16418, -16545, -16670, -16796, -16921, -17047, -17173, -17299, -17422, -17592, -17804, -18012, -18221, -18430, -18639, -18847, -19055, -19265, -19469, -19654, -19837, -20020, -20203, -20386, -20569, -20753, -20935, -21123, -21235, -21288, -21348, -21407, -21466, -21526, -21584, -21641, -21706, -21724, -21577, -21411, -21248, -21085, -20923, -20758, -20596, -20432, -20273, -19948, -19500, -19065, -18629, -18194, -17757, -17320, -16882, -16454, -15959, -15243, -14506, -13775, -13042, -12310, -11577, -10844, -10112, -9377, -8709, -8083, -7453, -6823, -6193, -5563, -4932, -4302, -3671, -3054, -2479, -1908, -1336, -765, -183};