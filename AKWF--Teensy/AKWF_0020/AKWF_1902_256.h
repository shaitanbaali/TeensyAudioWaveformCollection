/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1902 256 samples */
 
const int16_t AKWF_1902_256_DATA [256] = 
{2967, 8056, 12952, 17379, 20967, 23479, 24804, 25086, 24467, 23142, 21330, 19256, 17151, 15240, 13569, 11998, 10517, 9166, 7964, 6938, 6080, 5401, 4921, 4704, 4740, 4964, 5307, 5693, 6049, 6308, 6419, 6371, 6195, 5928, 5617, 5316, 5077, 4947, 4969, 5154, 5475, 5906, 6420, 6985, 7564, 8121, 8629, 9073, 9474, 9838, 10173, 10488, 10793, 11099, 11419, 11758, 12090, 12421, 12764, 13136, 13552, 14028, 14576, 15201, 15923, 16733, 17600, 18483, 19332, 20124, 20809, 21358, 21754, 22006, 22138, 22181, 22168, 22134, 22115, 22140, 22226, 22362, 22534, 22722, 22909, 23069, 23184, 23233, 23204, 23109, 22960, 22760, 22524, 22259, 21980, 21699, 21423, 21144, 20857, 20576, 20322, 20115, 19966, 19895, 19913, 20033, 20257, 20565, 20933, 21324, 21712, 22065, 22356, 22562, 22649, 22646, 22601, 22569, 22605, 22757, 23064, 23559, 24277, 25170, 26116, 26986, 27637, 27935, 27760, 27018, 25705, 23881, 21601, 18945, 15961, 12761, 9417, 6017, 2571, -1001, -4652, -8250, -11719, -14961, -17858, -20385, -22466, -24073, -25260, -26096, -26664, -27071, -27400, -27741, -28160, -28616, -29087, -29571, -30053, -30520, -30957, -31343, -31671, -31953, -32207, -32424, -32602, -32734, -32770, -32758, -32751, -32656, -32476, -32239, -31939, -31575, -31151, -30659, -30104, -29489, -28804, -28061, -27276, -26453, -25615, -24774, -23941, -23135, -22360, -21613, -20893, -20184, -19474, -18759, -18019, -17254, -16445, -15592, -14736, -13921, -13189, -12589, -12166, -11948, -11965, -12219, -12663, -13236, -13867, -14487, -15029, -15431, -15656, -15706, -15613, -15414, -15154, -14883, -14648, -14496, -14458, -14526, -14672, -14878, -15121, -15369, -15597, -15776, -15883, -15922, -15917, -15857, -15741, -15564, -15326, -15026, -14669, -14223, -13635, -12950, -12231, -11543, -10952, -10513, -10270, -10276, -10660, -11315, -12040, -12608, -12788, -12358, -11144, -9007, -5828, -1625};