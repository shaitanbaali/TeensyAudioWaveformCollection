/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1924 256 samples */
 
const int16_t AKWF_1924_256_DATA [256] = 
{1523, 4115, 6655, 9201, 11747, 14293, 16844, 19389, 21912, 24571, 26259, 26111, 25929, 25762, 25587, 25412, 25238, 25063, 24887, 24714, 24539, 24363, 24190, 24014, 23840, 23666, 23490, 23316, 23142, 22966, 22792, 22615, 22449, 22226, 21640, 20997, 20368, 19736, 19103, 18472, 17839, 17206, 16575, 15942, 15309, 14678, 14045, 13413, 12781, 12148, 11515, 10884, 10251, 9618, 8990, 8354, 7733, 7709, 7991, 8229, 8474, 8720, 8967, 9212, 9459, 9705, 9950, 10198, 10443, 10689, 10935, 11181, 11427, 11673, 11919, 12164, 12411, 12657, 12882, 13223, 12569, 10829, 9187, 7532, 5872, 4212, 2556, 896, -763, -2419, -4080, -5738, -7395, -9056, -10713, -12370, -14032, -15689, -17346, -19008, -20664, -22295, -24068, -24936, -23593, -22121, -20688, -19241, -17792, -16348, -14900, -13452, -12007, -10559, -9112, -7666, -6219, -4771, -3327, -1879, -431, 1012, 2461, 3908, 5349, 6811, 8203, 9070, 9812, 10575, 11333, 12094, 12853, 13611, 14372, 15130, 15890, 16649, 17407, 18167, 18927, 19685, 20445, 21205, 21962, 22723, 23483, 24236, 24992, 25773, 25142, 23598, 22175, 20733, 19286, 17840, 16397, 14951, 13506, 12063, 10616, 9172, 7727, 6280, 4837, 3392, 1945, 503, -942, -2389, -3831, -5263, -6770, -7678, -7783, -7923, -8059, -8193, -8327, -8461, -8596, -8730, -8864, -8999, -9133, -9267, -9402, -9536, -9670, -9805, -9939, -10073, -10207, -10342, -10477, -10608, -10760, -10981, -11209, -11435, -11661, -11888, -12115, -12340, -12567, -12794, -13020, -13247, -13473, -13699, -13926, -14152, -14379, -14605, -14832, -15058, -15285, -15513, -15734, -15987, -16605, -17351, -18075, -18802, -19531, -20260, -20987, -21716, -22444, -23172, -23902, -24629, -25358, -26086, -26813, -27542, -28271, -28999, -29728, -30456, -31180, -31887, -32716, -31585, -28878, -26364, -23821, -21270, -18722, -16178, -13627, -11080, -8536, -5989, -3449, -857};