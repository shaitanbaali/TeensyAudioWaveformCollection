/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1908 256 samples */
 
const int16_t AKWF_1908_256_DATA [256] = 
{436, 1115, 1784, 2443, 3080, 3682, 4246, 4754, 5203, 5586, 5904, 6167, 6378, 6536, 6649, 6718, 6750, 6752, 6727, 6684, 6626, 6559, 6491, 6414, 6314, 6196, 6067, 5937, 5814, 5708, 5629, 5586, 5587, 5641, 5754, 5932, 6180, 6501, 6889, 7340, 7849, 8405, 8993, 9615, 10254, 10899, 11541, 12171, 12775, 13355, 13909, 14449, 14977, 15483, 15967, 16429, 16859, 17258, 17622, 17946, 18232, 18476, 18678, 18835, 18944, 19006, 19025, 19007, 18957, 18884, 18794, 18692, 18586, 18486, 18396, 18323, 18275, 18243, 18211, 18190, 18183, 18197, 18241, 18320, 18441, 18612, 18838, 19126, 19479, 19898, 20388, 20935, 21529, 22177, 22868, 23595, 24351, 25130, 25927, 26733, 27534, 28325, 29093, 29831, 30567, 31358, 32065, 32180, 32153, 32151, 32144, 32136, 32128, 32120, 32107, 32111, 32039, 30801, 28890, 26694, 24170, 21384, 18370, 15183, 11907, 8540, 5169, 1841, -1400, -4494, -7401, -10181, -12844, -15389, -17809, -20068, -22190, -24160, -25961, -27594, -29056, -30330, -31431, -32392, -32796, -32755, -32759, -32754, -32749, -32742, -32731, -32750, -32474, -31810, -31114, -30377, -29628, -28872, -28100, -27292, -26459, -25615, -24772, -23932, -23115, -22328, -21578, -20886, -20249, -19676, -19178, -18755, -18416, -18161, -17979, -17867, -17817, -17820, -17864, -17944, -18048, -18165, -18286, -18403, -18506, -18613, -18738, -18870, -19004, -19127, -19232, -19309, -19347, -19340, -19276, -19151, -18956, -18691, -18342, -17915, -17406, -16826, -16191, -15507, -14788, -14057, -13312, -12576, -11863, -11181, -10547, -9966, -9424, -8915, -8444, -8006, -7610, -7247, -6921, -6633, -6382, -6165, -5982, -5831, -5710, -5623, -5578, -5574, -5601, -5656, -5731, -5816, -5904, -5987, -6056, -6104, -6125, -6110, -6057, -5971, -5859, -5718, -5547, -5344, -5110, -4840, -4536, -4197, -3826, -3419, -2977, -2504, -1994, -1440, -844, -198};