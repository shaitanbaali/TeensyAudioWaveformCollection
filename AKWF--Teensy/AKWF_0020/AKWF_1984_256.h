/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1984 256 samples */
 
const int16_t AKWF_1984_256_DATA [256] = 
{222, 798, 1364, 1927, 2520, 3160, 3798, 4435, 5074, 5712, 6349, 6988, 7627, 8264, 8902, 9540, 10178, 10816, 11454, 12090, 12730, 13365, 14024, 14791, 15568, 16340, 17117, 17891, 18664, 19440, 20214, 20988, 21764, 22539, 23313, 24088, 24861, 25636, 26411, 27187, 27952, 28315, 28515, 28744, 28970, 29193, 29418, 29642, 29865, 30091, 30316, 30539, 30764, 30988, 31213, 31437, 31661, 31875, 32145, 31724, 30618, 29576, 28523, 27472, 26418, 25366, 24313, 23259, 22206, 21155, 20100, 19048, 17994, 16941, 15889, 14842, 13763, 12894, 12498, 12124, 11743, 11364, 10985, 10607, 10229, 9849, 9470, 9092, 8713, 8335, 7955, 7577, 7199, 6821, 6436, 6085, 5942, 5852, 5754, 5658, 5561, 5465, 5369, 5272, 5176, 5080, 4983, 4888, 4790, 4694, 4598, 4502, 4404, 4312, 4082, 3763, 3455, 3145, 2836, 2526, 2216, 1906, 1595, 1286, 976, 666, 357, 48, -263, -572, -882, -1191, -1508, -1833, -2158, -2483, -2808, -3135, -3459, -3784, -4109, -4434, -4759, -5084, -5410, -5735, -6061, -6385, -6708, -7042, -7329, -7420, -7491, -7566, -7639, -7713, -7787, -7861, -7935, -8009, -8082, -8157, -8231, -8305, -8379, -8453, -8527, -8600, -8676, -8977, -9370, -9746, -10127, -10507, -10887, -11267, -11646, -12026, -12407, -12787, -13167, -13547, -13926, -14307, -14688, -15071, -15430, -16084, -17047, -17982, -18922, -19861, -20803, -21741, -22680, -23622, -24560, -25500, -26441, -27380, -28320, -29261, -30199, -31128, -32117, -32707, -32328, -31897, -31481, -31060, -30640, -30221, -29799, -29379, -28959, -28537, -28117, -27698, -27276, -26856, -26435, -26011, -25600, -25137, -24294, -23347, -22419, -21484, -20552, -19620, -18686, -17753, -16821, -15887, -14955, -14022, -13087, -12156, -11222, -10289, -9359, -8419, -7708, -7157, -6588, -6021, -5454, -4888, -4321, -3756, -3188, -2622, -2057, -1490, -925, -348};