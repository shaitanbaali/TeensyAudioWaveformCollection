/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1960 256 samples */
 
const int16_t AKWF_1960_256_DATA [256] = 
{283, 904, 1468, 1996, 2491, 2962, 3415, 3860, 4306, 4762, 5233, 5726, 6244, 6784, 7349, 7933, 8529, 9136, 9745, 10350, 10947, 11532, 12102, 12659, 13202, 13732, 14258, 14778, 15300, 15827, 16361, 16904, 17459, 18022, 18593, 19170, 19747, 20323, 20896, 21459, 22015, 22562, 23101, 23635, 24168, 24702, 25243, 25793, 26355, 26931, 27518, 28112, 28712, 29307, 29887, 30443, 30963, 31435, 31849, 32192, 32460, 32647, 32749, 32765, 32702, 32564, 32356, 32091, 31777, 31424, 31043, 30643, 30230, 29811, 29390, 28967, 28544, 28120, 27692, 27258, 26816, 26361, 25892, 25411, 24913, 24401, 23879, 23344, 22803, 22258, 21709, 21162, 20617, 20073, 19534, 18997, 18461, 17927, 17392, 16853, 16313, 15766, 15215, 14661, 14103, 13540, 12979, 12416, 11853, 11294, 10739, 10185, 9636, 9089, 8544, 8000, 7454, 6906, 6357, 5802, 5245, 4685, 4119, 3555, 2990, 2425, 1864, 1305, 750, 200, -345, -890, -1432, -1973, -2517, -3062, -3612, -4167, -4726, -5290, -5858, -6427, -6998, -7569, -8133, -8696, -9253, -9802, -10347, -10886, -11420, -11955, -12490, -13027, -13571, -14121, -14679, -15246, -15819, -16398, -16981, -17563, -18143, -18717, -19282, -19838, -20382, -20914, -21437, -21955, -22467, -22982, -23504, -24035, -24580, -25143, -25723, -26322, -26936, -27558, -28185, -28806, -29411, -29993, -30538, -31035, -31478, -31857, -32165, -32400, -32557, -32640, -32649, -32589, -32464, -32283, -32051, -31775, -31462, -31118, -30747, -30354, -29944, -29519, -29081, -28632, -28171, -27703, -27229, -26748, -26262, -25772, -25282, -24791, -24300, -23807, -23315, -22819, -22320, -21816, -21305, -20782, -20248, -19701, -19140, -18567, -17984, -17391, -16796, -16201, -15610, -15030, -14463, -13913, -13382, -12869, -12372, -11888, -11410, -10932, -10450, -9949, -9426, -8877, -8290, -7667, -7008, -6313, -5586, -4838, -4073, -3305, -2542, -1795, -1075, -376};