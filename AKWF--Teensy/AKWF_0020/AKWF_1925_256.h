/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1925 256 samples */
 
const int16_t AKWF_1925_256_DATA [256] = 
{1121, 4132, 7016, 9816, 12495, 15028, 17396, 19564, 21523, 23252, 24732, 25996, 27066, 27942, 28635, 29146, 29487, 29666, 29695, 29585, 29346, 28994, 28542, 28002, 27389, 26718, 26001, 25253, 24488, 23715, 22951, 22204, 21485, 20804, 20135, 19434, 18706, 17955, 17187, 16411, 15629, 14846, 14072, 13311, 12568, 11852, 11166, 10516, 9909, 9348, 8838, 8384, 7990, 7659, 7392, 7194, 7064, 7016, 7087, 7275, 7565, 7951, 8415, 8944, 9525, 10138, 10768, 11400, 12012, 12588, 13113, 13565, 13932, 14196, 14343, 14356, 14226, 13941, 13489, 12865, 12060, 11053, 9847, 8461, 6904, 5200, 3371, 1431, -587, -2659, -4770, -6883, -8974, -11022, -12994, -14865, -16617, -18217, -19648, -20889, -21917, -22717, -23276, -23579, -23641, -23480, -23105, -22524, -21747, -20791, -19662, -18379, -16962, -15419, -13772, -12044, -10244, -8396, -6522, -4631, -2747, -891, 929, 2692, 4382, 5993, 7501, 8935, 10349, 11732, 13082, 14394, 15657, 16867, 18021, 19106, 20122, 21060, 21913, 22677, 23348, 23917, 24384, 24741, 24985, 25114, 25125, 25014, 24781, 24426, 23940, 23291, 22482, 21524, 20423, 19198, 17859, 16417, 14892, 13299, 11649, 9966, 8264, 6554, 4863, 3199, 1578, 22, -1460, -2856, -4148, -5330, -6390, -7320, -8135, -8845, -9450, -9956, -10368, -10689, -10928, -11090, -11183, -11216, -11196, -11133, -11034, -10910, -10767, -10616, -10465, -10323, -10195, -10091, -10019, -9982, -9986, -10008, -10018, -10019, -10017, -10015, -10017, -10028, -10052, -10094, -10158, -10248, -10369, -10525, -10720, -10957, -11241, -11573, -11956, -12395, -12889, -13437, -14045, -14706, -15444, -16299, -17262, -18319, -19456, -20654, -21897, -23166, -24436, -25692, -26911, -28067, -29144, -30120, -30971, -31680, -32226, -32591, -32759, -32713, -32443, -31933, -31176, -30165, -28876, -27322, -25520, -23482, -21234, -18802, -16200, -13465, -10623, -7698, -4730, -1677};