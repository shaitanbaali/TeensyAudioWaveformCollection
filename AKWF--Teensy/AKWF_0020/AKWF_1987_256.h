/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1987 256 samples */
 
const int16_t AKWF_1987_256_DATA [256] = 
{779, 2544, 4272, 6005, 7737, 9470, 11205, 12937, 14671, 16396, 18173, 19496, 20114, 20744, 21375, 22005, 22635, 23265, 23895, 24522, 25154, 25784, 26413, 27044, 27672, 28301, 28932, 29554, 30209, 30680, 30430, 30071, 29732, 29390, 29048, 28705, 28363, 28020, 27677, 27335, 26993, 26649, 26306, 25965, 25621, 25279, 24937, 24587, 24034, 23388, 22755, 22121, 21483, 20847, 20213, 19577, 18942, 18308, 17670, 17035, 16401, 15765, 15130, 14495, 13848, 13258, 12094, 10338, 8633, 6917, 5199, 3484, 1769, 50, -1662, -3380, -5097, -6810, -8528, -10245, -11959, -13675, -15379, -17150, -18528, -18887, -19214, -19553, -19886, -20218, -20552, -20886, -21219, -21553, -21886, -22219, -22553, -22886, -23220, -23553, -23886, -24218, -24561, -24995, -25454, -25908, -26363, -26820, -27275, -27730, -28187, -28643, -29098, -29552, -30010, -30465, -30920, -31375, -31827, -32273, -32781, -31862, -29912, -28099, -26264, -24423, -22586, -20749, -18909, -17071, -15235, -13393, -11559, -9721, -7879, -6044, -4206, -2374, -503, 1017, 1956, 2902, 3851, 4797, 5741, 6689, 7636, 8580, 9526, 10474, 11418, 12366, 13311, 14256, 15204, 16138, 17127, 17816, 17250, 16473, 15738, 14996, 14254, 13510, 12767, 12024, 11281, 10538, 9795, 9051, 8310, 7566, 6822, 6083, 5336, 4604, 4313, 4229, 4116, 4009, 3902, 3796, 3689, 3580, 3474, 3367, 3260, 3154, 3047, 2939, 2832, 2725, 2615, 2522, 2269, 1844, 1433, 1019, 604, 191, -222, -636, -1050, -1464, -1878, -2291, -2705, -3120, -3534, -3948, -4361, -4776, -5177, -5534, -5887, -6243, -6598, -6951, -7306, -7661, -8016, -8371, -8723, -9078, -9434, -9789, -10142, -10498, -10850, -11209, -11549, -11648, -11684, -11733, -11779, -11824, -11871, -11916, -11961, -12008, -12053, -12099, -12145, -12190, -12236, -12283, -12326, -12361, -12459, -11464, -9641, -7927, -6195, -4462, -2734, -971};