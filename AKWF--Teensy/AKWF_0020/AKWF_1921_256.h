/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1921 256 samples */
 
const int16_t AKWF_1921_256_DATA [256] = 
{700, 2779, 4815, 6857, 8899, 10928, 13024, 14729, 15289, 15757, 16246, 16730, 17215, 17698, 18181, 18665, 19149, 19633, 20117, 20600, 21085, 21568, 22051, 22536, 23019, 23502, 23987, 24471, 24947, 25449, 25848, 25210, 24253, 23350, 22437, 21522, 20610, 19697, 18782, 17869, 16957, 16041, 15129, 14215, 13302, 12389, 11476, 10561, 9649, 8734, 7821, 6911, 6003, 5056, 4951, 5470, 5908, 6361, 6814, 7267, 7719, 8173, 8626, 9079, 9533, 9986, 10438, 10892, 11344, 11798, 12251, 12704, 13157, 13611, 14063, 14505, 15008, 15038, 14333, 13641, 12949, 12255, 11560, 10866, 10172, 9478, 8784, 8089, 7395, 6702, 6006, 5312, 4619, 3923, 3230, 2536, 1841, 1147, 452, -238, -954, -1787, -2634, -3475, -4319, -5164, -6007, -6850, -7695, -8537, -9381, -10226, -11068, -11913, -12756, -13598, -14444, -15287, -16129, -16974, -17818, -18651, -19515, -20269, -19159, -17282, -15525, -13747, -11964, -10185, -8407, -6623, -4845, -3065, -1282, 494, 2276, 4057, 5835, 7616, 9398, 11176, 12957, 14740, 16515, 18271, 20171, 20539, 19513, 18651, 17762, 16870, 15978, 15089, 14197, 13306, 12416, 11524, 10634, 9743, 8851, 7961, 7071, 6178, 5289, 4397, 3505, 2616, 1727, 822, 34, -533, -1096, -1659, -2222, -2786, -3349, -3912, -4475, -5038, -5602, -6165, -6727, -7291, -7854, -8417, -8980, -9543, -10106, -10670, -11232, -11791, -12370, -12859, -12775, -12597, -12439, -12278, -12115, -11952, -11791, -11628, -11466, -11305, -11142, -10980, -10818, -10656, -10494, -10332, -10170, -10008, -9845, -9684, -9525, -9360, -9208, -9853, -10919, -11925, -12940, -13958, -14975, -15991, -17009, -18024, -19040, -20059, -21074, -22091, -23109, -24125, -25141, -26159, -27174, -28192, -29210, -30224, -31208, -32375, -31971, -29807, -27789, -25752, -23706, -21663, -19623, -17578, -15535, -13494, -11448, -9406, -7366, -5323, -3287, -1209};