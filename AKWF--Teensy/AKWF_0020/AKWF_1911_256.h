/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1911 256 samples */
 
const int16_t AKWF_1911_256_DATA [256] = 
{971, 2515, 4004, 5462, 6844, 8131, 9298, 10315, 11182, 11897, 12469, 12910, 13228, 13436, 13550, 13584, 13557, 13487, 13389, 13280, 13176, 13091, 13038, 13007, 12979, 12959, 12944, 12932, 12926, 12925, 12925, 12927, 12929, 12929, 12926, 12917, 12903, 12885, 12871, 12860, 12851, 12847, 12844, 12844, 12844, 12846, 12849, 12852, 12853, 12852, 12852, 12850, 12847, 12846, 12844, 12844, 12842, 12838, 12837, 12835, 12832, 12828, 12823, 12816, 12809, 12801, 12800, 12811, 12832, 12856, 12882, 12908, 12930, 12945, 12950, 12942, 12918, 12878, 12822, 12751, 12628, 12432, 12186, 11910, 11631, 11377, 11175, 11053, 11040, 11162, 11442, 11901, 12552, 13404, 14493, 15844, 17423, 19171, 21044, 22964, 24885, 26734, 28446, 29948, 31182, 32094, 32635, 32758, 32451, 31762, 30719, 29330, 27630, 25637, 23390, 20941, 18313, 15533, 12662, 9723, 6780, 3837, 914, -2084, -5176, -8309, -11443, -14541, -17550, -20407, -23073, -25484, -27618, -29423, -30862, -31925, -32456, -32475, -32390, -31726, -30647, -29272, -27657, -25854, -23945, -21990, -20065, -18243, -16574, -15104, -13894, -12921, -12145, -11556, -11138, -10879, -10754, -10742, -10818, -10955, -11130, -11313, -11483, -11617, -11693, -11722, -11743, -11760, -11769, -11773, -11775, -11771, -11764, -11756, -11748, -11740, -11737, -11738, -11745, -11755, -11763, -11769, -11772, -11771, -11767, -11761, -11755, -11746, -11738, -11729, -11720, -11714, -11707, -11703, -11700, -11697, -11693, -11690, -11688, -11685, -11682, -11680, -11677, -11674, -11670, -11667, -11663, -11658, -11650, -11640, -11627, -11611, -11595, -11579, -11565, -11552, -11545, -11544, -11549, -11561, -11581, -11608, -11642, -11680, -11722, -11763, -11803, -11842, -11878, -11906, -11927, -11938, -11939, -11923, -11892, -11841, -11776, -11717, -11659, -11593, -11507, -11391, -11228, -11007, -10716, -10345, -9881, -9312, -8633, -7839, -6924, -5869, -4677, -3372, -1979, -485};