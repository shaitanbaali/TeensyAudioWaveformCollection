/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1978 256 samples */
 
const int16_t AKWF_1978_256_DATA [256] = 
{1415, 3578, 5238, 6950, 8652, 10357, 12064, 13766, 15468, 17185, 18837, 20141, 21380, 22631, 23881, 25131, 26378, 27629, 28870, 30154, 30879, 31062, 31288, 31508, 31727, 31945, 32164, 32379, 32609, 32761, 32565, 32305, 32059, 31809, 31559, 31310, 31060, 30810, 30565, 30249, 29870, 29497, 29124, 28750, 28377, 28003, 27630, 27252, 26903, 26684, 26478, 26271, 26064, 25858, 25650, 25443, 25235, 25029, 24851, 24698, 24543, 24389, 24234, 24079, 23924, 23770, 23613, 23474, 23393, 23319, 23245, 23171, 23097, 23022, 22949, 22876, 22798, 22827, 22935, 23033, 23133, 23234, 23334, 23435, 23536, 23630, 23765, 24040, 24327, 24610, 24894, 25178, 25462, 25745, 26027, 26314, 26500, 26619, 26746, 26873, 26999, 27125, 27252, 27371, 27521, 27495, 26992, 26451, 25919, 25386, 24851, 24316, 23781, 23245, 22713, 21636, 20222, 18855, 17482, 16103, 14727, 13352, 11971, 10611, 9134, 7346, 5550, 3759, 1961, 168, -1625, -3422, -5213, -7014, -8580, -10022, -11487, -12948, -14406, -15867, -17328, -18777, -20272, -21503, -22155, -22789, -23429, -24065, -24703, -25340, -25974, -26614, -27240, -27380, -27281, -27216, -27144, -27073, -27001, -26930, -26856, -26793, -26656, -26368, -26077, -25787, -25497, -25208, -24918, -24628, -24338, -24049, -23879, -23760, -23631, -23504, -23377, -23250, -23124, -22998, -22863, -22798, -22857, -22915, -22973, -23032, -23090, -23149, -23208, -23266, -23328, -23455, -23608, -23756, -23906, -24056, -24205, -24354, -24504, -24652, -24817, -25013, -25206, -25401, -25595, -25789, -25983, -26178, -26371, -26571, -26894, -27259, -27614, -27973, -28329, -28687, -29046, -29401, -29764, -30094, -30379, -30669, -30957, -31246, -31535, -31823, -32109, -32403, -32663, -32605, -32448, -32309, -32166, -32023, -31879, -31736, -31583, -31479, -30939, -29818, -28724, -27624, -26522, -25423, -24322, -23215, -22136, -20929, -18675, -16139, -13652, -11158, -8665, -6171, -3684, -1146};