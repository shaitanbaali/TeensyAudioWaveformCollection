/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1971 256 samples */
 
const int16_t AKWF_1971_256_DATA [256] = 
{1742, 4134, 6029, 7982, 9926, 11871, 13820, 15763, 17704, 19675, 21469, 22713, 23914, 25120, 26327, 27534, 28739, 29943, 31141, 32395, 32575, 32080, 31688, 31275, 30863, 30453, 30040, 29622, 29238, 28660, 27568, 26443, 25322, 24202, 23082, 21960, 20841, 19720, 18597, 17609, 16698, 15774, 14856, 13935, 13015, 12096, 11183, 10228, 9553, 9560, 9600, 9632, 9666, 9701, 9736, 9771, 9807, 9836, 10289, 10959, 11594, 12237, 12879, 13520, 14164, 14802, 15456, 16024, 16400, 16775, 17152, 17526, 17900, 18276, 18647, 19026, 19385, 19037, 18354, 17718, 17076, 16430, 15785, 15143, 14490, 13881, 12963, 11438, 9903, 8376, 6842, 5310, 3780, 2247, 715, -813, -2319, -3810, -5303, -6799, -8290, -9783, -11279, -12758, -14306, -15445, -15840, -16258, -16675, -17089, -17504, -17918, -18327, -18754, -19117, -18458, -17411, -16428, -15432, -14436, -13440, -12445, -11441, -10476, -9211, -7468, -5733, -3999, -2261, -527, 1208, 2945, 4684, 6394, 7733, 8939, 10171, 11399, 12623, 13850, 15078, 16287, 17583, 18289, 18115, 17995, 17869, 17741, 17613, 17484, 17350, 17238, 17036, 15915, 14526, 13186, 11839, 10487, 9137, 7789, 6436, 5099, 3638, 2013, 400, -1214, -2833, -4446, -6062, -7677, -9303, -10856, -11853, -12692, -13563, -14429, -15292, -16157, -17022, -17875, -18788, -19175, -18922, -18720, -18509, -18299, -18087, -17876, -17663, -17461, -17210, -16603, -15921, -15257, -14588, -13917, -13249, -12579, -11913, -11226, -10775, -10575, -10357, -10141, -9926, -9711, -9497, -9288, -9052, -8955, -9577, -10349, -11094, -11844, -12592, -13343, -14095, -14846, -15582, -16539, -17717, -18876, -20037, -21199, -22362, -23523, -24680, -25856, -26952, -27617, -28223, -28840, -29455, -30072, -30685, -31299, -31903, -32572, -32402, -31501, -30673, -29831, -28988, -28148, -27305, -26446, -25664, -24482, -21760, -18802, -15887, -12965, -10045, -7124, -4211, -1237};