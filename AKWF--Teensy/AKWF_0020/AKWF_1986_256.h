/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1986 256 samples */
 
const int16_t AKWF_1986_256_DATA [256] = 
{974, 2772, 4537, 6304, 8066, 9861, 11415, 12595, 13796, 14996, 16193, 17391, 18590, 19787, 20986, 22185, 23381, 24581, 25780, 26975, 28175, 29374, 30554, 31813, 32652, 31892, 30926, 30006, 29077, 28144, 27214, 26284, 25352, 24422, 23492, 22559, 21630, 20699, 19767, 18837, 17909, 16974, 16060, 15534, 15177, 14795, 14415, 14036, 13659, 13279, 12901, 12524, 12144, 11765, 11388, 11009, 10630, 10253, 9874, 9507, 9077, 9469, 10672, 11813, 12966, 14117, 15270, 16423, 17575, 18726, 19881, 21032, 22185, 23339, 24489, 25643, 26796, 27928, 29163, 29767, 28933, 28034, 27152, 26267, 25378, 24489, 23604, 22714, 21826, 20941, 20052, 19163, 18277, 17389, 16501, 15612, 14730, 13810, 12571, 11250, 9948, 8640, 7331, 6025, 4718, 3409, 2103, 796, -512, -1818, -3126, -4434, -5740, -7045, -8340, -9714, -9670, -8700, -7863, -7000, -6138, -5278, -4415, -3553, -2693, -1830, -968, -108, 755, 1616, 2478, 3341, 4190, 5107, 5542, 5202, 4900, 4592, 4285, 3977, 3668, 3360, 3052, 2742, 2436, 2127, 1820, 1512, 1202, 895, 579, 299, -181, -1508, -2956, -4376, -5800, -7229, -8652, -10077, -11505, -12930, -14356, -15784, -17208, -18634, -20061, -21484, -22906, -24341, -25727, -25932, -25596, -25344, -25076, -24807, -24539, -24271, -24003, -23735, -23467, -23199, -22930, -22662, -22395, -22127, -21858, -21585, -21340, -20758, -19828, -18923, -18013, -17104, -16195, -15283, -14374, -13464, -12553, -11645, -10735, -9824, -8917, -8006, -7095, -6204, -5218, -4813, -5799, -6868, -7916, -8968, -10025, -11079, -12131, -13187, -14242, -15295, -16350, -17404, -18458, -19513, -20566, -21615, -22688, -23656, -23732, -23563, -23439, -23306, -23173, -23040, -22906, -22772, -22640, -22506, -22373, -22240, -22107, -21974, -21840, -21706, -21562, -21482, -20354, -18508, -16758, -14987, -13217, -11451, -9680, -7910, -6144, -4375, -2612, -813};