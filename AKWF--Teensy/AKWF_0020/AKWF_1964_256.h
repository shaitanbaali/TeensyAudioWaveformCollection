/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1964 256 samples */
 
const int16_t AKWF_1964_256_DATA [256] = 
{2114, 4627, 6742, 8907, 11064, 13223, 15386, 17543, 19692, 21897, 23751, 24765, 25735, 26715, 27691, 28670, 29645, 30616, 31592, 32582, 31747, 29954, 28316, 26644, 24975, 23308, 21636, 19955, 18343, 16329, 13430, 10523, 7614, 4710, 1804, -1107, -4009, -6919, -9819, -12218, -14389, -16595, -18788, -20987, -23186, -25379, -27556, -29848, -31304, -31145, -30952, -30773, -30588, -30402, -30216, -30024, -29847, -29619, -27987, -25751, -23618, -21459, -19306, -17153, -14995, -12838, -10700, -8436, -5951, -3472, -989, 1488, 3970, 6454, 8927, 11419, 13857, 15286, 16347, 17468, 18576, 19686, 20795, 21901, 22994, 24177, 24650, 24009, 23381, 22758, 22128, 21498, 20871, 20238, 19617, 18942, 17620, 16074, 14567, 13049, 11535, 10020, 8501, 6990, 5465, 4029, 2734, 1430, 124, -1175, -2479, -3783, -5082, -6395, -7657, -8353, -8893, -9460, -10022, -10584, -11146, -11707, -12264, -12850, -13166, -13134, -13115, -13094, -13073, -13054, -13032, -13009, -12995, -12939, -12582, -12142, -11717, -11287, -10860, -10430, -10002, -9570, -9156, -8566, -7765, -6976, -6186, -5396, -4605, -3814, -3023, -2237, -1418, -321, 838, 1982, 3128, 4277, 5423, 6570, 7717, 8870, 9930, 10891, 11856, 12821, 13788, 14753, 15718, 16678, 17664, 18506, 18596, 18524, 18484, 18437, 18389, 18342, 18294, 18237, 18233, 17549, 16185, 14879, 13564, 12251, 10934, 9620, 8300, 7004, 5581, 3463, 1237, -961, -3164, -5374, -7575, -9780, -11981, -14214, -16001, -17397, -18829, -20257, -21686, -23112, -24540, -25961, -27413, -28682, -29214, -29633, -30076, -30512, -30948, -31386, -31821, -32248, -32730, -32069, -30467, -28959, -27439, -25917, -24392, -22871, -21357, -19802, -18459, -17902, -17428, -16938, -16450, -15962, -15477, -14992, -14516, -13967, -14514, -15840, -17061, -18302, -19543, -20781, -22023, -23226, -24615, -24986, -22213, -19141, -16129, -13103, -10081, -7056, -4039, -961};