/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1928 256 samples */
 
const int16_t AKWF_1928_256_DATA [256] = 
{1069, 3730, 6249, 8667, 10953, 13091, 15063, 16844, 18433, 19866, 21163, 22327, 23357, 24253, 25023, 25667, 26189, 26597, 26895, 27087, 27183, 27187, 27108, 26950, 26724, 26436, 26091, 25698, 25264, 24793, 24295, 23775, 23198, 22536, 21795, 20982, 20108, 19180, 18206, 17202, 16175, 15134, 14095, 13064, 12054, 11079, 10144, 9261, 8443, 7695, 7027, 6448, 5962, 5578, 5298, 5132, 5086, 5157, 5338, 5620, 5993, 6448, 6971, 7551, 8176, 8830, 9503, 10181, 10846, 11489, 12095, 12650, 13144, 13564, 13897, 14136, 14271, 14293, 14203, 14024, 13766, 13428, 13014, 12528, 11969, 11343, 10655, 9907, 9105, 8256, 7360, 6427, 5463, 4469, 3455, 2426, 1385, 341, -700, -1739, -2762, -3773, -4813, -5902, -7033, -8194, -9370, -10555, -11733, -12889, -14012, -15087, -16098, -17033, -17879, -18618, -19243, -19736, -20088, -20289, -20326, -20194, -19882, -19388, -18708, -17814, -16687, -15341, -13790, -12058, -10163, -8125, -5977, -3739, -1435, 896, 3237, 5560, 7826, 10019, 12110, 14065, 15869, 17494, 18916, 20123, 21092, 21807, 22270, 22492, 22488, 22262, 21829, 21201, 20391, 19418, 18299, 17049, 15694, 14250, 12734, 11175, 9589, 7992, 6412, 4864, 3365, 1938, 593, -653, -1783, -2800, -3742, -4622, -5443, -6202, -6899, -7537, -8117, -8638, -9107, -9524, -9891, -10213, -10491, -10731, -10936, -11108, -11251, -11371, -11470, -11551, -11618, -11675, -11722, -11728, -11668, -11551, -11382, -11170, -10923, -10650, -10363, -10068, -9776, -9499, -9247, -9029, -8855, -8735, -8678, -8693, -8788, -8968, -9241, -9613, -10087, -10664, -11369, -12226, -13224, -14350, -15585, -16911, -18312, -19759, -21236, -22722, -24185, -25608, -26967, -28233, -29387, -30408, -31268, -31953, -32441, -32714, -32757, -32557, -32104, -31387, -30407, -29176, -27703, -26008, -24110, -22022, -19772, -17383, -14871, -12271, -9607, -6900, -4186, -1430};