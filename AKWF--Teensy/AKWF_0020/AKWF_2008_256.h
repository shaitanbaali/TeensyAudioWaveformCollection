/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2008 256 samples */
 
const int16_t AKWF_2008_256_DATA [256] = 
{638, 2660, 4587, 6458, 8257, 9976, 11608, 13138, 14567, 15906, 17164, 18349, 19457, 20486, 21445, 22331, 23146, 23895, 24580, 25202, 25768, 26279, 26739, 27152, 27523, 27853, 28148, 28411, 28645, 28855, 29044, 29215, 29371, 29514, 29644, 29742, 29802, 29827, 29820, 29783, 29716, 29624, 29508, 29370, 29213, 29041, 28854, 28657, 28451, 28238, 28023, 27806, 27589, 27376, 27168, 26966, 26774, 26591, 26420, 26261, 26119, 25997, 25895, 25811, 25741, 25685, 25640, 25601, 25568, 25535, 25501, 25461, 25412, 25350, 25273, 25177, 25058, 24913, 24738, 24532, 24291, 24013, 23694, 23336, 22934, 22487, 21996, 21459, 20881, 20263, 19608, 18920, 18203, 17459, 16695, 15913, 15116, 14312, 13503, 12693, 11889, 11094, 10311, 9547, 8803, 8085, 7397, 6740, 6118, 5535, 4992, 4489, 4022, 3588, 3188, 2820, 2482, 2172, 1890, 1631, 1394, 1177, 976, 790, 616, 451, 292, 136, -19, -176, -336, -505, -682, -870, -1073, -1290, -1525, -1769, -2015, -2266, -2521, -2781, -3048, -3323, -3604, -3895, -4196, -4507, -4829, -5163, -5510, -5871, -6245, -6633, -7039, -7458, -7893, -8347, -8815, -9300, -9803, -10322, -10858, -11421, -12006, -12615, -13246, -13893, -14558, -15237, -15923, -16619, -17320, -18021, -18720, -19416, -20101, -20776, -21437, -22078, -22701, -23300, -23871, -24416, -24929, -25409, -25855, -26264, -26632, -26957, -27237, -27476, -27677, -27842, -27975, -28077, -28154, -28208, -28244, -28265, -28276, -28279, -28280, -28282, -28290, -28305, -28332, -28374, -28434, -28514, -28618, -28745, -28898, -29079, -29302, -29571, -29878, -30218, -30586, -30973, -31371, -31773, -32167, -32563, -32775, -32765, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32764, -32776, -32705, -32175, -31445, -30601, -29623, -28512, -27268, -25901, -24422, -22831, -21143, -19370, -17514, -15594, -13621, -11599, -9549, -7483, -5407, -3342, -1254};