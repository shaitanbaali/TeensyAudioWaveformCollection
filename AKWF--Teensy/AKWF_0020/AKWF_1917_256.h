/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1917 256 samples */
 
const int16_t AKWF_1917_256_DATA [256] = 
{751, 2029, 3349, 4729, 6168, 7670, 9228, 10836, 12491, 14170, 15854, 17535, 19182, 20794, 22352, 23834, 25225, 26510, 27680, 28749, 29727, 30606, 31379, 32038, 32597, 32783, 32755, 32753, 32747, 32740, 32729, 32738, 32454, 31827, 31098, 30239, 29273, 28202, 27034, 25792, 24479, 23098, 21675, 20213, 18733, 17237, 15682, 14047, 12365, 10669, 8993, 7370, 5840, 4445, 3221, 2203, 1411, 881, 625, 670, 1043, 1721, 2654, 3791, 5077, 6442, 7816, 9152, 10371, 11417, 12237, 12777, 13000, 12936, 12616, 12051, 11254, 10258, 9071, 7724, 6252, 4675, 3029, 1351, -357, -2052, -3738, -5472, -7228, -9010, -10808, -12595, -14359, -16093, -17763, -19380, -20923, -22376, -23719, -24964, -26100, -27132, -28056, -28864, -29557, -30136, -30596, -30938, -31161, -31265, -31251, -31121, -30877, -30513, -30029, -29429, -28710, -27886, -26963, -25943, -24845, -23669, -22419, -21112, -19754, -18351, -16922, -15440, -13913, -12353, -10769, -9174, -7580, -5986, -4409, -2867, -1361, 86, 1480, 2807, 4066, 5262, 6388, 7442, 8421, 9317, 10125, 10835, 11455, 11973, 12386, 12695, 12895, 12987, 12980, 12872, 12668, 12365, 11970, 11478, 10891, 10214, 9450, 8604, 7680, 6678, 5608, 4457, 3191, 1842, 427, -1020, -2470, -3882, -5223, -6461, -7568, -8513, -9267, -9808, -10122, -10212, -10089, -9769, -9274, -8631, -7864, -7000, -6073, -5110, -4143, -3205, -2311, -1491, -727, 22, 743, 1421, 2053, 2615, 3101, 3494, 3786, 3967, 4026, 3955, 3753, 3408, 2911, 2267, 1486, 589, -402, -1480, -2614, -3789, -4978, -6154, -7304, -8416, -9461, -10458, -11423, -12342, -13221, -14043, -14800, -15485, -16089, -16603, -17026, -17348, -17565, -17673, -17667, -17537, -17282, -16911, -16430, -15851, -15186, -14439, -13627, -12761, -11849, -10910, -9947, -8963, -7968, -6966, -5946, -4903, -3839, -2746, -1619, -434};