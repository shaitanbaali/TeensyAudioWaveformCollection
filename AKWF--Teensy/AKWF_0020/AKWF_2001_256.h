/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2001 256 samples */
 
const int16_t AKWF_2001_256_DATA [256] = 
{493, 1784, 3046, 4300, 5529, 6727, 7889, 8998, 10053, 11046, 12013, 12997, 13986, 14973, 15952, 16912, 17844, 18741, 19593, 20388, 21120, 21778, 22350, 22829, 23206, 23472, 23618, 23638, 23524, 23267, 22866, 22313, 21602, 20735, 19708, 18510, 17100, 15470, 13635, 11621, 9437, 7104, 4654, 2098, -535, -3213, -5923, -8634, -11311, -13943, -16495, -18936, -21254, -23417, -25399, -27188, -28756, -30086, -31165, -31973, -32500, -32748, -32729, -32455, -31932, -31175, -30197, -29010, -27636, -26087, -24382, -22549, -20597, -18548, -16434, -14266, -12064, -9861, -7664, -5500, -3393, -1351, 602, 2445, 4173, 5768, 7217, 8577, 9872, 11093, 12245, 13322, 14319, 15239, 16079, 16838, 17516, 18110, 18620, 19050, 19398, 19662, 19846, 19949, 19973, 19917, 19785, 19578, 19296, 18944, 18520, 18029, 17461, 16777, 15979, 15079, 14079, 12989, 11824, 10585, 9290, 7951, 6571, 5169, 3757, 2341, 939, -438, -1783, -3079, -4319, -5492, -6587, -7594, -8508, -9318, -10019, -10606, -11075, -11432, -11678, -11820, -11861, -11809, -11671, -11455, -11167, -10818, -10416, -9970, -9492, -8988, -8471, -7948, -7429, -6924, -6444, -5992, -5582, -5219, -4907, -4657, -4471, -4353, -4300, -4308, -4373, -4492, -4658, -4865, -5107, -5379, -5671, -5976, -6287, -6596, -6895, -7176, -7430, -7649, -7827, -7956, -8029, -8042, -7984, -7853, -7644, -7354, -6979, -6509, -5937, -5268, -4509, -3670, -2762, -1791, -774, 280, 1362, 2454, 3546, 4625, 5674, 6685, 7644, 8535, 9351, 10077, 10702, 11218, 11613, 11881, 12013, 12004, 11848, 11535, 11067, 10454, 9700, 8822, 7832, 6739, 5562, 4313, 3008, 1667, 302, -1072, -2429, -3761, -5051, -6277, -7427, -8488, -9440, -10275, -10979, -11538, -11946, -12192, -12277, -12227, -12047, -11742, -11314, -10768, -10115, -9359, -8510, -7577, -6563, -5486, -4352, -3170, -1955, -686};