/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1954 256 samples */
 
const int16_t AKWF_1954_256_DATA [256] = 
{281, 709, 1101, 1472, 1826, 2166, 2499, 2829, 3162, 3505, 3858, 4224, 4605, 5000, 5408, 5825, 6247, 6674, 7100, 7520, 7934, 8341, 8737, 9126, 9504, 9875, 10244, 10608, 10971, 11339, 11708, 12085, 12466, 12853, 13244, 13640, 14035, 14431, 14825, 15212, 15593, 15967, 16332, 16689, 17040, 17384, 17725, 18063, 18400, 18741, 19085, 19433, 19786, 20145, 20506, 20872, 21237, 21600, 21959, 22310, 22652, 22982, 23301, 23606, 23901, 24184, 24458, 24729, 24996, 25265, 25538, 25816, 26103, 26399, 26702, 27012, 27325, 27638, 27946, 28245, 28528, 28793, 29037, 29255, 29449, 29619, 29768, 29901, 30021, 30135, 30249, 30369, 30499, 30642, 30800, 30969, 31146, 31325, 31498, 31652, 31781, 31872, 31916, 31908, 31843, 31721, 31547, 31327, 31072, 30798, 30518, 30248, 30002, 29788, 29614, 29476, 29366, 29267, 29151, 28983, 28725, 28328, 27743, 26924, 25826, 24403, 22633, 20496, 17981, 15111, 11907, 8406, 4682, 792, -3189, -7160, -11052, -14781, -18256, -21427, -24238, -26641, -28632, -30201, -31360, -32145, -32595, -32764, -32709, -32495, -32180, -31820, -31464, -31150, -30906, -30750, -30686, -30708, -30804, -30952, -31131, -31311, -31472, -31587, -31641, -31624, -31529, -31358, -31118, -30821, -30483, -30120, -29748, -29387, -29047, -28738, -28467, -28234, -28035, -27865, -27713, -27569, -27422, -27259, -27073, -26858, -26607, -26321, -26003, -25656, -25288, -24907, -24519, -24136, -23763, -23403, -23063, -22742, -22436, -22144, -21861, -21579, -21295, -21002, -20696, -20373, -20031, -19671, -19298, -18911, -18515, -18118, -17720, -17329, -16948, -16575, -16215, -15865, -15521, -15182, -14843, -14499, -14148, -13786, -13409, -13020, -12619, -12204, -11784, -11360, -10936, -10520, -10112, -9717, -9339, -8974, -8621, -8279, -7942, -7605, -7263, -6908, -6534, -6141, -5720, -5274, -4802, -4305, -3790, -3262, -2725, -2189, -1661, -1145, -651, -171};