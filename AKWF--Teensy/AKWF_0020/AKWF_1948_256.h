/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1948 256 samples */
 
const int16_t AKWF_1948_256_DATA [256] = 
{4233, 10558, 16370, 21526, 25749, 28824, 30582, 30912, 29775, 27203, 23314, 18264, 12298, 5721, -1165, -8001, -14418, -20108, -24751, -28089, -29949, -30215, -28865, -25958, -21650, -16172, -9796, -2889, 4180, 11054, 17333, 22695, 26869, 29628, 30853, 30502, 28631, 25369, 20933, 15619, 9733, 3631, -2304, -7756, -12404, -15979, -18305, -19257, -18796, -16963, -13874, -9725, -4730, 818, 6611, 12367, 17766, 22532, 26447, 29302, 30966, 31367, 30485, 28365, 25096, 20840, 15775, 10112, 4119, -1972, -7905, -13408, -18272, -22286, -25266, -27096, -27683, -26994, -25045, -21909, -17721, -12635, -6877, -711, 5614, 11787, 17511, 22534, 26584, 29450, 30983, 31080, 29714, 26923, 22833, 17626, 11530, 4865, -2056, -8900, -15294, -20933, -25531, -28830, -30674, -30961, -29675, -26872, -22695, -17368, -11134, -4314, 2729, 9688, 16200, 21939, 26664, 30135, 32196, 32770, 31841, 29469, 25767, 20935, 15204, 8826, 2122, -4612, -11091, -17001, -22098, -26169, -29023, -30552, -30692, -29445, -26864, -23065, -18232, -12558, -6303, 232, 6783, 13039, 18696, 23514, 27250, 29712, 30786, 30404, 28571, 25355, 20906, 15434, 9173, 2448, -4416, -11102, -17248, -22551, -26754, -29620, -31004, -30831, -29101, -25892, -21359, -15747, -9313, -2384, 4667, 11519, 17820, 23239, 27537, 30494, 31969, 31907, 30318, 27300, 23000, 17647, 11521, 4898, -1874, -8468, -14598, -19951, -24285, -27417, -29198, -29559, -28494, -26063, -22384, -17625, -12029, -5836, 670, 7169, 13392, 19050, 23866, 27643, 30199, 31408, 31218, 29630, 26717, 22592, 17445, 11519, 5052, -1642, -8250, -14501, -20086, -24750, -28296, -30551, -31423, -30879, -28957, -25760, -21441, -16234, -10389, -4180, 2060, 8052, 13509, 18152, 21784, 24233, 25385, 25207, 23716, 21005, 17205, 12517, 7190, 1466, -4360, -9990, -15176, -19644, -23170, -25593, -26778, -26658, -25225, -22536, -18707, -13901, -8351, -2163};