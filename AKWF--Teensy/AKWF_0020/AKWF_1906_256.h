/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1906 256 samples */
 
const int16_t AKWF_1906_256_DATA [256] = 
{1460, 5470, 9299, 12956, 16346, 19465, 22336, 24899, 27167, 29079, 30608, 31745, 32480, 32772, 32598, 32039, 31207, 30213, 29188, 28227, 27436, 26855, 26452, 26197, 26059, 25993, 25950, 25882, 25744, 25541, 25309, 25053, 24779, 24493, 24204, 23917, 23638, 23368, 23101, 22835, 22572, 22309, 22047, 21782, 21519, 21256, 20992, 20728, 20464, 20200, 19937, 19673, 19410, 19147, 18885, 18622, 18359, 18097, 17836, 17574, 17311, 17050, 16789, 16527, 16264, 16003, 15743, 15481, 15219, 14958, 14696, 14437, 14178, 13916, 13655, 13396, 13135, 12875, 12617, 12358, 12098, 11839, 11579, 11322, 11063, 10803, 10544, 10285, 10026, 9768, 9509, 9251, 8992, 8733, 8476, 8218, 7960, 7702, 7444, 7188, 6931, 6673, 6416, 6159, 5904, 5646, 5389, 5133, 4876, 4621, 4364, 4106, 3850, 3594, 3337, 3081, 2825, 2569, 2314, 2057, 1803, 1549, 1292, 1037, 782, 527, 274, 19, -236, -490, -744, -999, -1252, -1508, -1763, -2016, -2272, -2526, -2779, -3034, -3289, -3544, -3797, -4052, -4305, -4561, -4815, -5068, -5322, -5576, -5830, -6083, -6336, -6589, -6843, -7095, -7348, -7603, -7856, -8109, -8363, -8617, -8871, -9125, -9377, -9630, -9884, -10138, -10391, -10644, -10896, -11149, -11403, -11655, -11908, -12161, -12414, -12666, -12919, -13171, -13424, -13677, -13929, -14183, -14437, -14689, -14941, -15195, -15448, -15701, -15954, -16205, -16458, -16711, -16963, -17216, -17468, -17720, -17973, -18225, -18478, -18732, -18984, -19236, -19489, -19742, -19996, -20248, -20500, -20754, -21008, -21261, -21513, -21765, -22017, -22268, -22518, -22770, -23023, -23278, -23535, -23799, -24076, -24357, -24635, -24902, -25152, -25377, -25572, -25705, -25751, -25751, -25758, -25830, -26021, -26379, -26935, -27729, -28762, -29926, -31070, -32096, -32633, -32632, -32609, -31860, -30430, -28529, -26189, -23477, -20442, -17196, -13779, -10188, -6402, -2408};