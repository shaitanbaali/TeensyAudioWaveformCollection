/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_2007 256 samples */
 
const int16_t AKWF_2007_256_DATA [256] = 
{861, 3415, 5858, 8234, 10515, 12689, 14739, 16645, 18401, 19993, 21414, 22710, 23888, 24942, 25883, 26708, 27419, 28023, 28522, 28922, 29227, 29443, 29574, 29629, 29611, 29528, 29387, 29194, 28954, 28675, 28362, 28023, 27662, 27285, 26897, 26504, 26083, 25598, 25056, 24464, 23824, 23145, 22435, 21699, 20946, 20186, 19422, 18665, 17923, 17204, 16515, 15865, 15259, 14705, 14212, 13784, 13427, 13148, 12948, 12835, 12809, 12876, 13056, 13354, 13761, 14269, 14870, 15552, 16302, 17112, 17967, 18851, 19755, 20663, 21558, 22431, 23267, 24047, 24764, 25402, 25947, 26392, 26722, 26928, 27001, 26934, 26721, 26355, 25840, 25183, 24387, 23465, 22425, 21275, 20032, 18705, 17306, 15851, 14354, 12824, 11285, 9743, 8214, 6718, 5262, 3861, 2531, 1280, 120, -933, -1876, -2700, -3394, -3976, -4458, -4841, -5129, -5327, -5438, -5471, -5428, -5318, -5147, -4922, -4651, -4343, -4003, -3642, -3265, -2883, -2502, -2129, -1774, -1442, -1139, -873, -649, -473, -341, -223, -114, -17, 65, 131, 179, 204, 205, 180, 125, 39, -79, -236, -431, -666, -943, -1264, -1630, -2044, -2504, -3013, -3573, -4180, -4838, -5545, -6316, -7171, -8107, -9111, -10180, -11308, -12477, -13688, -14927, -16179, -17442, -18702, -19943, -21162, -22344, -23476, -24555, -25566, -26498, -27346, -28100, -28751, -29295, -29723, -30030, -30214, -30255, -30153, -29914, -29550, -29069, -28482, -27803, -27043, -26216, -25340, -24423, -23483, -22539, -21599, -20682, -19804, -18976, -18213, -17530, -16937, -16446, -16068, -15812, -15685, -15695, -15852, -16165, -16628, -17231, -17958, -18796, -19733, -20748, -21825, -22949, -24095, -25247, -26385, -27487, -28535, -29511, -30390, -31159, -31798, -32288, -32615, -32764, -32721, -32474, -32013, -31333, -30429, -29314, -27997, -26483, -24791, -22936, -20924, -18781, -16522, -14159, -11719, -9221, -6680, -4124, -1517};