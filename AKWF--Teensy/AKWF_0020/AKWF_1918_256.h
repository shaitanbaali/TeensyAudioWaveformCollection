/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1918 256 samples */
 
const int16_t AKWF_1918_256_DATA [256] = 
{155, 439, 759, 1126, 1545, 2026, 2572, 3182, 3852, 4572, 5325, 6101, 6883, 7662, 8425, 9156, 9841, 10471, 11037, 11535, 11971, 12352, 12681, 12968, 13222, 13449, 13662, 13871, 14084, 14312, 14565, 14848, 15171, 15521, 15887, 16277, 16688, 17122, 17578, 18057, 18562, 19090, 19641, 20214, 20806, 21420, 22056, 22721, 23411, 24118, 24836, 25561, 26286, 26998, 27693, 28358, 28992, 29584, 30132, 30627, 31075, 31484, 31851, 32172, 32446, 32678, 32773, 32758, 32752, 32745, 32736, 32727, 32723, 32574, 32294, 31957, 31564, 31126, 30649, 30145, 29626, 29098, 28576, 28070, 27583, 27127, 26705, 26314, 25953, 25615, 25296, 24993, 24702, 24415, 24123, 23824, 23510, 23173, 22813, 22416, 21995, 21567, 21126, 20668, 20185, 19666, 19106, 18495, 17826, 17100, 16297, 15420, 14465, 13427, 12296, 11081, 9778, 8415, 7012, 5578, 4150, 2736, 1350, 21, -1232, -2403, -3462, -4429, -5306, -6095, -6803, -7434, -7991, -8489, -8930, -9324, -9679, -10001, -10302, -10587, -10862, -11106, -11316, -11503, -11669, -11825, -11979, -12135, -12305, -12496, -12714, -12969, -13261, -13598, -13984, -14407, -14869, -15371, -15907, -16480, -17087, -17723, -18386, -19072, -19777, -20504, -21243, -21992, -22771, -23573, -24395, -25228, -26058, -26873, -27663, -28416, -29124, -29775, -30360, -30869, -31295, -31639, -31898, -32080, -32188, -32230, -32215, -32150, -32047, -31912, -31756, -31588, -31414, -31244, -31078, -30908, -30729, -30541, -30346, -30142, -29931, -29714, -29486, -29248, -29002, -28744, -28475, -28192, -27905, -27618, -27331, -27035, -26728, -26401, -26048, -25661, -25235, -24769, -24253, -23679, -23051, -22360, -21607, -20805, -19944, -19042, -18108, -17147, -16177, -15207, -14237, -13287, -12361, -11469, -10626, -9813, -9024, -8266, -7536, -6837, -6177, -5542, -4940, -4373, -3841, -3336, -2866, -2421, -2011, -1650, -1335, -1054, -801, -564, -333, -92};