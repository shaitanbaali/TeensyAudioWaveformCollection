/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1997 256 samples */
 
const int16_t AKWF_1997_256_DATA [256] = 
{388, 1572, 2733, 3892, 5073, 6310, 7549, 8784, 10021, 11259, 12494, 13730, 14967, 16200, 17436, 18672, 19905, 21140, 22375, 23606, 24834, 26088, 27213, 27465, 27484, 27544, 27596, 27648, 27699, 27750, 27802, 27852, 27903, 27953, 28003, 28053, 28104, 28155, 28203, 28250, 28318, 27748, 26766, 25833, 24891, 23951, 23008, 22066, 21125, 20183, 19241, 18301, 17359, 16418, 15478, 14536, 13595, 12662, 11694, 10964, 10597, 10214, 9833, 9454, 9073, 8694, 8314, 7935, 7556, 7178, 6799, 6421, 6042, 5663, 5285, 4912, 4513, 4239, 4530, 4882, 5218, 5558, 5899, 6239, 6580, 6920, 7260, 7601, 7941, 8281, 8622, 8962, 9303, 9643, 9983, 10323, 10651, 10973, 11297, 11621, 11944, 12267, 12589, 12912, 13235, 13558, 13881, 14204, 14527, 14849, 15171, 15494, 15811, 16154, 16199, 15931, 15689, 15442, 15194, 14947, 14700, 14454, 14206, 13959, 13712, 13465, 13218, 12971, 12723, 12477, 12226, 11995, 11637, 10972, 10290, 9614, 8936, 8257, 7580, 6902, 6223, 5546, 4867, 4189, 3514, 2835, 2158, 1481, 804, 128, -549, -1251, -1960, -2664, -3372, -4078, -4784, -5490, -6196, -6900, -7607, -8311, -9017, -9722, -10425, -11131, -11835, -12537, -13245, -13811, -14273, -14748, -15221, -15693, -16165, -16638, -17108, -17580, -18051, -18522, -18993, -19465, -19935, -20406, -20877, -21345, -21822, -22252, -22613, -22976, -23338, -23700, -24062, -24424, -24785, -25148, -25509, -25869, -26230, -26591, -26952, -27314, -27674, -28033, -28398, -28739, -28974, -29195, -29418, -29641, -29865, -30086, -30310, -30533, -30755, -30978, -31200, -31422, -31645, -31866, -32088, -32307, -32531, -32748, -32169, -31227, -30347, -29454, -28563, -27670, -26776, -25886, -24993, -24100, -23211, -22319, -21427, -20537, -19645, -18753, -17861, -16980, -15958, -14783, -13618, -12450, -11286, -10118, -8953, -7789, -6622, -5457, -4294, -3129, -1970, -785};