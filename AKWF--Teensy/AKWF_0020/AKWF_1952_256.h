/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1952 256 samples */
 
const int16_t AKWF_1952_256_DATA [256] = 
{1698, 5601, 9159, 12412, 15309, 17835, 19995, 21796, 23284, 24500, 25490, 26309, 27006, 27618, 28181, 28717, 29236, 29741, 30227, 30677, 31080, 31417, 31673, 31837, 31906, 31877, 31756, 31555, 31287, 30967, 30612, 30235, 29845, 29449, 29047, 28633, 28200, 27734, 27222, 26652, 26012, 25296, 24506, 23644, 22722, 21761, 20780, 19807, 18874, 18002, 17222, 16556, 16016, 15616, 15356, 15231, 15232, 15343, 15544, 15815, 16133, 16481, 16836, 17189, 17527, 17842, 18131, 18394, 18626, 18833, 19012, 19160, 19274, 19347, 19372, 19335, 19228, 19038, 18756, 18370, 17881, 17283, 16580, 15779, 14891, 13929, 12912, 11853, 10773, 9690, 8612, 7557, 6533, 5539, 4585, 3665, 2773, 1909, 1060, 222, -611, -1453, -2305, -3171, -4060, -4974, -5913, -6879, -7871, -8882, -9912, -10951, -11980, -12990, -13953, -14843, -15633, -16282, -16754, -17011, -17014, -16729, -16126, -15189, -13910, -12287, -10347, -8121, -5650, -3005, -250, 2538, 5271, 7875, 10276, 12395, 14189, 15617, 16650, 17292, 17553, 17461, 17059, 16399, 15540, 14537, 13453, 12340, 11235, 10175, 9183, 8261, 7411, 6622, 5873, 5145, 4413, 3655, 2855, 2000, 1083, 108, -918, -1987, -3077, -4175, -5264, -6324, -7351, -8337, -9277, -10177, -11045, -11883, -12709, -13525, -14336, -15145, -15947, -16730, -17484, -18186, -18817, -19356, -19784, -20083, -20244, -20264, -20144, -19899, -19547, -19114, -18625, -18115, -17610, -17140, -16728, -16390, -16132, -15963, -15875, -15860, -15906, -16001, -16132, -16290, -16471, -16674, -16907, -17184, -17519, -17928, -18433, -19045, -19772, -20620, -21578, -22627, -23746, -24895, -26035, -27124, -28116, -28974, -29671, -30179, -30498, -30634, -30608, -30454, -30219, -29953, -29707, -29533, -29470, -29549, -29780, -30154, -30649, -31216, -31790, -32298, -32652, -32766, -32557, -31951, -30891, -29336, -27276, -24724, -21707, -18296, -14567, -10611, -6542, -2376};