/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1949 256 samples */
 
const int16_t AKWF_1949_256_DATA [256] = 
{1797, 5092, 8051, 10727, 13103, 15196, 17037, 18662, 20129, 21485, 22767, 24013, 25237, 26436, 27598, 28690, 29663, 30473, 31059, 31366, 31353, 30980, 30228, 29087, 27571, 25710, 23533, 21100, 18463, 15673, 12797, 9881, 6960, 4077, 1250, -1516, -4205, -6828, -9393, -11895, -14346, -16744, -19071, -21320, -23465, -25467, -27303, -28928, -30302, -31398, -32187, -32645, -32766, -32550, -32009, -31162, -30037, -28669, -27089, -25337, -23449, -21446, -19364, -17214, -15006, -12755, -10462, -8123, -5749, -3339, -897, 1554, 4007, 6439, 8812, 11103, 13281, 15303, 17150, 18790, 20202, 21380, 22313, 23003, 23462, 23706, 23751, 23619, 23333, 22912, 22373, 21730, 20993, 20164, 19246, 18239, 17135, 15941, 14651, 13267, 11801, 10262, 8665, 7035, 5390, 3755, 2163, 625, -831, -2188, -3444, -4588, -5619, -6549, -7384, -8134, -8816, -9441, -10018, -10560, -11066, -11538, -11974, -12365, -12704, -12983, -13189, -13318, -13363, -13325, -13204, -13007, -12746, -12429, -12071, -11686, -11282, -10873, -10462, -10050, -9637, -9217, -8779, -8312, -7808, -7248, -6627, -5937, -5171, -4331, -3422, -2446, -1418, -349, 751, 1868, 2989, 4111, 5221, 6317, 7401, 8468, 9520, 10562, 11586, 12595, 13584, 14540, 15452, 16309, 17090, 17778, 18357, 18808, 19119, 19278, 19281, 19125, 18811, 18347, 17741, 17001, 16142, 15168, 14088, 12909, 11627, 10244, 8759, 7162, 5456, 3637, 1703, -328, -2448, -4642, -6874, -9120, -11347, -13512, -15587, -17542, -19343, -20983, -22451, -23743, -24875, -25862, -26725, -27492, -28184, -28820, -29416, -29972, -30479, -30920, -31261, -31465, -31488, -31285, -30818, -30054, -28977, -27590, -25909, -23988, -21884, -19680, -17482, -15392, -13514, -11960, -10812, -10138, -9983, -10355, -11231, -12549, -14230, -16157, -18190, -20197, -22024, -23533, -24604, -25139, -25067, -24356, -23006, -21058, -18566, -15632, -12367, -8882, -5312, -1694};