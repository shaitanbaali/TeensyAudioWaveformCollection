/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1905 256 samples */
 
const int16_t AKWF_1905_256_DATA [256] = 
{5465, 14941, 23070, 29599, 32757, 32743, 32744, 32782, 30741, 27104, 23555, 20365, 18023, 16503, 15540, 15080, 15020, 15230, 15576, 15918, 16127, 16200, 16271, 16348, 16422, 16492, 16554, 16608, 16654, 16687, 16698, 16682, 16641, 16577, 16494, 16392, 16278, 16152, 16010, 15852, 15679, 15495, 15306, 15111, 14915, 14724, 14533, 14346, 14160, 13977, 13796, 13618, 13440, 13266, 13092, 12920, 12752, 12586, 12421, 12258, 12093, 11928, 11762, 11595, 11427, 11259, 11090, 10919, 10748, 10575, 10403, 10228, 10052, 9874, 9697, 9520, 9340, 9160, 8979, 8798, 8617, 8435, 8253, 8071, 7887, 7703, 7521, 7337, 7154, 6972, 6788, 6605, 6422, 6238, 6055, 5871, 5687, 5503, 5320, 5135, 4952, 4767, 4583, 4399, 4214, 4029, 3844, 3661, 3476, 3291, 3106, 2920, 2736, 2551, 2365, 2180, 1994, 1808, 1622, 1436, 1251, 1067, 882, 698, 514, 328, 145, -39, -224, -408, -592, -776, -961, -1145, -1329, -1513, -1696, -1882, -2066, -2251, -2436, -2620, -2804, -2988, -3172, -3354, -3538, -3721, -3904, -4087, -4269, -4451, -4633, -4815, -4997, -5177, -5358, -5539, -5721, -5900, -6081, -6260, -6440, -6620, -6800, -6979, -7158, -7335, -7515, -7694, -7872, -8050, -8226, -8403, -8581, -8757, -8932, -9107, -9281, -9453, -9627, -9800, -9972, -10141, -10310, -10477, -10643, -10807, -10970, -11131, -11294, -11455, -11614, -11775, -11934, -12094, -12252, -12410, -12571, -12730, -12895, -13064, -13233, -13409, -13585, -13763, -13943, -14123, -14305, -14487, -14666, -14846, -15029, -15207, -15379, -15540, -15685, -15813, -15915, -15996, -16059, -16107, -16137, -16144, -16131, -16091, -16029, -15943, -15828, -15691, -15552, -15433, -15354, -15335, -15401, -15565, -15742, -15880, -16052, -16336, -16811, -17550, -18615, -19997, -21905, -24489, -27399, -30314, -32010, -32001, -32076, -31469, -27589, -21322, -13278, -3861};