/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw7bit 256 samples */
 
const int16_t AKWF_saw7bit_256_DATA [256] = 
{889, 890, 892, 915, 788, 1491, 2324, 2194, 2237, 2138, 2618, 3614, 3531, 3545, 3557, 3491, 4581, 4937, 4865, 4829, 5031, 6187, 6199, 6191, 6217, 6085, 6918, 7619, 7491, 7537, 7412, 8074, 8940, 8810, 8851, 8747, 9234, 10240, 10133, 10164, 10088, 10406, 11514, 11460, 11474, 11429, 11597, 12759, 12793, 12778, 12787, 12735, 12933, 14087, 14097, 14109, 13989, 14611, 15509, 15381, 15417, 15319, 15765, 16795, 16696, 16721, 16651, 16931, 18054, 18016, 18016, 18035, 17908, 18821, 19423, 19300, 19342, 19207, 19963, 20736, 20602, 20642, 20522, 21102, 22032, 21905, 21937, 21852, 22216, 23274, 23219, 23222, 23236, 23130, 24145, 24608, 24502, 24538, 24406, 25284, 25923, 25795, 25835, 25701, 26417, 27226, 27089, 27125, 27009, 27550, 28507, 28384, 28415, 28324, 28691, 29766, 29685, 29691, 29703, 29588, 30573, 31074, 30962, 30996, 30865, 31386, 33406, 28499, -29003, -33822, -32414, -31510, -31428, -31452, -31452, -31448, -30294, -30075, -30125, -30093, -30199, -29650, -28680, -28792, -28750, -28829, -28449, -27363, -27429, -27401, -27448, -27224, -26066, -26058, -26051, -26067, -25975, -24794, -24678, -24699, -24686, -24705, -23601, -23288, -23348, -23311, -23407, -22894, -21894, -21997, -21957, -22028, -21683, -20575, -20628, -20604, -20643, -20452, -19284, -19255, -19254, -19263, -19200, -18024, -17878, -17908, -17872, -17990, -17341, -16450, -16571, -16526, -16619, -16144, -15120, -15214, -15181, -15237, -14966, -13849, -13846, -13844, -13815, -13931, -12994, -12404, -12514, -12465, -12591, -11809, -11045, -11172, -11122, -11236, -10627, -9706, -9825, -9783, -9873, -9439, -8389, -8476, -8445, -8505, -8235, -7098, -7121, -7111, -7140, -7012, -5838, -5763, -5782, -5752, -5871, -5182, -4349, -4461, -4435, -4445, -4408, -3240, -3069, -3095, -3172, -2777, -1706, -1784, -1759, -1814, -1579, -430, -438, -438, -436, -437};