/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw6bit 256 samples */
 
const int16_t AKWF_saw6bit_256_DATA [256] = 
{1520, 1523, 1524, 1524, 1524, 1524, 1524, 1524, 1562, 1351, 2384, 4305, 4086, 4126, 4126, 4126, 4126, 4124, 4124, 4164, 3944, 5862, 6896, 6684, 6721, 6721, 6720, 6719, 6716, 6726, 6673, 6863, 9164, 9354, 9300, 9309, 9307, 9305, 9304, 9301, 9338, 9124, 10156, 12075, 11853, 11891, 11889, 11886, 11883, 11881, 11879, 11916, 11693, 13612, 14642, 14428, 14464, 14461, 14457, 14454, 14451, 14458, 14403, 14590, 16890, 17077, 17021, 17028, 17024, 17020, 17016, 17013, 17036, 16877, 18971, 19738, 19564, 19590, 19584, 19581, 19575, 19572, 19566, 19601, 19378, 21292, 22323, 22106, 22139, 22133, 22129, 22124, 22118, 22158, 21909, 23206, 24902, 24645, 24686, 24681, 24675, 24669, 24663, 24658, 24679, 24518, 26608, 27374, 27199, 27222, 27214, 27209, 27202, 27195, 27189, 27222, 26996, 28909, 29936, 29717, 29749, 29742, 29734, 29727, 29720, 29491, 30564, 26949, -28388, -31208, -29915, -30182, -30181, -30183, -30182, -30182, -30181, -30136, -30369, -29020, -27387, -27606, -27561, -27556, -27552, -27547, -27541, -27536, -27516, -27610, -25428, -24795, -24932, -24901, -24893, -24887, -24881, -24875, -24848, -24964, -24432, -22203, -22248, -22239, -22229, -22222, -22216, -22211, -22205, -22155, -22385, -21032, -19395, -19612, -19566, -19559, -19553, -19548, -19542, -19535, -19514, -19610, -17429, -16796, -16933, -16902, -16896, -16892, -16887, -16881, -16830, -17076, -15368, -14062, -14300, -14250, -14246, -14241, -14237, -14232, -14223, -14233, -14203, -11929, -11530, -11622, -11600, -11596, -11593, -11590, -11586, -11552, -11719, -10943, -8843, -8993, -8963, -8960, -8957, -8953, -8950, -8947, -8897, -9145, -7441, -6136, -6377, -6329, -6327, -6324, -6321, -6319, -6312, -6324, -6296, -4024, -3627, -3722, -3702, -3701, -3700, -3699, -3697, -3664, -3833, -3061, -962, -1114, -1086, -1085, -1083, -1084, -1082, -1080, -1081, -1080};