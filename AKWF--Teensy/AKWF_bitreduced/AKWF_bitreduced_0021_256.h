/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0021 256 samples */
 
const int16_t AKWF_bitreduced_0021_256_DATA [256] = 
{6868, 6872, 6874, 6875, 6877, 6879, 6879, 6882, 7016, 6249, 16693, 20534, 19689, 19839, 19838, 19835, 19833, 19830, 19828, 19824, 19821, 20041, 18838, 26250, 33688, 32552, 32754, 32752, 32745, 32739, 32732, 32726, 32719, 32713, 32706, 32700, 32692, 32684, 32678, 32669, 32662, 32653, 32646, 32638, 32630, 32622, 32613, 32605, 32596, 32589, 32580, 32571, 32563, 32555, 32547, 32538, 32529, 32521, 32512, 32503, 32495, 32487, 32478, 32470, 32461, 32452, 32444, 32435, 32426, 32418, 32409, 32401, 32392, 32383, 32374, 32366, 32357, 32348, 32340, 32331, 32323, 32314, 32305, 32297, 32288, 32279, 32271, 32218, 32410, 31704, 20243, 19010, 19322, 19253, 19246, 19237, 19231, 19224, 19217, 19211, 19205, 19177, 19216, 19185, 7921, 5795, 6302, 6204, 6200, 6195, 6191, 6188, 6184, 6180, 6177, 6173, 6171, 6168, 6165, 6163, 6160, 5973, 6988, -2853, -7624, -6629, -6811, -6811, -6813, -6814, -6813, -6813, -6813, -6813, -6814, -6811, -6810, -6811, -6810, -6808, -6808, -6806, -6804, -6805, -6803, -6802, -6800, -6799, -6797, -6796, -6793, -7010, -5837, -11939, -20741, -19518, -19743, -19740, -19737, -19734, -19731, -19726, -19723, -19720, -19715, -19711, -19707, -19702, -19698, -19929, -18665, -25897, -33673, -32397, -32628, -32622, -32615, -32609, -32602, -32596, -32589, -32583, -32575, -32567, -32561, -32552, -32545, -32536, -32529, -32521, -32513, -32505, -32497, -32489, -32481, -32472, -32463, -32456, -32447, -32438, -32430, -32422, -32413, -32405, -32396, -32387, -32379, -32371, -32362, -32354, -32345, -32336, -32328, -32319, -32310, -32302, -32293, -32284, -32276, -32267, -32258, -32250, -32241, -32232, -32224, -32215, -32207, -32199, -32190, -32181, -32173, -32163, -32016, -32801, -22840, -18459, -19317, -19155, -19148, -19139, -19133, -19126, -19120, -19113, -19067, -19233, -18652, -7209, -5839, -6185, -6112, -6109, -6104, -6100, -6096, -6092};