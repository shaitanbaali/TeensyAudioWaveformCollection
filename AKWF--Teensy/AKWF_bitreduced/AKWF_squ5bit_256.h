/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ5bit 256 samples */
 
const int16_t AKWF_squ5bit_256_DATA [256] = 
{32742, 32748, 32752, 32756, 32758, 32760, 32759, 32760, 32759, 32757, 32754, 32751, 32748, 32744, 32740, 32734, 32729, 32724, 32717, 32711, 32705, 32698, 32692, 32686, 32677, 32671, 32663, 32655, 32648, 32640, 32632, 32624, 32616, 32609, 32600, 32592, 32583, 32576, 32567, 32559, 32551, 32542, 32534, 32526, 32517, 32508, 32500, 32491, 32483, 32474, 32466, 32456, 32448, 32440, 32432, 32423, 32414, 32405, 32397, 32387, 32379, 32371, 32362, 32353, 32345, 32336, 32327, 32319, 32310, 32301, 32293, 32284, 32276, 32268, 32258, 32250, 32242, 32232, 32224, 32215, 32206, 32197, 32189, 32181, 32171, 32163, 32155, 32146, 32138, 32129, 32120, 32112, 32103, 32094, 32086, 32077, 32069, 32060, 32052, 32043, 32034, 32025, 32017, 32008, 32000, 31991, 31982, 31974, 31965, 31957, 31948, 31939, 31931, 31923, 31914, 31906, 31897, 31888, 31880, 31871, 31862, 31854, 31845, 31837, 31829, 31167, 34600, 17319, -33024, -32789, -32616, -32764, -32766, -32768, -32767, -32768, -32767, -32765, -32762, -32759, -32756, -32752, -32748, -32742, -32737, -32732, -32726, -32719, -32713, -32706, -32700, -32694, -32685, -32679, -32670, -32663, -32656, -32648, -32640, -32633, -32624, -32617, -32608, -32600, -32592, -32584, -32575, -32567, -32559, -32551, -32542, -32533, -32524, -32516, -32508, -32499, -32491, -32482, -32474, -32464, -32456, -32448, -32438, -32430, -32422, -32413, -32405, -32396, -32387, -32379, -32370, -32361, -32353, -32344, -32335, -32327, -32319, -32309, -32301, -32292, -32283, -32274, -32266, -32258, -32248, -32240, -32232, -32223, -32214, -32205, -32197, -32189, -32180, -32171, -32163, -32154, -32145, -32137, -32129, -32119, -32111, -32102, -32094, -32085, -32076, -32068, -32059, -32051, -32042, -32033, -32025, -32016, -32007, -31999, -31990, -31982, -31973, -31964, -31956, -31948, -31939, -31931, -31921, -31913, -31905, -31897, -31888, -31879, -31870, -31862, -31854, -31845, -31837, -31319, -34048, -19357};