/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin6bit 256 samples */
 
const int16_t AKWF_sin6bit_256_DATA [256] = 
{1624, 1672, 1424, 3167, 4463, 4085, 4726, 6929, 6871, 6727, 8834, 9614, 9424, 9500, 11788, 12199, 11851, 13398, 14893, 14675, 14501, 16426, 17462, 17290, 17090, 18318, 20089, 19861, 19786, 20275, 22517, 22479, 22521, 22272, 23614, 25282, 25023, 25071, 25056, 25055, 27318, 27740, 27631, 27644, 27654, 27564, 27892, 30179, 30242, 30212, 30211, 30204, 30197, 30190, 30183, 30176, 30168, 30193, 30003, 30844, 32895, 32710, 32734, 32727, 32718, 32711, 32665, 32858, 31889, 29897, 30095, 30049, 30041, 30033, 30024, 30016, 30008, 30000, 29991, 29935, 30184, 28643, 27140, 27388, 27331, 27323, 27278, 27480, 25623, 24514, 24710, 24644, 24754, 24254, 22000, 22027, 21974, 22211, 20860, 19178, 19426, 19344, 19503, 17413, 16596, 16719, 16935, 15471, 13883, 14219, 13830, 11530, 11416, 11661, 9752, 8669, 8868, 8925, 6736, 6058, 6435, 5177, 3390, 3671, 3496, 1241, 868, 1194, -531, -1885, -1394, -3182, -4452, -4243, -4121, -6204, -7044, -6714, -8850, -9627, -9438, -9515, -11803, -12213, -11866, -13414, -14907, -14690, -14516, -16441, -17477, -17306, -17105, -18333, -20104, -19854, -19933, -19732, -21738, -22657, -22503, -22287, -23628, -25297, -25038, -25086, -25071, -25070, -27333, -27755, -27646, -27659, -27669, -27579, -27908, -30194, -30257, -30226, -30226, -30219, -30211, -30205, -30197, -30190, -30183, -30208, -30017, -30858, -32910, -32726, -32749, -32740, -32733, -32725, -32680, -32873, -31904, -29912, -30109, -30064, -30055, -30047, -30039, -30031, -30022, -30015, -30007, -29950, -30198, -28658, -27155, -27401, -27346, -27338, -27292, -27497, -25534, -24527, -24725, -24680, -24637, -24827, -22810, -21880, -22055, -22073, -21846, -19529, -19335, -19496, -18955, -16759, -16750, -16764, -16728, -14444, -14026, -14202, -13845, -11545, -11430, -11677, -9766, -8685, -8883, -8940, -6751, -6109, -6289, -6120, -3799, -3595, -3491, -1166, -945, -1001};