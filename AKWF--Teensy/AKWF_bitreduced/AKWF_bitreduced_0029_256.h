/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0029 256 samples */
 
const int16_t AKWF_bitreduced_0029_256_DATA [256] = 
{10007, 10010, 10013, 10015, 10015, 10017, 10017, 10017, 10017, 10017, 10017, 10017, 10016, 10015, 10013, 10012, 10011, 10010, 10008, 10005, 10003, 10002, 10000, 9998, 9996, 9994, 9992, 9989, 9987, 9986, 9983, 9980, 9978, 9975, 9973, 9971, 9968, 9966, 9964, 9960, 9957, 9955, 9952, 9950, 9948, 9945, 9943, 9940, 9937, 9934, 9931, 9929, 9927, 9924, 9921, 9537, 11596, 856, -14636, -12491, -12889, -12891, -12699, -13777, -9181, 10302, 9852, 9885, 9906, 9906, 9905, 9904, 9904, 9902, 9900, 9899, 9897, 9896, 9838, 10045, 9442, -10586, -13507, -12775, -12912, -12912, -12912, -12913, -12912, -12911, -12521, -14616, -3540, 11665, 9490, 9895, 9896, 9896, 9896, 9895, 9894, 9894, 9893, 9892, 9890, 9889, 9505, 11577, -4469, -14535, -12551, -12916, -12916, -12916, -12917, -12915, -12915, -12913, -12912, -12910, -12908, -12906, -12904, -12902, -12900, -12897, -12894, -12892, -12889, -12886, -12884, -12881, -12878, -12876, -12872, -12868, -12866, -12863, -12860, -12857, -12854, -12850, -12846, -12425, -14656, -1280, 11776, 9550, 9968, 9970, 9971, 9972, 9973, 9973, 9973, 9972, 9971, 10064, 9606, 11283, 31452, 33128, 32668, 32759, 32755, 32751, 32746, 32740, 32398, 34245, 25181, 8347, 10264, 9908, 9903, 9898, 9894, 9889, 9884, 9880, 9876, 9873, 9869, 9866, 9861, 9858, 9855, 9438, 11650, -2965, -14710, -12557, -12960, -12961, -12961, -12963, -12962, -12960, -12961, -12960, -12958, -12957, -12956, -12954, -12952, -12950, -12949, -12946, -12943, -12940, -12938, -12936, -12933, -12930, -12928, -12925, -12922, -12918, -12915, -12912, -12910, -12906, -12903, -12900, -12896, -12893, -12890, -12887, -12883, -12880, -12877, -12873, -12870, -12867, -12863, -12860, -12857, -12854, -12851, -12846, -12843, -12839, -12836, -12833, -12830, -12826, -12822, -12819, -12816, -12812, -12809, -12806, -12803, -12798, -12795, -12792};