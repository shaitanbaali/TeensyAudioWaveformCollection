/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri3bit 256 samples */
 
const int16_t AKWF_tri3bit_256_DATA [256] = 
{11078, 11079, 11082, 11083, 11083, 11085, 11085, 11085, 11084, 11083, 11083, 11081, 11080, 11079, 11077, 11076, 11074, 11073, 11071, 11068, 11066, 11063, 11061, 11059, 11056, 11054, 11052, 11049, 11047, 11044, 11041, 11039, 11036, 11033, 11031, 11028, 11025, 11022, 11020, 11017, 11014, 11011, 11008, 11005, 11003, 10999, 10997, 10994, 10991, 10988, 10985, 10982, 11046, 10754, 11715, 30919, 33210, 32614, 32723, 32719, 32714, 32708, 32702, 32696, 32690, 32683, 32676, 32670, 32662, 32655, 32647, 32267, 34277, 19213, 9276, 11202, 10838, 10832, 10827, 10820, 10815, 10811, 10806, 10801, 10797, 10792, 10787, 10783, 10779, 10775, 10771, 10768, 10763, 10760, 10756, 10753, 10750, 10746, 10743, 10740, 10736, 10733, 10730, 10726, 10723, 10720, 10717, 10715, 10711, 10708, 10705, 10702, 10699, 10696, 10693, 10690, 10687, 10684, 10682, 10678, 10675, 10673, 10670, 10666, 10664, 10580, 10936, 9676, -9114, -11582, -11000, -11117, -11118, -11117, -11117, -11117, -11117, -11118, -11117, -11115, -11114, -11113, -11111, -11110, -11108, -11107, -11104, -11102, -11101, -11098, -11096, -11093, -11091, -11089, -11085, -11083, -11081, -11078, -11075, -11073, -11070, -11067, -11064, -11061, -11059, -11056, -11053, -11050, -11048, -11044, -11042, -11039, -11036, -11033, -11030, -11027, -11025, -11021, -11018, -11016, -11073, -10845, -11518, -30178, -33358, -32623, -32757, -32753, -32747, -32741, -32735, -32729, -32723, -32716, -32710, -32703, -32695, -32688, -32681, -32315, -34248, -20097, -9391, -11215, -10873, -10866, -10860, -10855, -10849, -10843, -10839, -10834, -10829, -10825, -10820, -10816, -10813, -10808, -10804, -10801, -10797, -10793, -10790, -10786, -10783, -10779, -10776, -10773, -10770, -10766, -10763, -10760, -10757, -10753, -10750, -10747, -10744, -10742, -10738, -10735, -10732, -10729, -10726, -10724, -10720, -10717, -10714, -10711, -10709, -10705, -10702, -10700, -10697, -10694, -10691, -10688};