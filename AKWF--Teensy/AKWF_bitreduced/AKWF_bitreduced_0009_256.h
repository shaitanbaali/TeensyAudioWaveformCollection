/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0009 256 samples */
 
const int16_t AKWF_bitreduced_0009_256_DATA [256] = 
{5460, 5556, 5035, 8678, 11331, 10890, 10636, 14989, 16685, 16415, 15950, 19001, 22281, 21745, 21859, 21809, 21953, 26749, 27448, 27272, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27245, 27586, 26044, 21599, 21897, 21810, 21998, 21228, 16544, 16271, 16711, 14922, 10612, 10974, 11016, 6349, 5151, 5926, 3067, -432, 3, 418, -3291, -5863, -5428, -5185, -9380, -11222, -10857, -10981, -10653, -12119, -16607, -16337, -16381, -16382, -16382, -16382, -16448, -16080, -17776, -22132, -21784, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21792, -22093, -20775, -16206, -16416, -16385, -16382, -16382, -16382, -16443, -16101, -17644, -22092, -21794, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21917, -21522, -23373, -27627, -27235, -27305, -27305, -27329, -27216, -27636, -32360, -32865, -32742, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32699, -33081, -31307, -27001, -27372, -27306, -27305, -27209, -27726, -24913, -21414, -21944, -21845, -21845, -21845, -21845, -21746, -22277, -19227, -15947, -16483, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16296, -16769, -12800, -10551, -11006, -10922, -10841, -11287, -7197, -5103, -5518, -5583, -949, 223, -49, 0};