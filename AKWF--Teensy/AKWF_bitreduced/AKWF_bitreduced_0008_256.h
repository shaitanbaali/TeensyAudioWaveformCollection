/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0008 256 samples */
 
const int16_t AKWF_bitreduced_0008_256_DATA [256] = 
{5162, 9079, 11607, 16040, 16458, 16362, 16382, 16329, 16629, 15312, 10746, 10944, 10952, 10852, 6069, 5306, 5434, 5741, 4199, -247, 51, 0, -80, 358, -3508, -5808, -5384, -5460, -5460, -5460, -5460, -5460, -5557, -5040, -7854, -11354, -10823, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10920, -10889, -11099, -6531, -5214, -5514, -5460, -5460, -5460, -5460, -5366, -5875, -3143, 428, -98, 7, -2, -33, 4686, 5677, 5298, 5916, 10736, 11033, 10647, 12055, 16583, 16342, 16380, 16380, 16342, 16545, 12157, 10187, 4575, -2214, -13457, -20260, -23808, -30640, -33097, -32670, -32767, -32721, -32980, -31878, -27114, -27743, -24068, -21545, -21531, -16512, -16745, -13859, -10457, -11154, -10417, -5507, -5848, -2770, 398, 9, 4943, 5401, 9819, 10888, 12192, 16649, 16307, 16447, 16072, 11546, 7531, -1619, -13355, -22028, -28164, -32308, -32854, -32745, -32741, -32876, -32360, -27435, -27668, -24773, -21418, -21955, -17248, -16092, -16859, -13690, -10487, -10936, -11310, -7339, -5086, -5510, -5637, -1071, 265, -120, 227, 5052, 5662, 5023, 8321, 11309, 10840, 10936, 10824, 15344, 16604, 16333, 16382, 16382, 16382, 16382, 16382, 16382, 16370, 16409, 16312, 11531, 10768, 10957, 10922, 10922, 10838, 11298, 7267, 5097, 5541, 5460, 5460, 5460, 5460, 5534, 5123, 9325, 11256, 10848, 10922, 10922, 11019, 10497, 13389, 16816, 16282, 16382, 16382, 16382, 16382, 16382, 16382, 16382, 16347, 16536, 15773, 10992, 10894, 10917, 10978, 10736, 5916, 5298, 5677, 4686, -33, -8, -6, 94, -4572, -5673, -5463, -5237, -6409, -11045, -10911, -10908, -10923, -15665, -16560, -16435, -15977, -19822, -22323, -21361, -25355, -27772, -26833, -30889, -33139, -32684, -32767, -32767, -32767, -32668, -33133, -30066, -25458, -21466, -16398, -9481, -567};