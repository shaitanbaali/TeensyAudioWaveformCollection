/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0028 256 samples */
 
const int16_t AKWF_bitreduced_0028_256_DATA [256] = 
{10462, 10464, 10466, 10468, 10469, 10470, 10471, 10471, 10471, 10470, 10469, 10469, 10468, 10467, 10465, 10464, 10462, 10460, 10611, 9781, 13162, 32626, 32839, 32718, 32756, 32751, 32746, 32742, 32737, 32731, 32725, 32718, 32612, 33104, 31225, 11483, 10059, 10449, 10359, 10354, 10348, 10343, 10339, 10333, 10329, 10326, 10321, 10316, 10313, 10309, 10305, 10302, 10298, 10295, 10292, 10288, 9877, 12054, -1953, -13772, -11641, -12040, -12042, -12043, -12042, -12042, -12042, -12043, -12041, -12041, -12039, -12038, -12036, -12035, -12033, -12031, -12029, -12027, -12025, -12022, -12020, -12017, -12015, -12013, -12010, -12007, -12005, -12001, -11998, -11995, -11992, -11989, -11987, -11983, -11981, -11978, -11975, -11971, -11968, -11965, -11963, -11960, -11957, -11953, -11949, -11946, -11943, -11940, -11937, -11934, -11931, -11928, -11925, -11922, -11919, -11916, -11912, -11909, -11905, -11902, -11899, -11896, -11893, -11710, -12705, -8490, 10695, 10411, 10410, 10438, 10439, 10440, 10441, 10441, 10441, 10439, 10439, 10439, 10437, 10437, 10435, 10433, 10432, 10430, 10428, 10426, 10424, 10422, 10420, 10417, 10416, 10414, 10411, 10409, 10407, 10404, 10402, 10399, 10396, 10394, 10392, 10389, 10387, 10383, 10380, 10378, 10376, 10373, 10370, 10368, 10365, 10362, 10360, 10357, 10354, 10351, 10349, 10346, 10343, 10341, 10338, 10335, 10331, 10329, 10327, 10323, 10321, 10318, 10012, 11688, -5480, -13370, -11706, -12008, -12009, -12008, -12008, -12008, -12009, -12008, -12007, -12005, -12004, -12002, -12000, -11998, -11997, -11994, -11993, -11990, -11988, -11986, -11983, -11980, -11978, -11975, -11973, -11970, -11967, -11964, -11962, -11959, -11956, -11952, -11949, -11946, -11943, -11940, -11937, -11935, -11932, -11928, -11925, -11922, -11919, -11916, -11913, -11910, -11907, -11903, -11900, -11897, -11894, -11891, -11887, -11884, -11881, -11878, -11875, -11872, -11869, -11866, -11862, -11858, -11855, -11852};