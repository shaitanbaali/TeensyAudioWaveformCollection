/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0036 256 samples */
 
const int16_t AKWF_bitreduced_0036_256_DATA [256] = 
{14708, 14712, 14715, 14716, 14718, 14719, 14720, 14720, 14720, 14718, 14718, 14717, 14715, 14714, 14712, 14711, 14707, 14705, 14703, 14700, 14698, 14694, 14691, 14689, 14686, 14683, 14679, 14676, 14673, 14669, 14665, 14662, 14658, 14655, 14650, 14647, 14644, 14640, 14636, 14632, 14629, 14625, 14621, 14618, 14614, 14610, 14607, 14602, 14598, 14594, 14591, 14587, 14583, 14580, 14575, 14572, 14567, 14564, 14559, 14556, 14552, 14548, 14544, 14540, 14537, 14532, 14529, 14525, 14522, 14516, 14513, 14509, 14505, 14502, 14498, 14494, 14489, 14486, 14482, 14478, 14474, 14471, 14466, 14462, 14459, 14455, 14451, 14447, 14444, 14439, 14435, 14432, 14428, 14424, 14420, 14417, 14412, 14409, 14404, 14401, 14396, 14393, 14390, 14385, 14382, 14377, 14374, 14369, 14366, 14362, 14358, 14354, 14351, 14347, 14343, 14340, 14335, 14331, 14327, 14324, 14320, 14316, 14312, 14309, 14304, 14204, 14673, 12933, -7956, -9696, -9226, -9325, -9326, -9328, -9329, -9328, -9329, -9330, -9328, -9329, -9329, -9328, -9327, -9326, -9325, -9323, -9321, -9320, -9318, -9317, -9315, -9314, -9312, -9309, -9307, -9305, -9304, -9301, -9300, -9297, -9294, -9292, -9291, -9288, -9286, -9283, -9281, -9279, -9277, -9274, -9272, -9268, -9266, -9265, -9263, -9260, -9258, -9255, -9252, -9250, -9247, -9245, -9242, -9240, -9238, -9236, -9233, -9231, -9228, -9225, -9223, -9221, -9218, -9215, -9213, -9210, -9208, -9205, -9203, -9201, -9199, -9196, -9194, -9191, -9188, -9186, -9184, -9181, -9179, -9176, -9173, -9171, -9168, -9599, -7283, -21777, -34617, -32337, -32758, -32753, -32748, -32743, -32738, -32732, -32725, -32720, -32713, -32706, -32699, -32692, -32685, -32678, -32670, -32662, -32655, -32647, -32638, -32631, -32623, -32615, -32607, -32598, -32428, -33298, -29709, -9107, -8870, -8989, -8937, -8930, -8925, -8920, -8915, -8910, -8905, -8900};