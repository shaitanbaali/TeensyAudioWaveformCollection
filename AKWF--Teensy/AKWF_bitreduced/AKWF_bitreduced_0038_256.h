/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0038 256 samples */
 
const int16_t AKWF_bitreduced_0038_256_DATA [256] = 
{11271, 11273, 11274, 11276, 11277, 11277, 11277, 11277, 11277, 11276, 11275, 11274, 11273, 11271, 11270, 11268, 11266, 11265, 11263, 11260, 11258, 11255, 11253, 11251, 11248, 11246, 11244, 11241, 11238, 11236, 11233, 11230, 11228, 11225, 11222, 11219, 11216, 11213, 11211, 11207, 11205, 11202, 11199, 11196, 11193, 11190, 11187, 11184, 11181, 11178, 11176, 11173, 11169, 11166, 11163, 11161, 11158, 11154, 11151, 11148, 11146, 11143, 11140, 11137, 11135, 11132, 11129, 11126, 11122, 11120, 11117, 11114, 11111, 11108, 11105, 11102, 11099, 11096, 11093, 11090, 11087, 11084, 11081, 11078, 11075, 11072, 11069, 11066, 11063, 11060, 11057, 11054, 11051, 11048, 11045, 11042, 11040, 11036, 11033, 11030, 11027, 11025, 11021, 11018, 11015, 11013, 11010, 11007, 11004, 11001, 11051, 10849, 11420, 30547, 33333, 32629, 32755, 32751, 32746, 32740, 32734, 32182, 35222, 21070, -13274, -10327, -10857, -10861, -10865, -10867, -10869, -10871, -11253, -9202, -24000, -34257, -32287, -32649, -32647, -32644, -32509, -33205, -30412, -11277, -10698, -10893, -10835, -10832, -10827, -10824, -10820, -10816, -10813, -10811, -10807, -10803, -10800, -10797, -10793, -10790, -10787, -10783, -10780, -10777, -10774, -10771, -10768, -10765, -10762, -10758, -10756, -10753, -10750, -10747, -10744, -10741, -10738, -10735, -10732, -10729, -10726, -10723, -10721, -10717, -10714, -10712, -10709, -10705, -10703, -10700, -10697, -10694, -10691, -10688, -10686, -10683, -10679, -10677, -10674, -10671, -10668, -10665, -10662, -10660, -10656, -10654, -10651, -10648, -10645, -10642, -10639, -10637, -10633, -10631, -10628, -10625, -10622, -10619, -10616, -10614, -10611, -10608, -10605, -10603, -10599, -10596, -10594, -10590, -10588, -10585, -10582, -10579, -10577, -10574, -10571, -10568, -10565, -10562, -10560, -10556, -10554, -10551, -10548, -10545, -10542, -10540, -10537, -10534, -10531, -10529, -10525, -10523, -10520, -10517, -10514, -10511};