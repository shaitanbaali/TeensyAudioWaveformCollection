/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ7bit 256 samples */
 
const int16_t AKWF_squ7bit_256_DATA [256] = 
{32744, 32750, 32755, 32758, 32761, 32763, 32762, 32762, 32761, 32759, 32757, 32754, 32750, 32746, 32742, 32736, 32733, 32726, 32720, 32714, 32709, 32701, 32694, 32688, 32679, 32673, 32665, 32658, 32650, 32642, 32635, 32627, 32619, 32611, 32603, 32594, 32586, 32578, 32569, 32562, 32553, 32544, 32537, 32527, 32519, 32511, 32502, 32493, 32485, 32477, 32468, 32459, 32451, 32442, 32433, 32425, 32416, 32408, 32399, 32390, 32381, 32373, 32365, 32356, 32347, 32338, 32330, 32321, 32313, 32303, 32295, 32287, 32278, 32269, 32260, 32252, 32244, 32235, 32226, 32217, 32209, 32201, 32192, 32183, 32174, 32166, 32157, 32149, 32139, 32131, 32123, 32114, 32105, 32096, 32089, 32080, 32071, 32062, 32054, 32045, 32037, 32027, 32019, 32011, 32002, 31993, 31985, 31977, 31968, 31959, 31951, 31942, 31933, 31925, 31917, 31908, 31899, 31890, 31883, 31874, 31865, 31857, 31848, 31839, 31830, 31140, 34740, 16486, -33332, -32712, -32625, -32763, -32766, -32767, -32768, -32767, -32766, -32764, -32761, -32758, -32755, -32750, -32746, -32741, -32736, -32732, -32725, -32719, -32711, -32705, -32699, -32692, -32684, -32678, -32670, -32663, -32655, -32647, -32639, -32631, -32623, -32615, -32607, -32599, -32591, -32583, -32575, -32566, -32557, -32549, -32541, -32532, -32524, -32515, -32507, -32499, -32489, -32481, -32473, -32464, -32455, -32446, -32438, -32430, -32421, -32412, -32404, -32395, -32387, -32377, -32368, -32361, -32352, -32343, -32334, -32325, -32317, -32309, -32300, -32291, -32282, -32274, -32266, -32256, -32248, -32239, -32231, -32222, -32213, -32204, -32196, -32188, -32179, -32170, -32161, -32153, -32144, -32136, -32127, -32118, -32110, -32101, -32092, -32084, -32076, -32067, -32058, -32049, -32041, -32033, -32024, -32015, -32007, -31998, -31989, -31980, -31973, -31964, -31955, -31946, -31938, -31930, -31921, -31912, -31904, -31895, -31886, -31878, -31870, -31861, -31852, -31844, -31836, -31278, -34220, -18390};