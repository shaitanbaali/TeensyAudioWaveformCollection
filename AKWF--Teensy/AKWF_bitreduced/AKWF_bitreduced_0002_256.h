/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0002 256 samples */
 
const int16_t AKWF_bitreduced_0002_256_DATA [256] = 
{9564, 16569, 18307, 17106, 16098, 16889, 21235, 23766, 27138, 22217, 17709, 15848, 17546, 22186, 21071, 17215, 6301, -3691, -5688, -5358, -5427, -5597, -1188, 801, 6188, 13573, 21442, 25725, 27202, 22682, 16765, 3758, -3318, -9665, -11152, -10949, -10498, -13389, -16915, -15854, -18926, -22281, -21745, -21834, -21873, -21775, -16906, -16608, -14468, -10526, -11106, -10512, -13563, -16810, -16117, -17081, -21911, -21628, -16781, -16180, -16819, -13523, -10489, -11222, -10034, -5318, -5698, -4518, 122, -21, -5, 0, 0, 0, 0, 0, 0, 0, 13, -72, 322, 4013, 1473, 5645, 5420, 5459, 5460, 5460, 5460, 5460, 5460, 5460, 5389, 5784, 3932, -322, 70, 0, 0, -27, 108, -408, -5233, -5526, -5442, -5460, -5460, -5460, -5361, -5894, -2768, 435, -188, 386, -3583, -5832, -5377, -5460, -5460, -5460, -5460, -5383, -5905, -1257, -1900, -5961, -5364, -5460, -5460, -5364, -5885, -2244, 408, -94, 0, 0, 0, 0, 0, 0, 0, -59, 283, -1233, -5577, -511, 143, -97, 291, -1327, -5724, -5370, -5733, -787, -2741, -5940, -5363, -5460, -5460, -5390, -5782, -1577, 547, -1020, -5583, -5440, -5428, -5580, -5005, -187, -36, 388, -3438, -5790, -5643, -4264, 163, 234, -1229, -5849, -4754, -633, 2239, 5469, -3645, -9997, -11308, -9816, -2913, 358, -144, 212, -889, -5458, -5805, -2543, 4409, 5608, 5665, 1782, -5744, -9794, -5119, -1344, 4633, 11818, 8484, 1449, 46, -7627, -11298, -15054, -16916, -14917, -10997, -2590, 9212, 17518, 22646, 18081, 11351, 5239, -1306, -10671, -16197, -16472, -16136, -17234, -22393, -19357, -15944, -16482, -16382, -16382, -16382, -16382, -16382, -16292, -16655, -13244, -5282, 5626, 15258, 16547, 10762, 5545, 5280, 310, -10277, -23012, -30635, -33331, -30976, -23210, -12858, -3801};