/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0005 256 samples */
 
const int16_t AKWF_bitreduced_0005_256_DATA [256] = 
{5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5515, 5201, 6593, 11123, 10895, 10883, 11029, 15825, 16524, 16349, 16382, 16382, 16382, 16382, 16382, 16382, 16382, 16426, 16181, 17213, 21910, 21839, 21839, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21845, 21932, 21458, 25427, 27677, 27222, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27298, 27307, 27338, 22618, 21656, 21793, 22258, 18479, 15985, 16420, 16628, 12183, 10641, 10983, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10922, 10848, 11257, 7275, 5053, 5867, 3863, -337, 74, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -83, 368, -3437, -5814, -5382, -5502, -5272, -6234, -10955, -10924, -10915, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -11011, -10531, -14146, -16753, -16299, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16405, -16296, -16697, -21531, -21932, -21831, -21844, -21813, -26532, -27494, -27264, -27305, -27305, -27305, -27317, -27278, -27376, -32158, -32921, -32732, -32752, -32814, -32621, -27811, -27174, -27336, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27217, -27697, -24082, -21475, -21929, -21846, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21845, -21777, -22159, -20385, -16078, -16449, -16383, -16309, -16717, -14786, -10586, -10997, -10922, -10922, -10922, -10829, -11335, -7557, -5065, -5550, -5460, -5460, -5460, -5460, -5374, -5847, -1878, 371, -84, 0, 0, 0, 0, 0, 20, -176, 702, 2031, -323, 71};