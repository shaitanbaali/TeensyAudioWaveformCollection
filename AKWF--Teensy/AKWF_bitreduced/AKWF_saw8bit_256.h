/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw8bit 256 samples */
 
const int16_t AKWF_saw8bit_256_DATA [256] = 
{562, 548, 603, 1198, 1177, 1514, 1927, 1864, 2456, 2510, 2745, 3241, 3148, 3676, 3849, 3983, 4539, 4448, 4936, 5183, 5226, 5820, 5763, 6163, 6510, 6482, 7083, 7085, 7387, 7828, 7750, 8331, 8413, 8612, 9131, 9030, 9284, 9746, 9842, 10410, 10350, 10510, 11069, 10981, 11449, 11715, 11740, 12338, 12287, 12667, 13034, 12990, 13580, 13645, 13652, 14235, 14280, 14821, 14923, 15100, 15629, 15531, 16048, 16244, 16325, 16903, 16823, 17261, 17561, 17558, 18157, 18129, 18447, 18861, 18807, 19388, 19478, 19461, 20041, 20097, 20609, 20790, 20716, 21270, 21391, 21541, 22083, 21986, 22483, 22704, 22748, 23326, 23275, 23684, 24030, 23899, 24345, 24606, 24878, 25303, 25230, 25814, 25871, 26089, 26587, 26488, 27026, 27176, 27295, 27853, 27757, 28229, 28483, 28497, 29080, 29043, 29422, 29795, 29660, 30078, 30370, 30609, 31069, 30940, 31264, 31695, 30444, 37288, -5168, -37238, -30978, -32016, -31446, -31500, -31349, -30788, -30845, -30678, -30146, -30092, -29494, -29531, -29157, -28772, -28815, -28209, -28178, -27904, -27428, -27507, -26933, -26813, -26639, -26093, -26180, -25689, -25444, -25363, -24777, -24811, -24669, -24116, -24066, -23466, -23480, -23137, -22719, -22775, -22175, -22115, -21873, -21372, -21457, -20906, -20709, -20777, -20223, -20036, -20099, -19531, -19413, -18955, -18707, -18647, -18049, -18109, -17690, -17347, -17362, -16754, -16754, -16434, -15998, -16064, -15474, -15391, -15196, -14674, -14748, -14213, -13998, -14077, -13524, -13384, -12957, -12676, -12645, -12040, -12085, -11700, -11325, -11363, -10757, -10736, -10451, -9979, -10097, -9772, -9311, -9430, -9088, -8695, -8532, -7997, -8088, -7559, -7367, -7271, -6690, -6767, -6313, -6019, -6006, -5401, -5434, -5072, -4677, -4735, -4154, -4089, -3833, -3352, -3437, -2873, -2747, -2589, -2041, -2133, -1627, -1404, -1337, -748, -815, -393, -54, -116};