/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin4bit 256 samples */
 
const int16_t AKWF_sin4bit_256_DATA [256] = 
{6814, 6816, 6818, 6819, 6820, 6822, 6822, 6822, 6822, 6822, 6822, 6822, 6822, 7027, 5905, 14647, 20658, 19594, 19786, 19784, 19780, 19779, 19776, 19772, 19769, 19765, 19761, 19758, 19754, 19750, 19745, 19901, 19018, 23158, 33241, 32578, 32679, 32684, 32677, 32671, 32664, 32658, 32651, 32644, 32635, 32629, 32621, 32613, 32607, 32598, 32590, 32582, 32575, 32566, 32558, 32550, 32542, 32533, 32525, 32517, 32508, 32499, 32491, 32483, 32475, 32466, 32457, 32448, 32441, 32432, 32423, 32415, 32406, 32397, 32389, 32380, 32372, 32363, 32354, 32346, 32337, 32328, 32320, 32311, 32302, 32293, 32285, 32276, 32267, 32260, 32251, 32243, 32065, 32995, 28588, 18473, 19395, 19220, 19213, 19204, 19198, 19191, 19184, 19178, 19172, 19165, 19159, 19152, 19146, 19139, 19104, 19216, 18867, 7467, 5801, 6213, 6131, 6126, 6122, 6117, 6114, 6112, 6108, 6104, 6101, 6098, 5863, 7111, -1375, -7868, -6659, -6886, -6886, -6887, -6889, -6888, -6888, -6888, -6888, -6888, -6889, -7099, -5944, -15225, -20759, -19651, -19853, -19850, -19848, -19844, -19842, -19840, -19836, -19831, -19829, -19825, -19820, -19815, -19812, -19981, -19009, -23591, -33564, -32584, -32754, -32748, -32744, -32737, -32731, -32724, -32715, -32709, -32702, -32694, -32686, -32680, -32671, -32664, -32656, -32648, -32639, -32632, -32623, -32615, -32607, -32599, -32590, -32582, -32574, -32565, -32556, -32548, -32541, -32531, -32523, -32514, -32505, -32497, -32488, -32480, -32471, -32462, -32454, -32446, -32437, -32428, -32420, -32411, -32403, -32394, -32385, -32377, -32368, -32359, -32351, -32342, -32333, -32325, -32316, -32307, -32130, -33059, -28653, -18538, -19460, -19285, -19277, -19271, -19264, -19255, -19249, -19242, -19236, -19229, -19223, -19216, -19210, -19206, -19168, -19280, -18931, -7533, -5866, -6278, -6195, -6191, -6187, -6184, -6180, -6175, -6172, -6169, -6166, -6164, -6161, -6158};