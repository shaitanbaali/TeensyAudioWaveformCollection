/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ2bit 256 samples */
 
const int16_t AKWF_squ2bit_256_DATA [256] = 
{32688, 32694, 32700, 32703, 32706, 32707, 32706, 32707, 32706, 32705, 32703, 32700, 32696, 32691, 32687, 32682, 32677, 32672, 32666, 32660, 32653, 32647, 32641, 32634, 32626, 32619, 32612, 32604, 32596, 32588, 32581, 32574, 32566, 32558, 32550, 32541, 32533, 32524, 32517, 32508, 32500, 32491, 32483, 32475, 32465, 32458, 32450, 32440, 32432, 32424, 32414, 32406, 32398, 32389, 32381, 32372, 32363, 32355, 32346, 32337, 32329, 32321, 32311, 32303, 32295, 32285, 32276, 32269, 32260, 32251, 32243, 32234, 32225, 32216, 32209, 32200, 32191, 32183, 32174, 32164, 32156, 32148, 32139, 32130, 32122, 32113, 32104, 32096, 32087, 32079, 32071, 32062, 32052, 32045, 32036, 32026, 32020, 32010, 32001, 31993, 31984, 31975, 31967, 31959, 31950, 31942, 31933, 31923, 31916, 31907, 31898, 31891, 31882, 31872, 31864, 31856, 31846, 31839, 31831, 31821, 31814, 31804, 31795, 31788, 31778, 31507, 32789, 28035, -29031, -33783, -32497, -32765, -32767, -32768, -32767, -32768, -32767, -32766, -32764, -32761, -32757, -32753, -32750, -32744, -32738, -32733, -32727, -32721, -32714, -32708, -32702, -32695, -32688, -32680, -32673, -32665, -32658, -32650, -32642, -32635, -32627, -32619, -32611, -32602, -32594, -32585, -32578, -32569, -32561, -32553, -32543, -32535, -32526, -32518, -32511, -32501, -32493, -32485, -32475, -32466, -32459, -32450, -32441, -32433, -32424, -32415, -32407, -32398, -32389, -32382, -32373, -32363, -32355, -32347, -32337, -32329, -32321, -32312, -32302, -32295, -32286, -32276, -32268, -32261, -32251, -32242, -32234, -32225, -32216, -32208, -32200, -32191, -32182, -32174, -32165, -32155, -32147, -32140, -32130, -32122, -32113, -32104, -32095, -32088, -32079, -32070, -32062, -32053, -32043, -32036, -32027, -32018, -32011, -32001, -31992, -31984, -31975, -31966, -31959, -31950, -31941, -31933, -31924, -31915, -31907, -31899, -31890, -31882, -31873, -31864, -31856, -31847, -31838, -31831, -31821, -31813};