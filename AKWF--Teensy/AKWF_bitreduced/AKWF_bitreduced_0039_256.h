/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0039 256 samples */
 
const int16_t AKWF_bitreduced_0039_256_DATA [256] = 
{11505, 11508, 11509, 11510, 11511, 11511, 11511, 11511, 11510, 11509, 11508, 11507, 11506, 11504, 11503, 11500, 11499, 11497, 11494, 11492, 11490, 11487, 11485, 11483, 11480, 11477, 11475, 11473, 11470, 11468, 11464, 11462, 11459, 11456, 11453, 11450, 11447, 11444, 11442, 11438, 11435, 11432, 11429, 11426, 11423, 11421, 11418, 11415, 11412, 11409, 11406, 11403, 11399, 11396, 11393, 11391, 11388, 11385, 11381, 11378, 11375, 11372, 11370, 11367, 11364, 11361, 11357, 11354, 11351, 11348, 11457, 10711, 13239, 25502, 8806, -12571, -9535, -10105, -10106, -10108, -10109, -10108, -10108, -10108, -10108, -10109, -10108, -10106, -10106, -10104, -10103, -10102, -10100, -10098, -10097, -10095, -10092, -10090, -10089, -10086, -10084, -10082, -10079, -10078, -10076, -10073, -10071, -10069, -10066, -10063, -10060, -10058, -10056, -10054, -10050, -10048, -10046, -10042, -10040, -10037, -10035, -10032, -10029, -10027, -10025, -10022, -10019, -10017, -10014, -10011, -10009, -10006, -10003, -10001, -9998, -9995, -9993, -9989, -9987, -9985, -9981, -9979, -9976, -9974, -9972, -9969, -9966, -9964, -9961, -9958, -9955, -9952, -9950, -9947, -9944, -9942, -9648, -11258, 5231, 12809, 11210, 11500, 11501, 11501, 11501, 11501, 11501, 11501, 11499, 11498, 11497, 11495, 11494, 11492, 11490, 11488, 11486, 11484, 11481, 11479, 11477, 11475, 11473, 11470, 11467, 11465, 11462, 11459, 11457, 11454, 11451, 11448, 11445, 11442, 11439, 11436, 11433, 11430, 11428, 11422, 11199, 12466, -4809, -11162, -9769, -10020, -10020, -10022, -10023, -10022, -10023, -10022, -10021, -10021, -10020, -10018, -10017, -10016, -10014, -10013, -10011, -10009, -10007, -10005, -10003, -10001, -9999, -9996, -9994, -9992, -9990, -9987, -9985, -9982, -9980, -9977, -9976, -9974, -9971, -9968, -9966, -9963, -9961, -9958, -9955, -9953, -9950, -9947, -9945, -9943, -9939, -9937, -9935, -9931, -9929, -9927};