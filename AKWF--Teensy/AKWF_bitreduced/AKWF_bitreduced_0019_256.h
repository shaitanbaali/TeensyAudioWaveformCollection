/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0019 256 samples */
 
const int16_t AKWF_bitreduced_0019_256_DATA [256] = 
{10978, 10980, 10982, 10985, 10985, 10985, 10985, 10985, 10985, 10985, 10985, 10985, 10984, 10980, 10980, 10980, 10977, 10976, 10975, 10971, 10970, 10967, 10967, 11322, 9376, 19498, 34103, 32075, 32446, 32441, 32437, 32433, 32428, 32420, 32415, 32409, 32402, 32397, 32389, 32382, 32375, 32368, 32361, 32353, 32344, 32338, 32330, 32321, 32313, 32306, 32297, 32289, 32281, 32273, 32265, 32256, 32249, 32239, 32232, 32223, 32215, 32206, 32199, 32188, 32181, 32171, 32164, 32155, 32148, 32137, 32131, 32120, 32113, 32103, 32096, 32086, 32079, 32069, 32061, 32052, 32043, 32035, 32028, 32018, 32010, 32002, 31992, 31985, 31975, 31968, 31958, 31951, 31940, 31933, 31923, 31916, 31906, 31899, 31889, 31881, 31873, 31556, 33247, 25014, 8906, 10653, 10326, 10319, 10312, 10306, 10301, 10295, 10290, 10284, 10279, 10276, 10270, 10267, 10262, 10258, 10255, 10251, 10248, 10244, 10240, 10236, 10233, 10204, 10203, 10476, -8007, -12069, -11109, -11284, -11283, -11283, -11283, -11283, -11283, -11283, -11283, -11284, -11283, -11280, -11280, -11279, -11274, -11286, -11406, -10577, -28552, -33736, -32550, -32755, -32752, -32747, -32741, -32735, -32730, -32725, -32719, -32711, -32706, -32699, -32691, -32684, -32677, -32670, -32661, -32654, -32647, -32638, -32631, -32622, -32614, -32606, -32598, -32590, -32580, -32573, -32564, -32557, -32546, -32540, -32530, -32523, -32513, -32506, -32496, -32489, -32479, -32472, -32462, -32454, -32445, -32437, -32428, -32419, -32411, -32402, -32394, -32384, -32377, -32367, -32360, -32350, -32343, -32332, -32326, -32315, -32306, -32299, -32288, -32282, -32271, -32264, -32254, -32247, -32237, -32230, -32220, -32212, -32203, -32194, -32186, -32177, -31870, -33514, -25595, -9264, -10944, -10630, -10623, -10618, -10610, -10604, -10599, -10594, -10588, -10583, -10580, -10574, -10571, -10566, -10562, -10557, -10553, -10550, -10546, -10542, -10539, -10536, -10532, -10528, -10526, -10522};