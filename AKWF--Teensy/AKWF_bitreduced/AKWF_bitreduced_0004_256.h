/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0004 256 samples */
 
const int16_t AKWF_bitreduced_0004_256_DATA [256] = 
{6552, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6564, 6529, 6593, 12312, 13306, 13132, 12783, 14543, 19929, 19605, 19658, 19660, 19680, 19593, 19884, 25668, 26359, 26181, 26215, 26215, 26215, 26215, 26215, 26304, 25814, 28131, 33172, 32678, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32649, 33285, 29086, 25711, 26331, 26215, 26215, 26215, 26215, 26101, 26718, 22265, 19177, 19770, 19660, 19660, 19660, 19660, 19660, 19660, 19660, 19658, 19607, 19922, 14724, 12780, 13178, 13107, 13107, 13107, 13013, 13528, 8551, 6139, 6643, 6552, 6552, 6552, 6552, 6552, 6552, 6491, 6834, 5341, -181, 32, 4, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -119, 514, -3051, -6956, -6951, -3474, 817, -5160, -6890, -6480, -6552, -6552, -6552, -6552, -6552, -6552, -6557, -6585, -6372, -11897, -13390, -13046, -13193, -12719, -14941, -20046, -19576, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19677, -19617, -19789, -25547, -26387, -26176, -26215, -26215, -26215, -26128, -26619, -23884, -25223, -26460, -26184, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26328, -25720, -30253, -33242, -32660, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32745, -32839, -32521, -26875, -26062, -26253, -26215, -26215, -26215, -26215, -26154, -26498, -25005, -19479, -19625, -19985, -14699, -12757, -13184, -13004, -13569, -9153, -6114, -6651, -6553, -6552, -6552, -6552, -6548, -6520, -6733, -1211, 282, -62, 0, 0, 0, 0};