/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0037 256 samples */
 
const int16_t AKWF_bitreduced_0037_256_DATA [256] = 
{23572, 34408, 32389, 32764, 32762, 32761, 32758, 32756, 32752, 32748, 32744, 32739, 32733, 32728, 32722, 32716, 32709, 32703, 32696, 32689, 32682, 32675, 32667, 32660, 32653, 32645, 32637, 32630, 32622, 32613, 32605, 32597, 32589, 32581, 32572, 32564, 32555, 32547, 32540, 32530, 32523, 32513, 32505, 32450, 32596, 32201, 13236, 10203, 10945, 10799, 10792, 10786, 10780, 10774, 10769, 10763, 10758, 10753, 10749, 10744, 10739, 10737, 10733, 10728, 10725, 10721, 10717, 10713, 10710, 10706, 10703, 10699, 10696, 10692, 10689, 10686, 10683, 10680, 10677, 10674, 10671, 10667, 10664, 10661, 10658, 10655, 10652, 10649, 10646, 10643, 10640, 10637, 10634, 10631, 10628, 10626, 10624, 10620, 10618, 10615, 10612, 10609, 10606, 10603, 10601, 10597, 10594, 10592, 10589, 10586, 10583, 10580, 10577, 10575, 10571, 10569, 10566, 10563, 10560, 10557, 10554, 10551, 10549, 10546, 10543, 10452, 10493, 10985, -22328, -34756, -32304, -32767, -32767, -32765, -32762, -32760, -32756, -32753, -32748, -32744, -32738, -32732, -32727, -32720, -32714, -32708, -32700, -32693, -32686, -32679, -32672, -32664, -32657, -32649, -32641, -32634, -32626, -32617, -32609, -32601, -32593, -32585, -32576, -32568, -32559, -32551, -32544, -32534, -32527, -32517, -32510, -32454, -32600, -32205, -13241, -10208, -10950, -10803, -10797, -10791, -10784, -10779, -10773, -10767, -10763, -10758, -10753, -10749, -10744, -10740, -10737, -10733, -10729, -10725, -10722, -10718, -10715, -10711, -10708, -10704, -10701, -10698, -10694, -10691, -10688, -10685, -10682, -10678, -10675, -10672, -10669, -10666, -10663, -10660, -10657, -10654, -10651, -10648, -10645, -10642, -10639, -10636, -10633, -10630, -10627, -10625, -10623, -10620, -10616, -10614, -10611, -10608, -10605, -10602, -10599, -10597, -10593, -10591, -10588, -10585, -10582, -10579, -10576, -10574, -10570, -10568, -10565, -10562, -10559, -10556, -10553, -10551, -10548, -10545, -10542, -10539};