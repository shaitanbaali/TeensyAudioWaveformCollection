/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0040 256 samples */
 
const int16_t AKWF_bitreduced_0040_256_DATA [256] = 
{10191, 10193, 10196, 10196, 10198, 10198, 10198, 10199, 10198, 10198, 10198, 10197, 10196, 10194, 10193, 10192, 10190, 10189, 10187, 10186, 10184, 10182, 10180, 10178, 10175, 10173, 10171, 10168, 10166, 10164, 10161, 10159, 10157, 10153, 10151, 10149, 10146, 10143, 10141, 10139, 10137, 10133, 10131, 10129, 10125, 10123, 10121, 10117, 10115, 10112, 9963, 10755, 7509, -11152, -11361, -11249, -11291, -11292, -11291, -11291, -11291, -11292, -11291, -11290, -11288, -11287, -11286, -11284, -11282, -11281, -11278, -11276, -11274, -11272, -11270, -11267, -11265, -11263, -11261, -11258, -11255, -11252, -11250, -11247, -11244, -11241, -11239, -11236, -11233, -11230, -11227, -11224, -11221, -11219, -11216, -10925, -12519, -4955, 11504, 9896, 10188, 10188, 10190, 10190, 10190, 10190, 10190, 10190, 10189, 10188, 10187, 10186, 10185, 10184, 10181, 10180, 10179, 10177, 10174, 10172, 10170, 10168, 10166, 10163, 10161, 10159, 10156, 10154, 10152, 10149, 10146, 10144, 10141, 10140, 10138, 10134, 10132, 10130, 10126, 10124, 10121, 10118, 10116, 10113, 10110, 10108, 10105, 10102, 10100, 10097, 10094, 10093, 10089, 10087, 10084, 10081, 10079, 10076, 10073, 10070, 10068, 10065, 10062, 10060, 10057, 10054, 10051, 10048, 10046, 10044, 10041, 10039, 10035, 10033, 10031, 10027, 10025, 10022, 9873, 10346, 8960, -25633, -19497, -18227, -10380, -11653, -11379, -11380, -11378, -11378, -11376, -11375, -11374, -11372, -11371, -11368, -11367, -11365, -11362, -11361, -11359, -11356, -11354, -11352, -11349, -11346, -11344, -11341, -11338, -11336, -11333, -11330, -11326, -11324, -11321, -11318, -11315, -11313, -11310, -11308, -11304, -11301, -11298, -11295, -11292, -11290, -11286, -11283, -11280, -11277, -11274, -11271, -11268, -11266, -11263, -11260, -11257, -11254, -11251, -11247, -11244, -11241, -11239, -11236, -11232, -11229, -11226, -11223, -11220, -11218, -11215, -11212, -11208, -11205, -11203, -11200};