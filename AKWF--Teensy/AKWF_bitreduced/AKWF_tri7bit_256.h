/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri7bit 256 samples */
 
const int16_t AKWF_tri7bit_256_DATA [256] = 
{938, 909, 1023, 2210, 2262, 2368, 3548, 3622, 4780, 4894, 5372, 6378, 6193, 7313, 7609, 7884, 9016, 8833, 9822, 10321, 10411, 11616, 11504, 12258, 13050, 12800, 13661, 14343, 14297, 15522, 15507, 16143, 17018, 16869, 18055, 18202, 18629, 19664, 19470, 20561, 20905, 21096, 22241, 22106, 23040, 23647, 23407, 24387, 24904, 24971, 26181, 26068, 26857, 27581, 27505, 28722, 28736, 29323, 30236, 30059, 31180, 31420, 31792, 32820, 32817, 32355, 31305, 31488, 30397, 30026, 29808, 28637, 28796, 27852, 27274, 27229, 26002, 26069, 25365, 24547, 24620, 23416, 23254, 23241, 22031, 21985, 21410, 20467, 20626, 19456, 19239, 18870, 17782, 17967, 16908, 16486, 16345, 15167, 15270, 14382, 13704, 13946, 13006, 12409, 12384, 11156, 11222, 10488, 9688, 9791, 8574, 8498, 7970, 6994, 7173, 6075, 5762, 5445, 4337, 4504, 4063, 3054, 2901, 1706, 1841, 982, 318, 344, -866, -935, -1021, -2230, -2198, -2828, -3698, -3591, -4772, -4984, -4944, -6130, -6260, -7310, -7614, -7888, -9021, -8838, -9825, -10326, -10414, -11622, -11503, -12313, -13064, -12802, -13662, -14390, -14129, -15029, -15590, -16130, -17022, -16873, -18060, -18206, -18633, -19668, -19475, -20567, -20903, -21131, -22280, -22103, -23045, -23643, -23443, -23825, -24872, -24986, -26183, -26070, -26861, -27586, -27510, -28727, -28742, -29326, -30237, -30070, -31237, -31420, -31798, -32841, -32738, -32765, -31594, -31425, -30412, -30030, -29812, -28640, -28800, -27856, -27278, -27233, -26005, -26080, -25321, -24539, -24627, -23424, -23221, -23389, -22550, -21917, -21430, -20470, -20631, -19461, -19242, -18873, -17785, -17969, -16910, -16496, -16320, -15134, -15283, -14380, -13752, -13768, -12580, -12488, -12373, -11160, -11227, -10492, -9693, -9796, -8579, -8503, -7975, -7000, -7175, -6027, -5771, -5449, -4338, -4522, -3551, -3044, -2909, -1725, -1790, -1539, -389, -404};