/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin7bit 256 samples */
 
const int16_t AKWF_sin7bit_256_DATA [256] = 
{917, 1412, 2319, 3048, 3764, 4732, 5300, 6329, 6450, 7559, 8652, 9204, 10183, 10816, 11650, 12496, 13039, 13120, 14255, 15331, 15865, 16932, 17032, 18107, 18660, 19701, 19521, 20520, 21090, 22167, 22266, 22349, 23429, 23992, 25002, 24810, 25886, 26244, 26447, 27581, 27547, 27468, 28536, 28945, 28740, 29296, 30258, 30160, 30051, 30769, 31563, 31439, 31453, 31470, 31332, 32142, 32858, 32722, 32738, 32731, 32723, 32715, 32706, 32698, 32690, 32682, 32673, 32665, 32656, 32648, 32632, 32661, 32511, 31327, 31260, 31270, 31249, 31284, 31104, 29926, 29868, 29955, 29568, 28475, 28530, 28568, 27492, 27085, 27275, 26625, 25710, 25862, 24684, 24487, 24083, 23090, 22910, 21724, 21869, 20951, 20422, 19813, 19055, 18647, 17743, 16899, 16394, 15750, 14993, 14127, 13493, 12415, 12310, 11232, 10653, 9738, 8989, 8278, 7389, 6744, 5783, 5118, 4304, 4015, 2838, 1844, 1240, 340, -343, -1522, -2299, -3109, -3780, -4738, -5324, -6270, -6920, -7705, -8626, -9199, -10276, -10384, -11415, -12579, -12971, -13654, -14386, -15309, -15875, -16941, -17040, -18115, -18677, -19650, -19778, -20903, -21022, -22207, -22201, -22799, -23601, -23959, -25014, -24818, -25841, -26252, -26455, -27588, -27552, -27473, -28541, -28932, -28830, -28864, -30023, -30227, -30043, -30825, -31581, -31443, -31461, -31477, -31340, -32149, -32866, -32730, -32745, -32737, -32730, -32721, -32714, -32706, -32697, -32689, -32680, -32672, -32664, -32655, -32641, -32662, -32537, -31378, -31260, -31278, -31256, -31290, -31112, -29934, -29875, -29963, -29574, -28483, -28538, -28569, -27448, -27097, -27283, -26633, -25717, -25870, -24691, -24494, -24091, -23097, -22917, -21731, -21877, -20958, -20430, -19822, -19063, -18664, -17708, -17466, -16456, -15746, -14998, -14080, -13503, -12424, -12317, -11239, -10661, -9746, -8999, -8280, -7344, -6756, -5789, -5125, -4320, -3507, -2836, -1854, -1271, -261};