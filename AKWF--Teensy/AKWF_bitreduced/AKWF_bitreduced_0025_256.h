/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0025 256 samples */
 
const int16_t AKWF_bitreduced_0025_256_DATA [256] = 
{13309, 13313, 13551, 12236, 27569, 33884, 32524, 32768, 32767, 32765, 32762, 32759, 32756, 32752, 32746, 32742, 32736, 32731, 32724, 32718, 32712, 32706, 32698, 32691, 32684, 32677, 32670, 32662, 32655, 32646, 32639, 32632, 32623, 32615, 32606, 32598, 32590, 32581, 32573, 32565, 32556, 32548, 32540, 32531, 32406, 33022, 30524, 13435, 12913, 12772, 14410, 5819, -7872, -6108, -6675, -5366, -11406, -26915, -25679, -25898, -25899, -25900, -25898, -25897, -25894, -25892, -25889, -25887, -25884, -25879, -25875, -25871, -25866, -25861, -25856, -25851, -25846, -25522, -27247, -13328, -5024, -6677, -6368, -6363, -6358, -6355, -6352, -6348, -6344, -6341, -6338, -6335, -6333, -6330, -6327, -6324, -6322, -6319, -6317, -6315, -6312, -6092, -7327, 8180, 14220, 12907, 13142, 13438, 11819, 19831, 33967, 32277, 32583, 32580, 32577, 32574, 32569, 32564, 32559, 32553, 32548, 32542, 32535, 32528, 32522, 32515, 32508, 32500, 32493, 32486, 32479, 32470, 32463, 32455, 32447, 32439, 32432, 32424, 32415, 32407, 32398, 32390, 32382, 32373, 32365, 32357, 32348, 32040, 33672, 19310, 11577, 13082, 13088, 12036, -5154, -6998, -6786, -5422, -20386, -27262, -25812, -26075, -26075, -26076, -26074, -26073, -26071, -26068, -26065, -26062, -26059, -26055, -26051, -26046, -26041, -26037, -26031, -26026, -26021, -26015, -26010, -26004, -25998, -25992, -25985, -25980, -25974, -25967, -25961, -25954, -25948, -25942, -25935, -25928, -25922, -25915, -25909, -25870, -25931, -25888, -8990, -5799, -6565, -6122, -7736, 274, 14256, 13532, -2354, -6355, -10676, -26712, -25649, -25825, -25826, -25821, -25816, -25812, -25807, -25802, -25796, -25791, -25786, -25780, -25774, -25769, -25762, -25757, -25750, -25745, -25738, -25732, -25725, -25719, -25712, -25706, -25699, -25693, -25687, -25680, -25673, -25666, -25660, -25653, -25646, -25639, -25633, -25627, -25619, -25368, -26723, -20400, -5063, -6376, -6136, -6130};