/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0032 256 samples */
 
const int16_t AKWF_bitreduced_0032_256_DATA [256] = 
{-9624, 11061, 15666, 1256, 3470, 3147, 3148, 3149, 3151, 3152, 3152, 3153, 3154, 3155, 3155, 2941, 3993, -3881, -4650, -4298, -9296, -5105, -5025, -9571, -3848, -4460, -5929, -6337, -1640, -9907, -5382, -5729, -6972, -8035, -1930, -6859, -5282, -9852, -1596, -6365, -5931, -4343, -3782, -10266, -1286, 3978, 2947, 3187, 3188, 3188, 3189, 3189, 3189, 3189, 3189, 3189, 3189, 3189, 3189, 3189, 3188, 3188, 3188, 3187, 3186, 3186, 3185, 3184, 3184, 3183, 3183, 3183, 3181, 3181, 3180, 3180, 3178, 3178, 3177, 3176, 3175, 3175, 3174, 3173, 3172, 3171, 3171, 3170, 3169, 3168, 3167, 3166, 3166, 3165, 3164, 3163, 3162, 3161, 3161, 3160, 3159, 3158, 3157, 3156, 3155, 3155, 3154, 3153, 3152, 3152, 3151, 3150, 3149, 3148, 3147, 3147, 3146, 3145, 3144, 3143, 3142, 3142, 3141, 3139, 3138, 3138, 3137, 3136, 3135, 3135, 3133, 3133, 3132, 3131, 3130, 3130, 3129, 3128, 3127, 3126, 3125, 3125, 3124, 3123, 3122, 3121, 3120, 3119, 3119, 3118, 3117, 3116, 3115, 3114, 3114, 3113, 3112, 3110, 3110, 3109, 3109, 3108, 3107, 3106, 3106, 3105, 3104, 3102, 3102, 3101, 3101, 3100, 3099, 3097, 3097, 3096, 3096, 3095, 3094, 3092, 3092, 3091, 3091, 3090, 3088, 3087, 3087, 3086, 3085, 3084, 3084, 3083, 3083, 3081, 3080, 3079, 3079, 3078, 3078, 3076, 3075, 3074, 3074, 3073, 3073, 3071, 3070, 3069, 3069, 3018, 3219, 2663, -13625, -7327, -5721, -5066, -10145, -2658, -5539, -5899, -5769, -2385, -10189, -5102, -5811, -7080, -13261, -5136, -6053, -6267, -9148, -1660, -6737, -6305, -3366, -5663, -8694, -5393, -5134, -9633, -15771, -14618, -14853, -14850, -14848, -14845, -14843, -14840, -14837, -14835, -14831, -14828, -15069, -13714, -27520, -33863};