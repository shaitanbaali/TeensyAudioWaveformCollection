/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin2bit 256 samples */
 
const int16_t AKWF_sin2bit_256_DATA [256] = 
{32425, 32431, 32436, 32440, 32443, 32445, 32444, 32445, 32444, 32442, 32440, 32437, 32433, 32429, 32426, 32421, 32415, 32411, 32405, 32398, 32392, 32385, 32378, 32372, 32365, 32358, 32350, 32343, 32336, 32328, 32321, 32312, 32305, 32297, 32288, 32280, 32272, 32265, 32256, 32248, 32239, 32231, 32223, 32215, 32206, 32197, 32189, 32180, 32172, 32165, 32155, 32146, 32138, 32129, 32122, 32113, 32104, 32096, 32087, 32078, 32070, 32062, 32052, 32044, 32036, 32027, 32019, 32011, 32001, 31992, 31984, 31976, 31967, 31959, 31950, 31941, 31933, 31925, 31916, 31908, 31899, 31889, 31881, 31874, 31864, 31856, 31848, 31838, 31830, 31823, 31813, 31805, 31796, 31787, 31779, 31771, 31762, 31754, 31745, 31735, 31728, 31720, 31711, 31703, 31694, 31685, 31678, 31669, 31660, 31652, 31642, 31634, 31627, 31617, 31609, 31601, 31591, 31584, 31576, 31566, 31559, 31549, 31541, 31533, 31524, 31517, 30355, 36538, -5480, -37632, -31643, -32762, -32765, -32767, -32768, -32768, -32767, -32766, -32764, -32761, -32757, -32754, -32750, -32745, -32740, -32734, -32728, -32722, -32717, -32710, -32703, -32696, -32689, -32682, -32674, -32668, -32660, -32652, -32645, -32637, -32628, -32621, -32613, -32605, -32596, -32588, -32579, -32572, -32563, -32555, -32546, -32538, -32529, -32520, -32513, -32504, -32495, -32486, -32478, -32469, -32461, -32453, -32444, -32434, -32426, -32418, -32409, -32400, -32392, -32383, -32374, -32367, -32358, -32348, -32339, -32332, -32323, -32314, -32306, -32297, -32288, -32278, -32271, -32263, -32253, -32245, -32237, -32227, -32219, -32211, -32202, -32193, -32183, -32176, -32168, -32158, -32150, -32142, -32132, -32124, -32116, -32107, -32098, -32090, -32081, -32072, -32064, -32056, -32046, -32037, -32030, -32021, -32012, -32004, -31995, -31985, -31978, -31970, -31960, -31952, -31944, -31934, -31926, -31919, -31909, -31900, -31893, -31883, -31875, -31868, -31858, -31849, -31841, -31832, -31824, -31816};