/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0010 256 samples */
 
const int16_t AKWF_bitreduced_0010_256_DATA [256] = 
{5556, 5039, 7853, 11354, 10823, 11000, 10568, 12658, 16746, 16301, 16383, 16433, 16136, 20584, 22140, 21748, 21953, 26749, 27448, 27272, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27290, 27351, 27159, 22334, 21770, 21690, 16838, 16262, 16342, 16695, 14922, 10618, 10988, 10922, 10848, 11256, 9325, 5057, 5838, 1364, 96, -3213, -5916, -9867, -12269, -16087, -19050, -21907, -23623, -27692, -27254, -27152, -27915, -32697, -32795, -32666, -33163, -30671, -26893, -27399, -27237, -27619, -25846, -21541, -21912, -21748, -22274, -18701, -15968, -16477, -16382, -16433, -16147, -17392, -21996, -21818, -21842, -21845, -21845, -21845, -21845, -21760, -22226, -19894, -15971, -16518, -16236, -11428, -10691, -11388, -8003, -5032, -5559, -5460, -5460, -5460, -5555, -5046, -7785, -11357, -10809, -15328, -17622, -21529, -24109, -27663, -27221, -32048, -32945, -32728, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32699, -33081, -31307, -26930, -27695, -25680, -21953, -18676, -16388, -14009, -10835, -9355, -5109, -5538, -5460, -5460, -5460, -5460, -5460, -5490, -5340, -5929, -10679, -10837, -11511, -16312, -16410, -16371, -16422, -16205, -17009, -22248, -19685, -15954, -16478, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16382, -16433, -16147, -17392, -21996, -21818, -21941, -21414, -24463, -27741, -27205, -27305, -27305, -27305, -27305, -27305, -27303, -27272, -27482, -22912, -21571, -21949, -17821, -13133, -10628, -6707, -4406, 15, -6};