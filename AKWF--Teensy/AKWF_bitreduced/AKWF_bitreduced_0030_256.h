/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0030 256 samples */
 
const int16_t AKWF_bitreduced_0030_256_DATA [256] = 
{-5464, 16613, 32716, 29339, 29883, 29850, 29923, 29883, 11755, 8337, 9163, 9011, 9009, 9008, 9006, 9004, 9002, 9001, 8998, 8996, 8995, 8993, 8991, 8989, 8986, 8985, 8983, 8980, 8978, 8976, 8973, 8971, 8970, 8967, 8965, 8961, 8959, 8957, 8955, 8952, 8950, 8948, 8946, 8944, 8942, 8939, 8936, 8933, 8931, 8929, 8927, 8925, 8922, 8919, 8917, 8915, 8912, 8910, 8908, 8905, 8903, 8901, 8898, 8896, 8894, 8891, 8888, 8886, 8884, 8882, 8880, 8877, 8875, 8871, 8869, 8867, 8864, 8863, 8861, 8610, 9830, 674, -222, 183, -5630, -759, -668, -5956, 696, -16, -1726, -2201, 3257, -6356, -921, -2837, 2974, -4335, -2840, -1522, -1159, -6305, 3291, -2254, -1752, 94, 745, -6796, 3643, 9763, 8563, 8838, 8838, 8838, 8836, 8836, 8834, 8833, 8832, 8830, 8828, 8827, 8825, 8823, 8821, 8820, 8818, 8816, 8814, 8812, 8810, 8808, 8805, 8804, 8801, 8800, 8798, 8795, 8793, 8791, 8788, 8786, 8784, 8781, 8779, 8778, 8633, 9495, 5769, -2831, -367, -6035, 616, -96, -1806, -2283, 3176, -6438, -1179, -1584, -3030, -4269, 2827, -2734, -1671, -973, -10405, -2648, -1798, -3, 452, -5967, -775, -1038, -4873, -4234, -11265, -12258, -12101, -12106, -12105, -12103, -12101, -12098, -12097, -12095, -12092, -12091, -12089, -12086, -12083, -12081, -12077, -12075, -12072, -12069, -12067, -12064, -12061, -12058, -12055, -12052, -12049, -12047, -12043, -12040, -12037, -12033, -12030, -12027, -12024, -12021, -12018, -12015, -12011, -12008, -12005, -12003, -11999, -11996, -11993, -11989, -11986, -11984, -11980, -11977, -11974, -11970, -11967, -11964, -11961, -11958, -11955, -11951, -11948, -11945, -11941, -11939, -11936, -11932, -11929, -11926, -11922, -11919, -11917, -11913, -11923, -12011, -11329, -28913, -33665, -32567, -32755, -32750, -32746, -32740};