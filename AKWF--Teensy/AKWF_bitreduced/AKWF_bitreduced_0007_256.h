/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0007 256 samples */
 
const int16_t AKWF_bitreduced_0007_256_DATA [256] = 
{6552, 6552, 6552, 6552, 6552, 6552, 6586, 6408, 7099, 12883, 13174, 13087, 13107, 13177, 12783, 14543, 19929, 19605, 19658, 19736, 19310, 21252, 26535, 26147, 26265, 25989, 27143, 32807, 32770, 32758, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32757, 32780, 32767, 26979, 26401, 24250, 18526, 13712, 7817, 832, -4175, -11565, -16704, -19849, -24479, -26562, -26078, -26439, -32220, -32911, -32640, -33189, -28214, -25803, -26307, -26215, -26127, -26617, -24299, -19256, -19641, -20135, -16929, -12661, -13208, -13039, -13438, -8406, -6193, -6631, -6483, -6876, -5117, 268, -56, -2, 76, -351, 1591, 6872, 6484, 6551, 6557, 6576, 6404, 11969, 13375, 13049, 13115, 13114, 13030, 18663, 19901, 19668, 19378, 20871, 26396, 26182, 26211, 26282, 25905, 27575, 33008, 32719, 32765, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32649, 33285, 29086, 25656, 26585, 25148, 19431, 20185, 15689, 13126, 10163, 6455, 4476, 58, -4059, -6509, -9587, -13750, -12467, -16339, -20183, -19613, -19323, -21174, -26511, -26154, -26214, -26215, -26215, -26215, -26215, -26319, -25762, -28687, -33189, -32673, -32765, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32706, -33063, -27729, -25878, -26288, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26152, -26512, -24931, -19449, -19701, -19664, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19660, -19578, -20037, -17909, -12742, -13187, -13108, -13107, -13107, -13107, -13107, -13107, -13107, -13107, -13107, -12995, -13603, -9069, -6078, -6660, -6552, -6552, -6552, -6552, -6552, -6552, -6508, -6751, -5758, -42, 22, -13, 0, 0, 0, 0, 0, 0, 0, 0};