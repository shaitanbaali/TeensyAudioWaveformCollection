/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0006 256 samples */
 
const int16_t AKWF_bitreduced_0006_256_DATA [256] = 
{5460, 5460, 5460, 5460, 5460, 5521, 5173, 9529, 11225, 10887, 10791, 11427, 16236, 16428, 16452, 16002, 18333, 22242, 21793, 21680, 22508, 27271, 27324, 27295, 27305, 27305, 27305, 27305, 27234, 27629, 25680, 21879, 19081, 14323, 10891, 1886, -7401, -13213, -19804, -22125, -26584, -27119, -29073, -33061, -33055, -30889, -26918, -27357, -27459, -26697, -21916, -21734, -22234, -18150, -16197, -15746, -10881, -11101, -10158, -5428, -5388, -5792, -3933, 321, -46, -98, 360, 5216, 5427, 5847, 10723, 10868, 11359, 16227, 16307, 16871, 21732, 21749, 22387, 27198, 27342, 27292, 27305, 27305, 27289, 27361, 27053, 22585, 20356, 16003, 10927, 1723, -5248, -10041, -16462, -22048, -24844, -27817, -26786, -30523, -33176, -32596, -33121, -31031, -26941, -27387, -27250, -27564, -26173, -21645, -21886, -21747, -22281, -19076, -15949, -16482, -16366, -16438, -16196, -11378, -10803, -10951, -10922, -10922, -10851, -11247, -9394, -5139, -5531, -5461, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5369, -5866, -2023, 387, -88, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -101, 435, -2843, -5892, -5361, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5548, -5073, -7484, -11328, -10831, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10827, -11342, -7631, -5058, -5552, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5360, -5896, -2542, 428, -99, 0, 0, 0, 0, 0, 0};