/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri5bit 256 samples */
 
const int16_t AKWF_tri5bit_256_DATA [256] = 
{3236, 3235, 3236, 3238, 3238, 3237, 3239, 3241, 3241, 3348, 2772, 6083, 9643, 9061, 9170, 9168, 9167, 9167, 9165, 9168, 9199, 8970, 13927, 15357, 15028, 15084, 15081, 15079, 15077, 15073, 15070, 15144, 14715, 19332, 21340, 20908, 20981, 20977, 20973, 20969, 20964, 20993, 20813, 21499, 26718, 26921, 26849, 26861, 26855, 26848, 26844, 26838, 26850, 26765, 27021, 32247, 32866, 32698, 32723, 32715, 32707, 32701, 32692, 32685, 32677, 32670, 32662, 32653, 32646, 32637, 32630, 32520, 33061, 28951, 26236, 26755, 26649, 26642, 26634, 26626, 26618, 26611, 26500, 27041, 23720, 20228, 20738, 20637, 20628, 20621, 20614, 20608, 20596, 20581, 20691, 15618, 14417, 14691, 14634, 14630, 14624, 14619, 14614, 14608, 14543, 14889, 10105, 8343, 8724, 8651, 8647, 8644, 8640, 8636, 8633, 8539, 9035, 4655, 2296, 2775, 2684, 2682, 2680, 2678, 2675, 2650, 2767, 2328, -2918, -3356, -3239, -3263, -3264, -3266, -3265, -3265, -3277, -3245, -3303, -8478, -9375, -9155, -9196, -9195, -9192, -9193, -9190, -9192, -9225, -8995, -13953, -15381, -15053, -15109, -15107, -15103, -15101, -15098, -15095, -15168, -14740, -19357, -21365, -20933, -21005, -21002, -20998, -20993, -20989, -20984, -21079, -20535, -24705, -27317, -26796, -26885, -26879, -26873, -26869, -26863, -26875, -26789, -27046, -32271, -32890, -32723, -32747, -32740, -32732, -32726, -32717, -32710, -32702, -32694, -32686, -32679, -32670, -32662, -32654, -32544, -33085, -28975, -26260, -26780, -26674, -26666, -26658, -26650, -26643, -26635, -26519, -27093, -23524, -20205, -20775, -20661, -20654, -20646, -20639, -20633, -20620, -20606, -20716, -15643, -14441, -14716, -14659, -14655, -14649, -14644, -14639, -14634, -14567, -14914, -10130, -8367, -8750, -8676, -8673, -8669, -8665, -8662, -8658, -8586, -8969, -7209, -2425, -2774, -2710, -2707, -2705, -2703, -2701, -2699, -2698, -2695};