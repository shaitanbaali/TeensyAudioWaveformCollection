/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0035 256 samples */
 
const int16_t AKWF_bitreduced_0035_256_DATA [256] = 
{11084, 11086, 11088, 11089, 11090, 11091, 11091, 11091, 11091, 11089, 11089, 11088, 11087, 11085, 11084, 11082, 11080, 11079, 11077, 11074, 11072, 11070, 11068, 11066, 11064, 11060, 11058, 11274, 10167, 19576, 23030, 19701, 10193, 11243, 11034, 11031, 11027, 11024, 11021, 11018, 11015, 11012, 11009, 11006, 11002, 10999, 10997, 10994, 10991, 10987, 10984, 10981, 10978, 10975, 10973, 10969, 10966, 10963, 10961, 10958, 10954, 10951, 10948, 10946, 10943, 10940, 10936, 10934, 10931, 10928, 10924, 10922, 10920, 10917, 10914, 10911, 10908, 10911, 11085, 10008, 27855, 33682, 32374, 32602, 32597, 32592, 32587, 32581, 32575, 32568, 32562, 32555, 32548, 32165, 34183, 23308, 9097, 11184, 10787, 10782, 10776, 10771, 10765, 10760, 10755, 10751, 10747, 10743, 10739, 10734, 10730, 10727, 10723, 10720, 10715, 10712, 10708, 10705, 10702, 10698, 10695, 10692, 10689, 10685, 10682, 10302, 12325, 1455, -12751, -10659, -11050, -11052, -11053, -11054, -11053, -11053, -11054, -11052, -11052, -11051, -11049, -11048, -11046, -11045, -11043, -11041, -11039, -11037, -11034, -11033, -11031, -11028, -11026, -11023, -11020, -11018, -11016, -11102, -10664, -12260, -31470, -33064, -32627, -32711, -32706, -32700, -32695, -32689, -32683, -32677, -32670, -32664, -32657, -32418, -33715, -27876, -10020, -11087, -10903, -10892, -10886, -10881, -10874, -10869, -10865, -10860, -10855, -10850, -10847, -10843, -10838, -10835, -10831, -10827, -10824, -10819, -10816, -10813, -10810, -10806, -10802, -10800, -10796, -10792, -10789, -10786, -10783, -10780, -10777, -10774, -10771, -10768, -10764, -10762, -10759, -10756, -10753, -10751, -10748, -10745, -10742, -10827, -10185, -12858, -21797, -23893, -23209, -8968, -11109, -10712, -10709, -10705, -10702, -10698, -10695, -10692, -10688, -10685, -10682, -10679, -10676, -10673, -10670, -10667, -10663, -10660, -10657, -10654, -10652, -10648, -10645, -10643, -10640, -10637, -10634, -10630};