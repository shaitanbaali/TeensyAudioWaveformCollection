/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw2bit 256 samples */
 
const int16_t AKWF_saw2bit_256_DATA [256] = 
{32661, 32667, 32672, 32676, 32678, 32680, 32681, 32680, 32679, 32677, 32675, 32672, 32668, 32665, 32660, 32656, 32650, 32645, 32640, 32633, 32627, 32620, 32613, 32606, 32599, 32592, 32585, 32578, 32571, 32563, 32555, 32546, 32539, 32530, 32523, 32515, 32506, 32499, 32490, 32482, 32473, 32465, 32457, 32448, 32440, 32431, 32422, 32414, 32405, 32397, 32389, 32379, 32371, 32363, 32353, 32345, 32338, 32328, 32319, 32312, 32302, 32293, 32286, 32277, 32268, 32259, 32251, 32242, 32233, 32226, 32217, 32207, 32200, 32191, 32181, 32173, 32165, 32156, 32148, 32139, 32130, 32121, 32113, 32104, 32096, 32088, 32079, 32069, 32061, 32053, 32043, 32036, 32027, 32018, 32009, 32001, 31992, 31984, 31976, 31966, 31958, 31950, 31940, 31932, 31924, 31915, 31907, 31899, 31889, 31881, 31873, 31864, 31856, 31848, 31838, 31829, 31821, 31812, 31805, 31796, 31787, 31779, 31770, 31761, 31753, 31744, 30579, 36786, -5383, -37649, -31639, -32762, -32765, -32767, -32767, -32767, -32767, -32765, -32764, -32761, -32757, -32754, -32750, -32745, -32740, -32734, -32728, -32722, -32716, -32710, -32703, -32696, -32689, -32682, -32675, -32667, -32659, -32651, -32644, -32637, -32628, -32620, -32613, -32604, -32596, -32587, -32580, -32571, -32563, -32554, -32546, -32538, -32528, -32521, -32513, -32503, -32495, -32487, -32477, -32470, -32462, -32452, -32443, -32435, -32426, -32417, -32409, -32401, -32391, -32384, -32375, -32365, -32357, -32349, -32340, -32331, -32323, -32314, -32304, -32297, -32288, -32279, -32271, -32263, -32253, -32244, -32236, -32227, -32219, -32210, -32202, -32193, -32184, -32176, -32167, -32158, -32150, -32142, -32132, -32124, -32115, -32106, -32098, -32090, -32081, -32072, -32064, -32055, -32046, -32039, -32030, -32020, -32013, -32004, -31994, -31987, -31978, -31969, -31961, -31952, -31943, -31934, -31926, -31918, -31909, -31901, -31891, -31883, -31875, -31866, -31858, -31850, -31840, -31833, -31824, -31814};