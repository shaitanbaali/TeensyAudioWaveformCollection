/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0003 256 samples */
 
const int16_t AKWF_bitreduced_0003_256_DATA [256] = 
{6166, 11389, 12977, 16885, 20190, 13849, 13224, 8274, 6285, 6232, 8630, 13869, 20711, 26596, 31971, 32950, 32619, 33166, 28765, 20298, 13935, 8697, 5930, 644, -144, 34, 0, 0, 0, 0, 0, 84, -386, 4719, 6940, 6435, 6682, 6052, 285, -193, -5242, -10603, -18045, -22735, -28022, -32888, -32719, -32727, -32925, -32043, -26847, -24163, -16135, -10987, -6794, -3482, 2184, 6695, 6854, 4681, 67, -3319, -8429, -16020, -19622, -24401, -26012, -30360, -28657, -25912, -25481, -17453, -12453, -6206, 2328, 7606, 12518, 17943, 19975, 19628, 19458, 14094, 11433, 6316, -168, -6503, -11596, -14252, -19596, -19673, -19538, -20151, -16879, -12897, -8991, -3848, 1524, 6064, 9405, 13619, 12988, 13033, 13450, 8160, 6484, 5310, -55, -566, -6413, -6437, -7203, -12858, -13674, -9769, -6032, -6669, -6512, -6764, -1285, 405, -547, 2603, 7030, 6529, 6227, 432, -118, 21, -8, 77, -5556, -6793, -6500, -6552, -6552, -6552, -6552, -6552, -6551, -6491, -6848, -1514, 337, -73, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -56, 254, -1038, -6783, -6187, 56, -1718, -6873, -6489, -6548, -6552, -6552, -6552, -6552, -6672, -6032, -9785, -13630, -12987, -13002, -13573, -10676, -6025, -6874, -1285, 274, 15, -279, -6088, -6416, -12449, -9677, -6048, -1437, 1320, 6609, 6452, 6920, 4742, -296, 63, 5, 67, -321, 5070, 6416, 10603, 13573, 13002, 12987, 13627, 9736, 6272, 1479, -311, 66, 0, 109, -483, 2603, 7054, 6319, 6974, 3231, -4924, -12788, -19064, -24430, -26498, -26379, -21922, -16249, -13047, -8200, -6749, -12978, -13060, -19514, -25944, -31265, -33071, -32738, -32534, -27330, -21799, -19079, -13814, -12950, -13144, -13107, -13107, -13107, -13083, -13199, -12698, -7374, -4602, 356};