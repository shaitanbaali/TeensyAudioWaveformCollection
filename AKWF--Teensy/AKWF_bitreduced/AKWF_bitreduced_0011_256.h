/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0011 256 samples */
 
const int16_t AKWF_bitreduced_0011_256_DATA [256] = 
{5125, 7057, 11325, 10543, 14922, 16695, 16314, 16382, 16382, 16382, 16438, 16124, 17515, 22047, 21855, 21605, 25894, 27587, 27244, 27305, 27305, 27305, 27305, 27305, 27305, 27237, 27619, 25846, 21467, 22247, 18197, 16049, 16455, 16382, 16382, 16356, 16491, 15966, 11160, 10762, 6527, 2281, -2219, -5489, -6510, -11123, -10882, -10920, -10925, -10963, -10722, -15252, -16675, -16150, -20775, -22093, -21792, -21845, -21845, -21845, -21845, -21751, -22260, -19527, -15954, -16432, -16599, -15436, -10832, -6191, -5568, -1651, 308, -68, 55, -259, 1132, 5719, 5150, 6755, 10713, 13684, 16613, 20612, 22104, 21789, 21845, 21845, 21945, 21411, 24838, 27730, 27208, 27305, 27305, 27305, 27283, 27385, 27018, 22299, 21738, 21872, 21845, 21845, 21835, 21864, 21810, 16993, 16430, 12363, 10084, 5593, 5579, 4904, -131, 4297, 5696, 5580, 1004, 55, -1382, -5562, -6193, -10832, -15436, -16599, -16334, -16382, -16382, -16382, -16382, -16480, -15958, -18851, -22378, -21317, -24387, -27741, -27205, -27305, -27305, -27305, -27305, -27305, -27305, -27321, -27259, -27452, -32262, -32899, -32737, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32716, -33014, -28567, -27110, -26986, -29256, -33164, -32678, -32767, -32767, -32728, -32945, -32050, -27306, -27295, -27314, -27305, -27305, -27305, -27305, -27305, -27305, -27305, -27298, -27307, -27338, -22540, -22010, -20151, -16018, -16464, -16382, -16382, -16382, -16382, -16382, -16382, -16322, -16663, -15021, -11112, -8130, -4930, -5995, -2634, 830, -2268, -5859, -5442, -5190, -361, 97, -25};