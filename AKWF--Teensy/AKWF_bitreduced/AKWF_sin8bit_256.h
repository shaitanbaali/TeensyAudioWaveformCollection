/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin8bit 256 samples */
 
const int16_t AKWF_sin8bit_256_DATA [256] = 
{347, 895, 1940, 2713, 3491, 4239, 5027, 5809, 6574, 7398, 7914, 8775, 9699, 10467, 11102, 11767, 12801, 13522, 14314, 14999, 15497, 16284, 17076, 17733, 17947, 19059, 19701, 20228, 20961, 21436, 22199, 22683, 23142, 23860, 24447, 24938, 25452, 25939, 26481, 26926, 27231, 27804, 28222, 28576, 28934, 29408, 29562, 29685, 30244, 30786, 30863, 30857, 31445, 31456, 31730, 32182, 32118, 32094, 32202, 32764, 32753, 32744, 32737, 32729, 32720, 32712, 32704, 32695, 32675, 32728, 32272, 31953, 32004, 31987, 31972, 31379, 31325, 31069, 30572, 30649, 30110, 29833, 29275, 29305, 28948, 28362, 27944, 27603, 27012, 26598, 26253, 25662, 25253, 24894, 24081, 23636, 22800, 22535, 21989, 21118, 20557, 19945, 19287, 18738, 17886, 17272, 16756, 15915, 15104, 14544, 13952, 13146, 12351, 11580, 10781, 10094, 9500, 8431, 7700, 6914, 6164, 5364, 4586, 3817, 3007, 2529, 1528, 698, -58, -1121, -1951, -2717, -3486, -4287, -4764, -5783, -6592, -7363, -8111, -8893, -9680, -10441, -11258, -11822, -12591, -13572, -14313, -15029, -15499, -16289, -17081, -17731, -18207, -19071, -19703, -20225, -20993, -21169, -22161, -22693, -23162, -23863, -24434, -24946, -25453, -25964, -26491, -26929, -27237, -27810, -28227, -28582, -28939, -29414, -29551, -29942, -30265, -30793, -30825, -31086, -31559, -31433, -31737, -32185, -32121, -32097, -32206, -32768, -32756, -32747, -32740, -32732, -32723, -32715, -32707, -32698, -32679, -32730, -32300, -31960, -31998, -32029, -31781, -31267, -31356, -31068, -30575, -30652, -30114, -29835, -29294, -29244, -28719, -28399, -27941, -27603, -27033, -26616, -26251, -25685, -25179, -24675, -24120, -23623, -22842, -22357, -21864, -21151, -20557, -19939, -19271, -18746, -17889, -17273, -16737, -15944, -15104, -14560, -13907, -13300, -12531, -11543, -10808, -10034, -9273, -8468, -7698, -6911, -6172, -5643, -4568, -3820, -3037, -2292, -1487, -734};