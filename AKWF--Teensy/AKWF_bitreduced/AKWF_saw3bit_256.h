/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw3bit 256 samples */
 
const int16_t AKWF_saw3bit_256_DATA [256] = 
{10166, 11177, 10990, 11027, 11027, 11029, 11029, 11029, 11028, 11027, 11027, 11025, 11024, 11023, 11021, 11020, 11018, 11016, 11014, 11012, 11010, 11007, 11005, 11003, 11000, 10998, 10996, 10993, 10991, 10988, 10985, 10983, 10980, 10977, 10975, 10972, 10969, 10966, 10964, 10961, 10958, 10955, 10952, 10949, 10947, 10943, 10941, 10938, 10935, 10932, 10929, 10926, 10924, 10921, 10918, 10916, 10913, 10909, 10907, 10904, 10901, 10898, 10895, 10892, 10889, 10886, 10883, 10880, 10877, 10875, 10872, 10868, 10866, 10863, 10860, 10857, 10854, 10851, 10848, 10845, 10842, 10839, 10836, 10834, 10830, 10827, 10825, 10822, 10818, 10816, 10813, 10810, 10807, 10804, 10801, 10798, 10796, 10792, 10789, 10787, 10784, 10781, 10778, 10775, 10773, 10771, 10767, 11095, 9285, 18222, 33991, 32104, 32446, 32442, 32435, 32430, 32425, 32419, 32413, 32406, 32399, 32392, 32385, 32378, 32371, 32097, 33392, 28596, -28999, -33793, -32495, -32765, -32767, -32767, -32768, -32767, -32766, -32763, -32761, -32758, -32753, -32750, -32746, -32740, -32514, -33727, -28252, -10551, -11103, -11032, -11003, -10998, -10994, -10989, -10984, -10980, -10975, -10972, -10968, -10963, -10960, -10956, -10953, -10948, -10945, -10942, -10939, -10935, -10931, -10929, -10925, -10922, -10919, -10916, -10913, -10910, -10907, -10904, -10901, -10898, -10894, -10891, -10888, -10885, -10883, -10879, -10876, -10873, -10870, -10867, -10865, -10861, -10858, -10855, -10853, -10850, -10846, -10844, -10841, -10838, -10835, -10832, -10829, -10826, -10823, -10820, -10817, -10814, -10811, -10808, -10805, -10802, -10799, -10797, -10794, -10791, -10788, -10785, -10782, -10779, -10776, -10774, -10772, -10768, -10765, -10763, -10760, -10756, -10754, -10751, -10748, -10745, -10742, -10739, -10737, -10734, -10730, -10728, -10725, -10722, -10719, -10716, -10713, -10711, -10707, -10704, -10702, -10699, -10696, -10693, -10690, -10687, -10685, -10681, -10679, -10676};