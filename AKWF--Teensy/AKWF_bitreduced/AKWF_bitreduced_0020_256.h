/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0020 256 samples */
 
const int16_t AKWF_bitreduced_0020_256_DATA [256] = 
{6512, 6512, 6514, 6515, 6515, 6515, 6515, 6515, 6515, 6515, 6515, 6515, 6513, 6511, 6512, 6510, 6510, 6509, 6507, 6507, 6505, 6504, 6503, 6501, 6499, 6499, 6497, 6496, 6493, 6492, 6490, 6490, 6487, 6486, 6485, 6483, 6481, 6479, 6478, 6476, 6475, 6474, 6472, 6469, 6468, 6466, 6464, 6462, 6461, 6460, 6458, 6456, 6454, 6452, 6450, 6448, 6447, 6446, 6444, 6442, 6441, 6438, 6437, 6435, 6434, 6432, 6430, 6429, 6427, 6424, 6423, 6421, 6420, 6418, 6417, 6415, 6413, 6411, 6410, 6408, 6406, 6404, 6403, 6401, 6399, 6397, 6396, 6394, 6393, 6390, 6389, 6387, 6386, 6384, 6382, 6380, 6379, 6377, 6375, 6373, 6372, 6370, 6368, 6367, 6365, 6363, 6361, 6359, 6358, 6357, 6355, 6353, 6351, 6349, 6348, 6346, 6345, 6343, 6342, 6339, 6337, 6335, 6334, 6332, 6331, 6329, 6328, 6326, 6324, 6322, 6321, 6319, 6317, 6315, 6314, 6312, 6310, 6309, 6307, 6306, 6304, 6088, 7246, -2074, -7635, -6619, -6249, -17049, -20367, -19618, -19943, -18879, -28629, -33610, -32577, -32760, -32756, -32752, -32748, -32742, -32736, -32732, -32707, -32723, -32791, -21527, -19226, -19769, -19663, -19583, -19963, -18438, -6965, -6500, -6640, -6600, -6595, -6555, -6698, -6235, 5237, 6759, 6375, 6450, 6452, 6454, 6455, 6457, 6457, 6457, 6457, 6457, 6457, 6457, 6457, 6457, 6457, 6455, 6453, 6454, 6452, 6214, 7480, 206, -7613, -6335, -6574, -6574, -6574, -6574, -6574, -6574, -6574, -6575, -6573, -6571, -6572, -6570, -6568, -6569, -6566, -6566, -6564, -6564, -6562, -6560, -6558, -6558, -6555, -6554, -6552, -6551, -6550, -6548, -6547, -6545, -6543, -6541, -6539, -6538, -6536, -6535, -6533, -6531, -6529, -6528, -6526, -6525, -6524, -6521, -6519, -6518, -6516, -6514, -6512, -6511};