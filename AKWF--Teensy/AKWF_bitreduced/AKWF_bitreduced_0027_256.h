/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0027 256 samples */
 
const int16_t AKWF_bitreduced_0027_256_DATA [256] = 
{11238, 11240, 11241, 11243, 11244, 11244, 11244, 11244, 11244, 11243, 11242, 11241, 11240, 11238, 11237, 11235, 11233, 11232, 11230, 11227, 11225, 11222, 11220, 11218, 11215, 11213, 11211, 11208, 11205, 11203, 11200, 11197, 11194, 11191, 11189, 11186, 11183, 11181, 11179, 11175, 11172, 11170, 11167, 11164, 11161, 11158, 11155, 11152, 11149, 11146, 11143, 11140, 11137, 11134, 11131, 11128, 11290, 10374, 14185, 32897, 32770, 32727, 32753, 32748, 32743, 32737, 32732, 32339, 34402, 22930, 9336, 11445, 11044, 11038, 11034, 11029, 11023, 11017, 11015, 11010, 11006, 11001, 10997, 10994, 10989, 10985, 10981, 10978, 10974, 10971, 10967, 10964, 10961, 10958, 10955, 10952, 10948, 10945, 10942, 10939, 10935, 10932, 10929, 10926, 10923, 10920, 10917, 10914, 10911, 10908, 10905, 10902, 10899, 10895, 10892, 10890, 10887, 10884, 10880, 10878, 10875, 10872, 10869, 10865, 10863, 10485, 12501, 1665, -12495, -10410, -10800, -10801, -10803, -10802, -10802, -10802, -10803, -10801, -10801, -10800, -10798, -10797, -10795, -10794, -10792, -10790, -10788, -10786, -10784, -10782, -10780, -10777, -10775, -10773, -10770, -10768, -10765, -10762, -10760, -10757, -10754, -10752, -10749, -10746, -10744, -10741, -10738, -10737, -10734, -10731, -10728, -10726, -10722, -10720, -10717, -10714, -10711, -10708, -10705, -10703, -10699, -10697, -10694, -11054, -9093, -19287, -33991, -31949, -32324, -32319, -32315, -32308, -32303, -32297, -32291, -32284, -31900, -33932, -19217, -9013, -10964, -10597, -10590, -10586, -10580, -10574, -10570, -10565, -10561, -10558, -10553, -10548, -10545, -10541, -10537, -10533, -10530, -10526, -10523, -10519, -10517, -10514, -10511, -10507, -10504, -10501, -10498, -10495, -10491, -10489, -10486, -10483, -10480, -10476, -10474, -10471, -10468, -10465, -10462, -10459, -10456, -10453, -10450, -10447, -10444, -10442, -10439, -10436, -10433, -10430, -10427, -10424, -10422, -10419, -10416, -10413};