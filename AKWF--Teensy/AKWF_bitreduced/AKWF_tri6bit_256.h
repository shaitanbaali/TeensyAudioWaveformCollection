/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri6bit 256 samples */
 
const int16_t AKWF_tri6bit_256_DATA [256] = 
{1557, 1558, 1561, 1573, 1509, 1758, 4070, 4210, 4208, 4005, 5044, 6974, 6753, 6794, 6816, 6684, 8834, 9536, 9377, 9444, 9222, 11150, 12188, 11975, 12031, 11919, 12378, 14636, 14619, 14623, 14571, 14761, 17071, 17261, 17209, 17211, 17194, 19451, 19908, 19793, 19848, 19631, 20666, 22592, 22368, 22430, 22269, 22966, 25110, 24977, 24993, 25028, 24802, 26726, 27760, 27541, 27622, 27361, 28995, 30373, 30118, 30168, 30062, 30500, 31096, 29971, 30156, 30114, 30062, 30300, 28515, 27276, 27500, 27463, 27431, 25141, 24736, 24827, 24761, 24976, 23854, 21975, 22201, 22121, 22284, 21503, 19388, 19535, 19503, 19459, 19660, 17668, 16699, 16895, 16805, 17052, 15336, 14021, 14259, 14167, 14394, 13110, 11402, 11616, 11567, 11575, 11546, 9260, 8859, 8952, 8908, 9035, 6882, 6176, 6330, 6269, 6436, 5658, 3548, 3701, 3651, 3759, 3296, 1034, 1046, 1038, 1086, 893, -1423, -1615, -1564, -1623, -1373, -2759, -4403, -4147, -4199, -4186, -4211, -6492, -6889, -6791, -6828, -6699, -8849, -9549, -9392, -9458, -9237, -11165, -12203, -11988, -12046, -11933, -12392, -14651, -14633, -14636, -14585, -14774, -17085, -17275, -17223, -17226, -17208, -19465, -19922, -19808, -19860, -19662, -20601, -22560, -22393, -22444, -22283, -22981, -25125, -24990, -25007, -25043, -24817, -26742, -27775, -27557, -27637, -27374, -29009, -30388, -30131, -30181, -30076, -30513, -31110, -29986, -30170, -30117, -30164, -29955, -27686, -27437, -27487, -27421, -27668, -26200, -24622, -24871, -24775, -24990, -23868, -21989, -22215, -22134, -22299, -21516, -19402, -19551, -19518, -19474, -19672, -17681, -16712, -16908, -16818, -17064, -15350, -14037, -14275, -14177, -14423, -13033, -11386, -11637, -11585, -11533, -11783, -10319, -8745, -8997, -8924, -9049, -6897, -6192, -6345, -6284, -6451, -5673, -3563, -3715, -3665, -3774, -3311, -1048, -1061, -1064, -1059, -1057};