/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0015 256 samples */
 
const int16_t AKWF_bitreduced_0015_256_DATA [256] = 
{-10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10752, -11682, -7022, 793, -179, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -216, 918, -3701, -31799, -32864, -33377, -25177, -21158, -21998, -21649, -22703, -15559, -10093, -11112, -10922, -10922, -10922, -10922, -10735, -11748, -4193, 790, -179, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};