/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0012 256 samples */
 
const int16_t AKWF_bitreduced_0012_256_DATA [256] = 
{5460, 5460, 5467, 5458, 5427, 10148, 11111, 10974, 10509, 14286, 16777, 16304, 16355, 16452, 21236, 21999, 21871, 21564, 23106, 27551, 27254, 27304, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27305, 27224, 27670, 23581, 21492, 21830, 22254, 19530, 16281, 14905, 10806, 10097, 5333, 1260, -3410, -5888, -9637, -14500, -16314, -18915, -21918, -23552, -27682, -27321, -26872, -29999, -33203, -32667, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32752, -32814, -32621, -27811, -27174, -27336, -27214, -27708, -25136, -21427, -21897, -22046, -21015, -16318, -16382, -16383, -16447, -11753, -10722, -10871, -11342, -7631, -5058, -5552, -5430, -5592, -4955, -147, 46, -16, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -57, 266, -4134, -5752, -5397, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5379, -5825, -1736, 353, -79, 0, 0, 0, 0, 0};