/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0026 256 samples */
 
const int16_t AKWF_bitreduced_0026_256_DATA [256] = 
{9574, 9576, 9577, 9579, 9579, 9579, 9579, 9579, 9579, 9579, 9577, 9577, 9576, 9574, 9573, 9572, 9570, 9568, 9566, 9564, 9562, 9560, 9558, 9556, 9554, 9552, 9551, 9548, 9546, 9544, 9541, 9539, 9537, 9534, 9532, 9530, 9526, 9525, 9523, 9520, 9518, 9515, 9512, 9510, 9381, 10055, 7353, -11169, -11727, -11535, -11588, -11589, -11588, -11588, -11589, -11588, -11587, -11586, -11585, -11583, -11582, -11580, -11579, -11577, -11574, -11573, -11571, -11568, -11565, -11563, -11560, -11558, -11555, -11553, -11550, -11548, -11545, -11542, -11539, -11536, -11533, -11472, -11705, -10960, 7611, 10071, 9449, 9568, 9569, 9571, 9571, 9571, 9571, 9571, 9570, 9569, 9569, 9568, 9566, 9565, 9564, 9562, 9560, 9558, 9557, 9554, 9553, 9552, 9550, 9547, 9545, 9542, 9540, 9539, 9537, 9533, 9531, 9528, 9526, 9525, 9522, 9520, 9518, 9515, 9512, 9510, 9507, 9505, 9503, 9499, 9497, 9496, 9493, 9490, 9488, 9485, 9483, 9479, 9477, 9475, 9472, 9469, 9468, 9466, 9463, 9460, 9457, 9455, 9452, 9449, 9447, 9445, 9441, 9440, 9438, 9435, 9432, 9430, 9427, 9424, 9422, 9419, 9417, 9414, 9412, 9410, 9407, 9404, 9362, 9472, 9264, -9133, -12331, -11549, -11694, -11695, -11694, -11694, -11695, -11694, -11693, -11692, -11692, -11690, -11689, -11987, -10329, -26336, -34094, -32470, -32759, -32482, -33989, -17559, -10405, -11925, -11646, -11642, -11637, -11633, -11630, -11626, -11621, -11618, -11614, -11610, -11607, -11603, -11600, -11596, -11593, -11589, -11585, -11582, -11579, -11576, -11573, -11569, -11566, -11563, -11559, -11556, -11175, -13204, 588, 11142, 9177, 9545, 9546, 9547, 9548, 9548, 9548, 9548, 9548, 9502, 9653, 9275, -9189, -12135, -11405, -11540, -11541, -11540, -11538, -11538, -11536, -11535, -11533, -11532, -11529, -11528, -11526, -11524, -11522, -11520};