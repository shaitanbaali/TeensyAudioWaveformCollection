/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0016 256 samples */
 
const int16_t AKWF_bitreduced_0016_256_DATA [256] = 
{16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16419, 16302, 16595, 30941, 33229, 32662, 32768, 32768, 32768, 32768, 32768, 32768, 32712, 32965, 32085, 17607, 16058, 16037, 18328, 7217, -18311, -15890, -16678, -15303, -812, 228, -533, 2121, -10417, -34953, -32281, -32767, -32767, -32767, -32767, -32727, -32877, -32445, -18054, -15957, -16483, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16567, -15542, -20168, -33506, -32613, -32765, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32569, -33680, -20764, -15444, -16590, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16128, -17524, -10533, 1190, -269, 190, -877, 3979, 17184, 16214, 16382, 16384, 16384, 16384, 16607, 15374, 27978, 33770, 32547, 32768, 32768, 32768, 32482, 34024, 22893, 15177, 16658, 16384, 16384, 16384, 16384, 16384, 16384, 16384, 16202, 17227, 12600, -739, 154, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, -221, 1002, -4790, -17395, -16162, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16395, -16467, -15934, -29741, -33474, -32615, -32767, -32767, -32767, -32767, -32767, -32767, -32744, -32773, -32866, -18704, -15818, -16510, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16384, -16202, -17227, -12601, 738, -155, -3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};