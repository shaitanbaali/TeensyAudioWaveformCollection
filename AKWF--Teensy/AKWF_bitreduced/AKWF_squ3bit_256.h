/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ3bit 256 samples */
 
const int16_t AKWF_squ3bit_256_DATA [256] = 
{32710, 32717, 32721, 32725, 32728, 32729, 32731, 32730, 32728, 32726, 32724, 32721, 32717, 32714, 32709, 32705, 32700, 32694, 32689, 32682, 32676, 32669, 32662, 32655, 32648, 32642, 32634, 32627, 32620, 32612, 32603, 32595, 32587, 32579, 32572, 32564, 32555, 32547, 32539, 32530, 32522, 32513, 32506, 32497, 32489, 32480, 32471, 32463, 32454, 32446, 32438, 32429, 32420, 32412, 32403, 32393, 32386, 32378, 32368, 32360, 32351, 32342, 32333, 32326, 32317, 32307, 32300, 32291, 32281, 32273, 32265, 32256, 32248, 32240, 32230, 32221, 32213, 32204, 32195, 32187, 32179, 32169, 32160, 32153, 32143, 32135, 32128, 32118, 32109, 32101, 32092, 32083, 32075, 32067, 32058, 32050, 32041, 32031, 32023, 32015, 32006, 31998, 31990, 31980, 31972, 31964, 31954, 31946, 31939, 31929, 31921, 31912, 31903, 31894, 31886, 31878, 31869, 31861, 31851, 31843, 31835, 31825, 31818, 31810, 31800, 31446, 32525, 26755, -15907, -35703, -32005, -32763, -32766, -32767, -32768, -32767, -32767, -32765, -32763, -32760, -32757, -32752, -32748, -32743, -32738, -32733, -32727, -32721, -32714, -32708, -32702, -32695, -32688, -32680, -32673, -32666, -32658, -32650, -32643, -32635, -32627, -32619, -32611, -32602, -32594, -32585, -32578, -32569, -32562, -32552, -32544, -32536, -32526, -32519, -32510, -32502, -32494, -32484, -32476, -32468, -32458, -32450, -32442, -32433, -32424, -32416, -32407, -32397, -32390, -32382, -32372, -32363, -32356, -32347, -32337, -32329, -32322, -32312, -32303, -32295, -32286, -32276, -32269, -32261, -32251, -32243, -32235, -32225, -32217, -32209, -32199, -32191, -32183, -32174, -32164, -32156, -32148, -32138, -32131, -32123, -32113, -32104, -32097, -32087, -32078, -32071, -32062, -32053, -32045, -32036, -32026, -32019, -32010, -32001, -31994, -31985, -31975, -31967, -31959, -31949, -31942, -31934, -31924, -31916, -31907, -31898, -31890, -31882, -31873, -31865, -31856, -31847, -31839, -31457, -33454, -22686};