/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0024 256 samples */
 
const int16_t AKWF_bitreduced_0024_256_DATA [256] = 
{11330, 11333, 11336, 11338, 11339, 11339, 11340, 11341, 11341, 11341, 11339, 11339, 11339, 11689, 9780, 25113, 34257, 32428, 32760, 32756, 32751, 32747, 32742, 32737, 32731, 32724, 32718, 32713, 32706, 32699, 32692, 32684, 32677, 32670, 32662, 32655, 32647, 32639, 32631, 32623, 32615, 32607, 32599, 32591, 32582, 32573, 32565, 32557, 32549, 32541, 32531, 32523, 32514, 32506, 32499, 32489, 32480, 32472, 32463, 32454, 32447, 32438, 32428, 32420, 32412, 32403, 32394, 32387, 32377, 32368, 32359, 32352, 32343, 32333, 32326, 32317, 32307, 32299, 32291, 32282, 32273, 32264, 32256, 32247, 32239, 32231, 32222, 32212, 32204, 32196, 32187, 32178, 32170, 32161, 32151, 32144, 32136, 32126, 32118, 32110, 32100, 32092, 32085, 32075, 32066, 31668, 33743, 21767, 8889, 10986, 10584, 10577, 10571, 10564, 10558, 10554, 10548, 10543, 10538, 10534, 10529, 10524, 10520, 10517, 10512, 10136, 12134, 1404, -12615, -10551, -10938, -10940, -10942, -10941, -10943, -10944, -10943, -10942, -10942, -10941, -10940, -10939, -10937, -11329, -9226, -21797, -34065, -31968, -32356, -32352, -32348, -32343, -32339, -32333, -32327, -32321, -32315, -32308, -32302, -32296, -32289, -32281, -32274, -32267, -32259, -32251, -32244, -32236, -32228, -32220, -32212, -32204, -32196, -32189, -32180, -32171, -32163, -32154, -32146, -32138, -32130, -32121, -32113, -32104, -32095, -32088, -32079, -32070, -32062, -32053, -32045, -32037, -32028, -32020, -32011, -32002, -31994, -31986, -31976, -31969, -31960, -31950, -31943, -31934, -31925, -31917, -31909, -31899, -31891, -31883, -31874, -31866, -31857, -31848, -31840, -31832, -31823, -31815, -31806, -31797, -31789, -31780, -31772, -31764, -31755, -31746, -31738, -31729, -31721, -31713, -31703, -31695, -31687, -31677, -31671, -31662, -31652, -31416, -32694, -26930, -9308, -10360, -10177, -10165, -10158, -10152, -10146, -10142, -10136, -10131, -10126, -10122, -10117, -10112, -10108, -10105};