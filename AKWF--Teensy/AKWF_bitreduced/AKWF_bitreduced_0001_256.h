/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0001 256 samples */
 
const int16_t AKWF_bitreduced_0001_256_DATA [256] = 
{6569, 6435, 11940, 13040, 17719, 20620, 25436, 28377, 33182, 32670, 32768, 32768, 32768, 32660, 33243, 28435, 26279, 22947, 19380, 14485, 13228, 8855, 5889, 604, 64, -5136, -6479, -8239, -13558, -12639, -14941, -20134, -19175, -21577, -26620, -26126, -26215, -26215, -26215, -26215, -26215, -26215, -26106, -26702, -22089, -19088, -20242, -15448, -12547, -13675, -8807, -6107, -6652, -6552, -6552, -6552, -6552, -6552, -6577, -6461, -6877, -12675, -13225, -13078, -13107, -13224, -12598, -16968, -20151, -19549, -19660, -19660, -19660, -19549, -20145, -16755, -12650, -13212, -13109, -13107, -13107, -13107, -13107, -13184, -12757, -14699, -19981, -19593, -19660, -19743, -19284, -21413, -26581, -26136, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26215, -26214, -26154, -26511, -21173, -19264, -20020, -14697, -13234, -8840, -6277, -5973, -119, -462, 3481, 7066, 6434, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6552, 6670, 6037, 9604, 13629, 12987, 13107, 13107, 13107, 13107, 13107, 13211, 12642, 17361, 20305, 18765, 13148, 13085, 13119, 13107, 13025, 13483, 11354, 6098, 7034, 2058, 114, -3710, -6955, -6784, -12563, -13236, -13075, -13107, -13107, -13010, -13543, -10939, -6001, -7099, -4299, 464, -105, 0, 0, 0, -4, -41, 211, -5268, -6849, -6539, -6321, -7456, -13295, -7693, -6275, -6493, -7067, -2782, 555, -383, 1137, 6699, 6527, 6546, 6552, 6552, 6515, 6709, 5945, 175, 51, -458, 4212, 7008, 6467, 6496, 6727, 12500, 13264, 13070, 13107, 13107, 13107, 13107, 12988, 13625, 9424, 6047, 6667, 6436, 7056, 3681, -518, 118, 86, -386, 1889, 6868, 6483, 6547, 6552, 6552, 6552, 6552, 6552, 6552, 6534, 6607, 6376, 606, -158, 36, 0, 0, 0, 0, 0, 0, 0, 0, 0};