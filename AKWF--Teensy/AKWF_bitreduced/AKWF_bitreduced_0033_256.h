/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0033 256 samples */
 
const int16_t AKWF_bitreduced_0033_256_DATA [256] = 
{11059, 11061, 11063, 11064, 11064, 11066, 11066, 11066, 11066, 11064, 11064, 11062, 11061, 11060, 11059, 11057, 11055, 11054, 11052, 11049, 11047, 11044, 11043, 11041, 11038, 11035, 11033, 11030, 11028, 11025, 11022, 11020, 11017, 11014, 11012, 11009, 11006, 11003, 11001, 10998, 10995, 10992, 10989, 10987, 10983, 10980, 10978, 10975, 10972, 10969, 10966, 10963, 10961, 10957, 10954, 10952, 10949, 10945, 10943, 10940, 10937, 10934, 10931, 10928, 10925, 10922, 10919, 10916, 10913, 10911, 10908, 10904, 10902, 10899, 10899, 11098, 9909, 27630, 33775, 32408, 32646, 32641, 32237, 34367, 21289, 9128, 11239, 10837, 10832, 10827, 10824, 10819, 10816, 10812, 10807, 10804, 10799, 10795, 10792, 10789, 10785, 10782, 10778, 10775, 10772, 10768, 10765, 10762, 10758, 10755, 10752, 10749, 10746, 10743, 10740, 10737, 10733, 10730, 10727, 10725, 10722, 10718, 10716, 10713, 10710, 10618, 11050, 9446, -9816, -11420, -10986, -11077, -11079, -11078, -11078, -11078, -11079, -11078, -11076, -11076, -11075, -11073, -11072, -11070, -11068, -11066, -11065, -11063, -11060, -11058, -11056, -11053, -11051, -11049, -11046, -11044, -11041, -11038, -11036, -11033, -11030, -11028, -11025, -11022, -11020, -11017, -11014, -11011, -11008, -11128, -10480, -13015, -32184, -32948, -32700, -32755, -32742, -32585, -33539, -15479, -9927, -11175, -10946, -10941, -10937, -10932, -10928, -10925, -10920, -10915, -10912, -10908, -10904, -10901, -10897, -10893, -10890, -10887, -10883, -10880, -10877, -10873, -10870, -10867, -10863, -10860, -10857, -10854, -10851, -10848, -10845, -10842, -10838, -10836, -10833, -10830, -10827, -10825, -10822, -10819, -10816, -10813, -10810, -10807, -10804, -10801, -10798, -10795, -10792, -10790, -10787, -10783, -10781, -10778, -10775, -10772, -10769, -10766, -10763, -10760, -10757, -10754, -10751, -10749, -10745, -10743, -10740, -10737, -10734, -10731, -10728, -10726, -10722, -10719, -10717, -10714};