/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0017 256 samples */
 
const int16_t AKWF_bitreduced_0017_256_DATA [256] = 
{11996, 11997, 11999, 11999, 11999, 11999, 11999, 11999, 11999, 11997, 11997, 11996, 11994, 11992, 11991, 11989, 11986, 11984, 11982, 11979, 11977, 11975, 11972, 11970, 11967, 11964, 11961, 11959, 11956, 11953, 12323, 10316, 23908, 34308, 32365, 32721, 32715, 32476, 33795, 17213, 10752, 12035, 12394, 9965, -8345, -9081, -8527, -10357, -1489, 13382, 11528, 11546, 13296, -2048, -10309, -8621, -8930, -8932, -8931, -8931, -8931, -8931, -8931, -8932, -8931, -8930, -8929, -8929, -8927, -8926, -8925, -8923, -8921, -8919, -8918, -8916, -8914, -8912, -8910, -8909, -8907, -8904, -8902, -8900, -8897, -8895, -8893, -8891, -8890, -8888, -8885, -8882, -8880, -8877, -8875, -8873, -8870, -8869, -8867, -8864, -8862, -8860, -8857, -8855, -8852, -8850, -8848, -8846, -8843, -8841, -8839, -8836, -8833, -8831, -8829, -8827, -8824, -8822, -8820, -8817, -8814, -8812, -8810, -8431, -10449, 2876, 13585, 11622, 11988, 11989, 11990, 11990, 11988, 11988, 11987, 11986, 11985, 12337, 10446, 21198, 34219, 32212, 33781, 28200, 11110, 12135, 11962, 11952, 11949, 11944, 11940, 11937, 11934, 11930, 11926, 11923, 11919, 11916, 11913, 11909, 11906, 11902, 11899, 11896, 11893, 11889, 11885, 11882, 11879, 11876, 11873, 11869, 11741, 12405, 9741, -8521, -9072, -8884, -8936, -8937, -8939, -8940, -8939, -8939, -8939, -8940, -8939, -8938, -8937, -8936, -8935, -8934, -8932, -8931, -8929, -8929, -8927, -8925, -8923, -8921, -8919, -8917, -8915, -8912, -8911, -8910, -8908, -8905, -8903, -8900, -8898, -8896, -8893, -8891, -8890, -8887, -8885, -8883, -8880, -8878, -8876, -8873, -8870, -8869, -8866, -8864, -8862, -8859, -8857, -8855, -8852, -8850, -8848, -8845, -8843, -8841, -8838, -8836, -8833, -8831, -8829, -8826, -8824, -8822, -8819, -8817, -8814, -8812, -8810, -8808, -8805, -8803, -8801, -8798, -8795, -8793};