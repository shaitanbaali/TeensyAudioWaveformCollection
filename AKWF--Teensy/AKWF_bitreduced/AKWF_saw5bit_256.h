/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw5bit 256 samples */
 
const int16_t AKWF_saw5bit_256_DATA [256] = 
{3142, 3142, 3142, 3141, 3144, 3145, 3145, 3145, 3145, 3145, 3145, 3143, 3141, 3142, 3142, 3142, 3142, 3141, 3140, 3143, 3176, 2949, 7881, 9303, 8976, 9034, 9032, 9031, 9030, 9029, 9027, 9024, 9023, 9021, 9019, 9018, 9016, 9013, 9011, 9010, 9007, 9038, 8861, 9548, 14739, 14945, 14875, 14889, 14887, 14883, 14881, 14877, 14874, 14871, 14868, 14864, 14861, 14857, 14854, 14851, 14846, 14843, 14839, 14842, 14839, 14759, 19826, 20935, 20667, 20710, 20706, 20701, 20697, 20693, 20687, 20683, 20677, 20673, 20668, 20664, 20657, 20652, 20648, 20642, 20638, 20670, 20462, 21288, 26340, 26554, 26485, 26498, 26492, 26486, 26479, 26473, 26467, 26460, 26454, 26448, 26442, 26435, 26428, 26420, 26414, 26407, 26401, 26484, 25986, 28408, 32690, 32170, 32257, 32249, 32242, 32235, 32226, 32219, 32211, 32203, 32195, 32187, 32179, 32171, 32163, 31889, 33179, 28397, -29010, -33789, -32495, -32764, -32767, -32768, -32767, -32768, -32767, -32766, -32763, -32760, -32756, -32752, -32748, -32743, -32673, -33035, -31363, -26556, -26871, -26810, -26803, -26797, -26790, -26784, -26778, -26771, -26765, -26758, -26750, -26743, -26737, -26731, -26724, -26715, -26709, -26702, -26590, -27150, -23936, -20307, -20877, -20762, -20756, -20750, -20743, -20737, -20731, -20725, -20718, -20711, -20707, -20702, -20696, -20689, -20683, -20676, -20672, -20667, -20580, -21017, -16474, -14383, -14819, -14734, -14729, -14724, -14719, -14714, -14709, -14704, -14700, -14695, -14691, -14687, -14682, -14678, -14674, -14669, -14665, -14660, -14548, -15123, -11578, -8280, -8850, -8739, -8735, -8731, -8728, -8724, -8722, -8718, -8715, -8712, -8710, -8707, -8704, -8701, -8699, -8696, -8693, -8690, -8626, -8974, -4217, -2467, -2849, -2778, -2776, -2774, -2772, -2771, -2770, -2768, -2766, -2764, -2764, -2763, -2762, -2759, -2760, -2757, -2756, -2756, -2754, -2755};