/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ8bit 256 samples */
 
const int16_t AKWF_squ8bit_256_DATA [256] = 
{18904, 35224, 32189, 32758, 32761, 32763, 32762, 32763, 32762, 32761, 32758, 32755, 32752, 32748, 32744, 32740, 32735, 32729, 32723, 32717, 32711, 32705, 32698, 32691, 32684, 32677, 32669, 32662, 32654, 32646, 32639, 32632, 32623, 32614, 32607, 32599, 32590, 32583, 32574, 32566, 32557, 32549, 32541, 32532, 32523, 32515, 32507, 32498, 32490, 32481, 32472, 32463, 32455, 32447, 32438, 32429, 32420, 32413, 32404, 32395, 32386, 32377, 32370, 32361, 32352, 32343, 32334, 32326, 32318, 32309, 32300, 32291, 32282, 32274, 32266, 32257, 32247, 32239, 32231, 32222, 32213, 32204, 32195, 32188, 32179, 32170, 32161, 32152, 32145, 32136, 32127, 32118, 32110, 32102, 32093, 32084, 32075, 32067, 32058, 32049, 32041, 32032, 32024, 32015, 32006, 31998, 31990, 31981, 31972, 31963, 31955, 31947, 31938, 31929, 31921, 31912, 31904, 31895, 31887, 31878, 31869, 31860, 31853, 31844, 31835, 31696, 31742, 32526, -17067, -35738, -32061, -32761, -32765, -32766, -32768, -32767, -32765, -32765, -32762, -32759, -32756, -32752, -32748, -32743, -32737, -32733, -32729, -32721, -32713, -32708, -32702, -32695, -32687, -32681, -32673, -32665, -32657, -32650, -32643, -32635, -32627, -32618, -32610, -32602, -32594, -32586, -32578, -32569, -32561, -32552, -32544, -32536, -32527, -32518, -32510, -32502, -32493, -32485, -32476, -32467, -32458, -32450, -32442, -32433, -32424, -32415, -32407, -32399, -32390, -32381, -32372, -32365, -32356, -32347, -32338, -32329, -32321, -32313, -32303, -32294, -32285, -32277, -32269, -32260, -32251, -32242, -32233, -32225, -32217, -32208, -32199, -32190, -32182, -32174, -32165, -32156, -32147, -32140, -32131, -32122, -32113, -32104, -32097, -32088, -32079, -32070, -32062, -32053, -32044, -32036, -32027, -32019, -32010, -32001, -31993, -31985, -31976, -31967, -31958, -31950, -31942, -31933, -31923, -31916, -31907, -31898, -31890, -31882, -31873, -31864, -31855, -31848, -31839, -31830, -31821, -31813};