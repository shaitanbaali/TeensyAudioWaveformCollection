/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri4bit 256 samples */
 
const int16_t AKWF_tri4bit_256_DATA [256] = 
{6804, 6805, 6807, 6808, 6807, 6809, 6811, 6811, 6811, 6810, 6808, 6808, 6808, 6808, 6805, 6805, 6805, 6803, 6803, 6802, 6800, 7025, 5816, 13271, 20751, 19611, 19817, 19817, 19815, 19811, 19808, 19804, 19800, 19797, 19793, 19789, 19784, 19781, 19777, 19771, 19767, 19763, 19758, 19753, 19749, 19956, 18792, 28110, 33666, 32549, 32746, 32740, 32736, 32728, 32720, 32714, 32707, 32701, 32693, 32684, 32678, 32669, 32662, 32654, 32646, 32637, 32630, 32621, 32613, 32605, 32596, 32588, 32580, 32571, 32563, 32555, 32546, 32537, 32497, 32607, 32255, 20801, 19125, 19535, 19449, 19442, 19433, 19427, 19421, 19414, 19407, 19401, 19395, 19388, 19381, 19376, 19371, 19365, 19358, 19352, 19348, 19341, 19267, 19617, 18237, 6733, 6151, 6319, 6275, 6271, 6267, 6263, 6260, 6257, 6253, 6250, 6247, 6244, 6242, 6238, 6236, 6234, 6231, 6229, 6226, 6171, 6430, 5469, -6060, -7020, -6761, -6814, -6816, -6817, -6816, -6816, -6816, -6817, -6816, -6815, -6814, -6815, -6814, -6812, -6812, -6810, -6808, -6808, -6806, -7044, -5766, -13766, -20853, -19594, -19826, -19824, -19820, -19817, -19814, -19811, -19806, -19803, -19800, -19795, -19791, -19787, -19782, -19778, -19773, -19768, -19764, -19759, -19754, -19888, -19101, -22595, -33300, -32649, -32751, -32748, -32741, -32735, -32729, -32722, -32713, -32706, -32700, -32692, -32684, -32677, -32668, -32661, -32652, -32645, -32636, -32628, -32620, -32612, -32604, -32595, -32587, -32579, -32570, -32561, -32554, -32545, -32504, -32615, -32262, -20809, -19132, -19543, -19457, -19449, -19443, -19436, -19429, -19423, -19417, -19410, -19403, -19397, -19391, -19384, -19377, -19373, -19367, -19360, -19354, -19350, -19276, -19623, -18245, -6741, -6159, -6327, -6283, -6278, -6275, -6271, -6268, -6264, -6261, -6258, -6254, -6252, -6250, -6247, -6244, -6241, -6239, -6237, -6235, -6233, -6231, -6228};