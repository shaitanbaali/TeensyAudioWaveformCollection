/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin5bit 256 samples */
 
const int16_t AKWF_sin5bit_256_DATA [256] = 
{3291, 3293, 3295, 3295, 3298, 3364, 2989, 7702, 9536, 9137, 9209, 9209, 9244, 9054, 9810, 15001, 15156, 15100, 15112, 15113, 15145, 14915, 19855, 21278, 20951, 21004, 21001, 20997, 21070, 20638, 22638, 27238, 26810, 26881, 26877, 26870, 26866, 26860, 26854, 26848, 26929, 26442, 28785, 33142, 32637, 32722, 32713, 32706, 32700, 32691, 32685, 32676, 32668, 32660, 32653, 32645, 32636, 32629, 32621, 32612, 32604, 32595, 32587, 32579, 32571, 32562, 32554, 32545, 32536, 32527, 32519, 32510, 32502, 32494, 32485, 32477, 32468, 32459, 32451, 32442, 32434, 32424, 32416, 32405, 32362, 32581, 27630, 26195, 26512, 26446, 26438, 26429, 26422, 26414, 26406, 26318, 26753, 24655, 20100, 20538, 20451, 20444, 20436, 20430, 20336, 20810, 18456, 14088, 14580, 14482, 14476, 14433, 14633, 13800, 8621, 8511, 8548, 8531, 8523, 8493, 8682, 3696, 2347, 2654, 2596, 2593, 2486, 3053, -815, -3774, -3224, -3327, -3330, -3397, -3021, -7735, -9570, -9171, -9242, -9242, -9351, -8772, -12154, -15620, -15039, -15147, -15145, -15145, -15177, -14947, -19888, -21310, -20982, -21037, -21032, -21029, -21102, -20670, -22670, -27270, -26842, -26913, -26908, -26903, -26897, -26891, -26886, -26881, -26938, -26570, -31101, -33088, -32687, -32751, -32745, -32737, -32730, -32723, -32714, -32708, -32699, -32692, -32684, -32676, -32667, -32659, -32651, -32643, -32634, -32626, -32617, -32609, -32600, -32592, -32584, -32575, -32567, -32558, -32550, -32542, -32533, -32523, -32515, -32507, -32498, -32490, -32481, -32472, -32463, -32455, -32447, -32435, -32392, -32611, -27660, -26225, -26542, -26476, -26468, -26460, -26453, -26444, -26437, -26421, -26415, -26483, -21394, -20271, -20529, -20474, -20466, -20459, -20392, -20736, -15967, -14209, -14588, -14513, -14506, -14464, -14663, -13831, -8651, -8541, -8579, -8562, -8553, -8524, -8712, -3727, -2378, -2684, -2627, -2624, -2621, -2620};