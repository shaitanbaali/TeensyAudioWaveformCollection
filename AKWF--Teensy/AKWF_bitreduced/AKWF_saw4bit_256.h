/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_saw4bit 256 samples */
 
const int16_t AKWF_saw4bit_256_DATA [256] = 
{6728, 6729, 6731, 6731, 6731, 6731, 6731, 6731, 6731, 6731, 6731, 6731, 6729, 6727, 6728, 6726, 6725, 6724, 6722, 6722, 6720, 6720, 6717, 6716, 6714, 6714, 6711, 6710, 6708, 6707, 6706, 6703, 6702, 6700, 6698, 6697, 6695, 6694, 6692, 6691, 6688, 6686, 6685, 6683, 6760, 6342, 8001, 19404, 19744, 19623, 19652, 19648, 19645, 19642, 19639, 19634, 19631, 19627, 19622, 19618, 19615, 19610, 19605, 19600, 19597, 19591, 19586, 19583, 19577, 19573, 19568, 19563, 19558, 19553, 19548, 19543, 19538, 19532, 19527, 19522, 19518, 19512, 19508, 19501, 19497, 19492, 19487, 19481, 19476, 19471, 19466, 19461, 19632, 18650, 28632, 33218, 32242, 32410, 32403, 32397, 32391, 32384, 32378, 32370, 32362, 32355, 32347, 32340, 32333, 32324, 32316, 32308, 32301, 32292, 32284, 32276, 32268, 32259, 32251, 32243, 32234, 32226, 32218, 32209, 32200, 32192, 31019, 37268, -5193, -37682, -31632, -32761, -32765, -32767, -32768, -32768, -32767, -32766, -32763, -32761, -32757, -32754, -32750, -32744, -32740, -32733, -32730, -32723, -32717, -32710, -32704, -32697, -32691, -32682, -32675, -32668, -32660, -32653, -32644, -32621, -32615, -32774, -21604, -19146, -19720, -19607, -19601, -19594, -19587, -19581, -19575, -19568, -19561, -19555, -19549, -19542, -19536, -19532, -19525, -19519, -19514, -19509, -19502, -19496, -19492, -19485, -19479, -19475, -19468, -19463, -19459, -19452, -19448, -19441, -19437, -19431, -19426, -19421, -19415, -19411, -19404, -19400, -19394, -19389, -19384, -19378, -19374, -19129, -20398, -12777, -5340, -6603, -6361, -6357, -6353, -6350, -6346, -6343, -6340, -6337, -6333, -6331, -6328, -6325, -6323, -6321, -6318, -6316, -6314, -6311, -6309, -6306, -6304, -6302, -6301, -6299, -6297, -6294, -6292, -6291, -6289, -6287, -6286, -6283, -6281, -6280, -6279, -6277, -6274, -6273, -6271, -6270, -6267, -6266, -6265, -6262};