/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ4bit 256 samples */
 
const int16_t AKWF_squ4bit_256_DATA [256] = 
{32733, 32739, 32744, 32747, 32750, 32752, 32751, 32751, 32749, 32748, 32745, 32742, 32739, 32735, 32731, 32725, 32721, 32714, 32708, 32702, 32698, 32689, 32682, 32676, 32669, 32662, 32653, 32647, 32639, 32631, 32624, 32616, 32607, 32600, 32591, 32584, 32575, 32567, 32558, 32550, 32542, 32534, 32525, 32517, 32508, 32500, 32491, 32483, 32474, 32466, 32457, 32448, 32440, 32431, 32423, 32414, 32405, 32397, 32388, 32379, 32371, 32362, 32354, 32345, 32336, 32328, 32319, 32311, 32302, 32293, 32284, 32276, 32267, 32259, 32250, 32240, 32232, 32223, 32215, 32206, 32198, 32189, 32180, 32172, 32163, 32155, 32146, 32137, 32129, 32120, 32112, 32103, 32094, 32085, 32077, 32068, 32060, 32051, 32043, 32034, 32025, 32017, 32008, 32000, 31992, 31983, 31974, 31966, 31957, 31949, 31940, 31931, 31923, 31914, 31905, 31897, 31888, 31880, 31871, 31862, 31854, 31846, 31838, 31829, 31820, 31205, 34380, 18604, -32541, -32907, -32601, -32763, -32766, -32766, -32768, -32766, -32766, -32764, -32760, -32758, -32754, -32750, -32746, -32741, -32735, -32731, -32724, -32718, -32711, -32705, -32699, -32692, -32685, -32676, -32670, -32662, -32654, -32647, -32638, -32632, -32623, -32615, -32607, -32599, -32591, -32582, -32574, -32565, -32557, -32549, -32540, -32532, -32523, -32515, -32506, -32497, -32489, -32481, -32472, -32464, -32455, -32447, -32438, -32429, -32421, -32412, -32404, -32395, -32386, -32378, -32369, -32361, -32351, -32342, -32334, -32325, -32317, -32308, -32299, -32290, -32282, -32273, -32265, -32256, -32248, -32239, -32230, -32222, -32213, -32204, -32196, -32187, -32178, -32170, -32161, -32153, -32144, -32136, -32127, -32118, -32110, -32101, -32093, -32084, -32075, -32067, -32058, -32050, -32041, -32032, -32024, -32015, -32006, -31998, -31989, -31980, -31972, -31963, -31955, -31946, -31938, -31929, -31920, -31912, -31904, -31895, -31887, -31878, -31869, -31861, -31852, -31844, -31835, -31379, -33778, -20853};