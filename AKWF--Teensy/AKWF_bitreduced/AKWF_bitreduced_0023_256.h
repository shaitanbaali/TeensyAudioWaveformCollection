/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0023 256 samples */
 
const int16_t AKWF_bitreduced_0023_256_DATA [256] = 
{11784, 11786, 11788, 11789, 11789, 11789, 11789, 11789, 11789, 11787, 11786, 11785, 11783, 11781, 11780, 11779, 11777, 11775, 11772, 11770, 11768, 11765, 11762, 11760, 11757, 11754, 11753, 11749, 12021, 10497, 17624, 34002, 32491, 32759, 32753, 32747, 32743, 32737, 32731, 32725, 32678, 32784, 32572, 14222, 11027, 11801, 11652, 11647, 11640, 11636, 11630, 11625, 11621, 11616, 11611, 11607, 11603, 11600, 11596, 11591, 11588, 11583, 11580, 11576, 11573, 11570, 11566, 11562, 11559, 11555, 11552, 11548, 11546, 11543, 11539, 11536, 11533, 11529, 11525, 11523, 11520, 11516, 11513, 11510, 11506, 11503, 11500, 11497, 11494, 11491, 11488, 11485, 11482, 11478, 11475, 11472, 11470, 11467, 11463, 11359, 11876, 9884, -8699, -9832, -9508, -9581, -9583, -9584, -9583, -9583, -9583, -9583, -9584, -9582, -9581, -9581, -9579, -9578, -9577, -9575, -9574, -9572, -9570, -9569, -9567, -9565, -9563, -9561, -9558, -9556, -9554, -9551, -9549, -9547, -9544, -9542, -9541, -9538, -9536, -9534, -9531, -9528, -9526, -9523, -9521, -9518, -9516, -9514, -9511, -9509, -9506, -9503, -9501, -9499, -9496, -9493, -9491, -9489, -9486, -9484, -9481, -9478, -9476, -9473, -9471, -9468, -9465, -9464, -9461, -9458, -9456, -9453, -9450, -9448, -9446, -9443, -9440, -9439, -9436, -9433, -9430, -9428, -9425, -9422, -9420, -9418, -9415, -9413, -9411, -9408, -9405, -9403, -9400, -9397, -9395, -9392, -9390, -9387, -9385, -9383, -9380, -9377, -9375, -9373, -9370, -9367, -9364, -9363, -9360, -9357, -9355, -9353, -9350, -9347, -9345, -9342, -9339, -9337, -9335, -9333, -9330, -9327, -9325, -9322, -9319, -9317, -9315, -9312, -9310, -9308, -9305, -9302, -9299, -9297, -9295, -9292, -9289, -9287, -9285, -9282, -9280, -9277, -9275, -9273, -9269, -9267, -9265, -9262, -9259, -9258, -9255, -9253, -9250, -9247, -9245, -9243};