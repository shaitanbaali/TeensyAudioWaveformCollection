/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri8bit 256 samples */
 
const int16_t AKWF_tri8bit_256_DATA [256] = 
{555, 801, 1256, 1613, 2409, 2880, 3408, 3920, 4433, 4947, 5496, 5876, 6272, 7054, 7523, 8051, 8562, 9075, 9590, 10110, 10612, 11115, 11650, 12161, 12701, 13113, 13454, 14255, 14728, 15236, 15742, 16274, 16781, 17325, 17717, 18084, 18874, 19340, 19864, 20368, 20893, 21156, 21691, 22214, 22430, 23200, 23741, 24240, 24726, 25266, 25777, 26283, 26805, 27024, 27806, 28333, 28834, 29341, 29854, 30367, 30874, 31380, 31851, 32449, 32695, 32065, 31569, 31042, 30516, 29992, 29472, 28976, 28422, 27896, 27380, 26836, 26608, 25826, 25273, 24759, 24237, 23711, 23185, 22667, 22135, 21906, 21076, 20693, 20295, 19766, 19232, 18702, 18194, 17620, 17332, 16761, 16062, 15581, 15052, 14528, 14009, 13501, 12927, 12656, 12055, 11376, 10893, 10366, 9843, 9325, 8810, 8283, 7786, 7255, 6725, 6219, 5650, 5349, 4813, 4100, 3620, 3119, 2586, 2058, 1555, 985, 701, 135, -548, -787, -1341, -1834, -2374, -2888, -3424, -3872, -4170, -4986, -5466, -5989, -6502, -7016, -7531, -8068, -8500, -8818, -9627, -10101, -10626, -11137, -11649, -12166, -12685, -13188, -13683, -14223, -14734, -15261, -15723, -15999, -16813, -17299, -17806, -18301, -18839, -19349, -19879, -20318, -20629, -21188, -21689, -22199, -22685, -23222, -23737, -24236, -24786, -25007, -25719, -26303, -26794, -27279, -27817, -28330, -28830, -29373, -29588, -30320, -30888, -31381, -31878, -32452, -32696, -32067, -31568, -31070, -30520, -29993, -29474, -28951, -28424, -27898, -27377, -26855, -26358, -25807, -25280, -24769, -24206, -23974, -23248, -22651, -22147, -21628, -21067, -20695, -20301, -19747, -19226, -18707, -18189, -17660, -17157, -16631, -16096, -15584, -15018, -14681, -14204, -13453, -12979, -12447, -11927, -11409, -10898, -10330, -10012, -9504, -8772, -8298, -7768, -7247, -6731, -6216, -5690, -5188, -4669, -4134, -3625, -3067, -2714, -2269, -1509, -1035, -515, -52};