/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sin3bit 256 samples */
 
const int16_t AKWF_sin3bit_256_DATA [256] = 
{11074, 11077, 11078, 11080, 11081, 11081, 11081, 11081, 11081, 11081, 11079, 11079, 11078, 11076, 11075, 11073, 11071, 11070, 11067, 11065, 11064, 11061, 11059, 11057, 11054, 11052, 11049, 11046, 11044, 11041, 11038, 11036, 11033, 11030, 11028, 11025, 11022, 11020, 11017, 11016, 11236, 9949, 27414, 33832, 32419, 32667, 32661, 32655, 32650, 32644, 32639, 32632, 32626, 32619, 32612, 32605, 32598, 32591, 32583, 32575, 32568, 32560, 32552, 32544, 32536, 32527, 32520, 32512, 32504, 32495, 32487, 32478, 32471, 32461, 32454, 32445, 32436, 32428, 32418, 32410, 32402, 32393, 32386, 32366, 32234, 33059, 14927, 9691, 10875, 10656, 10650, 10642, 10637, 10631, 10627, 10622, 10616, 10611, 10606, 10601, 10598, 10594, 10589, 10585, 10582, 10578, 10575, 10570, 10567, 10563, 10560, 10557, 10553, 10550, 10547, 10544, 10541, 10538, 10535, 10531, 10528, 10525, 10522, 10519, 10516, 10513, 10121, 12207, -1967, -12814, -10794, -11172, -11173, -11173, -11174, -11175, -11173, -11172, -11172, -11171, -11170, -11169, -11168, -11166, -11164, -11162, -11160, -11158, -11156, -11154, -11152, -11149, -11147, -11145, -11142, -11139, -11137, -11134, -11132, -11130, -11127, -11124, -11122, -11118, -11116, -11113, -11110, -11110, -11338, -10007, -26646, -33956, -32504, -32758, -32754, -32748, -32742, -32737, -32731, -32724, -32718, -32711, -32704, -32697, -32689, -32682, -32674, -32667, -32659, -32651, -32644, -32636, -32629, -32620, -32612, -32603, -32595, -32587, -32579, -32570, -32562, -32552, -32545, -32536, -32527, -32519, -32511, -32503, -32494, -32485, -32477, -32457, -32325, -33150, -15018, -9782, -10967, -10748, -10742, -10735, -10730, -10723, -10719, -10712, -10707, -10702, -10698, -10693, -10688, -10685, -10681, -10676, -10673, -10669, -10666, -10662, -10658, -10654, -10651, -10648, -10644, -10641, -10638, -10635, -10632, -10629, -10626, -10623, -10620, -10617, -10614, -10611, -10608, -10605, -10602, -10598};