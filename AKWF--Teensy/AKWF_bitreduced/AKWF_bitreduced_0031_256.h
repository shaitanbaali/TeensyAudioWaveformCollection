/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0031 256 samples */
 
const int16_t AKWF_bitreduced_0031_256_DATA [256] = 
{-7897, 12222, 26633, 25018, 18515, 4076, 5571, 5301, 5302, 5302, 5302, 5303, 5303, 5303, 5302, 5302, 5302, 5301, 5300, 5300, 5299, 5298, 5297, 5296, 5295, 5294, 5293, 5292, 5291, 5290, 5288, 5288, 5287, 5285, 5283, 5282, 5281, 5280, 5279, 5277, 5240, 5578, 4236, -4664, -4043, -4452, -120, -8762, -3522, -4028, -6089, -5737, -556, -4995, -5079, -260, -6322, -5674, -4115, -3682, -8658, 105, -4849, -3101, -8397, -1736, -3097, -4297, -4472, -603, -777, 6308, 5028, 5282, 5282, 5282, 5282, 5282, 5282, 5282, 5281, 5281, 5280, 5279, 5278, 5277, 5277, 5275, 5274, 5274, 5273, 5272, 5270, 5269, 5267, 5267, 5266, 5264, 5262, 5261, 5260, 5259, 5258, 5256, 5255, 5254, 5253, 5251, 5249, 5248, 5247, 5246, 5244, 5243, 5241, 5241, 5239, 5237, 5236, 5234, 5234, 5232, 5231, 5229, 5228, 5227, 5225, 5224, 5221, 5220, 5219, 5218, 5216, 5215, 5213, 5213, 5211, 5209, 5208, 5206, 5206, 5204, 5203, 5201, 5201, 5199, 5197, 5195, 5194, 5193, 5191, 5190, 5188, 5187, 5186, 5185, 5183, 5182, 5180, 5179, 5178, 5176, 5175, 5173, 5172, 5170, 5169, 5167, 5166, 5165, 5164, 5162, 5160, 5159, 5158, 5157, 5155, 5154, 5153, 5152, 5150, 5148, 5147, 5146, 4943, 5949, -2206, -5697, -1021, -5090, -6740, -4022, -3519, -8908, -639, -4317, -3475, -7891, -3179, -2311, -4634, -5150, 174, -8345, -4289, -4359, -5022, -7482, 35, -5324, -4381, -3423, -11820, -6347, -13425, -13949, -13860, -13861, -13858, -13856, -13854, -13851, -13849, -13847, -13844, -13841, -13838, -13834, -13832, -13828, -13826, -13822, -13819, -13815, -13813, -13809, -13805, -13802, -13798, -13795, -13792, -13788, -13784, -13782, -13777, -13773, -13771, -13767, -13763, -13775, -13828, -13324, -29465, -33542, -32590, -32754};