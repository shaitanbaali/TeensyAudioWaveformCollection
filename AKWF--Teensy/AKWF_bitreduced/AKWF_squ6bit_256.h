/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_squ6bit 256 samples */
 
const int16_t AKWF_squ6bit_256_DATA [256] = 
{32745, 32751, 32755, 32759, 32761, 32763, 32764, 32763, 32761, 32759, 32756, 32753, 32750, 32746, 32742, 32737, 32731, 32725, 32720, 32714, 32708, 32701, 32694, 32687, 32680, 32673, 32665, 32658, 32650, 32642, 32634, 32627, 32618, 32611, 32602, 32595, 32587, 32578, 32569, 32561, 32553, 32545, 32536, 32528, 32519, 32510, 32502, 32493, 32485, 32476, 32467, 32459, 32450, 32442, 32433, 32425, 32416, 32407, 32399, 32390, 32382, 32373, 32364, 32356, 32347, 32339, 32330, 32322, 32313, 32304, 32296, 32287, 32279, 32269, 32260, 32252, 32243, 32234, 32226, 32217, 32209, 32200, 32191, 32183, 32174, 32166, 32157, 32149, 32140, 32131, 32123, 32114, 32106, 32097, 32088, 32080, 32071, 32063, 32054, 32045, 32037, 32028, 32020, 32011, 32003, 31994, 31985, 31977, 31968, 31960, 31951, 31942, 31934, 31925, 31917, 31908, 31899, 31891, 31882, 31874, 31865, 31856, 31848, 31839, 31831, 31148, 34701, 16719, -33245, -32734, -32622, -32764, -32765, -32766, -32768, -32767, -32765, -32764, -32761, -32758, -32755, -32750, -32746, -32742, -32736, -32730, -32725, -32719, -32712, -32705, -32699, -32691, -32684, -32677, -32670, -32662, -32655, -32647, -32639, -32631, -32623, -32615, -32607, -32599, -32592, -32583, -32574, -32566, -32557, -32549, -32541, -32533, -32524, -32515, -32507, -32498, -32490, -32481, -32472, -32464, -32455, -32447, -32438, -32429, -32421, -32412, -32404, -32395, -32386, -32378, -32369, -32361, -32352, -32343, -32335, -32326, -32317, -32308, -32300, -32291, -32282, -32274, -32265, -32257, -32248, -32239, -32231, -32222, -32214, -32205, -32196, -32188, -32179, -32171, -32162, -32153, -32145, -32136, -32128, -32119, -32109, -32101, -32092, -32083, -32075, -32066, -32058, -32049, -32040, -32032, -32023, -32015, -32006, -31998, -31989, -31981, -31972, -31963, -31955, -31946, -31938, -31929, -31920, -31912, -31903, -31895, -31887, -31879, -31870, -31861, -31853, -31844, -31836, -31290, -34172, -18659};