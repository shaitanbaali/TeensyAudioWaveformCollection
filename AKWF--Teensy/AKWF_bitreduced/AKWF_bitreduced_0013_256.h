/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0013 256 samples */
 
const int16_t AKWF_bitreduced_0013_256_DATA [256] = 
{5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5541, 5097, 7267, 11298, 10838, 10922, 10922, 10922, 10922, 10937, 10876, 11068, 15876, 16513, 16351, 16382, 16382, 16382, 16402, 16306, 16653, 21485, 21943, 21821, 21845, 21845, 21845, 21872, 21736, 21390, 30966, 8275, -36793, -31875, -32767, -32684, -33139, -30889, -26918, -27392, -27305, -27305, -27205, -27741, -24463, -21414, -21945, -21845, -21845, -21841, -21818, -21995, -17542, -16140, -16436, -16382, -16382, -16382, -16316, -16687, -12382, -10609, -10991, -10922, -10922, -10922, -10922, -10871, -11169, -6722, -5179, -5521, -5460, -5460, -5460, -5460, -5460, -5460, -5395, -5763, -4068, 286, -62, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 99, -432, 2617, 5895, 5359, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5460, 5449, 5478, 5425, 662, -166, 37, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -8, 1, 32, -4687, -5649, -5419, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5559, -5032, -8604, -11337, -10828, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10922, -10878, -11123, -10092, -5396, -5466, -5467, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5460, -5458, -5420, -5661, -1133, 258, -56, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};