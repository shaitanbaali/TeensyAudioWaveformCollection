/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_tri2bit 256 samples */
 
const int16_t AKWF_tri2bit_256_DATA [256] = 
{32702, 32708, 32713, 32716, 32719, 32721, 32720, 32721, 32720, 32718, 32716, 32713, 32709, 32705, 32701, 32696, 32691, 32686, 32680, 32674, 32667, 32660, 32654, 32647, 32640, 32633, 32626, 32618, 32610, 32602, 32595, 32587, 32580, 32572, 32564, 32555, 32547, 32538, 32530, 32521, 32514, 32505, 32497, 32489, 32479, 32471, 32463, 32454, 32446, 32438, 32428, 32420, 32411, 32402, 32394, 32386, 32377, 32369, 32360, 32351, 32342, 32334, 32325, 32316, 32309, 32299, 32290, 32282, 32273, 32264, 32257, 32248, 32239, 32230, 32222, 32213, 32204, 32197, 32188, 32178, 32170, 32162, 32152, 32143, 32136, 32127, 32118, 32110, 32101, 32092, 32084, 32075, 32066, 32058, 32050, 32040, 32032, 32024, 32014, 32007, 31998, 31989, 31981, 31972, 31963, 31955, 31947, 31937, 31930, 31921, 31911, 31903, 31895, 31886, 31878, 31870, 31860, 31852, 31844, 31834, 31826, 31819, 31809, 31802, 31792, 31519, 32802, 28047, -29029, -33781, -32495, -32763, -32765, -32767, -32767, -32767, -32766, -32764, -32762, -32759, -32755, -32752, -32747, -32743, -32737, -32731, -32726, -32719, -32713, -32707, -32700, -32693, -32686, -32679, -32671, -32664, -32656, -32648, -32641, -32633, -32625, -32617, -32609, -32600, -32592, -32583, -32576, -32567, -32560, -32550, -32542, -32534, -32524, -32517, -32509, -32500, -32492, -32482, -32474, -32466, -32456, -32448, -32440, -32431, -32422, -32414, -32405, -32395, -32388, -32380, -32370, -32361, -32354, -32345, -32335, -32327, -32320, -32310, -32301, -32293, -32284, -32274, -32267, -32259, -32249, -32241, -32233, -32223, -32214, -32206, -32198, -32189, -32181, -32172, -32162, -32154, -32146, -32137, -32128, -32121, -32111, -32102, -32095, -32085, -32076, -32069, -32060, -32051, -32043, -32034, -32024, -32017, -32009, -31999, -31992, -31983, -31973, -31965, -31957, -31948, -31940, -31932, -31922, -31913, -31905, -31896, -31888, -31880, -31871, -31863, -31854, -31845, -31837, -31828, -31820, -31812};