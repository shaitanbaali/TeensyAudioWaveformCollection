/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_bitreduced_0034 256 samples */
 
const int16_t AKWF_bitreduced_0034_256_DATA [256] = 
{18395, 19566, 27388, 16904, 10118, 11336, 11045, 11045, 11044, 11043, 11041, 11041, 11039, 11037, 11035, 11034, 11031, 11029, 11028, 11025, 11023, 11020, 11018, 11015, 11012, 11010, 11008, 11005, 11002, 11000, 10997, 10994, 10992, 10989, 10986, 10983, 10980, 10978, 10975, 10972, 10969, 10966, 10963, 10960, 10958, 10955, 10951, 10948, 10946, 10943, 10940, 10937, 10934, 10931, 10928, 10925, 10923, 10920, 10918, 10915, 10911, 10820, 11252, 9651, -9569, -11169, -10736, -10826, -10826, -10827, -10829, -10828, -10827, -10826, -10826, -10825, -10824, -10823, -10822, -10820, -10818, -10816, -10814, -10812, -10811, -10808, -10806, -10803, -10801, -10799, -10796, -10794, -10792, -10788, -10786, -10784, -10781, -10778, -10776, -10773, -10770, -10767, -10764, -10762, -10759, -10756, -10754, -10751, -10748, -10746, -10744, -10740, -10737, -10734, -10732, -10729, -10726, -10723, -10721, -10717, -10715, -10729, -10420, -12237, -17976, -22392, -23667, -23466, -313, 13237, 10572, 11040, 11042, 11043, 11044, 11045, 11045, 11045, 11045, 11043, 11043, 11042, 11040, 11039, 11038, 11036, 11034, 11033, 11031, 11028, 11026, 11024, 11021, 11019, 11017, 11014, 11012, 11010, 11007, 11004, 11002, 10999, 10996, 10994, 10991, 10988, 10986, 10983, 10980, 10977, 10974, 10971, 10969, 10965, 10963, 10960, 10957, 10954, 10951, 10948, 10946, 10942, 10939, 10937, 10934, 10930, 10928, 10925, 10922, 10543, 12567, 1694, -12514, -10421, -10813, -10814, -10815, -10814, -10814, -10814, -10814, -10815, -10813, -10812, -10811, -10810, -10808, -10807, -10805, -10803, -10801, -10799, -10796, -10795, -10793, -10790, -10788, -10786, -10782, -10780, -10778, -10775, -10773, -10770, -10767, -10765, -10762, -10759, -10756, -10753, -10751, -10748, -10746, -10744, -10741, -10738, -10735, -10733, -10729, -10727, -10724, -10721, -10718, -10715, -10712, -10710, -10707, -10704, -10701, -10699, -10695, -10692, -10690, -10687, -10684, -10681};