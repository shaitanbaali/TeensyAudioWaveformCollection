/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0121 512 samples */
 
const int16_t AKWF_stereo_0121_512_DATA [512] = 
{1338, 4143, 7014, 9955, 12897, 15789, 18580, 21206, 23633, 25819, 27726, 29342, 30646, 31631, 32306, 32679, 32765, 32588, 32172, 31542, 30725, 29750, 28644, 27430, 26135, 24783, 23387, 21975, 20559, 19151, 17770, 16423, 15116, 13864, 12669, 11534, 10468, 9467, 8533, 7671, 6877, 6146, 5480, 4872, 4317, 3812, 3347, 2915, 2508, 2113, 1722, 1324, 909, 467, -8, -523, -1080, -1681, -2329, -3018, -3743, -4504, -5287, -6087, -6895, -7700, -8493, -9267, -10014, -10728, -11403, -12036, -12626, -13169, -13663, -14109, -14507, -14851, -15146, -15389, -15578, -15711, -15785, -15798, -15745, -15621, -15419, -15134, -14764, -14303, -13747, -13099, -12361, -11533, -10625, -9643, -8597, -7503, -6375, -5225, -4079, -2951, -1858, -821, 149, 1038, 1837, 2537, 3133, 3622, 4004, 4284, 4463, 4553, 4562, 4501, 4383, 4221, 4031, 3825, 3619, 3424, 3256, 3126, 3042, 3013, 3046, 3143, 3304, 3529, 3811, 4145, 4518, 4920, 5337, 5753, 6154, 6523, 6845, 7108, 7300, 7412, 7434, 7365, 7199, 6939, 6585, 6145, 5620, 5025, 4366, 3649, 2887, 2087, 1256, 403, -463, -1340, -2214, -3078, -3927, -4747, -5530, -6271, -6953, -7572, -8116, -8577, -8952, -9235, -9420, -9510, -9506, -9414, -9242, -8998, -8696, -8347, -7964, -7561, -7149, -6740, -6346, -5970, -5621, -5302, -5014, -4755, -4523, -4313, -4119, -3931, -3743, -3545, -3332, -3095, -2832, -2543, -2225, -1884, -1522, -1148, -776, -412, -71, 233, 487, 682, 803, 842, 794, 656, 428, 110, -288, -762, -1302, -1897, -2535, -3204, -3893, -4589, -5280, -5959, -6619, -7253, -7856, -8429, -8967, -9474, -9950, -10396, -10818, -11219, -11601, -11969, -12324, -12663, -12988, -13293, -13570, -13811, -13998, -14111, -14128, -14022, -13766, -13332, -12692, -11826, -10711, -9336, -7697, -5791, -3638, -1193, -3241, -1147, 1059, 3386, 5785, 8222, 10661, 13051, 15366, 17571, 19625, 21512, 23207, 24687, 25949, 26985, 27789, 28371, 28735, 28886, 28841, 28610, 28205, 27646, 26947, 26126, 25200, 24189, 23109, 21977, 20814, 19632, 18447, 17277, 16132, 15020, 13958, 12946, 11993, 11104, 10278, 9518, 8822, 8184, 7600, 7063, 6565, 6095, 5646, 5205, 4763, 4312, 3840, 3342, 2812, 2244, 1638, 995, 317, -393, -1131, -1893, -2668, -3453, -4241, -5023, -5796, -6556, -7294, -8011, -8706, -9374, -10019, -10638, -11229, -11795, -12336, -12848, -13332, -13784, -14200, -14580, -14915, -15200, -15429, -15592, -15684, -15695, -15618, -15448, -15172, -14791, -14300, -13697, -12987, -12173, -11261, -10266, -9198, -8070, -6904, -5715, -4519, -3345, -2204, -1115, -99, 833, 1672, 2402, 3021, 3524, 3909, 4177, 4331, 4376, 4319, 4171, 3944, 3651, 3304, 2926, 2527, 2129, 1752, 1405, 1112, 882, 729, 665, 690, 811, 1026, 1327, 1709, 2155, 2654, 3189, 3744, 4304, 4851, 5371, 5848, 6272, 6629, 6912, 7114, 7228, 7254, 7190, 7039, 6799, 6475, 6069, 5583, 5025, 4401, 3715, 2979, 2199, 1383, 543, -312, -1177, -2039, -2890, -3724, -4526, -5293, -6014, -6679, -7284, -7819, -8280, -8663, -8965, -9184, -9324, -9385, -9371, -9290, -9150, -8960, -8728, -8465, -8179, -7880, -7572, -7260, -6945, -6628, -6307, -5976, -5635, -5276, -4897, -4495, -4067, -3614, -3137, -2642, -2134, -1623, -1120, -636, -184, 222, 573, 855, 1062, 1187, 1223, 1167, 1015, 773, 439, 24, -466, -1025, -1637, -2294, -2983, -3692, -4408, -5121, -5819, -6495, -7143, -7750, -8317, -8844, -9327, -9769, -10176, -10548, -10894, -11216, -11518, -11804, -12074, -12328, -12563, -12772, -12939, -13053, -13092, -13038, -12868, -12558, -12087, -11438, -10595, -9546, -8282, -6809, -5080};