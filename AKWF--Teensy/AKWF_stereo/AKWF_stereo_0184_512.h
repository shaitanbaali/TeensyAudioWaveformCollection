/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0184 512 samples */
 
const int16_t AKWF_stereo_0184_512_DATA [512] = 
{75, 343, 630, 949, 1308, 1719, 2205, 2758, 3348, 3945, 4640, 5376, 6131, 6926, 7760, 8608, 9486, 10415, 11352, 12286, 13249, 14202, 15104, 16014, 16943, 17819, 18644, 19482, 20304, 21036, 21707, 22354, 22943, 23466, 23929, 24338, 24710, 25055, 25332, 25515, 25633, 25681, 25639, 25549, 25420, 25219, 24938, 24618, 24248, 23807, 23332, 22813, 22219, 21589, 20953, 20274, 19584, 18891, 18155, 17371, 16592, 15805, 14981, 14153, 13352, 12579, 11824, 11088, 10342, 9592, 8889, 8216, 7537, 6889, 6311, 5758, 5209, 4716, 4280, 3862, 3474, 3143, 2841, 2552, 2317, 2136, 1953, 1765, 1617, 1502, 1386, 1285, 1223, 1177, 1135, 1125, 1147, 1169, 1183, 1197, 1196, 1193, 1221, 1274, 1309, 1330, 1372, 1422, 1448, 1441, 1418, 1364, 1274, 1180, 1101, 997, 828, 625, 413, 161, -146, -478, -818, -1186, -1585, -2007, -2467, -2978, -3522, -4090, -4704, -5348, -5996, -6667, -7391, -8155, -8929, -9719, -10542, -11394, -12243, -13090, -13948, -14819, -15698, -16599, -17507, -18425, -19351, -20245, -21110, -21980, -22816, -23594, -24340, -25066, -25752, -26402, -27046, -27639, -28156, -28640, -29089, -29460, -29750, -29993, -30143, -30208, -30245, -30211, -30079, -29898, -29641, -29273, -28836, -28353, -27757, -27071, -26380, -25601, -24680, -23734, -22773, -21689, -20536, -19414, -18218, -16947, -15769, -14606, -13297, -12125, -11394, -10696, -9565, -8257, -7135, -6080, -4936, -3863, -2920, -1981, -1050, -162, 679, 1474, 2162, 2786, 3428, 4015, 4467, 4861, 5259, 5585, 5817, 6026, 6206, 6302, 6342, 6363, 6334, 6247, 6137, 6004, 5826, 5625, 5393, 5100, 4779, 4476, 4173, 3847, 3513, 3180, 2847, 2527, 2222, 1920, 1625, 1336, 1030, 732, 483, 263, 49, -130, -266, -390, -499, -562, -596, -605, -559, -455, -322, -145, -16180, -16293, -16300, -16238, -16104, -15863, -15543, -15156, -14671, -14112, -13437, -12695, -11851, -10921, -9921, -8851, -7719, -6534, -5311, -4031, -2686, -1292, 125, 1534, 2934, 4344, 5767, 7157, 8511, 9872, 11233, 12544, 13793, 15005, 16165, 17239, 18282, 19319, 20287, 21175, 22036, 22826, 23493, 24123, 24746, 25289, 25749, 26203, 26614, 26927, 27205, 27454, 27606, 27686, 27765, 27787, 27745, 27679, 27582, 27431, 27253, 27029, 26745, 26458, 26175, 25845, 25453, 25052, 24613, 24092, 23575, 23086, 22551, 21953, 21359, 20766, 20109, 19424, 18747, 18086, 17437, 16776, 16085, 15391, 14734, 14083, 13391, 12688, 11995, 11291, 10557, 9825, 9122, 8436, 7751, 7043, 6335, 5688, 5079, 4452, 3825, 3240, 2673, 2106, 1547, 984, 409, -141, -662, -1215, -1799, -2357, -2909, -3512, -4132, -4719, -5322, -5983, -6660, -7309, -7963, -8666, -9410, -10170, -10952, -11741, -12515, -13291, -14120, -14980, -15818, -16646, -17493, -18364, -19223, -20061, -20903, -21733, -22523, -23280, -24050, -24847, -25619, -26331, -27020, -27731, -28409, -29031, -29620, -30155, -30635, -31085, -31471, -31792, -32082, -32334, -32512, -32637, -32746, -32769, -32701, -32604, -32440, -32150, -31770, -31357, -30843, -30257, -29666, -28990, -28189, -27347, -26435, -25409, -24334, -23241, -22024, -20695, -19371, -17980, -16477, -14970, -13450, -11823, -10195, -8636, -6964, -5223, -3652, -2157, -485, 1050, 2061, 2970, 4327, 5903, 7266, 8495, 9772, 10975, 12050, 13099, 14099, 14975, 15740, 16476, 17118, 17634, 18100, 18519, 18806, 18978, 19118, 19178, 19098, 18927, 18701, 18368, 17923, 17437, 16898, 16265, 15544, 14752, 13871, 12949, 11992, 10971, 9893, 8789, 7650, 6488, 5315, 4109, 2878, 1651, 422, -830, -2071, -3244, -4387, -5526, -6633, -7700, -8746, -9745, -10670, -11531, -12340, -13090, -13770, -14360, -14879, -15342, -15721, -15994};