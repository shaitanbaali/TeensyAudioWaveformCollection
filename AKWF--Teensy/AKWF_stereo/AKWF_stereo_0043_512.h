/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0043 512 samples */
 
const int16_t AKWF_stereo_0043_512_DATA [512] = 
{19060, 32141, 32406, 31917, 31657, 31334, 31009, 30724, 30406, 30085, 29768, 29454, 29138, 28829, 28518, 28209, 27906, 27600, 27297, 26998, 26615, 26720, 23613, 14831, 13344, 13495, 13273, 13123, 12976, 12824, 12676, 12530, 12381, 12233, 12086, 11939, 11793, 11647, 11502, 11357, 11211, 11067, 10924, 10781, 10637, 10496, 10354, 10212, 10070, 9930, 9789, 9649, 9510, 9371, 9231, 9093, 8955, 8817, 8681, 8544, 8408, 8273, 8137, 8002, 7867, 7734, 7600, 7467, 7334, 7202, 7069, 6937, 6806, 6675, 6545, 6414, 6284, 6155, 6026, 5898, 5769, 5641, 5514, 5387, 5260, 5134, 5009, 4882, 4758, 4633, 4508, 4385, 4261, 4138, 4015, 3892, 3770, 3648, 3527, 3407, 3287, 3167, 3046, 2927, 2807, 2688, 2570, 2450, 2333, 2225, 1451, 784, 728, 619, 517, 414, 312, 210, 109, 9, -91, -202, -294, -409, -3212, -5334, -5181, -5260, -5308, -5354, -5401, -5447, -5494, -5542, -5588, -5636, -5683, -5731, -5779, -5826, -5876, -5924, -5972, -6021, -6069, -6118, -6167, -6216, -6266, -6316, -6365, -6415, -6465, -6514, -6564, -6614, -6665, -6716, -6766, -6817, -6867, -6919, -6969, -7020, -7071, -7122, -7173, -7224, -7276, -7327, -7379, -7429, -7481, -7532, -7584, -7635, -7688, -7739, -7790, -7842, -7895, -7946, -7998, -8050, -8101, -8152, -8206, -8258, -8309, -8361, -8412, -8464, -8516, -8568, -8619, -8671, -8723, -8775, -8826, -8877, -8928, -8980, -9031, -9082, -9134, -9186, -9237, -9288, -9339, -9390, -9441, -9493, -9544, -9595, -9645, -9695, -9746, -9796, -9846, -9897, -9947, -9997, -10048, -10097, -10147, -10195, -10245, -10295, -10342, -10391, -10494, -10314, -11373, -17947, -20229, -20082, -20302, -20462, -20622, -20784, -20942, -21106, -21269, -21433, -21599, -21764, -21930, -22100, -22265, -22432, -22612, -22778, -22900, -23208, -22830, -14411, 15884, 31771, 32679, 32039, 31793, 31457, 31121, 30814, 30484, 30153, 29827, 29504, 29180, 28862, 28544, 28227, 27917, 27604, 27295, 26989, 26569, 26824, 22626, 10557, 8603, 8921, 8721, 8621, 8524, 8423, 8325, 8227, 8127, 8029, 7930, 7832, 7735, 7637, 7539, 7443, 7345, 7250, 7154, 7058, 6962, 6867, 6772, 6677, 6583, 6489, 6395, 6302, 6209, 6115, 6023, 5932, 5839, 5748, 5656, 5565, 5475, 5384, 5294, 5204, 5115, 5026, 4937, 4849, 4760, 4672, 4584, 4496, 4409, 4322, 4235, 4148, 4062, 3976, 3890, 3805, 3720, 3635, 3550, 3467, 3382, 3298, 3215, 3131, 3049, 2966, 2884, 2802, 2721, 2639, 2558, 2476, 2395, 2316, 2236, 2156, 2076, 1996, 1917, 1839, 1761, 1682, 1604, 1519, 1440, 1397, -1113, -3229, -3082, -3137, -3165, -3193, -3220, -3247, -3275, -3301, -3329, -3361, -3386, -3420, -4504, -5321, -5251, -5272, -5281, -5288, -5297, -5306, -5316, -5325, -5335, -5345, -5355, -5365, -5376, -5388, -5400, -5412, -5423, -5435, -5447, -5459, -5472, -5486, -5499, -5513, -5527, -5540, -5556, -5569, -5584, -5598, -5613, -5629, -5644, -5659, -5675, -5692, -5708, -5723, -5740, -5756, -5773, -5790, -5806, -5824, -5842, -5859, -5876, -5894, -5912, -5930, -5948, -5965, -5984, -6003, -6021, -6039, -6058, -6078, -6095, -6115, -6134, -6153, -6172, -6191, -6210, -6230, -6249, -6269, -6288, -6308, -6328, -6348, -6368, -6387, -6407, -6427, -6447, -6467, -6487, -6507, -6527, -6546, -6567, -6587, -6608, -6628, -6648, -6668, -6688, -6708, -6729, -6748, -6768, -6788, -6808, -6828, -6848, -6868, -6888, -6907, -6927, -6947, -6964, -6985, -7057, -6853, -7859, -14251, -16451, -16280, -16468, -16595, -16723, -16854, -16982, -17114, -17247, -17379, -17514, -17648, -17784, -17921, -18056, -18193, -18339, -18475, -18569, -18864, -18344, -10674};