/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0128 512 samples */
 
const int16_t AKWF_stereo_0128_512_DATA [512] = 
{410, 1158, 1970, 2856, 3780, 4439, 4816, 5183, 5379, 5729, 6073, 6646, 7492, 8137, 8661, 9239, 9775, 10180, 10511, 11122, 11915, 12717, 13275, 13683, 14247, 15029, 15998, 17132, 18256, 19333, 20410, 21571, 22814, 24099, 25271, 26218, 26981, 27830, 28622, 29329, 29927, 30341, 30660, 30761, 30334, 29936, 29677, 29456, 29188, 28729, 28508, 28671, 28934, 29328, 29881, 30072, 29918, 30028, 30322, 30651, 30887, 30798, 30352, 30259, 30577, 31091, 31676, 32306, 32747, 32580, 32234, 31904, 31376, 30855, 30196, 29618, 29175, 28666, 27939, 27273, 26698, 26080, 25502, 25021, 24476, 24289, 24227, 24231, 24236, 24308, 24463, 24470, 24105, 23721, 23331, 22940, 22563, 22135, 21498, 20649, 19387, 18367, 17767, 17345, 16990, 16572, 16190, 15757, 14792, 13583, 12521, 11500, 10373, 9247, 8389, 7944, 7600, 7314, 6915, 6001, 5040, 4327, 3813, 3367, 2716, 1652, 408, -433, -883, -1145, -1331, -1399, -1594, -2104, -2468, -2792, -3179, -3608, -4044, -4498, -5225, -6055, -6956, -8086, -9372, -10648, -11799, -13037, -14409, -15547, -16803, -18094, -19263, -20172, -20785, -21217, -21570, -21754, -21948, -22150, -22382, -22687, -23147, -23849, -25090, -26034, -26486, -26673, -26593, -26448, -26382, -26562, -27165, -27745, -28158, -28609, -29294, -30171, -30777, -30935, -30923, -30733, -30580, -30892, -31238, -31286, -31055, -30694, -30383, -30216, -30327, -30288, -30031, -29735, -29421, -28990, -28697, -28988, -29426, -29826, -30386, -30770, -31161, -31420, -31576, -31826, -32209, -32383, -32386, -32433, -32471, -32521, -32682, -32562, -32515, -32446, -32172, -31601, -30736, -29778, -28934, -27862, -26590, -25233, -23874, -22529, -21232, -20204, -19756, -19071, -17793, -16325, -14906, -13530, -12098, -10698, -9403, -8416, -7436, -6431, -5644, -4954, -4190, -3396, -2685, -2053, -1671, -1509, -1178, -855, -485, -116, 27, -160, -353, -143, 2872, 3409, 4002, 4758, 5625, 6290, 6752, 7256, 7608, 8101, 8532, 9120, 9923, 10536, 11044, 11576, 12136, 12600, 12905, 13348, 13903, 14437, 14766, 14962, 15306, 15983, 16924, 18050, 19192, 20259, 21327, 22460, 23603, 24788, 25943, 26907, 27698, 28543, 29162, 29677, 30273, 30783, 31207, 31464, 31365, 31232, 31045, 30812, 30512, 29797, 29216, 29197, 29284, 29490, 29861, 30052, 29972, 30056, 30347, 30726, 31024, 31001, 30436, 30223, 30469, 30927, 31482, 32095, 32610, 32659, 32468, 32263, 31829, 31396, 30820, 30272, 29615, 28927, 28085, 27299, 26653, 25978, 25276, 24668, 24089, 23795, 23578, 23359, 23175, 23058, 22996, 22724, 22032, 21534, 21165, 20776, 20372, 19964, 19450, 18643, 17516, 16640, 15917, 15323, 14951, 14583, 14246, 13865, 13124, 11924, 10695, 9570, 8483, 7283, 6257, 5773, 5381, 5071, 4782, 4239, 3581, 3006, 2560, 2169, 1545, 442, -1025, -2040, -2584, -2974, -3305, -3467, -3625, -3912, -4099, -4257, -4505, -4848, -5203, -5626, -6515, -7437, -8441, -9742, -11139, -12478, -13723, -14982, -16217, -17321, -18520, -19755, -20889, -21699, -22173, -22578, -23097, -23351, -23584, -23878, -24244, -24592, -24965, -25604, -26587, -27253, -27704, -27940, -27821, -27635, -27510, -27549, -27784, -28262, -28755, -29163, -29723, -30730, -31599, -31852, -31886, -31669, -31331, -31230, -31275, -31161, -30811, -30324, -29900, -29771, -30073, -30130, -29888, -29621, -29369, -28992, -28651, -28728, -28981, -29169, -29459, -29577, -29746, -29866, -30065, -30252, -30593, -30839, -30937, -31093, -31309, -31506, -31694, -31697, -31746, -31774, -31574, -30981, -30056, -29127, -28456, -27499, -26332, -25096, -23874, -22592, -21254, -20127, -19391, -18469, -17124, -15605, -14051, -12461, -10836, -9265, -7858, -6941, -6008, -4952, -4154, -3531, -2799, -1947, -1099, -332, 275, 718, 1118, 1492, 1954, 2453, 2678, 2511, 2329, 2460};