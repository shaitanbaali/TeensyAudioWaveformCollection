/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0119 512 samples */
 
const int16_t AKWF_stereo_0119_512_DATA [512] = 
{923, 2929, 4992, 7174, 9285, 11280, 13287, 15371, 17482, 19392, 21228, 23032, 24699, 26334, 28143, 29985, 31203, 31784, 32213, 32556, 32757, 32744, 32560, 32158, 31642, 31086, 30487, 29701, 28682, 27420, 25957, 24437, 22795, 20833, 18768, 16660, 14571, 12483, 10274, 8020, 6027, 4250, 2472, 620, -1195, -3068, -4867, -6466, -7977, -9584, -11320, -13012, -14554, -15891, -17210, -18672, -20225, -21778, -23286, -24747, -26111, -27314, -28519, -29750, -30228, -30044, -29856, -29509, -29024, -28315, -27535, -26744, -25913, -25027, -23857, -22409, -20880, -19356, -17753, -15958, -13960, -11815, -9667, -7582, -5600, -3680, -1678, 391, 2101, 3404, 4685, 5910, 7082, 8239, 9418, 10504, 11533, 12570, 13475, 14171, 14597, 14848, 15077, 15190, 15137, 14289, 13124, 12020, 10837, 9517, 8038, 6468, 4770, 2918, 1082, -748, -2639, -4714, -6866, -8960, -11082, -13241, -15415, -17473, -19374, -21155, -22829, -24515, -25715, -25383, -24794, -24178, -23380, -22426, -21348, -20071, -18651, -17183, -15810, -14517, -13233, -11919, -10670, -9518, -8345, -7073, -5791, -4681, -3642, -2655, -1799, -872, -419, -735, -1093, -1492, -1693, -1467, -1185, -888, -516, 133, 1039, 2101, 3200, 4333, 5552, 6797, 8082, 9270, 10417, 11623, 13004, 14579, 16300, 17977, 19639, 21354, 23230, 25124, 26538, 27347, 28068, 28725, 29196, 28965, 28518, 27937, 27283, 26593, 25928, 25184, 24174, 22991, 21821, 20757, 19640, 18282, 16790, 15242, 13740, 12233, 10457, 8610, 6738, 4927, 3149, 1310, -442, -1700, -2885, -3966, -5013, -6197, -7526, -8763, -9749, -10459, -11276, -12343, -13489, -14632, -15703, -16564, -17333, -17940, -18393, -18754, -18801, -18706, -18686, -18800, -19029, -19297, -19678, -20138, -20399, -20259, -19908, -19532, -19152, -18419, -17362, -16117, -14714, -13289, -11991, -10823, -9745, -8719, -7525, -6302, -5152, -3917, -2527, -874, -4258, -3492, -2518, -1233, 364, 2173, 4085, 6096, 8341, 10349, 12201, 13819, 15325, 16943, 18660, 20403, 21665, 22639, 23736, 24728, 25819, 27009, 28041, 28842, 29558, 30220, 30655, 30695, 30365, 29756, 28954, 27904, 26646, 25154, 23548, 21975, 20437, 18919, 17349, 15607, 13965, 12388, 10771, 9039, 7069, 5039, 3016, 1047, -934, -3008, -5023, -6940, -8730, -10386, -11820, -12988, -14166, -15449, -16782, -18109, -19553, -21171, -22864, -24494, -25558, -26067, -26610, -26955, -27007, -26928, -26641, -26198, -25651, -25027, -24254, -23183, -22034, -20948, -19988, -19055, -17987, -16732, -15274, -13678, -11982, -10135, -8203, -6144, -4262, -2728, -1221, 132, 1367, 2524, 3596, 4606, 5620, 6680, 7632, 8349, 9007, 9749, 10667, 11524, 12236, 12341, 12003, 11478, 10873, 10218, 9384, 8200, 6852, 5519, 4192, 2867, 1500, 64, -1525, -3262, -5041, -6888, -8739, -10493, -12326, -14272, -16377, -18592, -20439, -20859, -20941, -21068, -21156, -21156, -20863, -20140, -19233, -18306, -17406, -16432, -15341, -14267, -13159, -11962, -10808, -9728, -8666, -7610, -6508, -5463, -4395, -3190, -2377, -2324, -2382, -2387, -2253, -1816, -1544, -1398, -1344, -1308, -874, -222, 393, 1039, 1863, 2920, 4094, 5343, 6573, 7725, 8956, 10360, 11805, 13235, 14699, 16239, 17801, 19462, 20985, 22180, 23321, 24400, 25471, 26024, 26171, 26083, 25936, 25908, 25797, 25288, 24531, 23697, 22917, 22187, 21323, 20340, 19216, 17989, 16766, 15521, 14245, 12802, 11228, 9652, 8073, 6322, 4592, 3300, 2007, 742, -540, -1953, -3350, -4596, -5574, -6449, -7494, -8665, -9875, -11054, -12056, -12951, -13879, -14889, -15763, -16274, -16594, -16923, -17087, -16953, -16766, -16589, -16446, -16382, -16388, -16367, -16384, -16426, -16648, -16502, -15937, -15101, -13995, -13023, -12155, -11188, -10139, -9077, -8126, -7324, -6654, -6030, -5450, -4869};