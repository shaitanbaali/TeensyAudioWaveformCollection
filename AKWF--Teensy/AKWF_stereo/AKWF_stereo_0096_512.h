/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0096 512 samples */
 
const int16_t AKWF_stereo_0096_512_DATA [512] = 
{17306, 29867, 24237, 23312, 24406, 24168, 23726, 23307, 23202, 23562, 24198, 25015, 25440, 25393, 26533, 25194, 23801, 25484, 15934, -4142, 3213, 5729, 6402, 5884, 5234, 4915, 4849, 4829, 4687, 4501, 4184, 5696, -6472, -6593, -4676, 8414, 6022, 3665, 3130, -1555, 27, 3391, 4423, 4568, 4058, 3003, 2149, 1445, 973, 617, 331, 802, -1058, -10845, -8872, -8757, -4789, 3682, 438, -389, -135, 475, 1096, 899, 634, 867, 531, 3771, 13902, 11218, 12461, 5689, 181, 900, 284, 332, 344, 1060, 2348, 2937, 2942, 2687, 2157, 1895, 1979, 2164, 2368, 2496, 2477, 2371, 2266, 2218, 2200, 1919, 2758, -9884, -20279, -5605, -7600, -4465, 6114, 2567, 930, 288, 603, 1051, 1187, 1077, 1831, 3222, 2000, 1279, -931, -678, 445, 1178, 1731, 2076, 1087, 1089, -7744, -10705, -8181, -7891, 2433, 3282, 1501, 1331, 1505, 1720, 1779, 1709, 1332, 574, 9120, 15014, 15995, 13852, 5609, -3221, -545, 615, 1519, 2191, 2575, 2643, 2517, 2184, 1794, 1479, 1361, 1525, 1484, 1811, -884, -1160, 2263, 3331, 6498, -10789, -29582, -22562, -21892, -22208, -22925, -23226, -23023, -22966, -23971, -23227, -21839, -21297, -22551, -23005, -23435, -23646, -23972, -24049, -23917, -23871, -23818, -23800, -23973, -24202, -24473, -24735, -24937, -24796, -25854, -26438, -25490, 2449, 5759, 856, -1310, -2755, -2603, -1530, -1378, -575, 734, 889, 744, 1653, 1661, -10, -1198, -2722, -961, 754, 1892, 2388, 2144, 2998, -2923, -10130, -7362, -5837, 4434, 3577, 1897, 1957, 2506, 3009, 3641, 3382, 3155, 3078, 3210, 13571, 13866, 9776, 4188, 461, 3750, 6013, 5286, 2648, 732, -116, 231, 662, 1019, 1264, 1381, 1451, 1526, 1565, 1534, 1422, 1289, 1242, 1160, 1185, 1429, 1583, 18115, 29257, 24713, 27822, 31812, 32803, 31904, 29755, 27942, 27617, 28797, 30457, 31481, 31422, 31327, 29785, 28333, 30167, 21861, 2892, 8842, 7970, 4847, 2067, 1434, 2801, 4647, 5426, 4669, 3086, 1593, 2728, -8419, -7545, -6202, 3270, -98, -1730, -264, -271, 2220, 4115, 3657, 2348, 1478, 1646, 2374, 2951, 2871, 2239, 1472, 1684, 33, -8874, -6702, -7477, -5085, 1679, -1027, -7, 2146, 3786, 3804, 2613, 1211, 710, 611, 4462, 14537, 12410, 13643, 6659, 3169, 3481, 1866, 406, 56, 841, 2120, 3188, 3390, 2724, 1816, 1230, 1252, 1752, 2286, 2497, 2318, 1945, 1666, 1653, 1851, 1779, 3312, -9080, -19211, -6518, -11105, -9002, -331, -2197, -275, 2484, 3899, 3371, 1809, 489, 855, 2634, 3111, 3266, 1729, 1160, 1187, 1502, 2158, 2774, 3034, 3863, -5579, -8962, -7603, -8713, 49, 363, -341, 1327, 2967, 3489, 2744, 1511, 1079, 205, 8568, 13593, 14480, 14512, 8457, 1021, 3031, 2336, 1356, 885, 1369, 2422, 3221, 3236, 2521, 1618, 1109, 1224, 1792, 2728, 1053, 663, 2054, 1969, 5339, -11018, -28341, -22444, -24991, -28699, -31318, -31366, -29314, -27552, -27764, -27896, -28472, -28744, -29629, -29252, -28413, -27957, -28148, -28807, -29370, -29379, -28893, -28280, -27916, -27993, -28365, -28728, -28867, -28583, -28899, -29020, -28490, -1863, 615, -1868, 166, 3267, 4656, 3660, 1741, 270, 304, 1934, 3515, 4989, 4600, 2517, 859, -349, 1041, 2608, 3544, 3578, 2772, 3112, -2838, -9607, -7215, -6947, 1803, 91, -519, 1113, 3030, 3854, 3111, 1778, 809, 776, 1687, 12577, 13311, 11478, 6537, 2883, 5216, 5218, 3575, 1165, 607, 1323, 2345, 2945, 2783, 2175, 1707, 1730, 2172, 2678, 2891, 2703, 2291, 1942, 1898, 2112, 2369, 2526};