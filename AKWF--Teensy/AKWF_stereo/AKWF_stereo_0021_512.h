/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0021 512 samples */
 
const int16_t AKWF_stereo_0021_512_DATA [512] = 
{815, 2098, 3412, 4751, 6062, 7343, 8593, 9807, 10985, 12128, 13230, 14295, 15321, 16306, 17255, 18166, 19039, 19878, 20684, 21455, 22197, 22909, 23588, 24238, 24859, 25447, 26008, 26538, 27035, 27506, 27949, 28364, 28756, 29124, 29471, 29799, 30110, 30405, 30685, 30949, 31201, 31437, 31656, 31859, 32046, 32212, 32358, 32484, 32586, 32666, 32724, 32758, 32768, 32757, 32725, 32671, 32599, 32508, 32402, 32281, 32147, 32002, 31848, 31685, 31516, 31340, 31160, 30975, 30786, 30592, 30393, 30190, 29980, 29764, 29540, 29308, 29067, 28815, 28552, 28279, 27993, 27696, 27385, 27062, 26727, 26378, 26016, 25640, 25251, 24847, 24428, 23995, 23548, 23086, 22612, 22126, 21627, 21121, 20606, 20085, 19560, 19032, 18503, 17974, 17446, 16916, 16385, 15851, 15309, 14760, 14199, 13620, 13022, 12402, 11764, 11109, 10427, 9717, 8977, 8199, 7384, 6530, 5628, 4681, 3684, 2634, 1533, 378, -833, -2095, -3412, -4752, -6062, -7344, -8595, -9807, -10986, -12129, -13231, -14295, -15322, -16307, -17256, -18166, -19039, -19878, -20684, -21455, -22198, -22908, -23587, -24239, -24859, -25448, -26007, -26537, -27036, -27506, -27948, -28364, -28755, -29123, -29471, -29799, -30110, -30405, -30685, -30949, -31200, -31436, -31656, -31860, -32046, -32211, -32358, -32484, -32586, -32666, -32724, -32758, -32768, -32757, -32725, -32671, -32599, -32508, -32402, -32281, -32147, -32002, -31848, -31685, -31516, -31341, -31160, -30975, -30786, -30592, -30393, -30190, -29981, -29764, -29540, -29308, -29067, -28815, -28553, -28279, -27993, -27695, -27385, -27062, -26727, -26378, -26017, -25640, -25250, -24847, -24428, -23995, -23548, -23087, -22612, -22126, -21627, -21120, -20606, -20084, -19560, -19032, -18503, -17974, -17445, -16915, -16385, -15851, -15310, -14761, -14198, -13620, -13022, -12402, -11765, -11109, -10427, -9718, -8978, -8200, -7385, -6531, -5629, -4681, -3686, -2637, -1540, -362, 14287, 15269, 16139, 17051, 17983, 18936, 19910, 20894, 21889, 22887, 23874, 24848, 25792, 26728, 27479, 27716, 27794, 27750, 27573, 27272, 26847, 26313, 25678, 24950, 24143, 23270, 22339, 21364, 20357, 19321, 18274, 17218, 16151, 15092, 14048, 13028, 12047, 11119, 10254, 9471, 8779, 8193, 7729, 7395, 7199, 7151, 7251, 7503, 7907, 8464, 9174, 10082, 11335, 12501, 13572, 14649, 15720, 16778, 17802, 18694, 19674, 20754, 21844, 22933, 24012, 25060, 26071, 27035, 27939, 28778, 29545, 30232, 30839, 31361, 31798, 32151, 32421, 32611, 32725, 32768, 32744, 32658, 32515, 32319, 32075, 31782, 31447, 31068, 30645, 30187, 29635, 28837, 28017, 27230, 26470, 25740, 25034, 24379, 23619, 22632, 21616, 20568, 19487, 18380, 17244, 16080, 14893, 13676, 12433, 11169, 9878, 8565, 7234, 5883, 4518, 3146, 1762, 376, -1008, -2392, -3768, -5131, -6486, -7825, -9147, -10458, -11753, -13038, -14305, -15263, -16136, -17051, -17983, -18936, -19910, -20894, -21889, -22887, -23874, -24847, -25792, -26728, -27480, -27716, -27794, -27750, -27573, -27271, -26847, -26313, -25677, -24950, -24144, -23270, -22339, -21364, -20357, -19322, -18275, -17218, -16152, -15092, -14049, -13028, -12048, -11120, -10255, -9472, -8780, -8194, -7730, -7395, -7200, -7152, -7252, -7503, -7907, -8465, -9175, -10083, -11336, -12501, -13572, -14649, -15720, -16779, -17803, -18694, -19675, -20755, -21844, -22933, -24012, -25061, -26071, -27035, -27939, -28779, -29545, -30233, -30839, -31361, -31798, -32150, -32421, -32611, -32725, -32767, -32744, -32658, -32515, -32319, -32075, -31782, -31448, -31068, -30644, -30186, -29635, -28837, -28017, -27231, -26471, -25740, -25034, -24379, -23619, -22633, -21616, -20568, -19487, -18380, -17244, -16080, -14893, -13676, -12434, -11170, -9879, -8565, -7235, -5884, -4519, -3147, -1763, -377, 1007, 2391, 3767, 5130, 6485, 7824, 9146, 10455, 11748, 13053};