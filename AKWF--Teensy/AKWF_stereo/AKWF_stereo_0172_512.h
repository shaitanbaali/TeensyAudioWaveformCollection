/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0172 512 samples */
 
const int16_t AKWF_stereo_0172_512_DATA [512] = 
{310, 1220, 2116, 3024, 3924, 4842, 5741, 6641, 7519, 8417, 9292, 10147, 11011, 11854, 12681, 13499, 14304, 15091, 15867, 16634, 17373, 18103, 18817, 19506, 20176, 20838, 21484, 22104, 22719, 23315, 23877, 24423, 24964, 25476, 25953, 26430, 26877, 27271, 27680, 28097, 28344, 28617, 28977, 29298, 29579, 29874, 30146, 30379, 30614, 30840, 31025, 31200, 31380, 31524, 31632, 31756, 31863, 31928, 31993, 32054, 32080, 32080, 32098, 32091, 32039, 31995, 31946, 31849, 31746, 31643, 31508, 31330, 31168, 30988, 30755, 30512, 30264, 29980, 29663, 29360, 29033, 28653, 28278, 27906, 27489, 27057, 26643, 26185, 25721, 25276, 24806, 24307, 23832, 23347, 22837, 22337, 21850, 21360, 20838, 20309, 19784, 19223, 18673, 18125, 17542, 16950, 16363, 15751, 15104, 14465, 13813, 13131, 12435, 11736, 11010, 10259, 9512, 8744, 7944, 7143, 6347, 5528, 4684, 3840, 2979, 2103, 1218, 333, -570, -1470, -2362, -3279, -4179, -5085, -5990, -6900, -7780, -8673, -9549, -10415, -11272, -12109, -12932, -13744, -14541, -15320, -16093, -16857, -17598, -18312, -19039, -19799, -20465, -21127, -21778, -22393, -22992, -23586, -24150, -24688, -25222, -25738, -26209, -26673, -27122, -27522, -27912, -28308, -28665, -29006, -29349, -29666, -29941, -30221, -30493, -30723, -30944, -31166, -31355, -31509, -31676, -31826, -31932, -32038, -32140, -32205, -32252, -32309, -32342, -32329, -32325, -32322, -32273, -32209, -32154, -32068, -31937, -31826, -31699, -31518, -31330, -31146, -30905, -30664, -30414, -30122, -29798, -29486, -29155, -28773, -28397, -28017, -27601, -27173, -26760, -26316, -25833, -25374, -24911, -24413, -23922, -23435, -22929, -22408, -21917, -21440, -20911, -20365, -19969, -19556, -18970, -18422, -17851, -17241, -16644, -16031, -15386, -14736, -14081, -13400, -12688, -11982, -11265, -10506, -9747, -8973, -8187, -7393, -6593, -5780, -4937, -4087, -3231, -2359, -1483, -562, 13236, 13963, 14675, 15388, 16089, 16810, 17500, 18171, 18828, 19499, 20128, 20737, 21349, 21931, 22489, 23043, 23577, 24078, 24576, 25065, 25519, 25978, 26430, 26850, 27255, 27668, 28066, 28431, 28810, 29173, 29503, 29829, 30160, 30459, 30721, 30996, 31248, 31454, 31666, 31870, 31995, 32108, 32247, 32357, 32417, 32492, 32539, 32541, 32551, 32549, 32499, 32436, 32379, 32285, 32152, 32030, 31894, 31703, 31502, 31307, 31074, 30814, 30570, 30289, 29960, 29636, 29302, 28911, 28505, 28098, 27653, 27159, 26678, 26173, 25605, 25038, 24471, 23866, 23225, 22596, 21943, 21245, 20552, 19857, 19108, 18328, 17578, 16820, 15940, 15050, 14284, 13480, 12702, 11920, 11126, 10352, 9593, 8851, 8093, 7330, 6586, 5820, 5064, 4323, 3569, 2815, 2073, 1325, 573, -161, -893, -1625, -2357, -3089, -3824, -4549, -5267, -5999, -6731, -7455, -8158, -8850, -9548, -10239, -10935, -11636, -12340, -13042, -13751, -14456, -15162, -15877, -16558, -17260, -17949, -18622, -19272, -19929, -20549, -21162, -21766, -22343, -22892, -23434, -23962, -24462, -24963, -25453, -25903, -26339, -26788, -27230, -27622, -28023, -28414, -28773, -29127, -29489, -29818, -30121, -30437, -30734, -30985, -31238, -31484, -31692, -31884, -32080, -32229, -32362, -32495, -32597, -32646, -32703, -32750, -32743, -32730, -32722, -32677, -32592, -32520, -32430, -32285, -32142, -31994, -31805, -31593, -31391, -31166, -30887, -30617, -30346, -30034, -29706, -29376, -28997, -28566, -28151, -27709, -27206, -26699, -26188, -25623, -25058, -24483, -23865, -23219, -22590, -21946, -21247, -20548, -19840, -19091, -18316, -17562, -16795, -15995, -15220, -14443, -13643, -12858, -12079, -11290, -10504, -9748, -9018, -8253, -7457, -6858, -6270, -5482, -4741, -3989, -3224, -2479, -1736, -986, -245, 497, 1236, 1974, 2707, 3437, 4175, 4906, 5636, 6349, 7054, 7767, 8466, 9171, 9864, 10558, 11268, 11956, 12557};