/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0174 512 samples */
 
const int16_t AKWF_stereo_0174_512_DATA [512] = 
{401, 1220, 2040, 2879, 3733, 4601, 5484, 6369, 7272, 8180, 9089, 10004, 10921, 11824, 12735, 13637, 14518, 15387, 16250, 17090, 17906, 18711, 19485, 20222, 20942, 21640, 22292, 22913, 23508, 24069, 24582, 25079, 25535, 25938, 26325, 26679, 26975, 27245, 27492, 27689, 27835, 27968, 28071, 28117, 28154, 28177, 28155, 28117, 28085, 28033, 27945, 27868, 27786, 27669, 27556, 27453, 27331, 27187, 27068, 26950, 26803, 26674, 26562, 26432, 26299, 26200, 26079, 25955, 25861, 25765, 25646, 25556, 25476, 25369, 25269, 25191, 25099, 24984, 24890, 24794, 24663, 24542, 24426, 24280, 24110, 23950, 23765, 23537, 23307, 23062, 22769, 22455, 22138, 21783, 21380, 20976, 20546, 20062, 19568, 19053, 18496, 17896, 17290, 16657, 15968, 15269, 14556, 13801, 13030, 12257, 11460, 10637, 9822, 8998, 8184, 7388, 6598, 5780, 4986, 4198, 3406, 2617, 1847, 1074, 309, -431, -1182, -1900, -2622, -3327, -4013, -4690, -5344, -5989, -6620, -7231, -7827, -8416, -8986, -9548, -10100, -10633, -11164, -11689, -12205, -12711, -13223, -13724, -14221, -14721, -15224, -15724, -16225, -16737, -17247, -17760, -18288, -18816, -19336, -19874, -20417, -20947, -21486, -22040, -22585, -23120, -23670, -24219, -24745, -25284, -25825, -26345, -26852, -27370, -27871, -28336, -28805, -29265, -29680, -30080, -30476, -30815, -31143, -31462, -31741, -31970, -32196, -32385, -32513, -32630, -32726, -32762, -32753, -32735, -32676, -32553, -32419, -32253, -32021, -31763, -31491, -31179, -30810, -30438, -30038, -29589, -29126, -28654, -28143, -27595, -27065, -26520, -25925, -25346, -24766, -24151, -23542, -22947, -22333, -21701, -21116, -20537, -19926, -19333, -18761, -18175, -17579, -17023, -16465, -15903, -15366, -14839, -14298, -13775, -13264, -12735, -12197, -11679, -11146, -10594, -10058, -9513, -8942, -8370, -7796, -7201, -6592, -5978, -5346, -4685, -4015, -3334, -2626, -1894, -1153, -373, 15992, 16392, 16757, 17107, 17460, 17798, 18118, 18438, 18754, 19043, 19321, 19596, 19860, 20096, 20339, 20569, 20763, 20953, 21140, 21299, 21435, 21576, 21697, 21786, 21872, 21953, 21994, 22020, 22051, 22054, 22025, 22002, 21957, 21878, 21806, 21720, 21600, 21474, 21353, 21203, 21036, 20882, 20715, 20516, 20329, 20148, 19944, 19741, 19560, 19376, 19175, 19000, 18832, 18646, 18476, 18321, 18163, 18002, 17864, 17735, 17591, 17458, 17346, 17226, 17104, 17008, 16900, 16794, 16710, 16621, 16521, 16435, 16359, 16267, 16180, 16108, 16027, 15929, 15848, 15764, 15652, 15548, 15441, 15313, 15160, 15014, 14838, 14625, 14398, 14146, 13855, 13543, 13222, 12870, 12479, 12084, 11672, 11224, 10765, 10291, 9784, 9250, 8714, 8154, 7558, 6951, 6328, 5678, 5021, 4357, 3681, 2986, 2294, 1593, 905, 222, -462, -1169, -1864, -2562, -3266, -3973, -4675, -5387, -6086, -6776, -7485, -8166, -8853, -9539, -10213, -10883, -11550, -12215, -12865, -13505, -14144, -14774, -15389, -16003, -16614, -17204, -17798, -18395, -18976, -19541, -20116, -20684, -21234, -21790, -22345, -22877, -23400, -23930, -24434, -24930, -25427, -25906, -26359, -26819, -27271, -27686, -28089, -28494, -28870, -29211, -29559, -29888, -30167, -30452, -30726, -30956, -31157, -31357, -31527, -31642, -31756, -31851, -31886, -31898, -31902, -31837, -31754, -31656, -31512, -31312, -31105, -30860, -30543, -30209, -29860, -29444, -28982, -28517, -28005, -27429, -26848, -26233, -25552, -24843, -24124, -23366, -22558, -21753, -20928, -20064, -19191, -18314, -17409, -16478, -15566, -14647, -13690, -12752, -11813, -10850, -9902, -8969, -8024, -7083, -6203, -5342, -4465, -3605, -2768, -1936, -1103, -312, 460, 1225, 1960, 2670, 3365, 4039, 4694, 5341, 5974, 6581, 7181, 7764, 8331, 8894, 9438, 9969, 10498, 11014, 11513, 12010, 12498, 12969, 13431, 13894, 14342, 14772, 15199, 15618};