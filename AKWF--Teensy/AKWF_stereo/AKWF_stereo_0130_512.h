/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0130 512 samples */
 
const int16_t AKWF_stereo_0130_512_DATA [512] = 
{578, 1263, 1846, 2453, 3314, 4430, 5569, 6496, 7137, 7751, 8618, 9706, 10729, 11674, 12464, 13164, 13907, 14658, 15541, 16414, 17187, 17830, 18519, 19286, 20066, 20694, 21118, 21487, 21843, 22202, 22449, 22814, 23302, 23825, 24361, 25003, 25759, 26457, 27080, 27541, 27845, 28084, 28364, 28614, 28824, 29024, 29102, 29158, 29233, 29468, 29773, 30022, 30157, 30166, 30148, 30250, 30417, 30505, 30530, 30523, 30595, 30774, 30911, 31086, 31272, 31453, 31621, 31730, 31729, 31609, 31412, 31308, 31299, 31341, 31316, 31123, 30746, 30434, 30124, 29661, 28948, 28095, 27301, 26696, 26432, 26353, 26229, 25903, 25369, 24868, 24371, 23995, 23459, 22676, 21694, 20842, 20019, 19118, 18099, 16963, 15901, 15042, 14454, 13909, 13191, 12280, 11217, 10215, 9377, 8567, 7732, 6883, 6104, 5580, 5094, 4507, 3924, 3255, 2681, 2192, 1703, 1284, 943, 666, 442, 149, -176, -574, -1217, -1905, -2601, -3320, -4036, -4657, -5164, -5666, -6266, -6867, -7214, -7271, -7228, -7484, -8091, -8950, -9861, -10610, -11169, -11593, -12227, -13149, -14130, -14911, -15334, -15550, -15927, -16504, -17090, -17646, -18031, -18446, -19008, -19710, -20393, -20964, -21461, -22001, -22521, -22971, -23398, -23688, -23919, -24119, -24356, -24626, -24811, -24978, -25111, -25368, -25817, -26375, -26890, -27280, -27551, -27795, -28098, -28312, -28495, -28601, -28662, -28710, -28808, -28979, -29161, -29387, -29714, -30129, -30569, -30981, -31376, -31710, -32008, -32294, -32577, -32728, -32768, -32690, -32542, -32483, -32517, -32393, -32044, -31573, -31085, -30630, -30185, -29792, -29393, -28952, -28376, -27673, -26915, -26207, -25517, -24806, -23938, -22908, -21892, -21037, -20462, -19976, -19420, -18713, -17905, -17223, -16679, -16134, -15445, -14558, -13536, -12609, -11727, -10858, -10015, -9185, -8347, -7575, -6913, -6257, -5579, -4695, -3835, -3216, -2751, -2217, -1405, -348, 8385, 9096, 9762, 10397, 11208, 12212, 13176, 13912, 14337, 14805, 15567, 16642, 17749, 18782, 19664, 20442, 21206, 21947, 22751, 23469, 24067, 24555, 25142, 25800, 26435, 26928, 27210, 27452, 27727, 28076, 28350, 28711, 29109, 29473, 29783, 30182, 30650, 31012, 31298, 31487, 31626, 31739, 31885, 31973, 32079, 32174, 32158, 32092, 32006, 32074, 32185, 32267, 32169, 31907, 31580, 31388, 31261, 31110, 31005, 30898, 30881, 30901, 30907, 30883, 30879, 30890, 30839, 30740, 30516, 30241, 29862, 29565, 29348, 29216, 29011, 28656, 28113, 27566, 27092, 26498, 25723, 24783, 23889, 23179, 22781, 22474, 22044, 21445, 20676, 20002, 19292, 18720, 18018, 17142, 16069, 15097, 14206, 13282, 12255, 11030, 9858, 8885, 8224, 7562, 6704, 5644, 4368, 3242, 2327, 1554, 739, -160, -1072, -1758, -2402, -3133, -3792, -4511, -5101, -5627, -6120, -6563, -6981, -7385, -7792, -8212, -8611, -9028, -9630, -10264, -10910, -11544, -12180, -12723, -13159, -13630, -14182, -14727, -14977, -14967, -14904, -15177, -15756, -16541, -17334, -17990, -18494, -18868, -19450, -20228, -21003, -21572, -21840, -21953, -22177, -22555, -22935, -23351, -23666, -24043, -24469, -24968, -25424, -25810, -26177, -26581, -26942, -27175, -27357, -27432, -27494, -27513, -27560, -27639, -27731, -27823, -27823, -27887, -28072, -28336, -28537, -28712, -28833, -28960, -29115, -29201, -29223, -29104, -28935, -28650, -28405, -28239, -28195, -28246, -28412, -28680, -28988, -29298, -29538, -29715, -29781, -29869, -30008, -30016, -29874, -29523, -29079, -28668, -28470, -28252, -27955, -27554, -27087, -26609, -26080, -25542, -24947, -24267, -23361, -22375, -21406, -20590, -19847, -19028, -18039, -16892, -15814, -14889, -14179, -13512, -12823, -12032, -11157, -10376, -9741, -9186, -8434, -7505, -6438, -5453, -4477, -3474, -2491, -1558, -691, 77, 711, 1386, 2011, 2790, 3594, 4242, 4839, 5502, 6407, 7476};