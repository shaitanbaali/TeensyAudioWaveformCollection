/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0189 512 samples */
 
const int16_t AKWF_stereo_0189_512_DATA [512] = 
{969, 2735, 4428, 6082, 7692, 9251, 10753, 12188, 13552, 14847, 16069, 17232, 18311, 19312, 20225, 21038, 21773, 22424, 22967, 23423, 23805, 24075, 24263, 24380, 24399, 24321, 24185, 23968, 23649, 23274, 22842, 22322, 21732, 21108, 20422, 19663, 18884, 18074, 17211, 16330, 15443, 14537, 13614, 12711, 11817, 10925, 10066, 9246, 8451, 7693, 6998, 6357, 5761, 5239, 4786, 4396, 4082, 3852, 3698, 3620, 3631, 3725, 3898, 4155, 4501, 4922, 5417, 5992, 6633, 7341, 8121, 8960, 9846, 10785, 11771, 12786, 13833, 14909, 16002, 17092, 18215, 19355, 20429, 21496, 22547, 23560, 24521, 25460, 26351, 27166, 27942, 28666, 29306, 29871, 30389, 30807, 31141, 31417, 31605, 31680, 31696, 31631, 31445, 31174, 30833, 30382, 29815, 29183, 28456, 27607, 26678, 25673, 24560, 23345, 22077, 20725, 19265, 17756, 16183, 14524, 12814, 11083, 9302, 7485, 5670, 3840, 2002, 179, -1595, -3329, -5032, -6691, -8300, -9857, -11357, -12791, -14151, -15437, -16656, -17820, -18894, -19889, -20800, -21608, -22342, -22992, -23535, -23993, -24376, -24662, -24846, -24963, -24995, -24923, -24784, -24577, -24274, -23890, -23459, -22957, -22365, -21738, -21061, -20312, -19523, -18709, -17813, -16916, -16024, -15119, -14194, -13278, -12382, -11496, -10622, -9793, -9001, -8235, -7530, -6884, -6286, -5757, -5309, -4927, -4612, -4384, -4229, -4153, -4164, -4258, -4430, -4689, -5031, -5450, -5946, -6525, -7175, -7888, -8672, -9515, -10407, -11346, -12336, -13363, -14410, -15489, -16591, -17689, -18787, -19895, -20984, -22040, -23089, -24110, -25071, -26003, -26896, -27709, -28481, -29204, -29843, -30406, -30918, -31351, -31679, -31948, -32145, -32229, -32230, -32165, -32000, -31719, -31374, -30937, -30374, -29732, -29009, -28158, -27230, -26226, -25112, -23894, -22620, -21260, -19794, -18282, -16722, -15077, -13385, -11667, -9903, -8060, -6235, -4422, -2595, -747, -1296, 570, 2360, 4114, 5824, 7479, 9074, 10598, 12044, 13414, 14704, 15930, 17063, 18102, 19044, 19872, 20608, 21246, 21762, 22178, 22503, 22701, 22801, 22814, 22714, 22499, 22209, 21823, 21322, 20746, 20097, 19349, 18519, 17641, 16690, 15660, 14600, 13499, 12341, 11161, 9969, 8758, 7534, 6328, 5136, 3956, 2808, 1702, 638, -374, -1319, -2195, -3004, -3728, -4366, -4918, -5375, -5738, -6003, -6163, -6224, -6182, -6031, -5780, -5426, -4965, -4402, -3744, -2990, -2139, -1202, -184, 913, 2078, 3302, 4586, 5921, 7293, 8701, 10128, 11586, 13069, 14517, 15956, 17384, 18778, 20123, 21441, 22708, 23897, 25038, 26117, 27107, 28013, 28857, 29594, 30240, 30814, 31287, 31637, 31913, 32095, 32146, 32098, 31968, 31717, 31337, 30879, 30314, 29611, 28815, 27930, 26923, 25802, 24609, 23319, 21906, 20432, 18891, 17247, 15541, 13791, 11975, 10107, 8232, 6331, 4409, 2495, 627, -1203, -3010, -4771, -6480, -8139, -9734, -11257, -12705, -14074, -15363, -16590, -17717, -18753, -19694, -20520, -21254, -21892, -22408, -22824, -23150, -23364, -23460, -23473, -23385, -23177, -22884, -22505, -22018, -21434, -20785, -20050, -19214, -18330, -17384, -16358, -15286, -14177, -12993, -11794, -10591, -9373, -8141, -6919, -5718, -4536, -3383, -2283, -1229, -219, 720, 1590, 2391, 3113, 3748, 4296, 4751, 5112, 5376, 5536, 5595, 5553, 5404, 5152, 4800, 4342, 3780, 3124, 2375, 1528, 596, -413, -1508, -2680, -3911, -5202, -6542, -7920, -9336, -10773, -12220, -13680, -15136, -16570, -17997, -19396, -20741, -22052, -23320, -24506, -25644, -26720, -27707, -28612, -29452, -30203, -30841, -31406, -31885, -32243, -32506, -32690, -32758, -32700, -32567, -32329, -31955, -31489, -30928, -30227, -29436, -28556, -27549, -26425, -25231, -23938, -22519, -21040, -19492, -17840, -16128, -14389, -12591, -10711, -8833, -6948, -5040, -3101};