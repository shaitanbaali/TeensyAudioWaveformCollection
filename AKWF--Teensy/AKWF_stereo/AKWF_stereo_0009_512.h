/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0009 512 samples */
 
const int16_t AKWF_stereo_0009_512_DATA [512] = 
{97, 266, 425, 582, 735, 881, 1024, 1161, 1295, 1424, 1549, 1664, 1770, 1880, 1985, 2087, 2181, 2273, 2361, 2443, 2521, 2598, 2669, 2721, 2762, 2820, 2871, 2919, 2963, 3002, 3039, 3069, 3096, 3120, 3137, 3155, 3156, 3139, 3146, 3142, 3138, 3130, 3117, 3101, 3082, 3058, 3034, 3001, 2970, 2920, 2861, 2827, 2880, 2493, 3933, 22100, 31559, 30887, 32255, 32218, 30828, 29728, 27509, 26389, 24826, 23877, 23068, 22329, 22078, 21692, 21731, 21725, 21907, 22196, 22481, 22761, 23108, 23556, 23977, 24407, 24833, 25228, 25618, 25965, 26294, 26583, 26846, 27051, 27106, 27257, 27368, 27446, 27488, 27495, 27473, 27415, 27330, 27215, 27068, 26916, 26669, 26338, 26116, 25857, 25585, 25298, 24987, 24641, 24272, 23892, 23504, 23097, 22702, 22200, 21693, 21284, 20750, 20592, 18934, 956, -9171, -9085, -11094, -11727, -10837, -10054, -8311, -7691, -6563, -6055, -5725, -5439, -5674, -5764, -6290, -6770, -7436, -8200, -8968, -9807, -10634, -11546, -12425, -13316, -14200, -15022, -15830, -16584, -17309, -17985, -18620, -19203, -19646, -20139, -20583, -20984, -21339, -21653, -21925, -22156, -22350, -22508, -22626, -22730, -22683, -22664, -22673, -22646, -22596, -22524, -22430, -22318, -22188, -22041, -21878, -21708, -21537, -21215, -20986, -20772, -20541, -20303, -20059, -19806, -19548, -19284, -19014, -18740, -18466, -18157, -17759, -17473, -17182, -16889, -16593, -16295, -15997, -15696, -15394, -15090, -14784, -14486, -14134, -13748, -13451, -13144, -12838, -12533, -12228, -11922, -11617, -11313, -11008, -10705, -10409, -10053, -9712, -9423, -9125, -8832, -8539, -8247, -7959, -7673, -7388, -7104, -6821, -6538, -6261, -5971, -5705, -5437, -5173, -4911, -4653, -4399, -4146, -3898, -3653, -3411, -3169, -2910, -2677, -2453, -2230, -2013, -1800, -1591, -1387, -1184, -987, -795, -606, -416, -234, -57, 4862, 5062, 5250, 5434, 5612, 5781, 5944, 6100, 6251, 6394, 6532, 6657, 6771, 6886, 6995, 7097, 7191, 7280, 7362, 7438, 7505, 7571, 7629, 7665, 7688, 7725, 7755, 7777, 7796, 7806, 7812, 7810, 7803, 7790, 7768, 7747, 7705, 7644, 7604, 7553, 7500, 7440, 7372, 7304, 7227, 7145, 7061, 6965, 6872, 6756, 6628, 6528, 6526, 5959, 7824, 27098, 32428, 28093, 30890, 31849, 30778, 30367, 28352, 27913, 26694, 26210, 25767, 25248, 25235, 24892, 24995, 24924, 25010, 25156, 25230, 25293, 25365, 25538, 25654, 25769, 25877, 25941, 26005, 26023, 26029, 25996, 25947, 25839, 25581, 25440, 25265, 25069, 24844, 24593, 24323, 24025, 23710, 23374, 23015, 22659, 22206, 21675, 21275, 20842, 20406, 19957, 19499, 19066, 18624, 18178, 17731, 17272, 16832, 16282, 15734, 15297, 14719, 14660, 12447, -6792, -13173, -9726, -13038, -14769, -14370, -14429, -13114, -13326, -12713, -12800, -12954, -12986, -13544, -13756, -14413, -14895, -15522, -16198, -16812, -17491, -18098, -18788, -19420, -20035, -20625, -21171, -21716, -22201, -22667, -23086, -23473, -23814, -24024, -24293, -24525, -24723, -24884, -25015, -25113, -25179, -25218, -25228, -25209, -25180, -25005, -24868, -24767, -24635, -24484, -24317, -24134, -23936, -23721, -23494, -23254, -23002, -22752, -22352, -22051, -21765, -21463, -21155, -20840, -20516, -20186, -19850, -19509, -19162, -18814, -18428, -17949, -17588, -17219, -16846, -16471, -16094, -15714, -15329, -14943, -14555, -14164, -13779, -13338, -12862, -12477, -12082, -11687, -11291, -10896, -10500, -10105, -9710, -9316, -8921, -8534, -8086, -7654, -7277, -6888, -6506, -6126, -5747, -5373, -5000, -4630, -4263, -3895, -3524, -3165, -2794, -2449, -2104, -1763, -1426, -1094, -767, -443, -127, 185, 494, 800, 1124, 1417, 1700, 1981, 2252, 2520, 2780, 3034, 3285, 3527, 3763, 3994, 4223, 4445, 4657};