/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0067 512 samples */
 
const int16_t AKWF_stereo_0067_512_DATA [512] = 
{501, 1319, 2125, 2942, 3757, 4570, 5383, 6188, 6987, 7780, 8564, 9338, 10104, 10857, 11602, 12333, 13052, 13760, 14457, 15138, 15808, 16466, 17109, 17740, 18356, 18959, 19549, 20125, 20686, 21235, 21769, 22288, 22796, 23286, 23764, 24228, 24677, 25114, 25535, 25945, 26337, 26717, 27083, 27434, 27774, 28097, 28407, 28705, 28986, 29255, 29511, 29753, 29980, 30195, 30395, 30582, 30756, 30916, 31062, 31195, 31314, 31420, 31511, 31590, 31656, 31708, 31746, 31772, 31765, 31659, 31476, 31245, 30975, 30673, 30344, 29988, 29606, 29201, 28778, 28330, 27866, 27379, 26875, 26353, 25812, 25254, 24681, 24090, 23482, 22860, 22221, 21569, 20899, 20215, 19519, 18810, 18084, 17348, 16600, 15837, 15066, 14285, 13490, 12690, 11878, 11059, 10237, 9407, 8572, 7738, 6900, 6064, 5234, 4409, 3598, 2807, 2043, 1318, 664, 155, -360, 1580, 3588, 2976, 2445, 1772, 1042, 276, -513, -1316, -2125, -2943, -3758, -4573, -5384, -6189, -6988, -7781, -8564, -9339, -10105, -10858, -11602, -12334, -13052, -13761, -14457, -15139, -15809, -16467, -17109, -17740, -18358, -18960, -19550, -20126, -20686, -21235, -21769, -22288, -22796, -23286, -23764, -24228, -24678, -25114, -25535, -25945, -26337, -26718, -27083, -27436, -27774, -28097, -28408, -28705, -28986, -29256, -29512, -29753, -29980, -30195, -30396, -30582, -30756, -30916, -31062, -31195, -31314, -31420, -31511, -31590, -31656, -31708, -31746, -31772, -31765, -31659, -31476, -31246, -30976, -30673, -30344, -29988, -29606, -29201, -28778, -28330, -27866, -27379, -26875, -26353, -25814, -25255, -24681, -24091, -23483, -22861, -22222, -21569, -20901, -20216, -19519, -18811, -18085, -17349, -16600, -15837, -15067, -14285, -13491, -12690, -11879, -11060, -10237, -9407, -8573, -7739, -6901, -6064, -5235, -4410, -3600, -2809, -2044, -1319, -665, -156, 359, -1581, -3589, -2977, -2446, -1775, -1045, -267, 11982, 12780, 13510, 14201, 14855, 15481, 16077, 16652, 17205, 17741, 18255, 18757, 19243, 19716, 20176, 20625, 21062, 21489, 21904, 22309, 22707, 23095, 23473, 23845, 24207, 24560, 24907, 25245, 25576, 25899, 26213, 26522, 26824, 27117, 27402, 27682, 27953, 28218, 28477, 28726, 28969, 29205, 29434, 29656, 29870, 30077, 30277, 30470, 30655, 30833, 31005, 31168, 31324, 31474, 31614, 31749, 31876, 31993, 32105, 32209, 32304, 32393, 32475, 32548, 32613, 32670, 32720, 32762, 32724, 32630, 32528, 32412, 32283, 32141, 31988, 31826, 31654, 31475, 31283, 31085, 30877, 30661, 30436, 30206, 29962, 29709, 29449, 29179, 28898, 28610, 28309, 27998, 27678, 27346, 27004, 26650, 26282, 25904, 25511, 25106, 24688, 24254, 23805, 23340, 22858, 22356, 21838, 21295, 20727, 20136, 19513, 18856, 18163, 17423, 16628, 15767, 14818, 13753, 12518, 10929, 9337, 2228, -5039, -6431, -7973, -9176, -10215, -11145, -11994, -12777, -13509, -14201, -14857, -15481, -16078, -16653, -17206, -17741, -18255, -18758, -19244, -19717, -20178, -20624, -21062, -21489, -21904, -22309, -22707, -23095, -23473, -23845, -24207, -24560, -24908, -25245, -25576, -25899, -26214, -26522, -26824, -27117, -27403, -27682, -27953, -28218, -28477, -28726, -28969, -29205, -29435, -29657, -29870, -30077, -30277, -30470, -30655, -30834, -31006, -31168, -31324, -31474, -31615, -31749, -31876, -31993, -32105, -32209, -32305, -32392, -32474, -32548, -32614, -32670, -32719, -32762, -32724, -32630, -32529, -32412, -32283, -32141, -31988, -31826, -31654, -31475, -31284, -31085, -30877, -30661, -30436, -30206, -29962, -29709, -29449, -29179, -28898, -28610, -28309, -27999, -27678, -27347, -27004, -26650, -26283, -25904, -25512, -25107, -24689, -24254, -23805, -23340, -22859, -22357, -21838, -21296, -20728, -20136, -19513, -18857, -18164, -17424, -16627, -15768, -14818, -13753, -12519, -10930, -9337, -2229, 5038, 6430, 7972, 9174, 10210, 11154};