/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0033 512 samples */
 
const int16_t AKWF_stereo_0033_512_DATA [512] = 
{2918, 7852, 12490, 16683, 20291, 23369, 25989, 28200, 30033, 31456, 32375, 32668, 32302, 31407, 30148, 28721, 27294, 25929, 24648, 23462, 22447, 21696, 21245, 21083, 21225, 21678, 22395, 23350, 24573, 26070, 27718, 29345, 30788, 31906, 32595, 32738, 32337, 31492, 30246, 28623, 26676, 24489, 22099, 19504, 16785, 14031, 11239, 8439, 5720, 3083, 439, -2272, -4927, -7321, -9360, -11027, -12306, -13200, -13819, -14272, -14521, -14446, -13961, -13097, -11939, -10564, -9095, -7735, -6617, -5738, -5069, -4517, -3989, -3485, -3083, -2848, -2721, -2611, -2514, -2502, -2588, -2778, -3151, -3757, -4559, -5492, -6523, -7662, -8932, -10348, -11939, -13679, -15458, -17183, -18788, -20209, -21365, -22213, -22850, -23429, -24005, -24607, -25150, -25739, -26314, -26865, -27367, -27911, -28462, -28936, -29358, -29764, -30148, -30522, -31009, -31628, -32077, -31993, -31231, -29835, -27897, -25444, -22486, -19120, -15357, -11156, -6639, -1897, 2966, 7807, 12456, 16656, 20264, 23342, 25965, 28177, 30012, 31437, 32358, 32654, 32293, 31401, 30147, 28725, 27302, 25940, 24661, 23479, 22466, 21716, 21264, 21104, 21246, 21697, 22415, 23370, 24591, 26087, 27733, 29360, 30801, 31920, 32608, 32751, 32353, 31510, 30266, 28645, 26701, 24517, 22130, 19538, 16821, 14069, 11280, 8483, 5767, 3130, 486, -2223, -4879, -7272, -9310, -10980, -12260, -13154, -13777, -14231, -14484, -14409, -13927, -13066, -11911, -10537, -9072, -7715, -6598, -5722, -5052, -4501, -3973, -3469, -3067, -2832, -2706, -2594, -2497, -2486, -2572, -2762, -3133, -3739, -4541, -5472, -6502, -7641, -8910, -10324, -11915, -13655, -15432, -17155, -18760, -20180, -21338, -22187, -22824, -23404, -23982, -24576, -25139, -25729, -26302, -26840, -27345, -27891, -28442, -28917, -29339, -29746, -30130, -30505, -30989, -31638, -32099, -32015, -31255, -29862, -27927, -25480, -22524, -19161, -15402, -11214, -6713, -1883, -15240, -16220, -16761, -16956, -16926, -16824, -16711, -16632, -16628, -16515, -16095, -15377, -14447, -13343, -12072, -10690, -9362, -8266, -7484, -7104, -7141, -7432, -7681, -7581, -7042, -6163, -5076, -3994, -3114, -2452, -1875, -1322, -845, -546, -670, -1385, -2695, -4473, -6384, -7980, -8930, -8951, -7944, -6022, -3323, 48, 4094, 8739, 13590, 18125, 22017, 25143, 27533, 29351, 30781, 31875, 32573, 32760, 32341, 31249, 29464, 27168, 24646, 22101, 19748, 17781, 16234, 15022, 14044, 13298, 12905, 12983, 13596, 14822, 16595, 18601, 20427, 21766, 22494, 22646, 22210, 21161, 19623, 17746, 15660, 13451, 11215, 9060, 7072, 5370, 3999, 2789, 1540, 268, -920, -2105, -3495, -5212, -7332, -9848, -12636, -15614, -18328, -20787, -22890, -24582, -25607, -25957, -25667, -24734, -23116, -20854, -18224, -15589, -13269, -11491, -10319, -9618, -9171, -8847, -8673, -8705, -8920, -9377, -10193, -11330, -12627, -13978, -15254, -16207, -16752, -16950, -16921, -16820, -16707, -16628, -16625, -16513, -16093, -15376, -14448, -13344, -12074, -10694, -9369, -8273, -7490, -7111, -7146, -7436, -7683, -7584, -7045, -6166, -5081, -3999, -3119, -2456, -1880, -1326, -849, -551, -675, -1388, -2695, -4470, -6380, -7974, -8924, -8946, -7941, -6021, -3326, 41, 4082, 8721, 13569, 18100, 21990, 25115, 27505, 29325, 30756, 31852, 32553, 32742, 32327, 31238, 29458, 27167, 24647, 22107, 19755, 17790, 16245, 15034, 14056, 13309, 12915, 12994, 13604, 14828, 16599, 18601, 20425, 21762, 22491, 22645, 22209, 21162, 19626, 17753, 15669, 13463, 11229, 9075, 7087, 5387, 4016, 2806, 1557, 285, -903, -2088, -3478, -5195, -7314, -9827, -12617, -15576, -18330, -20794, -22887, -24549, -25583, -25933, -25646, -24717, -23102, -20845, -18218, -15586, -13270, -11513, -10346, -9644, -9196, -8871, -8696, -8725, -8939, -9394, -10207, -11341, -12633, -14003};