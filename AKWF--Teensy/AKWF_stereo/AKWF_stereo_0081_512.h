/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0081 512 samples */
 
const int16_t AKWF_stereo_0081_512_DATA [512] = 
{716, 2457, 4148, 5823, 7467, 9079, 10649, 12167, 13633, 15035, 16366, 17625, 18804, 19894, 20894, 21799, 22601, 23301, 23891, 24367, 24733, 24978, 25194, 25468, 25769, 26079, 26389, 26689, 26973, 27240, 27481, 27696, 27882, 28039, 28162, 28255, 28313, 28337, 28328, 28288, 28215, 28114, 27987, 27837, 27665, 27472, 27262, 27039, 26805, 26560, 26309, 26056, 25799, 25543, 25290, 25041, 24797, 24560, 24330, 24109, 23898, 23694, 23498, 23313, 23134, 22966, 22808, 22659, 22519, 22381, 22248, 22123, 22004, 21893, 21787, 21679, 21570, 21458, 21338, 21209, 21070, 20918, 20750, 20568, 20368, 20151, 19917, 19662, 19387, 19093, 18780, 18450, 18099, 17729, 17342, 16939, 16519, 16085, 15634, 15169, 14698, 14212, 13716, 13213, 12701, 12179, 11655, 11127, 10597, 10063, 9527, 8988, 8449, 7908, 7367, 6828, 6288, 5752, 5218, 4686, 4158, 3632, 3140, 2689, 2264, 1852, 1446, 1045, 643, 238, -168, -581, -1000, -1424, -1856, -2290, -2730, -3178, -3627, -4084, -4545, -5008, -5477, -5947, -6419, -6898, -7374, -7851, -8332, -8812, -9291, -9768, -10245, -10719, -11191, -11662, -12128, -12591, -13042, -13485, -13926, -14364, -14804, -15244, -15679, -16110, -16534, -16949, -17357, -17759, -18153, -18539, -18918, -19287, -19649, -20004, -20350, -20691, -21026, -21353, -21677, -21994, -22306, -22616, -22921, -23220, -23516, -23808, -24098, -24383, -24663, -24940, -25213, -25483, -25749, -26009, -26267, -26519, -26769, -27012, -27249, -27482, -27711, -27930, -28147, -28357, -28560, -28756, -28942, -29124, -29297, -29464, -29619, -29768, -29909, -30039, -30161, -30271, -30375, -30465, -30547, -30618, -30664, -30687, -30692, -30685, -30660, -30597, -30482, -30307, -30066, -29750, -29363, -28894, -28348, -27719, -27007, -26217, -25341, -24387, -23357, -22245, -21063, -19814, -18494, -17112, -15676, -14180, -12639, -11057, -9433, -7778, -6101, -4401, -2696, -956, 2303, 4367, 6371, 8352, 10294, 12189, 14031, 15803, 17503, 19120, 20640, 22064, 23383, 24586, 25671, 26631, 27458, 28154, 28709, 29123, 29397, 29524, 29571, 29607, 29619, 29614, 29604, 29600, 29598, 29593, 29581, 29556, 29521, 29484, 29447, 29412, 29374, 29327, 29270, 29204, 29132, 29057, 28979, 28896, 28808, 28712, 28607, 28498, 28384, 28265, 28141, 28014, 27878, 27736, 27590, 27438, 27281, 27121, 26954, 26781, 26604, 26420, 26231, 26036, 25837, 25632, 25421, 25201, 24976, 24746, 24509, 24265, 24013, 23755, 23491, 23215, 22934, 22648, 22353, 22052, 21745, 21430, 21109, 20781, 20447, 20107, 19761, 19409, 19050, 18687, 18318, 17943, 17563, 17176, 16786, 16391, 15991, 15587, 15176, 14763, 14346, 13923, 13496, 13066, 12632, 12192, 11751, 11308, 10865, 10418, 9965, 9511, 9052, 8588, 8119, 7649, 7174, 6695, 6215, 5731, 5245, 4754, 4258, 3752, 3244, 2730, 2214, 1697, 1175, 652, 130, -394, -921, -1448, -1975, -2503, -3030, -3559, -4086, -4614, -5142, -5668, -6195, -6719, -7242, -7766, -8287, -8805, -9323, -9839, -10352, -10862, -11372, -11877, -12380, -12879, -13375, -13867, -14347, -14816, -15286, -15754, -16224, -16697, -17164, -17631, -18091, -18545, -18994, -19437, -19874, -20307, -20735, -21158, -21576, -21989, -22395, -22797, -23191, -23580, -23963, -24338, -24708, -25070, -25427, -25774, -26115, -26448, -26774, -27094, -27404, -27706, -28001, -28288, -28566, -28837, -29098, -29350, -29596, -29832, -30059, -30277, -30486, -30685, -30878, -31059, -31232, -31397, -31552, -31697, -31833, -31960, -32076, -32185, -32285, -32373, -32454, -32525, -32586, -32638, -32680, -32714, -32739, -32757, -32765, -32766, -32754, -32713, -32631, -32494, -32298, -32030, -31683, -31249, -30726, -30109, -29397, -28591, -27681, -26671, -25566, -24356, -23052, -21660, -20176, -18607, -16963, -15241, -13453, -11607, -9704, -7759, -5780, -3771, -1750, 317};