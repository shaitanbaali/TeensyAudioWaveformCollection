/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0060 512 samples */
 
const int16_t AKWF_stereo_0060_512_DATA [512] = 
{6221, 15528, 19933, 22860, 24902, 26360, 27447, 28273, 28906, 29396, 29769, 30056, 30272, 30427, 30534, 30599, 30626, 30619, 30581, 30514, 30417, 30293, 30142, 29961, 29754, 29517, 29250, 28955, 28629, 28272, 27884, 27465, 27012, 26527, 26010, 25459, 24877, 24260, 23609, 22928, 22214, 21465, 20689, 19879, 19041, 18175, 17280, 16358, 15414, 14443, 13452, 12443, 11413, 10370, 9317, 8253, 7188, 6127, 5073, 4045, 3067, 2149, 1568, 2904, 2648, 1669, 712, -299, -1323, -2350, -3374, -4387, -5387, -6373, -7338, -8287, -9216, -10122, -11007, -11871, -12710, -13530, -14325, -15098, -15850, -16578, -17283, -17968, -18631, -19271, -19892, -20492, -21070, -21629, -22169, -22689, -23191, -23673, -24138, -24587, -25017, -25432, -25830, -26211, -26579, -26932, -27269, -27592, -27902, -28199, -28483, -28753, -29012, -29259, -29495, -29719, -29932, -30136, -30328, -30511, -30685, -30848, -31004, -31150, -31288, -31417, -31538, -31653, -31758, -31857, -31948, -32033, -32110, -32180, -32244, -32302, -32353, -32399, -32438, -32471, -32499, -32521, -32536, -32547, -32552, -32552, -32546, -32535, -32519, -32498, -32471, -32439, -32403, -32361, -32314, -32261, -32204, -32142, -32074, -32001, -31924, -31842, -31753, -31660, -31561, -31458, -31348, -31233, -31114, -30988, -30858, -30721, -30579, -30432, -30279, -30119, -29955, -29784, -29607, -29425, -29235, -29041, -28841, -28633, -28420, -28201, -27975, -27743, -27504, -27259, -27008, -26749, -26485, -26213, -25935, -25650, -25359, -25061, -24754, -24442, -24124, -23798, -23466, -23128, -22781, -22428, -22068, -21701, -21328, -20947, -20559, -20166, -19765, -19358, -18945, -18524, -18097, -17664, -17224, -16778, -16326, -15868, -15404, -14935, -14458, -13978, -13492, -12999, -12504, -12003, -11497, -10987, -10472, -9954, -9433, -8908, -8379, -7851, -7318, -6785, -6252, -5717, -5183, -4652, -4122, -3598, -3080, -2570, -2073, -1594, -1141, -738, -352, -417, -1651, -1488, 21768, 23905, 24970, 25975, 26686, 27130, 27431, 27648, 27804, 27913, 27990, 28050, 28099, 28140, 28177, 28211, 28246, 28279, 28310, 28339, 28365, 28387, 28402, 28409, 28405, 28392, 28368, 28330, 28275, 28204, 28115, 28007, 27879, 27731, 27560, 27366, 27151, 26911, 26646, 26356, 26041, 25698, 25331, 24935, 24511, 24062, 23582, 23072, 22533, 21959, 21353, 20713, 20033, 19311, 18544, 17723, 16839, 15882, 14829, 13649, 12265, 10642, 7955, -660, -4378, -5807, -7228, -8414, -9470, -10437, -11337, -12178, -12975, -13734, -14457, -15151, -15819, -16460, -17082, -17682, -18262, -18824, -19370, -19899, -20411, -20908, -21389, -21859, -22314, -22753, -23182, -23597, -24000, -24391, -24769, -25135, -25491, -25834, -26167, -26490, -26800, -27101, -27393, -27673, -27945, -28206, -28457, -28700, -28935, -29159, -29375, -29583, -29782, -29973, -30157, -30332, -30500, -30661, -30814, -30961, -31100, -31233, -31358, -31478, -31592, -31699, -31800, -31896, -31986, -32069, -32149, -32222, -32291, -32353, -32411, -32467, -32515, -32559, -32599, -32635, -32666, -32692, -32714, -32733, -32748, -32759, -32765, -32767, -32767, -32762, -32753, -32742, -32726, -32707, -32684, -32657, -32628, -32595, -32558, -32518, -32475, -32427, -32377, -32323, -32265, -32204, -32140, -32073, -32001, -31927, -31849, -31767, -31682, -31594, -31501, -31406, -31306, -31204, -31097, -30986, -30873, -30755, -30633, -30508, -30379, -30246, -30110, -29969, -29825, -29675, -29524, -29368, -29206, -29042, -28873, -28699, -28523, -28342, -28155, -27966, -27772, -27574, -27371, -27162, -26950, -26735, -26514, -26288, -26059, -25823, -25583, -25340, -25089, -24835, -24576, -24311, -24041, -23766, -23485, -23200, -22909, -22611, -22308, -21999, -21684, -21363, -21035, -20699, -20358, -20007, -19650, -19286, -18913, -18528, -18138, -17735, -17323, -16900, -16462, -16011, -15546, -15063, -14561, -14041, -13496, -12921, -12313, -11664, -10964, -10200, -9341, -8315, -7231, -4536, 424, 7616};