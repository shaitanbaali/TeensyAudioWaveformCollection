/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0004 512 samples */
 
const int16_t AKWF_stereo_0004_512_DATA [512] = 
{306, 1390, 2514, 3751, 5061, 6438, 7903, 10151, 12394, 14672, 16686, 18438, 20059, 21563, 22945, 24198, 25317, 26316, 27207, 27997, 28699, 29322, 29872, 30361, 30790, 31167, 31497, 31781, 32025, 32231, 32399, 32530, 32628, 32692, 32724, 32725, 32694, 32629, 32532, 32405, 32246, 32051, 31820, 31550, 31240, 30893, 30505, 30078, 29614, 29111, 28575, 28006, 27408, 26793, 26177, 25574, 25012, 24512, 24072, 23685, 23273, 22855, 22487, 22122, 21830, 21568, 21363, 21229, 21166, 21165, 21224, 21342, 21533, 21809, 22160, 22574, 23019, 23460, 23872, 24241, 24637, 24478, 24120, 23680, 23580, 23822, 24125, 24379, 24495, 24567, 24628, 24668, 24668, 24609, 24475, 24253, 23931, 23498, 22939, 22238, 21383, 20353, 19139, 17737, 16124, 14289, 12236, 9958, 7461, 4773, 1895, -1075, -3778, -6122, -8136, -9836, -11238, -12406, -12994, -12930, -12651, -12073, -11483, -10760, -9825, -8668, -7323, -5813, -4165, -2412, -576, 1260, 2925, 4423, 5753, 6965, 7851, 7399, 7162, 6653, 6149, 5422, 4133, 2275, -13, -2575, -5191, -7786, -10312, -12708, -14947, -16925, -19224, -21820, -23954, -25846, -27229, -28345, -29281, -30070, -30722, -31253, -31677, -32013, -32273, -32470, -32611, -32703, -32754, -32768, -32756, -32717, -32672, -32561, -32301, -32069, -31754, -31458, -31209, -31027, -30796, -30602, -30057, -29263, -28672, -27937, -27440, -26856, -26203, -25539, -24888, -24266, -23680, -23152, -22691, -22310, -22017, -21811, -21697, -21667, -21707, -21803, -22126, -22476, -22826, -23114, -23314, -23470, -23580, -23635, -23642, -23604, -23523, -23783, -23815, -23714, -23533, -23221, -23006, -22821, -22630, -22422, -22199, -21972, -21745, -21521, -21306, -21102, -20911, -20746, -20513, -20130, -19782, -19368, -18961, -18517, -18002, -17436, -16817, -16139, -15400, -14595, -13729, -12816, -11860, -10858, -9838, -8794, -7744, -6705, -5679, -4667, -3676, -2698, -1718, -704, 12703, 11458, 10253, 9152, 8161, 7304, 6654, 7242, 8100, 9323, 10448, 11425, 12453, 13554, 14699, 15845, 16958, 18034, 19071, 20065, 21019, 21929, 22790, 23608, 24377, 25094, 25758, 26366, 26911, 27390, 27799, 28134, 28396, 28587, 28703, 28746, 28714, 28606, 28417, 28151, 27800, 27360, 26825, 26189, 25447, 24601, 23647, 22592, 21444, 20206, 18891, 17508, 16066, 14590, 13109, 11649, 10261, 8989, 7825, 6769, 5647, 4523, 3553, 2605, 1853, 1182, 649, 290, 107, 84, 214, 496, 954, 1602, 2419, 3377, 4419, 5472, 6487, 7423, 8459, 7963, 6894, 5569, 5181, 5752, 6530, 7203, 7521, 7763, 8020, 8273, 8474, 8573, 8536, 8338, 7957, 7378, 6576, 5528, 4216, 2620, 722, -1407, -3626, -5860, -8057, -10185, -12208, -14092, -15829, -17398, -18784, -19994, -21019, -21861, -22511, -23012, -23053, -22548, -21833, -20818, -19743, -18492, -16979, -15177, -13104, -10777, -8215, -5462, -2559, 406, 3114, 5462, 7495, 9261, 10746, 11685, 12495, 13128, 13683, 14141, 14431, 14553, 14541, 14408, 14156, 13790, 13309, 12717, 11991, 11317, 9565, 6419, 2957, -1095, -4272, -6942, -9370, -11562, -13486, -15112, -16452, -17528, -18360, -18972, -19380, -19591, -19633, -19524, -19289, -18946, -18588, -17898, -16401, -15099, -13385, -11859, -10683, -9964, -9075, -8463, -6107, -2586, -276, 2490, 3864, 5392, 6965, 8368, 9565, 10556, 11362, 11980, 12423, 12698, 12804, 12755, 12550, 12189, 11721, 11134, 5686, -1192, -8275, -13539, -17128, -20376, -23323, -25806, -27772, -29272, -30394, -31530, -32225, -32613, -32779, -32698, -32557, -32310, -31936, -31429, -30795, -30041, -29171, -28191, -27106, -25920, -24639, -23298, -21705, -19672, -17570, -15169, -12656, -9932, -6926, -3734, -382, 2873, 5733, 8238, 10393, 12211, 13720, 14945, 15890, 16580, 17019, 17216, 17175, 16911, 16430, 15745, 14881, 13827};