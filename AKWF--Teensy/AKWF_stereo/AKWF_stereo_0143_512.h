/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0143 512 samples */
 
const int16_t AKWF_stereo_0143_512_DATA [512] = 
{1181, 3881, 6387, 8348, 10135, 12273, 14321, 15743, 16563, 17174, 17833, 18422, 18835, 19163, 19558, 19963, 20431, 21120, 21945, 22904, 23986, 24999, 25904, 26585, 26875, 26834, 26588, 26279, 25978, 25726, 25655, 25901, 26218, 26351, 26309, 26245, 26345, 26475, 26350, 26019, 25585, 25110, 24616, 24087, 23658, 23375, 23111, 22880, 22935, 23357, 23896, 24230, 24089, 23683, 23156, 22633, 22095, 21450, 20647, 19761, 19064, 18542, 17949, 16937, 15319, 13366, 10828, 7910, 5737, 4859, 5074, 5622, 5519, 4597, 2698, 266, -1554, -2337, -2280, -1799, -1432, -1270, -676, 878, 3453, 6489, 9236, 11423, 12666, 13005, 13524, 14451, 15292, 15844, 16266, 16625, 16701, 16297, 15583, 15014, 14956, 15294, 15594, 15486, 14919, 14175, 13524, 13106, 12808, 12389, 11766, 11209, 11029, 11167, 11177, 10835, 10263, 9498, 8730, 8259, 8097, 7788, 6986, 6042, 5386, 5129, 5066, 4893, 4597, 4148, 3182, 1615, -255, -2037, -3606, -4910, -6137, -7218, -8151, -8911, -9877, -11372, -13164, -14899, -16455, -17698, -18614, -19353, -20093, -20835, -21481, -21941, -22158, -22265, -22305, -22303, -22403, -22758, -23294, -23812, -24339, -24867, -25204, -25363, -25352, -25081, -24632, -24187, -23942, -23870, -23847, -23657, -23394, -23193, -22881, -22381, -21586, -20507, -19234, -17880, -16745, -15966, -15190, -14135, -12728, -11032, -9164, -7423, -6182, -5868, -6446, -7521, -8254, -8088, -7090, -5482, -3954, -3371, -3776, -5016, -6677, -8064, -9030, -9696, -9935, -10064, -10588, -11722, -13262, -14704, -15741, -16429, -16815, -16763, -16392, -15814, -15053, -14389, -14285, -14894, -16052, -17230, -18148, -18831, -19356, -20108, -21029, -21783, -22140, -22001, -21654, -21343, -21148, -21221, -21345, -21304, -21296, -21441, -21692, -21809, -21528, -20728, -19594, -18634, -18116, -17823, -17480, -17068, -16549, -15673, -14363, -12686, -10631, -7984, -4792, -1575, -17681, -16205, -14551, -12767, -10739, -8391, -3355, 3733, 7747, 10350, 12455, 14167, 15526, 16695, 17828, 19017, 20256, 21520, 22830, 24206, 25588, 26853, 27930, 28768, 29372, 29824, 30209, 30550, 30858, 31126, 31331, 31494, 31597, 31663, 31776, 31998, 32331, 32656, 32771, 32557, 32019, 31312, 30604, 30003, 29590, 29304, 29023, 28726, 28558, 28570, 28560, 28278, 27536, 26378, 25009, 23646, 22478, 21569, 20826, 20070, 19174, 18104, 16783, 15038, 12854, 10463, 7982, 5587, 3710, 2815, 3088, 3874, 3723, 1817, -1589, -7802, -14672, -16813, -16791, -15814, -14517, -12905, -8140, -2715, 1867, 6142, 9844, 12755, 14723, 15858, 16840, 18190, 19794, 21370, 22722, 23731, 24297, 24428, 24275, 24095, 24065, 24221, 24420, 24455, 24295, 23968, 23572, 23299, 23265, 23405, 23586, 23735, 23835, 23796, 23515, 23028, 22462, 21907, 21454, 21097, 20765, 20364, 19747, 18955, 18108, 17137, 13927, 9745, 7085, 4746, 2336, -203, -2683, -4917, -6857, -8648, -10576, -12629, -14658, -16538, -18288, -19933, -21444, -22791, -23975, -25003, -25887, -26693, -27507, -28326, -29043, -29547, -29780, -29849, -29917, -30086, -30381, -30775, -31179, -31503, -31772, -32008, -32177, -32239, -32124, -31819, -31406, -30945, -30513, -30158, -29839, -29406, -28827, -28199, -27541, -26861, -26132, -25348, -24474, -23437, -22179, -20689, -18949, -16828, -14207, -11027, -7251, -2071, 5820, 10400, 11515, 10670, 9708, 11154, 13826, 16449, 18589, 20019, 20727, 20767, 20287, 19519, 18625, 17694, 16771, 15735, 14359, 12621, 8636, -113, -6242, -9513, -11862, -13600, -14829, -15559, -15849, -16003, -16566, -17726, -19194, -20606, -21774, -22694, -23464, -24256, -25109, -25979, -26772, -27355, -27733, -28006, -28290, -28699, -29147, -29507, -29757, -29842, -29713, -29351, -28768, -28080, -27456, -27033, -26816, -26729, -26648, -26454, -26079, -25457, -24656, -23795, -22856, -21734, -20405, -18992};