/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0073 512 samples */
 
const int16_t AKWF_stereo_0073_512_DATA [512] = 
{23653, 27213, 18821, 14546, 11382, 9654, 9020, 8944, 8914, 8652, 8193, 7757, 7571, 7715, 8103, 8570, 8987, 9332, 9673, 10087, 10613, 11214, 11815, 12356, 12821, 13237, 13646, 14067, 14487, 14870, 15187, 15431, 15588, 15698, 15774, 15816, 15814, 15753, 15632, 15454, 15237, 15018, 14589, 15150, 15984, 14805, 14000, 13321, 12747, 12248, 11805, 11403, 11031, 10687, 10369, 10082, 9821, 9589, 9384, 9204, 9049, 8919, 8812, 8730, 8670, 8631, 8608, 8599, 8603, 8617, 8639, 8666, 8695, 8724, 8749, 8769, 8780, 8784, 8776, 8754, 8720, 8669, 8601, 8519, 8418, 8302, 8167, 8096, 7930, 7713, 7502, 7284, 7060, 6829, 6590, 6348, 6100, 5934, 5239, 6797, 18458, 14623, 9926, 7211, 5263, 3922, 2995, 2345, 1879, 1543, 1293, 1101, 950, 827, 720, 629, 546, 468, 394, 322, 252, 181, 108, 32, -46, -126, -213, -305, -399, -502, -607, -719, -841, -947, -1212, -735, 522, -1044, -2247, -2862, -3009, -2867, -2719, -2145, -1857, -2305, -2686, -3069, -3420, -3718, -3962, -4166, -4341, -4506, -4670, -4838, -5012, -5187, -5362, -5534, -5700, -5862, -6018, -6170, -6319, -6464, -6609, -6750, -6890, -7029, -7164, -7300, -7432, -7564, -7694, -7822, -7952, -8078, -8207, -8334, -8462, -8591, -8718, -8847, -8975, -9105, -9231, -9329, -9466, -9607, -9742, -9875, -10006, -10136, -10263, -10391, -10517, -10586, -11017, -9695, -5878, -7934, -9439, -10425, -11123, -11612, -11960, -12211, -12400, -12543, -12658, -12753, -12833, -12906, -12971, -13031, -13089, -13142, -13195, -13245, -13294, -13342, -13389, -13435, -13479, -13523, -13566, -13608, -13649, -13688, -13726, -13764, -13802, -13838, -13873, -13907, -13941, -13973, -14004, -14033, -14060, -14084, -14127, -13958, -13933, -14063, -14132, -14186, -14226, -14254, -14275, -14291, -14301, -14308, -14313, -14314, 17922, 24146, 20115, 24765, 30109, 32757, 31610, 28429, 25994, 25988, 28071, 30488, 31527, 30667, 28731, 27104, 26734, 27586, 28847, 29596, 29420, 28579, 27711, 27341, 27562, 28064, 28406, 28337, 27922, 27431, 27132, 27108, 27244, 27336, 27241, 26962, 26619, 26341, 26189, 26123, 26052, 25895, 25673, 25259, 24819, 24723, 24614, 24491, 24320, 24094, 23834, 23572, 23331, 23112, 22898, 22672, 22424, 22159, 21896, 21641, 21398, 21161, 20917, 20664, 20402, 20141, 19880, 19624, 19371, 19114, 18852, 18584, 18311, 18038, 17766, 17493, 17215, 16934, 16649, 16357, 16066, 15769, 15470, 15172, 14865, 14556, 14243, 13915, 13598, 13280, 12960, 12633, 12305, 11973, 11637, 11302, 10962, 10610, 10333, 9727, 7662, 7834, 8128, 8139, 8037, 7849, 7600, 7313, 6999, 6669, 6327, 5975, 5621, 5264, 4902, 4544, 4181, 3819, 3459, 3096, 2737, 2376, 2015, 1655, 1296, 937, 576, 218, -139, -498, -856, -1217, -1574, -1882, -2539, -1494, 1343, -2235, -4975, -6359, -6673, -6340, -5806, -5490, -5458, -5649, -6088, -6632, -7183, -7672, -8079, -8419, -8716, -9001, -9295, -9606, -9936, -10277, -10625, -10968, -11307, -11639, -11962, -12284, -12601, -12916, -13232, -13544, -13857, -14169, -14476, -14783, -15084, -15385, -15682, -15977, -16271, -16560, -16849, -17133, -17415, -17697, -17973, -18249, -18520, -18789, -19058, -19324, -19584, -19841, -20094, -20347, -20594, -20841, -21082, -21324, -21559, -21798, -21985, -22418, -23211, -23151, -23164, -23252, -23375, -23525, -23692, -23868, -24051, -24234, -24419, -24600, -24780, -24959, -25132, -25303, -25470, -25632, -25792, -25946, -26095, -26242, -26385, -26522, -26655, -26785, -26911, -27031, -27147, -27260, -27369, -27472, -27572, -27667, -27757, -27845, -27927, -28005, -28079, -28149, -28214, -28275, -28329, -28410, -28463, -28491, -28523, -28553, -28579, -28603, -28624, -28640, -28651, -28659, -28664, -28662};