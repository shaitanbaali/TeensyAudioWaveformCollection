/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0094 512 samples */
 
const int16_t AKWF_stereo_0094_512_DATA [512] = 
{322, 1366, 2206, 2896, 3449, 3877, 4213, 4447, 4610, 4724, 4807, 4885, 4978, 5099, 5250, 5453, 5715, 6041, 6436, 6902, 7441, 8041, 8697, 9402, 10144, 10909, 11693, 12476, 13245, 13992, 14703, 15364, 15970, 16541, 17152, 17663, 18055, 18380, 18634, 18821, 18944, 19000, 19001, 18949, 18853, 18723, 18569, 18400, 18227, 18055, 17893, 17746, 17623, 17513, 17426, 17365, 17327, 17307, 17298, 17304, 17319, 17331, 17346, 17353, 17344, 17323, 17284, 17220, 17134, 17023, 16889, 16732, 16556, 16348, 16132, 15896, 15657, 15406, 15157, 14905, 14656, 14418, 14183, 13963, 13757, 13563, 13385, 13222, 13064, 12950, 13601, 14404, 14767, 15070, 15389, 15691, 15935, 16085, 16132, 16057, 15841, 15493, 15019, 14439, 13763, 13013, 12218, 11371, 10507, 9637, 8773, 7931, 7118, 6353, 5630, 4972, 4381, 3853, 3390, 3001, 2678, 2420, 2226, 2087, 1995, 1956, 1988, 2037, 2079, 2136, 2208, 2294, 2384, 2493, 2639, 2762, 2868, 2967, 3060, 3152, 3235, 3312, 3384, 3447, 3506, 3556, 3604, 3639, 3671, 3697, 3706, 3709, 3696, 3663, 3608, 3533, 3428, 3295, 3123, 2917, 2673, 2380, 2053, 1679, 1259, 800, 296, -249, -834, -1451, -2105, -2786, -3494, -4227, -4973, -5744, -6508, -7292, -8077, -8861, -9644, -10424, -11198, -11967, -12726, -13479, -14221, -14956, -15687, -16373, -16755, -17147, -17683, -18218, -18745, -19273, -19815, -20380, -20971, -21596, -22257, -22944, -23654, -24380, -25112, -25840, -26552, -27247, -27902, -28526, -29101, -29627, -30091, -30492, -30829, -31093, -31280, -31392, -31436, -31397, -31291, -31113, -30866, -30557, -30190, -29767, -29293, -28776, -28218, -27628, -27008, -26364, -25701, -25018, -24314, -23610, -22909, -22207, -21512, -20819, -20144, -19474, -18822, -18188, -17566, -17003, -15445, -13235, -11598, -10092, -8527, -6920, -5312, -3738, -2246, -851, -2880, -1120, 616, 2325, 3973, 5550, 7054, 8483, 9838, 11104, 12264, 13313, 14252, 15081, 15823, 16478, 17055, 17556, 17983, 18344, 18647, 18909, 19134, 19330, 19500, 19646, 19774, 19885, 19982, 20068, 20141, 20202, 20247, 20263, 20222, 20168, 20106, 20017, 19898, 19751, 19576, 19373, 19146, 18897, 18627, 18341, 18041, 17729, 17410, 17089, 16766, 16450, 16141, 15845, 15564, 15300, 15057, 14834, 14634, 14456, 14299, 14162, 14046, 13942, 13853, 13775, 13703, 13635, 13567, 13495, 13418, 13332, 13233, 13122, 12998, 12855, 12699, 12527, 12338, 12138, 11928, 11710, 11485, 11258, 11031, 10806, 10591, 10384, 10193, 10008, 9580, 9126, 8842, 8601, 8375, 8178, 8018, 7905, 7843, 7832, 7875, 7969, 8106, 8275, 8469, 8679, 8894, 9107, 9311, 9495, 9654, 9785, 9880, 9937, 9952, 9926, 9855, 9743, 9589, 9396, 9167, 8908, 8621, 8312, 7984, 7661, 7436, 7166, 6808, 6439, 6092, 5773, 5487, 5225, 4978, 4765, 4578, 4416, 4283, 4179, 4105, 4061, 4042, 4045, 4069, 4104, 4150, 4202, 4257, 4309, 4355, 4391, 4415, 4421, 4407, 4370, 4306, 4212, 4087, 3927, 3731, 3496, 3222, 2906, 2548, 2145, 1698, 1206, 669, 87, -540, -1216, -1934, -2692, -3496, -4340, -5221, -6141, -7095, -8076, -9090, -10126, -11180, -12255, -13342, -14434, -15534, -16631, -17718, -18814, -19992, -21144, -22224, -23271, -24288, -25268, -26199, -27077, -27898, -28655, -29345, -29971, -30527, -31017, -31442, -31804, -32107, -32346, -32532, -32661, -32740, -32767, -32747, -32684, -32577, -32433, -32250, -32031, -31777, -31494, -31179, -30835, -30465, -30068, -29645, -29198, -28729, -28237, -27725, -27193, -26641, -26072, -25485, -24885, -24277, -23652, -23014, -22368, -21714, -21053, -20389, -19719, -19047, -18378, -17707, -17046, -16235, -15278, -14327, -13268, -12043, -10681, -9232, -7726, -6173, -4521};