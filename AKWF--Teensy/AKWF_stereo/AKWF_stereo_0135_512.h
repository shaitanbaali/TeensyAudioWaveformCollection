/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0135 512 samples */
 
const int16_t AKWF_stereo_0135_512_DATA [512] = 
{1312, 3297, 5195, 7041, 8820, 10525, 12152, 13689, 15136, 16490, 17744, 18902, 19960, 20922, 21795, 22573, 23259, 23860, 24381, 24826, 25199, 25500, 25737, 25912, 26031, 26100, 26123, 26108, 26055, 25968, 25848, 25696, 25511, 25298, 25059, 24784, 24466, 24089, 23649, 23142, 22565, 21910, 21182, 20376, 19492, 18535, 17501, 16395, 15221, 13978, 12671, 11309, 9896, 8441, 6948, 5414, 3846, 2245, 612, -1042, -2715, -4405, -6097, -7789, -9479, -11151, -12797, -14410, -15975, -17487, -18937, -20307, -21594, -22789, -23880, -24863, -25732, -26480, -27105, -27601, -27957, -28171, -28248, -28193, -28013, -27713, -27304, -26800, -26219, -25579, -24889, -24162, -23396, -22600, -21788, -20973, -20162, -19362, -18572, -17792, -17028, -16284, -15561, -14863, -14189, -13528, -12882, -12246, -11622, -11012, -10406, -9804, -9202, -8591, -7972, -7342, -6698, -6041, -5371, -4683, -3968, -3228, -2462, -1675, -865, -33, 819, 1693, 2592, 3511, 4449, 5401, 6364, 7337, 8321, 9305, 10297, 11292, 12269, 13220, 14125, 14971, 15758, 16477, 17122, 17697, 18201, 18634, 19000, 19300, 19537, 19710, 19823, 19880, 19884, 19851, 19779, 19671, 19528, 19350, 19141, 18908, 18651, 18369, 18069, 17744, 17399, 17036, 16654, 16255, 15842, 15419, 14987, 14553, 14113, 13674, 13239, 12813, 12399, 12006, 11630, 11280, 10954, 10653, 10376, 10120, 9885, 9673, 9479, 9293, 9100, 8888, 8643, 8355, 8013, 7611, 7143, 6604, 5990, 5302, 4541, 3706, 2801, 1821, 770, -344, -1526, -2766, -4052, -5390, -6770, -8187, -9640, -11114, -12599, -14097, -15592, -17082, -18563, -20022, -21450, -22843, -24185, -25468, -26684, -27818, -28861, -29802, -30626, -31329, -31901, -32330, -32613, -32738, -32690, -32466, -32057, -31468, -30702, -29755, -28619, -27318, -25869, -24298, -22611, -20831, -18969, -17030, -15037, -13006, -10942, -8868, -6793, -4724, -2680, -624, -2237, -273, 1619, 3473, 5273, 7014, 8688, 10284, 11804, 13242, 14590, 15855, 17030, 18115, 19115, 20025, 20846, 21587, 22251, 22841, 23362, 23814, 24200, 24527, 24793, 25009, 25180, 25309, 25399, 25454, 25473, 25455, 25403, 25319, 25202, 25048, 24847, 24590, 24268, 23876, 23409, 22864, 22239, 21532, 20742, 19875, 18929, 17906, 16812, 15645, 14414, 13122, 11773, 10371, 8926, 7431, 5894, 4319, 2705, 1062, -601, -2284, -3977, -5673, -7372, -9057, -10724, -12367, -13966, -15520, -17018, -18443, -19789, -21049, -22205, -23254, -24190, -25006, -25701, -26268, -26701, -26999, -27163, -27195, -27101, -26886, -26553, -26120, -25600, -25014, -24373, -23689, -22968, -22219, -21453, -20682, -19914, -19158, -18409, -17667, -16942, -16238, -15562, -14914, -14292, -13692, -13111, -12546, -11996, -11459, -10931, -10407, -9880, -9340, -8787, -8217, -7626, -7012, -6376, -5715, -5024, -4305, -3554, -2778, -1976, -1142, -283, 603, 1530, 2488, 3474, 4486, 5513, 6560, 7621, 8687, 9764, 10842, 11904, 12939, 13931, 14868, 15745, 16554, 17289, 17957, 18555, 19081, 19536, 19917, 20224, 20462, 20627, 20722, 20755, 20731, 20653, 20528, 20357, 20145, 19894, 19616, 19313, 18985, 18635, 18264, 17876, 17473, 17056, 16624, 16181, 15726, 15265, 14800, 14333, 13868, 13410, 12962, 12531, 12121, 11735, 11379, 11054, 10759, 10493, 10258, 10050, 9869, 9710, 9561, 9408, 9235, 9031, 8785, 8491, 8141, 7733, 7259, 6714, 6097, 5403, 4634, 3793, 2873, 1878, 813, -322, -1523, -2779, -4091, -5455, -6861, -8309, -9781, -11268, -12767, -14271, -15772, -17272, -18755, -20212, -21639, -23022, -24355, -25632, -26836, -27958, -28989, -29912, -30722, -31413, -31970, -32389, -32661, -32770, -32711, -32478, -32073, -31499, -30752, -29820, -28724, -27480, -26115, -24635, -23056, -21389, -19636, -17815, -15942, -14021, -12069, -10099, -8118, -6143, -4140};