/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0047 512 samples */
 
const int16_t AKWF_stereo_0047_512_DATA [512] = 
{17546, 27760, 22267, 24908, 25515, 22229, 23317, 23115, 21303, 21145, 21727, 21193, 20421, 21697, 21659, 21384, 22089, 22408, 22474, 22373, 22894, 22678, 22516, 22672, 22412, 22377, 22147, 22218, 22034, 21973, 22086, 21937, 22099, 22039, 22168, 22174, 22195, 22320, 22217, 22350, 22260, 22302, 22277, 22221, 22278, 22155, 22238, 22153, 22181, 22185, 22144, 22221, 22145, 22232, 22185, 22214, 22235, 22194, 22260, 22189, 22249, 22205, 22214, 22230, 22181, 22236, 22175, 22222, 22195, 22197, 22220, 22181, 22233, 22186, 22223, 22207, 22205, 22228, 22191, 22232, 22193, 22220, 22208, 22200, 22223, 22191, 22224, 22195, 22214, 22209, 22201, 22221, 22195, 22222, 22200, 22213, 22212, 22202, 22220, 22199, 22218, 22203, 22210, 22211, 22204, 22215, 22201, 22214, 22206, 22209, 22210, 22206, 22212, 22206, 22212, 22208, 22210, 22209, 22209, 22210, 22210, 22210, 22208, 22210, 22207, 22211, 22206, 22212, 22208, 22208, 22212, 22203, 22215, 22202, 22214, 22207, 22208, 22214, 22201, 22220, 22200, 22216, 22207, 22206, 22217, 22197, 22223, 22196, 22217, 22207, 22203, 22221, 22193, 22226, 22195, 22217, 22210, 22200, 22226, 22187, 22229, 22193, 22216, 22212, 22195, 22232, 22183, 22233, 22192, 22215, 22217, 22190, 22237, 22177, 22236, 22191, 22211, 22222, 22183, 22244, 22173, 22238, 22193, 22207, 22230, 22172, 22253, 22164, 22254, 21964, 21919, 21985, 21895, 21985, 21907, 21980, 21940, 21945, 22002, 21904, 22024, 21915, 21992, 21958, 21936, 22013, 21885, 22029, 21898, 21983, 21960, 21909, 22028, 21865, 22043, 21892, 21983, 21981, 21888, 22064, 21838, 22067, 21886, 21972, 22011, 21838, 22120, 21781, 22104, 21877, 21935, 22096, 21707, 22277, 21638, 22156, 22073, 20716, 26091, 6437, -30693, -22298, -24482, -26143, -24242, -22849, -24019, -22598, -20942, -21774, -21470, -20605, -20547, -22110, -20494, -23731, 23669, 23483, 20372, 20536, 21975, 21162, 22179, 21791, 21900, 22160, 21701, 22241, 21745, 22096, 21941, 21891, 22114, 21783, 22142, 21834, 22034, 21974, 21893, 22089, 21830, 22094, 21881, 22004, 21992, 21899, 22071, 21862, 22064, 21912, 21986, 22001, 21905, 22058, 21885, 22043, 21934, 21975, 22006, 21913, 22047, 21903, 22027, 21950, 21967, 22010, 21919, 22037, 21919, 22015, 21961, 21963, 22010, 21926, 22029, 21931, 22004, 21971, 21961, 22011, 21933, 22020, 21943, 21997, 21978, 21959, 22009, 21941, 22013, 21952, 21990, 21983, 21961, 22007, 21947, 22006, 21960, 21985, 21985, 21961, 22003, 21954, 22001, 21967, 21982, 21988, 21965, 21999, 21961, 21996, 21972, 21981, 21988, 21968, 21996, 21966, 21991, 21976, 21980, 21986, 21972, 21992, 21972, 21987, 21979, 21980, 21986, 21975, 21986, 21977, 21984, 21980, 21981, 21982, 21982, 21982, 21982, 21983, 21980, 21985, 21979, 21986, 21979, 21984, 21982, 21980, 21988, 21974, 21992, 21975, 21988, 21983, 21978, 21993, 21970, 21997, 21971, 21988, 21984, 21974, 21998, 21965, 22001, 21970, 21989, 21986, 21969, 22004, 21960, 22005, 21968, 21987, 21991, 21963, 22010, 21953, 22009, 21967, 21985, 21997, 21957, 22018, 21948, 22012, 21968, 21981, 22005, 21948, 22026, 21942, 22014, 21970, 21974, 22014, 21939, 22035, 21937, 22015, 21975, 21966, 22026, 21926, 22046, 21932, 22023, 21719, 21702, 21797, 21675, 21803, 21684, 21762, 21742, 21694, 21804, 21652, 21813, 21677, 21757, 21755, 21674, 21825, 21633, 21826, 21676, 21749, 21774, 21648, 21855, 21609, 21842, 21674, 21732, 21805, 21608, 21896, 21572, 21862, 21678, 21702, 21859, 21535, 21973, 21510, 21890, 21698, 21622, 22002, 21346, 22172, 21366, 21871, 22078, 19942, 27329, 719, -30716, -18363, -21555, -20813, -21589, -21746, -21775, -21944, -21852, -22001, -21738, -22233, -21434, -22467, -21213, -24287};