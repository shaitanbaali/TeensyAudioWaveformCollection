/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0038 512 samples */
 
const int16_t AKWF_stereo_0038_512_DATA [512] = 
{1395, 3769, 5612, 7010, 8086, 8959, 9794, 10612, 11375, 12068, 12779, 13509, 14198, 14839, 15459, 16176, 16969, 17908, 18940, 19880, 20827, 21760, 22583, 23337, 24137, 25094, 26258, 27470, 28554, 29541, 30507, 31242, 31692, 31995, 32251, 32529, 32716, 32764, 32722, 32580, 32430, 32224, 31844, 31408, 31086, 30753, 30321, 29741, 29012, 28273, 27588, 26816, 26086, 25515, 25039, 24639, 24210, 23750, 23325, 22901, 22592, 22376, 22122, 21936, 22009, 22145, 22102, 21957, 21808, 21801, 21917, 22019, 22182, 22406, 22566, 22618, 22529, 22452, 22416, 22232, 21905, 21516, 21009, 20435, 19861, 19123, 18234, 17417, 16732, 16191, 15679, 15091, 14338, 13454, 12469, 11501, 10603, 9757, 8920, 7990, 7007, 6177, 5464, 4775, 4088, 3394, 2681, 2110, 1638, 1144, 579, 11, -564, -1096, -1568, -1967, -2240, -2526, -2932, -3393, -3795, -4073, -4343, -4792, -5350, -5882, -6454, -7123, -7936, -8794, -9600, -10304, -10990, -11683, -12250, -12787, -13258, -13764, -14305, -14728, -15078, -15402, -15681, -16025, -16282, -16314, -16210, -15932, -15456, -14790, -13920, -13046, -12379, -11980, -11779, -11744, -11763, -11864, -12012, -12115, -12290, -12582, -12941, -13391, -13859, -14344, -14919, -15514, -16151, -16875, -17741, -18845, -20059, -21195, -22123, -22842, -23360, -23687, -23919, -24176, -24441, -24555, -24495, -24264, -23851, -23370, -22773, -21995, -21242, -20578, -19955, -19279, -18537, -17732, -16840, -15912, -14954, -14011, -13178, -12477, -11853, -11194, -10607, -10131, -9780, -9649, -9634, -9677, -9835, -10038, -10209, -10381, -10557, -10680, -10719, -11091, -11774, -12515, -13362, -14266, -15182, -16025, -17024, -18145, -19266, -20461, -21595, -22567, -23503, -24414, -25194, -25880, -26550, -27223, -27901, -28725, -29469, -29490, -29025, -28279, -27404, -26432, -25317, -23910, -22248, -20452, -18471, -16355, -14207, -12067, -9983, -7938, -6091, -4326, -2526, -615, 19937, 20523, 21324, 22011, 22668, 23388, 24160, 24799, 25197, 25297, 25150, 24806, 24134, 23491, 22797, 21696, 20279, 18061, 15457, 13216, 11161, 9076, 7051, 4735, 2123, -641, -3611, -6717, -9645, -12486, -15192, -17395, -19305, -20785, -21876, -22960, -23994, -24774, -24921, -24238, -23410, -22926, -22666, -22396, -22200, -21867, -21198, -19855, -17846, -15473, -13137, -10688, -8276, -6027, -3745, -1732, 285, 2618, 5115, 7494, 9245, 10545, 12087, 14030, 16092, 18538, 21319, 24234, 27045, 29141, 30266, 30917, 31398, 31662, 31738, 31636, 31573, 31542, 31211, 30441, 29167, 27826, 26728, 25729, 24635, 23553, 22409, 20900, 19036, 16751, 14317, 12469, 11279, 10245, 9180, 8327, 7473, 6323, 5079, 3765, 2470, 1709, 1363, 951, 406, -107, -642, -1436, -2484, -3557, -4674, -5522, -6251, -7273, -8536, -9738, -10962, -12288, -13288, -14124, -15034, -15969, -17256, -18985, -20861, -22620, -24215, -25822, -27463, -28984, -30354, -31417, -32286, -32704, -32772, -32625, -32343, -32146, -31963, -31912, -32133, -32278, -32330, -32087, -31171, -29749, -28233, -26779, -25123, -23190, -21087, -18782, -16473, -14089, -11771, -9981, -8343, -6747, -5121, -3390, -1477, 812, 3332, 5912, 8489, 10719, 12494, 13905, 15249, 16392, 17149, 17708, 18018, 18243, 18405, 18075, 17632, 16988, 16092, 15078, 13898, 12427, 10632, 8560, 6655, 4751, 2620, 540, -1390, -3266, -4900, -6059, -7057, -8094, -8964, -9976, -11130, -11851, -12147, -12139, -11900, -11584, -11130, -10464, -9705, -9192, -9039, -8809, -8390, -7799, -7200, -6671, -6316, -5989, -5489, -4960, -4775, -4475, -4115, -4077, -4307, -4726, -4989, -5049, -5071, -5055, -4765, -3954, -3153, -2503, -2058, -1609, -938, -150, 687, 1468, 1849, 2343, 3254, 4121, 4888, 5856, 7004, 8337, 9650, 10788, 11859, 12698, 13204, 13782, 14672, 15830, 17194, 18175, 18833, 19451};