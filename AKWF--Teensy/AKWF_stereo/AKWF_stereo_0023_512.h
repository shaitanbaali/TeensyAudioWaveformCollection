/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0023 512 samples */
 
const int16_t AKWF_stereo_0023_512_DATA [512] = 
{1151, 3399, 3834, 3542, 3607, 4644, 4435, 3413, 3282, 4592, 5886, 5202, 4367, 5046, 7721, 9657, 9632, 9076, 9103, 9829, 10519, 11596, 12883, 13359, 15781, 18999, 22011, 24960, 26112, 26567, 27986, 29474, 30009, 29787, 29338, 29102, 28489, 27611, 26759, 26024, 26019, 25338, 24758, 25192, 26601, 27268, 27214, 28680, 30286, 31570, 31226, 30375, 30127, 29842, 30041, 30935, 30978, 29648, 28499, 26488, 23577, 23651, 24820, 24621, 23752, 23439, 22884, 21931, 21423, 21893, 22812, 23967, 25619, 26619, 27448, 28230, 28492, 29174, 29772, 29122, 28380, 28167, 28735, 28400, 26133, 22265, 20369, 20163, 19838, 19732, 19809, 20088, 19717, 18536, 17835, 17955, 17480, 15818, 14776, 14180, 14366, 14366, 13122, 12673, 12804, 12130, 12051, 11605, 11197, 10821, 10061, 9479, 9631, 10147, 9577, 8990, 9720, 10938, 11287, 10018, 7284, 5244, 4329, 4535, 6663, 9054, 10131, 9932, 10519, 10187, 7780, 4379, 690, -929, -953, -994, -1834, -3923, -6781, -9007, -10426, -13677, -16935, -18904, -19969, -21662, -22717, -22288, -21342, -19035, -17512, -16215, -16025, -16769, -17474, -18010, -18527, -19265, -20449, -21219, -21997, -22001, -21390, -21270, -21706, -22025, -21295, -21208, -21979, -22442, -23095, -24518, -26556, -27688, -27847, -28778, -29420, -30796, -32266, -32546, -31475, -30987, -31858, -32733, -31867, -30668, -30561, -29957, -29649, -30107, -30306, -30419, -30935, -31255, -30908, -29342, -27632, -27200, -26521, -25549, -24429, -22903, -21730, -21637, -20635, -19887, -20059, -19868, -18928, -17928, -19080, -20538, -21172, -21429, -20898, -20264, -20356, -20863, -21149, -21910, -22058, -21392, -21625, -21226, -19977, -19754, -19354, -18502, -17956, -17204, -14278, -11724, -9986, -8035, -7651, -8325, -8029, -8061, -9201, -10803, -12902, -14666, -15238, -15468, -15387, -15410, -15180, -13176, -10021, -7716, -7471, -7874, -7029, -5741, -4678, -2164, 3284, 1294, -471, 1105, 1369, 3181, 4803, 6674, 8061, 7909, 7983, 8620, 10784, 16138, 18682, 18228, 16563, 15303, 15511, 17006, 20083, 22201, 20773, 16851, 13394, 11136, 9056, 3634, -1048, -4815, -7699, -8081, -7802, -9226, -12849, -16816, -15089, -7253, -3823, -3400, -1208, -1083, -3617, -7805, -11791, -12971, -10929, -8813, -4522, -3852, -5069, -3451, -4522, -6743, -5737, -2165, 3099, 6202, 7092, 5755, 3502, -273, -2030, 14, 5896, 15445, 23578, 27344, 27111, 27865, 28900, 28293, 27034, 25625, 25006, 27082, 31046, 30374, 27976, 25971, 24949, 24084, 23734, 25698, 28642, 31405, 32631, 30703, 27480, 26649, 26685, 24829, 26543, 29180, 28943, 27644, 25649, 21481, 17280, 15302, 15657, 16860, 18385, 21313, 22147, 20783, 19819, 17413, 18520, 22331, 24766, 24358, 22142, 19914, 16510, 15127, 14103, 11694, 11276, 10693, 9021, 6206, 5386, 6704, 8307, 5988, 2733, -1555, -4345, -3500, -733, 1818, 2710, 3041, 1880, 1912, 2934, 1329, -3160, -10026, -16159, -20337, -21293, -18998, -17030, -15590, -15683, -17481, -18236, -18647, -19528, -19816, -17894, -16272, -16641, -18536, -21531, -25031, -26485, -26519, -28420, -28602, -27057, -26249, -26703, -22514, -17998, -16667, -15648, -14423, -12752, -6902, -1373, 1455, 4767, 6820, 7126, 5847, 5348, 3691, 1308, -1457, -4805, -7539, -10163, -13158, -15116, -16362, -16397, -15937, -14124, -10281, -6983, -8175, -10631, -13314, -13873, -13034, -14913, -17428, -20342, -18521, -15366, -16995, -21530, -25555, -26191, -22798, -18772, -18006, -19597, -19608, -15290, -11833, -10860, -9118, -7986, -8938, -8870, -9462, -11198, -15084, -19347, -21851, -21244, -20184, -19768, -20180, -18729, -15680, -12259, -10647, -9154, -10755, -11261, -9319, -9254, -10089, -12707, -14600, -11636, -7337, -4588, -3199, -2156, -6930, -10616, -10924, -10199, -4604, -372, 1077, 3513, 2846, -587, 1002};