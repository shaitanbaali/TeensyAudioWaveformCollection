/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0115 512 samples */
 
const int16_t AKWF_stereo_0115_512_DATA [512] = 
{11700, 11703, 11707, 11710, 11724, 11674, 11887, 13947, 14292, 14217, 14235, 14239, 14253, 14206, 15418, 19772, 20760, 20571, 20612, 20623, 20571, 20802, 22249, 22408, 22371, 22380, 22381, 22388, 22365, 22459, 23412, 24052, 23791, 25430, 27070, 26885, 26919, 26921, 26921, 26928, 26902, 27008, 27815, 28269, 28220, 28231, 28230, 28232, 28232, 28232, 28233, 28233, 28276, 28057, 29283, 32740, 32778, 32754, 32766, 32766, 32767, 32767, 32766, 32767, 32766, 32766, 32767, 32767, 32766, 32766, 32752, 32786, 32678, 29163, 28052, 28277, 28233, 28233, 28233, 28232, 28231, 28230, 28229, 28221, 28260, 28068, 27019, 26900, 26928, 26921, 26920, 26920, 26879, 27096, 25469, 23774, 24103, 23170, 22289, 22405, 22383, 22381, 22380, 22371, 22405, 22266, 21183, 20557, 20627, 20611, 20572, 20737, 19954, 15844, 14147, 14266, 14240, 14235, 14217, 14292, 13948, 11887, 11674, 11724, 11710, 11561, 12219, 9099, -9099, -12219, -11562, -11710, -11725, -11674, -11888, -13949, -14293, -14218, -14235, -14240, -14267, -14148, -15844, -19954, -20737, -20572, -20612, -20627, -20558, -21183, -22266, -22406, -22371, -22380, -22382, -22384, -22405, -22289, -23171, -24103, -23774, -25469, -27097, -26879, -26920, -26920, -26921, -26929, -26900, -27020, -28068, -28261, -28221, -28229, -28230, -28231, -28232, -28233, -28233, -28233, -28277, -28052, -29163, -32678, -32786, -32752, -32766, -32766, -32767, -32767, -32766, -32766, -32767, -32766, -32767, -32767, -32766, -32766, -32754, -32778, -32740, -29283, -28057, -28276, -28234, -28233, -28232, -28233, -28232, -28230, -28231, -28220, -28270, -27815, -27008, -26902, -26928, -26921, -26921, -26919, -26885, -27070, -25431, -23791, -24053, -23413, -22460, -22365, -22388, -22381, -22380, -22371, -22408, -22250, -20803, -20571, -20623, -20612, -20571, -20760, -19772, -15419, -14206, -14253, -14240, -14235, -14217, -14293, -13948, -11887, -11674, -11725, -11710, -11708, -11703, -11701, 11417, 11420, 11423, 11425, 11440, 11390, 11599, 13609, 13946, 13873, 13889, 13894, 13907, 13861, 15045, 19292, 20256, 20072, 20112, 20123, 20072, 20298, 21709, 21865, 21829, 21837, 21838, 21846, 21823, 21915, 22845, 23469, 23214, 24814, 26414, 26234, 26266, 26267, 26268, 26275, 26251, 26353, 27140, 27584, 27535, 27545, 27546, 27546, 27548, 27548, 27548, 27549, 27590, 27377, 28573, 31946, 31983, 31960, 31972, 31972, 31973, 31973, 31972, 31973, 31973, 31973, 31973, 31973, 31972, 31972, 31958, 31991, 31885, 28456, 27372, 27592, 27548, 27548, 27548, 27548, 27547, 27545, 27545, 27537, 27575, 27387, 26365, 26248, 26276, 26269, 26267, 26267, 26228, 26440, 24851, 23198, 23519, 22609, 21748, 21862, 21840, 21838, 21838, 21829, 21862, 21726, 20669, 20059, 20127, 20111, 20073, 20234, 19469, 15459, 13805, 13920, 13895, 13889, 13873, 13946, 13610, 11599, 11390, 11440, 11425, 11280, 11922, 8879, -8879, -11922, -11281, -11426, -11440, -11391, -11600, -13611, -13946, -13873, -13890, -13895, -13921, -13805, -15460, -19470, -20234, -20074, -20111, -20127, -20060, -20669, -21727, -21863, -21829, -21838, -21839, -21840, -21862, -21749, -22609, -23519, -23198, -24851, -26440, -26228, -26267, -26268, -26269, -26276, -26248, -26365, -27387, -27575, -27537, -27545, -27545, -27547, -27548, -27549, -27548, -27549, -27592, -27372, -28456, -31885, -31991, -31958, -31972, -31972, -31973, -31973, -31973, -31973, -31973, -31972, -31973, -31973, -31972, -31972, -31960, -31983, -31946, -28573, -27377, -27591, -27549, -27548, -27549, -27548, -27546, -27546, -27545, -27535, -27584, -27140, -26354, -26251, -26275, -26268, -26268, -26266, -26234, -26414, -24814, -23214, -23469, -22845, -21915, -21823, -21846, -21838, -21838, -21829, -21865, -21710, -20298, -20072, -20124, -20112, -20072, -20257, -19293, -15045, -13862, -13908, -13895, -13890, -13873, -13947, -13610, -11600, -11391, -11440, -11426, -11424, -11420, -11418};