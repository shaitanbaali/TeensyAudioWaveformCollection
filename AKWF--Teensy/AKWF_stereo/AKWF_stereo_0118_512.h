/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0118 512 samples */
 
const int16_t AKWF_stereo_0118_512_DATA [512] = 
{1072, 2186, 2069, 3653, 4134, 4902, 4216, 2065, 3654, 24371, 13998, 3742, 3378, 3145, 1388, 3479, 999, -495, -542, -1415, -1315, -1017, 3, 43, -74, 1955, 1721, -45, 203, 534, -547, -852, 476, -1829, -1694, 490, 1230, 1128, -353, -999, -771, -1002, 1268, 1294, -1095, -1145, -1439, -2923, -2230, 601, -860, -591, 1615, 1825, 1942, 2134, 2093, 1508, 3185, 2598, -847, -2749, -705, 985, 552, 837, 935, -198, -759, -852, 1011, 411, -1384, -1693, -2270, -68, 2031, 639, -527, -276, -194, 301, 639, -712, -1323, -637, -744, -1915, -2147, -546, 676, 1226, 541, 407, -560, -2084, -2382, -2568, -3139, -1037, -472, -23226, -17825, 24, 93, 804, 2837, -611, 398, 1490, 1243, -895, -2283, -2159, -1893, -1683, -386, 2107, -325, -825, -448, -48, 450, 1533, -152, -732, -394, -1346, -2693, -3098, 609, 2663, 1651, 1876, -687, -746, 1687, 1905, 702, 1540, 1755, -499, -132, 1199, -27, 2833, 2970, 426, -552, 1155, 1215, -182, 781, 1278, 1773, 707, 1814, 2643, 1908, 1297, 1682, 2456, 4278, 734, 234, 472, -526, -1665, -2301, -2363, -374, -797, -14, 2992, 1439, -245, 20, 754, 2256, 953, 2468, 1244, 289, 621, 2163, 1628, 875, 835, -341, -484, 295, -27, -997, -1527, -1129, -2707, -2360, -1036, -4808, -3323, -2287, -1275, -224, 654, 1341, 2334, 2551, 2087, 917, -4336, -1896, 3702, 3215, 1021, 1868, -290, -1358, -89, 210, 118, -152, -443, -3003, -3862, -703, -147, -2537, -3054, -2477, -1601, -919, -2915, -3246, -928, -1605, -2483, -1548, -3689, -2829, -1201, -34, 26, -2866, -2017, -325, -423, -1841, -630, -1409, -2898, -2718, 206, 1022, -502, -4181, -1215, 593, 833, 2066, 3543, 2946, 2311, 930, -2740, -841, 22711, 13798, 2585, 2364, 1249, 1718, 4985, 5065, 2918, 2074, 2633, 2788, 1812, -867, 3, 455, -555, 239, -1552, -182, 1602, 1083, 319, 428, 1145, 293, -1064, 78, 786, -4, -506, -2993, -3001, 1942, 1900, -890, -372, -1098, -2625, -1724, -173, 1537, 1362, 1134, 2260, 179, -687, 1816, 2049, 318, 1676, 2176, 162, -826, -688, 322, 613, 269, -980, -1502, 2343, 2992, 961, -177, -896, -2924, -2109, 622, 665, 35, 283, -636, -1947, -919, 1588, 1142, -408, -548, -1007, -1864, -1812, -1075, -718, -695, 298, -670, -3247, -1449, 749, -404, 45, 2911, -18156, -14592, -751, -929, -325, -559, -856, -606, -334, 988, 3250, -810, -1747, -1409, -2650, -2027, 288, -1199, -2111, -2070, -2070, -2368, 886, 3721, 32, -1175, -675, -1706, -1321, -830, -761, -342, -572, -2598, -2664, -1156, 712, 2442, 2180, 2964, 2466, 303, 204, 1821, 708, 58, 262, 221, -106, 1262, 1533, -245, 3634, 3786, 1159, 2567, 3591, 3081, 2549, 2350, 1426, -168, 750, 1808, 508, -1594, -250, 69, -1521, -971, 1677, 1660, 1067, 114, -592, -600, 501, 807, 489, 88, 688, 191, -3, 614, 296, 2516, 1902, -244, -566, 2142, 4452, -362, -2674, -2507, -1716, -1409, -1264, -1053, -2928, -3270, -1279, -1344, -4650, -507, 2655, 1165, 1695, 2380, 57, 360, 2655, 2101, 1996, 1193, -1979, -4510, -665, 2489, 2065, 36, 40, 333, -141, 75, 263, -1243, -1197, -307, -1906, -4423, -2818, -2870, -4208, -4029, -2476, -3739, -2782, 1307, 112, -1662, -1154, -1902, -2493, -621, -1523, -2910, -1090, -2742, -3286, -2173, -948, -382, -2267, -1665, 95};