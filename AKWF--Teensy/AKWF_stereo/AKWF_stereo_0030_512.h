/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0030 512 samples */
 
const int16_t AKWF_stereo_0030_512_DATA [512] = 
{345, 933, 1496, 2037, 2554, 3056, 3561, 4055, 4531, 4987, 5423, 5833, 6212, 6559, 6888, 7198, 7490, 7759, 8017, 8265, 8487, 8670, 8810, 8895, 8934, 8933, 8912, 8871, 8810, 8718, 8608, 8497, 8390, 8292, 8191, 8094, 8019, 7947, 7886, 7839, 7823, 7847, 7903, 7996, 8133, 8320, 8588, 8965, 9439, 10002, 10659, 11365, 12112, 12935, 13836, 14802, 15804, 16831, 17867, 18896, 19911, 20921, 21914, 22863, 23761, 24587, 25341, 26043, 26678, 27252, 27748, 28161, 28475, 28718, 28913, 29055, 29126, 29115, 29047, 28957, 28858, 28771, 28699, 28627, 28546, 28444, 28338, 28223, 28090, 27933, 27738, 27509, 27255, 26976, 26680, 26368, 26022, 25644, 25210, 24655, 24063, 23436, 22749, 22005, 21205, 20371, 19503, 18598, 17661, 16692, 15704, 14707, 13689, 12650, 11608, 10570, 9547, 8545, 7558, 6594, 5677, 4801, 3970, 3158, 2358, 1589, 859, 186, -425, -985, -1491, -1929, -2302, -2648, -2975, -3288, -3584, -3862, -4102, -4283, -4382, -4405, -4386, -4339, -4291, -4258, -4242, -4236, -4227, -4208, -4155, -4092, -4030, -3963, -3894, -3835, -3794, -3765, -3749, -3756, -3791, -3861, -3991, -4201, -4506, -4892, -5335, -5822, -6369, -6993, -7693, -8472, -9313, -10215, -11182, -12202, -13237, -14276, -15317, -16357, -17419, -18508, -19611, -20701, -21759, -22787, -23792, -24742, -25648, -26503, -27304, -28055, -28754, -29385, -29973, -30509, -30966, -31362, -31701, -31986, -32211, -32393, -32550, -32677, -32754, -32766, -32719, -32609, -32439, -32198, -31899, -31551, -31145, -30701, -30229, -29722, -29173, -28592, -27971, -27301, -26610, -25893, -25082, -24185, -23463, -22802, -22174, -21545, -20878, -20150, -19381, -18614, -17869, -17143, -16434, -15719, -14986, -14244, -13499, -12718, -11885, -11019, -10149, -9310, -8501, -7712, -6928, -6129, -5310, -4495, -3696, -2930, -2206, -1518, -878, -263, -6932, -7885, -8693, -9413, -10017, -10474, -10801, -11012, -11122, -11131, -11029, -10798, -10399, -9840, -9151, -8365, -7487, -6473, -5424, -4347, -3239, -2131, -1019, 113, 1263, 2422, 3542, 4585, 5624, 6716, 7811, 8931, 10089, 11240, 12344, 13395, 14371, 15325, 16290, 17280, 18316, 19334, 20317, 21253, 22094, 22827, 23468, 24052, 24598, 25114, 25569, 25925, 26145, 26212, 26143, 25962, 25754, 25575, 25441, 25279, 25018, 24636, 24121, 23471, 22673, 21733, 20663, 19525, 18353, 17086, 15677, 14146, 12494, 10734, 8897, 6997, 5056, 3108, 1146, -852, -2914, -5032, -7196, -9376, -11518, -13591, -15599, -17556, -19471, -21357, -23199, -24955, -26586, -28075, -29357, -30450, -31202, -31797, -32260, -32525, -32749, -32732, -32484, -32044, -31417, -30643, -29728, -28640, -27411, -26052, -24548, -22922, -21233, -19474, -17651, -15744, -13754, -11741, -9740, -7794, -5934, -4126, -2322, -542, 1190, 2872, 4457, 5955, 7366, 8663, 9818, 10798, 11579, 12175, 12642, 13023, 13340, 13570, 13668, 13621, 13349, 12954, 12581, 12135, 11630, 11023, 10278, 9394, 8362, 7195, 5925, 4574, 3175, 1760, 353, -1069, -2500, -3889, -5229, -6508, -7754, -9021, -10288, -11504, -12671, -13786, -14852, -15869, -16862, -17832, -18771, -19678, -20557, -21393, -22182, -22917, -23600, -24214, -24747, -25195, -25566, -25859, -26067, -26148, -26116, -25991, -25788, -25515, -25140, -24666, -24104, -23476, -22767, -21934, -20980, -19920, -18781, -17600, -16337, -14962, -13456, -11835, -10143, -8363, -6483, -4517, -2461, -319, 1847, 4023, 6178, 8298, 10375, 12359, 14220, 15982, 17641, 19187, 20617, 21920, 23095, 24164, 25159, 25903, 26516, 27004, 27414, 27758, 27952, 28011, 27896, 27625, 27228, 26714, 26083, 25348, 24478, 23402, 22144, 20688, 19102, 17456, 15768, 14055, 12332, 10547, 8711, 6878, 5052, 3234, 1454, -249, -1855, -3338, -4678, -5886};