/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0068 512 samples */
 
const int16_t AKWF_stereo_0068_512_DATA [512] = 
{15106, 24808, 24821, 25020, 25010, 24939, 24889, 24858, 24835, 24821, 24815, 24816, 24824, 24839, 24860, 24885, 24914, 24949, 24985, 25025, 25067, 25110, 25154, 25200, 25246, 25291, 25338, 25382, 25427, 25481, 25234, 27232, 11158, 276, 641, 455, 527, 655, 760, 842, 913, 972, 1019, 1056, 1082, 1100, 1108, 1108, 1100, 1087, 1067, 1042, 1014, 979, 943, 904, 862, 818, 773, 727, 681, 634, 587, 542, 496, 450, 407, 365, 324, 286, 249, 213, 178, 147, 117, 89, 63, 40, -76, 349, -1088, -10356, -12357, -12332, -12397, -12377, -12346, -12325, -12309, -12296, -12285, -12278, -12274, -12271, -12272, -12274, -12278, -12284, -12219, -12567, -11605, -2380, -8, -86, -38, -80, -133, -176, -211, -244, -271, -295, -314, -329, -341, -349, -354, -357, -356, -355, -351, -344, -336, -327, -316, -305, -292, -279, -261, -223, -411, 2385, 4121, 4091, 4141, 4150, 4151, 4155, 4162, 4168, 4175, 4184, 4194, 4157, 4448, 1902, -76, -31, -58, -44, -20, 0, 18, 35, 50, 64, 96, -225, 1535, -8824, -19443, -19385, -19559, -19550, -19478, -19419, -19378, -19345, -19319, -19301, -19291, -19287, -19290, -19297, -19310, -19327, -19349, -19374, -19401, -19430, -19463, -19497, -19532, -19568, -19605, -19642, -19679, -19715, -19752, -19788, -19822, -19856, -19889, -19922, -19952, -19981, -20008, -20035, -20060, -20083, -20104, -20124, -20142, -20160, -20174, -20188, -20201, -20212, -20222, -20231, -20239, -20244, -20248, -20253, -20257, -20259, -20261, -20262, -20261, -20262, -20260, -20258, -20276, -19931, -21649, -13577, -1119, -736, -573, -558, -623, -680, -718, -749, -774, -791, -802, -805, -804, -798, -786, -771, -752, -730, -705, -678, -649, -618, -586, -553, -519, -486, -451, -477, -122, -1818, 27006, 22243, 21456, 21525, 21384, 21134, 20958, 20853, 20775, 20724, 20702, 20708, 20736, 20787, 20857, 20944, 21046, 21161, 21286, 21421, 21564, 21712, 21863, 22018, 22175, 22333, 22489, 22644, 22797, 22373, 25694, 8705, -7600, 939, 1273, 1437, 1788, 2235, 2595, 2878, 3118, 3323, 3485, 3610, 3699, 3757, 3784, 3784, 3760, 3713, 3646, 3562, 3461, 3348, 3223, 3087, 2945, 2797, 2643, 2486, 2327, 2168, 2009, 1851, 1695, 1543, 1395, 1251, 1112, 978, 850, 728, 612, 503, 403, 306, 217, 132, -31, 475, -10720, -11454, -9283, -9346, -9354, -9256, -9150, -9077, -9023, -8978, -8942, -8918, -8902, -8895, -8896, -8904, -8919, -8940, -8817, -9709, 1047, 2524, -9, -27, -99, -271, -455, -601, -723, -830, -925, -1005, -1070, -1121, -1163, -1192, -1210, -1219, -1219, -1212, -1197, -1175, -1148, -1116, -1079, -1039, -996, -950, -822, -1214, 1257, 3404, 2250, 2277, 2320, 2338, 2339, 2352, 2372, 2396, 2422, 2451, 2410, 2848, 846, -1633, -360, -267, -222, -154, -69, 3, 65, 122, 173, 219, -61, 1818, -6841, -22432, -16227, -15685, -15625, -15472, -15216, -15014, -14872, -14760, -14672, -14611, -14576, -14562, -14571, -14598, -14642, -14700, -14772, -14857, -14951, -15053, -15163, -15278, -15397, -15521, -15645, -15771, -15898, -16023, -16147, -16270, -16390, -16505, -16618, -16726, -16831, -16930, -17024, -17113, -17198, -17278, -17351, -17419, -17481, -17539, -17592, -17639, -17682, -17720, -17754, -17784, -17809, -17829, -17847, -17862, -17873, -17880, -17884, -17888, -17888, -17886, -17883, -17877, -17660, -18893, -13531, 4674, -650, -1743, -1781, -1887, -2122, -2318, -2453, -2558, -2641, -2701, -2737, -2751, -2745, -2722, -2685, -2632, -2567, -2491, -2407, -2314, -2214, -2109, -2000, -1887, -1773, -1658, -1542, -838, -3891, 13206};