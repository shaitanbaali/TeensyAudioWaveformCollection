/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0008 512 samples */
 
const int16_t AKWF_stereo_0008_512_DATA [512] = 
{72, 314, 541, 758, 967, 1173, 1372, 1564, 1749, 1928, 2101, 2266, 2425, 2578, 2723, 2844, 2975, 3099, 3218, 3328, 3431, 3531, 3621, 3707, 3788, 3856, 3929, 3966, 4002, 4055, 4093, 4348, 3173, 13461, 30331, 31828, 32125, 32867, 32429, 31819, 30024, 28550, 27440, 26064, 25473, 24583, 24275, 23961, 23860, 23980, 24058, 24388, 24638, 24898, 25302, 25726, 26187, 26606, 27052, 27454, 27846, 28208, 28532, 28830, 29098, 29270, 29326, 29484, 29589, 29658, 29693, 29689, 29653, 29581, 29478, 29343, 29176, 29003, 28691, 28351, 28102, 27811, 27503, 27177, 26834, 26476, 26103, 25717, 25320, 24908, 24501, 23955, 23467, 23039, 22592, 22144, 21690, 21234, 20779, 20306, 19856, 19454, 18983, 18517, 17947, 17466, 17015, 16558, 16084, 15597, 15119, 14635, 14164, 13690, 13225, 12764, 12284, 11754, 11308, 10868, 10432, 10001, 9578, 9155, 8748, 8342, 7942, 7558, 7162, 6571, 7233, -2777, -19362, -21316, -22151, -23870, -23351, -23025, -21733, -20567, -19780, -18698, -18339, -17652, -17624, -17594, -17744, -18141, -18492, -19096, -19641, -20334, -20962, -21631, -22359, -22918, -23543, -24183, -24790, -25364, -25894, -26391, -26836, -27247, -27609, -27926, -28218, -28397, -28468, -28632, -28742, -28815, -28853, -28856, -28825, -28763, -28672, -28553, -28404, -28252, -27954, -27639, -27421, -27161, -26888, -26601, -26296, -25978, -25649, -25307, -24954, -24592, -24230, -23721, -23280, -22899, -22500, -22097, -21689, -21277, -20862, -20443, -20008, -19641, -19228, -18791, -18239, -17791, -17367, -16936, -16505, -16076, -15645, -15216, -14789, -14363, -13936, -13517, -13069, -12562, -12148, -11732, -11322, -10915, -10509, -10107, -9708, -9312, -8921, -8531, -8150, -7740, -7316, -6952, -6586, -6225, -5868, -5517, -5171, -4830, -4494, -4164, -3840, -3520, -3184, -2863, -2566, -2271, -1983, -1702, -1425, -1155, -897, -622, -400, -171, 5953, 6215, 6458, 6689, 6910, 7125, 7331, 7527, 7714, 7892, 8061, 8222, 8372, 8515, 8648, 8755, 8869, 8973, 9070, 9155, 9232, 9305, 9363, 9416, 9461, 9492, 9525, 9520, 9513, 9522, 9510, 9717, 8437, 19479, 33555, 31400, 31224, 32947, 32718, 32844, 31877, 31012, 30470, 29482, 29378, 28724, 28658, 28442, 28364, 28459, 28406, 28596, 28627, 28664, 28799, 28930, 29093, 29193, 29327, 29404, 29480, 29526, 29538, 29533, 29502, 29383, 29156, 29040, 28881, 28696, 28484, 28244, 27979, 27687, 27375, 27036, 26672, 26310, 25808, 25287, 24870, 24413, 23948, 23470, 22979, 22475, 21964, 21442, 20912, 20373, 19840, 19165, 18555, 18012, 17451, 16892, 16329, 15766, 15208, 14631, 14074, 13577, 13009, 12447, 11780, 11209, 10672, 10126, 9590, 9088, 8571, 8074, 7575, 7086, 6598, 6124, 5629, 5090, 4630, 4183, 3741, 3307, 2884, 2464, 2054, 1657, 1260, 881, 488, -91, 626, -10210, -25011, -23122, -23230, -26452, -26184, -26551, -25733, -25151, -24997, -24345, -24510, -24110, -24343, -24437, -24625, -25010, -25246, -25719, -26060, -26535, -26913, -27308, -27757, -28026, -28366, -28707, -29026, -29316, -29565, -29794, -29979, -30140, -30261, -30349, -30420, -30388, -30261, -30234, -30163, -30064, -29939, -29786, -29607, -29405, -29180, -28933, -28661, -28390, -27978, -27553, -27229, -26867, -26494, -26110, -25710, -25298, -24877, -24443, -24002, -23549, -23095, -22496, -21966, -21497, -21008, -20515, -20016, -19516, -19010, -18500, -17968, -17507, -17003, -16470, -15823, -15281, -14763, -14238, -13712, -13189, -12664, -12142, -11621, -11101, -10580, -10069, -9527, -8928, -8423, -7917, -7419, -6924, -6431, -5944, -5461, -4982, -4509, -4040, -3580, -3093, -2593, -2156, -1720, -1289, -866, -449, -42, 360, 756, 1141, 1521, 1893, 2279, 2650, 2991, 3328, 3658, 3976, 4288, 4593, 4882, 5187, 5438, 5691};