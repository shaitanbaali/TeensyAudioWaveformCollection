/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0146 512 samples */
 
const int16_t AKWF_stereo_0146_512_DATA [512] = 
{2264, 8792, 14033, 18278, 21928, 24821, 26987, 28479, 29955, 30891, 31484, 31919, 32310, 32476, 32482, 29080, 26342, 25491, 24407, 23288, 21938, 20298, 18746, 12757, 7729, 5827, 3825, 2064, 176, -1405, -2741, -9997, -12608, -14052, -16003, -17748, -18887, -19304, -19113, -19457, -21231, -22728, -23814, -24363, -24145, -23388, -22091, -24711, -26379, -25238, -23895, -21805, -19006, -15816, -12539, -13974, -13813, -11499, -10094, -9137, -8237, -6654, -4040, -6377, -3739, 1710, 6155, 9616, 12505, 15394, 17669, 19211, 21084, 22462, 23597, 24749, 25981, 27056, 28166, 25446, 23571, 24070, 24157, 24218, 24108, 23647, 22965, 18390, 15795, 15674, 15207, 14572, 13886, 13110, 12231, 5093, 1106, -1881, -5750, -9502, -12564, -14820, -16368, -18352, -21666, -24562, -26764, -28193, -28779, -28816, -28612, -31370, -32992, -32442, -31682, -30196, -28039, -25372, -22229, -22367, -21314, -18152, -15532, -13075, -10485, -7138, -2504, -3396, 2124, 8858, 14038, 18260, 21909, 24805, 26980, 28471, 29940, 30874, 31477, 31925, 32323, 32490, 32489, 29085, 26353, 25498, 24409, 23288, 21942, 20309, 18728, 12700, 7751, 5834, 3832, 2065, 157, -1439, -2712, -9710, -12627, -14028, -15996, -17746, -18889, -19300, -19089, -19433, -21217, -22724, -23814, -24375, -24164, -23410, -22103, -24716, -26386, -25223, -23881, -21791, -18987, -15792, -12550, -14073, -13771, -11510, -10107, -9150, -8241, -6672, -4033, -6182, -3781, 1720, 6172, 9634, 12522, 15415, 17693, 19237, 21092, 22455, 23576, 24731, 25969, 27043, 28158, 25439, 23567, 24081, 24166, 24218, 24098, 23646, 22962, 18378, 15812, 15688, 15220, 14578, 13876, 13101, 12197, 4943, 1110, -1903, -5769, -9512, -12564, -14806, -16344, -18351, -21674, -24571, -26761, -28187, -28779, -28824, -28633, -31400, -33002, -32453, -31684, -30190, -28027, -25369, -22230, -22363, -21301, -18130, -15519, -13085, -10513, -7152, -2554, -3376, -1041, 4053, 8422, 12001, 15364, 18371, 20838, 22792, 25005, 27034, 28528, 29642, 30590, 31414, 32226, 30901, 28654, 28136, 27572, 26822, 25912, 24805, 23644, 19806, 14571, 11820, 9369, 7032, 4756, 2690, 1173, -4947, -9317, -10510, -12027, -13673, -15083, -16087, -16783, -17817, -20059, -22332, -24114, -25421, -26118, -26249, -25650, -26967, -28967, -28455, -27503, -26205, -24428, -22227, -19632, -19558, -19732, -17205, -14404, -11644, -8721, -5350, -1196, -1369, -675, 3508, 6955, 9617, 11947, 14496, 16887, 18754, 21124, 23477, 25329, 26811, 28100, 29222, 30356, 29211, 26892, 26543, 26141, 25621, 25117, 24482, 23746, 20201, 16274, 14926, 13643, 12022, 10419, 8853, 7591, 1609, -3759, -5657, -7758, -9961, -11835, -13243, -14297, -15663, -18341, -21191, -23555, -25394, -26620, -27281, -27413, -29314, -31467, -31232, -30589, -29506, -27877, -25779, -23202, -22704, -22661, -20118, -17274, -14433, -11398, -7908, -3399, -3314, -1270, 4052, 8382, 11951, 15319, 18339, 20823, 22783, 24993, 27017, 28520, 29643, 30595, 31421, 32231, 30908, 28670, 28155, 27591, 26841, 25938, 24836, 23665, 19773, 14585, 11855, 9416, 7078, 4785, 2704, 1196, -4672, -9252, -10535, -12060, -13710, -15118, -16113, -16795, -17827, -20069, -22342, -24124, -25435, -26134, -26268, -25662, -26970, -28980, -28459, -27502, -26202, -24420, -22223, -19638, -19645, -19733, -17194, -14396, -11641, -8720, -5366, -1219, -1202, -660, 3462, 6923, 9587, 11923, 14485, 16887, 18765, 21142, 23493, 25334, 26811, 28104, 29226, 30363, 29218, 26889, 26543, 26139, 25614, 25108, 24475, 23735, 20172, 16264, 14921, 13635, 12009, 10397, 8831, 7564, 1469, -3809, -5671, -7780, -9982, -11853, -13258, -14302, -15674, -18352, -21203, -23561, -25398, -26625, -27287, -27424, -29335, -31472, -31236, -30590, -29504, -27873, -25782, -23210, -22705, -22652, -20106, -17263, -14442, -11416, -7913, -3426, -3259};