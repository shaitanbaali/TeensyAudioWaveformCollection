/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0106 512 samples */
 
const int16_t AKWF_stereo_0106_512_DATA [512] = 
{349, 1382, 2343, 3242, 4131, 5137, 6226, 7357, 8466, 9540, 10553, 11502, 12393, 13223, 14001, 14687, 15276, 15737, 16082, 16332, 16478, 16580, 16611, 16628, 16652, 16669, 16749, 16786, 16848, 16903, 16952, 17099, 17175, 17243, 17172, 17071, 17090, 17222, 17636, 18295, 19122, 19987, 20814, 21564, 22233, 22838, 23374, 23870, 24301, 24682, 25013, 25250, 25425, 25463, 25420, 25299, 25102, 24928, 24656, 24398, 24118, 23922, 23924, 23897, 23904, 23967, 24123, 24368, 24645, 24897, 25089, 25227, 25338, 25453, 25608, 25819, 26100, 26444, 26848, 27301, 27807, 28369, 28959, 29571, 30136, 30659, 31098, 31422, 31653, 31671, 31568, 31311, 31074, 30986, 30860, 30626, 30276, 29864, 29446, 29030, 28618, 28170, 27648, 27039, 26310, 25487, 24572, 23577, 22524, 21398, 20236, 19035, 17836, 16637, 15424, 14232, 13055, 11979, 11014, 10114, 9182, 8125, 6978, 5795, 4617, 3439, 2264, 1067, -171, -1430, -2710, -3961, -5164, -6305, -7362, -8360, -9259, -10091, -10842, -11522, -12193, -12785, -13368, -13859, -14297, -14780, -15269, -15873, -16351, -16743, -17085, -17321, -17449, -17464, -17399, -17274, -17123, -16947, -16775, -16624, -16511, -16474, -16493, -16602, -16785, -17041, -17380, -17726, -18100, -18453, -18984, -19783, -20711, -21688, -22534, -23797, -24444, -24732, -24842, -24841, -24820, -24829, -24882, -24965, -25057, -25137, -25193, -25221, -25207, -25166, -25091, -24993, -24884, -24746, -24622, -24507, -24458, -24503, -24618, -24863, -25151, -25547, -26038, -26550, -27108, -27473, -27778, -28121, -28517, -28912, -29225, -29448, -29626, -29808, -30036, -30317, -30639, -30973, -31283, -31537, -31715, -31807, -31806, -31696, -31455, -31085, -30572, -29948, -29212, -28358, -27421, -26395, -25403, -24491, -23690, -22934, -22024, -21032, -20009, -18993, -18008, -17020, -16011, -14950, -13812, -12623, -11383, -10131, -8877, -7627, -6402, -5182, -4019, -2886, -1787, -704, 1443, 2561, 3642, 4673, 5770, 6977, 8343, 9778, 11141, 12429, 13628, 14760, 15846, 16887, 17887, 18790, 19583, 20233, 20745, 21153, 21443, 21687, 21843, 21972, 22095, 22178, 22315, 22367, 22447, 22499, 22556, 22733, 22814, 22904, 22782, 22624, 22530, 22517, 22846, 23476, 24307, 25173, 25975, 26671, 27264, 27778, 28219, 28617, 28950, 29226, 29447, 29558, 29598, 29490, 29286, 29013, 28643, 28312, 27848, 27376, 26864, 26403, 26175, 25889, 25683, 25594, 25626, 25742, 25873, 25964, 25998, 25985, 25961, 25954, 25992, 26094, 26263, 26502, 26806, 27175, 27617, 28138, 28713, 29328, 29916, 30460, 30932, 31280, 31550, 31626, 31596, 31453, 31324, 31394, 31416, 31301, 31054, 30768, 30505, 30263, 30010, 29692, 29250, 28669, 27926, 27040, 26040, 24927, 23737, 22454, 21113, 19725, 18318, 16926, 15518, 14160, 12835, 11622, 10540, 9506, 8445, 7218, 5886, 4543, 3242, 1958, 679, -640, -2010, -3407, -4811, -6174, -7474, -8699, -9847, -10936, -11952, -12915, -13824, -14683, -15540, -16344, -17128, -17851, -18514, -19240, -19981, -20823, -21559, -22139, -22636, -22993, -23215, -23326, -23369, -23344, -23263, -23101, -22890, -22644, -22400, -22203, -22039, -21956, -21927, -21973, -22083, -22205, -22354, -22491, -22878, -23580, -24492, -25464, -26340, -27728, -28366, -28616, -28669, -28618, -28571, -28553, -28560, -28560, -28544, -28507, -28442, -28363, -28236, -28081, -27876, -27626, -27343, -26998, -26662, -26303, -26020, -25826, -25701, -25726, -25768, -25958, -26239, -26595, -27030, -27292, -27583, -27922, -28319, -28706, -28995, -29200, -29385, -29617, -29937, -30344, -30812, -31291, -31750, -32140, -32447, -32657, -32753, -32734, -32542, -32211, -31687, -31027, -30241, -29308, -28348, -27276, -26293, -25377, -24566, -23827, -22813, -21685, -20534, -19407, -18329, -17246, -16128, -14943, -13669, -12346, -10978, -9621, -8277, -6957, -5672, -4395, -3182, -1984, -832, 327};