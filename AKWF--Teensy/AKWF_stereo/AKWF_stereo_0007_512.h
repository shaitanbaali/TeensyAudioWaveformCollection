/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0007 512 samples */
 
const int16_t AKWF_stereo_0007_512_DATA [512] = 
{181, 608, 1023, 1444, 1865, 2277, 2691, 3103, 3515, 3927, 4337, 4748, 5158, 5567, 5976, 6384, 6794, 7161, 7544, 7925, 8295, 8657, 9008, 9352, 9687, 10015, 10337, 10653, 10967, 11264, 11519, 11808, 12063, 12354, 12635, 12912, 13183, 13450, 13711, 13968, 14218, 14472, 14682, 14849, 15084, 15304, 15520, 15731, 15936, 16135, 16328, 16514, 16694, 16867, 17050, 17153, 17251, 17413, 17557, 17697, 17831, 17961, 18085, 18204, 18318, 18427, 18528, 18638, 18646, 18696, 18791, 18870, 18946, 19020, 19089, 19154, 19216, 19274, 19328, 19382, 19429, 19372, 19406, 19453, 19489, 19524, 19558, 19587, 19615, 19642, 19666, 19687, 19713, 19711, 19629, 19647, 19661, 19676, 19687, 19698, 19709, 19717, 19726, 19734, 19739, 19755, 19719, 19645, 19660, 19664, 19670, 19677, 19684, 19690, 19698, 19705, 19713, 19724, 19729, 19647, 19646, 19661, 19675, 19688, 19704, 19719, 19718, 19707, 19707, 19699, 19706, 19680, 19595, 19596, 19605, 19610, 19613, 19626, 19634, 19615, 19601, 19665, 11306, -5490, -15959, -21903, -26905, -30367, -32467, -32480, -30043, -25368, -20010, -16226, -14481, -14210, -14064, -13103, -11452, -9833, -9045, -9437, -10822, -12529, -13944, -14834, -15351, -15928, -16868, -18204, -19586, -20927, -22004, -22732, -23269, -23795, -24423, -25137, -25827, -26370, -26712, -26881, -26962, -26889, -26983, -27106, -27146, -27115, -26978, -26767, -26526, -26290, -26066, -25833, -25579, -25231, -24729, -24355, -23974, -23603, -23239, -22872, -22490, -22088, -21673, -21254, -20838, -20446, -19976, -19466, -19071, -18656, -18237, -17821, -17410, -17003, -16599, -16193, -15781, -15368, -14964, -14474, -14008, -13614, -13205, -12799, -12390, -11979, -11569, -11159, -10748, -10338, -9927, -9512, -9035, -8593, -8178, -7826, -7407, -6991, -6576, -6157, -5738, -5320, -4900, -4482, -4053, -3598, -3176, -2759, -2340, -1920, -1502, -1084, -667, -242, 5333, 5776, 6204, 6638, 7066, 7482, 7897, 8307, 8713, 9116, 9512, 9909, 10299, 10685, 11069, 11446, 11823, 12156, 12502, 12844, 13174, 13496, 13803, 14103, 14391, 14671, 14942, 15203, 15459, 15695, 15887, 16106, 16293, 16510, 16712, 16909, 17096, 17276, 17448, 17612, 17767, 17924, 18033, 18099, 18230, 18343, 18450, 18550, 18642, 18727, 18802, 18872, 18933, 18985, 19045, 19023, 18997, 19032, 19050, 19061, 19066, 19065, 19057, 19042, 19024, 18998, 18964, 18937, 18807, 18721, 18677, 18618, 18553, 18486, 18414, 18339, 18259, 18175, 18086, 17996, 17897, 17697, 17580, 17477, 17369, 17259, 17147, 17030, 16913, 16795, 16673, 16549, 16429, 16280, 16055, 15927, 15797, 15669, 15537, 15405, 15274, 15143, 15011, 14878, 14747, 14624, 14448, 14237, 14116, 13989, 13862, 13736, 13614, 13492, 13371, 13252, 13136, 13023, 12904, 12700, 12581, 12479, 12378, 12276, 12181, 12088, 12018, 11960, 11896, 11846, 11796, 11730, 11595, 11559, 11524, 11496, 11471, 11443, 11429, 11385, 11365, 11332, 1914, -12337, -17411, -21426, -26966, -30598, -32602, -32424, -30654, -28105, -25665, -24344, -23819, -23832, -23533, -22646, -21538, -20713, -20559, -21031, -21896, -22715, -23238, -23479, -23614, -23877, -24350, -25046, -25672, -26212, -26587, -26784, -26931, -27118, -27373, -27649, -27866, -27965, -27941, -27837, -27703, -27439, -27321, -27202, -27012, -26778, -26486, -26161, -25829, -25504, -25179, -24836, -24475, -24034, -23461, -23033, -22599, -22171, -21741, -21302, -20850, -20383, -19911, -19436, -18963, -18506, -17965, -17382, -16915, -16428, -15940, -15453, -14969, -14484, -14000, -13511, -13018, -12526, -12041, -11468, -10920, -10441, -9948, -9459, -8966, -8473, -7982, -7491, -6999, -6510, -6021, -5527, -4975, -4459, -3967, -3544, -3056, -2574, -2093, -1612, -1133, -658, -184, 287, 766, 1269, 1737, 2195, 2653, 3108, 3560, 4006, 4451, 4900};