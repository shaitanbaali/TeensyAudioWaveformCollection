/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0055 512 samples */
 
const int16_t AKWF_stereo_0055_512_DATA [512] = 
{350, 972, 1653, 2273, 2914, 3556, 4197, 4835, 5470, 6104, 6733, 7361, 7985, 8602, 9217, 9824, 10423, 11016, 11601, 12177, 12743, 13302, 13849, 14388, 14917, 15433, 15939, 16433, 16915, 17384, 17841, 18284, 18717, 19129, 19538, 19926, 20300, 20662, 21011, 21343, 21661, 21965, 22255, 22530, 22791, 23037, 23270, 23489, 23691, 23882, 24058, 24220, 24369, 24504, 24626, 24735, 24830, 24913, 24983, 25038, 25082, 25114, 25133, 25139, 25132, 25114, 25082, 25038, 24982, 24913, 24830, 24735, 24625, 24503, 24369, 24220, 24058, 23884, 23692, 23489, 23273, 23042, 22795, 22536, 22261, 21973, 21672, 21355, 21025, 20684, 20326, 19956, 19573, 19176, 18768, 18340, 17908, 17456, 16995, 16521, 16035, 15537, 15040, 14559, 14067, 13558, 13044, 12520, 11984, 11439, 10880, 10308, 9726, 9132, 8530, 7921, 7304, 6680, 6054, 5421, 4786, 4150, 3510, 2870, 2232, 1590, 952, 282, -346, -968, -1648, -2272, -2914, -3554, -4196, -4833, -5468, -6103, -6733, -7360, -7982, -8600, -9215, -9823, -10423, -11016, -11600, -12175, -12743, -13301, -13849, -14387, -14915, -15432, -15939, -16433, -16914, -17384, -17841, -18285, -18719, -19130, -19538, -19926, -20302, -20663, -21010, -21343, -21661, -21966, -22255, -22530, -22791, -23038, -23270, -23488, -23691, -23882, -24057, -24220, -24369, -24504, -24626, -24735, -24831, -24913, -24983, -25038, -25082, -25115, -25134, -25140, -25133, -25115, -25083, -25039, -24982, -24913, -24831, -24736, -24627, -24505, -24370, -24222, -24058, -23884, -23695, -23492, -23274, -23042, -22797, -22537, -22263, -21975, -21674, -21357, -21028, -20685, -20328, -19958, -19575, -19179, -18770, -18342, -17910, -17460, -16997, -16522, -16036, -15538, -15043, -14562, -14070, -13562, -13047, -12523, -11987, -11442, -10883, -10311, -9729, -9136, -8535, -7926, -7308, -6683, -6058, -5426, -4790, -4155, -3515, -2875, -2237, -1596, -957, -295, 480, 1368, 2279, 3171, 4067, 4959, 5852, 6739, 7621, 8490, 9359, 10221, 11072, 11912, 12741, 13562, 14367, 15156, 15933, 16693, 17438, 18170, 18882, 19576, 20258, 20924, 21577, 22205, 22815, 23412, 23983, 24539, 25081, 25597, 26095, 26580, 27039, 27480, 27909, 28320, 28709, 29079, 29436, 29773, 30085, 30387, 30670, 30928, 31174, 31403, 31606, 31798, 31976, 32133, 32267, 32389, 32494, 32574, 32643, 32702, 32737, 32756, 32769, 32759, 32734, 32704, 32656, 32587, 32510, 32421, 32302, 32170, 32028, 31866, 31678, 31483, 31274, 31037, 30789, 30529, 30246, 29940, 29626, 29296, 28936, 28567, 28185, 27775, 27350, 26916, 26462, 25980, 25491, 24985, 24453, 23905, 23346, 22764, 22160, 21545, 20915, 20258, 19595, 18937, 18260, 17557, 16850, 16125, 15377, 14624, 13853, 13061, 12259, 11444, 10616, 9774, 8926, 8077, 7208, 6334, 5457, 4577, 3690, 2805, 1922, 1031, 147, -746, -1627, -2505, -3393, -4260, -5136, -6007, -6875, -7734, -8589, -9441, -10279, -11107, -11929, -12737, -13532, -14317, -15081, -15834, -16575, -17303, -18012, -18707, -19388, -20054, -20698, -21328, -21945, -22538, -23113, -23672, -24210, -24730, -25240, -25728, -26193, -26648, -27084, -27494, -27894, -28278, -28639, -28982, -29314, -29623, -29912, -30190, -30454, -30692, -30913, -31126, -31318, -31486, -31648, -31789, -31902, -32011, -32102, -32166, -32224, -32272, -32297, -32307, -32313, -32301, -32267, -32228, -32180, -32109, -32026, -31937, -31826, -31691, -31549, -31392, -31211, -31019, -30814, -30591, -30345, -30094, -29825, -29529, -29226, -28912, -28572, -28214, -27849, -27465, -27056, -26640, -26208, -25752, -25285, -24805, -24303, -23780, -23250, -22707, -22134, -21549, -20954, -20334, -19703, -19079, -18438, -17772, -17102, -16419, -15713, -14996, -14269, -13528, -12764, -11991, -11207, -10407, -9597, -8783, -7957, -7121, -6287, -5449, -4600, -3754, -2917, -2067, -1215, -348};