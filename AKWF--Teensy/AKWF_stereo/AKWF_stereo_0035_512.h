/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0035 512 samples */
 
const int16_t AKWF_stereo_0035_512_DATA [512] = 
{1325, 3444, 1572, 1165, 407, -342, -98, 920, 4198, 7754, 5351, 5985, 5598, 5147, 5551, 8080, 10779, 12609, 11526, 10412, 13541, 15292, 14955, 13423, 12195, 13723, 14715, 14734, 16589, 16824, 14320, 11694, 8617, 4522, 7642, 11893, 10596, 9697, 9120, 8407, 7831, 8653, 10085, 13790, 14698, 14857, 16008, 15040, 17780, 20070, 20632, 22396, 21807, 18640, 18327, 23635, 23695, 19532, 14767, 12970, 14409, 15579, 15454, 14616, 15574, 15022, 13078, 13170, 17140, 19290, 16580, 15678, 16650, 17232, 16435, 14326, 13782, 16176, 21261, 19177, 16058, 15717, 16499, 15423, 14675, 16255, 18569, 19188, 17608, 17185, 18274, 18702, 21269, 18721, 14497, 15808, 17285, 18628, 19540, 18714, 16321, 15409, 14245, 13000, 12254, 7759, 8160, 9571, 7880, 5109, 4302, 5212, 7966, 8311, 2237, -1679, -2382, -932, -1772, -4274, -1664, 2053, 6223, 8049, 9010, 9489, 6643, 3315, 387, 245, 1062, 509, 851, 1110, 1444, 470, -1028, -594, 704, 2602, 2286, 2463, 2055, 566, -2913, -6587, -5280, 1417, -123, -2806, -4916, -6771, -7079, -6153, -5896, -7113, -9449, -8401, -5925, -4635, -4235, -4918, -8175, -10204, -7012, -7989, -8772, -7667, -6050, -4983, -9449, -11385, -9896, -8560, -6334, -4925, -6251, -6720, -6130, -8660, -8916, -8000, -7865, -12125, -14750, -11958, -9056, -8634, -10039, -12273, -13143, -12973, -13898, -15102, -14518, -15749, -19261, -20567, -21277, -19579, -19298, -18719, -17817, -15294, -12785, -14894, -30221, -30531, -27733, -25561, -24938, -25705, -27810, -30125, -31836, -30872, -31105, -32224, -31559, -30168, -27697, -21794, -18540, -20713, -21090, -21732, -22032, -20768, -18201, -12711, -9680, -11386, -12475, -12194, -11275, -12725, -13945, -13590, -13973, -14366, -18271, -19476, -15101, -11798, -10627, -12669, -12300, -10309, -10119, -11598, -12545, -13222, -13547, -11022, -6556, -2248, -3580, -6320, -5963, -7222, -5288, -4068, -8348, -13205, -17173, -12150, -2366, -2250, -5961, -2896, -3004, -2924, -10267, -19037, -20080, -15766, -16855, -11208, -7723, -14410, -10922, -12152, -17454, -15228, -8750, -1991, 3119, 1540, -4104, -6893, -8860, -9822, -8421, -9115, 1682, 14359, 18996, 18372, 18343, 19942, 17972, 13010, 7958, 6103, 9250, 17077, 17383, 13205, 11595, 11857, 12252, 14916, 19749, 20237, 20884, 24491, 22643, 20266, 21014, 22844, 15510, 13229, 19319, 19912, 17747, 13480, 9829, 9544, 10338, 11227, 12398, 13279, 17072, 19081, 17152, 15573, 7785, 6908, 16140, 18323, 18999, 13295, 9252, 4248, -1451, -2184, -3680, 646, 3643, 5081, 420, -2532, -756, -834, -4644, -6888, -9922, -15433, -13791, -8264, -5094, -4650, -5994, -6497, -8649, -6855, -7467, -11977, -17586, -23550, -27762, -31950, -29592, -24881, -21204, -19259, -21346, -22799, -27199, -20080, -1038, -1158, 306, 118, -361, -2637, -5572, -7461, -8957, -11334, -11377, -8007, -5362, -7238, -6371, 2069, 4165, 399, -293, -3067, 4298, 12683, 14003, 17425, 18692, 17648, 15116, 15821, 15048, 12906, 10753, 6705, -697, -5450, -8363, -4888, -954, 122, 762, -2730, -1894, 2711, -4068, -10463, -11388, -11800, -7705, -6481, -5625, -6269, -3298, 1143, -2952, -12140, -16034, -14440, -11269, -4519, -6290, -16609, -19559, -14971, -12409, -11716, -7038, -3299, -5957, -7351, -5612, -4184, -8074, -12130, -12781, -11102, -9731, -7410, -8003, -8376, -4391, -3068, -4557, -2801, -7633, -14037, -8674, -6261, -11379, -14067, -14775, -8024, -1331, 1899, 3295, 6785, 2952, -3623, -2188, -4636, 5066, 11377, 7277, 8282, 8294, 3891, 7504, 12846, 11524, 7889, 8164, 6129, 4386, 3770, 3741, 6780, 7994, 7671, 7283, 10463, 19787, 24998, 18460, 14556, 11504, 11878, 14821, 17200, 20343, 19070, 7718, 3894, 2346, 1744};