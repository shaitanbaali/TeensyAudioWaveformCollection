/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0154 512 samples */
 
const int16_t AKWF_stereo_0154_512_DATA [512] = 
{23558, 31062, 25186, 24033, 23044, 22137, 21177, 20241, 19251, 18262, 17321, 16434, 15618, 14882, 14231, 13668, 13196, 12805, 12493, 12255, 12080, 11960, 11888, 11851, 11843, 11855, 11880, 11911, 11942, 11969, 11987, 11997, 11992, 11975, 11943, 11896, 11835, 11763, 11677, 11581, 11477, 11364, 11244, 11120, 10991, 10861, 10729, 10595, 10462, 10329, 10198, 10066, 9938, 9810, 9682, 9556, 9434, 9309, 9188, 9065, 8943, 8822, 8700, 8579, 8456, 8334, 8212, 8086, 7964, 7839, 7712, 7585, 7458, 7329, 7201, 7072, 6941, 6811, 6681, 6549, 6417, 6286, 6153, 6022, 5886, 5754, 5622, 5487, 5353, 5219, 5087, 4953, 4819, 4684, 4550, 4415, 4280, 4146, 4012, 3878, 3741, 3606, 3471, 3337, 3201, 3065, 2929, 2793, 2658, 2522, 2386, 2249, 2114, 1978, 1841, 1704, 1569, 1432, 1294, 1159, 1022, 886, 749, 613, 476, 340, 203, 67, -68, -204, -341, -477, -614, -750, -887, -1023, -1160, -1295, -1433, -1570, -1705, -1842, -1979, -2115, -2250, -2387, -2523, -2659, -2794, -2930, -3066, -3202, -3338, -3472, -3607, -3742, -3879, -4013, -4147, -4281, -4416, -4551, -4685, -4820, -4954, -5088, -5220, -5354, -5488, -5622, -5755, -5887, -6022, -6154, -6286, -6418, -6550, -6682, -6812, -6942, -7072, -7202, -7330, -7458, -7586, -7712, -7840, -7965, -8087, -8212, -8335, -8457, -8579, -8701, -8823, -8944, -9065, -9188, -9310, -9434, -9557, -9683, -9811, -9939, -10067, -10199, -10330, -10462, -10596, -10730, -10862, -10992, -11120, -11245, -11364, -11477, -11582, -11678, -11763, -11836, -11897, -11944, -11975, -11992, -11998, -11988, -11969, -11942, -11912, -11881, -11856, -11844, -11852, -11888, -11961, -12081, -12256, -12494, -12806, -13196, -13669, -14232, -14882, -15618, -16434, -17322, -18263, -19251, -20242, -21177, -22138, -23044, -24034, -25186, -31062, -23558, 24254, 32417, 28447, 27445, 26229, 24984, 23702, 22493, 21291, 20147, 19095, 18133, 17268, 16502, 15833, 15259, 14778, 14379, 14056, 13805, 13611, 13470, 13371, 13305, 13266, 13245, 13234, 13230, 13226, 13219, 13205, 13185, 13152, 13108, 13053, 12986, 12907, 12819, 12719, 12611, 12497, 12374, 12247, 12116, 11981, 11843, 11705, 11565, 11424, 11283, 11145, 11004, 10866, 10729, 10590, 10454, 10319, 10183, 10048, 9913, 9779, 9645, 9510, 9375, 9240, 9105, 8969, 8832, 8695, 8557, 8419, 8279, 8139, 7998, 7858, 7717, 7574, 7432, 7288, 7145, 7001, 6857, 6714, 6569, 6423, 6278, 6134, 5987, 5841, 5695, 5551, 5404, 5258, 5111, 4964, 4817, 4671, 4523, 4377, 4229, 4080, 3934, 3787, 3639, 3490, 3342, 3195, 3047, 2898, 2751, 2602, 2453, 2305, 2157, 2007, 1858, 1710, 1561, 1413, 1264, 1115, 966, 817, 668, 520, 371, 221, 73, -74, -222, -372, -521, -669, -818, -967, -1115, -1265, -1414, -1562, -1711, -1859, -2008, -2158, -2306, -2454, -2603, -2752, -2899, -3048, -3196, -3343, -3491, -3640, -3787, -3935, -4081, -4230, -4378, -4524, -4672, -4818, -4965, -5111, -5259, -5405, -5552, -5696, -5842, -5988, -6134, -6279, -6423, -6570, -6714, -6858, -7002, -7146, -7289, -7433, -7574, -7718, -7858, -7999, -8140, -8280, -8419, -8558, -8696, -8832, -8969, -9106, -9241, -9376, -9511, -9646, -9780, -9914, -10049, -10184, -10320, -10454, -10591, -10729, -10867, -11005, -11145, -11284, -11425, -11565, -11705, -11844, -11982, -12117, -12247, -12374, -12497, -12612, -12720, -12819, -12907, -12986, -13054, -13109, -13152, -13186, -13205, -13220, -13227, -13231, -13235, -13245, -13267, -13305, -13372, -13470, -13612, -13805, -14057, -14380, -14778, -15259, -15834, -16503, -17268, -18133, -19095, -20147, -21291, -22494, -23702, -24984, -26230, -27445, -28447, -32417, -24254};