/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0117 512 samples */
 
const int16_t AKWF_stereo_0117_512_DATA [512] = 
{1176, 3563, 6008, 8504, 10992, 13437, 15784, 17951, 19930, 21713, 23229, 24447, 25347, 25941, 26220, 26214, 25975, 25477, 24810, 24020, 23165, 22261, 21392, 20577, 19870, 19141, 18666, 18375, 18219, 18240, 18444, 18846, 19451, 20278, 21286, 22457, 23748, 25148, 26553, 27917, 29179, 30197, 30895, 31267, 31212, 30717, 29748, 28306, 26458, 24275, 21824, 19198, 16486, 13830, 11296, 8953, 6943, 5253, 3856, 2829, 2171, 1842, 1821, 2062, 2523, 3166, 3959, 4865, 5832, 6804, 7761, 8620, 9410, 10037, 10455, 10635, 10588, 10285, 9726, 8931, 7929, 6743, 5272, 3781, 2310, 852, -625, -2041, -3326, -4442, -5383, -6130, -6687, -7016, -7093, -6928, -6490, -5809, -4892, -3758, -2428, -937, 613, 2155, 3603, 4881, 5917, 6650, 6999, 6895, 6368, 5427, 4126, 2529, 666, -1357, -3421, -5387, -7196, -8803, -10088, -11044, -11647, -11874, -11719, -11235, -10469, -9418, -8140, -6671, -5054, -3393, -1683, 21, 1711, 3318, 4769, 6051, 7098, 7890, 8437, 8728, 8718, 8443, 7933, 7250, 6408, 5449, 4473, 3457, 2487, 1627, 845, 230, -217, -560, -779, -711, -592, -164, 433, 1200, 2115, 3184, 4366, 5612, 6823, 7969, 8965, 9721, 10165, 10213, 9804, 8917, 7518, 5800, 3604, 983, -1883, -4900, -7968, -10999, -13874, -16550, -18936, -20985, -22686, -23997, -24816, -25411, -25716, -25695, -25390, -24897, -24257, -23499, -22694, -21855, -21028, -20269, -19619, -19124, -18826, -18768, -18887, -19165, -19811, -20670, -21681, -22834, -24113, -25427, -26778, -28088, -29287, -30338, -31235, -31946, -32465, -32737, -32732, -32440, -31907, -31127, -30037, -28645, -27007, -25113, -23006, -20741, -18401, -16045, -13698, -11373, -9420, -7771, -6439, -5469, -4894, -4730, -4928, -5409, -6084, -6880, -7710, -8467, -9094, -9473, -9545, -9285, -8685, -7756, -6507, -4938, -3110, -1008, -4286, -2465, -528, 1532, 3667, 5879, 8115, 10342, 12510, 14636, 16658, 18513, 20177, 21625, 22782, 23645, 24189, 24442, 24407, 24072, 23526, 22818, 21975, 21111, 20261, 19347, 18624, 18083, 17680, 17478, 17454, 17619, 17985, 18555, 19328, 20212, 21256, 22445, 23703, 25016, 26367, 27660, 28830, 29805, 30531, 30961, 31024, 30719, 29980, 28800, 27275, 25440, 23314, 21013, 18618, 16214, 13924, 11810, 9876, 8211, 6859, 5785, 4975, 4478, 4233, 4164, 4276, 4579, 5016, 5550, 6170, 6857, 7569, 8285, 8963, 9559, 10012, 10312, 10417, 10308, 9941, 9337, 8339, 7171, 5888, 4444, 2907, 1340, -198, -1645, -2956, -4068, -4984, -5685, -6144, -6386, -6354, -6102, -5641, -4974, -4103, -3047, -1869, -613, 694, 2028, 3277, 4398, 5313, 5952, 6274, 6243, 5846, 5088, 4005, 2610, 977, -773, -2570, -4346, -5999, -7422, -8636, -9574, -10179, -10463, -10448, -10168, -9601, -8813, -7851, -6716, -5454, -4105, -2663, -1172, 329, 1805, 3225, 4552, 5716, 6715, 7465, 7946, 8183, 8134, 7799, 7225, 6474, 5557, 4523, 3481, 2454, 1521, 723, 47, -532, -824, -1039, -929, -674, -225, 364, 1099, 1965, 2948, 4002, 5096, 6202, 7216, 8098, 8817, 9265, 9354, 9050, 8451, 7402, 5876, 4011, 1803, -688, -3310, -6010, -8733, -11366, -13811, -16023, -17990, -19523, -20823, -21857, -22608, -23065, -23284, -23291, -23124, -22831, -22439, -21926, -21334, -20720, -20120, -19587, -19126, -18748, -18425, -18441, -18676, -19124, -19792, -20702, -21809, -23072, -24449, -25878, -27286, -28606, -29810, -30857, -31657, -32223, -32513, -32530, -32292, -31771, -30990, -29958, -28687, -27175, -25478, -23634, -21658, -19573, -17347, -15311, -13343, -11520, -9945, -8633, -7633, -6989, -6689, -6699, -6963, -7436, -8032, -8678, -9279, -9744, -10011, -10043, -9803, -9244, -8383, -7289, -5862};