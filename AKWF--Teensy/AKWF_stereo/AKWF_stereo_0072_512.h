/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0072 512 samples */
 
const int16_t AKWF_stereo_0072_512_DATA [512] = 
{1010, 1413, 1572, 1486, 1392, 921, 857, 816, 1133, 1315, 1538, 1710, 1851, 1959, 2055, 2136, 2212, 2296, 2384, 2465, 2554, 2643, 2719, 2799, 2882, 2956, 3025, 3100, 3171, 3238, 3308, 3381, 3445, 3512, 3582, 3644, 3707, 3777, 3848, 3909, 3978, 4051, 4117, 4184, 4261, 4334, 4401, 4478, 4551, 4606, 4686, 4772, 4858, 4935, 5021, 5106, 5183, 5267, 5357, 5390, 5784, 4456, 3288, 3257, 4257, 5121, 5642, 6023, 6306, 6496, 6653, 6779, 6871, 6953, 7032, 7097, 7149, 7213, 7278, 7329, 7385, 7449, 7504, 7556, 7619, 7682, 7732, 7795, 7862, 7914, 7970, 8041, 8106, 8159, 8228, 8297, 8352, 8424, 8499, 8557, 8622, 8699, 8766, 8820, 8911, 8857, 8934, 8983, 9143, 9221, 9310, 9400, 9483, 9548, 9627, 9685, 9977, 8728, -11330, -12486, -17253, -9196, -8483, -6457, -5924, -5683, -5614, -5416, -5087, -4725, -4481, -4486, -4676, -4938, -5185, -5397, -5581, -5804, -6111, -6477, -6845, -7195, -7500, -7752, -7996, -8261, -8521, -8753, -8962, -9121, -9207, -9265, -9306, -9314, -9291, -9244, -9156, -9012, -8851, -8699, -8340, -8858, -8842, -8737, -7972, -7524, -7074, -6705, -6373, -6086, -5812, -5552, -5328, -5118, -4916, -4750, -4608, -4466, -4354, -4269, -4185, -4123, -4089, -4065, -4046, -4048, -4063, -4073, -4094, -4133, -4165, -4190, -4229, -4265, -4282, -4306, -4328, -4332, -4328, -4325, -4304, -4262, -4225, -4178, -4108, -4076, -3991, -3897, -3762, -3649, -3527, -3393, -3260, -3130, -2985, -2890, -2296, -4280, -9304, -8629, -7408, -4234, -3118, -2032, -1360, -892, -566, -340, -183, -71, 12, 62, 98, 126, 149, 162, 176, 187, 191, 199, 212, 222, 233, 251, 267, 285, 308, 340, 367, 400, 442, 468, 643, 112, -165, 152, 2308, 3262, 3643, 3458, 3065, 2754, 2580, 2626, 2792, 3084, 3391, 3667, 3895, 4076, 4226, 4359, 4497, 4648, 4809, 4978, 5160, 5337, 5506, 5683, 5854, 6018, 6183, 6353, 6516, 6681, 6854, 7021, 7182, 7354, 7522, 7679, 7844, 8015, 8179, 8340, 8509, 8677, 8836, 9003, 9173, 9334, 9495, 9666, 9830, 9985, 10154, 10322, 10480, 10641, 10811, 10974, 11132, 11300, 11467, 11629, 11748, 12125, 12458, 12635, 12671, 12715, 12804, 12930, 13064, 13199, 13353, 13515, 13665, 13820, 13988, 14148, 14297, 14465, 14631, 14784, 14941, 15111, 15269, 15420, 15587, 15751, 15898, 16058, 16225, 16373, 16522, 16689, 16849, 16992, 17155, 17314, 17458, 17618, 17782, 17926, 18077, 18241, 18393, 18531, 18691, 18869, 19007, 19164, 19314, 19460, 19599, 19758, 19912, 20048, 20202, 20335, 20757, 19245, -6108, -8750, -18546, -14518, -20020, -21486, -21507, -19660, -17900, -17425, -18378, -19815, -20602, -20267, -19084, -17865, -17317, -17595, -18262, -18748, -18705, -18177, -17511, -17106, -17078, -17269, -17439, -17393, -17098, -16703, -16409, -16283, -16266, -16269, -16181, -15959, -15676, -15432, -15260, -15137, -15044, -14909, -14729, -14387, -14139, -13923, -13824, -13708, -13581, -13397, -13203, -13009, -12822, -12644, -12486, -12323, -12135, -11952, -11769, -11578, -11411, -11252, -11080, -10910, -10746, -10575, -10401, -10242, -10085, -9919, -9758, -9600, -9434, -9264, -9108, -8949, -8782, -8623, -8463, -8297, -8132, -7969, -7805, -7632, -7468, -7302, -7128, -6948, -6780, -6608, -6436, -6265, -6095, -5921, -5746, -5572, -5395, -5210, -5105, -4617, -3675, -3581, -3566, -3835, -3803, -3772, -3679, -3560, -3418, -3262, -3096, -2931, -2758, -2581, -2406, -2229, -2052, -1876, -1701, -1526, -1354, -1180, -1006, -832, -659, -487, -314, -140, 28, 204, 376, 547, 716, 845, 1323, 97, -529, 253};