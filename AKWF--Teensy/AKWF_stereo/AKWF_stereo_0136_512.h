/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0136 512 samples */
 
const int16_t AKWF_stereo_0136_512_DATA [512] = 
{936, 2536, 4075, 5579, 7034, 8432, 9766, 11024, 12207, 13307, 14319, 15247, 16088, 16839, 17506, 18088, 18588, 19010, 19357, 19635, 19848, 20000, 20098, 20146, 20149, 20113, 20045, 19948, 19829, 19692, 19542, 19384, 19220, 19055, 18891, 18732, 18577, 18428, 18285, 18146, 18011, 17875, 17735, 17587, 17426, 17246, 17039, 16798, 16517, 16185, 15794, 15340, 14813, 14208, 13522, 12745, 11878, 10920, 9865, 8717, 7478, 6145, 4728, 3229, 1651, 9, -1695, -3455, -5255, -7087, -8946, -10809, -12675, -14529, -16352, -18142, -19881, -21554, -23155, -24669, -26080, -27385, -28567, -29616, -30529, -31293, -31902, -32354, -32642, -32764, -32720, -32509, -32135, -31599, -30911, -30074, -29097, -27994, -26774, -25449, -24039, -22552, -21004, -19415, -17793, -16153, -14515, -12883, -11271, -9695, -8155, -6663, -5230, -3850, -2530, -1278, -86, 1041, 2103, 3107, 4053, 4942, 5783, 6575, 7323, 8035, 8712, 9359, 9982, 10581, 11164, 11731, 12284, 12827, 13363, 13889, 14407, 14919, 15422, 15917, 16401, 16871, 17327, 17764, 18177, 18565, 18922, 19244, 19526, 19762, 19946, 20074, 20142, 20145, 20080, 19943, 19734, 19448, 19088, 18652, 18139, 17554, 16897, 16170, 15380, 14528, 13619, 12661, 11655, 10609, 9529, 8417, 7284, 6137, 4978, 3817, 2665, 1523, 402, -688, -1745, -2758, -3715, -4618, -5454, -6217, -6902, -7506, -8023, -8453, -8792, -9041, -9201, -9273, -9263, -9174, -9017, -8795, -8521, -8205, -7860, -7496, -7129, -6768, -6427, -6116, -5845, -5627, -5470, -5380, -5364, -5426, -5570, -5795, -6102, -6490, -6955, -7488, -8089, -8746, -9451, -10199, -10974, -11770, -12576, -13377, -14166, -14929, -15655, -16336, -16961, -17518, -18000, -18397, -18701, -18905, -19004, -18992, -18864, -18618, -18252, -17762, -17153, -16424, -15577, -14618, -13555, -12388, -11128, -9787, -8369, -6892, -5368, -3808, -2229, -610, -526, 1041, 2557, 4045, 5491, 6888, 8227, 9496, 10694, 11816, 12854, 13811, 14683, 15468, 16170, 16789, 17325, 17786, 18172, 18490, 18743, 18937, 19075, 19166, 19214, 19225, 19203, 19155, 19085, 19000, 18903, 18798, 18689, 18582, 18478, 18378, 18286, 18201, 18124, 18054, 17989, 17925, 17859, 17788, 17705, 17604, 17478, 17319, 17119, 16868, 16560, 16188, 15742, 15219, 14612, 13914, 13123, 12240, 11256, 10175, 9000, 7726, 6364, 4915, 3381, 1776, 103, -1632, -3413, -5234, -7086, -8951, -10824, -12691, -14534, -16350, -18123, -19834, -21482, -23048, -24517, -25887, -27142, -28270, -29268, -30125, -30832, -31388, -31787, -32025, -32102, -32019, -31775, -31375, -30826, -30131, -29296, -28336, -27259, -26078, -24808, -23461, -22048, -20590, -19092, -17572, -16047, -14519, -13003, -11516, -10055, -8634, -7262, -5935, -4661, -3443, -2278, -1170, -119, 881, 1832, 2733, 3594, 4413, 5197, 5950, 6675, 7377, 8062, 8730, 9386, 10034, 10673, 11310, 11943, 12572, 13199, 13823, 14442, 15056, 15664, 16259, 16841, 17405, 17946, 18462, 18946, 19392, 19797, 20153, 20453, 20695, 20869, 20974, 21005, 20957, 20829, 20618, 20324, 19945, 19482, 18938, 18313, 17611, 16837, 15993, 15085, 14121, 13101, 12033, 10928, 9787, 8618, 7433, 6234, 5029, 3832, 2642, 1472, 333, -773, -1835, -2843, -3795, -4679, -5489, -6221, -6867, -7425, -7892, -8266, -8546, -8733, -8830, -8840, -8769, -8623, -8410, -8139, -7823, -7471, -7096, -6714, -6334, -5969, -5634, -5337, -5091, -4905, -4787, -4743, -4779, -4898, -5101, -5390, -5765, -6220, -6751, -7353, -8018, -8737, -9504, -10305, -11131, -11973, -12814, -13646, -14460, -15238, -15974, -16656, -17274, -17818, -18280, -18651, -18925, -19096, -19157, -19105, -18936, -18647, -18237, -17706, -17056, -16287, -15406, -14420, -13327, -12141, -10871, -9521, -8108, -6644, -5140, -3611, -2036};