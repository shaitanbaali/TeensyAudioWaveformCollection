/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0190 512 samples */
 
const int16_t AKWF_stereo_0190_512_DATA [512] = 
{2314, 7737, 12913, 17762, 22061, 25672, 28530, 30607, 31960, 32648, 32736, 32354, 31605, 30569, 29343, 28043, 26715, 25377, 24112, 22939, 21838, 20860, 20032, 19335, 18769, 18380, 18136, 17994, 17950, 17963, 17946, 17832, 17588, 17129, 16394, 15395, 14126, 12593, 10866, 9049, 7192, 5389, 3757, 2334, 1144, 201, -527, -1114, -1619, -2128, -2724, -3458, -4362, -5442, -6658, -7964, -9282, -10523, -11619, -12514, -13171, -13588, -13814, -13906, -13938, -14018, -14248, -14691, -15387, -16371, -17606, -19002, -20488, -21954, -23254, -24287, -24988, -25276, -25103, -24513, -23536, -22208, -20632, -18933, -17161, -15435, -13846, -12413, -11154, -10106, -9233, -8491, -7866, -7329, -6837, -6373, -5946, -5533, -5119, -4715, -4310, -3876, -3401, -2880, -2288, -1623, -917, -200, 476, 1028, 1371, 1421, 1100, 346, -857, -2488, -4481, -6721, -9034, -11233, -13116, -14489, -15186, -15096, -14146, -12310, -9655, -6314, -2458, 1662, 5803, 9732, 13216, 16096, 18281, 19715, 20414, 20434, 19849, 18759, 17302, 15591, 13722, 11831, 9999, 8266, 6700, 5344, 4201, 3283, 2622, 2213, 2054, 2156, 2506, 3067, 3802, 4667, 5581, 6466, 7260, 7888, 8298, 8466, 8399, 8114, 7673, 7160, 6653, 6237, 5997, 5976, 6193, 6644, 7293, 8061, 8859, 9610, 10226, 10630, 10802, 10735, 10441, 9980, 9439, 8885, 8388, 8023, 7816, 7752, 7801, 7901, 7951, 7842, 7494, 6819, 5761, 4313, 2506, 414, -1856, -4169, -6385, -8382, -10049, -11314, -12145, -12554, -12587, -12308, -11815, -11217, -10603, -10060, -9667, -9454, -9427, -9586, -9910, -10344, -10847, -11396, -11943, -12455, -12935, -13367, -13725, -14010, -14218, -14322, -14289, -14123, -13805, -13316, -12692, -11975, -11209, -10468, -9867, -9485, -9393, -9668, -10333, -11342, -12650, -14131, -15606, -16899, -17826, -18188, -17807, -16591, -14456, -11374, -7442, -2701, -1326, 3884, 9012, 13980, 18553, 22564, 25914, 28534, 30459, 31740, 32448, 32723, 32689, 32439, 32072, 31694, 31325, 30964, 30624, 30260, 29787, 29196, 28473, 27558, 26439, 25180, 23780, 22247, 20658, 19036, 17376, 15674, 13952, 12164, 10251, 8217, 6047, 3718, 1265, -1235, -3748, -6186, -8440, -10452, -12156, -13508, -14515, -15198, -15612, -15842, -15967, -16068, -16233, -16507, -16887, -17393, -17980, -18564, -19082, -19480, -19685, -19642, -19384, -18929, -18311, -17633, -16996, -16471, -16121, -16027, -16179, -16522, -17016, -17565, -18030, -18298, -18289, -17907, -17090, -15878, -14310, -12444, -10409, -8362, -6399, -4653, -3223, -2134, -1398, -1003, -872, -913, -1040, -1158, -1183, -1058, -756, -272, 378, 1152, 2002, 2881, 3744, 4548, 5278, 5907, 6428, 6825, 7080, 7173, 7068, 6718, 6083, 5126, 3823, 2173, 208, -1995, -4336, -6671, -8824, -10623, -11909, -12543, -12433, -11525, -9846, -7481, -4554, -1278, 2127, 5456, 8486, 11046, 13021, 14338, 14998, 15052, 14584, 13712, 12584, 11324, 10036, 8831, 7759, 6824, 6027, 5347, 4721, 4104, 3476, 2800, 2072, 1317, 554, -180, -850, -1426, -1904, -2291, -2605, -2886, -3175, -3508, -3914, -4398, -4948, -5520, -6053, -6468, -6698, -6667, -6316, -5627, -4604, -3280, -1730, -45, 1671, 3318, 4817, 6104, 7154, 7974, 8602, 9095, 9523, 9963, 10473, 11078, 11779, 12553, 13328, 14010, 14520, 14763, 14648, 14154, 13277, 12041, 10525, 8857, 7152, 5528, 4128, 3031, 2272, 1874, 1785, 1914, 2155, 2388, 2478, 2315, 1832, 979, -239, -1769, -3539, -5442, -7366, -9208, -10872, -12289, -13429, -14281, -14855, -15189, -15335, -15333, -15214, -15032, -14804, -14533, -14240, -13946, -13653, -13380, -13191, -13117, -13190, -13474, -13997, -14735, -15684, -16773, -17875, -18859, -19586, -19874, -19548, -18511, -16660, -13936, -10398, -6033};