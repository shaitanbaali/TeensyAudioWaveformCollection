/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0025 512 samples */
 
const int16_t AKWF_stereo_0025_512_DATA [512] = 
{179, 719, 1235, 1737, 2235, 2802, 3434, 4071, 4739, 5411, 6030, 6606, 7283, 8029, 8681, 9168, 9532, 9864, 10216, 10619, 11056, 11540, 12059, 12585, 13148, 13804, 14493, 15117, 15650, 16094, 16498, 16914, 17278, 17517, 17949, 18946, 19856, 20689, 21467, 22181, 22852, 23536, 24275, 25093, 25946, 26795, 27616, 28400, 29161, 29879, 30429, 30800, 31127, 31481, 31863, 32226, 32505, 32664, 32697, 32654, 32569, 32466, 32291, 32062, 31868, 31731, 31624, 31519, 31387, 31285, 31238, 31180, 30967, 30589, 30124, 29614, 29075, 28619, 28320, 28179, 28127, 28076, 28003, 27830, 27561, 27163, 26648, 26103, 25563, 25023, 24453, 23857, 23256, 22649, 22065, 21541, 21093, 20686, 20271, 19847, 19386, 18840, 18172, 17394, 16624, 15852, 15061, 14207, 13285, 12357, 11443, 10560, 9661, 8683, 7707, 6868, 6134, 5486, 4982, 4459, 3830, 3218, 2668, 2171, 1683, 1210, 762, 278, -242, -772, -1289, -1792, -2290, -2857, -3489, -4126, -4793, -5466, -6084, -6660, -7337, -8082, -8735, -9220, -9585, -9916, -10269, -10673, -11108, -11592, -12112, -12637, -13200, -13856, -14547, -15170, -15702, -16147, -16551, -16967, -17330, -17570, -18001, -18998, -19909, -20741, -21518, -22233, -22904, -23586, -24325, -25143, -25998, -26845, -27666, -28450, -29212, -29929, -30479, -30851, -31178, -31531, -31912, -32276, -32555, -32713, -32767, -32727, -32642, -32540, -32364, -32135, -31942, -31806, -31699, -31594, -31463, -31360, -31313, -31256, -31043, -30665, -30200, -29693, -29152, -28696, -28398, -28257, -28203, -28153, -28081, -27908, -27634, -27239, -26724, -26180, -25640, -25099, -24528, -23932, -23332, -22725, -22140, -21617, -21167, -20761, -20347, -19923, -19460, -18914, -18245, -17469, -16697, -15925, -15133, -14280, -13359, -12430, -11516, -10632, -9733, -8756, -7778, -6938, -6205, -5555, -5051, -4527, -3897, -3285, -2734, -2236, -1748, -1275, -828, -334, 14311, 15700, 17049, 18165, 18885, 19646, 20904, 22453, 23898, 24974, 25643, 26117, 26630, 27309, 28003, 28627, 29271, 29751, 29885, 29902, 29883, 29750, 29758, 30184, 30918, 31727, 32389, 32732, 32742, 32628, 32434, 32126, 31724, 31468, 31288, 31166, 31149, 30877, 30509, 30478, 30828, 31411, 31745, 31655, 31151, 30401, 29526, 28719, 28225, 27796, 27304, 26331, 24933, 23497, 22082, 20595, 19200, 17605, 15522, 13535, 12018, 10777, 9677, 8588, 7348, 5965, 4551, 3075, 1383, -723, -3333, -6495, -9928, -13087, -15833, -18246, -20539, -22937, -25490, -28232, -29792, -30436, -30836, -30964, -30783, -30594, -30291, -30028, -29814, -29660, -29690, -29768, -29607, -29113, -28673, -28479, -28216, -27766, -27396, -27045, -26564, -25545, -23845, -21800, -19725, -17716, -15991, -14549, -13061, -11740, -10610, -9531, -8665, -8189, -8190, -8638, -9266, -9786, -10021, -9888, -9407, -8734, -8087, -8077, -8880, -10217, -11641, -12927, -14270, -15634, -16987, -18104, -18826, -19587, -20843, -22392, -23839, -24913, -25585, -26056, -26570, -27249, -27943, -28568, -29214, -29690, -29827, -29841, -29823, -29690, -29699, -30126, -30861, -31668, -32330, -32674, -32686, -32569, -32375, -32069, -31667, -31411, -31231, -31110, -31093, -30820, -30455, -30423, -30770, -31354, -31688, -31600, -31096, -30345, -29469, -28664, -28169, -27741, -27249, -26278, -24880, -23445, -22030, -20546, -19149, -17558, -15495, -13514, -11994, -10751, -9652, -8560, -7318, -5940, -4523, -3045, -1354, 751, 3362, 6524, 9957, 13118, 15863, 18276, 20571, 22971, 25523, 28267, 29828, 30476, 30869, 31007, 30914, 30628, 30339, 30077, 29864, 29712, 29742, 29820, 29662, 29170, 28727, 28534, 28274, 27825, 27453, 27104, 26625, 25606, 23907, 21862, 19787, 17779, 16053, 14612, 13125, 11802, 10670, 9592, 8726, 8248, 8251, 8698, 9323, 9842, 10078, 9945, 9464, 8791, 8143, 8133, 8935, 10267, 11688, 12999};