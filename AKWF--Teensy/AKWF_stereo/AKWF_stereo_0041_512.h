/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0041 512 samples */
 
const int16_t AKWF_stereo_0041_512_DATA [512] = 
{1004, 2554, 3977, 5301, 6510, 7602, 8572, 9413, 10130, 10724, 11197, 11558, 11815, 11978, 12057, 12066, 12020, 11933, 11819, 11694, 11573, 11469, 11399, 11375, 11406, 11505, 11680, 11938, 12284, 12722, 13251, 13872, 14583, 15376, 16245, 17187, 18186, 19235, 20322, 21429, 22550, 23670, 24770, 25842, 26873, 27844, 28752, 29582, 30324, 30974, 31523, 31965, 32301, 32528, 32645, 32655, 32560, 32369, 32084, 31714, 31269, 30755, 30184, 29567, 28912, 28233, 27537, 26835, 26139, 25455, 24792, 24157, 23556, 22994, 22476, 22004, 21579, 21202, 20871, 20587, 20345, 20143, 19974, 19838, 19727, 19635, 19558, 19490, 19424, 19356, 19281, 19194, 19090, 18967, 18820, 18647, 18447, 18220, 17963, 17676, 17363, 17020, 16651, 16259, 15845, 15410, 14956, 14488, 14004, 13511, 13006, 12492, 11972, 11444, 10911, 10373, 9828, 9278, 8721, 8156, 7584, 7002, 6410, 5807, 5194, 4566, 3926, 3276, 2611, 1937, 1254, 562, -133, -832, -1531, -2225, -2911, -3586, -4243, -4879, -5493, -6074, -6625, -7139, -7612, -8045, -8434, -8778, -9080, -9337, -9551, -9727, -9866, -9974, -10056, -10119, -10168, -10210, -10255, -10310, -10383, -10483, -10617, -10794, -11019, -11301, -11645, -12056, -12536, -13089, -13713, -14412, -15181, -16016, -16916, -17872, -18873, -19917, -20991, -22082, -23182, -24277, -25351, -26399, -27402, -28348, -29229, -30030, -30742, -31358, -31868, -32268, -32553, -32719, -32767, -32700, -32517, -32227, -31833, -31347, -30777, -30133, -29432, -28683, -27902, -27106, -26305, -25516, -24754, -24031, -23359, -22754, -22220, -21769, -21407, -21138, -20964, -20888, -20906, -21015, -21209, -21480, -21817, -22211, -22648, -23114, -23593, -24071, -24530, -24954, -25328, -25635, -25861, -25992, -26014, -25919, -25696, -25339, -24842, -24203, -23423, -22501, -21442, -20258, -18948, -17529, -16014, -14413, -12743, -11025, -9266, -7492, -5721, -3965, -2250, -555, 1436, 2898, 4218, 5420, 6495, 7436, 8243, 8911, 9446, 9854, 10141, 10320, 10402, 10400, 10333, 10214, 10063, 9898, 9737, 9596, 9494, 9446, 9467, 9568, 9761, 10054, 10454, 10962, 11580, 12309, 13140, 14069, 15088, 16181, 17340, 18551, 19793, 21051, 22311, 23551, 24755, 25908, 26989, 27988, 28888, 29678, 30350, 30896, 31308, 31586, 31730, 31739, 31620, 31379, 31025, 30568, 30022, 29399, 28714, 27985, 27226, 26452, 25681, 24929, 24207, 23532, 22912, 22358, 21880, 21483, 21170, 20944, 20802, 20744, 20764, 20855, 21010, 21216, 21465, 21744, 22036, 22333, 22617, 22876, 23099, 23272, 23382, 23424, 23385, 23263, 23049, 22743, 22346, 21855, 21277, 20618, 19880, 19077, 18217, 17309, 16371, 15411, 14441, 13480, 12535, 11620, 10750, 9929, 9171, 8483, 7868, 7331, 6876, 6500, 6205, 5984, 5830, 5740, 5703, 5709, 5747, 5804, 5869, 5929, 5970, 5982, 5951, 5867, 5721, 5504, 5210, 4834, 4375, 3830, 3198, 2487, 1698, 838, -80, -1052, -2065, -3104, -4160, -5218, -6261, -7283, -8266, -9197, -10069, -10870, -11589, -12225, -12768, -13219, -13575, -13840, -14015, -14109, -14127, -14078, -13975, -13830, -13655, -13465, -13274, -13099, -12951, -12847, -12798, -12818, -12916, -13102, -13382, -13762, -14245, -14830, -15515, -16297, -17169, -18121, -19145, -20227, -21349, -22503, -23667, -24824, -25962, -27058, -28096, -29065, -29943, -30720, -31385, -31927, -32339, -32615, -32752, -32750, -32612, -32343, -31949, -31439, -30828, -30126, -29349, -28515, -27639, -26740, -25839, -24948, -24088, -23277, -22525, -21849, -21261, -20768, -20379, -20099, -19928, -19867, -19911, -20056, -20292, -20608, -20994, -21430, -21903, -22396, -22889, -23364, -23803, -24184, -24493, -24712, -24824, -24816, -24678, -24400, -23974, -23397, -22671, -21791, -20764, -19602, -18306, -16893, -15381, -13775, -12102, -10380, -8623, -6857, -5101, -3373, -1696, -57};