/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0199 512 samples */
 
const int16_t AKWF_stereo_0199_512_DATA [512] = 
{1921, 8177, 13530, 17986, 21441, 23921, 25454, 26084, 25890, 24906, 23277, 21242, 19022, 16853, 14982, 13509, 12511, 12088, 12262, 12990, 14223, 15864, 17624, 19336, 20901, 22185, 23046, 23410, 23272, 22616, 21487, 19982, 18205, 16315, 14478, 12794, 11321, 10108, 9212, 8743, 8734, 9162, 9975, 10847, 11559, 12029, 12147, 11860, 11229, 10320, 9156, 7759, 6084, 4191, 2339, 697, -631, -1571, -2095, -2228, -1994, -1427, -597, 426, 1492, 2388, 3018, 3295, 3154, 2588, 1637, 358, -1191, -2926, -4722, -6352, -7618, -8456, -8877, -8852, -8346, -7297, -5713, -3666, -1205, 1526, 4080, 6317, 8108, 9380, 10201, 10656, 10782, 10613, 10174, 9547, 8888, 8364, 8096, 8165, 8601, 9384, 10443, 11640, 12834, 13946, 14889, 15432, 15402, 14719, 13316, 11170, 8403, 5132, 1444, -2442, -6268, -9791, -12702, -14825, -16061, -16326, -15596, -13902, -11271, -7757, -3512, 1329, 6339, 10888, 14759, 17784, 19866, 20975, 21085, 20298, 18680, 16287, 13217, 9738, 6119, 2608, -516, -3111, -5098, -6408, -7017, -6959, -6285, -5116, -3730, -2289, -931, 201, 975, 1290, 1116, 473, -574, -1960, -3544, -5128, -6574, -7790, -8691, -9243, -9424, -9105, -8239, -6894, -5104, -3225, -1519, -94, 957, 1580, 1802, 1716, 1348, 689, -300, -1530, -2761, -3835, -4635, -5091, -5193, -4959, -4416, -3603, -2601, -1475, -377, 461, 955, 1021, 592, -337, -1722, -3506, -5624, -7984, -10447, -12785, -14795, -16410, -17645, -18488, -18886, -18789, -18215, -17216, -15836, -14226, -12761, -11589, -10845, -10611, -10797, -11297, -12096, -13141, -14371, -15730, -17060, -18156, -18910, -19266, -19171, -18623, -17735, -16627, -15408, -14187, -13073, -12267, -11956, -12261, -13221, -14814, -16952, -19491, -22274, -25140, -27858, -30180, -31829, -32687, -32639, -31580, -29495, -26398, -22264, -17149, -11248, -4577, -2227, 2902, 7508, 11613, 15111, 17965, 20141, 21619, 22418, 22560, 22159, 21373, 20320, 19125, 17941, 16798, 15745, 14893, 14305, 14016, 14029, 14316, 14737, 15224, 15763, 16297, 16722, 16964, 17021, 16851, 16439, 15858, 15162, 14416, 13681, 12995, 12363, 11813, 11385, 11145, 11135, 11350, 11749, 12136, 12408, 12547, 12498, 12225, 11757, 11124, 10319, 9340, 8150, 6790, 5425, 4126, 2911, 1793, 798, -78, -835, -1430, -1840, -2083, -2212, -2304, -2378, -2449, -2523, -2601, -2669, -2722, -2775, -2809, -2778, -2581, -2152, -1535, -807, -17, 839, 1769, 2739, 3717, 4661, 5493, 5964, 6046, 5717, 5001, 3984, 2763, 1397, -74, -1584, -3013, -4233, -5128, -5659, -5812, -5602, -5045, -4222, -3245, -2188, -1117, -128, 629, 1025, 1008, 552, -356, -1669, -3287, -5151, -7167, -9150, -10919, -12272, -13103, -13336, -12907, -11797, -10014, -7577, -4514, -932, 3066, 7219, 11092, 14549, 17484, 19821, 21486, 22402, 22626, 22167, 21069, 19404, 17336, 14996, 12514, 10050, 7670, 5447, 3461, 1803, 522, -391, -968, -1337, -1566, -1687, -1753, -1857, -2086, -2452, -2980, -3669, -4473, -5321, -6121, -6830, -7420, -7858, -8116, -8190, -7995, -7470, -6651, -5569, -4437, -3389, -2461, -1689, -1104, -720, -485, -399, -503, -824, -1309, -1814, -2268, -2648, -2948, -3160, -3285, -3321, -3231, -3001, -2649, -2229, -1833, -1475, -1170, -929, -753, -627, -550, -533, -566, -598, -526, -285, 79, 483, 879, 1274, 1675, 2056, 2385, 2610, 2652, 2304, 1526, 311, -1324, -3286, -5452, -7753, -10151, -12562, -14862, -16921, -18608, -19885, -20759, -21230, -21305, -21080, -20664, -20110, -19487, -18902, -18490, -18359, -18594, -19208, -20184, -21494, -23042, -24728, -26485, -28136, -29484, -30342, -30632, -30263, -29152, -27302, -24716, -21377, -17325, -12670, -7405};