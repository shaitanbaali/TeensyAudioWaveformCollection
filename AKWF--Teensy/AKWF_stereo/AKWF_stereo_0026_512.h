/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0026 512 samples */
 
const int16_t AKWF_stereo_0026_512_DATA [512] = 
{991, 3876, 6846, 9723, 12355, 14686, 16620, 18092, 19272, 20270, 20983, 21546, 22603, 24218, 25784, 26796, 27077, 26717, 25824, 24644, 23664, 23296, 23395, 23613, 24085, 24800, 25559, 25983, 25775, 25208, 24661, 24078, 22858, 19886, 15962, 12111, 8601, 5413, 2219, -1231, -4828, -8678, -12674, -16792, -20733, -24276, -27439, -29807, -31083, -31595, -31807, -32075, -32483, -32765, -32479, -31373, -29579, -27509, -25533, -23684, -21823, -19934, -18071, -16238, -14231, -12176, -10240, -8312, -6389, -4649, -3377, -2586, -2134, -1933, -1774, -1062, 841, 3627, 7064, 10509, 13369, 15852, 18174, 20118, 21679, 22903, 23791, 24357, 24631, 24771, 24733, 24131, 22735, 20593, 17960, 15264, 12616, 9713, 6844, 4574, 2931, 1448, 527, 51, -664, -2335, -4473, -6439, -7993, -8919, -9078, -8319, -6957, -5625, -4762, -4427, -4672, -5127, -5270, -5090, -4357, -3254, -2101, -808, 833, 2361, 3380, 4464, 5664, 7132, 8774, 10567, 12686, 15195, 18059, 20862, 22833, 23845, 24259, 24330, 23941, 22885, 21277, 19586, 18334, 17751, 17545, 17431, 17361, 17343, 17340, 17254, 16976, 16405, 15474, 14052, 12290, 10896, 9882, 9322, 9064, 8475, 7145, 5237, 2876, -91, -3678, -7290, -10661, -13611, -15978, -17957, -19841, -21681, -23523, -25180, -26322, -27106, -27623, -27960, -28177, -28193, -27818, -26942, -25751, -24287, -22597, -20709, -18662, -16369, -13643, -10708, -8137, -6203, -4737, -3363, -1693, 272, 2077, 3563, 4739, 5689, 6220, 6348, 6485, 6737, 7081, 7669, 8497, 9296, 10153, 11099, 11825, 12050, 11530, 10256, 8747, 6838, 3969, 262, -2821, -5079, -7072, -8953, -10881, -12960, -15256, -17669, -19886, -21607, -22782, -23359, -23502, -23434, -23259, -23124, -23254, -23513, -23594, -23382, -22592, -21087, -19337, -17755, -16424, -15438, -14822, -14395, -14207, -14271, -13249, -10212, -7036, -5113, -3521, -1425, 31024, 30878, 30216, 28777, 26514, 23850, 21517, 20408, 20638, 20859, 19797, 17077, 13280, 9547, 6466, 4475, 3643, 2519, 228, -2590, -5672, -9464, -13517, -16830, -19515, -21612, -22822, -23247, -23053, -22161, -20549, -18575, -16780, -15265, -14083, -13429, -13160, -12912, -12884, -13338, -13652, -12937, -11568, -9818, -8231, -6998, -5587, -3570, -864, 2672, 6882, 11562, 16553, 20961, 23421, 23424, 22001, 20212, 18190, 15861, 13861, 12897, 13094, 13631, 13843, 13719, 13376, 13088, 13152, 13677, 14795, 16583, 18389, 19306, 19135, 18272, 17736, 18104, 19261, 20499, 21026, 20290, 17909, 13673, 8010, 2206, -2577, -6177, -8510, -9618, -9993, -10355, -10992, -11718, -12012, -11640, -10930, -10501, -10873, -12070, -13729, -15522, -17261, -19058, -20202, -20147, -19599, -19387, -19750, -20607, -22042, -23916, -25282, -25119, -23714, -21495, -19124, -17524, -17304, -18200, -19460, -20333, -20426, -19950, -19278, -18562, -18014, -17591, -16761, -15260, -13209, -10966, -8333, -5148, -1785, 1768, 5156, 8013, 9758, 11142, 12385, 13276, 14008, 14702, 15388, 16132, 16868, 17072, 16661, 16016, 15386, 15158, 15568, 16062, 16004, 15589, 15746, 17503, 20849, 24593, 27655, 29400, 29700, 28605, 26389, 23794, 21267, 18683, 15053, 10338, 6799, 4800, 3855, 4021, 4976, 6498, 8142, 9496, 10366, 10745, 10514, 9534, 7936, 5733, 2908, 525, -369, -169, 30, -890, -3206, -6079, -8900, -11475, -13535, -15018, -16221, -16886, -16657, -15873, -14779, -13696, -13119, -13136, -13428, -13840, -14318, -14425, -15345, -17427, -20316, -23276, -25588, -27365, -28660, -29536, -30157, -30637, -31017, -31629, -32545, -32645, -31104, -28349, -25283, -22660, -20746, -18964, -16779, -14196, -11870, -10329, -9289, -8223, -6894, -4922, -2425, 355, 3649, 7430, 11380, 15331, 18890, 21609, 23760, 25593, 26840, 27345, 27676, 27867, 27817, 28067, 28758, 29506, 30069, 30676};