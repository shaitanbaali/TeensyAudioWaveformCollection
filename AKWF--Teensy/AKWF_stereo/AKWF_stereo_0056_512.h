/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0056 512 samples */
 
const int16_t AKWF_stereo_0056_512_DATA [512] = 
{81, 200, 316, 430, 543, 653, 762, 870, 977, 1081, 1184, 1286, 1387, 1485, 1582, 1678, 1770, 1863, 1955, 2043, 2132, 2219, 2303, 2387, 2470, 2550, 2629, 2707, 2785, 2860, 2933, 3006, 3076, 3148, 3216, 3284, 3349, 3413, 3478, 3539, 3601, 3661, 3720, 3777, 3833, 3888, 3942, 3995, 4046, 4097, 4146, 4194, 4242, 4288, 4334, 4377, 4420, 4462, 4503, 4543, 4582, 4620, 4656, 4693, 4728, 4761, 4795, 4827, 4858, 4890, 4919, 4948, 4975, 5002, 5029, 5054, 5078, 5102, 5124, 5145, 5167, 5188, 5207, 5226, 5244, 5262, 5279, 5296, 5310, 5324, 5338, 5351, 5364, 5376, 5388, 5399, 5408, 5417, 5426, 5434, 5441, 5448, 5454, 5459, 5465, 5469, 5473, 5478, 5480, 5482, 5484, 5485, 5487, 5487, 5487, 5485, 5485, 5483, 5480, 5477, 5474, 5471, 5467, 5464, 5458, 5453, 5448, 5440, 5434, 5428, 5421, 5409, 5714, 3829, 12332, 28568, 13681, 5325, 1532, 172, -105, 33, 263, 438, 508, 459, 300, 48, -277, -662, -1089, -1547, -2024, -2511, -3003, -3492, -3974, -4446, -4901, -5343, -5765, -6167, -6549, -6909, -7247, -7563, -7857, -8129, -8379, -8607, -8813, -8999, -9166, -9312, -9441, -9551, -9643, -9719, -9779, -9823, -9853, -9868, -9870, -9860, -9838, -9805, -9761, -9707, -9644, -9570, -9490, -9402, -9306, -9203, -9094, -8977, -8856, -8732, -8601, -8466, -8327, -8185, -8040, -7891, -7740, -7586, -7429, -7272, -7112, -6950, -6789, -6626, -6462, -6297, -6132, -5965, -5800, -5634, -5467, -5302, -5137, -4971, -4806, -4643, -4479, -4318, -4155, -3994, -3835, -3676, -3518, -3361, -3207, -3053, -2900, -2747, -2599, -2450, -2303, -2156, -2013, -1870, -1729, -1588, -1451, -1314, -1179, -1046, -913, -784, -655, -527, -402, -279, -157, -35, 196, 313, 428, 540, 650, 759, 866, 971, 1076, 1180, 1280, 1380, 1478, 1574, 1669, 1762, 1853, 1945, 2034, 2120, 2206, 2291, 2374, 2456, 2537, 2616, 2694, 2770, 2845, 2918, 2991, 3062, 3131, 3200, 3267, 3333, 3397, 3462, 3523, 3583, 3643, 3702, 3761, 3817, 3871, 3925, 3978, 4030, 4081, 4129, 4178, 4226, 4272, 4318, 4362, 4405, 4448, 4489, 4529, 4568, 4605, 4643, 4680, 4715, 4750, 4784, 4817, 4848, 4879, 4909, 4938, 4966, 4993, 5020, 5045, 5071, 5095, 5118, 5141, 5163, 5184, 5204, 5223, 5242, 5260, 5277, 5293, 5309, 5325, 5339, 5353, 5365, 5378, 5390, 5402, 5412, 5421, 5431, 5439, 5447, 5455, 5462, 5467, 5473, 5478, 5483, 5487, 5490, 5493, 5495, 5497, 5498, 5499, 5501, 5499, 5498, 5497, 5496, 5494, 5491, 5487, 5484, 5480, 5476, 5472, 5467, 5461, 5454, 5448, 5441, 5433, 5423, 5599, 4515, 8648, 20066, 14732, 12370, 10724, 9628, 8728, 7886, 7033, 6149, 5235, 4294, 3340, 2385, 1433, 498, -413, -1299, -2151, -2967, -3747, -4485, -5183, -5839, -6452, -7024, -7556, -8047, -8498, -8912, -9288, -9628, -9934, -10207, -10449, -10662, -10843, -10999, -11129, -11235, -11317, -11377, -11417, -11438, -11442, -11428, -11398, -11354, -11297, -11225, -11142, -11050, -10947, -10833, -10712, -10582, -10447, -10303, -10155, -10001, -9842, -9679, -9511, -9340, -9166, -8990, -8810, -8629, -8447, -8263, -8078, -7892, -7706, -7519, -7333, -7144, -6958, -6771, -6585, -6400, -6214, -6029, -5847, -5664, -5483, -5303, -5125, -4948, -4772, -4598, -4424, -4254, -4084, -3915, -3749, -3584, -3421, -3260, -3100, -2942, -2786, -2632, -2478, -2328, -2179, -2032, -1887, -1743, -1601, -1461, -1322, -1186, -1051, -919, -787, -658, -531, -404, -281, -158, -38, 81};