/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0200 512 samples */
 
const int16_t AKWF_stereo_0200_512_DATA [512] = 
{472, 1189, 1891, 2606, 3332, 4071, 4826, 5589, 6360, 7142, 7931, 8748, 9594, 10471, 11392, 12351, 13343, 14373, 15438, 16516, 17608, 18705, 19791, 20834, 21836, 22808, 23677, 24438, 25108, 25628, 26158, 26684, 27063, 27349, 27580, 27765, 27890, 27975, 28081, 28191, 28291, 28426, 28593, 28754, 28946, 29201, 29459, 29739, 30051, 30355, 30632, 30915, 31168, 31345, 31469, 31544, 31398, 31126, 30867, 30560, 30174, 29589, 28843, 27969, 26966, 25888, 24710, 23428, 22100, 20714, 19259, 17790, 16316, 14832, 13348, 11921, 10567, 9293, 8079, 6925, 5807, 4734, 3698, 2658, 1632, 645, -281, -1176, -2058, -2901, -3723, -4527, -5308, -6092, -6872, -7608, -8310, -8961, -9565, -10150, -10702, -11218, -11720, -12209, -12660, -13072, -13451, -13793, -14100, -14393, -14660, -14896, -15115, -15322, -15516, -15725, -15952, -16181, -16401, -16638, -16871, -17080, -17291, -17513, -17730, -17965, -18232, -18506, -18781, -19082, -19380, -19633, -19851, -20048, -20196, -20313, -20397, -20411, -20339, -20212, -20006, -19685, -19273, -18779, -18183, -17490, -16739, -15910, -14987, -14036, -13067, -12068, -11081, -10136, -9247, -8416, -7687, -7143, -6578, -6058, -5727, -5488, -5354, -5339, -5434, -5617, -5855, -6132, -6419, -6700, -6974, -7199, -7361, -7464, -7512, -7501, -7455, -7377, -7265, -7117, -6952, -6778, -6607, -6459, -6363, -6327, -6367, -6478, -6631, -6817, -7033, -7267, -7518, -7782, -8043, -8291, -8523, -8745, -8929, -9077, -9209, -9307, -9367, -9393, -9384, -9324, -9219, -9086, -8916, -8704, -8499, -8324, -8163, -8005, -7874, -7756, -7666, -7633, -7640, -7685, -7790, -7964, -8176, -8402, -8635, -8855, -9064, -9302, -9545, -9779, -10019, -10254, -10457, -10610, -10716, -10766, -10748, -10683, -10564, -10365, -10093, -9750, -9323, -8830, -8297, -7715, -7081, -6409, -5699, -4952, -4162, -3363, -2556, -1755, -991, -231, -7871, -7217, -6543, -5837, -5118, -4385, -3636, -2871, -2097, -1303, -496, 314, 1157, 2059, 3024, 4046, 5134, 6286, 7500, 8784, 10135, 11523, 12943, 14395, 15853, 17292, 18656, 19927, 21123, 22200, 23307, 24394, 25313, 26119, 26834, 27452, 27971, 28426, 28841, 29206, 29507, 29785, 30047, 30267, 30481, 30735, 30975, 31211, 31471, 31720, 31941, 32179, 32396, 32554, 32677, 32763, 32625, 32366, 32137, 31900, 31620, 31143, 30509, 29746, 28873, 27933, 26893, 25740, 24537, 23268, 21912, 20528, 19133, 17711, 16272, 14872, 13514, 12210, 10969, 9774, 8600, 7462, 6357, 5253, 4156, 3090, 2079, 1099, 130, -791, -1684, -2567, -3430, -4291, -5156, -6000, -6819, -7607, -8371, -9136, -9905, -10674, -11466, -12273, -13079, -13885, -14689, -15493, -16291, -17095, -17892, -18663, -19421, -20147, -20824, -21474, -22103, -22669, -23154, -23596, -23971, -24257, -24485, -24654, -24748, -24804, -24838, -24826, -24766, -24707, -24627, -24494, -24327, -24145, -23913, -23661, -23407, -23109, -22758, -22389, -21973, -21465, -20894, -20262, -19521, -18677, -17772, -16777, -15673, -14532, -13350, -12102, -10838, -9589, -8348, -7122, -5984, -5003, -3994, -3032, -2259, -1587, -1012, -566, -249, -35, 81, 114, 95, 39, -45, -117, -170, -191, -184, -156, -101, -6, 130, 291, 463, 636, 799, 942, 1049, 1104, 1087, 1014, 888, 713, 508, 266, -10, -321, -660, -1021, -1398, -1781, -2160, -2524, -2873, -3218, -3550, -3857, -4138, -4366, -4547, -4697, -4811, -4883, -4934, -4982, -5017, -5031, -5031, -5006, -4985, -4974, -4970, -4977, -5016, -5101, -5216, -5350, -5481, -5620, -5781, -5983, -6219, -6487, -6807, -7185, -7605, -8040, -8481, -8920, -9364, -9824, -10276, -10688, -11051, -11366, -11613, -11795, -11935, -11995, -11967, -11877, -11713, -11460, -11114, -10684, -10194, -9654, -9091, -8487};