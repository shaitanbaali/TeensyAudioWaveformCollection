/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0019 512 samples */
 
const int16_t AKWF_stereo_0019_512_DATA [512] = 
{1005, 3197, 7878, 11855, 13431, 14859, 15651, 15942, 16136, 16103, 16157, 16180, 16295, 16599, 17099, 17716, 18319, 19104, 19981, 20907, 21872, 22821, 23757, 24637, 25470, 26248, 26986, 27696, 28378, 28936, 29559, 30166, 30736, 31266, 31756, 32204, 32629, 32783, 32763, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32766, 32770, 32592, 32296, 32002, 31704, 31242, 30870, 30547, 30205, 29853, 29494, 29126, 28748, 28366, 27974, 27573, 27168, 26728, 26214, 25775, 25339, 24891, 24436, 23973, 23503, 23024, 22537, 22040, 21537, 21028, 20466, 19823, 19287, 18730, 18166, 17587, 16994, 16387, 15764, 15122, 14461, 13778, 13079, 12299, 11479, 10698, 9873, 9004, 8087, 7121, 6082, 4965, 3744, 2406, 891, -904, -2931, -7137, -11831, -13572, -15050, -15998, -16448, -16959, -17233, -17554, -17911, -18265, -18778, -19098, -19579, -20148, -20740, -21365, -22010, -22690, -23390, -24121, -24862, -25610, -26353, -27076, -27673, -28329, -28969, -29576, -30148, -30690, -31207, -31702, -32198, -32650, -32781, -32763, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32771, -32597, -32292, -32002, -31640, -31171, -30847, -30502, -30150, -29788, -29416, -29036, -28646, -28247, -27839, -27420, -27008, -26491, -25938, -25501, -25038, -24566, -24086, -23598, -23101, -22593, -22075, -21548, -21009, -20467, -19811, -19181, -18609, -18012, -17400, -16772, -16127, -15467, -14786, -14082, -13355, -12606, -11799, -10924, -10131, -9229, -8291, -7289, -6221, -5083, -3834, -2465, -867, 4652, 6389, 10698, 13143, 13011, 14858, 16461, 17295, 18180, 18534, 19058, 19372, 19711, 20157, 20588, 21033, 21357, 21881, 22416, 22967, 23550, 24105, 24686, 25224, 25759, 26268, 26758, 27242, 27699, 28039, 28453, 28865, 29256, 29622, 29968, 30287, 30584, 30857, 31106, 31330, 31559, 31735, 31743, 31935, 32108, 32271, 32421, 32578, 32707, 32768, 32767, 32767, 32767, 32768, 32763, 32729, 32681, 32615, 32532, 32433, 32319, 32188, 32040, 31879, 31701, 31504, 31315, 30962, 30630, 30396, 30128, 29849, 29558, 29254, 28939, 28610, 28269, 27919, 27556, 27190, 26648, 26203, 25813, 25400, 24979, 24551, 24115, 23669, 23219, 22761, 22293, 21825, 21317, 20738, 20243, 19754, 19254, 18750, 18244, 17729, 17211, 16688, 16159, 15628, 15093, 14510, 13847, 13299, 12738, 12174, 11599, 11018, 10428, 9831, 9218, 8597, 7962, 7317, 6601, 5853, 5158, 4431, 3673, 2881, 2060, 1180, 247, -760, -1850, -3078, -4533, -6098, -9947, -13335, -12943, -14507, -16428, -17414, -18594, -19113, -19745, -20364, -20850, -21494, -21782, -22235, -22674, -23107, -23538, -23935, -24363, -24763, -25191, -25602, -26017, -26434, -26834, -27124, -27492, -27867, -28224, -28565, -28894, -29213, -29524, -29844, -30199, -30547, -30909, -31128, -31345, -31635, -31880, -32099, -32296, -32445, -32575, -32684, -32761, -32769, -32767, -32769, -32741, -32720, -32691, -32643, -32575, -32491, -32388, -32269, -32133, -31979, -31809, -31629, -31412, -31032, -30797, -30553, -30291, -30017, -29728, -29424, -29108, -28780, -28437, -28081, -27725, -27293, -26746, -26353, -25941, -25522, -25091, -24650, -24201, -23743, -23276, -22800, -22315, -21839, -21253, -20635, -20143, -19625, -19102, -18574, -18042, -17500, -16953, -16400, -15842, -15274, -14709, -14030, -13384, -12804, -12204, -11593, -10974, -10346, -9707, -9056, -8387, -7706, -7013, -6270, -5470, -4765, -3963, -3142, -2272, -1355, -393, 660, 1799, 3109};