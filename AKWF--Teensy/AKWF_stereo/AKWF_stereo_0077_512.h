/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0077 512 samples */
 
const int16_t AKWF_stereo_0077_512_DATA [512] = 
{9967, 30442, 27025, 23422, 21486, 20234, 19484, 19002, 18613, 18263, 17937, 17633, 17380, 17185, 17064, 17026, 17063, 17166, 17308, 17466, 17632, 17792, 17948, 18106, 18261, 18410, 18546, 18657, 18743, 18799, 18823, 18824, 18786, 18709, 18600, 18451, 18274, 18060, 17819, 17553, 17256, 16946, 16597, 16287, 16722, 16424, 15601, 15000, 14464, 13990, 13558, 13159, 12797, 12432, 11883, 12991, -958, -22845, -18339, -14133, -11842, -10381, -9538, -9021, -8641, -8323, -8032, -7771, -7560, -7401, -7317, -7312, -7378, -7508, -7679, -7871, -8071, -8273, -8476, -8686, -8900, -9117, -9328, -9528, -9712, -9870, -10013, -10110, -10170, -10257, -10309, -10325, -10312, -10265, -10194, -10094, -9969, -9819, -9598, -9785, -5169, -1433, -4546, -6296, -7357, -7974, -8281, -8381, -8352, -8237, -8070, -7878, -7673, -7466, -7264, -7073, -6896, -6736, -6592, -6466, -6355, -6263, -6183, -6119, -6069, -6029, -6000, -5980, -5965, -5957, -5951, -5947, -5946, -5940, -5946, -5920, -4734, -4728, -5981, -6599, -6745, -6535, -6169, -5730, -5130, -4996, -5069, -5127, -5177, -5185, -5149, -5071, -4960, -4848, -4752, -4340, -9442, -13019, -9103, -6755, -5180, -4110, -3398, -2927, -2618, -2419, -2294, -2222, -2183, -2166, -2166, -2177, -2193, -2214, -2240, -2266, -2293, -2320, -2348, -2373, -2398, -2422, -2443, -2461, -2477, -2489, -2501, -2497, -2490, -2501, -2492, -2503, -3652, -3656, -2362, -1689, -1477, -1604, -1900, -2243, -486, 203, -1011, -1557, -1879, -2055, -2157, -2217, -2252, -2265, -2258, -2233, -2192, -2141, -2084, -2024, -1968, -1914, -1865, -1820, -1775, -1734, -1696, -1658, -1622, -1588, -1555, -1525, -1495, -1468, -1441, -1415, -1391, -1367, -1343, -1320, -1296, -1273, -1251, -1226, -1203, -1177, -1158, -1098, -967, -979, -1002, -998, -993, -975, -955, -936, -903, -883, -837, -897, 10899, 30059, 27560, 27741, 30427, 32505, 32568, 30857, 28771, 27698, 28040, 29126, 29888, 29636, 28478, 27100, 26217, 26108, 26501, 26856, 26774, 26203, 25429, 24812, 24537, 24535, 24572, 24433, 24068, 23578, 23132, 22836, 22676, 22558, 22373, 22075, 21711, 21350, 21053, 20829, 20630, 20412, 20146, 19831, 19427, 19137, 18944, 18747, 18533, 18299, 18039, 17772, 17523, 17267, 16836, 17848, 5538, -14172, -12137, -12551, -15488, -17805, -18101, -16600, -14707, -13810, -14314, -15571, -16508, -16433, -15447, -14233, -13503, -13545, -14091, -14606, -14681, -14269, -13650, -13182, -13054, -13201, -13388, -13403, -13188, -12845, -12546, -12399, -12392, -12416, -12372, -12221, -11999, -11780, -11624, -11538, -11481, -11402, -11278, -11063, -11426, -11706, -11188, -10851, -10594, -10367, -10160, -9974, -9816, -9688, -9578, -9474, -9366, -9251, -9134, -9024, -8922, -8829, -8739, -8646, -8550, -8454, -8358, -8268, -8182, -8098, -8012, -7927, -7841, -7754, -7670, -7590, -7510, -7423, -7357, -7246, -5429, -5366, -7173, -8050, -8240, -7918, -7356, -6796, -6412, -6174, -6082, -6095, -6139, -6163, -6144, -6083, -5988, -5878, -5767, -5705, -4985, -4463, -4859, -5068, -5183, -5235, -5240, -5217, -5173, -5117, -5056, -4990, -4921, -4853, -4785, -4716, -4647, -4578, -4512, -4445, -4380, -4317, -4253, -4190, -4130, -4069, -4011, -3951, -3893, -3836, -3780, -3725, -3670, -3621, -3551, -3520, -5178, -5154, -3212, -2196, -1868, -2054, -2483, -2912, -3444, -3643, -3436, -3209, -2978, -2787, -2654, -2576, -2537, -2518, -2500, -2478, -2446, -2403, -2356, -2306, -2260, -2217, -2177, -2141, -2103, -2067, -2033, -1996, -1959, -1922, -1885, -1850, -1815, -1780, -1745, -1712, -1679, -1645, -1611, -1579, -1546, -1514, -1483, -1449, -1419, -1388, -1355, -1331, -1313, -1279, -1244, -1208, -1179, -1147, -1117, -1091, -1056, -1028, -1007, -926};