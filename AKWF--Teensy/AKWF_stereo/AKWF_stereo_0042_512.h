/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0042 512 samples */
 
const int16_t AKWF_stereo_0042_512_DATA [512] = 
{1134, 3143, 5043, 6874, 8620, 10262, 11768, 13085, 14186, 15070, 15751, 16236, 16524, 16635, 16619, 16522, 16382, 16222, 16055, 15891, 15733, 15584, 15447, 15327, 15226, 15153, 15122, 15157, 15297, 15575, 15985, 16490, 17052, 17648, 18278, 18958, 19714, 20582, 21575, 22662, 23804, 24957, 26086, 27179, 28219, 29193, 30097, 30912, 31615, 32174, 32549, 32734, 32764, 32689, 32547, 32358, 32138, 31890, 31616, 31308, 30953, 30523, 29987, 29315, 28509, 27610, 26663, 25710, 24788, 23922, 23150, 22518, 22047, 21717, 21485, 21309, 21165, 21040, 20928, 20824, 20727, 20637, 20556, 20485, 20434, 20413, 20440, 20546, 20761, 21098, 21526, 21975, 22364, 22631, 22758, 22776, 22724, 22623, 22485, 22317, 22120, 21895, 21642, 21359, 21045, 20696, 20314, 19893, 19434, 18934, 18390, 17798, 17157, 16463, 15726, 14949, 14128, 13265, 12368, 11439, 10489, 9522, 8541, 7553, 6561, 5566, 4575, 3590, 2610, 1640, 680, -275, -1227, -2192, -3194, -4259, -5401, -6581, -7717, -8737, -9593, -10275, -10825, -11279, -11671, -12023, -12345, -12646, -12929, -13198, -13451, -13690, -13909, -14102, -14256, -14349, -14342, -14208, -13954, -13623, -13266, -12921, -12618, -12389, -12272, -12306, -12505, -12847, -13289, -13791, -14324, -14876, -15440, -16015, -16608, -17231, -17902, -18660, -19543, -20555, -21667, -22826, -23992, -25148, -26273, -27355, -28386, -29350, -30228, -30993, -31605, -32034, -32283, -32385, -32384, -32311, -32182, -31994, -31726, -31345, -30832, -30207, -29521, -28809, -28098, -27401, -26722, -26067, -25439, -24838, -24267, -23732, -23237, -22798, -22437, -22184, -22080, -22151, -22392, -22784, -23319, -23998, -24791, -25645, -26510, -27350, -28145, -28886, -29563, -30173, -30713, -31175, -31560, -31863, -32077, -32196, -32213, -32113, -31879, -31480, -30870, -29977, -28733, -27129, -25226, -23129, -20922, -18650, -16354, -14059, -11770, -9510, -7286, -5100, -2967, -845, 1517, 3445, 5264, 7009, 8655, 10173, 11509, 12587, 13366, 13873, 14179, 14341, 14391, 14355, 14263, 14139, 14002, 13861, 13725, 13597, 13478, 13372, 13282, 13212, 13169, 13168, 13231, 13404, 13752, 14334, 15139, 16094, 17124, 18179, 19237, 20297, 21358, 22435, 23533, 24635, 25726, 26790, 27808, 28775, 29682, 30516, 31268, 31915, 32417, 32716, 32744, 32488, 32005, 31386, 30695, 29969, 29229, 28490, 27753, 27021, 26292, 25552, 24793, 24002, 23179, 22347, 21525, 20737, 20010, 19379, 18898, 18637, 18637, 18862, 19226, 19663, 20127, 20594, 21054, 21499, 21925, 22333, 22721, 23089, 23442, 23782, 24114, 24451, 24795, 25145, 25468, 25701, 25760, 25574, 25146, 24545, 23844, 23095, 22321, 21536, 20747, 19955, 19158, 18361, 17558, 16747, 15932, 15107, 14275, 13443, 12612, 11799, 11034, 10359, 9830, 9464, 9212, 9010, 8817, 8606, 8366, 8096, 7793, 7458, 7094, 6705, 6292, 5859, 5405, 4934, 4442, 3922, 3364, 2737, 1993, 1071, -67, -1376, -2754, -4124, -5430, -6645, -7785, -8857, -9869, -10835, -11756, -12633, -13472, -14270, -15027, -15742, -16406, -17008, -17526, -17915, -18110, -18056, -17765, -17314, -16783, -16229, -15686, -15177, -14728, -14356, -14069, -13861, -13713, -13610, -13544, -13510, -13508, -13545, -13632, -13789, -14056, -14494, -15169, -16095, -17216, -18441, -19706, -20977, -22226, -23440, -24613, -25733, -26789, -27772, -28662, -29448, -30131, -30720, -31230, -31670, -32031, -32291, -32401, -32297, -31938, -31361, -30653, -29882, -29090, -28305, -27533, -26781, -26058, -25359, -24690, -24054, -23449, -22885, -22371, -21922, -21560, -21305, -21173, -21191, -21402, -21853, -22520, -23325, -24186, -25046, -25874, -26656, -27378, -28034, -28623, -29135, -29572, -29928, -30196, -30373, -30450, -30414, -30249, -29926, -29396, -28582, -27405, -25856, -24002, -21957, -19807, -17598, -15370, -13147, -10932, -8748, -6599, -4489, -2432, -388};