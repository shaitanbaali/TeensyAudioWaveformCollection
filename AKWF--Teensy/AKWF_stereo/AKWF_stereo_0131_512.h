/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0131 512 samples */
 
const int16_t AKWF_stereo_0131_512_DATA [512] = 
{289, 1042, 1769, 2590, 3437, 4263, 5184, 6034, 6754, 7497, 8242, 9006, 9825, 10533, 11200, 11865, 12551, 13328, 14138, 14811, 15454, 15997, 16549, 17158, 17804, 18439, 19068, 19581, 20118, 20700, 21368, 22097, 22800, 23413, 24018, 24562, 25090, 25579, 26053, 26436, 26747, 27011, 27329, 27662, 28017, 28342, 28644, 28914, 29181, 29460, 29800, 30156, 30465, 30657, 30772, 30911, 31188, 31456, 31666, 31823, 31931, 31961, 32011, 31993, 31932, 31815, 31662, 31484, 31317, 31176, 31057, 30864, 30628, 30345, 30010, 29690, 29429, 29142, 28848, 28542, 28225, 27923, 27662, 27391, 27113, 26773, 26411, 26077, 25802, 25463, 24994, 24459, 23863, 23264, 22631, 22143, 21702, 21208, 20602, 19990, 19332, 18807, 18302, 17757, 17086, 16357, 15611, 14907, 14176, 13599, 12905, 12160, 11384, 10518, 9660, 8958, 8200, 7415, 6560, 5687, 4829, 4059, 3191, 2297, 1370, 553, -187, -964, -1733, -2472, -3312, -4087, -4793, -5517, -6198, -6800, -7475, -8160, -8836, -9576, -10287, -10956, -11685, -12444, -13211, -13887, -14464, -15095, -15739, -16394, -17041, -17655, -18209, -18759, -19274, -19857, -20408, -20976, -21447, -21861, -22353, -22944, -23480, -24022, -24504, -24986, -25527, -26109, -26646, -27149, -27527, -27862, -28186, -28652, -29221, -29753, -30160, -30441, -30564, -30689, -30890, -31131, -31328, -31427, -31366, -31211, -31091, -31119, -31206, -31321, -31392, -31384, -31315, -31306, -31369, -31468, -31425, -31196, -30833, -30481, -30265, -30178, -30081, -29897, -29543, -29078, -28598, -28186, -27862, -27540, -27086, -26549, -25988, -25536, -25183, -24831, -24472, -24015, -23465, -22963, -22553, -22147, -21783, -21282, -20700, -20095, -19567, -19153, -18798, -18335, -17854, -17219, -16571, -16027, -15433, -14764, -14100, -13286, -12474, -11709, -10971, -10237, -9657, -9009, -8375, -7646, -6927, -6187, -5414, -4596, -3886, -3182, -2554, -1884, -1152, -375, 8500, 9191, 9822, 10542, 11317, 12105, 12942, 13751, 14450, 15161, 15869, 16583, 17319, 17939, 18514, 19084, 19686, 20405, 21155, 21723, 22234, 22658, 23085, 23578, 24119, 24639, 25147, 25573, 26013, 26472, 26992, 27563, 28078, 28479, 28905, 29308, 29737, 30126, 30440, 30612, 30723, 30832, 31016, 31211, 31426, 31584, 31693, 31764, 31814, 31872, 32033, 32200, 32279, 32227, 32140, 32109, 32224, 32348, 32406, 32329, 32181, 31980, 31823, 31640, 31443, 31132, 30745, 30308, 29909, 29607, 29362, 29008, 28559, 28026, 27506, 27020, 26599, 26170, 25716, 25156, 24594, 24048, 23619, 23267, 22918, 22428, 21828, 21253, 20804, 20341, 19784, 19112, 18324, 17520, 16747, 16160, 15658, 15113, 14419, 13647, 12781, 12048, 11424, 10851, 10175, 9378, 8500, 7707, 6924, 6310, 5588, 4798, 3896, 2903, 1911, 1114, 334, -423, -1294, -2228, -3161, -3945, -4789, -5636, -6521, -7349, -8158, -8974, -9797, -10533, -11332, -12091, -12792, -13504, -14143, -14646, -15224, -15809, -16464, -17233, -17934, -18546, -19201, -19862, -20549, -21152, -21635, -22137, -22629, -23143, -23644, -24122, -24583, -25030, -25413, -25858, -26275, -26718, -27101, -27436, -27792, -28177, -28482, -28802, -29075, -29394, -29778, -30173, -30511, -30847, -31096, -31329, -31533, -31825, -32154, -32433, -32623, -32726, -32713, -32691, -32695, -32751, -32767, -32686, -32475, -32202, -31909, -31704, -31533, -31426, -31285, -31105, -30866, -30626, -30399, -30241, -30017, -29665, -29204, -28736, -28298, -27929, -27541, -27130, -26627, -26074, -25474, -24899, -24383, -23923, -23365, -22718, -22023, -21376, -20751, -20141, -19539, -18898, -18250, -17624, -17018, -16391, -15862, -15267, -14620, -13957, -13345, -12792, -12276, -11649, -10994, -10237, -9500, -8846, -8147, -7355, -6611, -5768, -4973, -4171, -3323, -2468, -1839, -1130, -455, 302, 1067, 1878, 2675, 3512, 4240, 4945, 5562, 6282, 7071, 7868};