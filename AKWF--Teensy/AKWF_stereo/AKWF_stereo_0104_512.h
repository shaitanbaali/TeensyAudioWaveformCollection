/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0104 512 samples */
 
const int16_t AKWF_stereo_0104_512_DATA [512] = 
{6540, 8752, 7122, 5459, 4066, 8304, 7348, 17723, 21444, 20916, 22189, 20135, 18866, 19818, 16646, 16991, 17707, 17371, 16352, 14783, 13999, 15554, 16426, 16783, 16296, 13446, 13825, 16106, 19107, 23576, 20640, 18591, 15529, 14924, 17273, 16161, 17429, 15119, 15384, 5197, -3196, 31, 2000, 7317, 12146, 11318, 9966, 10225, 10133, 9059, 6956, 6946, 9200, 11353, 12501, 11297, 8375, 7115, 6908, 9930, 15121, 15816, 16046, 14512, 14534, 15294, 14702, 15950, 13604, 14488, 6143, -219, -2182, -3253, -3287, -3962, -4780, -3305, -2640, -2635, -4572, -8714, -9861, -10592, -9758, -7726, -9330, -11924, -13233, -13455, -13010, -12747, -12209, -11743, -11098, -9412, -7816, -7213, -7937, -9727, -9666, -7619, -4299, -2172, -1451, -776, -1325, -2304, 27, 776, 2509, 1523, -3378, -2745, -2624, 1379, 4991, 3568, 4125, 3047, 5054, 4974, 5284, 5782, 2201, 1884, 2090, 19382, 22529, 21672, 17700, 14871, 13150, 11654, 9706, 13802, 13382, 12287, 11086, 13238, 14223, 16799, 18787, 13374, 11859, 8652, 9331, 7783, 5988, 5262, 1604, 3663, 3469, 4064, 4802, 1970, 5028, 2766, 73, -1845, -2012, -2769, -4624, -5970, -4906, -3224, -1803, -2491, -4402, -7244, -13989, -14588, -9125, -5608, -8195, -10463, -14067, -12581, -13678, -13982, -13975, -18618, -17797, -20731, -23327, -24226, -26761, -28841, -27864, -26747, -23717, -22555, -21516, -22831, -23885, -30493, -29976, -25394, -22144, -22098, -22667, -22188, -19425, -15896, -12549, -10697, -8652, -8186, -6418, -5503, -5526, -5626, -7297, -3889, -1827, -1311, -1216, -1399, -1674, -2572, -2215, 110, 758, 1720, -1457, -3773, -2909, -2705, 1354, 610, -1446, -1882, -5802, -6233, -8522, -7829, -9923, -11427, -10573, -10396, -8869, -10061, -10894, -12424, -14043, -12983, -11023, -9281, -8628, -9322, -11136, -10351, -8597, -7376, -5676, -10992, 4444, 7775, 7373, 5292, 5078, 9600, 9821, 21555, 25340, 25179, 25863, 24127, 21868, 23276, 20412, 22300, 24123, 23222, 21636, 20184, 18275, 19878, 20239, 20481, 21032, 17522, 19410, 21727, 25722, 29957, 27144, 26747, 23617, 23927, 25348, 24445, 24619, 21678, 22278, 10249, 1807, 4789, 7268, 11638, 15950, 14135, 11525, 11470, 11478, 9446, 7859, 7211, 9440, 12047, 12338, 12815, 8980, 8646, 8167, 11926, 19875, 20323, 21361, 18981, 20727, 22037, 22379, 25332, 22598, 24206, 13040, 5386, 2177, 713, 1206, 312, -917, 631, 238, 253, -2795, -7444, -9124, -11502, -10671, -10137, -10441, -14608, -16926, -17683, -17416, -15887, -16041, -14090, -14742, -13396, -12506, -12990, -13422, -17494, -16364, -14675, -12064, -10434, -10743, -10761, -11283, -13404, -10789, -10806, -9218, -10035, -15528, -14253, -15390, -10964, -9292, -10709, -9487, -9883, -7363, -8611, -7146, -7570, -9492, -8969, -6950, 14913, 18957, 19036, 14321, 11538, 11044, 10064, 8426, 14188, 14006, 14247, 13487, 16305, 17886, 20318, 23551, 17572, 18090, 15397, 16407, 14128, 12039, 11740, 7808, 11426, 11066, 12851, 13113, 10760, 13857, 10260, 8920, 7848, 7627, 7328, 5153, 3240, 3980, 4256, 5501, 3913, 1471, -1784, -9833, -10286, -5942, -1882, -5832, -8609, -13012, -11396, -12226, -13381, -12900, -19142, -18215, -22542, -24966, -24707, -25641, -25302, -24114, -23608, -20461, -19419, -18570, -19366, -21144, -27821, -27822, -23162, -19807, -20308, -20813, -21985, -18993, -15603, -11794, -10411, -8818, -8895, -8018, -6928, -7516, -6467, -8794, -4554, -3053, -4442, -4733, -4386, -4832, -4795, -4084, -1371, 282, 634, -1537, -4315, -3954, -4436, -1542, -1648, -5573, -5813, -11041, -12056, -14850, -14821, -16450, -18330, -17184, -17564, -15867, -18508, -20298, -23514, -25482, -23200, -20436, -18921, -17138, -17285, -18521, -16793, -15467, -12826, -11329, -16004};