/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0084 512 samples */
 
const int16_t AKWF_stereo_0084_512_DATA [512] = 
{11543, 16324, 18347, 19800, 20996, 22028, 22894, 23610, 24234, 24821, 25395, 25938, 26422, 26831, 27182, 27518, 27872, 28252, 28648, 29029, 29369, 29669, 29936, 30186, 30428, 30653, 30848, 31000, 31102, 31158, 31178, 31159, 31094, 30986, 30821, 30602, 30332, 30011, 29642, 29229, 28772, 28276, 27694, 27312, 26976, 26270, 25517, 24724, 23916, 23095, 22263, 21430, 20593, 19757, 18925, 18093, 17267, 16450, 15640, 14840, 14052, 13278, 12514, 11764, 11027, 10304, 9594, 8899, 8216, 7542, 6881, 6230, 5586, 4947, 4317, 3693, 3070, 2451, 1831, 1212, 598, -23, -647, -1273, -1905, -2539, -3177, -3803, -4446, -5101, -5760, -6421, -7086, -7754, -8421, -9087, -9754, -10395, -11183, -11302, -9223, -9752, -10877, -12069, -13240, -14343, -15366, -16310, -17181, -17985, -18732, -19431, -20083, -20697, -21281, -21828, -22350, -22847, -23321, -23772, -24206, -24620, -25017, -25398, -25762, -26116, -26458, -26782, -27100, -27405, -27700, -27987, -28261, -28521, -28832, -28837, -28567, -29092, -29692, -30205, -30556, -30757, -30878, -30849, -30843, -30974, -31140, -31336, -31537, -31728, -31900, -32047, -32175, -32285, -32377, -32463, -32538, -32602, -32657, -32705, -32738, -32757, -32767, -32767, -32753, -32727, -32691, -32644, -32586, -32517, -32439, -32348, -32248, -32141, -32020, -31889, -31751, -31602, -31448, -31283, -31107, -30924, -30735, -30537, -30330, -30118, -29895, -29660, -29424, -29181, -28930, -28677, -28413, -28143, -27866, -27582, -27291, -26979, -26751, -26066, -24815, -24558, -24402, -24272, -24125, -23950, -23740, -23496, -23231, -22936, -22618, -22280, -21928, -21558, -21178, -20781, -20379, -19964, -19540, -19107, -18668, -18220, -17767, -17310, -16842, -16373, -15898, -15416, -14931, -14443, -13947, -13452, -12951, -12447, -11940, -11432, -10918, -10405, -9888, -9368, -8845, -8322, -7799, -7232, -6681, -6159, -5640, -5117, -4594, -4070, -3543, -3011, -2482, -1947, -1430, -804, 8269, 11975, 14459, 17272, 20154, 22563, 24174, 25102, 25781, 26611, 27709, 28895, 29875, 30465, 30709, 30812, 30986, 31312, 31723, 32068, 32235, 32218, 32097, 31974, 31909, 31880, 31823, 31684, 31446, 31140, 30819, 30511, 30213, 29902, 29544, 29131, 28678, 28204, 27725, 27247, 26759, 26246, 25707, 25113, 24494, 23907, 23317, 22719, 22110, 21483, 20836, 20181, 19520, 18853, 18182, 17504, 16817, 16123, 15422, 14718, 14014, 13308, 12600, 11888, 11173, 10458, 9741, 9025, 8310, 7595, 6881, 6167, 5454, 4739, 4029, 3322, 2614, 1912, 1208, 508, -184, -877, -1568, -2253, -2938, -3616, -4291, -4965, -5632, -6292, -6948, -7599, -8244, -8886, -9520, -10148, -10772, -11390, -11986, -12648, -13531, -14132, -14663, -15177, -15684, -16189, -16694, -17198, -17702, -18199, -18694, -19186, -19670, -20148, -20621, -21083, -21539, -21988, -22426, -22857, -23280, -23692, -24095, -24491, -24874, -25251, -25617, -25971, -26319, -26656, -26982, -27301, -27606, -27896, -28238, -28250, -27966, -28534, -29179, -29729, -30105, -30319, -30427, -30506, -30587, -30690, -30826, -30988, -31158, -31318, -31465, -31588, -31692, -31780, -31855, -31923, -31982, -32034, -32079, -32116, -32142, -32157, -32162, -32157, -32142, -32116, -32081, -32038, -31984, -31920, -31848, -31766, -31674, -31574, -31463, -31343, -31215, -31076, -30931, -30776, -30612, -30438, -30257, -30067, -29868, -29662, -29447, -29224, -28994, -28753, -28505, -28250, -27986, -27716, -27436, -27151, -26858, -26559, -26242, -25969, -25744, -25408, -25054, -24689, -24320, -23947, -23568, -23185, -22802, -22413, -22019, -21619, -21217, -20811, -20399, -19980, -19560, -19133, -18702, -18267, -17826, -17380, -16932, -16480, -16021, -15558, -15094, -14624, -14150, -13675, -13192, -12709, -12223, -11731, -11238, -10742, -10244, -9743, -9238, -8732, -8223, -7712, -7199, -6690, -6176, -5656, -5138, -4615, -4091, -3569, -3044, -2517, -1991, -1465, -950, -357};