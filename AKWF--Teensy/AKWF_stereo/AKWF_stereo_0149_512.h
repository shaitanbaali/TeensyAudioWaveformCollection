/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0149 512 samples */
 
const int16_t AKWF_stereo_0149_512_DATA [512] = 
{188, 523, 833, 1111, 1372, 1622, 1864, 2100, 2330, 2557, 2780, 2999, 3217, 3432, 3647, 3858, 4069, 4280, 4489, 4697, 4906, 5115, 5322, 5529, 5737, 5943, 6151, 6357, 6565, 6772, 6978, 7185, 7392, 7600, 7808, 8016, 8225, 8433, 8642, 8851, 9060, 9271, 9481, 9692, 9903, 10112, 10324, 10536, 10749, 10961, 11173, 11387, 11600, 11814, 12028, 12243, 12457, 12672, 12890, 13105, 13319, 13537, 13755, 13972, 14189, 14408, 14625, 14843, 15063, 15282, 15502, 15722, 15943, 16163, 16382, 16604, 16826, 17047, 17270, 17491, 17713, 17936, 18160, 18383, 18606, 18830, 19050, 19269, 19486, 19701, 19914, 20123, 20332, 20538, 20741, 20942, 21141, 21336, 21530, 21721, 21908, 22093, 22277, 22458, 22636, 22811, 22983, 23153, 23321, 23487, 23649, 23809, 23968, 24123, 24275, 24426, 24575, 24720, 24863, 25005, 25144, 25279, 25414, 25547, 25675, 25799, 25829, 26424, 22716, 11179, 10971, 2481, -27435, -30882, -26233, -27198, -26806, -26255, -25944, -25567, -25200, -24850, -24503, -24164, -23833, -23508, -23190, -22879, -22574, -22274, -21980, -21691, -21408, -21131, -20857, -20590, -20328, -20068, -19813, -19565, -19318, -19078, -18841, -18606, -18377, -18148, -17924, -17702, -17484, -17267, -17051, -16836, -16622, -16409, -16195, -15982, -15772, -15561, -15350, -15141, -14931, -14724, -14516, -14310, -14103, -13898, -13694, -13489, -13286, -13084, -12882, -12681, -12479, -12280, -12079, -11881, -11684, -11485, -11288, -11092, -10896, -10702, -10507, -10313, -10120, -9926, -9734, -9543, -9351, -9161, -8971, -8781, -8591, -8402, -8214, -8026, -7839, -7652, -7464, -7278, -7092, -6907, -6721, -6535, -6351, -6165, -5980, -5796, -5611, -5426, -5241, -5057, -4872, -4685, -4501, -4314, -4127, -3941, -3751, -3562, -3372, -3181, -2988, -2793, -2597, -2398, -2197, -1991, -1783, -1569, -1350, -1126, -893, -648, -392, -108, 327, 945, 1508, 1998, 2444, 2863, 3257, 3632, 3990, 4334, 4666, 4989, 5303, 5608, 5909, 6200, 6486, 6769, 7046, 7318, 7586, 7852, 8113, 8371, 8626, 8879, 9128, 9376, 9621, 9863, 10103, 10342, 10580, 10814, 11047, 11280, 11510, 11739, 11967, 12193, 12418, 12642, 12864, 13087, 13307, 13526, 13743, 13962, 14178, 14393, 14609, 14822, 15034, 15247, 15458, 15670, 15880, 16089, 16299, 16506, 16713, 16920, 17127, 17332, 17538, 17742, 17945, 18150, 18352, 18555, 18756, 18958, 19159, 19360, 19559, 19758, 19958, 20157, 20355, 20552, 20750, 20947, 21143, 21340, 21537, 21731, 21923, 22115, 22305, 22492, 22679, 22864, 23046, 23227, 23407, 23583, 23757, 23927, 24097, 24263, 24425, 24586, 24743, 24899, 25053, 25202, 25350, 25495, 25639, 25778, 25916, 26053, 26187, 26316, 26445, 26571, 26696, 26818, 26937, 27055, 27170, 27284, 27395, 27504, 27611, 27708, 27585, 28788, 19975, -6683, -9520, -11464, -29673, -31577, -28633, -29121, -28775, -28339, -28049, -27722, -27404, -27098, -26794, -26499, -26209, -25924, -25645, -25372, -25104, -24841, -24581, -24325, -24076, -23830, -23587, -23349, -23114, -22884, -22656, -22433, -22211, -21995, -21781, -21568, -21359, -21149, -20941, -20736, -20531, -20327, -20124, -19921, -19717, -19516, -19313, -19109, -18907, -18705, -18502, -18300, -18097, -17896, -17694, -17491, -17290, -17088, -16885, -16684, -16483, -16279, -16077, -15876, -15673, -15470, -15269, -15067, -14864, -14662, -14458, -14255, -14051, -13848, -13646, -13441, -13236, -13032, -12827, -12621, -12415, -12210, -12001, -11795, -11587, -11378, -11168, -10958, -10747, -10536, -10322, -10109, -9896, -9681, -9464, -9246, -9027, -8807, -8586, -8362, -8137, -7910, -7682, -7451, -7218, -6982, -6744, -6503, -6260, -6012, -5762, -5507, -5249, -4985, -4716, -4442, -4161, -3874, -3578, -3271, -2956, -2629, -2286, -1927, -1549, -1143, -705, -209};