/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0001 512 samples */
 
const int16_t AKWF_stereo_0001_512_DATA [512] = 
{28075, 30187, 27556, 25927, 24658, 23619, 22460, 21392, 20495, 19681, 18945, 18308, 17830, 17427, 17053, 16718, 16407, 16107, 15825, 15562, 15311, 15073, 14847, 14630, 14422, 14219, 14027, 13839, 13658, 13482, 13309, 13141, 12978, 12821, 12665, 12514, 12367, 12222, 12077, 11938, 11802, 11667, 11534, 11405, 11279, 11154, 11031, 10910, 10793, 10675, 10559, 10447, 10335, 10223, 10114, 10006, 9898, 9792, 9689, 9584, 9483, 9380, 9279, 9180, 9079, 8980, 8883, 8786, 8690, 8595, 8500, 8407, 8312, 8218, 8124, 8030, 7938, 7848, 7756, 7665, 7576, 7484, 7394, 7304, 7215, 7126, 7037, 6950, 6862, 6773, 6686, 6599, 6512, 6425, 6341, 6246, 6130, 6013, 5893, 5777, 5660, 5543, 5426, 5320, 5248, 5190, 4844, 6302, -6898, -13334, -13854, -14790, -14977, -13990, -12588, -10335, -8439, -6791, -5682, -4950, -4509, -4150, -3877, -3696, -3664, -3730, -3717, -3709, -3736, -3786, -3857, -3938, -4031, -4136, -4246, -4360, -4480, -4602, -4726, -4849, -4974, -5098, -5221, -5345, -5467, -5588, -5706, -5823, -5940, -6052, -6165, -6275, -6384, -6488, -6593, -6696, -6794, -6894, -6993, -7088, -7184, -7277, -7366, -7456, -7544, -7631, -7717, -7803, -7883, -7965, -8044, -8124, -8200, -8274, -8350, -8424, -8495, -8569, -8640, -8709, -8777, -8844, -8909, -8976, -9040, -9103, -9168, -9229, -9290, -9353, -9410, -9470, -9530, -9587, -9643, -9700, -9755, -9809, -9862, -9915, -9967, -10020, -10071, -10119, -10169, -10218, -10266, -10314, -10360, -10407, -10450, -10495, -10541, -10585, -10627, -10670, -10711, -10753, -10793, -10833, -10872, -10911, -10950, -10986, -11022, -11059, -11096, -11131, -11164, -11200, -11232, -11263, -11294, -11320, -11334, -11346, -11356, -11370, -11383, -11393, -11404, -11415, -11427, -11440, -11453, -11466, -11479, -11494, -11504, -11506, -11535, -11539, -11550, -11456, -12087, -9194, 2322, 8206, 7207, 6284, 7226, 7804, 7285, 6965, 7174, 7345, 7451, 7770, 8345, 8961, 9582, 10259, 10956, 11638, 12303, 12960, 13601, 14213, 14799, 15361, 15896, 16402, 16884, 17341, 17775, 18186, 18575, 18945, 19299, 19636, 19957, 20265, 20560, 20841, 21112, 21373, 21624, 21866, 22099, 22326, 22547, 22760, 22967, 23170, 23366, 23559, 23747, 23930, 24111, 24287, 24461, 24633, 24800, 24965, 25130, 25291, 25451, 25609, 25763, 25918, 26070, 26220, 26372, 26521, 26669, 26817, 26963, 27107, 27253, 27397, 27539, 27681, 27823, 27965, 28106, 28247, 28386, 28526, 28666, 28804, 28944, 29082, 29219, 29359, 29496, 29633, 29772, 29909, 30045, 30184, 30322, 30453, 30561, 30668, 30774, 30882, 30989, 31095, 31202, 31321, 31417, 31490, 31398, 32344, 24831, 21380, 21261, 21203, 20075, 15691, 10347, 2838, -3321, -8327, -11877, -14340, -16095, -17235, -17974, -18459, -18846, -19177, -19500, -19769, -19971, -20127, -20255, -20359, -20448, -20528, -20602, -20670, -20736, -20801, -20864, -20925, -20987, -21048, -21107, -21166, -21223, -21277, -21331, -21381, -21429, -21475, -21517, -21556, -21593, -21624, -21653, -21679, -21699, -21716, -21731, -21740, -21747, -21749, -21746, -21740, -21730, -21716, -21700, -21680, -21653, -21625, -21593, -21559, -21519, -21477, -21431, -21382, -21330, -21276, -21219, -21157, -21092, -21026, -20956, -20882, -20806, -20729, -20648, -20565, -20478, -20390, -20299, -20205, -20110, -20011, -19911, -19808, -19703, -19595, -19485, -19374, -19259, -19144, -19027, -18905, -18783, -18659, -18533, -18407, -18277, -18146, -18012, -17878, -17743, -17605, -17466, -17325, -17182, -17040, -16894, -16748, -16601, -16451, -16300, -16148, -15994, -15841, -15686, -15528, -15369, -15211, -15051, -14889, -14725, -14559, -14384, -14206, -14027, -13851, -13672, -13493, -13313, -13133, -12951, -12770, -12590, -12408, -12227, -12045, -11861, -11673, -11493, -11307, -11122, -10912, -10869, -9997};