/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0145 512 samples */
 
const int16_t AKWF_stereo_0145_512_DATA [512] = 
{655, 1673, 2658, 3626, 4574, 5507, 6424, 7322, 8203, 9067, 9909, 10737, 11550, 12339, 13114, 13871, 14604, 15323, 16026, 16710, 17378, 18030, 18664, 19286, 19889, 20480, 21055, 21612, 22155, 22683, 23192, 23686, 24167, 24627, 25074, 25506, 25918, 26319, 26707, 27076, 27432, 27775, 28103, 28417, 28718, 29006, 29280, 29540, 29786, 30017, 30236, 30439, 30629, 30803, 30965, 31111, 31242, 31361, 31463, 31551, 31627, 31687, 31734, 31768, 31788, 31795, 31789, 31767, 31730, 31681, 31618, 31538, 31443, 31334, 31209, 31070, 30916, 30745, 30559, 30359, 30144, 29911, 29661, 29400, 29123, 28828, 28520, 28195, 27854, 27499, 27126, 26740, 26338, 25919, 25483, 25030, 24558, 24070, 23566, 23044, 22507, 21954, 21385, 20801, 20198, 19577, 18941, 18286, 17613, 16925, 16217, 15493, 14750, 13992, 13213, 12419, 11606, 10778, 9935, 9074, 8199, 7312, 6408, 5489, 4557, 3608, 2651, 1683, 700, -288, -1260, -2214, -3150, -4068, -4967, -5846, -6710, -7555, -8383, -9192, -9980, -10752, -11520, -12278, -13020, -13750, -14468, -15178, -15876, -16560, -17229, -17888, -18533, -19166, -19789, -20399, -20994, -21575, -22141, -22694, -23236, -23763, -24276, -24776, -25264, -25738, -26195, -26636, -27064, -27478, -27876, -28257, -28624, -28974, -29309, -29630, -29934, -30222, -30494, -30753, -30995, -31222, -31436, -31634, -31817, -31984, -32134, -32271, -32391, -32494, -32581, -32653, -32707, -32744, -32764, -32766, -32751, -32718, -32669, -32603, -32519, -32420, -32306, -32173, -32026, -31861, -31680, -31482, -31264, -31030, -30774, -30500, -30205, -29893, -29564, -29214, -28845, -28458, -28056, -27633, -27190, -26728, -26246, -25749, -25232, -24696, -24138, -23561, -22965, -22347, -21711, -21056, -20382, -19689, -18980, -18249, -17501, -16740, -15957, -15157, -14344, -13511, -12661, -11795, -10916, -10019, -9111, -8188, -7251, -6302, -5335, -4356, -3369, -2370, -1364, -333, -2679, -1779, -883, 25, 927, 1811, 2681, 3531, 4362, 5177, 5968, 6746, 7508, 8254, 8982, 9695, 10389, 11068, 11733, 12381, 13016, 13636, 14238, 14829, 15406, 15970, 16524, 17063, 17591, 18109, 18613, 19105, 19586, 20055, 20512, 20960, 21394, 21815, 22229, 22627, 23013, 23390, 23754, 24106, 24446, 24775, 25093, 25401, 25695, 25975, 26245, 26503, 26750, 26984, 27206, 27415, 27611, 27795, 27968, 28127, 28274, 28409, 28530, 28637, 28733, 28817, 28888, 28943, 28986, 29017, 29033, 29036, 29026, 29000, 28960, 28908, 28840, 28757, 28660, 28550, 28425, 28283, 28126, 27955, 27768, 27565, 27346, 27111, 26861, 26594, 26310, 26011, 25697, 25366, 25019, 24654, 24272, 23874, 23459, 23025, 22577, 22111, 21629, 21130, 20615, 20083, 19535, 18972, 18391, 17796, 17186, 16561, 15922, 15266, 14595, 13909, 13210, 12497, 11772, 11031, 10278, 9515, 8737, 7947, 7146, 6332, 5510, 4677, 3831, 2978, 2115, 1245, 370, -509, -1376, -2219, -3046, -3856, -4645, -5416, -6169, -6905, -7636, -8358, -9066, -9764, -10450, -11125, -11793, -12448, -13088, -13723, -14342, -14951, -15553, -16142, -16720, -17289, -17843, -18389, -18926, -19447, -19959, -20461, -20950, -21430, -21899, -22352, -22797, -23231, -23653, -24061, -24460, -24843, -25214, -25574, -25919, -26251, -26569, -26874, -27166, -27443, -27706, -27957, -28192, -28414, -28620, -28813, -28990, -29154, -29302, -29435, -29554, -29657, -29744, -29817, -29875, -29914, -29940, -29950, -29941, -29917, -29876, -29820, -29748, -29660, -29552, -29430, -29289, -29134, -28957, -28766, -28554, -28327, -28081, -27816, -27535, -27236, -26919, -26582, -26230, -25857, -25465, -25058, -24632, -24190, -23727, -23245, -22747, -22227, -21691, -21139, -20568, -19978, -19372, -18748, -18106, -17451, -16778, -16087, -15383, -14662, -13925, -13175, -12412, -11635, -10848, -10048, -9236, -8419, -7584, -6743, -5897, -5043, -4181, -3300};