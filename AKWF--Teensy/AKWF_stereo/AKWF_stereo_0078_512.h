/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0078 512 samples */
 
const int16_t AKWF_stereo_0078_512_DATA [512] = 
{367, 1240, 2118, 3004, 3891, 4777, 5662, 6535, 7401, 8254, 9092, 9916, 10725, 11482, 12379, 13296, 13966, 14604, 15208, 15786, 16341, 16874, 17364, 17938, 18546, 18992, 19389, 19744, 20069, 20369, 20646, 20901, 21140, 21361, 21566, 21755, 21932, 22095, 22249, 22391, 22527, 22645, 22754, 22865, 22972, 23074, 23172, 23264, 23352, 23429, 23540, 23627, 23634, 23817, 21864, 19836, 18975, 18306, 17789, 17322, 16879, 16451, 16035, 15633, 15240, 14856, 14476, 14101, 13717, 13317, 12900, 12471, 12023, 11559, 11085, 10598, 10099, 9604, 9028, 8747, 9529, 9370, 8834, 8177, 7464, 6738, 6023, 5325, 4652, 4006, 3386, 2795, 2228, 1687, 1170, 677, 213, -257, -777, -1205, -1590, -1949, -2288, -2610, -2918, -3218, -3504, -3783, -4056, -4322, -4584, -4842, -5096, -5356, -5563, -5675, -5731, -6060, -6467, -6875, -7238, -7548, -7826, -8028, -8226, -8481, -8759, -9057, -9368, -9683, -9999, -10311, -10619, -10922, -11224, -11520, -11815, -12108, -12398, -12683, -12965, -13245, -13519, -13785, -14043, -14295, -14541, -14780, -15013, -15242, -15463, -15682, -15890, -16101, -16963, -17498, -17698, -17830, -17911, -17984, -18054, -18128, -18208, -18295, -18391, -18494, -18604, -18717, -18825, -19011, -18850, -18149, -18123, -18193, -18306, -18435, -18566, -18695, -18867, -18841, -18521, -18579, -18734, -18932, -19145, -19360, -19570, -19771, -19959, -20158, -20461, -20626, -20717, -20797, -20889, -21006, -21140, -21300, -21479, -21624, -21751, -21864, -21966, -22065, -22162, -22259, -22355, -22453, -22551, -22648, -22744, -22838, -22931, -23023, -23083, -23160, -23253, -23345, -23435, -23521, -23603, -23684, -23762, -23813, -23867, -23930, -23990, -24050, -24103, -24152, -24196, -24234, -24267, -24275, -24358, -24171, -19628, -16558, -14931, -13633, -12547, -11558, -10615, -9712, -8841, -8000, -7189, -6397, -5620, -4853, -4082, -3309, -2515, -1744, -1192, -442, 4593, 5688, 6683, 7663, 8663, 9686, 10704, 11678, 12597, 13471, 14319, 15166, 16014, 16851, 17645, 18396, 19137, 19856, 20563, 21256, 21937, 22593, 23223, 23812, 24369, 24923, 25468, 25996, 26502, 26988, 27449, 27887, 28309, 28711, 29095, 29461, 29806, 30130, 30433, 30718, 30985, 31235, 31466, 31678, 31870, 32042, 32196, 32331, 32451, 32544, 32676, 32763, 32740, 32861, 31087, 29189, 28122, 26926, 25633, 24370, 23275, 22383, 21614, 20845, 19996, 19083, 18178, 17356, 16643, 15999, 15360, 14684, 13962, 13231, 12533, 11884, 11278, 10683, 10083, 9425, 8637, 7975, 7384, 6831, 6295, 5760, 5220, 4677, 4139, 3615, 3103, 2599, 2097, 1594, 1090, 593, 103, -371, -834, -1301, -1767, -2233, -2695, -3149, -3598, -4042, -4480, -4917, -5349, -5777, -6201, -6620, -7034, -7439, -7883, -8157, -8236, -8713, -9295, -9872, -10380, -10807, -11168, -11496, -11816, -12143, -12486, -12846, -13216, -13587, -13957, -14318, -14670, -15016, -15358, -15694, -16030, -16363, -16694, -17023, -17349, -17672, -17991, -18307, -18619, -18928, -19234, -19537, -19836, -20132, -20424, -20716, -21003, -21286, -21486, -21722, -21995, -22275, -22555, -22834, -23111, -23383, -23650, -23915, -24176, -24433, -24686, -24937, -25173, -25468, -25451, -24943, -24982, -25018, -25023, -25034, -25101, -25245, -25430, -25642, -25864, -26008, -26137, -26285, -26463, -26663, -26865, -27050, -27207, -27389, -27740, -27916, -28005, -28088, -28193, -28328, -28497, -28684, -28880, -29078, -29264, -29434, -29589, -29734, -29877, -30022, -30167, -30313, -30459, -30598, -30729, -30857, -30982, -31103, -31224, -31339, -31446, -31548, -31645, -31738, -31827, -31912, -31991, -32069, -32140, -32203, -32261, -32314, -32362, -32403, -32439, -32469, -32493, -32493, -32560, -32387, -28357, -25472, -23429, -21137, -18714, -16416, -14478, -12914, -11530, -10104, -8531, -6863, -5253, -3827, -2594, -1473, -346, 863, 2158, 3444};