/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0142 512 samples */
 
const int16_t AKWF_stereo_0142_512_DATA [512] = 
{675, 2362, 3851, 5197, 6485, 7577, 8437, 9046, 9855, 10962, 12013, 13088, 14281, 15546, 16793, 18001, 19140, 20190, 21146, 21952, 22655, 23357, 24070, 24798, 25500, 26188, 26840, 27439, 28008, 28484, 28833, 29117, 29367, 29594, 29864, 30176, 30508, 30811, 31042, 31227, 31396, 31555, 31711, 31962, 32394, 32482, 32563, 32635, 32680, 32737, 32795, 32571, 31045, 30880, 31035, 30925, 30824, 30704, 30529, 30280, 30017, 29763, 29527, 29314, 29181, 29114, 29000, 28844, 28550, 28130, 27726, 27419, 27160, 26877, 26648, 26605, 27760, 27993, 27517, 27465, 27395, 27331, 27324, 27344, 27340, 27284, 27170, 27011, 26855, 26718, 26595, 26483, 26457, 26452, 26384, 26233, 26030, 25883, 25772, 25589, 25397, 25215, 25007, 24761, 24532, 24300, 23983, 23511, 22943, 22415, 21976, 21567, 21101, 20494, 19776, 18993, 18234, 17480, 16634, 15686, 14620, 13431, 12143, 10879, 9522, 8002, 6462, 4804, 2811, 723, -1189, -2814, -4245, -5492, -6486, -7296, -8027, -9000, -10038, -11105, -12374, -13673, -14925, -16124, -17248, -18415, -19597, -20664, -21631, -22553, -23464, -24416, -25296, -25970, -26480, -26942, -27424, -27929, -28441, -28942, -29393, -29745, -30081, -30395, -30615, -30758, -30887, -31058, -31276, -31468, -31618, -31779, -31939, -32148, -31759, -30836, -30662, -30643, -30648, -30694, -30683, -30582, -30431, -30291, -30154, -30016, -29839, -29645, -29527, -29443, -29318, -29192, -29080, -28883, -28686, -28547, -28449, -28395, -28417, -28543, -29542, -29943, -29447, -29254, -29107, -29037, -29003, -28987, -28972, -28917, -28865, -28814, -28702, -28542, -28453, -28424, -28400, -28367, -28241, -28109, -28076, -28057, -27969, -27814, -27647, -27527, -27435, -27339, -27200, -26935, -26559, -26149, -25727, -25289, -24831, -24427, -24065, -23585, -22947, -22267, -21630, -21025, -20415, -19755, -18882, -17822, -16712, -15545, -14269, -12837, -11239, -9377, -7285, -5207, -3161, -1135, -14891, -13282, -11614, -9962, -7998, -5807, -3474, 64, 4134, 6811, 8729, 10726, 12840, 14767, 16493, 17985, 19168, 20176, 21201, 22070, 22873, 23758, 24726, 25680, 26527, 27343, 28056, 28748, 29471, 29990, 30297, 30478, 30597, 30840, 31228, 31522, 31737, 31923, 31986, 32010, 32088, 32189, 32240, 32303, 32595, 32735, 32671, 32595, 32571, 32565, 32468, 32120, 30547, 29521, 29482, 29427, 29297, 29121, 28837, 28541, 28256, 27750, 27193, 26754, 26494, 26331, 26152, 26047, 25707, 25065, 24454, 24082, 23720, 23278, 22953, 22866, 23832, 24666, 24522, 24468, 24469, 24560, 24593, 24589, 24637, 24826, 25046, 25256, 25425, 25505, 25552, 25545, 25627, 25773, 25829, 25796, 25721, 25794, 26042, 26260, 26510, 26710, 26852, 26950, 27002, 26982, 26908, 26703, 26414, 26288, 26284, 26120, 25839, 25485, 25081, 24694, 24368, 24057, 23688, 23273, 22766, 22204, 21534, 20765, 19773, 18705, 17714, 16538, 15010, 13421, 11819, 10054, 8204, 6123, 3780, 770, -3308, -6768, -9258, -11245, -13081, -14594, -15814, -16938, -17987, -19143, -20425, -21609, -22595, -23493, -24477, -25515, -26395, -27031, -27565, -28075, -28671, -29298, -29857, -30343, -30709, -30941, -31099, -31189, -31244, -31293, -31354, -31464, -31605, -31669, -31646, -31668, -31691, -31639, -31134, -30006, -29385, -29199, -29167, -29222, -29148, -28887, -28486, -28100, -27690, -27191, -26730, -26432, -26279, -26190, -26137, -26151, -26016, -25602, -25216, -24997, -24881, -24785, -24805, -25028, -25833, -26552, -26292, -26003, -25868, -25763, -25666, -25681, -25720, -25907, -26247, -26445, -26522, -26511, -26557, -26642, -26721, -26824, -26878, -26992, -27142, -27285, -27472, -27582, -27654, -27778, -27898, -28009, -28027, -27934, -27856, -27912, -28086, -28091, -27948, -27856, -27689, -27393, -27020, -26733, -26455, -26105, -25785, -25567, -25278, -24783, -24142, -23482, -22881, -22246, -21530, -20598, -19475, -18376, -17289, -16106};