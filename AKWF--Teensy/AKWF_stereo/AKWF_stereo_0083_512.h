/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0083 512 samples */
 
const int16_t AKWF_stereo_0083_512_DATA [512] = 
{2470, 3587, 3447, 3570, 3930, 4354, 4720, 5199, 5581, 5691, 6182, 7556, 8865, 9106, 9511, 10041, 10696, 11472, 12290, 13089, 13868, 14555, 15353, 16190, 17037, 17866, 18648, 19362, 20008, 20535, 21450, 19728, 19324, 13670, -3503, -2500, -2010, -1628, -1537, -1616, -1762, -1981, -2289, -1781, -2304, -3167, -3946, -4684, -5410, -6184, -7026, -7917, -8834, -9715, -10520, -11236, -11981, -12728, -13457, -14148, -14782, -15344, -15836, -16303, -16443, -19161, -20700, -18117, -6388, -4681, -3972, -3213, -2697, -2377, -2101, -1993, -1595, -1706, -1262, -445, 275, 945, 1573, 2194, 2830, 3474, 4138, 4788, 5344, 5866, 6364, 6845, 7309, 7746, 8143, 8495, 8799, 9208, 8650, 14332, 17900, 15014, 13802, 12973, 12238, 11560, 10916, 10331, 9766, 9211, 8860, 8948, 8925, 8650, 8445, 8260, 8084, 7925, 7781, 7658, 7553, 7453, 7414, 7393, 7386, 7431, 7253, 8350, 10053, 9994, 10242, 9300, 9384, 6967, 4000, 7486, 8815, 8922, 9202, 9665, 10326, 11065, 11843, 12806, 13215, 13435, 13556, 13616, 13655, 13696, 13753, 13825, 13893, 13960, 14020, 14076, 14092, 14091, 14082, 14066, 14045, 14021, 13990, 13962, 13934, 12933, 12561, 14074, 16732, 15096, 14321, 14687, 14807, 14748, 14495, 14086, 13722, 13188, 12989, 12956, 12977, 13034, 13099, 13152, 13189, 13030, 14019, 9585, -3080, -3130, -3225, -3297, -3475, -3688, -3881, -4054, -4249, -4458, -4932, -2815, -2425, -3471, -4305, -4606, -5005, -6131, -7071, -7802, -8348, -8754, -9044, -9198, -9495, -9896, -10288, -10668, -11017, -11327, -11603, -12065, -11096, -18901, -26580, -25979, -26262, -26433, -26733, -26578, -26523, -26852, -27073, -27786, -27953, -29455, -30312, -29744, -29428, -29189, -29065, -29037, -29067, -29139, -29173, -29150, -29303, -29481, -29680, -29886, -30085, -30273, -30452, -30625, -30796, -30446, -33367, -18624, -8467, -6158, -2926, 1458, 5401, 7725, 8408, 8550, 9031, 10398, 12365, 14097, 15098, 15414, 15366, 15523, 16178, 17220, 18277, 19007, 19322, 19401, 19492, 19788, 20274, 20796, 21185, 21370, 21407, 21426, 21466, 21639, 23138, 18079, 5001, 4157, 1836, -1203, -4038, -5791, -6378, -6425, -6718, -7757, -9156, -10453, -11257, -11485, -11428, -11486, -11890, -12590, -13334, -13874, -14128, -14199, -14262, -14456, -14788, -15156, -15440, -15584, -15618, -15618, -15693, -15466, -15814, -14905, -6988, -5456, -3908, -1981, -265, 750, 1013, 939, 997, 1551, 2406, 3256, 3845, 4083, 4113, 4175, 4429, 4870, 5359, 5750, 5981, 6094, 6198, 6376, 6644, 6945, 7206, 7388, 7505, 7588, 7796, 7367, 7180, 6923, 7366, 8062, 8547, 8842, 8982, 9026, 9033, 9045, 9063, 9072, 9126, 9229, 9328, 9411, 9473, 9511, 9535, 9553, 9572, 9596, 9618, 9635, 9646, 9678, 9538, 10294, 11488, 11523, 11759, 12185, 12472, 12940, 13188, 14649, 14534, 13263, 12505, 12178, 12216, 12464, 12770, 13016, 13234, 13367, 13415, 13399, 13350, 13307, 13296, 13326, 13386, 13454, 13509, 13542, 13560, 13571, 13585, 13605, 13627, 13650, 13666, 13676, 13686, 13803, 13854, 13673, 13542, 12622, 12412, 13357, 13996, 14351, 14411, 14281, 14068, 13899, 13775, 13725, 13742, 13793, 13850, 13892, 13912, 13786, 14457, 11277, 2184, 1588, 113, -1910, -3854, -5091, -5522, -5545, -5703, -6296, -7199, -8365, -9011, -9085, -9075, -8559, -8442, -9398, -10245, -10810, -11003, -10942, -10827, -10826, -10952, -11154, -11345, -11467, -11517, -11540, -11577, -11800, -11037, -16507, -22004, -22111, -23550, -25252, -26730, -27614, -27871, -27865, -28067, -28574, -29346, -29879, -30174, -30318, -30317, -30406, -30684, -31096, -31497, -31763, -31873, -31904, -31935, -32045, -32223, -32411, -32542, -32596, -32599, -32596, -32621, -32310, -34341, -23795};