/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0159 512 samples */
 
const int16_t AKWF_stereo_0159_512_DATA [512] = 
{202, 359, 516, 667, 819, 970, 1104, 1232, 1364, 1503, 1626, 1753, 1884, 1994, 2110, 2233, 2341, 2446, 2554, 2662, 2767, 2869, 2965, 3056, 3147, 3244, 3326, 3408, 3499, 3577, 3657, 3798, 3720, 4172, 22657, 29199, 28969, 29845, 30427, 30934, 31389, 31760, 32068, 32318, 32508, 32643, 32724, 32760, 32762, 32714, 32632, 32510, 32365, 32175, 31959, 31729, 31469, 31188, 30884, 30559, 30219, 29860, 29494, 29111, 28712, 28306, 27896, 27466, 27039, 26602, 26144, 25680, 25240, 24779, 24324, 23853, 23387, 22921, 22450, 21979, 21513, 21045, 20573, 20111, 19645, 19183, 18729, 18282, 17821, 17373, 16920, 16481, 16042, 15606, 15178, 14751, 14328, 13910, 13500, 13084, 12682, 12295, 11885, 11495, 11123, 10745, 10369, 10006, 9645, 9284, 8937, 8596, 8251, 7916, 7588, 7268, 6947, 6638, 6335, 6033, 5733, 5442, 5162, 4884, 4608, 4349, 4083, 3825, 3576, 3325, 3087, 2851, 2631, 2403, 2158, 1943, 1742, 1535, 1336, 1132, 933, 622, 824, -2086, -20983, -29745, -29495, -30286, -30801, -31233, -31571, -31837, -32026, -32148, -32208, -32210, -32165, -32067, -31925, -31742, -31525, -31269, -30971, -30648, -30300, -29939, -29565, -29148, -28714, -28268, -27819, -27351, -26862, -26373, -25878, -25371, -24861, -24349, -23823, -23304, -22771, -22255, -21727, -21197, -20671, -20146, -19617, -19095, -18575, -18063, -17540, -17030, -16533, -16021, -15528, -15035, -14533, -14056, -13588, -13110, -12637, -12172, -11709, -11262, -10818, -10373, -9938, -9508, -9082, -8657, -8246, -7838, -7435, -7033, -6647, -6257, -5884, -5510, -5141, -4777, -4417, -4067, -3717, -3376, -3086, -2592, -2806, -11721, -16178, -15518, -15475, -15337, -15209, -15075, -14957, -14851, -14745, -14645, -14560, -14467, -14378, -14306, -14233, -14170, -14110, -14057, -14010, -13965, -13932, -13897, -13869, -13850, -13780, -13924, -13395, -4286, 304, 414, 525, 619, 719, 818, 904, 990, 1075, 1165, 1248, 1331, 1416, 1491, 1568, 1650, 1723, 1794, 1867, 1939, 2012, 2081, 2147, 2211, 2275, 2342, 2401, 2460, 2524, 2581, 2640, 2733, 2700, 2975, 13760, 17585, 17464, 17987, 18339, 18646, 18924, 19153, 19345, 19504, 19629, 19721, 19782, 19817, 19832, 19818, 19785, 19727, 19657, 19561, 19449, 19330, 19194, 19046, 18882, 18710, 18527, 18333, 18135, 17928, 17711, 17492, 17269, 17035, 16803, 16565, 16316, 16062, 15825, 15573, 15325, 15068, 14815, 14561, 14304, 14049, 13797, 13544, 13288, 13037, 12785, 12536, 12292, 12050, 11803, 11562, 11320, 11083, 10849, 10617, 10388, 10161, 9936, 9715, 9497, 9277, 9066, 8864, 8648, 8444, 8249, 8053, 7859, 7672, 7485, 7300, 7122, 6948, 6772, 6604, 6438, 6277, 6116, 5962, 5813, 5664, 5516, 5374, 5239, 5105, 4972, 4850, 4724, 4603, 4487, 4370, 4262, 4154, 4056, 3954, 3843, 3748, 3663, 3573, 3490, 3404, 3320, 3171, 3323, 1659, -9320, -14393, -14211, -14638, -14904, -15121, -15280, -15400, -15474, -15510, -15508, -15471, -15408, -15314, -15193, -15046, -14881, -14693, -14478, -14251, -14008, -13757, -13499, -13214, -12919, -12617, -12313, -11998, -11669, -11342, -11009, -10669, -10327, -9984, -9632, -9284, -8927, -8579, -8224, -7868, -7514, -7160, -6803, -6449, -6097, -5749, -5393, -5046, -4705, -4354, -4015, -3676, -3331, -2998, -2672, -2340, -2009, -1682, -1358, -1040, -725, -409, -97, 210, 515, 823, 1121, 1420, 1714, 2009, 2297, 2585, 2865, 3147, 3424, 3703, 3977, 4246, 4519, 4783, 4930, 5575, 4572, -16715, -27618, -26537, -26903, -27044, -27192, -27340, -27496, -27664, -27832, -28005, -28193, -28373, -28560, -28762, -28961, -29173, -29386, -29604, -29831, -30057, -30298, -30538, -30783, -31042, -31177, -31808, -30849, -9880};