/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0133 512 samples */
 
const int16_t AKWF_stereo_0133_512_DATA [512] = 
{690, 2040, 3389, 4805, 6346, 8068, 9974, 11973, 13965, 15854, 17582, 19139, 20522, 21734, 22801, 23742, 24572, 25304, 25935, 26443, 26803, 26998, 27046, 26987, 26861, 26670, 26390, 25999, 25498, 24913, 24283, 23630, 22954, 22261, 21557, 20855, 20167, 19494, 18836, 18202, 17598, 17027, 16480, 15930, 15365, 14781, 14188, 13599, 13023, 12469, 11946, 11457, 10999, 10570, 10198, 9929, 9806, 9831, 9970, 10152, 10305, 10368, 10301, 10085, 9714, 9194, 8524, 7715, 6792, 5779, 4691, 3526, 2262, 885, -592, -2159, -3789, -5463, -7195, -8991, -10839, -12716, -14578, -16382, -18117, -19769, -21334, -22813, -24189, -25447, -26583, -27591, -28477, -29251, -29907, -30445, -30871, -31198, -31454, -31663, -31844, -31987, -32045, -31954, -31667, -31177, -30489, -29554, -28297, -26688, -24786, -22727, -20636, -18556, -16498, -14456, -12426, -10444, -8546, -6741, -5049, -3484, -2052, -768, 388, 1459, 2469, 3424, 4301, 5066, 5702, 6208, 6596, 6886, 7085, 7203, 7268, 7322, 7402, 7520, 7669, 7852, 8090, 8401, 8785, 9219, 9673, 10124, 10570, 11016, 11474, 11958, 12479, 13039, 13644, 14289, 14990, 15789, 16730, 17828, 19044, 20289, 21483, 22575, 23541, 24381, 25090, 25656, 26072, 26334, 26441, 26394, 26185, 25805, 25241, 24510, 23644, 22676, 21633, 20512, 19280, 17915, 16402, 14742, 12963, 11094, 9143, 7126, 5050, 2919, 771, -1365, -3474, -5536, -7553, -9514, -11396, -13198, -14917, -16540, -18079, -19540, -20925, -22217, -23354, -24266, -24923, -25333, -25522, -25495, -25253, -24823, -24275, -23703, -23178, -22712, -22263, -21780, -21245, -20706, -20222, -19821, -19486, -19177, -18869, -18572, -18322, -18149, -18059, -18024, -18003, -17974, -17947, -17939, -17950, -17966, -17948, -17864, -17681, -17381, -16963, -16432, -15811, -15102, -14276, -13309, -12200, -10987, -9720, -8435, -7145, -5861, -4572, -3266, -1948, -600, -836, 678, 2194, 3773, 5452, 7271, 9221, 11224, 13193, 15052, 16750, 18278, 19635, 20842, 21954, 22997, 23975, 24877, 25677, 26349, 26874, 27226, 27402, 27417, 27292, 27039, 26653, 26134, 25496, 24777, 24023, 23264, 22504, 21747, 21005, 20299, 19644, 19031, 18448, 17889, 17344, 16808, 16273, 15722, 15148, 14554, 13949, 13347, 12771, 12234, 11752, 11327, 10951, 10629, 10383, 10254, 10274, 10433, 10675, 10916, 11075, 11104, 10994, 10751, 10392, 9927, 9352, 8663, 7863, 6960, 5958, 4861, 3653, 2320, 872, -684, -2331, -4050, -5857, -7757, -9730, -11739, -13712, -15594, -17382, -19078, -20692, -22230, -23668, -24983, -26170, -27232, -28188, -29053, -29821, -30484, -31039, -31490, -31858, -32166, -32432, -32647, -32764, -32722, -32485, -32059, -31452, -30620, -29476, -27985, -26204, -24271, -22321, -20405, -18528, -16674, -14819, -12981, -11186, -9442, -7770, -6189, -4710, -3351, -2100, -927, 183, 1228, 2186, 3025, 3730, 4304, 4758, 5113, 5390, 5603, 5780, 5946, 6115, 6289, 6469, 6668, 6919, 7243, 7644, 8108, 8604, 9099, 9585, 10059, 10544, 11062, 11630, 12249, 12918, 13629, 14392, 15241, 16215, 17332, 18563, 19837, 21087, 22262, 23326, 24264, 25061, 25695, 26169, 26483, 26648, 26669, 26540, 26257, 25819, 25239, 24540, 23734, 22832, 21828, 20700, 19432, 18018, 16464, 14799, 13051, 11232, 9356, 7427, 5437, 3411, 1366, -683, -2716, -4725, -6699, -8610, -10453, -12213, -13864, -15406, -16845, -18187, -19435, -20557, -21511, -22275, -22843, -23213, -23370, -23302, -23018, -22571, -22054, -21545, -21079, -20648, -20224, -19792, -19381, -19030, -18755, -18525, -18286, -18014, -17736, -17507, -17371, -17332, -17372, -17457, -17570, -17710, -17881, -18083, -18297, -18483, -18589, -18574, -18418, -18112, -17659, -17072, -16362, -15526, -14570, -13511, -12378, -11208, -10029, -8850, -7660, -6426, -5117, -3734, -2267};