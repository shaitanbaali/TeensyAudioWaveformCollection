/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0163 512 samples */
 
const int16_t AKWF_stereo_0163_512_DATA [512] = 
{332, 1126, 1879, 2661, 3473, 4303, 5141, 5987, 6837, 7690, 8539, 9393, 10247, 11093, 11930, 12663, 13179, 13619, 14194, 14884, 15641, 16435, 17243, 18062, 18895, 19729, 20545, 21373, 22201, 23017, 23818, 24569, 25306, 26052, 26788, 27092, 26399, 25067, 24303, 24437, 24872, 25483, 26190, 26916, 27647, 28371, 29108, 29888, 30675, 31359, 31980, 33464, 8576, -20788, -15982, -13863, -14698, -13802, -13144, -12522, -11800, -11056, -10289, -9492, -8667, -7829, -6973, -6101, -5263, -4491, -4410, -5413, -5816, -5839, -6419, -6491, -5978, -5249, -4853, -5384, -4834, -3758, -3401, -3824, -4703, -5696, -5792, -5360, -4786, -4097, -3335, -2567, -1845, -1112, -342, 413, 1176, 1958, 2699, 3408, 4153, 4869, 4825, 4145, 3192, 2596, 2793, 3267, 3869, 4552, 5264, 6003, 6106, 5480, 5443, 5907, 6475, 7029, 7932, 7833, -13346, -29574, -25353, -24938, -25302, -24663, -24217, -23741, -23257, -22786, -22267, -21725, -21164, -20546, -19859, -19132, -18394, -17681, -17091, -16544, -15939, -15262, -14549, -13807, -13053, -12342, -11652, -10937, -10195, -9449, -8697, -7933, -7179, -6443, -5878, -6415, -7289, -7237, -6824, -6313, -5687, -5510, -5985, -6043, -5704, -5268, -4731, -4100, -4202, -4578, -3938, -3293, -2718, -2101, -1512, -895, -263, 369, -5, -1956, -3113, -3233, -3092, -2733, -2250, -1757, -1217, -619, 2, 642, 1294, 1942, 2590, 3243, 3902, 4559, 5206, 5799, 6383, 7014, 7669, 8327, 8975, 9627, 10322, 10685, 9242, 7351, 6892, 7016, 7328, 7799, 8323, 8901, 8517, 7111, 6625, 6853, 7211, 7699, 8273, 8876, 9486, 10119, 10729, 11239, 11754, 12344, 12798, 14274, 7805, -11574, -13758, -10866, -11431, -11029, -10456, -9961, -9368, -8743, -8092, -7409, -6701, -5982, -5236, -4531, -3908, -3208, -2999, -3599, -3694, -3233, -2658, -1985, -1243, -454, 12615, 12844, 12490, 12562, 13059, 13641, 14277, 14964, 15677, 16387, 17098, 17826, 18548, 19241, 19987, 20075, 18007, 14944, 13301, 13008, 13163, 13583, 14152, 14787, 15478, 16192, 16907, 17641, 18378, 19127, 19686, 19412, 19112, 19448, 19992, 20608, 21269, 21958, 22669, 23372, 24059, 24754, 25448, 26055, 26006, 25625, 25749, 26145, 26578, 26972, 27409, 28641, 7605, -17523, -14126, -12570, -13309, -12585, -12040, -11555, -11050, -10537, -10005, -9469, -8902, -8292, -7645, -6961, -6258, -5532, -4783, -4080, -3453, -2819, -2141, -1437, -894, 705, -4662, -25840, -30157, -26846, -27393, -27158, -26634, -26271, -25834, -25369, -24949, -24507, -23984, -23409, -22820, -22173, -21616, -21709, -21865, -21548, -21083, -20544, -19915, -19257, -18590, -17902, -17191, -16495, -15802, -15087, -14405, -13774, -13143, -12490, -11840, -11175, -10489, -9815, -9141, -8458, -7779, -7111, -6452, -5827, -5243, -4655, -4049, -3441, -2837, -2227, -1613, -1011, -452, 83, 629, 1190, 1763, 2341, 2946, 3115, 2515, 2285, 2556, 2925, 3371, 3816, 4226, 4668, 5146, 5637, 6140, 6612, 7039, 7465, 7922, 7867, 7290, 7206, 7490, 7838, 8248, 8707, 9181, 9652, 10136, 10625, 11102, 11544, 11948, 12914, 2421, -11867, -10234, -9100, -9560, -9623, -10322, -10595, -10435, -10193, -9865, -9480, -9067, -8630, -8179, -7692, -7349, -7772, -8245, -8123, -7804, -7415, -6961, -6499, -6080, -5677, -5246, -4752, -4481, -5231, -5961, -5905, -5626, -5257, -4804, -4317, -3811, -3294, -2770, -2236, -1699, -1156, -604, -49, 511, 1075, 1609, 2105, 2605, 3136, 3673, 4175, 4619, 5033, 5464, 5972, 6416, 6044, 5422, 5445, 5742, 6101, 6448, 6739, 7073, 7511, 8028, 8586, 9174, 9795, 10430, 11060, 11708, 12370, 13020, 13670, 14377, 14221, 12715, 12029, 11618, 10425, 9913, 10082, 10402, 10870, 11432, 12014};