/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0134 512 samples */
 
const int16_t AKWF_stereo_0134_512_DATA [512] = 
{1321, 3564, 5817, 8099, 10371, 12610, 14791, 16883, 18881, 20777, 22558, 24231, 25793, 27234, 28553, 29734, 30753, 31589, 32218, 32615, 32768, 32663, 32301, 31680, 30811, 29706, 28367, 26810, 25043, 23077, 20942, 18673, 16314, 13935, 11597, 9358, 7281, 5400, 3741, 2324, 1141, 179, -580, -1171, -1623, -1968, -2240, -2468, -2676, -2886, -3108, -3344, -3595, -3852, -4111, -4367, -4620, -4872, -5130, -5397, -5678, -5975, -6284, -6605, -6933, -7265, -7600, -7940, -8292, -8669, -9091, -9583, -10169, -10871, -11692, -12632, -13668, -14763, -15876, -16955, -17953, -18832, -19558, -20102, -20453, -20601, -20545, -20295, -19865, -19274, -18548, -17718, -16811, -15850, -14863, -13864, -12866, -11883, -10919, -9973, -9043, -8118, -7179, -6212, -5194, -4107, -2943, -1690, -351, 1062, 2541, 4066, 5609, 7149, 8652, 10086, 11423, 12626, 13664, 14511, 15139, 15520, 15632, 15451, 14961, 14149, 13023, 11604, 9927, 8059, 6065, 4026, 2030, 150, -1549, -3014, -4222, -5159, -5829, -6250, -6439, -6417, -6202, -5813, -5262, -4559, -3714, -2740, -1641, -436, 858, 2231, 3658, 5119, 6604, 8091, 9565, 11019, 12431, 13793, 15094, 16319, 17461, 18515, 19470, 20327, 21082, 21729, 22263, 22671, 22932, 23019, 22899, 22533, 21883, 20915, 19610, 17955, 15966, 13677, 11129, 8393, 5547, 2656, -186, -2899, -5419, -7671, -9608, -11211, -12472, -13407, -14061, -14479, -14716, -14823, -14836, -14782, -14676, -14523, -14321, -14070, -13774, -13434, -13061, -12667, -12265, -11870, -11498, -11155, -10850, -10583, -10349, -10140, -9942, -9741, -9525, -9288, -9026, -8746, -8458, -8179, -7933, -7748, -7655, -7683, -7861, -8204, -8719, -9400, -10229, -11175, -12204, -13283, -14364, -15412, -16382, -17229, -17912, -18392, -18639, -18636, -18380, -17883, -17165, -16260, -15202, -14015, -12721, -11332, -9842, -8253, -6557, -4746, -2827, -754, -391, 1913, 4231, 6578, 8912, 11208, 13439, 15573, 17606, 19524, 21314, 22984, 24531, 25949, 27243, 28404, 29419, 30276, 30955, 31434, 31691, 31709, 31468, 30962, 30188, 29156, 27874, 26365, 24653, 22761, 20732, 18610, 16437, 14280, 12185, 10195, 8360, 6698, 5227, 3959, 2885, 1997, 1281, 715, 277, -55, -311, -516, -693, -867, -1056, -1271, -1520, -1800, -2109, -2443, -2793, -3149, -3507, -3857, -4194, -4519, -4833, -5144, -5466, -5811, -6191, -6619, -7103, -7652, -8274, -8978, -9776, -10671, -11658, -12729, -13865, -15026, -16187, -17307, -18350, -19293, -20111, -20785, -21300, -21642, -21797, -21756, -21513, -21073, -20445, -19647, -18709, -17657, -16527, -15355, -14166, -12992, -11851, -10753, -9704, -8697, -7714, -6740, -5750, -4720, -3633, -2469, -1218, 121, 1552, 3065, 4637, 6248, 7862, 9436, 10933, 12299, 13486, 14458, 15173, 15600, 15717, 15512, 14981, 14133, 12995, 11600, 9990, 8227, 6361, 4450, 2554, 725, -989, -2539, -3896, -5029, -5918, -6558, -6949, -7096, -7014, -6719, -6228, -5557, -4721, -3738, -2613, -1367, -20, 1417, 2916, 4458, 6028, 7599, 9155, 10682, 12153, 13557, 14884, 16114, 17245, 18274, 19199, 20028, 20765, 21413, 21974, 22439, 22784, 22980, 22987, 22758, 22245, 21408, 20226, 18683, 16801, 14624, 12198, 9603, 6917, 4207, 1555, -970, -3325, -5453, -7328, -8942, -10293, -11399, -12296, -13012, -13580, -14027, -14362, -14592, -14710, -14708, -14579, -14326, -13956, -13487, -12945, -12361, -11763, -11184, -10651, -10182, -9793, -9490, -9265, -9106, -8994, -8902, -8806, -8688, -8531, -8334, -8104, -7857, -7619, -7424, -7309, -7312, -7470, -7805, -8331, -9047, -9936, -10964, -12098, -13286, -14474, -15615, -16655, -17545, -18251, -18743, -19004, -19035, -18844, -18452, -17877, -17147, -16281, -15286, -14169, -12929, -11552, -10037, -8377, -6571, -4633, -2518};