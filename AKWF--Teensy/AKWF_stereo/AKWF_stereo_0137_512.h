/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0137 512 samples */
 
const int16_t AKWF_stereo_0137_512_DATA [512] = 
{799, 2224, 3641, 5072, 6505, 7937, 9363, 10772, 12163, 13534, 14873, 16186, 17466, 18707, 19913, 21080, 22203, 23286, 24325, 25318, 26268, 27174, 28032, 28848, 29618, 30342, 31023, 31667, 32208, 32477, 32668, 32772, 32703, 32506, 32192, 31765, 31228, 30587, 29848, 29026, 28124, 27155, 26131, 25055, 23934, 22784, 21602, 20400, 19187, 17961, 16732, 15507, 14283, 13070, 11872, 10688, 9523, 8381, 7260, 6166, 5100, 4060, 3053, 2075, 1127, 214, -666, -1516, -2331, -3114, -3865, -4581, -5267, -5920, -6540, -7130, -7689, -8217, -8717, -9187, -9629, -10044, -10432, -10792, -11129, -11441, -11727, -11992, -12235, -12455, -12655, -12835, -12995, -13138, -13261, -13367, -13457, -13531, -13590, -13633, -13664, -13682, -13686, -13678, -13659, -13629, -13588, -13537, -13478, -13408, -13331, -13245, -13152, -13051, -12943, -12830, -12711, -12585, -12454, -12319, -12179, -12033, -11885, -11732, -11576, -11417, -11255, -11090, -10922, -10752, -10581, -10407, -10232, -10055, -9875, -9696, -9515, -9333, -9151, -8968, -8783, -8599, -8415, -8230, -8045, -7860, -7676, -7491, -7306, -7122, -6939, -6754, -6571, -6389, -6207, -6026, -5845, -5664, -5485, -5307, -5129, -4952, -4775, -4600, -4426, -4251, -4079, -3908, -3736, -3566, -3397, -3229, -3062, -2895, -2731, -2566, -2403, -2241, -2079, -1918, -1759, -1599, -1442, -1284, -1129, -973, -819, -665, -513, -361, -210, -59, 89, 237, 386, 532, 679, 824, 969, 1114, 1258, 1401, 1542, 1686, 1818, 1859, 1866, 1863, 1801, 1695, 1551, 1371, 1152, 895, 604, 279, -73, -452, -857, -1282, -1726, -2188, -2662, -3149, -3648, -4155, -4667, -5187, -5708, -6233, -6760, -7285, -7809, -8334, -8854, -9372, -9886, -10396, -10890, -11297, -11601, -11657, -11618, -11480, -11165, -10715, -10145, -9453, -8645, -7730, -6714, -5611, -4436, -3195, -1904, -540, -21409, -19961, -18495, -16987, -15454, -13902, -12335, -10769, -9203, -7642, -6100, -4572, -3066, -1589, -137, 1281, 2662, 4011, 5321, 6588, 7817, 9004, 10146, 11248, 12306, 13318, 14288, 15218, 16063, 16694, 17259, 17745, 18094, 18335, 18480, 18530, 18487, 18357, 18144, 17856, 17502, 17087, 16620, 16107, 15551, 14962, 14342, 13698, 13035, 12356, 11666, 10970, 10269, 9568, 8870, 8175, 7489, 6812, 6145, 5491, 4852, 4228, 3621, 3032, 2460, 1907, 1374, 859, 367, -104, -557, -989, -1400, -1791, -2161, -2511, -2843, -3152, -3445, -3717, -3971, -4207, -4424, -4625, -4809, -4976, -5127, -5263, -5383, -5489, -5580, -5657, -5722, -5774, -5813, -5840, -5856, -5860, -5854, -5838, -5811, -5776, -5731, -5677, -5616, -5546, -5469, -5384, -5293, -5194, -5089, -4978, -4863, -4741, -4613, -4481, -4344, -4203, -4058, -3908, -3755, -3598, -3438, -3274, -3107, -2937, -2766, -2592, -2414, -2235, -2053, -1870, -1684, -1497, -1308, -1118, -926, -732, -537, -341, -144, 53, 251, 451, 651, 852, 1055, 1257, 1461, 1664, 1869, 2074, 2279, 2484, 2691, 2897, 3104, 3312, 3519, 3726, 3935, 4143, 4352, 4561, 4770, 4978, 5189, 5398, 5608, 5818, 6029, 6239, 6450, 6661, 6873, 7084, 7295, 7508, 7721, 7932, 8145, 8359, 8571, 8785, 8999, 9213, 9428, 9643, 9858, 10074, 10290, 10505, 10724, 10941, 11159, 11377, 11596, 11815, 12036, 12256, 12478, 12700, 12920, 13147, 13346, 13297, 13157, 12985, 12658, 12211, 11662, 11012, 10259, 9404, 8457, 7421, 6304, 5120, 3867, 2558, 1202, -203, -1642, -3114, -4616, -6136, -7674, -9227, -10784, -12349, -13918, -15481, -17042, -18598, -20142, -21678, -23201, -24712, -26183, -27394, -28447, -29283, -29922, -30382, -30623, -30677, -30550, -30245, -29770, -29137, -28357, -27445, -26419, -25287, -24069, -22742};