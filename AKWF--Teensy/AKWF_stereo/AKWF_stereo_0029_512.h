/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0029 512 samples */
 
const int16_t AKWF_stereo_0029_512_DATA [512] = 
{284, 831, 1294, 1717, 2141, 2593, 3102, 3668, 4283, 4920, 5546, 6143, 6689, 7175, 7609, 7995, 8345, 8681, 9015, 9321, 9583, 9835, 10132, 10521, 11023, 11645, 12398, 13275, 14265, 15308, 16306, 17252, 18154, 18993, 19761, 20468, 21126, 21720, 22234, 22679, 23068, 23401, 23695, 23947, 24174, 24427, 24737, 25079, 25426, 25784, 26196, 26686, 27251, 27880, 28554, 29251, 29946, 30622, 31242, 31794, 32249, 32579, 32751, 32739, 32534, 32159, 31636, 30946, 30079, 29071, 28001, 26929, 25824, 24720, 23661, 22644, 21667, 20723, 19819, 19017, 18280, 17571, 16898, 16267, 15674, 15142, 14765, 14427, 14014, 13510, 12918, 12270, 11600, 10922, 10248, 9606, 9044, 8579, 8159, 7753, 7400, 7116, 6916, 6820, 6805, 6835, 6884, 6936, 6980, 6981, 6890, 6705, 6451, 6122, 5705, 5198, 4602, 3929, 3168, 2291, 1316, 274, -827, -1976, -3175, -4406, -5626, -6743, -7658, -8409, -9016, -9464, -9775, -10037, -10282, -10536, -10794, -11077, -11398, -11775, -12212, -12703, -13237, -13813, -14421, -15037, -15635, -16227, -16814, -17349, -17816, -18245, -18663, -19076, -19468, -19802, -20062, -20250, -20372, -20450, -20491, -20512, -20518, -20499, -20458, -20419, -20406, -20377, -20319, -20226, -20140, -20109, -20110, -20094, -20023, -19884, -19699, -19470, -19193, -18872, -18517, -18131, -17705, -17222, -16684, -16116, -15541, -14971, -14391, -13793, -13204, -12662, -12178, -11747, -11382, -11108, -10957, -10948, -11080, -11343, -11709, -12125, -12537, -12923, -13274, -13592, -13876, -14109, -14275, -14381, -14440, -14471, -14505, -14577, -14701, -14916, -15354, -15939, -16503, -17008, -17458, -17885, -18311, -18705, -19032, -19263, -19400, -19442, -19383, -19210, -18903, -18452, -17884, -17247, -16578, -15873, -15113, -14291, -13414, -12473, -11468, -10409, -9350, -8347, -7401, -6508, -5686, -4951, -4305, -3723, -3175, -2641, -2100, -1536, -943, -325, 17874, 18423, 18930, 19290, 19380, 19327, 19109, 18714, 18202, 17670, 17179, 16687, 16154, 15571, 14931, 14240, 13505, 12701, 11771, 10728, 9720, 8846, 8019, 7139, 6155, 5031, 3780, 2438, 1063, -239, -1381, -2343, -3127, -3785, -4372, -4904, -5426, -5930, -6323, -6550, -6642, -6678, -6729, -6816, -6901, -6938, -6805, -6369, -5583, -4477, -3192, -1888, -648, 509, 1512, 2254, 2764, 3158, 3535, 3924, 4270, 4498, 4653, 4852, 5129, 5435, 5743, 6101, 6492, 6810, 6961, 6921, 6754, 6605, 6542, 6533, 6519, 6417, 6166, 5786, 5314, 4747, 4081, 3353, 2635, 1971, 1380, 844, 274, -330, -832, -1113, -1117, -925, -685, -506, -440, -501, -655, -810, -969, -1122, -1270, -1477, -1744, -2061, -2397, -2700, -2998, -3377, -3831, -4346, -4960, -5705, -6616, -7750, -9138, -10733, -12423, -14110, -15759, -17401, -19109, -20897, -22655, -24265, -25678, -26835, -27684, -28373, -28999, -29571, -30050, -30439, -30605, -30760, -30999, -31278, -31565, -31844, -32139, -32455, -32700, -32770, -32634, -32292, -31771, -31054, -30029, -28587, -26832, -24880, -22796, -20617, -18349, -16051, -13805, -11651, -9599, -7616, -5761, -4091, -2555, -1166, -18, 807, 1306, 1592, 1778, 1961, 2206, 2525, 2856, 3114, 3221, 3203, 3157, 3147, 3215, 3337, 3491, 3604, 3574, 3362, 2997, 2559, 2115, 1699, 1327, 1036, 898, 950, 1094, 1172, 1133, 1062, 1091, 1265, 1525, 1812, 2099, 2374, 2620, 2904, 3321, 3870, 4575, 5455, 6471, 7542, 8569, 9504, 10354, 11117, 11793, 12347, 12748, 12961, 12990, 12882, 12659, 12353, 12006, 11697, 11514, 11447, 11456, 11524, 11624, 11734, 11918, 12225, 12642, 13142, 13667, 14158, 14576, 14879, 15030, 15024, 14847, 14500, 14049, 13586, 13187, 12911, 12787, 12838, 13069, 13463, 14004, 14648, 15349, 16070, 16743, 17359};