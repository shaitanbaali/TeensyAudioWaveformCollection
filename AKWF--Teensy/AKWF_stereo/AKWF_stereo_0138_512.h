/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0138 512 samples */
 
const int16_t AKWF_stereo_0138_512_DATA [512] = 
{1022, 4643, 7848, 10743, 13325, 15618, 17646, 19422, 20982, 22349, 23540, 24583, 25497, 26294, 26994, 27610, 28151, 28629, 29051, 29425, 29757, 30052, 30316, 30552, 30764, 30953, 31125, 31279, 31417, 31544, 31659, 31762, 31857, 31942, 32020, 32092, 32157, 32217, 32271, 32321, 32366, 32409, 32447, 32482, 32514, 32544, 32571, 32596, 32618, 32639, 32657, 32674, 32690, 32703, 32715, 32727, 32736, 32744, 32751, 32756, 32761, 32765, 32767, 32768, 32768, 32767, 32766, 32763, 32758, 32753, 32747, 32739, 32731, 32720, 32708, 32696, 32681, 32664, 32647, 32627, 32605, 32582, 32556, 32527, 32496, 32463, 32426, 32385, 32341, 32293, 32241, 32183, 32120, 32052, 31976, 31894, 31803, 31704, 31595, 31473, 31340, 31193, 31028, 30848, 30645, 30420, 30168, 29887, 29571, 29216, 28815, 28362, 27850, 27266, 26604, 25851, 24988, 24002, 22878, 21587, 20113, 18434, 16514, 14338, 11883, 9116, 6040, 2630, -1071, -4629, -7842, -10744, -13326, -15619, -17646, -19423, -20983, -22349, -23541, -24584, -25497, -26294, -26994, -27610, -28151, -28629, -29051, -29425, -29757, -30052, -30316, -30552, -30764, -30953, -31125, -31279, -31417, -31544, -31659, -31762, -31857, -31942, -32020, -32092, -32157, -32217, -32271, -32321, -32366, -32409, -32447, -32482, -32514, -32544, -32571, -32596, -32618, -32639, -32657, -32674, -32690, -32703, -32715, -32727, -32736, -32744, -32751, -32756, -32761, -32765, -32767, -32768, -32768, -32767, -32766, -32763, -32758, -32753, -32747, -32739, -32731, -32720, -32708, -32696, -32681, -32664, -32647, -32627, -32605, -32582, -32556, -32527, -32496, -32463, -32426, -32385, -32341, -32293, -32241, -32183, -32120, -32052, -31976, -31894, -31803, -31704, -31595, -31473, -31340, -31193, -31028, -30848, -30645, -30420, -30168, -29887, -29571, -29216, -28815, -28363, -27850, -27266, -26604, -25851, -24988, -24003, -22878, -21588, -20113, -18434, -16514, -14339, -11884, -9124, -6057, -2578, 755, 3480, 5982, 8319, 10479, 12463, 14277, 15920, 17406, 18748, 19950, 21031, 22000, 22864, 23640, 24335, 24955, 25512, 26012, 26458, 26862, 27225, 27550, 27846, 28112, 28353, 28572, 28770, 28951, 29115, 29264, 29400, 29524, 29638, 29741, 29837, 29924, 30004, 30077, 30144, 30206, 30262, 30315, 30363, 30406, 30446, 30483, 30516, 30547, 30575, 30600, 30624, 30645, 30663, 30680, 30695, 30708, 30719, 30728, 30737, 30743, 30747, 30751, 30753, 30754, 30752, 30750, 30744, 30740, 30732, 30723, 30713, 30701, 30686, 30671, 30653, 30633, 30610, 30586, 30559, 30529, 30497, 30463, 30423, 30382, 30336, 30285, 30231, 30171, 30107, 30036, 29959, 29875, 29783, 29683, 29574, 29455, 29323, 29180, 29023, 28850, 28659, 28449, 28218, 27963, 27680, 27368, 27022, 26636, 26208, 25732, 25199, 24608, 23945, 23206, 22381, 21457, 20426, 19278, 17995, 16572, 14999, 13256, 11347, 9264, 6996, 4560, 1954, -793, -3470, -5978, -8320, -10480, -12463, -14278, -15920, -17407, -18749, -19950, -21032, -22000, -22865, -23640, -24335, -24955, -25512, -26012, -26458, -26862, -27225, -27551, -27846, -28112, -28353, -28572, -28770, -28951, -29115, -29264, -29400, -29525, -29638, -29741, -29837, -29924, -30004, -30077, -30144, -30206, -30262, -30315, -30363, -30406, -30446, -30483, -30516, -30547, -30575, -30600, -30624, -30645, -30663, -30680, -30695, -30708, -30719, -30728, -30737, -30743, -30748, -30751, -30753, -30754, -30752, -30750, -30745, -30740, -30732, -30723, -30713, -30701, -30686, -30671, -30653, -30633, -30610, -30586, -30559, -30529, -30498, -30463, -30424, -30382, -30336, -30285, -30231, -30171, -30107, -30036, -29959, -29875, -29783, -29683, -29574, -29455, -29324, -29180, -29023, -28850, -28659, -28449, -28218, -27963, -27680, -27368, -27022, -26636, -26208, -25732, -25200, -24609, -23945, -23206, -22381, -21458, -20426, -19278, -17996, -16573, -15000, -13257, -11348, -9265, -7002, -4573, -1916};