/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0089 512 samples */
 
const int16_t AKWF_stereo_0089_512_DATA [512] = 
{5589, 13105, 18568, 21643, 22541, 22254, 21472, 20383, 18851, 17025, 14858, 12194, 9223, 6975, 5890, 5844, 6498, 7581, 8396, 8219, 7104, 6145, 5815, 6015, 6320, 6499, 5862, 3675, 727, -622, 623, 3858, 7818, 12218, 16096, 18138, 18246, 17865, 17281, 15792, 12943, 9194, 5107, 857, -3132, -5131, -5073, -4170, -3480, -3124, -3419, -4674, -6825, -8966, -10580, -11766, -12933, -14095, -15442, -17114, -18083, -15839, -9996, -1997, 6089, 13251, 18671, 21790, 22673, 22289, 20819, 18042, 14106, 9889, 5738, 967, -4330, -8167, -9649, -8967, -6867, -3840, -1227, -584, -2105, -3945, -4847, -5021, -5287, -6018, -7403, -9382, -10779, -9082, -3861, 3601, 11655, 19336, 25720, 30110, 32236, 32756, 32009, 29972, 26530, 22089, 17138, 11450, 5528, 1423, -280, -69, 897, 1752, 1846, 582, -1851, -3854, -4821, -5483, -6665, -8484, -10791, -13239, -14762, -13171, -8425, -2017, 4295, 9663, 13615, 15890, 16726, 17188, 17282, 16465, 14614, 12382, 9888, 6317, 1810, -1520, -2668, -1823, 172, 2791, 4857, 5059, 3234, 1138, -186, -1097, -2355, -4175, -6487, -8973, -11017, -10929, -8593, -5369, -2267, 841, 3779, 6116, 7503, 8316, 8467, 7648, 5628, 2713, -880, -4927, -8724, -11083, -12144, -13099, -14505, -15771, -16652, -17065, -17071, -16626, -16391, -17206, -19037, -20831, -21901, -22472, -22470, -20094, -15107, -8672, -2151, 3883, 8523, 10741, 10745, 10158, 9539, 8405, 5918, 2006, -2758, -7803, -12249, -14159, -13683, -12572, -12041, -12060, -12377, -12730, -13155, -13237, -13099, -13375, -14290, -15189, -15952, -16869, -17481, -15635, -10834, -4210, 2667, 9019, 13768, 15815, 15309, 13908, 12335, 10266, 7055, 2764, -2175, -7356, -11849, -13635, -13020, -11952, -11716, -12203, -13008, -13778, -14419, -14425, -14117, -14364, -15476, -16721, -17829, -19029, -19443, -16861, -10908, -2574, -6024, 587, 6268, 11161, 15442, 19352, 22808, 25579, 27328, 28006, 27787, 26874, 25645, 24841, 24793, 25447, 26363, 27073, 27290, 26867, 26033, 25431, 25194, 25058, 24574, 23534, 21752, 18992, 15798, 13541, 12705, 13037, 13608, 13689, 13011, 11398, 9314, 7758, 6799, 5932, 4420, 2012, -888, -3903, -6560, -7822, -7817, -7188, -6710, -6978, -7951, -9380, -11112, -12724, -14117, -15363, -16606, -17975, -19581, -21396, -22799, -22213, -19076, -13744, -7480, -1592, 3326, 7099, 9993, 12623, 15014, 16979, 18101, 18224, 17429, 15567, 13131, 11557, 11268, 12082, 13209, 13878, 13850, 12934, 11324, 9975, 9035, 7983, 6278, 3765, 729, -2457, -5135, -5939, -4483, -1099, 3075, 6957, 10080, 12325, 14000, 15696, 17353, 18703, 19341, 19171, 18223, 16238, 13618, 11789, 11237, 11851, 12921, 13736, 13927, 13122, 11447, 9903, 8763, 7606, 5893, 3424, 422, -2795, -5568, -6455, -4987, -1449, 3035, 7355, 10952, 13637, 15700, 17611, 19322, 20642, 21133, 20641, 19375, 17209, 14436, 12336, 11447, 11814, 12815, 13632, 13793, 12914, 11060, 9219, 7878, 6779, 5415, 3434, 805, -2266, -5382, -7414, -8042, -7774, -7551, -8073, -9517, -11692, -14035, -15878, -17096, -17856, -18633, -19718, -21217, -23069, -24781, -25598, -25473, -24720, -23953, -23684, -24062, -24972, -26035, -26786, -27269, -27653, -28180, -29032, -30043, -31002, -31409, -29760, -25746, -20014, -13931, -8709, -4945, -2896, -1946, -932, 269, 1101, 787, -890, -3469, -6457, -9216, -10538, -10398, -9358, -8259, -7832, -8275, -9602, -11499, -13200, -14398, -15138, -15821, -16884, -18563, -20771, -22742, -22625, -19897, -15198, -9975, -5470, -2263, -628, 16, 784, 1809, 2563, 2255, 606, -1973, -5031, -7964, -9555, -9713, -8924, -8000, -7684, -8213, -9623, -11626, -13466, -14798, -15627, -16347, -17410, -19075, -21297, -23036, -22352, -18759, -12711};