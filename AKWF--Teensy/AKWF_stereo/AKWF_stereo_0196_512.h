/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0196 512 samples */
 
const int16_t AKWF_stereo_0196_512_DATA [512] = 
{930, 2913, 4713, 6377, 7892, 9263, 10511, 11642, 12687, 13670, 14601, 15511, 16419, 17315, 18233, 19174, 20101, 20997, 21871, 22698, 23439, 24095, 24662, 25117, 25436, 25663, 25773, 25765, 25692, 25557, 25357, 25151, 24962, 24779, 24620, 24526, 24478, 24451, 24485, 24561, 24638, 24708, 24784, 24820, 24790, 24732, 24620, 24427, 24187, 23916, 23596, 23236, 22894, 22561, 22225, 21939, 21705, 21498, 21328, 21219, 21134, 21050, 20995, 20935, 20840, 20745, 20632, 20479, 20313, 20157, 19995, 19837, 19734, 19680, 19665, 19734, 19886, 20096, 20364, 20704, 21080, 21452, 21849, 22224, 22520, 22750, 22914, 22979, 22933, 22820, 22628, 22344, 22016, 21671, 21303, 20934, 20613, 20328, 20060, 19845, 19671, 19494, 19318, 19144, 18928, 18631, 18282, 17843, 17288, 16660, 15945, 15134, 14273, 13391, 12494, 11614, 10803, 10066, 9410, 8868, 8441, 8106, 7857, 7691, 7571, 7466, 7366, 7232, 7024, 6734, 6350, 5855, 5246, 4548, 3760, 2898, 1999, 1087, 185, -682, -1488, -2227, -2898, -3492, -4023, -4504, -4948, -5381, -5828, -6304, -6831, -7426, -8086, -8821, -9629, -10483, -11377, -12294, -13194, -14050, -14858, -15589, -16220, -16764, -17216, -17561, -17823, -18021, -18157, -18266, -18389, -18532, -18695, -18909, -19191, -19521, -19893, -20334, -20813, -21291, -21790, -22289, -22754, -23184, -23604, -23972, -24303, -24631, -24938, -25216, -25522, -25855, -26192, -26563, -26985, -27428, -27874, -28359, -28846, -29293, -29726, -30130, -30464, -30723, -30942, -31090, -31147, -31174, -31169, -31113, -31041, -31000, -30978, -30968, -31038, -31153, -31291, -31501, -31746, -31977, -32219, -32459, -32636, -32729, -32769, -32713, -32524, -32261, -31919, -31464, -30936, -30382, -29776, -29123, -28498, -27885, -27255, -26650, -26071, -25471, -24829, -24167, -23431, -22564, -21589, -20478, -19180, -17690, -16040, -14209, -12186, -10049, -7810, -5523, -3294, -1101, 432, 2504, 4415, 6205, 7854, 9365, 10750, 12010, 13169, 14244, 15237, 16178, 17085, 17945, 18798, 19650, 20469, 21245, 21994, 22699, 23330, 23893, 24392, 24802, 25103, 25335, 25469, 25496, 25464, 25366, 25194, 24994, 24784, 24550, 24304, 24090, 23892, 23686, 23516, 23374, 23224, 23068, 22929, 22767, 22561, 22353, 22121, 21837, 21531, 21214, 20871, 20501, 20152, 19806, 19446, 19116, 18815, 18517, 18231, 17985, 17752, 17514, 17304, 17100, 16880, 16678, 16481, 16270, 16068, 15890, 15717, 15554, 15434, 15347, 15274, 15243, 15251, 15270, 15294, 15337, 15363, 15348, 15317, 15236, 15062, 14811, 14494, 14091, 13603, 13065, 12475, 11832, 11176, 10528, 9894, 9290, 8752, 8275, 7851, 7504, 7221, 6981, 6786, 6629, 6483, 6329, 6177, 6005, 5806, 5595, 5369, 5128, 4894, 4682, 4505, 4379, 4329, 4358, 4466, 4669, 4959, 5319, 5739, 6205, 6684, 7155, 7597, 7982, 8277, 8471, 8551, 8501, 8317, 8012, 7586, 7045, 6422, 5735, 4997, 4227, 3453, 2685, 1922, 1184, 471, -226, -908, -1578, -2260, -2957, -3673, -4428, -5219, -6047, -6916, -7813, -8729, -9656, -10566, -11440, -12275, -13050, -13743, -14366, -14907, -15355, -15717, -16007, -16218, -16375, -16502, -16602, -16668, -16727, -16792, -16853, -16908, -16985, -17065, -17128, -17199, -17271, -17320, -17351, -17389, -17401, -17398, -17403, -17404, -17388, -17400, -17435, -17473, -17536, -17635, -17748, -17866, -18019, -18184, -18336, -18497, -18663, -18811, -18945, -19096, -19246, -19386, -19562, -19778, -20022, -20320, -20699, -21151, -21663, -22274, -22955, -23679, -24471, -25300, -26121, -26941, -27746, -28477, -29115, -29688, -30156, -30489, -30735, -30886, -30914, -30845, -30718, -30508, -30212, -29892, -29532, -29099, -28628, -28127, -27550, -26880, -26148, -25306, -24308, -23183, -21911, -20455, -18816, -17041, -15108, -13005, -10806, -8518, -6193, -3920, -1669};