/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0071 512 samples */
 
const int16_t AKWF_stereo_0071_512_DATA [512] = 
{277, 165, 366, 465, 581, 663, 726, 769, 802, 830, 860, 892, 927, 963, 1000, 1035, 1068, 1100, 1130, 1157, 1184, 1211, 1238, 1263, 1289, 1314, 1340, 1364, 1388, 1412, 1436, 1461, 1485, 1511, 1536, 1562, 1588, 1615, 1643, 1670, 1700, 1731, 1756, 1775, 1816, 1847, 1884, 1919, 1955, 1989, 2024, 2058, 2094, 2086, 2435, 1052, 313, 1269, 1512, 2015, 2255, 2434, 2564, 2652, 2718, 2767, 2806, 2839, 2866, 2890, 2912, 2933, 2954, 2975, 2996, 3017, 3037, 3058, 3080, 3103, 3125, 3148, 3172, 3195, 3220, 3246, 3269, 3296, 3323, 3351, 3378, 3405, 3433, 3462, 3491, 3520, 3549, 3577, 3620, 3524, 3623, 3640, 3716, 3751, 3795, 3831, 3867, 3901, 3934, 3958, 4195, 3104, -12255, -4384, -7383, -2942, -2886, -1976, -1768, -1585, -1467, -1332, -1194, -1085, -1038, -1063, -1148, -1272, -1419, -1578, -1749, -1937, -2137, -2347, -2555, -2755, -2945, -3125, -3297, -3462, -3615, -3749, -3866, -3959, -4024, -4071, -4096, -4104, -4092, -4059, -4006, -3935, -3848, -3773, -3506, -4124, -3955, -3662, -3321, -3077, -2840, -2652, -2479, -2324, -2184, -2056, -1941, -1837, -1746, -1666, -1598, -1543, -1498, -1463, -1439, -1427, -1423, -1428, -1441, -1460, -1484, -1513, -1546, -1581, -1617, -1654, -1689, -1723, -1753, -1781, -1805, -1823, -1836, -1843, -1843, -1838, -1827, -1807, -1784, -1795, -1729, -1693, -1629, -1575, -1514, -1453, -1388, -1322, -1256, -1230, -707, -2755, -7055, -3327, -3558, -1653, -1193, -644, -334, -116, 25, 117, 176, 211, 232, 240, 241, 237, 230, 221, 209, 198, 185, 173, 162, 152, 143, 136, 130, 128, 125, 127, 129, 135, 145, 137, 311, -394, -570, 198, 507, 780, 763, 626, 550, 50, 912, 969, 1069, 1213, 1351, 1468, 1557, 1623, 1676, 1727, 1782, 1843, 1912, 1984, 2060, 2135, 2206, 2278, 2347, 2416, 2483, 2552, 2620, 2690, 2759, 2828, 2897, 2967, 3035, 3104, 3174, 3243, 3312, 3381, 3449, 3518, 3587, 3656, 3725, 3795, 3864, 3932, 4002, 4072, 4140, 4210, 4278, 4348, 4418, 4487, 4557, 4626, 4695, 4770, 4799, 5050, 5220, 5170, 5213, 5223, 5266, 5316, 5373, 5436, 5501, 5568, 5636, 5708, 5777, 5847, 5917, 5987, 6058, 6127, 6198, 6269, 6339, 6409, 6479, 6549, 6619, 6689, 6759, 6829, 6899, 6968, 7038, 7107, 7178, 7247, 7317, 7387, 7455, 7526, 7596, 7664, 7734, 7804, 7872, 7957, 8018, 8090, 8153, 8222, 8290, 8359, 8428, 8497, 8567, 8625, 8908, 7782, -9493, -2052, -8045, -6588, -9376, -9616, -9060, -7869, -7131, -7253, -7997, -8718, -8892, -8438, -7705, -7168, -7091, -7398, -7778, -7937, -7782, -7436, -7126, -7009, -7085, -7227, -7292, -7212, -7030, -6845, -6738, -6724, -6753, -6755, -6690, -6571, -6439, -6337, -6281, -6249, -6211, -6140, -6064, -5863, -5772, -5717, -5684, -5637, -5578, -5498, -5411, -5325, -5250, -5182, -5116, -5046, -4970, -4889, -4811, -4738, -4670, -4604, -4537, -4467, -4396, -4327, -4258, -4193, -4130, -4066, -4000, -3934, -3867, -3802, -3737, -3673, -3609, -3543, -3477, -3410, -3343, -3277, -3209, -3142, -3075, -3006, -2937, -2862, -2796, -2726, -2657, -2587, -2516, -2444, -2373, -2301, -2230, -2153, -2139, -1796, -1164, -1562, -1453, -1618, -1598, -1591, -1553, -1503, -1446, -1382, -1315, -1246, -1174, -1103, -1030, -958, -887, -814, -743, -671, -601, -530, -459, -389, -319, -247, -178, -107, -39, 31, 100, 170, 240, 276, 613, -534, -793, 536, 1087, 1571, 1565, 1375, 1131, 1007};