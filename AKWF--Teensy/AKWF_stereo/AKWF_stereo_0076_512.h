/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0076 512 samples */
 
const int16_t AKWF_stereo_0076_512_DATA [512] = 
{10799, 30344, 25780, 21567, 19076, 17448, 16518, 16008, 15661, 15328, 14979, 14655, 14400, 14254, 14224, 14286, 14399, 14539, 14695, 14861, 15071, 15275, 13317, 12782, 14355, 15252, 15910, 16377, 16708, 16936, 17076, 17150, 17157, 17109, 17020, 16892, 16732, 16537, 16308, 16050, 15765, 15465, 15123, 14875, 15415, 15086, 14239, 13630, 13094, 12627, 12204, 11823, 11472, 11144, 10846, 10569, 10313, 10084, 9874, 9686, 9520, 9372, 9245, 9137, 9050, 8932, 8759, 8753, 8771, 8770, 8769, 8768, 8760, 8756, 8746, 8713, 8473, 9743, -2748, -22880, -18540, -14332, -11869, -10276, -9405, -8947, -8681, -8422, -8137, -7929, -7789, -7760, -7852, -8034, -8275, -8546, -8829, -9126, -9419, -10042, -5218, -2095, -6138, -8594, -10293, -11487, -12312, -12876, -13252, -13485, -13606, -13635, -13597, -13509, -13372, -13194, -12978, -12725, -12444, -12145, -11805, -11549, -12076, -11775, -10929, -10320, -9788, -9327, -8914, -8544, -8208, -7899, -7619, -7366, -7150, -6935, -5705, -5570, -6591, -7067, -7152, -6944, -6626, -6237, -5696, -5673, -5857, -6032, -6207, -6352, -6460, -6530, -6575, -6603, -6622, -6639, -6655, -6667, -6672, -6667, -6650, -6621, -6577, -6520, -6449, -6393, -6339, -6219, -6092, -5969, -5839, -5709, -5574, -5436, -5300, -5173, -5068, -4651, -9531, -13035, -9224, -6920, -5369, -4310, -3608, -3142, -2838, -2633, -2502, -2443, -2412, -2406, -2415, -2433, -2460, -2491, -2523, -2553, -2603, -2612, -420, 225, -1189, -1935, -2455, -2798, -3018, -3156, -3237, -3278, -3291, -3287, -3257, -3236, -4229, -4213, -3017, -2376, -2144, -2229, -2444, -2742, -3212, -3188, -2957, -2746, -2541, -2372, -2244, -2154, -2094, -2046, -2007, -1965, -1918, -1871, -1821, -1775, -1733, -1690, -1656, -1623, -1600, -1527, -1389, -1409, -1439, -1445, -1446, -1438, -1425, -1415, -1395, -1379, -1365, -1309, 9999, 29531, 27157, 27456, 30286, 32470, 32574, 30851, 28740, 27664, 28032, 29157, 29950, 29705, 28529, 27131, 26239, 26137, 26553, 26929, 26853, 26282, 25781, 25258, 24810, 24727, 24712, 24540, 24151, 23644, 23187, 22891, 22738, 22627, 22448, 22157, 21797, 21439, 21148, 20931, 20741, 20529, 20270, 19957, 19538, 19258, 19080, 18892, 18690, 18461, 18207, 17946, 17698, 17466, 17248, 17032, 16807, 16578, 16346, 16120, 15907, 15701, 15499, 15299, 15090, 14893, 14707, 14506, 14312, 14121, 13932, 13748, 13556, 13375, 13193, 12994, 12598, 13680, 1319, -18891, -16797, -17150, -20093, -22425, -22709, -21137, -19157, -18188, -18654, -19896, -20822, -20719, -19683, -18403, -17621, -17626, -18149, -18649, -18702, -18218, -18219, -18148, -17506, -17343, -17318, -17179, -16850, -16419, -16046, -15838, -15783, -15770, -15693, -15507, -15245, -14989, -14797, -14675, -14583, -14466, -14301, -14084, -13758, -13565, -13477, -13377, -13264, -13121, -12952, -12778, -12611, -12463, -12325, -12186, -12057, -11877, -9945, -9819, -11616, -12465, -12617, -12242, -11617, -11002, -10569, -10283, -10150, -10130, -10141, -10131, -10078, -9980, -9852, -9711, -9573, -9443, -9327, -9217, -9115, -9017, -8918, -8816, -8710, -8603, -8494, -8382, -8270, -8167, -8063, -7961, -7858, -7754, -7650, -7546, -7444, -7341, -7236, -7172, -6429, -5866, -6242, -6426, -6517, -6545, -6531, -6488, -6426, -6355, -6275, -6189, -6101, -6012, -5924, -5835, -5748, -5662, -5577, -5496, -5412, -5332, -5538, -5546, -5291, -5121, -4983, -4866, -4765, -4677, -4595, -4518, -4443, -4379, -4299, -4248, -5924, -5909, -3913, -2859, -2504, -2680, -3107, -3531, -3780, -3884, -3841, -3689, -3504, -3339, -3217, -3140, -3100, -3073, -3047, -3013, -2965, -2911, -2850, -2787, -2729, -2669, -2618, -2568, -2517, -2477, -2441, -2387, -2334, -2280, -2232, -2182, -2133, -2089, -2039, -1995, -1955, -1873};