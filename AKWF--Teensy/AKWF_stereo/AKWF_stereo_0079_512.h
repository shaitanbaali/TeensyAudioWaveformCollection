/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0079 512 samples */
 
const int16_t AKWF_stereo_0079_512_DATA [512] = 
{13955, 11914, 10271, 9474, 9040, 8696, 8289, 7855, 7473, 7187, 7026, 6957, 6923, 6082, 3336, 6606, 6457, 5755, 5409, 5139, 4893, 4694, 4597, 4488, 4851, 4826, 3461, 3442, 3424, 3355, 3223, 3039, 2979, 2620, 2196, 1975, 1744, 1541, 1358, 1188, 1024, 870, 846, -97, 4986, 16275, 12666, 11173, 10208, 9235, 8310, 8831, 8074, 7347, 6787, 6376, 6064, 5647, 5367, 5220, 4950, 4731, 4390, 4021, 3660, 3326, 3048, 2854, 2756, 2741, 2780, 2847, 2931, 3016, 3167, 3500, 3819, 4020, 4110, 4067, 3898, 3619, 3248, 2810, 2313, 1828, 1464, 1083, 1865, 1994, 175, 121, 20, -103, -231, -361, -487, -578, -875, -186, 2614, 1060, 84, -578, -1027, -1328, -1522, -1635, -1690, -1699, -1673, -1631, -1484, -1790, -2279, -772, -793, -863, -2664, -5925, -9626, -13519, -17423, -21161, -24570, -27515, -29865, -31545, -32505, -32747, -32138, -28916, -23897, -18636, -13479, -8191, -3470, -841, 989, 1816, 1528, 300, -637, -2138, 1757, 13782, -565, -5731, -4743, -5097, -5362, -5607, -5704, -5609, -5363, -5059, -4763, -4533, -4194, -3773, -3311, -2805, -2353, -1942, -1567, -1202, -818, -449, 128, 224, -10945, -730, 4098, 2445, 2461, 2599, 2835, 2992, 3016, 2794, 3264, 3116, 2261, 1737, 1343, 1056, 842, 647, 924, 675, -64, -217, -471, -720, -947, -1131, -1260, -1332, -1517, -1045, -244, -899, -1195, -1383, -1473, -1498, -1474, -1419, -1337, -1228, -1101, -963, -776, -850, -777, -152, -100, -52, -454, -1024, -1526, -1908, -2146, -2230, -2161, -1955, -1623, -1189, -665, -96, 593, 1759, 2967, 3864, 4470, 4761, 4730, 4405, 3820, 3023, 2059, 1077, 418, -310, 1471, 3365, -1388, -1739, -1501, -1449, -1386, -1333, -1277, -1275, -1241, -1783, 9003, 8035, 7880, 8650, 9460, 9699, 9262, 8509, 7919, 7733, 7891, 8138, 8039, 7581, 7065, 5990, 5485, 5260, 5085, 4837, 4456, 4030, 3706, 3454, 3727, 3687, 2392, 2312, 2212, 2065, 1891, 1700, 1473, 1257, 1031, 788, 579, 416, 299, 217, 147, 74, 119, -628, 2346, 9478, 7856, 8097, 8902, 9235, 8896, 9322, 8386, 7673, 7428, 7481, 7510, 7287, 6783, 6183, 5727, 5486, 5405, 5312, 5078, 4693, 4240, 3834, 3535, 3323, 3127, 2882, 2569, 2222, 1890, 1595, 1357, 1158, 961, 755, 554, 377, 246, 159, 103, 55, -1, -51, -201, -258, -98, -111, -116, -126, -140, -156, -170, -181, -166, -246, -538, -397, -313, -257, -220, -193, -173, -159, -151, -145, -144, -141, -145, -104, -44, -188, -165, -201, -1330, -3403, -5894, -8779, -12012, -15435, -18819, -21946, -24640, -26838, -28521, -29688, -30219, -28977, -26372, -23080, -19339, -14881, -10352, -7307, -4667, -2678, -1452, -927, -446, -364, 1126, 7665, 740, -1001, 676, 743, 205, -502, -856, -681, -201, 203, 272, 30, -312, -497, -416, -160, 92, 193, 122, -26, -123, -132, 64, -14, -6992, -1245, 893, -775, -865, -397, 254, 593, 460, -68, 167, 140, -243, -197, -101, -92, -176, -253, -276, -143, 60, 124, 78, -53, -186, -250, -226, -155, -79, -117, -236, -224, -226, -198, -151, -110, -89, -92, -106, -113, -105, -84, -65, -29, -20, -71, -65, -52, 11, 92, 162, 211, 242, 254, 254, 239, 211, 166, 111, 48, -28, -152, -279, -377, -445, -485, -495, -475, -429, -361, -276, -190, -134, -73, -260, -458, 9, 37, 9, 1, -10, -18, -20, -65, -124, -524};