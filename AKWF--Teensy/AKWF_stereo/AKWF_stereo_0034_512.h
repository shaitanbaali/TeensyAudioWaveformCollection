/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0034 512 samples */
 
const int16_t AKWF_stereo_0034_512_DATA [512] = 
{1955, 5493, 8733, 11723, 14417, 16795, 18843, 20561, 21974, 23088, 23897, 24409, 24641, 24613, 24340, 23857, 23226, 22528, 21836, 21212, 20702, 20323, 20078, 19963, 19993, 20168, 20479, 20911, 21449, 22067, 22717, 23354, 23952, 24495, 24970, 25372, 25697, 25947, 26120, 26221, 26266, 26252, 26162, 25976, 25677, 25251, 24679, 23968, 23149, 22269, 21381, 20532, 19755, 19081, 18525, 18103, 17848, 17782, 17910, 18231, 18730, 19375, 20103, 20853, 21585, 22267, 22879, 23403, 23833, 24168, 24415, 24588, 24717, 24816, 24883, 24914, 24922, 24908, 24876, 24770, 24654, 24593, 24614, 24728, 24931, 25185, 25437, 25644, 25776, 25806, 25688, 25382, 24857, 24067, 22981, 21612, 19891, 17820, 15415, 12713, 9774, 6644, 3382, 68, -3237, -6493, -9660, -12543, -15249, -17790, -20341, -22720, -24848, -26682, -28173, -29275, -29972, -30255, -30132, -29615, -28704, -27414, -25774, -23825, -21621, -19226, -16748, -14277, -11887, -9645, -7598, -5787, -4256, -3021, -2096, -1481, -1154, -1105, -1334, -1836, -2589, -3565, -4747, -6101, -7560, -9052, -10502, -11848, -13054, -14097, -14979, -15699, -16245, -16613, -16813, -16863, -16776, -16580, -16321, -16042, -15767, -15509, -15282, -15089, -14931, -14811, -14726, -14677, -14650, -14647, -14694, -14814, -15024, -15345, -15791, -16363, -17022, -17726, -18422, -19063, -19614, -20050, -20356, -20517, -20503, -20295, -19891, -19293, -18520, -17605, -16610, -15593, -14591, -13637, -12751, -11948, -11237, -10622, -10095, -9641, -9232, -8853, -8505, -8188, -7891, -7613, -7353, -7108, -6850, -6539, -6146, -5654, -5065, -4413, -3745, -3099, -2508, -1995, -1600, -1362, -1311, -1479, -1910, -2640, -3680, -5012, -6621, -8473, -10511, -12686, -14951, -17232, -19475, -21624, -23646, -25530, -27246, -28772, -30104, -31217, -32066, -32599, -32771, -32542, -31893, -30822, -29346, -27469, -25206, -22571, -19587, -16311, -12794, -9107, -5356, -1560, 13722, 11265, 9292, 7825, 6922, 6622, 6920, 7750, 8972, 10412, 11883, 13167, 14010, 14189, 13518, 11914, 9432, 6239, 2594, -1231, -5009, -8525, -11639, -14322, -16593, -18480, -20025, -21263, -22244, -23041, -23718, -24345, -24962, -25568, -26145, -26678, -27117, -27359, -27283, -26783, -25773, -24176, -21952, -19113, -15760, -12063, -8179, -4272, -436, 3329, 7000, 10543, 13924, 17071, 19888, 22242, 23974, 25004, 25333, 25009, 24137, 22806, 21166, 19371, 17601, 16082, 14968, 14363, 14336, 14939, 16182, 17998, 20269, 22837, 25503, 28064, 30265, 31869, 32702, 32595, 31601, 29903, 27716, 25280, 22797, 20456, 18372, 16541, 14923, 13456, 12077, 10743, 9386, 7929, 6317, 4524, 2485, 233, -2198, -4766, -7380, -9915, -12222, -14180, -15701, -16705, -17139, -16910, -16238, -15284, -14239, -13177, -12158, -11186, -10260, -9385, -8576, -7880, -7379, -7203, -7491, -8300, -9627, -11394, -13498, -15825, -18230, -20571, -22678, -24359, -25473, -25947, -25739, -24819, -23191, -20950, -18227, -15209, -12101, -9127, -6536, -4575, -3412, -3149, -3737, -5014, -6742, -8677, -10605, -12337, -13751, -14833, -15609, -16127, -16424, -16544, -16551, -16518, -16520, -16632, -16894, -17301, -17841, -18494, -19197, -19839, -20298, -20460, -20234, -19537, -18317, -16585, -14436, -12022, -9500, -7017, -4660, -2429, -326, 1638, 3447, 5050, 6363, 7259, 7598, 7311, 6404, 4941, 3023, 753, -1713, -4221, -6591, -8604, -10109, -11004, -11219, -10713, -9467, -7552, -5088, -2241, 793, 3804, 6540, 8762, 10291, 11027, 10996, 10349, 9301, 8075, 6869, 5859, 5154, 4759, 4626, 4691, 4904, 5207, 5533, 5806, 5950, 5896, 5618, 5132, 4467, 3661, 2781, 1955, 1323, 995, 1070, 1633, 2734, 4362, 6424, 8761, 11229, 13680, 16034, 18290, 20446, 22485, 24386, 26090, 27501, 28479, 28877, 28617, 27695, 26180, 24163, 21760, 19109, 16304};