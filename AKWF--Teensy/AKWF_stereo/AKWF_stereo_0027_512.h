/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0027 512 samples */
 
const int16_t AKWF_stereo_0027_512_DATA [512] = 
{349, 1166, 1943, 2696, 3392, 4101, 4840, 5550, 6209, 6842, 7481, 8136, 8801, 9450, 10079, 10726, 11405, 12069, 12702, 13294, 13879, 14493, 15119, 15746, 16356, 16931, 17477, 18007, 18510, 18979, 19464, 20012, 20670, 21449, 22343, 23329, 24339, 25317, 26210, 27004, 27691, 28272, 28765, 29212, 29632, 30005, 30303, 30468, 30465, 30339, 30138, 29858, 29492, 29058, 28558, 27973, 27316, 26616, 25865, 25044, 24213, 23414, 22637, 21870, 21100, 20328, 19592, 18909, 18256, 17613, 17039, 16604, 16260, 15923, 15574, 15240, 14926, 14654, 14466, 14369, 14331, 14331, 14371, 14469, 14588, 14691, 14764, 14789, 14769, 14700, 14556, 14358, 14146, 13882, 13557, 13182, 12792, 12390, 11972, 11583, 11244, 10969, 10750, 10567, 10415, 10310, 10263, 10290, 10399, 10570, 10818, 11168, 11616, 12147, 12722, 13288, 13833, 14356, 14813, 15080, 15013, 14991, 15063, 15102, 15084, 14976, 14779, 14520, 14236, 13938, 13598, 13210, 12796, 12340, 11821, 11290, 10729, 10118, 9468, 8795, 8118, 7408, 6609, 5696, 4650, 3432, 2048, 529, -1107, -2837, -4620, -6409, -8156, -9833, -11426, -12882, -14148, -15191, -16011, -16660, -17164, -17535, -17775, -17896, -17889, -17777, -17614, -17430, -17233, -17043, -16911, -16876, -16959, -17131, -17376, -17690, -18051, -18463, -18929, -19451, -20030, -20628, -21224, -21813, -22393, -22967, -23516, -24037, -24539, -25040, -25519, -25983, -26441, -26883, -27316, -27728, -28111, -28467, -28810, -29185, -29625, -30120, -30618, -31115, -31544, -31873, -32141, -32377, -32571, -32696, -32756, -32764, -32714, -32599, -32428, -32193, -31871, -31478, -30988, -30297, -29574, -29049, -28624, -28298, -28000, -27688, -27410, -27215, -27093, -26965, -26763, -26486, -26133, -25703, -25215, -24650, -23955, -23105, -22108, -21007, -19869, -18681, -17429, -16110, -14703, -13232, -11752, -10289, -8869, -7488, -6137, -4856, -3658, -2539, -1450, -474, 18327, 18977, 19692, 20438, 21104, 21726, 22294, 22717, 23013, 23252, 23459, 23566, 23492, 23242, 22928, 22570, 22251, 22015, 21828, 21653, 21480, 21296, 21055, 20712, 20231, 19697, 19147, 18617, 18240, 18060, 18037, 18064, 18019, 17879, 17696, 17534, 17485, 17657, 17971, 18073, 18058, 17877, 17513, 17003, 16435, 15884, 15365, 14792, 14114, 13282, 12206, 10894, 9479, 8126, 6863, 5709, 4712, 3913, 3383, 3091, 2902, 2758, 2605, 2409, 2202, 1968, 1674, 1292, 832, 297, -304, -929, -1543, -2040, -2338, -2430, -2354, -2128, -1750, -1297, -845, -357, 228, 900, 1647, 2360, 2938, 3370, 3687, 3908, 3926, 3717, 3352, 2915, 2481, 1999, 1386, 654, -104, -800, -1465, -2203, -3066, -4014, -5074, -6272, -7596, -9063, -10674, -12431, -14275, -16097, -17836, -19537, -21216, -22880, -24542, -26176, -27743, -29163, -30389, -31399, -32116, -32553, -32751, -32733, -32535, -32158, -31670, -31222, -30877, -30612, -30440, -30315, -30101, -29826, -29478, -29155, -28654, -27928, -27103, -26236, -25259, -24141, -23026, -21955, -20836, -19612, -18327, -17007, -15680, -14342, -13066, -11802, -10449, -9035, -7589, -6182, -4942, -3820, -2730, -1640, -509, 652, 1782, 2786, 3643, 4403, 5108, 5749, 6275, 6709, 7140, 7560, 7993, 8433, 8826, 9142, 9427, 9815, 10420, 11090, 11632, 12061, 12386, 12606, 12701, 12666, 12524, 12387, 12307, 12213, 11965, 11397, 10572, 9574, 8439, 7242, 6011, 4715, 3363, 1938, 425, -1129, -2623, -3966, -5020, -5765, -6227, -6568, -7005, -7637, -8403, -9192, -9994, -10815, -11596, -12241, -12672, -12908, -13065, -13301, -13608, -13873, -14044, -14114, -14099, -14020, -13865, -13615, -13269, -12793, -12019, -10931, -9677, -8241, -6647, -4946, -3183, -1414, 345, 2075, 3704, 5283, 6882, 8409, 9773, 10974, 11976, 12828, 13596, 14361, 15223, 16129, 17014, 17738};