/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0024 512 samples */
 
const int16_t AKWF_stereo_0024_512_DATA [512] = 
{263, 1384, 2805, 4496, 6518, 8043, 10532, 13861, 15193, 15449, 15958, 16513, 16823, 16323, 16096, 15724, 15018, 15810, 17849, 20039, 21324, 21461, 21828, 23328, 25834, 27420, 28751, 29236, 29739, 30555, 30428, 29139, 27098, 26425, 27362, 28438, 28843, 28227, 26294, 23194, 22816, 24404, 23599, 21802, 20619, 19565, 19189, 18884, 18386, 18752, 19632, 19099, 18902, 19158, 20669, 22447, 23684, 26383, 27654, 26428, 25105, 25333, 24888, 22919, 20340, 18394, 18813, 19927, 20997, 23016, 24243, 23658, 22400, 20973, 20758, 21210, 20272, 17768, 13841, 21566, 32013, 30033, 30210, 30301, 29574, 29762, 30765, 32187, 32718, 31778, 30921, 29746, 29316, 29101, 26468, 22564, 20215, 19732, 20266, 19557, 16500, 13677, 11543, 9636, 8731, 8425, 8198, 8676, 8963, 8820, 8841, 7142, 5810, 5647, 6281, 6602, 6027, 4113, 2383, 1644, -528, -4355, -7343, -9050, -10394, -11342, -10179, -8855, -7521, -7339, -8937, -10175, -11053, -12226, -13351, -13945, -14542, -15207, -15626, -15800, -15320, -15100, -15414, -16106, -16174, -15299, -14628, -15783, -16889, -17637, -19863, -22081, -24232, -24426, -23985, -24289, -25262, -27506, -30209, -31140, -30075, -29884, -28767, -25388, -23796, -23991, -23381, -21957, -21597, -22020, -21706, -21732, -22509, -23777, -23665, -22821, -23594, -23935, -24977, -26005, -26093, -26353, -26111, -24432, -23101, -23763, -23313, -20963, -17891, -17655, -19087, -19581, -19543, -19327, -18905, -18487, -18318, -18089, -19649, -21181, -20919, -21290, -21741, -21525, -21199, -20175, -19389, -18664, -17349, -15341, -11587, -14121, -26017, -23670, -22177, -21386, -21466, -22333, -23530, -25561, -27195, -28220, -29526, -29045, -27389, -27011, -25896, -23349, -21409, -20595, -19975, -20223, -18853, -15832, -12077, -6964, -3892, -3104, -2805, -2537, -1628, -1259, -1985, -2365, -414, 2714, 4272, 4720, 5602, 6524, 5673, 3367, 743, 248, 227, -280, 18069, 17857, 16445, 15653, 15828, 15958, 13742, 11631, 9686, 7045, 6119, 6274, 3070, -1555, -4943, -5752, -2967, -1604, -5211, -7902, -9505, -12349, -15400, -17576, -18021, -16651, -14726, -11567, -9096, -8572, -6786, -5373, -4937, -4175, -2280, -52, 1369, 756, -2436, -6179, -7963, -8527, -6931, -4350, 94, 5787, 10110, 11773, 10756, 9606, 10066, 11500, 12650, 12495, 11225, 11128, 11022, 10628, 9608, 6871, 4492, 3468, 3329, 4530, 6588, 7340, 6904, 5969, 6410, 8280, 8371, 8461, 9511, 9566, 8935, 6869, 3069, -1008, -3067, -4018, -2276, -717, -156, 649, 798, 1879, 1833, 149, -173, -67, -627, -2321, -1063, -672, -1738, -2569, -6775, -9712, -10767, -12694, -13726, -12408, -12644, -12942, -12343, -12541, -14752, -17013, -18051, -17630, -16936, -16786, -16277, -16533, -17120, -17557, -20971, -24305, -27192, -29848, -31656, -32746, -32390, -32302, -32324, -31040, -29383, -27207, -26496, -18295, -8448, -5779, -2497, -787, -1176, -2473, -3553, -3238, -1458, -3027, -7353, -8104, -7150, -8230, -6522, -2189, 1349, 3872, 5156, 4417, 5956, 7690, 9840, 13074, 13991, 14941, 15546, 14968, 12823, 9128, 6149, 4355, 4223, 4764, 5305, 5282, 3835, 779, -4194, -8190, -8928, -6781, -7036, -8869, -9690, -9581, -7986, -7866, -9794, -13026, -12250, -8620, -7556, -9043, -10816, -11506, -11268, -10790, -11407, -12781, -12375, -8780, -5590, -4342, -2625, -2490, -4138, -3740, -2786, -2128, -1532, -1530, -2011, -2172, -2365, -3163, -5244, -5358, -3171, -688, 1469, 1684, -1101, -3640, -2611, -880, -348, 83, -669, 628, 4097, 6035, 7077, 8809, 8951, 6653, 5626, 4846, 8507, 13209, 16728, 19880, 19955, 16420, 14756, 15626, 14683, 13415, 13356, 12975, 14467, 17851, 22344, 26933, 29261, 29553, 28283, 27548, 29093, 30965, 31385, 30391, 29581, 20068, 16758, 17697};