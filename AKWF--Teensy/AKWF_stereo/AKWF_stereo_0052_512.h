/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0052 512 samples */
 
const int16_t AKWF_stereo_0052_512_DATA [512] = 
{785, 1171, 1002, 2443, 4262, 4596, 5572, 7550, 7795, 7906, 9520, 10379, 11280, 14274, 17519, 20506, 24969, 28652, 30200, 32029, 32593, 30586, 29208, 28143, 25817, 24607, 24228, 22594, 21732, 21644, 20063, 18921, 18607, 17072, 15838, 15831, 15105, 14129, 14276, 13883, 12859, 12925, 12562, 11463, 11503, 11217, 9730, 8706, 7428, 5243, 3932, 3280, 2361, 2442, 3351, 3892, 4818, 6149, 6713, 7164, 8159, 8600, 8863, 9985, 10974, 11952, 13487, 14131, 14001, 13740, 12538, 10850, 9325, 7608, 5958, 4578, 3204, 1905, 809, -193, -993, -1576, -2168, -2768, -3369, -3986, -4539, -5133, -5949, -6782, -7481, -8341, -9035, -9355, -9831, -10272, -10677, -11660, -12810, -13784, -14873, -15476, -15378, -15218, -14702, -13719, -12897, -12024, -10936, -10110, -9344, -8441, -7833, -7354, -6712, -6326, -6193, -6099, -6351, -6931, -7468, -8047, -8624, -8897, -9175, -9607, -9888, -10211, -10689, -10817, -10423, -10005, -9855, -9662, -9278, -9003, -9101, -9584, -10160, -10578, -11161, -12092, -12902, -13508, -14162, -14611, -14957, -15510, -15910, -15893, -15556, -14813, -13946, -13185, -12143, -10838, -9849, -8936, -7712, -6517, -5430, -4391, -3706, -3170, -2710, -2584, -2497, -2298, -2177, -1988, -1658, -1111, -180, 787, 1429, 1962, 2527, 2969, 3216, 3251, 3084, 2804, 2402, 1720, 765, -320, -1377, -2265, -3164, -4217, -5133, -5804, -6327, -6647, -6791, -6694, -6237, -5661, -5052, -4324, -3572, -2835, -2167, -1781, -1716, -1839, -1886, -1867, -1985, -2115, -2049, -1877, -1533, -1248, -1155, -690, -60, 157, 554, 1218, 1501, 1762, 2253, 2364, 2215, 2126, 1596, 818, 372, -457, -1804, -2514, -2974, -4032, -4845, -5361, -5895, -5543, -5315, -6008, -5648, -4879, -5300, -5239, -5039, -5993, -6015, -5184, -5511, -5488, -4285, -3541, -2602, -770, -73, -230, -451, 1512, 2477, 4371, 5005, 3933, 5510, 7534, 7388, 8330, 10164, 12354, 15884, 19843, 22146, 25233, 28235, 27544, 27331, 29303, 29062, 28879, 30781, 31898, 32334, 32686, 30475, 28341, 28693, 27319, 24867, 24104, 22618, 20923, 20715, 20511, 18702, 17302, 16672, 15302, 15095, 15083, 13321, 13016, 13559, 12017, 9826, 8178, 6585, 6386, 7292, 6935, 6243, 6436, 6362, 6177, 6465, 6177, 5592, 6511, 7986, 8425, 9431, 10899, 12250, 14281, 14445, 12707, 11938, 11651, 11595, 11627, 10832, 9934, 9110, 7751, 6127, 4599, 3222, 2135, 1343, 196, -1346, -2874, -4023, -4516, -4965, -6151, -7864, -8653, -8895, -9346, -9521, -10086, -10978, -11657, -13108, -14855, -15615, -15923, -15755, -14936, -14885, -15503, -15567, -15333, -14899, -14188, -13739, -13285, -12254, -11343, -10835, -10029, -9172, -8702, -8459, -8590, -8949, -8992, -8772, -8668, -8485, -8598, -9512, -10408, -10864, -11273, -11496, -10897, -9888, -10222, -11952, -12631, -11320, -10194, -11519, -13801, -13862, -12052, -11981, -14059, -15539, -15246, -14410, -14647, -16420, -17945, -17778, -16391, -14925, -14722, -15941, -16392, -14522, -12355, -11982, -12073, -10840, -8531, -6780, -6858, -7124, -5957, -4532, -3736, -3293, -2891, -2189, -1500, -936, 282, 1610, 1678, 765, 665, 1994, 3430, 3351, 2240, 1761, 2381, 2708, 1684, 4, -970, -686, -412, -1794, -4056, -5215, -4939, -4545, -5302, -6631, -6728, -5833, -5371, -5631, -5850, -5258, -4159, -3738, -4167, -4722, -4217, -2639, -1633, -2164, -2811, -2396, -966, -109, -1117, -1855, -468, 742, 626, 392, 652, 1199, 1894, 2002, 1596, 1384, 1113, 505, 657, 775, -816, -2291, -1750, -1544, -2959, -4851, -5972, -4252, -2403, -5347, -8421, -6752, -4938, -5252, -6833, -9216, -8779, -5039, -3992, -6141, -7029, -5239, -2538, -314, -1082, -4365, -4091};