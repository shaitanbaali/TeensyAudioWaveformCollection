/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0166 512 samples */
 
const int16_t AKWF_stereo_0166_512_DATA [512] = 
{263, 820, 1355, 1898, 2514, 3378, 4201, 4948, 5822, 6566, 7118, 7571, 7976, 8382, 8722, 8977, 8810, 8664, 8866, 9348, 9737, 10012, 10223, 10405, 10332, 9939, 9729, 9640, 9600, 9606, 9635, 9660, 9709, 9744, 9602, 9570, 9681, 9936, 10206, 10572, 9648, 4139, 2911, 2373, 1885, 1530, 1389, 1670, 2157, 2394, 2688, 3072, 3674, 3856, 8376, 15127, 16089, 17332, 18216, 18767, 19307, 19847, 20384, 20923, 21424, 21884, 22337, 22751, 23106, 23445, 23774, 24073, 24355, 24662, 24955, 25203, 25450, 25685, 25875, 26082, 26291, 26462, 26568, 26561, 26615, 26735, 26871, 26961, 26978, 27206, 27661, 27970, 28169, 28325, 28414, 28481, 28734, 28955, 29065, 29101, 29093, 28938, 28512, 27940, 27394, 26971, 26638, 26360, 26075, 25766, 25495, 25059, 24554, 24733, 24756, 24450, 23767, 23634, 17563, 8666, 7417, 5709, 4309, 3097, 2018, 1036, 140, -656, -1377, -2052, -2685, -3259, -3802, -4314, -4787, -5257, -5840, -6712, -7441, -8064, -8435, -8367, -8383, -8470, -8599, -8768, -8894, -9011, -9101, -9044, -9273, -9839, -10177, -10363, -10523, -10694, -10849, -10986, -10954, -10876, -10867, -10793, -10672, -10476, -10000, -4693, -2554, -2017, -1609, -1542, -1709, -1911, -2003, -2061, -2121, -2203, -2316, -2461, -2782, -3559, -4271, -4753, -5249, -5557, -6119, -6348, -12374, -18020, -18861, -20141, -21139, -22019, -22808, -23504, -24150, -24752, -25288, -25777, -26242, -26659, -27011, -27337, -27637, -27895, -28143, -28380, -28549, -28690, -28831, -28949, -29031, -29127, -29219, -29280, -29347, -29424, -29467, -29476, -29502, -29519, -29502, -29739, -30089, -30244, -30288, -30242, -29943, -29469, -29172, -28972, -28758, -28550, -28347, -28108, -27844, -27563, -26971, -26533, -26094, -25521, -24704, -24240, -20135, -10484, -8817, -7856, -6994, -6060, -5156, -4326, -3555, -2827, -2151, -1514, -898, -289, 1631, 2149, 2628, 3091, 3548, 4010, 4636, 5016, 5187, 5633, 6219, 7007, 7817, 14689, 18500, 19501, 20744, 21777, 22683, 23514, 24280, 24963, 25610, 26233, 26765, 27245, 27696, 28103, 28456, 28934, 29452, 29824, 30139, 30414, 30628, 30627, 30535, 30515, 30505, 30538, 30568, 30547, 30535, 30567, 30599, 30615, 30657, 30688, 30675, 30670, 30681, 30658, 30596, 30547, 30474, 30233, 29634, 29159, 28682, 28030, 27522, 27109, 26777, 26531, 26316, 26119, 25981, 25757, 25334, 25026, 24833, 24720, 24870, 25051, 25122, 25100, 25062, 25032, 24975, 24915, 24843, 24615, 23760, 22423, 21402, 20795, 20375, 20088, 20015, 19926, 19817, 19702, 19583, 19475, 19357, 19231, 19279, 19004, 18668, 18544, 18611, 18559, 20212, 25237, 26042, 26591, 27011, 27395, 27865, 28091, 27996, 27605, 27093, 26774, 26276, 25614, 24687, 24405, 18232, 9328, 8089, 6363, 4930, 3678, 2561, 1529, 557, -326, -1147, -1919, -2628, -3031, -3295, -3693, -4143, -4625, -5132, -5687, -6500, -7180, -7846, -8583, -9406, -10261, -11840, -19170, -21811, -22957, -24143, -25123, -25988, -26780, -27491, -28119, -28709, -29233, -29679, -30092, -30480, -30681, -30730, -31014, -31360, -31620, -31842, -32010, -32122, -32226, -32343, -32442, -32509, -32591, -32665, -32687, -32715, -32756, -32756, -32719, -32696, -32552, -32005, -31509, -31095, -30449, -29900, -29487, -29116, -28809, -28564, -28322, -28072, -27808, -27367, -26943, -26623, -26365, -26134, -25921, -25755, -25647, -25459, -25236, -25030, -24907, -25029, -25021, -24360, -23186, -22136, -21414, -20865, -20453, -20110, -19793, -19505, -19264, -19059, -18866, -18692, -18644, -18763, -18579, -18222, -17952, -17728, -17556, -17403, -17337, -17394, -17316, -17285, -17288, -17420, -17247, -19737, -23983, -23748, -23911, -23909, -23817, -23623, -23666, -19905, -10409, -8543, -6956, -5629, -4434, -3366, -2427, -1578, -1014, -565, -29, 530, 1101};