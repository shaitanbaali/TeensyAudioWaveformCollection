/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0070 512 samples */
 
const int16_t AKWF_stereo_0070_512_DATA [512] = 
{-17158, -32765, -24050, -19661, -16191, -13984, -12849, -12395, -12138, -11785, -11287, -10746, -10388, -10316, -10511, -10848, -11201, -11494, -11764, -12112, -12557, -13088, -13654, -14190, -14649, -15055, -15438, -15813, -16180, -16514, -16761, -16945, -17032, -17030, -16975, -16871, -16710, -16460, -16147, -15752, -15306, -14814, -14203, -13933, -14983, -13864, -12574, -11517, -10563, -9697, -8880, -8118, -7390, -6704, -6060, -5456, -4888, -4372, -3879, -3432, -3032, -2684, -2360, -2088, -1854, -1653, -1495, -1366, -1263, -1185, -1126, -1087, -1074, -1055, -1052, -1054, -1052, -1047, -1044, -1032, -1013, -957, -901, -826, -738, -640, -499, -412, -294, -91, 133, 345, 574, 808, 1051, 1292, 1539, 1782, 1940, 2843, -8710, -10325, -4293, -1177, 1163, 2811, 3976, 4823, 5446, 5882, 6205, 6452, 6629, 6758, 6845, 6901, 6925, 6932, 6941, 6920, 6875, 6844, 6794, 6737, 6675, 6608, 6544, 6480, 6417, 6352, 6296, 6235, 6187, 6136, 6119, 6010, 4627, 5168, 6198, 6692, 6804, 6631, 6397, 5897, 5181, 5373, 5603, 5811, 6002, 6137, 6245, 6300, 6331, 6354, 6358, 6368, 6378, 6397, 6421, 6423, 6425, 6422, 6427, 6413, 6393, 6374, 6344, 6327, 6296, 6261, 6234, 6196, 6153, 6117, 6074, 6031, 5994, 5954, 5906, 5865, 5824, 5799, 5756, 5719, 5689, 5649, 5628, 5583, 5541, 5530, 5516, 5491, 5481, 5460, 5443, 5432, 5413, 5372, 5415, 5214, 552, 928, 2810, 3806, 4523, 5003, 5313, 5520, 5652, 5724, 5761, 5768, 5762, 5741, 5712, 5674, 5626, 5573, 5526, 5467, 5406, 5359, 5293, 5225, 5164, 5099, 5037, 4976, 4910, 4852, 4791, 4723, 4665, 4607, 4551, 4486, 4425, 4369, 4316, 4264, 4213, 4148, 4128, 3946, 3734, 3793, 3815, 3812, 3796, 3768, 3738, 3703, 3665, 3646, 3495, 3822, -14536, -29496, -22515, -23097, -26114, -29085, -30282, -29795, -28906, -28837, -29841, -31183, -31888, -31472, -30237, -28958, -28331, -28486, -29049, -29469, -29337, -28683, -27850, -27207, -26900, -26838, -26752, -26445, -25891, -25215, -24582, -24108, -23737, -23368, -22896, -22296, -21630, -20942, -20338, -19784, -19247, -18653, -18025, -17301, -16390, -15793, -15249, -14685, -14110, -13509, -12869, -12242, -11629, -11042, -10479, -9923, -9365, -8821, -8274, -7749, -7251, -6779, -6312, -5856, -5412, -4985, -4570, -4170, -3792, -3420, -3058, -2703, -2365, -2028, -1704, -1388, -1081, -781, -486, -193, 87, 383, 663, 940, 1216, 1487, 1762, 2052, 2325, 2575, 2846, 3101, 3361, 3617, 3872, 4115, 4355, 4599, 4844, 4988, 6777, 7238, 6683, 6512, 6437, 6437, 6490, 6593, 6715, 6835, 6968, 7107, 7243, 7379, 7511, 7637, 7759, 7867, 7989, 8100, 8191, 8298, 8399, 8491, 8574, 8658, 8745, 8822, 8900, 8969, 9037, 9106, 9177, 9210, 9377, 9095, 2648, 5372, 10466, 12943, 13557, 12802, 11458, 10188, 9400, 9025, 9089, 9405, 9791, 10097, 10282, 10336, 10300, 10240, 10170, 10126, 10111, 10131, 10160, 10178, 10201, 10214, 10222, 10213, 10198, 10184, 10166, 10160, 10142, 10123, 10111, 10087, 10064, 10042, 10013, 9985, 9957, 9930, 9895, 9865, 9833, 9803, 9766, 9725, 9693, 9651, 9617, 9592, 9548, 9511, 9465, 9421, 9386, 9340, 9300, 9266, 9220, 9167, 9118, 9103, 9666, 9565, 9264, 9081, 8938, 8828, 8729, 8643, 8570, 8508, 8444, 8379, 8323, 8263, 8208, 8152, 8096, 8037, 7978, 7918, 7859, 7804, 7741, 7675, 7618, 7554, 7493, 7434, 7367, 7312, 7250, 7182, 7123, 7064, 7005, 6938, 6872, 6806, 6745, 6684, 6622, 6549, 6490, 6446, 6398, 6315, 6249, 6179, 6109, 6043, 5974, 5914, 5846, 5799, 5632, 5926};