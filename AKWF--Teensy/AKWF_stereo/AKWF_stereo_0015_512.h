/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0015 512 samples */
 
const int16_t AKWF_stereo_0015_512_DATA [512] = 
{16266, 25323, 25049, 28495, 29273, 29122, 28979, 27202, 26510, 24592, 23391, 22131, 20819, 20233, 19359, 19139, 20103, 20276, 20120, 20487, 20847, 21129, 21685, 22199, 22892, 23594, 24330, 25100, 25830, 26550, 27093, 27747, 28348, 28890, 29387, 29816, 30196, 30514, 30780, 30991, 31146, 31275, 31273, 31162, 31157, 31096, 31005, 30882, 30731, 30555, 30355, 30135, 29896, 29636, 29384, 28987, 28588, 28299, 27978, 27651, 27317, 26976, 26626, 26268, 25906, 25537, 25162, 24791, 24271, 23828, 23432, 23077, 22695, 22283, 21874, 21456, 21039, 20616, 20191, 19763, 19343, 18820, 18399, 18003, 17602, 17196, 16791, 16384, 15975, 15567, 15159, 14751, 14352, 13925, 13439, 13048, 12659, 12260, 11941, 11197, 9397, 7934, 6472, 5033, 3918, 3033, 2401, 2001, 1814, 1790, 1855, 2009, 2195, 2404, 2617, 2812, 2992, 3138, 3253, 3324, 3369, 3373, 3373, 3342, 3286, 3204, 2836, 4397, -17993, -27051, -26502, -29934, -30562, -30127, -29715, -27663, -26643, -24493, -22991, -21494, -19933, -19088, -17982, -17579, -17071, -16860, -16993, -17185, -17661, -18131, -18783, -19452, -20177, -20937, -21675, -22429, -23151, -23763, -24334, -24944, -25495, -25986, -26431, -26819, -27157, -27441, -27678, -27869, -28012, -28133, -28077, -28061, -28078, -28069, -27939, -28253, -29433, -30269, -31105, -31895, -32396, -32702, -32758, -32474, -32164, -31738, -31233, -30652, -30045, -29419, -28793, -28183, -27587, -27022, -26493, -25948, -25330, -24892, -24478, -24091, -23726, -23379, -23050, -22732, -22426, -22126, -21830, -21547, -21193, -20801, -20520, -20223, -19923, -19619, -19313, -18999, -18684, -18365, -18042, -17716, -17398, -16998, -16621, -16302, -15966, -15690, -15363, -15043, -14737, -14094, -13477, -12906, -12294, -11724, -11125, -10595, -10134, -9682, -9260, -8851, -8461, -8084, -7715, -7359, -7009, -6668, -6323, -5953, -5625, -5293, -4986, -4671, -4359, -4096, -3557, -4218, 23069, 27338, 22178, 29167, 30960, 31056, 32143, 30384, 30999, 29470, 29090, 28380, 27311, 27131, 26127, 25979, 26639, 26192, 25486, 25675, 25813, 25659, 25856, 25862, 26118, 26348, 26623, 26974, 27273, 27622, 27791, 28125, 28433, 28711, 28977, 29196, 29400, 29558, 29688, 29782, 29836, 29881, 29798, 29616, 29558, 29449, 29318, 29157, 28972, 28762, 28528, 28273, 27997, 27700, 27406, 26955, 26501, 26159, 25781, 25392, 24989, 24576, 24151, 23714, 23268, 22812, 22344, 21878, 21253, 20709, 20207, 19748, 19261, 18739, 18221, 17694, 17166, 16633, 16097, 15557, 15028, 14384, 13842, 13329, 12816, 12300, 11790, 11278, 10769, 10262, 9759, 9259, 8769, 8251, 7674, 7201, 6730, 6252, 5880, 5038, 3245, 2235, 1184, -91, -1095, -2006, -2733, -3289, -3688, -3927, -4103, -4166, -4189, -4163, -4101, -4032, -3941, -3859, -3774, -3713, -3650, -3611, -3558, -3523, -3505, -3497, -3763, -2074, -24803, -28554, -22792, -29733, -31588, -31460, -32360, -30393, -30718, -29029, -28369, -27475, -26186, -25781, -24590, -24286, -23546, -23101, -22923, -22673, -22766, -22726, -22934, -23110, -23368, -23685, -23980, -24347, -24688, -24959, -25217, -25551, -25858, -26128, -26386, -26608, -26804, -26965, -27096, -27199, -27265, -27320, -27199, -27132, -27104, -27049, -26871, -27191, -28286, -28646, -29079, -29682, -30027, -30291, -30342, -30090, -29860, -29511, -29098, -28585, -28036, -27442, -26819, -26189, -25540, -24902, -24271, -23598, -22831, -22231, -21642, -21069, -20509, -19962, -19429, -18907, -18397, -17896, -17403, -16930, -16386, -15811, -15361, -14903, -14452, -14005, -13564, -13125, -12693, -12266, -11841, -11422, -11018, -10533, -10079, -9692, -9297, -8982, -8618, -8262, -7924, -7236, -6695, -6245, -5678, -5142, -4557, -4030, -3576, -3115, -2688, -2267, -1866, -1479, -1099, -738, -381, -38, 306, 673, 993, 1315, 1602, 1902, 2195, 2426, 2945, 2211};