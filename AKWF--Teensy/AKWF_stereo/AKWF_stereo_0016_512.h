/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0016 512 samples */
 
const int16_t AKWF_stereo_0016_512_DATA [512] = 
{17613, 32610, 30963, 28763, 23612, 17840, 11458, 4927, 1183, 154, -1004, -3618, -5687, -5836, -5998, -8051, -8061, -4762, -1705, -209, -223, -101, -619, -1520, -1931, 109, 677, 1339, 2375, 2055, 51, -1395, 5142, 11361, 13553, 14392, 15161, 16743, 15647, 13497, 12080, 12943, 12615, 10708, 8987, 8750, 8513, 5966, 5474, 8100, 10381, 11051, 10174, 9229, 8629, 9574, 8941, 9407, 8676, 6320, 4315, 2892, -23, -1783, 8387, 15306, 16397, 17551, 17457, 16870, 15144, 12740, 10873, 13432, 14873, 12464, 9836, 8789, 7645, 4439, 3306, 5437, 7379, 7759, 6647, 5679, 4068, 2124, 686, 1705, 1321, 1058, 1201, 31, -2754, -4981, 749, 6393, 8039, 8273, 8436, 9475, 7771, 5025, 3095, 3474, 2705, 437, -1866, -731, 1558, -795, -2086, -359, 918, 778, -915, -2328, -4279, -6486, -8139, -7384, -7813, -9765, -11458, -12584, -15395, -16651, 1460, 12091, 10994, 10722, 9600, 8305, 6414, 3846, 2284, 2873, 2307, 87, -2040, -2604, -3244, -6026, -6756, -4608, -1076, 2629, 2457, 1212, -725, -3194, -5037, -4359, -4929, -5169, -4961, -5961, -8528, -10519, -4673, 1181, 3192, 3746, 4192, 5486, 4127, 1733, 57, 689, 202, -1826, -3679, -4022, -4396, -6973, -7593, -5185, -2995, -2356, -3290, -4331, -5022, -4154, -4835, -4376, -5082, -7465, -9507, -10964, -13838, -15598, -5668, 1354, 2604, 3774, 3630, 2986, 1272, -1126, -3032, -488, 991, -1371, -4004, -5098, -6226, -9304, -10433, -8398, -6448, -5928, -6963, -7919, -9502, -11388, -12789, -11815, -12144, -12362, -12217, -13323, -16000, -18138, -12657, -7105, -5308, -5011, -4865, -3871, -5516, -8181, -10134, -9799, -10543, -12795, -14842, -15430, -16038, -18755, -19587, -17494, -15563, -15126, -16265, -17301, -18983, -20967, -22514, -21665, -22042, -23918, -25597, -26548, -30510, -24821, 27963, 29196, 14245, 14548, 17061, 17233, 14289, 9303, 7782, 7904, 7404, 5298, 4507, 5584, 5623, 3657, 4094, 7335, 8632, 8201, 7344, 7586, 7432, 6675, 6414, 8021, 7472, 7115, 7636, 6828, 4905, 4242, 10457, 13530, 11694, 10974, 11876, 13644, 12157, 10060, 9629, 10941, 10225, 7989, 6989, 7595, 7467, 4947, 5046, 7788, 8613, 7718, 6382, 6068, 6291, 7335, 6211, 6276, 5508, 3475, 2651, 2313, 118, -684, 8838, 11283, 7673, 8143, 8890, 9149, 8076, 6240, 5443, 8327, 8692, 5175, 3582, 4328, 4048, 1351, 1065, 3558, 4215, 3168, 1745, 1493, 839, -365, -1056, 134, -806, -1538, -1359, -2488, -4683, -5616, 344, 3188, 1020, 44, 750, 2354, 645, -1663, -2216, -1052, -1922, -4245, -5515, -3402, -1661, -5174, -6035, -3333, -2690, -3771, -5519, -5977, -6743, -7994, -8677, -7552, -8360, -10461, -11228, -11289, -13344, -13566, 2934, 5740, -2591, -2162, -239, 388, -622, -2897, -3392, -2248, -2818, -4873, -5785, -5023, -5186, -7602, -7415, -4818, -2654, -1199, -3111, -4172, -4533, -5524, -6070, -4961, -5955, -6550, -6223, -7105, -9051, -9700, -3585, -617, -2560, -3296, -2326, -490, -1908, -3901, -4205, -2805, -3434, -5556, -6394, -5608, -5631, -7986, -7761, -4968, -4093, -4902, -6101, -6269, -5887, -4702, -5697, -5452, -6002, -7854, -8467, -8592, -10559, -11135, -1510, 990, -2562, -1918, -951, -466, -1250, -2819, -3367, -257, 302, -3001, -4319, -3291, -3275, -5637, -5651, -2959, -2117, -2890, -4042, -4022, -4384, -5293, -5705, -4295, -4997, -5497, -5084, -5951, -7861, -8469, -2363, 532, -1489, -2261, -1328, 477, -971, -2984, -3298, -1923, -2582, -4731, -5554, -4776, -4822, -7194, -6984, -4223, -3399, -4258, -5524, -5615, -6149, -7214, -7812, -6517, -7305, -9395, -10117, -9963, -13130, -7001};