/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0192 512 samples */
 
const int16_t AKWF_stereo_0192_512_DATA [512] = 
{612, 2606, 4601, 6635, 8696, 10740, 12709, 14641, 16527, 18357, 20112, 21777, 23351, 24822, 26172, 27400, 28515, 29489, 30327, 31055, 31682, 32147, 32495, 32709, 32759, 32685, 32499, 32173, 31708, 31157, 30495, 29697, 28822, 27874, 26820, 25686, 24519, 23288, 21982, 20672, 19338, 17960, 16581, 15216, 13841, 12465, 11121, 9789, 8464, 7171, 5912, 4670, 3447, 2264, 1103, -47, -1164, -2259, -3342, -4405, -5446, -6475, -7483, -8472, -9448, -10398, -11332, -12250, -13135, -14000, -14844, -15653, -16427, -17179, -17895, -18562, -19200, -19801, -20350, -20853, -21324, -21744, -22103, -22432, -22720, -22943, -23129, -23288, -23398, -23457, -23507, -23526, -23497, -23462, -23422, -23349, -23262, -23191, -23094, -22989, -22900, -22802, -22673, -22561, -22444, -22289, -22123, -21952, -21743, -21486, -21215, -20902, -20517, -20091, -19621, -19071, -18443, -17765, -17009, -16150, -15229, -14233, -13132, -11950, -10705, -9370, -7945, -6461, -4908, -3281, -1609, 101, 1846, 3615, 5386, 7146, 8889, 10598, 12256, 13854, 15384, 16830, 18183, 19436, 20590, 21634, 22553, 23368, 24070, 24640, 25100, 25458, 25697, 25817, 25855, 25797, 25624, 25379, 25067, 24662, 24184, 23672, 23099, 22461, 21810, 21136, 20416, 19689, 18973, 18244, 17503, 16794, 16096, 15392, 14716, 14066, 13411, 12784, 12177, 11571, 10966, 10380, 9793, 9186, 8586, 7980, 7344, 6696, 6039, 5353, 4641, 3917, 3169, 2394, 1600, 790, -39, -887, -1744, -2611, -3486, -4362, -5235, -6107, -6968, -7815, -8647, -9457, -10243, -11007, -11734, -12433, -13103, -13736, -14324, -14889, -15421, -15904, -16363, -16796, -17183, -17553, -17903, -18219, -18507, -18786, -19041, -19255, -19461, -19644, -19782, -19890, -19977, -20013, -19991, -19936, -19828, -19636, -19388, -19081, -18679, -18189, -17629, -16976, -16204, -15350, -14403, -13334, -12161, -10901, -9528, -8043, -6484, -4827, -3079, -1223, -734, 1282, 3309, 5385, 7493, 9589, 11612, 13593, 15523, 17388, 19163, 20834, 22397, 23833, 25126, 26265, 27262, 28082, 28729, 29222, 29566, 29704, 29671, 29453, 29017, 28406, 27628, 26658, 25505, 24215, 22775, 21168, 19452, 17639, 15710, 13699, 11656, 9559, 7416, 5294, 3191, 1109, -909, -2852, -4717, -6484, -8137, -9674, -11082, -12359, -13499, -14497, -15351, -16069, -16650, -17084, -17395, -17582, -17636, -17575, -17421, -17154, -16797, -16370, -15865, -15286, -14670, -14014, -13313, -12596, -11876, -11147, -10416, -9714, -9036, -8373, -7758, -7190, -6660, -6180, -5767, -5407, -5100, -4863, -4691, -4574, -4524, -4542, -4616, -4748, -4946, -5201, -5503, -5862, -6271, -6720, -7205, -7734, -8284, -8857, -9450, -10049, -10644, -11238, -11818, -12367, -12884, -13369, -13802, -14168, -14482, -14727, -14879, -14954, -14947, -14834, -14617, -14309, -13894, -13354, -12718, -11976, -11110, -10138, -9074, -7901, -6627, -5281, -3853, -2348, -787, 817, 2456, 4119, 5783, 7433, 9058, 10641, 12162, 13609, 14975, 16239, 17388, 18413, 19314, 20076, 20682, 21147, 21464, 21611, 21607, 21460, 21152, 20688, 20097, 19371, 18498, 17516, 16441, 15253, 13975, 12649, 11263, 9821, 8376, 6927, 5471, 4044, 2667, 1339, 76, -1095, -2176, -3158, -4027, -4779, -5412, -5919, -6302, -6561, -6694, -6713, -6616, -6404, -6094, -5692, -5196, -4625, -3992, -3299, -2559, -1789, -995, -188, 617, 1408, 2178, 2916, 3613, 4260, 4848, 5374, 5826, 6202, 6496, 6708, 6834, 6868, 6816, 6676, 6445, 6127, 5728, 5246, 4682, 4049, 3344, 2571, 1738, 852, -88, -1070, -2085, -3131, -4200, -5278, -6359, -7436, -8496, -9534, -10536, -11490, -12396, -13237, -13996, -14683, -15280, -15766, -16151, -16430, -16578, -16597, -16497, -16260, -15869, -15348, -14691, -13877, -12920, -11838, -10608, -9236, -7754, -6145, -4423, -2576};