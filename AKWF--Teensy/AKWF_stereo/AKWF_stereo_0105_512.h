/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0105 512 samples */
 
const int16_t AKWF_stereo_0105_512_DATA [512] = 
{504, 1709, 2442, 3127, 3708, 4393, 4978, 5139, 5169, 5017, 5272, 5670, 5982, 6133, 6189, 5797, 5502, 6052, 6275, 7039, 6626, 6010, 6367, 6230, 6673, 6103, 5556, 5907, 5515, 5483, 5561, 5903, 6339, 6639, 7305, 7980, 9152, 9819, 12643, 14836, 14956, 15425, 15769, 16574, 16976, 17180, 17152, 16939, 17540, 17526, 17835, 17528, 17552, 18671, 18901, 19312, 19675, 20056, 20395, 20631, 21119, 21500, 21994, 22206, 22126, 22424, 22703, 23808, 24602, 24942, 25267, 25391, 26054, 26769, 27927, 28756, 29057, 29686, 30496, 31650, 31905, 31873, 30584, 29647, 30042, 30449, 30903, 31149, 31177, 30903, 30462, 30281, 30088, 30028, 29487, 28457, 27528, 26549, 26511, 26153, 25481, 24198, 24847, 25454, 24491, 23560, 22356, 20630, 19224, 18363, 18172, 18173, 17636, 16720, 15414, 13987, 12646, 11517, 10540, 9404, 8120, 6731, 5617, 4888, 4299, 3564, 2469, 1375, 123, -423, -723, -972, -1455, -2842, -3491, -3700, -3990, -3960, -5168, -5486, -5976, -6659, -6784, -6622, -6180, -5968, -5720, -5445, -5144, -4597, -4598, -4685, -5072, -5374, -5084, -5240, -5264, -5619, -6206, -7169, -7499, -7699, -7741, -7942, -8863, -9529, -15601, -16575, -16748, -16860, -16925, -17308, -17728, -18108, -18602, -18909, -19630, -20099, -20387, -20457, -19960, -20230, -20314, -20591, -20808, -20986, -20853, -20705, -21031, -21426, -22133, -22201, -22669, -23557, -24606, -26350, -26502, -26433, -26432, -26638, -27116, -27650, -28382, -28918, -29237, -29557, -29784, -30628, -31297, -31855, -31921, -31262, -31462, -31667, -32304, -32535, -32384, -31848, -30883, -30840, -30566, -29936, -28485, -27084, -25976, -25824, -26390, -26187, -25803, -25108, -24159, -23217, -22431, -21798, -21035, -19953, -18649, -17337, -16584, -15952, -15398, -14413, -12861, -11639, -10195, -9798, -9210, -7897, -6742, -5620, -5068, -4970, -4348, -3522, -2272, -863, 2737, 3985, 4757, 5451, 6142, 6947, 7714, 8101, 8298, 8386, 8784, 9432, 9997, 10283, 10491, 10259, 9975, 10748, 10918, 11821, 11317, 10530, 10826, 10573, 11295, 10696, 10492, 10694, 9839, 9451, 9263, 9424, 9681, 9865, 10318, 10828, 11803, 12264, 15256, 17435, 17404, 17745, 17940, 18626, 19025, 19088, 19055, 18581, 19151, 19120, 19507, 19264, 19067, 20079, 19666, 19723, 19976, 20369, 20699, 20882, 21240, 21404, 21711, 21680, 21454, 21544, 21626, 22543, 23077, 23386, 23746, 23889, 24464, 25204, 26210, 27195, 27525, 28250, 29028, 30151, 30352, 30232, 29168, 28257, 29067, 29781, 30403, 30683, 30761, 30521, 30113, 30010, 29783, 29777, 29169, 28146, 27249, 26250, 26408, 26038, 25226, 23743, 24688, 25220, 24217, 23093, 21788, 19987, 18553, 17830, 17685, 17903, 17229, 16077, 14578, 13073, 11698, 10639, 9696, 8624, 7386, 5967, 4910, 4082, 3535, 2695, 1377, 13, -1288, -1962, -2449, -2736, -3618, -4931, -5761, -5960, -6362, -6506, -7793, -8651, -9286, -10191, -10396, -10235, -9789, -9609, -9399, -9213, -8941, -8414, -8383, -8380, -8777, -9005, -8797, -8877, -8754, -8754, -9200, -9999, -9987, -10123, -9503, -9630, -10373, -11229, -17948, -18793, -18924, -18814, -18734, -19074, -19530, -19969, -20507, -20793, -21465, -21845, -22062, -22075, -21483, -21640, -21474, -21496, -21489, -21749, -21389, -21237, -21344, -21509, -22413, -22317, -22832, -23348, -24184, -25544, -25328, -25466, -25531, -25847, -26369, -26878, -27552, -28040, -28348, -28711, -28984, -29892, -30616, -31223, -31406, -30848, -31220, -31563, -32438, -32605, -32744, -32291, -31517, -31716, -31135, -30581, -28824, -27640, -26580, -26652, -27795, -27327, -26711, -25753, -24606, -23499, -22567, -21817, -20918, -19728, -18313, -16910, -16101, -15424, -14820, -13699, -11978, -10799, -9172, -8849, -8017, -6563, -5389, -4243, -3940, -3691, -3358, -2164, -410, 1241};