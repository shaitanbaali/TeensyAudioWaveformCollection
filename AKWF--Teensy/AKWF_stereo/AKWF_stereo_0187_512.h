/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0187 512 samples */
 
const int16_t AKWF_stereo_0187_512_DATA [512] = 
{450, 1156, 1845, 2539, 3231, 3922, 4616, 5308, 5996, 6682, 7363, 8042, 8719, 9395, 10062, 10724, 11386, 12035, 12676, 13315, 13947, 14560, 15178, 15788, 16378, 16963, 17547, 18114, 18661, 19216, 19749, 20262, 20781, 21287, 21763, 22241, 22711, 23155, 23582, 24015, 24430, 24813, 25202, 25580, 25926, 26263, 26602, 26916, 27200, 27494, 27775, 28015, 28257, 28498, 28706, 28888, 29083, 29242, 29376, 29522, 29644, 29726, 29816, 29898, 29937, 29963, 29996, 30000, 29963, 29937, 29899, 29817, 29729, 29642, 29521, 29371, 29235, 29076, 28873, 28679, 28478, 28236, 27975, 27723, 27443, 27121, 26813, 26483, 26112, 25753, 25381, 24963, 24543, 24124, 23675, 23196, 22727, 22243, 21717, 21198, 20675, 20118, 19539, 18974, 18386, 17766, 17156, 16536, 15883, 15230, 14579, 13905, 13212, 12527, 11835, 11115, 10398, 9682, 8949, 8202, 7481, 6763, 6016, 5290, 4554, 3803, 3062, 2324, 1571, 812, 53, -714, -1490, -2262, -3048, -3840, -4630, -5418, -6212, -7008, -7804, -8600, -9396, -10191, -10978, -11774, -12554, -13337, -14112, -14870, -15628, -16392, -17117, -17848, -18577, -19285, -19972, -20660, -21331, -21967, -22600, -23223, -23817, -24391, -24961, -25510, -26020, -26532, -27029, -27487, -27930, -28368, -28777, -29145, -29519, -29865, -30171, -30482, -30774, -31018, -31255, -31486, -31675, -31834, -31998, -32135, -32224, -32314, -32389, -32418, -32429, -32443, -32422, -32358, -32300, -32224, -32097, -31964, -31828, -31648, -31435, -31237, -30995, -30719, -30452, -30164, -29827, -29492, -29149, -28759, -28352, -27957, -27532, -27064, -26610, -26144, -25633, -25120, -24613, -24077, -23510, -22958, -22389, -21780, -21181, -20582, -19953, -19310, -18683, -18037, -17360, -16701, -16042, -15351, -14668, -13993, -13307, -12607, -11923, -11239, -10540, -9853, -9176, -8494, -7804, -7125, -6441, -5743, -5062, -4380, -3684, -2990, -2305, -1615, -923, -221, -4936, -4244, -3571, -2887, -2197, -1510, -816, -114, 588, 1290, 1998, 2709, 3419, 4133, 4848, 5562, 6275, 6990, 7698, 8404, 9111, 9809, 10508, 11204, 11889, 12571, 13254, 13925, 14582, 15247, 15895, 16529, 17168, 17798, 18405, 19010, 19610, 20188, 20752, 21318, 21866, 22385, 22909, 23423, 23905, 24378, 24851, 25299, 25714, 26138, 26546, 26913, 27277, 27637, 27962, 28260, 28568, 28837, 29080, 29332, 29558, 29741, 29932, 30113, 30249, 30371, 30499, 30596, 30650, 30713, 30762, 30761, 30754, 30747, 30701, 30622, 30557, 30467, 30326, 30197, 30059, 29879, 29680, 29489, 29270, 29007, 28761, 28492, 28178, 27879, 27567, 27208, 26848, 26489, 26098, 25678, 25269, 24846, 24379, 23920, 23463, 22970, 22457, 21960, 21444, 20893, 20356, 19809, 19228, 18647, 18072, 17473, 16854, 16246, 15632, 14989, 14352, 13719, 13065, 12399, 11762, 11123, 10453, 9804, 9146, 8465, 7793, 7124, 6436, 5737, 5037, 4328, 3599, 2872, 2131, 1376, 615, -147, -914, -1698, -2483, -3272, -4070, -4872, -5670, -6485, -7293, -8108, -8924, -9735, -10548, -11373, -12170, -12979, -13789, -14586, -15370, -16156, -16931, -17681, -18429, -19168, -19885, -20586, -21282, -21961, -22607, -23251, -23883, -24481, -25063, -25639, -26190, -26702, -27218, -27707, -28156, -28608, -29043, -29429, -29808, -30179, -30508, -30808, -31110, -31383, -31609, -31833, -32040, -32202, -32341, -32481, -32586, -32644, -32708, -32754, -32746, -32730, -32710, -32646, -32547, -32463, -32333, -32168, -32014, -31837, -31607, -31381, -31146, -30861, -30557, -30265, -29939, -29566, -29208, -28836, -28416, -27992, -27572, -27121, -26636, -26168, -25684, -25155, -24636, -24119, -23567, -23000, -22450, -21883, -21281, -20699, -20118, -19502, -18894, -18297, -17685, -17056, -16446, -15834, -15203, -14582, -13971, -13351, -12719, -12101, -11473, -10826, -10192, -9558, -8900, -8243, -7594, -6933, -6264, -5587};