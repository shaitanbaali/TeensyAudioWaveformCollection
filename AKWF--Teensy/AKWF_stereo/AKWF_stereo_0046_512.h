/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0046 512 samples */
 
const int16_t AKWF_stereo_0046_512_DATA [512] = 
{18816, 33963, 28627, 31721, 32134, 29105, 29330, 29565, 27126, 26537, 27320, 26263, 25621, 26653, 26887, 26553, 27278, 27970, 27879, 28090, 28547, 28484, 28319, 28393, 28277, 28002, 27893, 27801, 27618, 27534, 27538, 27506, 27513, 27592, 27652, 27701, 27780, 27843, 27871, 27898, 27916, 27905, 27884, 27865, 27835, 27803, 27779, 27760, 27745, 27738, 27739, 27743, 27753, 27766, 27778, 27788, 27799, 27807, 27810, 27811, 27810, 27807, 27802, 27797, 27792, 27786, 27783, 27781, 27780, 27780, 27781, 27783, 27785, 27788, 27789, 27791, 27793, 27793, 27793, 27793, 27793, 27791, 27790, 27789, 27788, 27788, 27788, 27788, 27788, 27788, 27788, 27788, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27788, 27788, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27789, 27671, 27693, 28591, -17155, -34422, -28509, -31721, -32134, -29106, -29330, -29565, -27126, -26537, -27320, -26264, -25621, -26653, -26887, -26553, -27278, -27970, -27879, -28090, -28547, -28484, -28319, -28393, -28277, -28002, -27893, -27801, -27618, -27534, -27538, -27506, -27513, -27592, -27652, -27701, -27780, -27843, -27871, -27898, -27916, -27905, -27884, -27865, -27836, -27803, -27779, -27760, -27745, -27738, -27740, -27743, -27753, -27766, -27778, -27788, -27799, -27807, -27810, -27812, -27810, -27807, -27802, -27797, -27792, -27786, -27783, -27781, -27780, -27781, -27781, -27783, -27785, -27788, -27789, -27791, -27793, -27794, -27793, -27794, -27793, -27791, -27790, -27789, -27789, -27788, -27789, -27788, -27788, -27788, -27789, -27788, -27789, -27790, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27790, -27789, -27788, -27789, -27789, -27790, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, -27789, 21271, 24471, 20934, 21644, 22040, 22346, 22524, 22613, 22650, 22663, 22666, 22666, 22666, 22666, 22667, 22669, 22669, 22670, 22672, 22673, 22675, 22676, 22677, 22678, 22679, 22680, 22681, 22682, 22683, 22684, 22685, 22685, 22687, 22688, 22688, 22689, 22691, 22691, 22692, 22693, 22693, 22694, 22695, 22696, 22696, 22697, 22697, 22699, 22699, 22700, 22700, 22701, 22701, 22703, 22703, 22704, 22704, 22705, 22705, 22705, 22707, 22707, 22707, 22708, 22708, 22709, 22709, 22710, 22711, 22711, 22711, 22712, 22712, 22712, 22713, 22713, 22713, 22714, 22715, 22715, 22715, 22716, 22716, 22716, 22716, 22717, 22717, 22717, 22717, 22719, 22719, 22719, 22719, 22720, 22720, 22720, 22720, 22720, 22721, 22722, 22722, 22722, 22722, 22722, 22723, 22723, 22723, 22723, 22723, 22723, 22724, 22724, 22724, 22724, 22724, 22724, 22724, 22726, 22726, 22726, 22726, 22726, 22726, 22726, 22727, 22599, 22864, 22520, -19465, -24969, -20807, -21644, -22041, -22346, -22525, -22613, -22650, -22663, -22666, -22666, -22667, -22666, -22667, -22669, -22669, -22671, -22672, -22673, -22675, -22676, -22677, -22678, -22679, -22680, -22681, -22682, -22684, -22684, -22685, -22686, -22687, -22688, -22689, -22689, -22691, -22692, -22692, -22693, -22693, -22695, -22696, -22696, -22696, -22697, -22698, -22699, -22700, -22700, -22701, -22701, -22702, -22704, -22703, -22704, -22705, -22705, -22706, -22705, -22707, -22708, -22708, -22709, -22708, -22709, -22709, -22710, -22712, -22711, -22712, -22713, -22713, -22712, -22713, -22714, -22713, -22714, -22716, -22715, -22716, -22716, -22717, -22716, -22717, -22717, -22718, -22718, -22717, -22719, -22720, -22719, -22719, -22720, -22721, -22720, -22721, -22720, -22721, -22723, -22722, -22723, -22722, -22722, -22723, -22724, -22723, -22724, -22723, -22724, -22724, -22725, -22724, -22724, -22725, -22724, -22725, -22726, -22727, -22726, -22726, -22726, -22727, -22726, -22727, -22728, -22727, -22727};