/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0185 512 samples */
 
const int16_t AKWF_stereo_0185_512_DATA [512] = 
{1160, 3280, 5320, 7344, 9342, 11287, 13159, 14949, 16624, 18198, 19660, 21004, 22215, 23309, 24290, 25136, 25867, 26499, 27016, 27429, 27768, 27989, 28105, 28142, 28096, 27937, 27713, 27431, 27053, 26598, 26107, 25547, 24907, 24235, 23526, 22740, 21916, 21066, 20166, 19213, 18259, 17260, 16219, 15162, 14098, 13001, 11884, 10773, 9660, 8527, 7408, 6305, 5200, 4105, 3052, 2013, 994, 32, -901, -1802, -2651, -3447, -4191, -4880, -5512, -6081, -6589, -7026, -7395, -7691, -7915, -8065, -8135, -8118, -8029, -7850, -7583, -7232, -6800, -6266, -5650, -4951, -4164, -3308, -2373, -1377, -329, 768, 1884, 3009, 4147, 5275, 6383, 7470, 8522, 9530, 10496, 11411, 12285, 13114, 13883, 14622, 15320, 15965, 16579, 17175, 17719, 18242, 18747, 19215, 19657, 20085, 20494, 20854, 21213, 21549, 21845, 22117, 22366, 22589, 22760, 22916, 23040, 23101, 23135, 23141, 23086, 22979, 22848, 22674, 22423, 22146, 21840, 21469, 21056, 20623, 20129, 19599, 19058, 18473, 17838, 17190, 16517, 15801, 15061, 14300, 13503, 12667, 11818, 10935, 10003, 9047, 8060, 7033, 5962, 4866, 3731, 2560, 1376, 176, -1047, -2260, -3469, -4665, -5830, -6956, -8055, -9095, -10087, -11029, -11915, -12751, -13538, -14279, -14975, -15638, -16269, -16868, -17448, -18014, -18560, -19079, -19606, -20126, -20620, -21123, -21626, -22110, -22593, -23084, -23563, -24025, -24502, -24971, -25417, -25867, -26317, -26737, -27146, -27562, -27955, -28318, -28681, -29034, -29348, -29652, -29951, -30221, -30443, -30672, -30878, -31029, -31173, -31302, -31365, -31421, -31457, -31433, -31367, -31295, -31175, -30984, -30785, -30549, -30243, -29903, -29547, -29140, -28678, -28210, -27716, -27167, -26608, -26040, -25437, -24803, -24176, -23526, -22820, -22109, -21372, -20569, -19719, -18825, -17860, -16798, -15678, -14455, -13108, -11666, -10122, -8465, -6694, -4842, -2900, -841, -8189, -5812, -3484, -1159, 1163, 3464, 5702, 7869, 9943, 11921, 13783, 15527, 17142, 18623, 19983, 21197, 22280, 23244, 24073, 24789, 25409, 25889, 26241, 26487, 26628, 26637, 26556, 26398, 26124, 25757, 25339, 24843, 24256, 23632, 22969, 22228, 21452, 20656, 19813, 18926, 18043, 17125, 16173, 15211, 14243, 13248, 12231, 11220, 10205, 9164, 8130, 7108, 6077, 5048, 4044, 3045, 2056, 1113, 196, -695, -1540, -2335, -3083, -3774, -4406, -4975, -5483, -5918, -6284, -6574, -6792, -6937, -7000, -6980, -6888, -6706, -6439, -6088, -5653, -5116, -4492, -3781, -2974, -2088, -1112, -61, 1051, 2225, 3437, 4676, 5941, 7207, 8463, 9701, 10911, 12082, 13206, 14274, 15296, 16263, 17157, 18010, 18809, 19536, 20218, 20864, 21435, 21969, 22462, 22892, 23271, 23618, 23921, 24152, 24358, 24526, 24633, 24701, 24739, 24739, 24678, 24603, 24495, 24324, 24131, 23912, 23636, 23309, 22961, 22573, 22107, 21613, 21088, 20494, 19851, 19188, 18459, 17690, 16905, 16076, 15198, 14308, 13392, 12439, 11469, 10487, 9479, 8454, 7432, 6396, 5339, 4282, 3223, 2163, 1098, 44, -1004, -2040, -3048, -4026, -4978, -5879, -6735, -7537, -8268, -8933, -9537, -10057, -10504, -10883, -11186, -11424, -11601, -11726, -11800, -11835, -11844, -11822, -11790, -11758, -11722, -11683, -11671, -11680, -11701, -11758, -11852, -11975, -12136, -12344, -12590, -12875, -13215, -13602, -14024, -14495, -15016, -15566, -16155, -16790, -17450, -18130, -18839, -19572, -20305, -21046, -21801, -22548, -23264, -23989, -24699, -25364, -26020, -26662, -27246, -27825, -28384, -28894, -29369, -29843, -30277, -30654, -31028, -31376, -31663, -31922, -32168, -32368, -32506, -32638, -32736, -32761, -32762, -32735, -32644, -32489, -32311, -32076, -31741, -31368, -30929, -30376, -29734, -29016, -28182, -27202, -26136, -24937, -23572, -22082, -20465, -18704, -16801, -14803, -12688, -10413};