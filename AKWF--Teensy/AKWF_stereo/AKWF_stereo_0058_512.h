/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0058 512 samples */
 
const int16_t AKWF_stereo_0058_512_DATA [512] = 
{16578, 25202, 25138, 25365, 25368, 25299, 25259, 25246, 25244, 25255, 25276, 25309, 25350, 25398, 25457, 25516, 25584, 25656, 25728, 25807, 25886, 25965, 26044, 26125, 26205, 26282, 26358, 26434, 26507, 26577, 26644, 26710, 26772, 26830, 26886, 26937, 26987, 27029, 27072, 27112, 27147, 27178, 27208, 27233, 27256, 27276, 27293, 27309, 27325, 27331, 27337, 28482, 29331, 29325, 29340, 29337, 29324, 29312, 29301, 29291, 29280, 29271, 29263, 29254, 29246, 29237, 29231, 29225, 29218, 29213, 29207, 29202, 29198, 29194, 29191, 29188, 29185, 29183, 29181, 29180, 29180, 29177, 29176, 29176, 29176, 29176, 29176, 29176, 29179, 29181, 29180, 29180, 29182, 29184, 29183, 29185, 29188, 29187, 29191, 29093, 29441, 27903, 11267, 3820, 4096, 3926, 3992, 4118, 4215, 4285, 4343, 4390, 4424, 4448, 4458, 4459, 4453, 4437, 4413, 4386, 4349, 4310, 4266, 4218, 4168, 4115, 4061, 4005, 3949, 3892, 3835, 3779, 3723, 3669, 3616, 3563, 3514, 3467, 3421, 3376, 3335, 3297, 3260, 3225, 3194, 3164, 3138, 3112, 3089, 3069, 2922, 3485, 1699, -18095, -23767, -23519, -23668, -23565, -23428, -23329, -23253, -23189, -23139, -23101, -23077, -23066, -23065, -23071, -23087, -23112, -23141, -23181, -23223, -23268, -23319, -23372, -23429, -23488, -23547, -23606, -23668, -23728, -23787, -23846, -23905, -23963, -24017, -24071, -24123, -24171, -24217, -24263, -24304, -24342, -24380, -24415, -24445, -24475, -24502, -24526, -24547, -24597, -24498, -25073, -29057, -30615, -30558, -30604, -30592, -30563, -30542, -30526, -30511, -30499, -30487, -30480, -30475, -30470, -30469, -30470, -30469, -30472, -30475, -30479, -30485, -30491, -30497, -30500, -30216, -31802, -20307, -2114, -1092, -950, -938, -1094, -1241, -1350, -1436, -1507, -1563, -1603, -1628, -1642, -1643, -1633, -1615, -1584, -1549, -1507, -1457, -1404, -1347, -1276, -1256, -948, 28206, 25068, 24408, 24562, 24500, 24332, 24237, 24208, 24207, 24230, 24280, 24355, 24451, 24566, 24698, 24843, 24998, 25165, 25339, 25518, 25701, 25888, 26076, 26261, 26448, 26631, 26810, 26986, 27156, 27319, 27479, 27630, 27773, 27910, 28040, 28161, 28275, 28380, 28478, 28568, 28650, 28723, 28791, 28852, 28906, 28952, 28993, 29028, 29075, 28989, 29512, 30756, 30374, 30303, 30301, 30287, 30255, 30229, 30204, 30179, 30156, 30134, 30112, 30093, 30073, 30055, 30039, 30022, 30008, 29995, 29984, 29973, 29963, 29953, 29947, 29939, 29934, 29928, 29924, 29920, 29917, 29915, 29916, 29914, 29911, 29914, 29916, 29915, 29916, 29918, 29921, 29923, 29925, 29928, 29931, 29934, 29936, 29939, 29942, 29543, 31743, 19529, 7958, 13245, 13503, 13519, 13729, 14029, 14256, 14421, 14557, 14667, 14747, 14798, 14825, 14827, 14809, 14774, 14720, 14652, 14569, 14477, 14375, 14263, 14144, 14022, 13895, 13765, 13632, 13500, 13368, 13236, 13107, 12979, 12856, 12736, 12619, 12506, 12401, 12299, 12200, 12110, 12024, 11943, 11869, 11799, 11735, 11678, 11626, 11577, 10902, 14381, -18388, -31239, -24859, -25070, -25056, -24773, -24447, -24213, -24035, -23886, -23768, -23682, -23626, -23597, -23592, -23610, -23648, -23705, -23778, -23864, -23963, -24072, -24190, -24315, -24446, -24582, -24721, -24863, -25003, -25146, -25285, -25424, -25560, -25693, -25821, -25946, -26066, -26181, -26290, -26392, -26492, -26583, -26668, -26749, -26823, -26889, -26953, -27010, -27061, -27199, -26740, -29660, -32055, -30814, -30765, -30780, -30738, -30672, -30619, -30582, -30549, -30521, -30497, -30480, -30465, -30456, -30452, -30451, -30451, -30458, -30466, -30476, -30489, -30503, -30519, -30358, -31341, -27615, 3190, 519, -1982, -2023, -2170, -2554, -2901, -3150, -3352, -3521, -3651, -3745, -3805, -3835, -3839, -3816, -3769, -3704, -3621, -3521, -3406, -3280, -3144, -2414, -5420, 11662};