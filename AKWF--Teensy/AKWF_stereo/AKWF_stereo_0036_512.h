/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0036 512 samples */
 
const int16_t AKWF_stereo_0036_512_DATA [512] = 
{959, 2741, 4491, 6239, 7974, 9694, 11394, 13060, 14693, 16285, 17828, 19320, 20756, 22125, 23430, 24663, 25818, 26895, 27889, 28795, 29613, 30341, 30974, 31514, 31959, 32307, 32559, 32713, 32770, 32733, 32598, 32370, 32048, 31635, 31132, 30541, 29865, 29107, 28270, 27358, 26372, 25318, 24203, 23029, 21798, 20522, 19198, 17836, 16444, 15019, 13571, 12110, 10633, 9148, 7663, 6176, 4698, 3232, 1777, 342, -1071, -2463, -3827, -5162, -6467, -7736, -8972, -10175, -11336, -12461, -13549, -14596, -15605, -16574, -17499, -18387, -19231, -20031, -20791, -21508, -22180, -22810, -23394, -23934, -24426, -24872, -25269, -25618, -25916, -26164, -26360, -26505, -26597, -26636, -26623, -26556, -26435, -26262, -26035, -25756, -25425, -25042, -24609, -24125, -23593, -23011, -22381, -21703, -20976, -20206, -19389, -18527, -17623, -16674, -15684, -14657, -13584, -12464, -11305, -10107, -8879, -7626, -6345, -5051, -3741, -2410, -1068, 285, 1651, 3018, 4385, 5754, 7109, 8456, 9789, 11100, 12387, 13649, 14874, 16068, 17224, 18339, 19391, 20379, 21319, 22213, 23049, 23834, 24570, 25245, 25857, 26406, 26888, 27302, 27649, 27928, 28136, 28276, 28347, 28348, 28280, 28142, 27935, 27659, 27317, 26908, 26432, 25896, 25296, 24631, 23891, 23083, 22217, 21304, 20341, 19334, 18291, 17208, 16092, 14951, 13780, 12589, 11389, 10180, 8960, 7730, 6490, 5244, 3994, 2740, 1488, 238, -1012, -2256, -3495, -4727, -5949, -7163, -8368, -9559, -10738, -11902, -13047, -14177, -15286, -16372, -17437, -18476, -19485, -20464, -21412, -22322, -23195, -24025, -24811, -25551, -26240, -26874, -27454, -27975, -28435, -28832, -29162, -29424, -29617, -29739, -29788, -29763, -29666, -29494, -29244, -28920, -28519, -28042, -27488, -26856, -26150, -25370, -24515, -23586, -22589, -21519, -20381, -19180, -17911, -16582, -15197, -13752, -12259, -10720, -9132, -7508, -5850, -4162, -2455, -693, -15110, -15234, -15352, -15465, -15570, -15669, -15757, -15833, -15894, -15937, -15961, -15962, -15939, -15888, -15809, -15698, -15554, -15375, -15163, -14914, -14629, -14304, -13942, -13537, -13092, -12605, -12073, -11498, -10878, -10211, -9499, -8740, -7933, -7082, -6183, -5237, -4248, -3214, -2136, -1020, 135, 1326, 2547, 3798, 5075, 6369, 7682, 9004, 10330, 11658, 12982, 14292, 15591, 16866, 18114, 19331, 20512, 21647, 22738, 23776, 24752, 25667, 26511, 27280, 27976, 28588, 29113, 29550, 29895, 30145, 30298, 30355, 30312, 30172, 29933, 29593, 29155, 28621, 27988, 27259, 26436, 25517, 24506, 23408, 22221, 20948, 19597, 18166, 16662, 15095, 13461, 11772, 10037, 8252, 6434, 4587, 2713, 829, -1062, -2958, -4843, -6715, -8568, -10389, -12177, -13926, -15621, -17266, -18855, -20375, -21831, -23214, -24518, -25742, -26881, -27931, -28893, -29740, -30474, -31104, -31627, -32043, -32357, -32588, -32726, -32769, -32712, -32557, -32303, -31953, -31509, -30971, -30343, -29626, -28822, -27936, -26968, -25920, -24802, -23608, -22346, -21020, -19656, -18259, -16815, -15325, -13807, -12252, -10654, -9033, -7404, -5764, -4123, -2490, -863, 747, 2335, 3902, 5436, 6939, 8406, 9829, 11210, 12547, 13831, 15063, 16240, 17358, 18416, 19414, 20331, 21172, 21941, 22633, 23251, 23793, 24257, 24643, 24951, 25182, 25337, 25416, 25433, 25394, 25288, 25116, 24879, 24577, 24213, 23788, 23303, 22763, 22166, 21523, 20828, 20089, 19309, 18493, 17640, 16760, 15853, 14923, 13980, 13021, 12054, 11083, 10107, 9130, 8162, 7195, 6236, 5288, 4347, 3422, 2512, 1614, 736, -120, -959, -1776, -2568, -3337, -4079, -4794, -5481, -6137, -6765, -7364, -7930, -8466, -8970, -9445, -9890, -10307, -10694, -11055, -11391, -11702, -11990, -12258, -12509, -12742, -12959, -13164, -13358, -13542, -13716, -13881, -14040, -14193, -14339, -14480, -14618, -14753, -14885, -15016};