/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0098 512 samples */
 
const int16_t AKWF_stereo_0098_512_DATA [512] = 
{723, 1804, 2829, 3897, 4967, 6008, 7036, 8065, 9118, 10150, 11181, 12201, 13177, 14162, 15096, 16042, 16913, 17758, 18498, 19199, 19809, 20383, 20891, 21356, 21753, 22085, 22361, 22544, 22711, 22804, 22885, 22881, 22852, 22730, 22611, 22387, 22171, 21868, 21564, 21170, 20814, 20351, 19871, 19303, 18714, 18065, 17448, 16714, 16049, 15303, 14570, 13768, 12948, 12099, 11249, 10351, 9450, 8530, 7577, 6568, 5555, 4530, 3490, 2459, 1370, 322, -770, -1854, -2972, -4091, -5227, -6368, -7575, -8753, -9976, -11164, -12396, -13575, -14769, -15900, -17033, -18114, -19160, -20189, -21156, -22097, -22960, -23784, -24526, -25198, -25817, -26378, -26905, -27318, -27640, -27902, -28085, -28210, -28269, -28259, -28187, -28049, -27834, -27543, -27176, -26741, -26277, -25749, -25143, -24511, -23779, -23039, -22229, -21388, -20489, -19549, -18535, -17513, -16441, -15362, -14242, -13137, -12015, -10905, -9779, -8638, -7513, -6402, -5319, -4272, -3276, -2336, -1411, -516, 374, 1236, 2077, 2865, 3675, 4401, 5144, 5862, 6559, 7247, 7892, 8549, 9175, 9803, 10436, 11045, 11640, 12224, 12754, 13286, 13766, 14242, 14629, 15033, 15357, 15675, 15961, 16230, 16450, 16690, 16841, 16986, 17031, 17085, 17089, 17105, 17044, 16993, 16840, 16716, 16535, 16347, 16090, 15784, 15421, 15025, 14617, 14144, 13635, 13051, 12413, 11716, 10963, 10110, 9252, 8337, 7413, 6444, 5456, 4429, 3417, 2370, 1341, 282, -778, -1815, -2837, -3852, -4852, -5854, -6811, -7777, -8691, -9591, -10459, -11300, -12104, -12854, -13611, -14288, -14945, -15498, -16024, -16506, -16936, -17313, -17642, -17922, -18132, -18311, -18460, -18524, -18602, -18615, -18591, -18520, -18335, -18123, -17800, -17455, -17029, -16561, -16037, -15483, -14906, -14261, -13618, -12869, -12155, -11371, -10632, -9805, -8972, -8092, -7199, -6272, -5342, -4371, -3392, -2384, -1352, -288, -9018, -8550, -8214, -7803, -7488, -7214, -7133, -6937, -6773, -6628, -6427, -6256, -6100, -5859, -5756, -5552, -5379, -5201, -5022, -4797, -4614, -4441, -4234, -4108, -3862, -3664, -3475, -3265, -3013, -2739, -2334, -1852, -1270, -660, 107, 808, 1638, 2426, 3217, 4011, 4828, 5640, 6428, 7168, 7919, 8664, 9494, 10178, 10935, 11501, 12012, 12405, 12726, 13057, 13242, 13370, 13403, 13299, 13153, 12817, 12404, 11861, 11210, 10593, 9786, 8929, 7914, 6763, 5607, 4248, 2808, 1237, -425, -2030, -3691, -5315, -6971, -8609, -10311, -11912, -13694, -15293, -16926, -18499, -19920, -21387, -22642, -23913, -24955, -26064, -26833, -27676, -28340, -28911, -29383, -29752, -30006, -30202, -30249, -30329, -30295, -30239, -30073, -29848, -29552, -29183, -28690, -28212, -27533, -26905, -26114, -25310, -24421, -23503, -22558, -21564, -20412, -19297, -18165, -16926, -15724, -14476, -13158, -11794, -10347, -8900, -7491, -6115, -4573, -3025, -1369, 170, 1830, 3479, 5137, 6811, 8357, 9857, 11283, 12595, 13922, 15232, 16509, 17905, 19224, 20552, 21814, 23146, 24362, 25581, 26690, 27692, 28672, 29583, 30455, 31171, 31745, 32158, 32472, 32629, 32712, 32725, 32692, 32605, 32437, 32138, 31696, 31080, 30359, 29568, 28603, 27619, 26411, 25275, 23915, 22667, 21308, 19894, 18550, 17187, 15821, 14508, 13187, 11954, 10686, 9404, 8202, 6920, 5753, 4530, 3292, 2184, 1006, -90, -1153, -2210, -3186, -4121, -4999, -5741, -6425, -7058, -7642, -8277, -8738, -9383, -9977, -10515, -11203, -11715, -12315, -12878, -13470, -13950, -14504, -14822, -15202, -15423, -15712, -15897, -16091, -16247, -16471, -16690, -16933, -17126, -17456, -17725, -17999, -18214, -18291, -18337, -18236, -18156, -17901, -17663, -17277, -16948, -16600, -16204, -15891, -15433, -15094, -14596, -14211, -13708, -13343, -12889, -12464, -12038, -11573, -11148, -10732, -10266, -9876, -9381};