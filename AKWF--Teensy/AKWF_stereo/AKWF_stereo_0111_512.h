/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0111 512 samples */
 
const int16_t AKWF_stereo_0111_512_DATA [512] = 
{852, 3409, 7374, 10225, 13255, 14541, 12009, 13651, 4813, -16667, -17868, -17426, -17489, -17880, -18273, -19196, -20251, -21541, -23491, -25157, -28015, -29827, -31812, -32386, -29869, -30698, -21903, -2461, 11358, 29714, 29651, 31265, 32608, 30594, 29060, 26418, 24186, 22495, 20711, 19747, 18600, 18065, 17632, 17467, 17328, 18901, 6789, -12945, -12059, -13409, -14515, -11444, -8946, -5137, -1981, 592, 3219, 4879, 6690, 7767, 8749, 9416, 9763, 10041, 9994, 9916, 9631, 9272, 8785, 8186, 7571, 6875, 6177, 5455, 4718, 4002, 3294, 2614, 1957, 1397, 850, 296, -220, -714, -1187, -1630, -2038, -2414, -2771, -3101, -3410, -3693, -3955, -4196, -4418, -4619, -4803, -4972, -5129, -5243, -5345, -5450, -5538, -5616, -5682, -5734, -5776, -5808, -5827, -5836, -5833, -5828, -5774, -5734, -5697, -5651, -5598, -5536, -5467, -5390, -5307, -5217, -5119, -5014, -4902, -4751, -4629, -4505, -4377, -4249, -4128, -3992, -3849, -3704, -3557, -3396, -3240, -3077, -2889, -2730, -2570, -2409, -2247, -2086, -1921, -1758, -1592, -1428, -1242, -1073, -893, -704, -542, -375, -207, -39, 126, 297, 463, 627, 800, 994, 1159, 1341, 1516, 1679, 1844, 2008, 2171, 2332, 2494, 2655, 2812, 2986, 3169, 3320, 3483, 3636, 3781, 3925, 4065, 4193, 4314, 4445, 4571, 4690, 4831, 4966, 5069, 5171, 5265, 5352, 5431, 5505, 5569, 5627, 5675, 5718, 5750, 5807, 5833, 5834, 5831, 5817, 5791, 5754, 5706, 5648, 5575, 5492, 5396, 5286, 5189, 5046, 4883, 4705, 4513, 4301, 4069, 3817, 3544, 3248, 2926, 2583, 2214, 1825, 1396, 937, 453, -54, -586, -1150, -1682, -2304, -2974, -3671, -4384, -5109, -5847, -6548, -7253, -7909, -8506, -9073, -9465, -9812, -9967, -10038, -9936, -9570, -9146, -8202, -7283, -5757, -4017, -1956, 7135, 7658, 10851, 11548, 13407, 12411, 6758, 16944, 15059, -9615, -11631, -11384, -11522, -12086, -12139, -12934, -13537, -14334, -16177, -16860, -20126, -20845, -22712, -21772, -16387, -26370, -24922, -2971, 13444, 30546, 18977, 18490, 23533, 21190, 20924, 18222, 16357, 15362, 13630, 13400, 12340, 12169, 11765, 11462, 11150, 12595, -2259, -21154, -9379, -8994, -14248, -11861, -11665, -8941, -7280, -6375, -4798, -4783, -3901, -4016, -3887, -3967, -4331, -4476, -5001, -5310, -5809, -6259, -6647, -7075, -7412, -7815, -8145, -8481, -8804, -9082, -9350, -9574, -9844, -10042, -10230, -10434, -10609, -10773, -10924, -11054, -11164, -11255, -11344, -11416, -11484, -11542, -11590, -11630, -11663, -11690, -11711, -11730, -11741, -11714, -11686, -11678, -11653, -11625, -11589, -11546, -11496, -11436, -11369, -11297, -11209, -11120, -10978, -10854, -10734, -10605, -10466, -10318, -10164, -9996, -9823, -9639, -9446, -9243, -9026, -8765, -8541, -8309, -8070, -7829, -7590, -7334, -7072, -6807, -6538, -6249, -5964, -5667, -5343, -5054, -4760, -4461, -4160, -3861, -3558, -3253, -2944, -2636, -2304, -1989, -1661, -1324, -1014, -701, -388, -73, 240, 555, 867, 1178, 1498, 1840, 2153, 2482, 2801, 3108, 3415, 3719, 4020, 4320, 4620, 4917, 5206, 5512, 5832, 6112, 6404, 6682, 6948, 7211, 7471, 7719, 7955, 8198, 8433, 8656, 8904, 9148, 9351, 9549, 9738, 9916, 10086, 10247, 10397, 10541, 10674, 10799, 10914, 11058, 11170, 11256, 11336, 11404, 11469, 11523, 11569, 11609, 11640, 11666, 11684, 11694, 11735, 11734, 11721, 11699, 11677, 11645, 11609, 11565, 11512, 11448, 11378, 11298, 11205, 11109, 10986, 10845, 10687, 10516, 10331, 10118, 9952, 9694, 9455, 9211, 8933, 8640, 8295, 7978, 7598, 7228, 6861, 6423, 6051, 5509, 5160, 4717, 4351, 4201, 3798, 4060, 3825, 4383, 4826, 5344};