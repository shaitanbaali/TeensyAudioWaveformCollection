/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0075 512 samples */
 
const int16_t AKWF_stereo_0075_512_DATA [512] = 
{284, 1088, 1877, 2663, 3448, 4233, 5016, 5792, 6564, 7336, 8099, 8859, 9612, 10358, 11099, 11835, 12562, 13286, 14000, 14704, 15399, 16085, 16760, 17423, 18075, 18715, 19343, 19961, 20565, 21158, 21737, 22305, 22859, 23398, 23926, 24438, 24936, 25420, 25889, 26340, 26779, 27201, 27606, 27995, 28360, 28698, 29018, 29316, 29595, 29857, 30100, 30325, 30537, 30730, 30909, 31069, 31210, 31334, 31441, 31532, 31607, 31667, 31708, 31733, 31743, 31734, 31710, 31670, 31610, 31535, 31442, 31330, 31200, 31052, 30883, 30697, 30490, 30264, 30014, 29743, 29452, 29137, 28797, 28436, 28061, 27672, 27269, 26851, 26416, 25968, 25502, 25025, 24532, 24025, 23504, 22969, 22421, 21860, 21287, 20699, 20101, 19489, 18865, 18228, 17581, 16922, 16254, 15575, 14884, 14186, 13476, 12758, 12034, 11301, 10559, 9813, 9060, 8300, 7538, 6768, 5995, 5217, 4436, 3651, 2864, 2074, 1284, 497, -296, -1086, -1876, -2664, -3449, -4234, -5017, -5793, -6565, -7336, -8099, -8860, -9613, -10359, -11100, -11836, -12563, -13287, -14001, -14704, -15400, -16085, -16760, -17424, -18076, -18715, -19344, -19961, -20565, -21158, -21738, -22305, -22860, -23398, -23926, -24438, -24936, -25420, -25889, -26340, -26779, -27202, -27606, -27995, -28360, -28699, -29018, -29316, -29595, -29857, -30100, -30326, -30537, -30730, -30909, -31069, -31210, -31334, -31441, -31532, -31607, -31667, -31708, -31733, -31743, -31734, -31710, -31670, -31610, -31535, -31442, -31330, -31200, -31052, -30884, -30697, -30491, -30264, -30014, -29744, -29452, -29137, -28797, -28436, -28062, -27673, -27269, -26851, -26417, -25968, -25503, -25025, -24533, -24025, -23504, -22969, -22421, -21860, -21287, -20699, -20101, -19489, -18865, -18229, -17581, -16922, -16255, -15576, -14885, -14187, -13476, -12759, -12035, -11301, -10560, -9813, -9061, -8300, -7539, -6769, -5995, -5218, -4437, -3652, -2865, -2077, -1289, -487, 1024, 1851, 2662, 3471, 4279, 5084, 5888, 6685, 7479, 8273, 9056, 9837, 10611, 11377, 12138, 12893, 13637, 14376, 15104, 15822, 16533, 17233, 17922, 18603, 19271, 19926, 20571, 21204, 21823, 22430, 23023, 23602, 24168, 24718, 25252, 25773, 26277, 26766, 27240, 27694, 28135, 28558, 28962, 29350, 29715, 30053, 30370, 30666, 30938, 31189, 31419, 31629, 31822, 31995, 32150, 32286, 32404, 32504, 32589, 32656, 32709, 32746, 32764, 32767, 32755, 32726, 32682, 32620, 32543, 32449, 32337, 32209, 32063, 31898, 31715, 31513, 31292, 31050, 30786, 30502, 30196, 29865, 29511, 29134, 28739, 28324, 27894, 27445, 26981, 26500, 26002, 25492, 24963, 24419, 23861, 23289, 22701, 22102, 21491, 20864, 20226, 19575, 18912, 18239, 17553, 16856, 16152, 15437, 14711, 13978, 13235, 12484, 11729, 10964, 10190, 9415, 8631, 7841, 7051, 6252, 5449, 4645, 3837, 3028, 2217, 1403, 591, -222, -1036, -1848, -2661, -3472, -4279, -5084, -5888, -6686, -7480, -8273, -9057, -9837, -10612, -11378, -12139, -12893, -13638, -14376, -15105, -15822, -16533, -17234, -17923, -18603, -19271, -19926, -20571, -21204, -21823, -22431, -23023, -23602, -24168, -24718, -25253, -25773, -26277, -26766, -27240, -27694, -28135, -28558, -28962, -29350, -29715, -30053, -30370, -30666, -30938, -31189, -31419, -31629, -31822, -31995, -32150, -32286, -32404, -32504, -32589, -32656, -32709, -32746, -32764, -32767, -32755, -32726, -32682, -32620, -32543, -32449, -32337, -32209, -32063, -31898, -31715, -31513, -31292, -31050, -30786, -30502, -30196, -29865, -29511, -29134, -28739, -28325, -27894, -27445, -26981, -26500, -26003, -25492, -24964, -24420, -23862, -23289, -22701, -22103, -21491, -20864, -20227, -19576, -18913, -18239, -17554, -16857, -16153, -15438, -14712, -13979, -13235, -12485, -11729, -10964, -10191, -9416, -8632, -7842, -7051, -6253, -5450, -4646, -3838, -3029, -2218, -1406, -595, 232};