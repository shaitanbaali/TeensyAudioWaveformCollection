/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0186 512 samples */
 
const int16_t AKWF_stereo_0186_512_DATA [512] = 
{2704, 8118, 13109, 17692, 21643, 24944, 27552, 29493, 30848, 31658, 31994, 31954, 31610, 30999, 30210, 29294, 28251, 27125, 25960, 24730, 23473, 22213, 20943, 19694, 18522, 17442, 16418, 15479, 14696, 14034, 13519, 13138, 12912, 12778, 12772, 12835, 12943, 13087, 13229, 13360, 13447, 13497, 13525, 13485, 13377, 13241, 13028, 12736, 12403, 12020, 11564, 11073, 10524, 9932, 9314, 8697, 8056, 7392, 6742, 6108, 5505, 4910, 4353, 3810, 3233, 2671, 2129, 1621, 1096, 582, 148, -256, -598, -912, -1128, -1222, -1180, -1033, -778, -449, -18, 457, 970, 1527, 2061, 2547, 2911, 3168, 3237, 3228, 3073, 2795, 2364, 1886, 1349, 852, 386, 0, -288, -446, -514, -496, -397, -227, -6, 257, 545, 822, 1112, 1361, 1596, 1805, 2031, 2209, 2385, 2511, 2628, 2673, 2646, 2553, 2419, 2171, 1825, 1446, 1012, 511, -43, -573, -1079, -1526, -1921, -2209, -2424, -2552, -2589, -2520, -2360, -2102, -1799, -1488, -1109, -686, -210, 242, 726, 1188, 1641, 2082, 2473, 2837, 3193, 3537, 3874, 4149, 4451, 4715, 4959, 5180, 5328, 5412, 5371, 5213, 4942, 4567, 4090, 3462, 2784, 1982, 1085, 134, -789, -1705, -2618, -3453, -4249, -4927, -5524, -6012, -6413, -6724, -6970, -7164, -7318, -7446, -7576, -7741, -7909, -8101, -8379, -8687, -8990, -9328, -9588, -9823, -10045, -10282, -10548, -10837, -11118, -11439, -11771, -12132, -12470, -12865, -13254, -13595, -13878, -14157, -14414, -14650, -14918, -15240, -15613, -16011, -16474, -17015, -17587, -18180, -18822, -19448, -20100, -20683, -21181, -21591, -21951, -22240, -22427, -22591, -22690, -22743, -22760, -22831, -22860, -22930, -23022, -23180, -23390, -23681, -24080, -24501, -24964, -25426, -25869, -26230, -26517, -26647, -26473, -25976, -25027, -23537, -21419, -18622, -15198, -10889, -7294, -2533, 2585, 8086, 13146, 17749, 21691, 24969, 27511, 29341, 30547, 31231, 31457, 31338, 30994, 30396, 29667, 28878, 27989, 27023, 26001, 24897, 23721, 22421, 21011, 19517, 17966, 16396, 14819, 13258, 11850, 10560, 9433, 8493, 7840, 7392, 7155, 7094, 7165, 7357, 7639, 7962, 8284, 8555, 8786, 8999, 9143, 9239, 9243, 9185, 9122, 9026, 8857, 8703, 8490, 8216, 7919, 7603, 7235, 6834, 6372, 5865, 5373, 4904, 4486, 4116, 3769, 3502, 3353, 3282, 3236, 3266, 3353, 3462, 3605, 3690, 3745, 3758, 3696, 3555, 3367, 3121, 2830, 2551, 2264, 2026, 1899, 1915, 2011, 2201, 2456, 2822, 3261, 3748, 4225, 4720, 5124, 5501, 5864, 6176, 6440, 6676, 6861, 7045, 7215, 7371, 7530, 7698, 7881, 8017, 8134, 8199, 8247, 8202, 8130, 7992, 7811, 7548, 7234, 6859, 6407, 5920, 5448, 4954, 4463, 3977, 3472, 2968, 2429, 1881, 1328, 738, 143, -491, -1169, -1859, -2554, -3224, -3838, -4393, -4840, -5177, -5415, -5566, -5623, -5645, -5546, -5411, -5261, -5145, -5028, -4908, -4774, -4607, -4400, -4233, -4001, -3737, -3405, -3052, -2686, -2289, -1880, -1475, -1060, -653, -287, 24, 298, 535, 687, 757, 766, 780, 750, 740, 718, 713, 681, 657, 630, 568, 423, 227, -58, -405, -787, -1250, -1735, -2203, -2675, -3137, -3543, -3896, -4160, -4364, -4526, -4699, -4891, -5145, -5452, -5883, -6446, -7099, -7813, -8606, -9427, -10239, -11012, -11727, -12364, -12893, -13357, -13738, -14043, -14299, -14580, -14889, -15247, -15683, -16234, -16880, -17650, -18455, -19324, -20208, -21146, -22099, -22973, -23873, -24720, -25468, -26119, -26755, -27281, -27767, -28251, -28757, -29252, -29783, -30389, -30970, -31524, -32035, -32464, -32700, -32775, -32562, -31968, -30984, -29456, -27336, -24525, -21032, -16956, -12090, -7929, -2795};