/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0064 512 samples */
 
const int16_t AKWF_stereo_0064_512_DATA [512] = 
{2291, 8233, 12632, 15911, 18302, 20035, 21306, 22275, 23082, 23838, 24614, 25449, 26347, 27277, 28199, 29063, 29824, 30458, 30947, 31286, 31481, 31543, 31492, 31350, 31148, 30918, 30694, 30501, 30354, 30246, 30159, 30063, 29913, 29665, 29276, 28709, 27940, 26957, 25767, 24414, 22958, 21488, 20112, 18903, 17907, 17121, 16473, 15852, 15126, 14151, 12804, 10994, 8697, 5860, 3622, 5989, 3598, 482, -1689, -3078, -3708, -3694, -3191, -2390, -1508, -760, -337, -389, -997, -2132, -3638, -5288, -6852, -8138, -9004, -9375, -9224, -8574, -7487, -6084, -4534, -3019, -1726, -794, -292, -247, -609, -1261, -2019, -2700, -3155, -3286, -3064, -2520, -1753, -903, -109, 520, 927, 1010, 650, -159, -1285, -2518, -3643, -4486, -4924, -4905, -4441, -3604, -2528, -1388, -372, 417, 916, 1001, 551, -404, -1664, -2969, -4054, -4719, -4821, -4296, -3220, -1362, -3252, -4033, -1143, 1136, 2897, 3971, 4348, 4093, 3331, 2243, 1041, -62, -924, -1482, -1641, -1285, -428, 754, 2019, 3144, 3952, 4335, 4261, 3756, 2907, 1854, 773, -171, -888, -1330, -1423, -1090, -368, 597, 1604, 2465, 3045, 3278, 3156, 2737, 2129, 1476, 928, 640, 753, 1371, 2497, 4007, 5705, 7363, 8776, 9801, 10347, 10370, 9876, 8925, 7620, 6112, 4597, 3275, 2312, 1829, 1872, 2393, 3236, 4175, 4963, 5378, 5257, 4524, 2968, 1965, 4871, 2136, -1665, -5026, -7866, -10113, -11801, -13019, -13905, -14597, -15240, -15972, -16890, -18033, -19396, -20905, -22463, -23978, -25361, -26558, -27550, -28332, -28926, -29363, -29683, -29932, -30152, -30381, -30647, -30960, -31314, -31687, -32052, -32370, -32611, -32746, -32754, -32617, -32325, -31881, -31289, -30572, -29768, -28913, -28060, -27244, -26478, -25747, -24998, -24137, -23052, -21606, -19623, -16943, -13461, -8537, -7909, -5002, 18544, 20551, 21675, 22342, 22707, 22896, 23007, 23112, 23270, 23512, 23846, 24270, 24749, 25250, 25744, 26203, 26608, 26956, 27244, 27475, 27657, 27803, 27924, 28039, 28165, 28320, 28514, 28747, 29012, 29292, 29559, 29786, 29946, 30014, 29970, 29805, 29519, 29117, 28633, 28105, 27586, 27134, 26787, 26564, 26449, 26387, 26298, 26092, 25681, 24978, 23898, 22353, 20159, 17428, 11794, -5156, -10596, -11950, -12791, -12920, -12584, -11920, -11068, -10194, -9498, -9204, -9484, -10360, -11662, -13142, -14573, -15793, -16720, -17310, -17550, -17453, -17036, -16340, -15413, -14340, -13230, -12233, -11532, -11308, -11649, -12452, -13486, -14500, -15317, -15828, -15989, -15791, -15254, -14422, -13383, -12268, -11299, -10813, -11120, -12209, -13725, -15296, -16675, -17716, -18365, -18600, -18422, -17856, -16937, -15730, -14320, -12864, -11618, -10971, -11278, -12454, -14049, -15624, -16916, -17798, -18195, -18067, -17372, -16046, -13844, -11348, 1289, 12296, 14306, 15882, 16522, 16533, 16035, 15119, 13878, 12428, 10909, 9574, 8807, 8967, 10048, 11609, 13214, 14595, 15620, 16244, 16452, 16263, 15704, 14822, 13684, 12384, 11067, 9973, 9423, 9693, 10715, 12116, 13521, 14708, 15568, 16056, 16175, 15955, 15457, 14770, 14036, 13442, 13220, 13552, 14460, 15773, 17245, 18649, 19835, 20717, 21245, 21416, 21237, 20730, 19928, 18891, 17701, 16474, 15370, 14588, 14302, 14591, 15334, 16290, 17200, 17858, 18134, 17922, 17128, 15546, 13402, 7406, -9874, -15512, -17895, -19671, -20782, -21463, -21851, -22061, -22199, -22360, -22621, -23031, -23601, -24302, -25083, -25877, -26624, -27286, -27840, -28278, -28613, -28860, -29043, -29186, -29320, -29464, -29641, -29865, -30136, -30444, -30767, -31088, -31383, -31627, -31811, -31922, -31952, -31898, -31764, -31558, -31296, -31001, -30700, -30421, -30182, -29984, -29810, -29619, -29350, -28934, -28287, -27311, -25878, -23815, -20694, -17221, 346, 16021};