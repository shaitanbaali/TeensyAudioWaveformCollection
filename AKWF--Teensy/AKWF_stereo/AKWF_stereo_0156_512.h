/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0156 512 samples */
 
const int16_t AKWF_stereo_0156_512_DATA [512] = 
{27367, 32420, 32432, 32301, 32237, 32154, 32070, 31987, 31905, 31823, 31742, 31662, 31582, 31503, 31425, 31347, 31271, 31195, 31119, 31044, 30969, 30896, 30823, 30751, 30680, 30609, 30538, 30468, 30399, 30330, 30262, 30195, 30129, 30063, 29998, 29933, 29868, 29805, 29742, 29679, 29617, 29555, 29495, 29434, 29374, 29316, 29257, 29198, 29140, 29083, 29026, 28970, 28914, 28859, 28804, 28749, 28696, 28643, 28590, 28538, 28486, 28434, 28384, 28334, 28285, 28234, 28187, 28134, 28034, 28291, 25070, 19827, 19751, 19859, 19884, 19933, 19982, 20028, 20076, 20123, 20169, 20216, 20261, 20306, 20351, 20395, 20439, 20483, 20525, 20569, 20611, 20652, 20694, 20736, 20777, 20818, 20858, 20898, 20937, 20977, 21016, 21055, 21093, 21130, 21168, 21206, 21243, 21280, 21316, 21352, 21388, 21423, 21458, 21493, 21528, 21562, 21596, 21630, 21663, 21696, 21729, 21762, 21794, 21826, 21857, 21889, 21920, 21950, 21981, 22012, 22042, 22072, 22102, 22130, 21902, 23269, 18103, -25349, -27504, -26822, -26946, -26918, -26891, -26864, -26838, -26811, -26785, -26759, -26734, -26709, -26683, -26658, -26634, -26609, -26585, -26561, -26537, -26513, -26490, -26467, -26444, -26421, -26398, -26376, -26354, -26331, -26310, -26289, -26267, -26246, -26225, -26204, -26183, -26163, -26143, -26123, -26103, -26083, -26064, -26044, -26025, -26006, -25988, -25968, -25950, -25931, -25913, -25896, -25878, -25860, -25843, -25825, -25808, -25792, -25775, -25758, -25742, -25725, -25709, -25693, -25677, -25661, -25646, -25631, -25616, -25600, -25585, -25570, -25555, -25541, -25527, -25512, -25498, -25484, -25470, -25456, -25443, -25429, -25416, -25403, -25390, -25376, -25364, -25351, -25338, -25326, -25314, -25301, -25289, -25278, -25265, -25253, -25242, -25230, -25219, -25207, -25196, -25185, -25173, -25163, -25152, -25142, -25131, -25120, -25111, -25100, -25091, -25081, -25070, -25061, -25051, -25041, -25033, -25023, -25018, -25000, 20727, 32516, 32544, 32239, 32090, 31894, 31699, 31504, 31314, 31123, 30933, 30747, 30560, 30377, 30195, 30013, 29835, 29657, 29479, 29305, 29131, 28960, 28790, 28621, 28455, 28288, 28124, 27962, 27800, 27641, 27483, 27327, 27171, 27017, 26865, 26713, 26563, 26415, 26268, 26122, 25977, 25833, 25691, 25550, 25410, 25273, 25135, 24999, 24864, 24730, 24598, 24467, 24337, 24207, 24080, 23953, 23828, 23703, 23580, 23458, 23337, 23218, 23099, 22982, 22867, 22751, 22639, 22516, 22284, 22882, 15368, 3138, 2962, 3213, 3271, 3384, 3499, 3608, 3719, 3829, 3936, 4044, 4150, 4255, 4360, 4463, 4565, 4667, 4768, 4868, 4967, 5065, 5161, 5258, 5354, 5448, 5542, 5636, 5728, 5820, 5911, 6001, 6091, 6179, 6267, 6354, 6440, 6526, 6611, 6695, 6779, 6862, 6944, 7026, 7106, 7186, 7265, 7344, 7422, 7499, 7575, 7652, 7726, 7801, 7875, 7948, 8020, 8091, 8163, 8235, 8305, 8375, 8443, 8512, 8430, 9276, 6316, -18959, -20167, -19720, -19743, -19681, -19617, -19555, -19493, -19431, -19370, -19310, -19250, -19191, -19132, -19073, -19017, -18959, -18903, -18846, -18791, -18736, -18680, -18627, -18573, -18520, -18467, -18415, -18363, -18312, -18262, -18211, -18161, -18111, -18062, -18014, -17966, -17918, -17870, -17824, -17778, -17732, -17686, -17641, -17596, -17552, -17508, -17465, -17421, -17379, -17337, -17296, -17253, -17212, -17171, -17131, -17092, -17052, -17012, -16973, -16936, -16898, -16860, -16823, -16785, -16748, -16713, -16676, -16640, -16605, -16570, -16535, -16500, -16467, -16434, -16400, -16366, -16334, -16301, -16270, -16238, -16207, -16176, -16144, -16114, -16084, -16054, -16024, -15995, -15966, -15937, -15908, -15880, -15852, -15824, -15797, -15769, -15743, -15716, -15689, -15662, -15637, -15610, -15585, -15560, -15536, -15511, -15486, -15464, -15439, -15416, -15393, -15369, -15348, -15325, -15302, -15284, -15260, -15249, -15207};