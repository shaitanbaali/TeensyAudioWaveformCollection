/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0197 512 samples */
 
const int16_t AKWF_stereo_0197_512_DATA [512] = 
{1941, 6387, 9958, 12632, 14385, 15280, 15429, 14993, 14176, 13160, 12106, 11133, 10300, 9653, 9199, 8891, 8752, 8779, 8938, 9203, 9575, 10009, 10436, 10862, 11295, 11743, 12213, 12726, 13296, 13955, 14751, 15697, 16708, 17721, 18733, 19694, 20543, 21257, 21782, 22087, 22230, 22261, 22204, 22043, 21860, 21673, 21476, 21295, 21114, 20868, 20525, 20017, 19288, 18387, 17410, 16456, 15711, 15412, 15676, 16563, 18114, 20265, 22824, 25570, 28173, 30302, 31790, 32584, 32648, 31989, 30709, 28977, 26947, 24789, 22725, 20860, 19253, 17988, 17079, 16474, 16173, 16202, 16483, 16970, 17673, 18492, 19295, 20095, 20874, 21599, 22266, 22889, 23458, 23978, 24506, 25048, 25495, 25800, 25970, 25938, 25656, 25112, 24253, 23044, 21567, 19883, 18033, 16051, 14051, 12078, 10150, 8321, 6605, 4948, 3308, 1654, -58, -1784, -3417, -4841, -5860, -6272, -5948, -4815, -2856, -134, 3170, 6818, 10359, 13380, 15683, 17138, 17688, 17356, 16243, 14516, 12360, 9956, 7513, 5150, 2942, 949, -826, -2416, -3806, -5003, -6041, -6941, -7721, -8423, -9101, -9775, -10427, -11042, -11609, -12126, -12569, -12885, -13050, -13049, -12952, -12824, -12699, -12610, -12590, -12720, -13044, -13555, -14223, -15013, -15846, -16748, -17676, -18577, -19424, -20257, -21071, -21888, -22796, -23864, -25099, -26446, -27860, -29206, -30267, -30904, -31008, -30471, -29261, -27456, -25156, -22522, -19976, -17874, -16387, -15678, -15826, -16755, -18315, -20355, -22623, -24872, -26956, -28773, -30217, -31292, -32025, -32417, -32472, -32244, -31747, -30993, -30041, -28962, -27822, -26661, -25527, -24392, -23249, -22165, -21109, -20022, -18920, -17802, -16716, -15742, -14935, -14304, -13879, -13745, -13936, -14424, -15163, -16103, -17153, -18249, -19344, -20365, -21257, -22029, -22675, -23208, -23679, -24170, -24682, -25157, -25551, -25719, -25436, -24547, -22911, -20412, -17029, -12866, -8067, -2838, 1373, 6644, 11165, 14837, 17556, 19324, 20209, 20359, 20015, 19407, 18759, 18230, 17874, 17718, 17737, 17784, 17804, 17720, 17429, 16872, 16053, 14970, 13652, 12214, 10797, 9529, 8520, 7879, 7655, 7875, 8581, 9751, 11220, 12824, 14472, 16051, 17458, 18650, 19557, 20156, 20546, 20812, 21007, 21155, 21333, 21549, 21769, 21970, 22090, 22026, 21697, 21000, 19866, 18343, 16546, 14592, 12719, 11222, 10300, 10109, 10771, 12309, 14618, 17517, 20641, 23595, 26118, 28051, 29277, 29752, 29540, 28796, 27709, 26496, 25406, 24583, 24069, 23898, 24024, 24300, 24627, 24945, 25097, 24995, 24641, 23980, 22973, 21740, 20398, 19042, 17780, 16721, 15899, 15335, 15099, 15169, 15370, 15568, 15687, 15608, 15256, 14607, 13607, 12258, 10694, 9025, 7343, 5734, 4299, 3071, 2044, 1191, 465, -223, -993, -1937, -3113, -4496, -5988, -7458, -8667, -9368, -9368, -8517, -6736, -4028, -513, 3617, 7889, 11843, 15215, 17787, 19429, 20104, 19870, 18878, 17348, 15518, 13638, 11868, 10284, 8918, 7719, 6574, 5408, 4149, 2689, 969, -1019, -3257, -5699, -8249, -10741, -13033, -15020, -16612, -17754, -18405, -18553, -18219, -17555, -16720, -15843, -15020, -14327, -13858, -13678, -13773, -14065, -14488, -14932, -15384, -15805, -16154, -16434, -16734, -17101, -17602, -18373, -19523, -21073, -22971, -25143, -27424, -29537, -31261, -32397, -32761, -32253, -30885, -28707, -25850, -22747, -19786, -17206, -15239, -14048, -13628, -13905, -14767, -15953, -17183, -18264, -19046, -19423, -19423, -19129, -18637, -18046, -17504, -17113, -16946, -17064, -17498, -18229, -19176, -20232, -21242, -22095, -22746, -23124, -23169, -22883, -22285, -21503, -20691, -19982, -19449, -19144, -19155, -19517, -20179, -21033, -21991, -22914, -23701, -24306, -24682, -24798, -24717, -24509, -24228, -23987, -23932, -24086, -24404, -24841, -25230, -25302, -24851, -23670, -21577, -18491, -14467, -9587, -3995};