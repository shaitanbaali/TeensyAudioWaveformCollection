/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0022 512 samples */
 
const int16_t AKWF_stereo_0022_512_DATA [512] = 
{1703, 5252, 8595, 10178, 10832, 12876, 15293, 16561, 16696, 17042, 17234, 16420, 14310, 10458, 8872, 9750, 11157, 13663, 16038, 18919, 20244, 20431, 20979, 22668, 24591, 23902, 22816, 22744, 22880, 22207, 22318, 22903, 24092, 24679, 24543, 24160, 24883, 25993, 24628, 23870, 23490, 23402, 22549, 20650, 20562, 21652, 22303, 24107, 25424, 24811, 23059, 20965, 19364, 21523, 24735, 26253, 27607, 28725, 27339, 24271, 20972, 20085, 20879, 21074, 21932, 22622, 22693, 21868, 20764, 19525, 19101, 18476, 16843, 14547, 13287, 14048, 13454, 12213, 12344, 13692, 15495, 17665, 19538, 22266, 23496, 22817, 22233, 23232, 23439, 22119, 21314, 20853, 20208, 18696, 17342, 15865, 15287, 13713, 12303, 10992, 9736, 8765, 7550, 7103, 8079, 9133, 7314, 4456, 5405, 7697, 7648, 6753, 5604, 4198, 2006, 445, -1058, -367, 2066, 2122, 662, -738, -3271, -5806, -7431, -8240, -6894, -4451, -1771, -93, 93, -305, 159, 8, -2013, -4950, -6810, -7870, -9316, -10577, -12503, -14967, -15740, -14444, -13958, -15050, -16024, -16715, -17627, -18291, -19878, -20554, -20069, -21062, -21394, -21057, -20716, -20824, -19477, -17514, -16651, -16108, -15987, -17731, -20281, -22061, -23607, -25717, -27720, -29589, -31521, -32761, -31973, -30330, -30227, -30687, -30019, -28403, -28435, -28763, -27048, -24664, -23051, -21805, -19950, -18468, -19449, -20605, -21483, -21806, -21298, -20923, -20570, -19901, -19523, -20862, -21524, -22073, -23367, -23708, -23937, -24465, -26058, -26597, -26269, -24587, -21884, -19806, -17819, -16029, -14305, -12233, -11027, -10223, -9606, -8501, -6866, -6706, -6409, -5528, -5601, -7196, -5859, -3825, -3205, -2643, -3165, -4938, -5885, -6206, -7574, -8657, -9526, -11085, -13506, -15763, -15312, -14273, -14716, -13748, -10172, -7309, -8006, -9868, -12273, -12701, -10871, -9265, -8431, -7788, -7631, -7457, -5970, -4244, -2398, -880, 7991, 7014, 8445, 9153, 9850, 10298, 10033, 10098, 10952, 10676, 9638, 10251, 14963, 20388, 22294, 20529, 18089, 15182, 14630, 11214, 7967, 5791, 1797, -1271, -1983, -3419, -6937, -10916, -11002, -5246, 301, 2997, 6043, 5691, 3698, 1549, -489, -193, 1521, 1654, 3640, 6225, 5455, 5691, 5987, 1799, -1891, -813, 916, 3587, 6129, 6929, 8051, 6237, 810, -840, 842, 4975, 9619, 14747, 16266, 17223, 18705, 18944, 20114, 19008, 16569, 13913, 13267, 13749, 13399, 13146, 12951, 12519, 12396, 12736, 15032, 17781, 18468, 15587, 12641, 11062, 10693, 6863, 2952, 870, -1875, -3032, -4426, -7195, -10570, -13625, -14546, -8830, -2534, 272, 2748, 3484, 2731, 2209, 3273, 5695, 10099, 13038, 14548, 14081, 11066, 9925, 8416, 4363, 1918, 1646, 2308, 1101, -442, -1436, -1667, -3864, -6633, -6415, -4068, 743, 5407, 8587, 8663, 9556, 9223, 7240, 5609, 4266, 4023, 1096, -2452, -7078, -10583, -9663, -7019, -5597, -6139, -6950, -4269, -544, 1098, 802, 1096, 861, 1387, -422, -2111, -4265, -7550, -9972, -11625, -13238, -14609, -15477, -15631, -12117, -6883, -3120, -604, -578, -1057, 1338, 4900, 8277, 10913, 11324, 11875, 12529, 12339, 11390, 10448, 6106, 856, -1197, -3427, -4624, -4174, -3967, -2004, -1975, -5147, -5764, -4265, -4777, -6321, -5487, -5317, -3870, -3767, -4761, -4695, -5223, -5039, -8084, -13145, -15627, -15828, -13627, -10865, -9826, -10104, -10934, -8416, -4831, -4463, -6128, -6372, -7289, -8079, -11250, -15902, -21273, -26546, -28768, -29383, -29825, -30323, -32183, -32539, -26317, -18923, -16701, -14537, -13707, -14922, -13684, -11910, -11806, -10038, -9063, -5685, -2666, -2112, -1175, -1438, -5536, -10249, -10667, -9496, -6854, -4506, -4816, -5017, -6088, -8979, -6823, -805, 3570, 5601, 7750, 7521, 8764, 9925, 9153};