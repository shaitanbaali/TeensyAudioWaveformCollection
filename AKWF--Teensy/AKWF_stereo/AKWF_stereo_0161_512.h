/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0161 512 samples */
 
const int16_t AKWF_stereo_0161_512_DATA [512] = 
{226, 926, 1595, 2251, 2892, 3517, 4127, 4719, 5294, 5853, 6394, 6918, 7425, 7915, 8388, 8845, 9283, 9707, 10115, 10506, 10882, 11243, 11588, 11919, 12236, 12539, 12828, 13105, 13367, 13619, 13857, 14084, 14300, 14504, 14699, 14882, 15055, 15220, 15376, 15522, 15659, 15788, 15910, 16023, 16130, 16228, 16321, 16407, 16486, 16561, 16629, 16692, 16745, 16830, 17019, 17200, 17419, 17694, 18011, 18366, 18760, 19194, 19665, 20171, 20710, 21274, 21864, 22474, 23100, 23741, 24393, 25051, 25713, 26376, 27037, 27693, 28342, 28985, 29589, 30041, 30493, 30886, 31196, 31441, 31624, 31743, 31799, 31792, 31724, 31600, 31425, 31146, 30715, 30231, 29661, 28985, 28222, 27381, 26463, 25467, 24410, 23418, 22389, 21325, 20287, 19256, 18237, 17229, 16240, 15277, 14337, 13423, 12538, 11677, 10844, 10040, 9262, 8512, 7792, 7098, 6433, 5794, 5183, 4597, 4045, 3481, 2809, 2187, 1539, 855, 151, -570, -1305, -2059, -2829, -3609, -4400, -5196, -5993, -6790, -7585, -8372, -9152, -9922, -10678, -11420, -12146, -12854, -13544, -14212, -14860, -15486, -16089, -16667, -17224, -17755, -18262, -18746, -19204, -19637, -20048, -20434, -20796, -21136, -21451, -21744, -22015, -22265, -22493, -22702, -22889, -23058, -23208, -23340, -23454, -23550, -23632, -23696, -23746, -23782, -23804, -23813, -23808, -23791, -23765, -23727, -23677, -23619, -23551, -23474, -23389, -23296, -23196, -23090, -22977, -22857, -22732, -22603, -22468, -22330, -22187, -22040, -21891, -21738, -21583, -21426, -21266, -21105, -20942, -20777, -20612, -20447, -20279, -20112, -19945, -19777, -19610, -19443, -19276, -19110, -18945, -18781, -18617, -18454, -18292, -18133, -17972, -17823, -17611, -17284, -16990, -16635, -16222, -15768, -15278, -14749, -14182, -13581, -12947, -12284, -11600, -10893, -10170, -9434, -8685, -7930, -7171, -6407, -5644, -4884, -4127, -3375, -2634, -1899, -1178, -454, 450, 1558, 2623, 3666, 4684, 5677, 6647, 7587, 8502, 9389, 10247, 11080, 11886, 12662, 13411, 14135, 14830, 15500, 16144, 16760, 17354, 17922, 18465, 18986, 19484, 19958, 20412, 20844, 21254, 21646, 22018, 22371, 22705, 23023, 23323, 23606, 23873, 24125, 24363, 24586, 24796, 24992, 25176, 25348, 25509, 25658, 25796, 25925, 26043, 26152, 26252, 26345, 26426, 26517, 26653, 26780, 26921, 27084, 27264, 27457, 27666, 27890, 28129, 28380, 28645, 28919, 29202, 29493, 29789, 30091, 30395, 30700, 31006, 31310, 31613, 31910, 32201, 32496, 32735, 32726, 32741, 32672, 32480, 32202, 31843, 31402, 30882, 30281, 29609, 28870, 28072, 27196, 26222, 25200, 24121, 22978, 21783, 20545, 19267, 17948, 16609, 15467, 14341, 13223, 12216, 11282, 10419, 9625, 8906, 8266, 7698, 7199, 6768, 6397, 6085, 5829, 5621, 5461, 5346, 5271, 5231, 5226, 5251, 5302, 5391, 5437, 5270, 5165, 4989, 4719, 4388, 3998, 3550, 3041, 2473, 1853, 1185, 475, -269, -1045, -1849, -2671, -3513, -4367, -5228, -6094, -6964, -7828, -8690, -9545, -10387, -11219, -12038, -12839, -13626, -14392, -15139, -15868, -16573, -17256, -17918, -18556, -19173, -19766, -20334, -20880, -21403, -21903, -22380, -22835, -23267, -23678, -24067, -24434, -24782, -25110, -25417, -25706, -25977, -26228, -26463, -26682, -26883, -27069, -27240, -27396, -27540, -27668, -27784, -27887, -27978, -28059, -28127, -28186, -28235, -28274, -28304, -28327, -28340, -28346, -28344, -28336, -28322, -28301, -28274, -28243, -28206, -28164, -28118, -28067, -28012, -27955, -27894, -27830, -27762, -27693, -27621, -27546, -27471, -27393, -27314, -27232, -27150, -27067, -26984, -26899, -26810, -26738, -26552, -26168, -25835, -25392, -24847, -24230, -23546, -22790, -21966, -21080, -20132, -19134, -18094, -17012, -15899, -14762, -13599, -12421, -11235, -10037, -8837, -7641, -6447, -5260, -4085, -2923, -1779, -631};