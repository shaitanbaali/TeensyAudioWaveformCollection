/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0170 512 samples */
 
const int16_t AKWF_stereo_0170_512_DATA [512] = 
{108, 402, 816, 1330, 2101, 4194, 7034, 9805, 12601, 15465, 18477, 21174, 22697, 23787, 24804, 25701, 26480, 27189, 27832, 28392, 28886, 29349, 29746, 30096, 30432, 30731, 30980, 31225, 31452, 31631, 31790, 31947, 32075, 32165, 32270, 32371, 32439, 32518, 32609, 32692, 32759, 32769, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32766, 32773, 32641, 32363, 32078, 31724, 31317, 30881, 29268, 26514, 23606, 20559, 17235, 13439, 9608, 7281, 5737, 4302, 3036, 1897, 875, -32, -848, -1589, -2261, -2895, -3517, -4157, -4797, -5452, -6145, -6857, -7559, -8184, -8642, -8953, -9139, -9200, -9205, -9197, -9229, -9376, -9559, -9692, -9796, -9866, -9862, -9754, -9576, -9418, -9303, -9212, -9136, -9048, -8950, -8845, -8709, -8563, -8144, -7213, -6247, -5328, -4389, -3384, -2294, -1600, -1350, -1134, -999, -981, -1067, -1254, -1546, -1962, -2478, -3253, -5354, -8199, -10964, -13747, -16588, -19557, -22203, -23700, -24768, -25758, -26637, -27407, -28090, -28721, -29270, -29756, -30208, -30609, -30949, -31274, -31575, -31828, -32059, -32285, -32475, -32628, -32758, -32769, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32764, -32781, -32615, -32212, -31769, -30175, -27462, -24562, -21543, -18285, -14549, -10743, -8434, -6907, -5467, -4202, -3068, -2045, -1133, -317, 424, 1099, 1726, 2350, 2993, 3637, 4295, 4993, 5707, 6414, 7045, 7503, 7815, 8001, 8061, 8061, 8051, 8083, 8226, 8407, 8543, 8646, 8712, 8706, 8595, 8415, 8255, 8139, 8046, 7969, 7884, 7783, 7676, 7540, 7397, 6974, 6044, 5083, 4164, 3228, 2231, 1149, 458, 210, -2, -137, -155, -62, 22881, 22824, 22697, 22460, 22194, 22001, 21740, 21376, 20946, 20512, 20155, 19792, 19333, 18915, 18562, 18204, 17828, 17477, 17152, 16824, 16504, 16252, 16086, 16045, 16107, 16206, 16310, 16448, 16533, 16353, 15865, 15184, 14374, 13460, 12486, 11546, 10770, 10207, 9848, 9669, 9608, 9629, 9712, 9822, 9897, 9875, 9774, 9650, 9535, 9433, 9410, 9550, 9883, 11400, 13999, 16635, 19282, 21971, 24826, 27578, 29094, 29878, 30457, 30791, 30905, 29558, 26858, 23928, 20804, 17393, 13604, 9900, 7786, 6525, 5415, 4509, 3716, 2967, 2278, 1653, 1084, 610, 286, 87, -50, -161, -267, -378, -551, -886, -1321, -2307, -4436, -6833, -9209, -11655, -14238, -16975, -19105, -20357, -21422, -22365, -23209, -23946, -24563, -25099, -25567, -25967, -26340, -26698, -26931, -27049, -27118, -27130, -27062, -26883, -26568, -26237, -25946, -25678, -25392, -25086, -24876, -24747, -24611, -24511, -24443, -24368, -24293, -24237, -24124, -23881, -23610, -23427, -23173, -22798, -22367, -21941, -21566, -21192, -20735, -20314, -19946, -19584, -19214, -18848, -18519, -18187, -17864, -17606, -17446, -17398, -17453, -17555, -17664, -17791, -17876, -17702, -17203, -16518, -15703, -14784, -13799, -12854, -12079, -11503, -11134, -10947, -10874, -10889, -10971, -11083, -11152, -11129, -11028, -10904, -10788, -10686, -10662, -10799, -11127, -12628, -15208, -17851, -20509, -23196, -26046, -28813, -30359, -31177, -31780, -32121, -32221, -30882, -28208, -25276, -22151, -18747, -14973, -11292, -9200, -7958, -6848, -5945, -5162, -4417, -3727, -3105, -2542, -2066, -1748, -1550, -1408, -1295, -1188, -1075, -898, -564, -130, 850, 2967, 5354, 7725, 10170, 12757, 15511, 17651, 18912, 19993, 20943, 21791, 22535, 23158, 23698, 24170, 24573, 24950, 25308, 25553, 25664, 25727, 25745, 25680, 25485, 25168, 24847, 24543, 24270, 23994, 23687, 23467, 23340, 23214, 23101, 23031, 22970};