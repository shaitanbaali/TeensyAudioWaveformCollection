/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0006 512 samples */
 
const int16_t AKWF_stereo_0006_512_DATA [512] = 
{392, 965, 1525, 2089, 2644, 3199, 3751, 4295, 4840, 5380, 5917, 6457, 6961, 7481, 8000, 8514, 9020, 9524, 10024, 10518, 11009, 11494, 11971, 12451, 12907, 13314, 13767, 14194, 14607, 15013, 15412, 15801, 16188, 16570, 16946, 17312, 17690, 18003, 18290, 18647, 18983, 19314, 19641, 19964, 20280, 20585, 20909, 21191, 21457, 21763, 21958, 22179, 22455, 22714, 22971, 23221, 23464, 23705, 23940, 24168, 24391, 24611, 24833, 24929, 25106, 25313, 25507, 25699, 25889, 26073, 26256, 26435, 26608, 26781, 26952, 27104, 27145, 27299, 27460, 27617, 27770, 27924, 28076, 28224, 28370, 28514, 28655, 28814, 28849, 28933, 29087, 29224, 29362, 29501, 29639, 29777, 29912, 30056, 30199, 30327, 30472, 30484, 30597, 30744, 30885, 31027, 31167, 31311, 31454, 31598, 31746, 31890, 32044, 32178, 32200, 32346, 32134, 34093, 24644, 10746, 8322, 5810, 3735, 4022, 3228, 3987, 3624, 3770, 3705, 3367, 3258, 2615, 2217, 1458, 719, -116, -1099, -2049, -3189, -4302, -5484, -6682, -7886, -9120, -10323, -11540, -12726, -13893, -15055, -16169, -17134, -18207, -19153, -20060, -20966, -21821, -22636, -23411, -24145, -24837, -25491, -26104, -26678, -27213, -27720, -28063, -28458, -28852, -29209, -29532, -29824, -30088, -30319, -30523, -30700, -30850, -30983, -31069, -30994, -31043, -31076, -31087, -31077, -31045, -30996, -30931, -30844, -30745, -30624, -30502, -30292, -29983, -29813, -29613, -29403, -29178, -28942, -28692, -28427, -28153, -27864, -27599, -27310, -26886, -26448, -26121, -25763, -25398, -25022, -24637, -24241, -23840, -23427, -23003, -22572, -22142, -21576, -21067, -20618, -20148, -19671, -19185, -18698, -18205, -17701, -17195, -16681, -16160, -15632, -15002, -14451, -13920, -13381, -12836, -12289, -11742, -11190, -10636, -10077, -9519, -8962, -8349, -7746, -7188, -6602, -6011, -5417, -4824, -4235, -3645, -3059, -2444, -1931, -1369, -766, -181, 6537, 7126, 7699, 8271, 8828, 9384, 9931, 10466, 11001, 11525, 12040, 12556, 13032, 13520, 14003, 14476, 14939, 15397, 15846, 16285, 16719, 17142, 17555, 17968, 18353, 18687, 19062, 19412, 19749, 20082, 20402, 20707, 21010, 21301, 21583, 21853, 22134, 22344, 22527, 22778, 23005, 23226, 23442, 23650, 23847, 24037, 24238, 24394, 24538, 24720, 24788, 24882, 25030, 25161, 25289, 25407, 25518, 25627, 25727, 25821, 25908, 25992, 26076, 26028, 26066, 26135, 26188, 26239, 26289, 26331, 26371, 26406, 26436, 26465, 26492, 26497, 26385, 26393, 26408, 26418, 26426, 26433, 26436, 26439, 26439, 26437, 26433, 26446, 26323, 26256, 26265, 26257, 26251, 26244, 26240, 26234, 26228, 26228, 26221, 26209, 26213, 26070, 26041, 26054, 26059, 26064, 26072, 26087, 26098, 26115, 26136, 26154, 26187, 26193, 26074, 26102, 25704, 28036, 16086, 5153, 8447, 4791, 972, 690, -1429, -992, -2302, -2688, -3338, -4285, -4743, -5866, -6485, -7522, -8412, -9343, -10399, -11324, -12415, -13364, -14375, -15363, -16332, -17323, -18255, -19204, -20107, -20992, -21870, -22697, -23386, -24181, -24855, -25523, -26214, -26857, -27466, -28041, -28581, -29086, -29557, -29992, -30396, -30765, -31112, -31298, -31541, -31790, -32007, -32192, -32351, -32485, -32589, -32669, -32726, -32756, -32772, -32740, -32546, -32484, -32406, -32307, -32186, -32044, -31887, -31713, -31516, -31308, -31078, -30845, -30520, -30095, -29813, -29501, -29179, -28840, -28490, -28124, -27743, -27353, -26938, -26556, -26148, -25596, -25031, -24584, -24104, -23616, -23118, -22609, -22090, -21567, -21028, -20481, -19927, -19373, -18677, -18043, -17472, -16881, -16283, -15680, -15077, -14464, -13844, -13225, -12599, -11969, -11331, -10587, -9931, -9298, -8659, -8017, -7375, -6737, -6094, -5453, -4811, -4173, -3538, -2847, -2173, -1547, -897, -253, 389, 1026, 1660, 2295, 2919, 3571, 4118, 4709, 5341, 5950};