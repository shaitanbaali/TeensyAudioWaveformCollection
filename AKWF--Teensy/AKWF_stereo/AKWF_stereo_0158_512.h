/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0158 512 samples */
 
const int16_t AKWF_stereo_0158_512_DATA [512] = 
{3835, 26824, 33272, 31680, 31582, 31217, 30859, 30514, 30159, 29815, 29475, 29131, 28801, 28466, 28135, 27812, 27313, 27744, 23047, -328, -7114, -5800, -5982, -5914, -5843, -5779, -5713, -5646, -5583, -5517, -5454, -5392, -5329, -5265, -5205, -5142, -5082, -5021, -4960, -4901, -4842, -4783, -4724, -4666, -4608, -4549, -4494, -4438, -4379, -4323, -4267, -4211, -4156, -4100, -4047, -3992, -3937, -3885, -3831, -3777, -3724, -3671, -3619, -3568, -3516, -3464, -3412, -3363, -3311, -3261, -3210, -3161, -3111, -3061, -3013, -2965, -2916, -2868, -2820, -2772, -2723, -2677, -2628, -2582, -2534, -2488, -2442, -2396, -2349, -2304, -2258, -2212, -2167, -2122, -2077, -2033, -1988, -1943, -1899, -1856, -1812, -1769, -1725, -1682, -1638, -1595, -1552, -1509, -1467, -1425, -1382, -1339, -1299, -1255, -1213, -1171, -1131, -1090, -1048, -1006, -965, -923, -883, -842, -800, -760, -719, -678, -637, -596, -555, -515, -474, -435, -395, -355, -314, -275, -235, -195, -155, -116, -76, -36, 3, 43, 82, 121, 160, 200, 239, 279, 318, 358, 397, 437, 476, 516, 555, 594, 635, 674, 714, 754, 793, 833, 872, 913, 952, 991, 1032, 1071, 1111, 1150, 1191, 1232, 1271, 1312, 1352, 1392, 1432, 1472, 1513, 1554, 1595, 1636, 1677, 1718, 1759, 1799, 1841, 1883, 1924, 1965, 2007, 2050, 2091, 2132, 2175, 2217, 2260, 2303, 2346, 2387, 2430, 2473, 2517, 2560, 2603, 2647, 2691, 2735, 2779, 2823, 2868, 2913, 2957, 3003, 3048, 3093, 3139, 3185, 3232, 3278, 3276, 3481, 3010, -5786, -10321, -9931, -10134, -10248, -10362, -10476, -10588, -10707, -10823, -10942, -11063, -11184, -11306, -11429, -11554, -11682, -11808, -11938, -12069, -12198, -12334, -12466, -12600, -12743, -12829, -13123, -12757, -4180, 2414, 15831, 19606, 18684, 18639, 18437, 18235, 18043, 17846, 17655, 17466, 17274, 17091, 16906, 16721, 16543, 16262, 16523, 13795, 181, -3764, -2989, -3084, -3034, -2982, -2935, -2886, -2837, -2788, -2739, -2692, -2644, -2596, -2547, -2501, -2453, -2406, -2359, -2310, -2264, -2218, -2171, -2124, -2078, -2032, -1984, -1939, -1892, -1844, -1800, -1753, -1708, -1661, -1616, -1570, -1524, -1478, -1432, -1387, -1341, -1294, -1248, -1203, -1158, -1112, -1066, -1021, -975, -929, -884, -838, -793, -747, -700, -655, -610, -564, -519, -473, -427, -381, -336, -289, -243, -198, -151, -105, -59, -14, 32, 79, 125, 172, 219, 265, 313, 359, 406, 453, 500, 547, 594, 641, 689, 738, 786, 834, 881, 928, 978, 1027, 1076, 1123, 1173, 1223, 1272, 1321, 1369, 1420, 1470, 1520, 1570, 1621, 1672, 1722, 1773, 1825, 1878, 1929, 1982, 2035, 2086, 2139, 2191, 2245, 2298, 2351, 2405, 2459, 2513, 2568, 2622, 2676, 2732, 2788, 2844, 2900, 2954, 3011, 3069, 3126, 3182, 3241, 3299, 3356, 3417, 3474, 3534, 3594, 3654, 3714, 3775, 3836, 3897, 3958, 4021, 4082, 4147, 4209, 4272, 4336, 4400, 4465, 4529, 4595, 4661, 4726, 4794, 4860, 4927, 4995, 5063, 5131, 5201, 5271, 5340, 5410, 5482, 5553, 5625, 5697, 5770, 5843, 5917, 5991, 6066, 6141, 6216, 6292, 6369, 6446, 6524, 6602, 6680, 6759, 6839, 6920, 6999, 7080, 7163, 7245, 7328, 7411, 7494, 7581, 7666, 7752, 7840, 7925, 8016, 8104, 8192, 8286, 8375, 8353, 8815, 7697, -12838, -23432, -22538, -23032, -23310, -23590, -23873, -24152, -24442, -24731, -25021, -25318, -25614, -25914, -26219, -26523, -26836, -27145, -27460, -27781, -28097, -28426, -28752, -29079, -29423, -29641, -30336, -29500, -9505};