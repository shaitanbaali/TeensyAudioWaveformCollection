/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0116 512 samples */
 
const int16_t AKWF_stereo_0116_512_DATA [512] = 
{850, 2485, 4071, 5635, 7173, 8680, 10155, 11589, 12983, 14334, 15633, 16884, 18085, 19226, 20313, 21340, 22299, 23196, 24025, 24785, 25476, 26097, 26643, 27116, 27516, 27839, 28087, 28256, 28347, 28362, 28301, 28167, 27956, 27675, 27326, 26907, 26424, 25878, 25269, 24605, 23884, 23107, 22281, 21407, 20491, 19535, 18541, 17516, 16465, 15385, 14286, 13170, 12037, 10894, 9747, 8593, 7442, 6296, 5159, 4040, 2942, 1867, 826, -180, -1150, -2077, -2961, -3801, -4591, -5334, -6026, -6662, -7243, -7768, -8235, -8645, -8999, -9296, -9539, -9731, -9871, -9967, -10020, -10030, -10002, -9938, -9838, -9705, -9539, -9344, -9118, -8869, -8594, -8294, -7975, -7636, -7276, -6899, -6503, -6088, -5654, -5201, -4728, -4237, -3725, -3192, -2642, -2070, -1479, -870, -240, 409, 1078, 1768, 2481, 3212, 3966, 4741, 5533, 6345, 7171, 8008, 8861, 9722, 10587, 11460, 12333, 13206, 14077, 14937, 15785, 16617, 17426, 18205, 18951, 19653, 20307, 20913, 21465, 21959, 22393, 22763, 23065, 23300, 23462, 23550, 23563, 23499, 23356, 23135, 22836, 22458, 22003, 21475, 20871, 20201, 19463, 18658, 17797, 16881, 15910, 14895, 13837, 12739, 11611, 10454, 9275, 8083, 6880, 5667, 4456, 3247, 2042, 850, -331, -1501, -2651, -3783, -4895, -5980, -7043, -8080, -9087, -10072, -11029, -11957, -12861, -13739, -14590, -15418, -16222, -17000, -17757, -18492, -19205, -19895, -20565, -21216, -21847, -22460, -23059, -23641, -24208, -24764, -25308, -25837, -26357, -26867, -27363, -27850, -28327, -28793, -29249, -29693, -30121, -30537, -30936, -31314, -31663, -31972, -32239, -32458, -32621, -32726, -32768, -32745, -32652, -32489, -32252, -31939, -31548, -31079, -30532, -29903, -29197, -28411, -27543, -26599, -25577, -24483, -23321, -22090, -20799, -19455, -18058, -16615, -15135, -13614, -12063, -10489, -8888, -7276, -5650, -4019, -2388, -729, -4880, -3346, -1841, -338, 1156, 2639, 4110, 5559, 6989, 8396, 9772, 11118, 12434, 13710, 14950, 16151, 17302, 18410, 19468, 20469, 21418, 22307, 23132, 23896, 24594, 25224, 25785, 26274, 26689, 27030, 27294, 27484, 27599, 27636, 27599, 27487, 27302, 27047, 26720, 26325, 25863, 25334, 24743, 24089, 23376, 22608, 21785, 20913, 19996, 19036, 18039, 17010, 15948, 14861, 13757, 12632, 11496, 10353, 9203, 8057, 6915, 5782, 4665, 3568, 2497, 1459, 456, -507, -1425, -2299, -3126, -3898, -4620, -5290, -5902, -6461, -6965, -7409, -7798, -8133, -8411, -8639, -8817, -8946, -9030, -9074, -9078, -9046, -8981, -8888, -8766, -8622, -8453, -8263, -8055, -7826, -7580, -7316, -7036, -6739, -6427, -6101, -5759, -5400, -5026, -4636, -4226, -3798, -3351, -2885, -2395, -1883, -1348, -790, -204, 405, 1042, 1707, 2397, 3114, 3855, 4617, 5404, 6210, 7033, 7879, 8737, 9608, 10491, 11380, 12270, 13164, 14051, 14927, 15786, 16616, 17418, 18186, 18910, 19590, 20222, 20800, 21321, 21782, 22182, 22515, 22779, 22974, 23095, 23141, 23112, 23003, 22818, 22554, 22211, 21793, 21300, 20733, 20099, 19401, 18639, 17820, 16948, 16026, 15061, 14056, 13015, 11948, 10853, 9734, 8602, 7456, 6302, 5146, 3988, 2834, 1690, 551, -573, -1681, -2777, -3855, -4912, -5954, -6974, -7972, -8951, -9909, -10846, -11764, -12660, -13537, -14393, -15228, -16044, -16840, -17615, -18373, -19113, -19832, -20534, -21221, -21890, -22544, -23185, -23811, -24422, -25021, -25605, -26176, -26734, -27279, -27809, -28325, -28824, -29306, -29770, -30215, -30634, -31018, -31366, -31672, -31934, -32145, -32306, -32410, -32456, -32443, -32365, -32223, -32011, -31729, -31374, -30948, -30450, -29879, -29235, -28521, -27735, -26879, -25958, -24969, -23918, -22811, -21645, -20429, -19167, -17857, -16512, -15135, -13723, -12291, -10835, -9360, -7876, -6349};