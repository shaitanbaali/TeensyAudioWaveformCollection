/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0103 512 samples */
 
const int16_t AKWF_stereo_0103_512_DATA [512] = 
{563, 1715, 2694, 3533, 4395, 5387, 6427, 7300, 7855, 8148, 8238, 8179, 8025, 7773, 7416, 6982, 6527, 6153, 5875, 5678, 5517, 5380, 5343, 5411, 5621, 5943, 6367, 6831, 7148, 7332, 7504, 7764, 8018, 8169, 8237, 8268, 8313, 8406, 8566, 8756, 8953, 9160, 9386, 9647, 9886, 10070, 10186, 10279, 10444, 10658, 10902, 11098, 11216, 11334, 11460, 11628, 11752, 11897, 12181, 12591, 13254, 14167, 15252, 16341, 17404, 18506, 19574, 20577, 21501, 22329, 23030, 23611, 24115, 24606, 25117, 25588, 25977, 26261, 26466, 26659, 26858, 27051, 27163, 27151, 27038, 26838, 26638, 26339, 25796, 24964, 23982, 23062, 22198, 21398, 20681, 20037, 19461, 18969, 18573, 18265, 17984, 17650, 17224, 16735, 16267, 15876, 15558, 15224, 14816, 14322, 13758, 13189, 12691, 12308, 11950, 11519, 11086, 10807, 10625, 10319, 9636, 8578, 7364, 6093, 4811, 3532, 2247, 966, -273, -1384, -2316, -3091, -3755, -4376, -4931, -5367, -5665, -5798, -5806, -5726, -5706, -5840, -6004, -6001, -5812, -5592, -5412, -5211, -4862, -4330, -3689, -3031, -2443, -1954, -1562, -1247, -1016, -918, -963, -1151, -1396, -1657, -1960, -2320, -2784, -3295, -3804, -4280, -4720, -5151, -5460, -5692, -5868, -5937, -5891, -5793, -5762, -5772, -5852, -6078, -6430, -6877, -7418, -8068, -8799, -9582, -10374, -11189, -12084, -13069, -14139, -15230, -16315, -17392, -18494, -19690, -20906, -22108, -23261, -24407, -25678, -27035, -28408, -29626, -30627, -31467, -32122, -32546, -32745, -32745, -32560, -32218, -31757, -31246, -30735, -30210, -29624, -28910, -28090, -27249, -26458, -25736, -25030, -24277, -23441, -22541, -21676, -20933, -20385, -19917, -19424, -19054, -18976, -19245, -19626, -19931, -20105, -20131, -20027, -19802, -19434, -18883, -18101, -17107, -15969, -14768, -13546, -12251, -10842, -9295, -7663, -6046, -4491, -3061, -1767, -562, 2146, 3240, 4214, 5093, 6101, 7341, 8699, 9872, 10650, 11164, 11498, 11698, 11811, 11822, 11714, 11503, 11244, 11033, 10889, 10785, 10659, 10481, 10333, 10214, 10178, 10219, 10324, 10400, 10199, 9750, 9249, 8879, 8545, 8135, 7641, 7192, 6902, 6783, 6832, 6996, 7239, 7556, 7957, 8459, 9005, 9555, 10078, 10599, 11185, 11798, 12410, 12948, 13366, 13733, 14028, 14257, 14322, 14292, 14321, 14405, 14656, 15071, 15635, 16239, 16917, 17705, 18475, 19210, 19915, 20595, 21226, 21820, 22414, 23062, 23791, 24539, 25266, 25948, 26603, 27273, 27955, 28612, 29154, 29550, 29841, 30042, 30189, 30145, 29759, 29010, 28044, 27052, 25964, 24799, 23641, 22518, 21452, 20474, 19605, 18842, 18142, 17431, 16691, 15964, 15343, 14897, 14606, 14381, 14144, 13891, 13645, 13464, 13407, 13478, 13584, 13611, 13605, 13707, 13832, 13717, 13094, 11960, 10587, 9090, 7500, 5822, 4052, 2211, 355, -1407, -3007, -4450, -5774, -7039, -8216, -9237, -10052, -10630, -10989, -11187, -11370, -11630, -11856, -11843, -11597, -11286, -11004, -10672, -10143, -9370, -8481, -7615, -6881, -6308, -5889, -5593, -5424, -5424, -5603, -5954, -6387, -6845, -7337, -7873, -8481, -9088, -9652, -10119, -10474, -10709, -10759, -10740, -10708, -10598, -10326, -9932, -9546, -9188, -8881, -8710, -8657, -8683, -8794, -9023, -9362, -9798, -10294, -10864, -11558, -12383, -13330, -14316, -15325, -16351, -17422, -18613, -19815, -20995, -22122, -23298, -24642, -26037, -27413, -28639, -29670, -30551, -31260, -31720, -31932, -31934, -31757, -31439, -31023, -30575, -30148, -29727, -29271, -28717, -28087, -27460, -26887, -26396, -25921, -25391, -24788, -24132, -23516, -22925, -22383, -21788, -21116, -20550, -20248, -20223, -20243, -20180, -19985, -19652, -19193, -18616, -17900, -17007, -15905, -14626, -13254, -11884, -10564, -9243, -7863, -6385, -4871, -3414, -2070, -894, 141, 1131};