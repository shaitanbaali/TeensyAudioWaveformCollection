/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0044 512 samples */
 
const int16_t AKWF_stereo_0044_512_DATA [512] = 
{8457, 22002, 23061, 23204, 23587, 23902, 24212, 24514, 24815, 25108, 25398, 25685, 25963, 26240, 26510, 26775, 27040, 27296, 27551, 27800, 27968, 28581, 26220, 18608, 17731, 18363, 18647, 18989, 19330, 19663, 19992, 20316, 20636, 20951, 21260, 21565, 21867, 22162, 22455, 22741, 23024, 23304, 23578, 23848, 24115, 24376, 24633, 24889, 25137, 25384, 25625, 25863, 26099, 26330, 26556, 26779, 26999, 27215, 27429, 27638, 27843, 28046, 28245, 28441, 28632, 28822, 29008, 29192, 29370, 29547, 29720, 29891, 30059, 30222, 30384, 30542, 30698, 30851, 31001, 31147, 31291, 31434, 31573, 31710, 31843, 31975, 32105, 32218, 32391, 32190, 31244, 30310, 29390, 28476, 27576, 26685, 25804, 24935, 24075, 23227, 22389, 21560, 20741, 19933, 19135, 18345, 17567, 16791, 16031, 15314, 12235, 9544, 9037, 8344, 7687, 7037, 6396, 5766, 5143, 4529, 3920, 3308, 2731, 2121, -3272, -7445, -7553, -8071, -8524, -8967, -9405, -9835, -10258, -10675, -11088, -11492, -11890, -12284, -12669, -13050, -13425, -13793, -14156, -14515, -14864, -15210, -15552, -15885, -16215, -16538, -16855, -17169, -17478, -17779, -18078, -18370, -18657, -18940, -19215, -19488, -19756, -20019, -20277, -20530, -20778, -21022, -21262, -21497, -21727, -21954, -22174, -22390, -22605, -22812, -23017, -23218, -23414, -23605, -23793, -23976, -24156, -24333, -24505, -24673, -24836, -24997, -25155, -25307, -25456, -25602, -25745, -25883, -26017, -26150, -26277, -26401, -26523, -26642, -26756, -26867, -26974, -27079, -27180, -27278, -27375, -27466, -27555, -27640, -27722, -27803, -27880, -27954, -28026, -28094, -28158, -28209, -28320, -27962, -26925, -25931, -24943, -23964, -22997, -22039, -21091, -20154, -19225, -18307, -17396, -16499, -15725, -14351, -15685, -29058, -33081, -31816, -31360, -30779, -30209, -29653, -29103, -28567, -28042, -27527, -27026, -26529, -26048, -25578, -25111, -24666, -24223, -23792, -23264, -23313, -20796, -5931, 8663, 30267, 32847, 32212, 32308, 32254, 32201, 32143, 32092, 32033, 31977, 31924, 31862, 31807, 31747, 31686, 31630, 31567, 31507, 31447, 31204, 32020, 25814, 7202, 4526, 5426, 5506, 5741, 5976, 6201, 6427, 6650, 6866, 7083, 7295, 7504, 7712, 7914, 8115, 8313, 8507, 8701, 8891, 9077, 9261, 9442, 9622, 9799, 9972, 10145, 10313, 10480, 10645, 10807, 10965, 11124, 11278, 11432, 11582, 11730, 11876, 12020, 12162, 12301, 12438, 12575, 12708, 12839, 12968, 13095, 13220, 13343, 13465, 13584, 13701, 13817, 13931, 14042, 14152, 14260, 14367, 14471, 14574, 14675, 14775, 14874, 14969, 15057, 15177, 15091, 14595, 14106, 13623, 13145, 12672, 12204, 11743, 11288, 10838, 10393, 9953, 9519, 9090, 8667, 8248, 7835, 7427, 7016, 6616, 6263, 2990, 190, 77, -270, -582, -889, -1191, -1489, -1782, -2072, -2357, -2642, -2917, -3195, -4310, -5209, -5393, -5644, -5884, -6118, -6349, -6576, -6801, -7023, -7241, -7455, -7666, -7874, -8079, -8281, -8480, -8676, -8868, -9057, -9244, -9427, -9608, -9786, -9961, -10133, -10303, -10468, -10634, -10794, -10952, -11107, -11260, -11411, -11558, -11702, -11845, -11985, -12122, -12257, -12391, -12520, -12649, -12774, -12897, -13018, -13137, -13253, -13367, -13479, -13588, -13695, -13801, -13903, -14005, -14103, -14201, -14296, -14388, -14480, -14568, -14655, -14740, -14823, -14905, -14982, -15061, -15136, -15209, -15281, -15351, -15420, -15486, -15551, -15614, -15675, -15735, -15793, -15850, -15904, -15958, -16010, -16059, -16108, -16156, -16201, -16244, -16287, -16328, -16367, -16405, -16435, -16498, -16304, -15735, -15191, -14651, -14116, -13586, -13063, -12545, -12033, -11525, -11023, -10527, -10038, -9593, -8938, -9252, -13875, -15157, -14547, -14229, -13868, -13512, -13164, -12819, -12482, -12150, -11822, -11503, -11186, -10877, -10572, -10270, -9980, -9689, -9404, -9090, -8976, -7955, -2488};