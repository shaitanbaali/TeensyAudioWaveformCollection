/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0069 512 samples */
 
const int16_t AKWF_stereo_0069_512_DATA [512] = 
{28202, 23855, 16885, 12989, 10585, 9296, 8618, 8258, 7868, 7465, 7075, 6763, 6587, 6584, 6757, 7083, 7529, 8058, 8641, 9254, 9885, 10524, 11162, 11797, 12415, 13009, 13570, 14086, 14548, 14951, 15285, 15548, 15738, 15854, 15894, 15861, 15757, 15584, 15346, 15048, 14694, 14291, 13848, 13367, 12858, 12329, 11785, 11233, 10684, 10139, 9607, 9094, 8605, 8143, 7714, 7319, 6962, 6646, 6367, 6132, 5937, 5815, 5519, 6180, 10724, 9197, 7539, 6629, 6039, 5693, 5514, 5455, 5458, 5508, 5587, 5678, 5773, 5863, 5942, 6008, 6054, 6080, 6085, 6066, 6023, 5957, 5867, 5754, 5621, 5468, 5294, 5105, 4900, 4682, 4455, 4219, 3977, 3731, 3485, 3238, 2994, 2755, 2522, 2297, 2081, 1875, 1681, 1497, 1327, 1170, 1024, 891, 770, 661, 563, 475, 397, 326, 262, 205, 151, 101, 54, 8, -38, -86, -138, -191, -249, -311, -381, -455, -537, -571, -984, 648, 2178, -663, -2315, -3060, -3045, -2613, -2096, -1726, -1604, -1709, -1967, -2286, -2595, -2849, -3042, -3186, -3299, -3404, -3523, -3645, -3781, -3856, -4356, -3010, 6041, 2896, -556, -2560, -3962, -4902, -5532, -5940, -6230, -6425, -6557, -6649, -6714, -6764, -6803, -6838, -6871, -6905, -6942, -6981, -7024, -7071, -7122, -7177, -7236, -7301, -7369, -7441, -7517, -7597, -7680, -7767, -7857, -7949, -8043, -8140, -8238, -8338, -8439, -8540, -8643, -8746, -8850, -8951, -9055, -9157, -9260, -9360, -9460, -9561, -9659, -9757, -9854, -9949, -10044, -10138, -10231, -10324, -10415, -10506, -10597, -10683, -10790, -10829, -9623, -9978, -10581, -10938, -11214, -11424, -11591, -11724, -11843, -11952, -12049, -12143, -12234, -12322, -12411, -12499, -12587, -12676, -12766, -12855, -12945, -13036, -13128, -13220, -13310, -13395, -13505, -13589, -13679, -13650, -14441, -11266, 27079, 21568, 17001, 19105, 22590, 24301, 23322, 21101, 19530, 19780, 21359, 22841, 23044, 21821, 20015, 18755, 18659, 19523, 20584, 21115, 20872, 20158, 19518, 19336, 19619, 20068, 20332, 20243, 19892, 19515, 19309, 19310, 19400, 19411, 19246, 18929, 18567, 18261, 18049, 17886, 17694, 17422, 17071, 16688, 16324, 16006, 15722, 15436, 15124, 14779, 14422, 14082, 13770, 13485, 13215, 12942, 12665, 12389, 12128, 11887, 11669, 11465, 11269, 11076, 10886, 10705, 10537, 10382, 10234, 10090, 9946, 9803, 9661, 9520, 9382, 9243, 9103, 8958, 8807, 8652, 8493, 8329, 8160, 7986, 7804, 7617, 7423, 7223, 7019, 6811, 6598, 6381, 6159, 5935, 5709, 5480, 5250, 5021, 4792, 4563, 4335, 4109, 3886, 3665, 3446, 3230, 3020, 2811, 2608, 2408, 2212, 2019, 1831, 1646, 1465, 1286, 1111, 937, 767, 599, 432, 266, 101, -62, -225, -388, -554, -719, -883, -1050, -1221, -1387, -1560, -1603, -2546, 1463, 5244, -1518, -5395, -7067, -6891, -5700, -4290, -3226, -2759, -2833, -3270, -3852, -4407, -4834, -5111, -5271, -5368, -5450, -5554, -5694, -5867, -6062, -6264, -6462, -6652, -6831, -7000, -7165, -7327, -7489, -7653, -7818, -7983, -8148, -8312, -8474, -8636, -8797, -8957, -9117, -9276, -9437, -9597, -9757, -9918, -10078, -10238, -10400, -10560, -10721, -10884, -11046, -11208, -11371, -11533, -11697, -11860, -12023, -12186, -12350, -12512, -12675, -12838, -12999, -13161, -13323, -13484, -13644, -13805, -13965, -14124, -14282, -14439, -14596, -14753, -14909, -15064, -15218, -15371, -15525, -15679, -15831, -15982, -16133, -16284, -16434, -16584, -16734, -16883, -17032, -17181, -17329, -17478, -17627, -17775, -17922, -18069, -18217, -18363, -18511, -18659, -18806, -18953, -19100, -19246, -19394, -19540, -19686, -19833, -19978, -20125, -20270, -20413, -20549, -20715, -20847, -20988, -20990, -21949, -18276};