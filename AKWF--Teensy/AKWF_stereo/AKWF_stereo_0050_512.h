/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0050 512 samples */
 
const int16_t AKWF_stereo_0050_512_DATA [512] = 
{4160, 13787, 19247, 20896, 20244, 19401, 19438, 19703, 19150, 17175, 14530, 13230, 13988, 15815, 17184, 15999, 11988, 7559, 4088, 2133, 2330, 3975, 6414, 9910, 14944, 21162, 26991, 31186, 32789, 30804, 25282, 17112, 8183, 786, -4165, -6592, -7031, -6539, -5681, -5365, -5846, -6737, -8097, -9346, -9960, -9902, -8778, -7375, -6629, -6531, -7204, -8590, -10482, -12669, -14870, -17001, -18583, -19219, -19148, -18287, -16596, -14972, -13323, -11570, -10099, -8830, -7561, -6313, -5571, -5190, -4869, -4775, -4232, -3470, -3126, -2827, -2817, -2685, -2202, -1946, -1077, -174, 279, 1464, 2224, 2865, 4034, 4435, 4624, 4711, 4506, 4376, 4190, 4169, 3963, 3572, 3338, 2917, 2705, 2667, 2209, 1749, 1032, 108, -144, -100, 58, 495, 697, 877, 1470, 1821, 2137, 2282, 1498, 1043, 482, -209, 23, -75, 46, 261, 273, 893, 894, 803, 1120, 833, 746, 633, 272, 742, 1389, 2127, 2482, 2569, 3230, 3079, 2739, 2915, 2266, 2077, 2183, 1307, 900, 1435, 1197, 1743, 2854, 1717, 1211, 1056, 328, 1587, 1215, 114, 539, -290, -310, 198, -207, 1000, 2098, 1515, 282, -646, -1266, -1796, -716, 1216, 2178, 2575, 1339, -1454, -2367, -1191, -822, 567, 868, -1439, -520, 1648, 3228, 5091, 1765, -3032, -4966, -5984, -3978, -984, 597, 2075, 1964, 194, -590, 1308, 4548, 7055, 7396, 4184, -539, -3391, -3692, -1033, 4323, 8190, 8616, 7411, 3538, -1606, -5056, -8341, -10591, -10188, -8377, -3325, 5796, 14689, 20264, 21831, 19339, 13158, 4907, -3374, -9790, -13627, -15907, -17033, -17032, -16118, -14382, -13008, -12399, -11163, -9577, -9383, -10492, -12208, -13334, -11765, -6468, 671, 6544, 9488, 8960, 6397, 3290, -1659, -9366, -18068, -26365, -31990, -31882, -26757, -18298, -7072, -3669, 2796, 6513, 9547, 13482, 17714, 21234, 23663, 24734, 24287, 24452, 26371, 28328, 28807, 27117, 23076, 18518, 14768, 11704, 9598, 8236, 7908, 9055, 11946, 17024, 22745, 27513, 31069, 32749, 31826, 27987, 22421, 17256, 12792, 8690, 5381, 2566, 215, -2239, -5121, -7756, -10512, -13165, -14885, -15905, -15738, -14761, -14050, -13527, -13240, -13215, -13656, -14863, -16281, -17928, -19729, -21035, -21830, -22341, -22093, -21589, -21010, -19896, -18722, -17255, -15854, -14025, -12305, -11079, -9807, -8583, -7214, -5554, -4697, -3863, -3384, -3041, -2164, -1917, -1519, -459, -354, 576, 1509, 1982, 3365, 4049, 4566, 5177, 5315, 5904, 5963, 6177, 6293, 6033, 5789, 5509, 5087, 5080, 4354, 3709, 2956, 1795, 1167, 1006, 686, 628, 466, 405, 887, 1336, 1494, 2073, 1522, 1217, 1337, 644, 911, 790, 592, 910, 361, 1071, 1228, 695, 1025, 1005, 861, 874, 258, 862, 1385, 1938, 2444, 2262, 3137, 3774, 3199, 3707, 3427, 3314, 3575, 2938, 2141, 2644, 2606, 2267, 3500, 2677, 1477, 1915, 893, 2269, 2221, 21, 855, 495, 57, 641, -355, 615, 1872, 1529, 359, -713, -400, -714, -1001, 699, 1734, 1956, 989, -876, -1889, -250, 37, 21, 770, -1795, -1618, 1413, 2533, 4598, 2082, -2775, -3090, -3581, -2534, -1029, -1201, -3, 457, -644, -1460, 70, 3708, 5968, 6198, 4325, 1277, -376, -284, 1176, 4489, 7488, 7389, 6721, 5333, 1946, -620, -3491, -6658, -7990, -8414, -6436, -35, 7424, 12623, 14868, 15601, 14733, 10887, 5245, 417, -2765, -6391, -10393, -13041, -14626, -15580, -16543, -17988, -18689, -17913, -17641, -18772, -20397, -20967, -19186, -14662, -8085, -2185, 1595, 3231, 4002, 4813, 3579, -1827, -9397, -16824, -23505, -26920, -26559, -23861, -18858, -11645};