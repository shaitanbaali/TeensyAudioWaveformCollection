/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0179 512 samples */
 
const int16_t AKWF_stereo_0179_512_DATA [512] = 
{2553, 8304, 12632, 15717, 17850, 19306, 20333, 21069, 21581, 21909, 22064, 22040, 21858, 21563, 21184, 20788, 20404, 20027, 19632, 19226, 18768, 18213, 17597, 16934, 16225, 15490, 14790, 14154, 13600, 13183, 12879, 12623, 12362, 12059, 11658, 11127, 10515, 9857, 9206, 8640, 8204, 7862, 7591, 7362, 7144, 6931, 6754, 6632, 6565, 6533, 6491, 6343, 6003, 5409, 4510, 3285, 1777, 27, -1923, -3996, -6093, -8072, -9681, -10613, -10536, -9239, -6778, -3569, -222, 2669, 4697, 5818, 6181, 6006, 5553, 5015, 4509, 4056, 3600, 3111, 2624, 2239, 2060, 2103, 2271, 2391, 2323, 2019, 1556, 1118, 938, 1165, 1791, 2672, 3576, 4315, 4801, 5027, 5036, 4899, 4682, 4435, 4172, 3893, 3590, 3259, 2916, 2586, 2293, 2041, 1844, 1699, 1596, 1547, 1556, 1612, 1715, 1854, 2011, 2180, 2361, 2579, 2871, 3262, 3765, 4348, 4923, 5406, 5701, 5741, 5498, 5001, 4282, 3393, 2384, 1283, 102, -1136, -2418, -3745, -5092, -6456, -7829, -9193, -10561, -11949, -13349, -14729, -15994, -16993, -17600, -17798, -17653, -17316, -16987, -16822, -16877, -17170, -17665, -18281, -18932, -19595, -20265, -20959, -21739, -22609, -23345, -23578, -22950, -21265, -18624, -15468, -12261, -9250, -6456, -3735, -912, 2007, 4832, 7392, 9529, 11184, 12432, 13370, 14114, 14764, 15398, 16054, 16757, 17500, 18242, 18978, 19691, 20330, 20864, 21287, 21552, 21626, 21539, 21298, 20894, 20337, 19638, 18733, 17565, 16156, 14473, 12523, 10392, 8105, 5707, 3229, 716, -1809, -4324, -6778, -9128, -11333, -13344, -15128, -16681, -18030, -19225, -20344, -21426, -22532, -23674, -24844, -26015, -27171, -28263, -29288, -30293, -31222, -31878, -32025, -31380, -29829, -27518, -24895, -22424, -20448, -19196, -18652, -18655, -19084, -19815, -20675, -21532, -22201, -22331, -21523, -19377, -15572, -10144, -3645, 10143, 16618, 21419, 24668, 26603, 27537, 27814, 27670, 27250, 26657, 25916, 25000, 23914, 22693, 21310, 19771, 18100, 16253, 14244, 12190, 10250, 8700, 7897, 8106, 9351, 11411, 13961, 16758, 19662, 22652, 25609, 28257, 30356, 31793, 32578, 32780, 32581, 32079, 31339, 30480, 29594, 28670, 27734, 26848, 26013, 25247, 24633, 24174, 23800, 23442, 23063, 22544, 21850, 20997, 19954, 18715, 17361, 15905, 14325, 12642, 10845, 8880, 6757, 4561, 2332, 130, -1997, -4103, -6260, -8543, -10968, -13490, -16024, -18506, -20847, -22994, -24930, -26676, -28265, -29673, -30844, -31629, -31869, -31590, -30922, -30057, -29207, -28550, -28110, -27825, -27661, -27542, -27404, -27263, -27213, -27228, -27324, -27511, -27724, -27913, -28138, -28403, -28729, -29192, -29828, -30569, -31293, -31895, -32149, -31841, -30843, -28982, -26044, -21892, -16643, -10683, -4569, 1084, 5886, 9807, 12929, 15389, 17392, 19049, 20430, 21598, 22653, 23563, 24338, 24987, 25565, 26182, 26869, 27652, 28509, 29311, 29924, 30314, 30445, 30316, 30015, 29637, 29214, 28758, 28287, 27739, 27031, 26180, 25212, 24115, 22904, 21615, 20190, 18572, 16776, 14763, 12511, 10024, 7388, 4617, 1763, -1036, -3755, -6420, -9025, -11559, -13781, -15238, -15463, -14275, -11884, -8900, -6029, -3764, -2297, -1594, -1482, -1816, -2515, -3512, -4779, -6291, -7998, -9855, -11815, -13831, -15861, -17816, -19634, -21250, -22572, -23572, -24155, -24135, -23311, -21601, -19085, -16001, -12800, -9888, -7515, -5867, -4966, -4703, -4966, -5656, -6683, -7971, -9468, -11145, -12916, -14703, -16445, -18032, -19360, -20336, -20837, -20765, -20144, -19067, -17680, -16197, -14828, -13678, -12781, -12167, -11774, -11521, -11369, -11272, -11179, -11072, -10962, -10834, -10671, -10479, -10248, -9980, -9713, -9546, -9565, -9821, -10361, -11144, -12113, -13210, -14379, -15554, -16644, -17483, -17727, -16913, -14546, -10276, -4184, 3142};