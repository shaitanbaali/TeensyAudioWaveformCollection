/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0194 512 samples */
 
const int16_t AKWF_stereo_0194_512_DATA [512] = 
{1551, 3870, 6044, 8107, 10060, 11906, 13636, 15246, 16742, 18126, 19401, 20569, 21620, 22578, 23441, 24207, 24902, 25515, 26029, 26445, 26804, 27084, 27264, 27388, 27454, 27435, 27343, 27212, 27011, 26721, 26393, 26008, 25539, 25014, 24459, 23820, 23128, 22393, 21587, 20710, 19819, 18893, 17914, 16916, 15897, 14839, 13739, 12633, 11500, 10326, 9145, 7950, 6727, 5492, 4267, 3029, 1789, 573, -632, -1818, -2964, -4066, -5108, -6084, -6982, -7803, -8540, -9196, -9769, -10249, -10637, -10939, -11152, -11262, -11285, -11224, -11074, -10848, -10559, -10200, -9782, -9305, -8790, -8296, -7812, -7356, -6922, -6528, -6182, -5879, -5622, -5427, -5280, -5170, -5101, -5070, -5069, -5104, -5174, -5278, -5406, -5571, -5763, -5967, -6187, -6414, -6634, -6841, -7042, -7223, -7373, -7500, -7594, -7647, -7662, -7645, -7587, -7484, -7353, -7182, -6962, -6709, -6426, -6106, -5752, -5386, -5011, -4622, -4239, -3860, -3482, -3126, -2787, -2460, -2150, -1864, -1596, -1347, -1126, -924, -729, -543, -358, -167, 35, 254, 493, 752, 1038, 1352, 1700, 2086, 2507, 2963, 3458, 3992, 4572, 5187, 5852, 6574, 7344, 8159, 9019, 9919, 10844, 11791, 12765, 13752, 14678, 15559, 16374, 17118, 17804, 18412, 18931, 19382, 19753, 20022, 20196, 20292, 20286, 20164, 19957, 19647, 19209, 18672, 18032, 17267, 16384, 15429, 14404, 13295, 12137, 10934, 9665, 8351, 7012, 5628, 4208, 2789, 1359, -91, -1543, -3000, -4463, -5918, -7371, -8828, -10277, -11725, -13152, -14533, -15884, -17200, -18467, -19693, -20890, -22050, -23160, -24240, -25278, -26245, -27155, -28023, -28827, -29548, -30225, -30833, -31340, -31777, -32142, -32398, -32547, -32624, -32576, -32401, -32141, -31761, -31226, -30592, -29835, -28910, -27844, -26657, -25289, -23734, -22042, -20181, -18125, -15916, -13561, -11057, -8382, -5775, -3266, -754, 6356, 8979, 11452, 13819, 16072, 18199, 20196, 22055, 23766, 25331, 26754, 28026, 29129, 30092, 30908, 31566, 32101, 32497, 32722, 32767, 32686, 32454, 32046, 31513, 30859, 30050, 29106, 28079, 26936, 25658, 24335, 22953, 21487, 19978, 18449, 16853, 15236, 13608, 11951, 10281, 8646, 7046, 5478, 3962, 2504, 1095, -268, -1570, -2821, -4026, -5180, -6277, -7328, -8323, -9261, -10146, -10965, -11727, -12437, -13083, -13669, -14183, -14602, -14925, -15167, -15317, -15358, -15311, -15176, -14935, -14601, -14194, -13695, -13097, -12438, -11708, -10899, -10034, -9121, -8153, -7146, -6092, -5014, -3973, -2961, -1988, -1047, -153, 693, 1495, 2245, 2932, 3561, 4129, 4638, 5089, 5476, 5797, 6055, 6247, 6373, 6445, 6459, 6408, 6303, 6148, 5946, 5702, 5424, 5113, 4761, 4391, 4011, 3621, 3227, 2847, 2485, 2139, 1820, 1524, 1244, 988, 749, 524, 316, 123, -59, -232, -397, -558, -723, -900, -1094, -1304, -1537, -1793, -2074, -2380, -2717, -3079, -3460, -3855, -4263, -4677, -5093, -5511, -5919, -6304, -6668, -7002, -7295, -7540, -7731, -7856, -7904, -7883, -7783, -7587, -7296, -6914, -6433, -5850, -5180, -4413, -3547, -2597, -1558, -414, 729, 1891, 3068, 4252, 5434, 6608, 7771, 8913, 10022, 11085, 12093, 13040, 13917, 14702, 15402, 16004, 16484, 16856, 17118, 17248, 17241, 17129, 16902, 16547, 16094, 15540, 14862, 14071, 13192, 12204, 11108, 9945, 8707, 7392, 6024, 4607, 3121, 1588, 10, -1619, -3288, -4986, -6699, -8401, -10086, -11744, -13364, -14948, -16499, -18011, -19475, -20895, -22269, -23570, -24799, -25970, -27065, -28059, -28982, -29815, -30525, -31143, -31669, -32061, -32315, -32471, -32472, -32315, -32042, -31611, -30985, -30223, -29307, -28190, -26898, -25459, -23825, -21992, -20019, -17871, -15531, -13042, -10417, -7648, -4706, -1825, 961, 3760};