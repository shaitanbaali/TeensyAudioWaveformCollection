/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0153 512 samples */
 
const int16_t AKWF_stereo_0153_512_DATA [512] = 
{11594, 23159, 9984, 6228, 6444, 5933, 5552, 5173, 4793, 4413, 4033, 3653, 3273, 2894, 2513, 2133, 1754, 1374, 993, 618, 218, -12, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, 7, -41, -420, -846, -1262, -1680, -2098, -2515, -2934, -3353, -3770, -4189, -4607, -5024, -5442, -5861, -6279, -6697, -7116, -7533, -7952, -8369, -8787, -9205, -9623, -10041, -10460, -10878, -11296, -11713, -12132, -12550, -12968, -13385, -13803, -14222, -14640, -15063, -15461, -16059, -16877, -17671, -18467, -19266, -20064, -20862, -21660, -22459, -23255, -24054, -24852, -25648, -26448, -27247, -28043, -28841, -29639, -30428, -31211, -32182, -25987, 20473, 26538, 18196, 15342, 14803, 13842, 12954, 12069, 11183, 10295, 9410, 8524, 7636, 6752, 5865, 4978, 4094, 3207, 2320, 1445, 511, -27, 7, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, 4, -24, -244, -493, -735, -979, -1223, -1466, -1710, -1954, -2197, -2441, -2685, -2928, -3172, -3417, -3659, -3903, -4147, -4390, -4634, -4878, -5121, -5365, -5609, -5852, -6096, -6339, -6583, -6827, -7070, -7314, -7559, -7801, -8045, -8289, -8533, -8787, -8984, -9648, -10822, -11943, -13071, -14202, -15333, -16461, -17592, -18723, -19850, -20980, -22111, -23239, -24370, -25501, -26629, -27760, -28890, -30000, -31095, -32629, -17435};