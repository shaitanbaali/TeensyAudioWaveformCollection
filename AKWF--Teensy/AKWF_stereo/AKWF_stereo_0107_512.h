/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0107 512 samples */
 
const int16_t AKWF_stereo_0107_512_DATA [512] = 
{9218, 13819, 14400, 16336, 17100, 17347, 11206, 5525, 5714, 4414, 4491, 5380, 6065, 7378, 8229, 9307, 10211, 11144, 11661, 11816, 22656, 24451, 24739, 25409, 25986, 26606, 27193, 27810, 28474, 28807, 28882, 29430, 29918, 30347, 30739, 31099, 31417, 31692, 32005, 31540, 31058, 31292, 31406, 31514, 31604, 31714, 31830, 31958, 32117, 31227, 30843, 31127, 31316, 31545, 31796, 32057, 32297, 32588, 32640, 30755, 30440, 30369, 30126, 30074, 30168, 30153, 29989, 29867, 29040, 26551, 25940, 25547, 25070, 24599, 24148, 23704, 23238, 22972, 21631, 19357, 19066, 18723, 18384, 18059, 17748, 17459, 17196, 17090, 15830, 14405, 14188, 13805, 13430, 13047, 12656, 12268, 11903, 11614, 10329, 9412, 9206, 8908, 8644, 8421, 8220, 8002, 7824, 7586, 6840, 6421, 6179, 5845, 5486, 5080, 4632, 4138, 3658, 2768, -2279, -3230, -4970, -4044, -4696, -5091, -5825, -6639, -7486, -8272, -8952, -9577, -10178, -10759, -11329, -11879, -12414, -12938, -13442, -13958, -14497, -15058, -15635, -16218, -16798, -17376, -17953, -18530, -19093, -19635, -20165, -20657, -21093, -21505, -21899, -22274, -22631, -22951, -23224, -23449, -23638, -23805, -23913, -24195, -24342, -24457, -24419, -24360, -24845, -20370, -16113, -16677, -16595, -16624, -16670, -16705, -16732, -16724, -16540, -22249, -25190, -24556, -24564, -24447, -24317, -24162, -23981, -23790, -23594, -23390, -23184, -22971, -22751, -22542, -22357, -22193, -22042, -21923, -21846, -21809, -21829, -21890, -21983, -22085, -22187, -22267, -22324, -22372, -22392, -22390, -22339, -22270, -22173, -22057, -21936, -21825, -21728, -21667, -21580, -22094, -23229, -23134, -22902, -22238, -22001, -21751, -21551, -21362, -21154, -20916, -20650, -20342, -19981, -19565, -19094, -18593, -18071, -17531, -16958, -16353, -15722, -15054, -14353, -13620, -12877, -12148, -11426, -10717, -10026, -9357, -8712, -8083, -7462, -6844, -6192, -5624, -5278, -3083, 23887, 27018, 22359, 25892, 27274, 26903, 15948, 10048, 15866, 13013, 11555, 12393, 12109, 13695, 13769, 14558, 14933, 15230, 15133, 14254, 28074, 29624, 29254, 29342, 29191, 29071, 28745, 28439, 28132, 27431, 26515, 26359, 26276, 26216, 26212, 26247, 26268, 26295, 26486, 25758, 25113, 25503, 25778, 26131, 26417, 26683, 26992, 27432, 28066, 27422, 27504, 28448, 29178, 29884, 30517, 31012, 31355, 31708, 31743, 29209, 28696, 29019, 29084, 29162, 29244, 29282, 29274, 29386, 28660, 25824, 25506, 25412, 25168, 24949, 24782, 24631, 24431, 24449, 22924, 20034, 19739, 19319, 18843, 18327, 17821, 17347, 16863, 16605, 14813, 12826, 12561, 12207, 12014, 11909, 11819, 11693, 11511, 11321, 9732, 8643, 8479, 8170, 7874, 7564, 7218, 6853, 6489, 6073, 4961, 4299, 3886, 3384, 2841, 2214, 1503, 682, -175, -1743, -10223, -12113, -15920, -15825, -18429, -19985, -21186, -21839, -22420, -23208, -24206, -25268, -26124, -26628, -26893, -27093, -27365, -27851, -28460, -29057, -29522, -29848, -30154, -30535, -30981, -31400, -31712, -31868, -31878, -31756, -31518, -31119, -30584, -29964, -29251, -28453, -27601, -26737, -25906, -25128, -24409, -23707, -23057, -22476, -21953, -21513, -21214, -20958, -21591, -15615, -9990, -10886, -10902, -11086, -11206, -11293, -11441, -11605, -11551, -19431, -23554, -22836, -22974, -22961, -23001, -23114, -23283, -23473, -23650, -23790, -23906, -23965, -23924, -23773, -23572, -23385, -23211, -22965, -22670, -22373, -22070, -21751, -21440, -21135, -20849, -20533, -20145, -19689, -19157, -18538, -17830, -17099, -16382, -15695, -15043, -14432, -13864, -13342, -12906, -12534, -12181, -11981, -11847, -11765, -11673, -11553, -11353, -11108, -10801, -10441, -10074, -9691, -9263, -8763, -8200, -7595, -6968, -6363, -5776, -5241, -4781, -4382, -4066, -3822, -3623, -3438, -3212, -2931, -2582, -2147, -1626, -1030, -365, 344, 1168, 1611, 1808, 4628};