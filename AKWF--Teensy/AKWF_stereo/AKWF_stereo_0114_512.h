/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0114 512 samples */
 
const int16_t AKWF_stereo_0114_512_DATA [512] = 
{378, 1130, 1881, 2648, 3422, 4215, 5028, 5845, 6654, 7437, 8200, 8948, 9689, 10430, 11177, 11913, 12615, 13270, 13896, 14515, 15111, 15671, 16202, 16708, 17196, 17675, 18142, 18571, 18949, 19285, 19608, 19951, 20335, 20834, 21277, 21665, 22050, 22423, 22771, 23105, 23437, 23770, 24100, 24434, 24773, 25107, 25461, 25847, 26249, 26668, 27109, 27542, 27961, 28395, 28859, 29349, 29834, 30297, 30732, 31127, 31475, 31771, 32024, 32223, 32348, 32395, 32365, 32270, 32100, 31865, 31548, 31164, 30700, 30170, 29603, 29012, 28394, 27737, 27045, 26340, 25631, 24941, 24292, 23684, 23109, 22559, 22055, 21595, 21170, 20767, 20369, 19986, 19636, 19331, 19065, 18826, 18589, 18348, 18088, 17759, 17414, 17061, 16675, 16251, 15792, 15310, 14801, 14248, 13668, 13068, 12461, 11859, 11254, 10633, 9996, 9333, 8633, 7895, 7127, 6353, 5595, 4854, 4131, 3408, 2676, 1923, 1150, 380, -381, -1151, -1923, -2677, -3409, -4132, -4855, -5596, -6354, -7128, -7896, -8633, -9334, -9996, -10634, -11255, -11859, -12461, -13069, -13669, -14248, -14801, -15311, -15792, -16252, -16675, -17061, -17415, -17759, -18088, -18348, -18590, -18826, -19065, -19331, -19637, -19986, -20369, -20768, -21170, -21595, -22056, -22559, -23109, -23685, -24292, -24942, -25632, -26340, -27045, -27737, -28394, -29012, -29603, -30171, -30700, -31164, -31548, -31865, -32100, -32270, -32365, -32395, -32348, -32223, -32024, -31771, -31475, -31127, -30732, -30297, -29834, -29349, -28859, -28395, -27961, -27542, -27109, -26669, -26249, -25847, -25462, -25107, -24774, -24434, -24100, -23770, -23438, -23105, -22772, -22423, -22050, -21665, -21277, -20835, -20336, -19952, -19609, -19285, -18949, -18572, -18142, -17675, -17197, -16708, -16202, -15672, -15111, -14515, -13897, -13271, -12615, -11914, -11178, -10431, -9690, -8948, -8200, -7438, -6654, -5846, -5029, -4216, -3423, -2649, -1882, -1131, -379, -701, -2152, -3594, -5073, -6556, -8004, -9416, -10775, -12068, -13300, -14458, -15494, -16373, -17135, -17791, -18353, -18812, -19090, -19211, -19188, -19004, -18729, -18381, -17942, -17409, -16784, -16081, -15313, -14455, -13461, -12422, -11310, -10085, -8772, -7320, -5857, -4373, -2817, -1166, 578, 2432, 4345, 6302, 8310, 10317, 12279, 14203, 16104, 17972, 19805, 21537, 23142, 24591, 25870, 26996, 27998, 28903, 29737, 30525, 31236, 31847, 32322, 32631, 32764, 32708, 32496, 32147, 31689, 31138, 30451, 29616, 28640, 27516, 26238, 24820, 23299, 21696, 20036, 18304, 16493, 14592, 12616, 10574, 8490, 6404, 4346, 2314, 297, -1706, -3705, -5707, -7684, -9609, -11470, -13223, -14844, -16218, -17509, -18751, -19894, -21036, -22011, -22816, -23498, -24042, -24453, -24714, -24787, -24674, -24371, -23873, -23200, -22411, -21535, -20567, -19557, -18406, -17090, -15682, -14222, -12761, -11291, -9763, -8165, -6473, -4680, -2834, -951, 950, 2833, 4679, 6472, 8165, 9762, 11290, 12760, 14221, 15681, 17089, 18406, 19557, 20567, 21535, 22411, 23200, 23873, 24371, 24674, 24787, 24714, 24453, 24042, 23497, 22816, 22010, 21036, 19893, 18750, 17508, 16217, 14843, 13222, 11469, 9608, 7683, 5707, 3705, 1705, -298, -2315, -4347, -6405, -8491, -10574, -12617, -14592, -16494, -18305, -20036, -21696, -23299, -24820, -26238, -27516, -28640, -29616, -30451, -31138, -31689, -32147, -32496, -32708, -32764, -32631, -32322, -31847, -31236, -30525, -29737, -28903, -27998, -26997, -25870, -24592, -23142, -21538, -19805, -17973, -16105, -14204, -12279, -10318, -8311, -6303, -4346, -2433, -579, 1165, 2816, 4372, 5857, 7320, 8771, 10084, 11309, 12421, 13460, 14455, 15312, 16080, 16784, 17408, 17941, 18381, 18728, 19004, 19188, 19210, 19090, 18811, 18353, 17791, 17135, 16373, 15493, 14457, 13299, 12068, 10774, 9416, 8003, 6555, 5072, 3593, 2151, 700};