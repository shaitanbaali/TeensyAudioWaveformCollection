/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0093 512 samples */
 
const int16_t AKWF_stereo_0093_512_DATA [512] = 
{558, 2576, 4491, 6344, 8120, 9822, 11443, 12955, 14336, 15537, 16537, 17325, 17881, 18217, 18313, 18160, 17860, 17434, 16923, 16383, 15854, 15367, 14935, 14565, 14224, 13904, 13625, 13359, 13094, 12814, 12517, 12190, 11825, 11412, 10944, 10417, 9832, 9185, 8475, 7724, 6927, 6132, 5306, 4357, 3523, 2841, 2324, 2041, 2047, 2360, 2972, 3853, 4895, 6003, 7213, 8443, 9605, 10640, 11506, 12157, 12557, 12681, 12518, 12089, 11411, 10516, 9442, 8228, 6920, 5576, 4168, 2416, 642, -1032, -2616, -4007, -5095, -5790, -6084, -5957, -5522, -5013, -4208, -3200, -2125, -1062, -108, 646, 1103, 1184, 831, 25, -1228, -2917, -5004, -7436, -10158, -13072, -16099, -19154, -22123, -24917, -27425, -29541, -31183, -32272, -32754, -32602, -31970, -31401, -30541, -29366, -28088, -26716, -25273, -23778, -22247, -20708, -19111, -17431, -15660, -13791, -11823, -9787, -7717, -5621, -3525, -1450, 588, 2567, 4488, 6344, 8120, 9823, 11443, 12957, 14336, 15538, 16538, 17326, 17883, 18216, 18312, 18158, 17860, 17434, 16924, 16383, 15855, 15365, 14936, 14566, 14227, 13907, 13624, 13361, 13094, 12815, 12517, 12192, 11826, 11414, 10945, 10419, 9833, 9184, 8475, 7723, 6927, 6132, 5307, 4359, 3525, 2842, 2324, 2043, 2047, 2362, 2973, 3854, 4896, 6003, 7215, 8442, 9606, 10640, 11506, 12158, 12558, 12680, 12519, 12088, 11411, 10517, 9443, 8231, 6920, 5581, 4170, 2417, 640, -1032, -2618, -4009, -5093, -5790, -6083, -5955, -5522, -5012, -4204, -3198, -2124, -1060, -105, 646, 1105, 1185, 831, 27, -1226, -2917, -5002, -7436, -10156, -13072, -16098, -19153, -22121, -24914, -27425, -29539, -31182, -32270, -32751, -32599, -31969, -31400, -30538, -29365, -28088, -26715, -25272, -23778, -22248, -20709, -19111, -17430, -15661, -13791, -11822, -9784, -7716, -5622, -3534, -1424, 4555, 6780, 8869, 10873, 12773, 14572, 16263, 17833, 19278, 20580, 21723, 22700, 23491, 24078, 24455, 24616, 24551, 24262, 23764, 23070, 22196, 21168, 20015, 18758, 17436, 16075, 14692, 13319, 11978, 10686, 9467, 8335, 7303, 6384, 5582, 4899, 4335, 3883, 3534, 3283, 3114, 3020, 3009, 3092, 3246, 3465, 3756, 4111, 4522, 4986, 5497, 6040, 6617, 7218, 7818, 8412, 8984, 9521, 10019, 10472, 10870, 11209, 11478, 11671, 11777, 11785, 11687, 11473, 11132, 10665, 10037, 9115, 7997, 6708, 5220, 3554, 1767, -76, -1958, -3832, -5582, -7156, -8550, -9728, -10676, -11404, -11935, -12318, -12598, -12833, -13084, -13404, -13836, -14424, -15192, -16155, -17314, -18653, -20149, -21767, -23457, -25166, -26836, -28394, -29778, -30918, -31748, -32206, -32301, -32204, -31755, -30938, -29853, -28518, -26950, -25174, -23247, -21221, -19065, -16806, -14483, -12111, -9693, -7256, -4820, -2393, -10, 2319, 4586, 6769, 8866, 10872, 12773, 14572, 16263, 17833, 19277, 20579, 21724, 22700, 23492, 24078, 24455, 24617, 24551, 24262, 23763, 23070, 22197, 21168, 20016, 18759, 17437, 16077, 14693, 13319, 11979, 10687, 9468, 8336, 7304, 6385, 5584, 4901, 4336, 3883, 3534, 3282, 3114, 3021, 3009, 3093, 3247, 3466, 3756, 4111, 4523, 4987, 5497, 6041, 6617, 7219, 7820, 8412, 8984, 9521, 10020, 10473, 10870, 11209, 11479, 11671, 11778, 11785, 11687, 11474, 11133, 10668, 10039, 9116, 7998, 6710, 5219, 3555, 1768, -76, -1957, -3831, -5582, -7155, -8548, -9726, -10676, -11402, -11934, -12316, -12597, -12832, -13084, -13402, -13835, -14423, -15190, -16154, -17312, -18651, -20148, -21768, -23456, -25165, -26836, -28393, -29777, -30918, -31746, -32205, -32300, -32203, -31753, -30937, -29851, -28516, -26949, -25173, -23246, -21220, -19065, -16805, -14483, -12110, -9692, -7255, -4820, -2396, -18, 2350};