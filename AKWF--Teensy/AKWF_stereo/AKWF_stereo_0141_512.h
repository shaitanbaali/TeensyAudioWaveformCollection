/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0141 512 samples */
 
const int16_t AKWF_stereo_0141_512_DATA [512] = 
{2970, 7690, 11998, 15939, 18262, 18416, 16902, 15941, 15242, 14748, 13777, 11718, 9998, 7835, 5454, 4389, 3423, 1853, 1329, 1419, 1556, 4352, 8567, 10829, 12603, 14395, 15257, 15228, 14809, 13786, 12187, 10809, 10266, 10380, 11059, 12732, 14308, 16055, 17128, 17395, 17447, 17626, 18577, 20228, 20598, 19525, 18780, 19425, 20765, 21231, 20701, 20669, 22497, 25104, 26597, 26964, 26579, 25667, 25170, 25049, 24948, 24894, 25058, 26353, 27628, 28474, 28938, 28822, 28300, 27227, 25272, 24414, 24637, 24647, 23960, 23217, 22461, 25819, 1482, -22863, -19292, -20468, -20323, -19661, -18892, -17112, -14789, -12476, -9075, -4802, -352, 4321, 7684, 9090, 8363, 5542, 2781, 1025, 1702, 4618, 7009, 8549, 9658, 10716, 11511, 12338, 13218, 14210, 14704, 13793, 12922, 13434, 14338, 13480, 11656, 10844, 13145, 16388, 18962, 20039, 19586, 18168, 17438, 18024, 19798, 21200, 21698, 23277, 25331, 26878, 28000, 28805, 29321, 28740, 26259, 24239, 24014, 23788, 23168, 22821, 22019, 25228, -237, -25579, -22068, -23184, -23157, -23104, -23333, -23711, -23781, -23912, -23803, -23071, -22114, -21611, -21813, -22316, -23770, -25654, -26478, -26330, -25171, -24027, -23780, -23141, -22790, -22691, -22607, -22332, -21714, -21219, -21404, -22447, -22773, -21977, -20772, -20380, -21122, -21496, -20248, -18157, -15376, -12742, -11856, -12205, -12308, -11253, -8665, -6540, -4253, 989, 5886, 9335, 12916, 15412, 16090, 12876, 7157, 4234, 3423, 1817, 587, 953, 1133, 2338, -16152, -33388, -30422, -30800, -30341, -29802, -29402, -28665, -28009, -27663, -27113, -26118, -25034, -23371, -21796, -20529, -20121, -21388, -22811, -23948, -24264, -24213, -24117, -23052, -21870, -21821, -21969, -21819, -21115, -20284, -20452, -21234, -20762, -19085, -17253, -17783, -19752, -20542, -18946, -15782, -13251, -12764, -13683, -14766, -14793, -13158, -10493, -8864, -7165, -2576, -13139, -8959, -5516, -3179, -2220, -4258, -8533, -9410, -7135, -5913, -6498, -7088, -5868, -6456, -9573, -10687, -12663, -14287, -13715, -11163, -7074, -1116, 6218, 10695, 13428, 13971, 14328, 16265, 18452, 19971, 19916, 19855, 19872, 19531, 20418, 22116, 22700, 23646, 23841, 23515, 24635, 26879, 29280, 30482, 29668, 28207, 27613, 27868, 28066, 27376, 26992, 27694, 29146, 30221, 30733, 30910, 29665, 26593, 24372, 23776, 25195, 26496, 26861, 28551, 30072, 30752, 30557, 29639, 28926, 26819, 23287, 22061, 22925, 22913, 21377, 21078, 21905, 23492, 3154, -28380, -31092, -32204, -32004, -31021, -29492, -27806, -25099, -22456, -21239, -21108, -20129, -16542, -12782, -9200, -7881, -8120, -8481, -8298, -4665, 789, 5955, 9740, 12037, 13356, 15720, 19014, 22144, 23688, 23340, 21663, 20781, 21295, 21722, 20979, 21587, 23266, 25586, 26321, 27167, 28154, 27099, 23759, 21592, 21855, 25143, 27100, 27458, 28975, 30599, 31122, 30786, 30589, 30660, 29014, 24989, 23312, 24564, 23476, 21696, 22219, 23213, 25094, 5443, -27024, -30080, -30773, -30665, -30470, -30229, -30465, -29907, -29758, -29924, -30114, -29784, -28767, -27738, -26879, -26835, -27008, -27130, -27005, -25203, -23481, -23410, -23148, -23546, -24015, -23234, -20070, -16531, -14620, -15182, -18032, -19135, -18071, -17247, -17265, -16518, -14945, -13436, -12780, -10808, -8396, -9142, -11744, -11936, -10647, -5255, -796, 1615, 7169, 12537, 16456, 20206, 22390, 22985, 20074, 15418, 14864, 17586, 18286, 18654, 19506, 19518, 20061, 500, -29476, -31862, -32682, -32146, -30710, -28581, -26656, -25453, -25492, -26226, -27002, -27144, -25297, -22830, -20014, -18479, -19189, -20444, -21511, -21485, -20462, -19569, -18111, -18690, -21465, -22628, -22248, -19766, -16701, -16721, -18282, -18164, -17706, -18496, -21039, -21821, -21360, -19965, -18688, -18795, -19885, -22432, -25628, -26782, -26348, -24752, -23256, -21407, -17557};