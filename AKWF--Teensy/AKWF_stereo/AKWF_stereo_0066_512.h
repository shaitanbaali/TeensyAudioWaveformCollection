/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0066 512 samples */
 
const int16_t AKWF_stereo_0066_512_DATA [512] = 
{115, 359, 584, 798, 994, 1173, 1331, 1472, 1593, 1691, 1772, 1836, 1877, 1902, 1911, 1904, 1883, 1852, 1809, 1757, 1700, 1638, 1569, 1500, 1434, 1367, 1304, 1246, 1196, 1151, 1118, 1097, 1082, 1081, 1097, 1126, 1166, 1227, 1303, 1390, 1498, 1622, 1761, 1916, 2091, 2279, 2477, 2694, 2924, 3162, 3412, 3674, 3940, 4210, 4489, 4768, 5045, 5328, 5608, 5881, 6147, 6415, 6671, 6914, 7155, 7383, 7593, 7799, 7993, 8168, 8331, 8487, 8627, 8749, 8866, 8973, 9062, 9143, 9219, 9282, 9334, 9388, 9434, 9469, 9504, 9541, 9570, 9597, 9634, 9666, 9698, 9742, 9784, 9826, 9881, 9941, 10001, 10072, 10154, 10240, 10326, 10429, 10537, 10646, 10768, 10898, 11029, 11166, 11315, 11465, 11612, 11774, 11939, 12099, 12263, 12434, 12612, 12175, 11008, 9551, 7886, 6170, 4446, 2132, 2529, 4776, 2111, -823, -3812, -6692, -9416, -11997, -14421, -16696, -18850, -20833, -22668, -24357, -25890, -27265, -28484, -29577, -30525, -31304, -31938, -32402, -32670, -32767, -32698, -32453, -32006, -31407, -30636, -29681, -28564, -27285, -25830, -24214, -22464, -20574, -18557, -16449, -14280, -12059, -9811, -7608, -5488, -3540, -1843, -690, -3693, -4089, -2693, -1593, -557, 328, 1038, 1564, 1910, 2079, 2081, 1925, 1630, 1210, 691, 100, -535, -1162, -1684, -2237, 390, 2147, 1538, 990, 337, -329, -969, -1562, -2097, -2562, -2950, -3261, -3496, -3656, -3739, -3758, -3717, -3615, -3467, -3281, -3058, -2807, -2541, -2264, -1976, -1687, -1410, -1141, -877, -632, -405, -192, 1, 177, 338, 486, 618, 740, 852, 957, 1051, 1146, 1236, 1320, 1402, 1477, 1540, 1586, 1601, 1530, 1508, 188, -2130, -2345, -2408, -2364, -2246, -2084, -1890, -1669, -1426, -1175, -916, -652, -389, -129, 12802, 13074, 13316, 13535, 13727, 13892, 14045, 14172, 14276, 14366, 14439, 14490, 14528, 14552, 14566, 14560, 14553, 14533, 14502, 14470, 14433, 14391, 14345, 14305, 14262, 14223, 14193, 14169, 14150, 14143, 14151, 14166, 14194, 14243, 14302, 14374, 14468, 14577, 14696, 14832, 14984, 15145, 15318, 15505, 15699, 15895, 16101, 16313, 16526, 16738, 16959, 17173, 17381, 17597, 17800, 17995, 18195, 18388, 18569, 18740, 18913, 19076, 19222, 19371, 19509, 19633, 19754, 19871, 19972, 20064, 20160, 20244, 20314, 20388, 20456, 20513, 20564, 20621, 20671, 20708, 20756, 20801, 20836, 20874, 20918, 20958, 20990, 21040, 21083, 21120, 21176, 21227, 21272, 21332, 21395, 21454, 21517, 21593, 21667, 21736, 21820, 21905, 21985, 22073, 22168, 22258, 22347, 22448, 22547, 22637, 22738, 22843, 22939, 23032, 23127, 23270, 23011, 21986, 20967, 19785, 18539, 17110, 14943, 12872, 3656, -10557, -14030, -16614, -18574, -20132, -21460, -22621, -23643, -24581, -25421, -26165, -26853, -27470, -28018, -28495, -28943, -29338, -29645, -29908, -30101, -30200, -30221, -30191, -30092, -29884, -29636, -29328, -28935, -28487, -27987, -27411, -26770, -26088, -25341, -24532, -23669, -22750, -21777, -20679, -19520, -18239, -16789, -15083, -12983, -9923, 2075, 7801, 8949, 10136, 10878, 11369, 11660, 11796, 11800, 11685, 11454, 11129, 10702, 10173, 9540, 8782, 7876, 6769, 5285, 3796, -4865, -11568, -12877, -14167, -15046, -15697, -16172, -16516, -16755, -16898, -16957, -16955, -16892, -16770, -16614, -16423, -16192, -15938, -15671, -15384, -15081, -14778, -14475, -14164, -13860, -13570, -13283, -12998, -12736, -12487, -12247, -12022, -11813, -11616, -11424, -11247, -11070, -10895, -10722, -10545, -10345, -10130, -9893, -9623, -9313, -8951, -8523, -8008, -7370, -6493, -5672, -1894, 4170, 5554, 6645, 7534, 8279, 8939, 9535, 10079, 10576, 11029, 11449, 11838, 12186, 12518};