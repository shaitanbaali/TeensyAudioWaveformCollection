/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0168 512 samples */
 
const int16_t AKWF_stereo_0168_512_DATA [512] = 
{307, 1318, 2336, 3362, 4384, 5392, 6385, 7355, 8303, 9229, 10128, 11007, 11856, 12683, 13489, 14265, 15023, 15763, 16475, 17166, 17845, 18495, 19115, 19729, 20321, 20879, 21431, 21973, 22483, 22976, 23467, 23944, 24398, 24867, 25339, 25786, 26230, 26683, 27123, 27547, 27988, 28411, 28782, 29138, 29479, 29775, 30069, 30363, 30629, 30875, 31139, 31390, 31608, 31842, 32078, 32306, 32494, 32434, 32087, 31546, 30916, 30214, 29437, 28646, 27859, 27050, 26228, 25440, 24661, 23865, 23102, 22370, 21625, 20892, 20198, 19500, 18774, 18073, 17363, 16616, 15868, 15130, 14390, 13670, 13016, 12393, 11793, 11231, 10677, 10120, 9573, 9050, 8535, 8042, 7593, 7153, 6712, 6295, 5898, 5492, 5097, 4719, 4347, 3981, 3631, 3286, 2944, 2688, 2550, 2474, 2435, 2425, 2427, 2434, 2451, 2472, 2489, 2501, 2506, 2495, 2473, 2447, 2416, 2384, 2257, 1827, 1138, 292, -649, -1642, -2663, -3690, -4710, -5719, -6711, -7680, -8627, -9550, -10449, -11327, -12175, -12999, -13805, -14581, -15333, -16073, -16787, -17472, -18148, -18802, -19420, -20027, -20620, -21183, -21725, -22264, -22782, -23269, -23755, -24234, -24692, -25149, -25620, -26078, -26511, -26960, -27400, -27823, -28261, -28683, -29052, -29406, -29748, -30055, -30336, -30627, -30903, -31146, -31401, -31656, -31883, -32103, -32338, -32580, -32757, -32693, -32359, -31825, -31189, -30493, -29735, -28934, -28150, -27344, -26523, -25738, -24962, -24165, -23404, -22672, -21929, -21196, -20502, -19803, -19077, -18376, -17668, -16925, -16179, -15443, -14707, -13990, -13336, -12721, -12122, -11556, -11002, -10444, -9895, -9369, -8869, -8371, -7910, -7477, -7043, -6626, -6225, -5821, -5423, -5045, -4677, -4311, -3959, -3616, -3278, -3018, -2880, -2807, -2768, -2755, -2759, -2767, -2781, -2802, -2821, -2831, -2835, -2826, -2804, -2777, -2745, -2715, -2586, -2158, -1471, -608, 17860, 18240, 18584, 18933, 19265, 19563, 19855, 20127, 20360, 20573, 20784, 20978, 21143, 21320, 21506, 21697, 21935, 22198, 22457, 22728, 22991, 23176, 23258, 23282, 23238, 23122, 22986, 22840, 22663, 22478, 22330, 22208, 22097, 22037, 22009, 21962, 21904, 21838, 21740, 21611, 21494, 21364, 21203, 21038, 20944, 21165, 21762, 22594, 23548, 24570, 25647, 26735, 27804, 28879, 29939, 30971, 31885, 32332, 32277, 31878, 31292, 30580, 29776, 28963, 28166, 27361, 26553, 25787, 25035, 24269, 23544, 22853, 22155, 21487, 20898, 20355, 19831, 19366, 18923, 18466, 18024, 17606, 17180, 16574, 15702, 14626, 13421, 12163, 10870, 9566, 8277, 7023, 5780, 4560, 3394, 2240, 1094, -13, -1075, -2136, -3182, -4197, -5177, -6101, -6972, -7800, -8583, -9299, -9937, -10517, -11053, -11560, -12041, -12495, -12938, -13371, -13787, -14194, -14603, -15006, -15393, -15780, -16145, -16454, -16760, -17136, -17538, -17928, -18324, -18703, -19048, -19391, -19726, -20031, -20313, -20586, -20819, -21031, -21240, -21434, -21598, -21773, -21963, -22157, -22385, -22648, -22916, -23175, -23435, -23627, -23709, -23724, -23681, -23573, -23426, -23277, -23110, -22918, -22762, -22645, -22540, -22466, -22436, -22402, -22331, -22263, -22163, -22033, -21913, -21783, -21620, -21454, -21359, -21589, -22172, -23003, -23966, -24983, -26054, -27145, -28221, -29285, -30344, -31389, -32293, -32736, -32693, -32299, -31705, -30996, -30208, -29383, -28588, -27783, -26975, -26209, -25458, -24692, -23966, -23275, -22578, -21908, -21319, -20775, -20249, -19784, -19341, -18884, -18443, -18025, -17599, -16996, -16124, -15061, -13859, -12598, -11307, -10000, -8714, -7457, -6234, -5010, -3826, -2682, -1547, -447, 624, 1687, 2734, 3750, 4725, 5649, 6519, 7345, 8128, 8843, 9479, 10060, 10595, 11102, 11581, 12038, 12477, 12909, 13329, 13733, 14140, 14546, 14934, 15317, 15682, 15996, 16297, 16672, 17072, 17469};