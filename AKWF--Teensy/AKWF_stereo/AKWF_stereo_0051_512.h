/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0051 512 samples */
 
const int16_t AKWF_stereo_0051_512_DATA [512] = 
{355, 1725, 3438, 4958, 6657, 8329, 9217, 10259, 10382, 10233, 10315, 10088, 11158, 12854, 14033, 14859, 16128, 15935, 15230, 14794, 13971, 13622, 15579, 19484, 24386, 28860, 31972, 32764, 30902, 27872, 24852, 21297, 17591, 15806, 15133, 14235, 14108, 14695, 14514, 14296, 15330, 14436, 12419, 11502, 10764, 8693, 6325, 3234, -597, -3745, -5496, -6016, -5173, -2733, 1131, 4219, 5430, 5975, 5876, 4854, 3449, 2053, 190, -1049, -1031, -528, -228, 341, 1387, 1925, 1993, 2179, 2537, 2537, 1894, 355, -2550, -6442, -9975, -12871, -15447, -16857, -16761, -16397, -15818, -14712, -13918, -13880, -14353, -15285, -16922, -18572, -19567, -19996, -20197, -19979, -19439, -19062, -18527, -17220, -15263, -13101, -10876, -8902, -7997, -8162, -8935, -10350, -12281, -13960, -15203, -16149, -16411, -15799, -14689, -13647, -12892, -12521, -12864, -13612, -14292, -15000, -15888, -16689, -17515, -18627, -19557, -19825, -19436, -18428, -16678, -14497, -12337, -10220, -8373, -7122, -6519, -6484, -6825, -7269, -7495, -7164, -6252, -5095, -3772, -2507, -1651, -993, -351, 39, 147, 60, -466, -1557, -2874, -4280, -5683, -6773, -7546, -7927, -7603, -6753, -5549, -4126, -3054, -2492, -2166, -1984, -1755, -1187, -277, 318, 561, 898, 1203, 1675, 2845, 3969, 4670, 5512, 6171, 6608, 7325, 7849, 7743, 7333, 6468, 5351, 4806, 4794, 5068, 5707, 6185, 6076, 6061, 6222, 6096, 6340, 6790, 6554, 6326, 6392, 5987, 5724, 6004, 5980, 5704, 5829, 6071, 6300, 7044, 8135, 8676, 8740, 8892, 8390, 7574, 7290, 6604, 5716, 5399, 4671, 3488, 3059, 2696, 2007, 2138, 2550, 2267, 2546, 3438, 3228, 2697, 2527, 1077, -877, -1812, -3358, -5156, -5687, -5878, -6225, -5593, -4105, -3027, -2110, -971, -538, -563, 2, 68, -731, -914, -757, -841, -417, 785, 2694, 3428, 4636, 6482, 7706, 8710, 9830, 10203, 11596, 11551, 13091, 15241, 16253, 16434, 17834, 18983, 18265, 18555, 18763, 18861, 19721, 22668, 26581, 29033, 30470, 32287, 32725, 31726, 31808, 31747, 29557, 27455, 27826, 26716, 24529, 23163, 23190, 20998, 20474, 19435, 17142, 14895, 14541, 13557, 10701, 7240, 4654, 2499, 54, -1461, -1736, -2014, -1088, 578, 375, -191, 528, 1657, 1366, 704, 486, 320, 559, 1066, 1562, 1068, 1505, 2222, 2265, 1678, 2100, 2752, 2175, 639, -945, -3472, -6169, -8175, -10198, -12802, -14360, -15317, -16633, -17796, -18358, -18818, -20090, -21251, -22157, -23214, -24173, -24318, -24317, -24768, -24841, -24505, -24240, -23658, -22072, -20150, -18747, -17243, -15767, -15009, -14732, -14392, -14428, -14948, -15379, -15666, -16019, -16218, -15912, -15602, -15985, -16320, -16625, -17202, -17836, -18173, -18688, -19550, -20348, -21164, -22081, -22657, -22579, -22179, -21654, -20627, -19316, -17902, -16458, -14969, -13650, -12737, -11930, -11005, -10133, -9181, -7854, -6544, -5484, -4368, -3432, -2624, -1781, -968, -471, -260, -270, -690, -1418, -2224, -3138, -4040, -5005, -5935, -6367, -6460, -6470, -6129, -5865, -5876, -5722, -5304, -4669, -3990, -2866, -1936, -1574, -984, 49, 960, 2195, 3543, 4241, 5022, 5944, 6823, 7812, 8619, 8898, 8952, 8723, 8205, 8157, 8375, 8390, 8438, 8491, 8013, 7624, 7915, 7871, 7748, 8075, 7922, 7455, 7619, 7624, 7392, 7564, 7736, 7484, 7288, 7579, 7914, 8216, 8917, 9545, 9387, 9483, 9768, 9410, 9481, 9301, 8681, 8433, 7953, 6812, 6145, 5925, 4942, 4317, 4382, 3735, 3035, 3527, 3607, 2449, 2227, 1768, 218, -558, -1253, -2746, -3880, -4343, -4899, -5560, -5335, -4686, -4731, -4625, -4051, -3818, -3190, -2574, -2649, -2626, -1865, -1292, -804, -266};