/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0182 512 samples */
 
const int16_t AKWF_stereo_0182_512_DATA [512] = 
{114, 426, 721, 1003, 1269, 1534, 1801, 2069, 2346, 2634, 2936, 3258, 3608, 3987, 4400, 4849, 5331, 5854, 6418, 7019, 7661, 8342, 9055, 9799, 10578, 11380, 12194, 13015, 13853, 14690, 15510, 16335, 17151, 17935, 18708, 19470, 20192, 20902, 21598, 22258, 22889, 23510, 24111, 24668, 25214, 25736, 26215, 26663, 27089, 27469, 27787, 28081, 28329, 28500, 28622, 28701, 28700, 28615, 28482, 28273, 27963, 27594, 27157, 26618, 25989, 25306, 24531, 23646, 22703, 21683, 20553, 19354, 18094, 16731, 15301, 13805, 12220, 10558, 8856, 7093, 5277, 3428, 1557, -336, -2243, -4148, -6042, -7924, -9773, -11582, -13347, -15055, -16709, -18293, -19790, -21221, -22572, -23819, -24985, -26071, -27043, -27918, -28713, -29402, -29971, -30455, -30843, -31105, -31256, -31318, -31255, -31050, -30751, -30321, -29741, -29058, -28249, -27279, -26188, -24979, -23627, -22136, -20545, -18838, -17001, -15079, -13085, -10999, -8843, -6669, -4444, -2167, 112, 2403, 4704, 6980, 9228, 11446, 13602, 15703, 17741, 19682, 21542, 23308, 24950, 26495, 27939, 29252, 30447, 31548, 32524, 32799, 32758, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32757, 32803, 32430, 31321, 30110, 28757, 27226, 25575, 23802, 21879, 19841, 17713, 15472, 13110, 10679, 8196, 5665, 3117, 576, -1949, -4444, -6885, -9257, -11548, -13753, -15859, -17857, -19748, -21529, -23192, -24733, -26168, -27496, -28707, -29809, -30812, -31684, -32483, -32793, -32760, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32762, -32784, -32636, -31964, -31138, -30246, -29307, -28288, -27188, -26075, -24928, -23733, -22550, -21372, -20184, -18996, -17849, -16722, -15586, -14503, -13470, -12465, -11500, -10598, -9729, -8891, -8109, -7367, -6651, -5978, -5347, -4745, -4167, -3628, -3113, -2622, -2159, -1726, -1313, -921, -560, -211, 15390, 14514, 13602, 12646, 11662, 10630, 9539, 8422, 7259, 6036, 4767, 3456, 2097, 706, -719, -2173, -3652, -5142, -6632, -8117, -9590, -11043, -12463, -13837, -15167, -16443, -17653, -18797, -19874, -20873, -21781, -22626, -23396, -24066, -24667, -25199, -25629, -25990, -26286, -26492, -26612, -26682, -26672, -26567, -26405, -26182, -25868, -25481, -25045, -24536, -23942, -23314, -22635, -21877, -21086, -20262, -19393, -18485, -17581, -16658, -15708, -14773, -13851, -12922, -12002, -11112, -10239, -9371, -8535, -7714, -6890, -6078, -5276, -4452, -3628, -2792, -1936, -1057, -155, 774, 1733, 2717, 3726, 4751, 5796, 6850, 7908, 8957, 9999, 11024, 12017, 12967, 13878, 14738, 15527, 16263, 16929, 17504, 18008, 18441, 18781, 19030, 19214, 19313, 19319, 19272, 19165, 18985, 18757, 18504, 18215, 17891, 17577, 17262, 16935, 16642, 16378, 16131, 15921, 15764, 15640, 15549, 15522, 15535, 15575, 15672, 15819, 15993, 16201, 16459, 16750, 17054, 17398, 17768, 18144, 18536, 18947, 19353, 19738, 20128, 20497, 20815, 21106, 21359, 21536, 21660, 21723, 21687, 21557, 21352, 21047, 20590, 20040, 19394, 18619, 17740, 16769, 15678, 14495, 13234, 11873, 10436, 8951, 7418, 5845, 4257, 2666, 1062, -551, -2142, -3708, -5245, -6742, -8203, -9611, -10959, -12266, -13532, -14746, -15915, -17048, -18127, -19153, -20152, -21102, -21990, -22843, -23652, -24393, -25077, -25724, -26291, -26789, -27234, -27603, -27868, -28071, -28193, -28202, -28117, -27947, -27639, -27229, -26709, -26047, -25250, -24352, -23333, -22175, -20901, -19523, -18020, -16404, -14707, -12932, -11062, -9159, -7219, -5233, -3241, -1265, 699, 2629, 4506, 6332, 8082, 9729, 11291, 12759, 14125, 15394, 16558, 17614, 18569, 19417, 20141, 20758, 21276, 21683, 21974, 22187, 22303, 22313, 22243, 22103, 21873, 21559, 21199, 20773, 20263, 19709, 19114, 18458, 17744, 17007, 16209};