/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0109 256 samples */
 
const int16_t AKWF_stereo_0109_256_DATA [256] = 
{4735, 5535, 6457, 7814, 8837, 10077, 11353, 12259, 13402, 14237, 15125, 16101, 16855, 17828, 18647, 19409, 20301, 20899, 21659, 22256, 22706, 23215, 23424, 23735, 23986, 24118, 24452, 24558, 24719, 24856, 24809, 24928, 24905, 24869, 24903, 24728, 24645, 24626, 24470, 24510, 24396, 24373, 24452, 24288, 24304, 24136, 24453, 27578, 27595, 27652, 27742, 27736, 27891, 27905, 27884, 27995, 27934, 27950, 27841, 27719, 27653, 27440, 27379, 27247, 27104, 27137, 27007, 27028, 26994, 26840, 26783, 26487, 26231, 25965, 25586, 25438, 25197, 24985, 25014, 24940, 25000, 24937, 24797, 24803, 24690, 24644, 24796, 24865, 25168, 25431, 25587, 25811, 25787, 25553, 27702, 28510, 28265, 28281, 28264, 28256, 28130, 28131, 27941, 27718, 27519, 27135, 26923, 26564, 26185, 25866, 25342, 24903, 24374, 23753, 23332, 22746, 22381, 22072, 21608, 21410, 21159, 20907, 20593, 20069, 19670, 19330, 17997, 22908, -10433, -35839, -31116, -32067, -32059, -32222, -32302, -32226, -32267, -32225, -32183, -32168, -32054, -32160, -32174, -32246, -32334, -32362, -32519, -32583, -32638, -32758, -32657, -32654, -32580, -32421, -32466, -32351, -32239, -32182, -31979, -31894, -31797, -31529, -29219, -28409, -28310, -28032, -27755, -27633, -27387, -27153, -26857, -26552, -26476, -26219, -25988, -25798, -25409, -25037, -24722, -24130, -23668, -23057, -22507, -22071, -21636, -21649, -21504, -21530, -21721, -21653, -21515, -21039, -20575, -20254, -19800, -19830, -19846, -19922, -20279, -20311, -20377, -20450, -20106, -20068, -20183, -20402, -20859, -21026, -21904, -19585, -17140, -17650, -17410, -17403, -17385, -17365, -17628, -17857, -18003, -18298, -18308, -18130, -17917, -17630, -17628, -17355, -17256, -17114, -16639, -16439, -15921, -15477, -15101, -14518, -14366, -14056, -13793, -13773, -13417, -13220, -12820, -12194, -11801, -11146, -10840, -10670, -10327, -10268, -9701, -9114, -8556, -7563, -6877, -5855, -4957, -4331};