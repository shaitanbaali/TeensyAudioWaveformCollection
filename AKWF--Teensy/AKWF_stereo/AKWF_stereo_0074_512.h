/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0074 512 samples */
 
const int16_t AKWF_stereo_0074_512_DATA [512] = 
{440, 1297, 2141, 2990, 3842, 4696, 5553, 6407, 7261, 8115, 8966, 9812, 10658, 11494, 12325, 13148, 13960, 14767, 15562, 16345, 17118, 17875, 18619, 19349, 20062, 20757, 21437, 22097, 22738, 23360, 23962, 24544, 25102, 25640, 26154, 26648, 27118, 27562, 27986, 28385, 28759, 29110, 29434, 29738, 30017, 30272, 30503, 30712, 30895, 31056, 31195, 31310, 31405, 31479, 31529, 31560, 31572, 31565, 31536, 31491, 31427, 31347, 31250, 31135, 31005, 30861, 30704, 30530, 30343, 30144, 29934, 29712, 29474, 29228, 28972, 28704, 28426, 28140, 27842, 27533, 27218, 26892, 26558, 26216, 25862, 25500, 25130, 24750, 24359, 23962, 23554, 23136, 22709, 22271, 21821, 21363, 20893, 20415, 19914, 19403, 18895, 18372, 17834, 17286, 16722, 16146, 15557, 14955, 14340, 13713, 13072, 12414, 11751, 11071, 10376, 9671, 8954, 8224, 7482, 6729, 5966, 5191, 4406, 3611, 2810, 1996, 1178, 354, -480, -1319, -2162, -3011, -3861, -4714, -5573, -6425, -7277, -8131, -8982, -9828, -10672, -11509, -12343, -13166, -13978, -14783, -15578, -16361, -17135, -17894, -18637, -19367, -20082, -20775, -21456, -22117, -22756, -23379, -23980, -24559, -25121, -25656, -26172, -26665, -27133, -27578, -28000, -28398, -28771, -29122, -29448, -29750, -30027, -30281, -30510, -30717, -30899, -31060, -31198, -31314, -31407, -31479, -31529, -31560, -31572, -31562, -31534, -31488, -31425, -31343, -31243, -31130, -31000, -30856, -30698, -30524, -30338, -30138, -29930, -29709, -29470, -29223, -28965, -28696, -28417, -28130, -27834, -27525, -27210, -26883, -26548, -26206, -25853, -25491, -25120, -24740, -24351, -23952, -23543, -23124, -22697, -22259, -21809, -21352, -20881, -20400, -19909, -19403, -18889, -18361, -17822, -17271, -16707, -16128, -15540, -14938, -14322, -13693, -13052, -12393, -11731, -11050, -10356, -9652, -8932, -8202, -7462, -6708, -5945, -5170, -4384, -3589, -2789, -1973, -1178, -385, 1199, 2080, 2946, 3818, 4696, 5579, 6465, 7347, 8225, 9103, 9975, 10846, 11715, 12575, 13429, 14273, 15104, 15930, 16744, 17544, 18334, 19109, 19867, 20610, 21338, 22045, 22736, 23408, 24059, 24691, 25301, 25888, 26453, 26996, 27514, 28011, 28483, 28928, 29353, 29751, 30122, 30470, 30792, 31090, 31363, 31609, 31833, 32032, 32203, 32354, 32480, 32582, 32662, 32720, 32754, 32767, 32761, 32734, 32686, 32620, 32534, 32430, 32311, 32173, 32019, 31851, 31667, 31468, 31256, 31031, 30793, 30543, 30280, 30007, 29724, 29429, 29122, 28808, 28485, 28150, 27807, 27455, 27095, 26725, 26345, 25959, 25564, 25157, 24742, 24319, 23885, 23442, 22990, 22527, 22054, 21570, 21074, 20569, 20053, 19524, 18983, 18430, 17864, 17287, 16696, 16091, 15475, 14845, 14202, 13545, 12875, 12190, 11495, 10785, 10061, 9325, 8578, 7817, 7044, 6259, 5466, 4660, 3842, 3017, 2184, 1339, 491, -363, -1229, -2096, -2968, -3846, -4724, -5604, -6490, -7371, -8249, -9127, -10000, -10872, -11739, -12599, -13453, -14296, -15128, -15953, -16767, -17567, -18355, -19130, -19888, -20631, -21359, -22067, -22756, -23428, -24077, -24708, -25317, -25904, -26470, -27011, -27530, -28024, -28495, -28942, -29364, -29761, -30133, -30479, -30801, -31099, -31369, -31616, -31838, -32035, -32207, -32356, -32483, -32585, -32664, -32721, -32755, -32767, -32761, -32732, -32684, -32617, -32532, -32428, -32307, -32169, -32015, -31846, -31662, -31463, -31251, -31026, -30785, -30536, -30273, -29999, -29715, -29420, -29114, -28800, -28476, -28142, -27799, -27446, -27085, -26716, -26336, -25947, -25552, -25146, -24732, -24307, -23874, -23430, -22977, -22514, -22040, -21557, -21061, -20556, -20040, -19509, -18968, -18415, -17849, -17272, -16681, -16074, -15458, -14829, -14184, -13527, -12857, -12171, -11476, -10765, -10040, -9307, -8558, -7795, -7024, -6240, -5444, -4638, -3821, -2995, -2162, -1317, -486, 351};