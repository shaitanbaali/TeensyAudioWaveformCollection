/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0013 512 samples */
 
const int16_t AKWF_stereo_0013_512_DATA [512] = 
{18549, 28381, 28266, 31749, 32234, 31589, 14170, -2107, -3380, -8756, -10650, -9941, -9705, -7736, -6877, -5346, -4186, -3187, -1977, -1282, -329, 248, 855, 1335, 1659, 2002, 2152, 2295, 2333, 2333, 2290, 2175, 2055, 1854, 1642, 1433, 1183, 927, 655, 383, 101, -184, -461, -741, -1028, -1277, -1540, -1802, -2042, -2284, -2523, -2733, -2950, -3157, -3345, -3516, -3687, -3850, -4008, -4147, -4282, -4406, -4522, -4633, -4720, -4830, -4928, -4979, -5034, -5107, -5154, -5203, -5242, -5278, -5297, -5319, -5338, -5348, -5354, -5355, -5340, -5324, -5303, -5288, -5267, -5231, -5210, -5176, -5137, -5089, -5047, -4996, -4940, -4869, -4816, -4766, -4700, -4659, -4609, -4529, -4469, -4390, -4328, -4242, -4174, -4086, -4001, -3935, -3862, -3794, -3722, -3653, -3571, -3502, -3437, -3360, -3288, -3215, -3145, -3061, -3002, -2930, -2871, -2804, -2742, -2681, -2616, -2551, -2474, -2430, -2389, -2310, -2261, -2196, -2141, -2095, -2033, -1983, -1938, -1883, -1835, -1784, -1733, -1684, -1636, -1588, -1548, -1501, -1461, -1424, -1375, -1337, -1294, -1250, -1214, -1176, -1131, -1084, -1042, -997, -972, -955, -916, -879, -853, -815, -787, -756, -729, -702, -682, -649, -619, -591, -565, -536, -515, -489, -467, -440, -428, -410, -390, -373, -356, -342, -326, -299, -286, -273, -255, -233, -223, -224, -212, -205, -201, -179, -176, -161, -148, -140, -138, -127, -118, -112, -107, -115, -104, -105, -101, -95, -90, -83, -85, -80, -71, -79, -76, -76, -83, -78, -83, -79, -68, -90, -97, -86, -88, -88, -91, -93, -93, -97, -92, -104, -103, -103, -112, -113, -119, -121, -122, -129, -126, -128, -133, -138, -142, -146, -148, -148, -159, -163, -133, -345, 23639, 27222, 16063, 22056, 24220, 22952, 1149, -10173, 1698, -4534, -8302, -7031, -8023, -5172, -5291, -3904, -3281, -3030, -2128, -2292, -1689, -1783, -1641, -1615, -1781, -1746, -2004, -2112, -2334, -2523, -2709, -2954, -3125, -3379, -3575, -3735, -3931, -4101, -4262, -4401, -4537, -4664, -4766, -4865, -4967, -5012, -5077, -5138, -5174, -5221, -5267, -5276, -5308, -5333, -5335, -5331, -5335, -5338, -5342, -5330, -5325, -5317, -5305, -5296, -5263, -5276, -5269, -5201, -5165, -5163, -5124, -5095, -5061, -5028, -4979, -4942, -4905, -4857, -4807, -4755, -4686, -4618, -4546, -4492, -4428, -4345, -4288, -4209, -4127, -4040, -3962, -3872, -3775, -3663, -3571, -3481, -3368, -3298, -3211, -3077, -2986, -2871, -2778, -2650, -2547, -2423, -2294, -2198, -2085, -1978, -1870, -1763, -1643, -1543, -1446, -1328, -1218, -1114, -1012, -885, -797, -692, -602, -499, -406, -314, -216, -120, -14, 47, 115, 246, 317, 405, 484, 548, 645, 716, 781, 864, 932, 1003, 1075, 1142, 1211, 1277, 1331, 1399, 1454, 1501, 1569, 1617, 1673, 1729, 1772, 1821, 1878, 1932, 1974, 2022, 2047, 2067, 2124, 2166, 2182, 2226, 2248, 2277, 2304, 2327, 2340, 2369, 2391, 2409, 2424, 2444, 2451, 2466, 2473, 2487, 2478, 2480, 2489, 2483, 2475, 2470, 2467, 2476, 2457, 2442, 2439, 2436, 2411, 2377, 2370, 2349, 2316, 2308, 2269, 2254, 2234, 2201, 2165, 2144, 2113, 2079, 2043, 1992, 1968, 1922, 1878, 1845, 1808, 1766, 1718, 1678, 1646, 1583, 1541, 1496, 1439, 1398, 1337, 1295, 1258, 1173, 1122, 1099, 1037, 980, 926, 874, 823, 764, 718, 645, 598, 548, 482, 434, 373, 319, 267, 205, 159, 101, 42, -14, -70, -126, -181, -229, -293, -347, -357, -683};