/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0125 512 samples */
 
const int16_t AKWF_stereo_0125_512_DATA [512] = 
{673, 2643, 4597, 6567, 8535, 10486, 12412, 14296, 16142, 17934, 19654, 21296, 22846, 24285, 25620, 26846, 27958, 28963, 29854, 30624, 31274, 31801, 32207, 32498, 32681, 32762, 32747, 32646, 32470, 32251, 32015, 31768, 31510, 31246, 30978, 30715, 30455, 30196, 29927, 29642, 29323, 28957, 28532, 28028, 27437, 26750, 25953, 25045, 24028, 22893, 21642, 20277, 18786, 17168, 15430, 13570, 11612, 9574, 7461, 5292, 3084, 849, -1372, -3555, -5676, -7704, -9634, -11457, -13154, -14727, -16171, -17469, -18647, -19754, -20792, -21764, -22668, -23498, -24256, -24939, -25545, -26082, -26551, -26945, -27265, -27508, -27679, -27778, -27808, -27774, -27678, -27527, -27330, -27095, -26824, -26518, -26173, -25795, -25386, -24947, -24482, -23997, -23486, -22950, -22383, -21784, -21163, -20518, -19848, -19154, -18428, -17667, -16866, -16018, -15119, -14165, -13144, -12057, -10904, -9674, -8382, -7029, -5617, -4150, -2626, -1039, 602, 2296, 4041, 5823, 7639, 9480, 11326, 13159, 14965, 16725, 18440, 20100, 21686, 23193, 24599, 25890, 27067, 28120, 29046, 29848, 30522, 31060, 31463, 31748, 31925, 32006, 31998, 31911, 31751, 31530, 31260, 30947, 30602, 30231, 29832, 29408, 28959, 28490, 28005, 27504, 26985, 26440, 25853, 25211, 24503, 23716, 22839, 21863, 20773, 19572, 18268, 16864, 15372, 13797, 12133, 10384, 8566, 6684, 4758, 2799, 811, -1193, -3199, -5200, -7169, -9086, -10935, -12691, -14350, -15914, -17371, -18731, -19984, -21122, -22164, -23156, -24097, -24991, -25829, -26604, -27316, -27968, -28556, -29084, -29552, -29956, -30292, -30565, -30778, -30927, -31013, -31039, -31007, -30921, -30789, -30616, -30404, -30158, -29879, -29574, -29255, -28921, -28577, -28226, -27864, -27482, -27067, -26614, -26123, -25586, -25001, -24370, -23683, -22938, -22136, -21268, -20337, -19337, -18256, -17095, -15850, -14513, -13097, -11604, -10031, -8390, -6682, -4910, -3089, -1183, -5500, -3798, -2080, -314, 1488, 3315, 5158, 7002, 8855, 10705, 12535, 14342, 16104, 17802, 19434, 20985, 22441, 23803, 25057, 26193, 27210, 28104, 28876, 29540, 30097, 30550, 30904, 31156, 31315, 31408, 31450, 31450, 31412, 31338, 31233, 31107, 30962, 30801, 30620, 30419, 30194, 29944, 29669, 29357, 28995, 28572, 28067, 27466, 26766, 25959, 25046, 24028, 22897, 21647, 20280, 18797, 17214, 15540, 13779, 11937, 10021, 8036, 6017, 3981, 1941, -77, -2064, -4010, -5892, -7700, -9413, -11006, -12495, -13924, -15290, -16599, -17845, -19017, -20116, -21141, -22086, -22956, -23744, -24444, -25063, -25601, -26058, -26441, -26748, -26978, -27134, -27218, -27238, -27203, -27117, -26980, -26795, -26566, -26291, -25971, -25614, -25222, -24794, -24330, -23820, -23267, -22685, -22080, -21457, -20817, -20157, -19478, -18779, -18056, -17316, -16549, -15745, -14899, -14008, -13059, -12056, -11000, -9881, -8707, -7474, -6179, -4833, -3435, -1980, -475, 1089, 2716, 4392, 6108, 7852, 9606, 11368, 13129, 14867, 16581, 18245, 19841, 21359, 22789, 24119, 25347, 26461, 27445, 28300, 29033, 29651, 30162, 30567, 30871, 31073, 31182, 31205, 31148, 31022, 30840, 30603, 30317, 29995, 29636, 29251, 28839, 28400, 27932, 27431, 26898, 26334, 25726, 25067, 24347, 23546, 22648, 21660, 20579, 19409, 18159, 16822, 15402, 13906, 12337, 10714, 9044, 7324, 5559, 3754, 1910, 49, -1811, -3661, -5481, -7262, -8996, -10665, -12261, -13767, -15164, -16463, -17710, -18909, -20066, -21180, -22245, -23264, -24235, -25157, -26026, -26833, -27568, -28231, -28821, -29336, -29777, -30142, -30435, -30656, -30807, -30895, -30930, -30913, -30850, -30738, -30582, -30386, -30150, -29876, -29569, -29227, -28847, -28420, -27948, -27439, -26904, -26344, -25761, -25147, -24505, -23835, -23132, -22395, -21620, -20793, -19912, -18967, -17945, -16845, -15672, -14423, -13098, -11699, -10229, -8700, -7087};