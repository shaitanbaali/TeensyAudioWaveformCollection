/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0100 512 samples */
 
const int16_t AKWF_stereo_0100_512_DATA [512] = 
{673, 1419, 2255, 2895, 3716, 4791, 5389, 5867, 5826, 5835, 6851, 7525, 7926, 8696, 9573, 10376, 10561, 10746, 10485, 10511, 10637, 9976, 9705, 9562, 9255, 8999, 8965, 8651, 8560, 8484, 8838, 9081, 9418, 9815, 10119, 10478, 10832, 11217, 11984, 13068, 13854, 14165, 14445, 14839, 14944, 15494, 16522, 17358, 17523, 17822, 17810, 17890, 18504, 19476, 20564, 21931, 22510, 23174, 23458, 23572, 24078, 24414, 24700, 25307, 25744, 26830, 27548, 27851, 27999, 28211, 28267, 28431, 28648, 28302, 28278, 28140, 28000, 28080, 28051, 27712, 27090, 26277, 25628, 25060, 25001, 24710, 24837, 24628, 24907, 24745, 24869, 24986, 24304, 23772, 23590, 23345, 22484, 21892, 21288, 20320, 20201, 19933, 19893, 20122, 19860, 19518, 19146, 18823, 18466, 18288, 18457, 18172, 17919, 17672, 17356, 16856, 16579, 16728, 16456, 16958, 17244, 17446, 17229, 17081, 16767, 16539, 16406, 16125, 15510, 14580, 13840, 12652, 11436, 10212, 9262, 7919, 6474, 4820, 3422, 2045, 615, -527, -1107, -2347, -3190, -4989, -6955, -8355, -10049, -11198, -12480, -13458, -14373, -15079, -15866, -16266, -16526, -16757, -17319, -17730, -18035, -19070, -20104, -21004, -21350, -22242, -22418, -22589, -22613, -22733, -23147, -23367, -23404, -24106, -23992, -24106, -24952, -26044, -27127, -27803, -28127, -28134, -28145, -28217, -28250, -28415, -28964, -29606, -30490, -30372, -31129, -31483, -31746, -32313, -32458, -32021, -32432, -32138, -32160, -32301, -32364, -32299, -32180, -31712, -31206, -30327, -29493, -29353, -29109, -28916, -28863, -28898, -28565, -27569, -26791, -25926, -25100, -24601, -24174, -23597, -22550, -21711, -20726, -20425, -20009, -19872, -20055, -19869, -19715, -19413, -19251, -19251, -19262, -19147, -18228, -17695, -16914, -16055, -15415, -14402, -13598, -12606, -11870, -11261, -10577, -9680, -8955, -8014, -6798, -5626, -4208, -3649, -3318, -2889, -1694, -249, 32471, 32318, 31903, 31788, 31895, 31371, 31621, 30870, 30714, 29494, 28076, 26688, 25841, 25240, 24649, 23113, 22703, 22534, 21485, 20620, 19729, 18228, 17632, 16360, 15283, 14717, 13319, 12163, 11202, 9525, 7948, 7246, 6082, 5717, 6109, 5805, 5917, 5986, 5958, 6002, 6087, 5528, 4586, 3867, 2259, 1175, 319, -585, -1092, -1543, -1813, -2057, -2849, -3301, -3540, -3745, -4706, -5959, -7282, -8784, -10022, -11679, -13049, -15091, -16750, -17509, -18239, -19221, -19712, -20438, -21320, -22498, -22733, -23331, -24112, -24936, -26602, -27504, -27990, -28789, -28900, -29315, -28813, -28686, -28993, -28714, -28468, -28881, -28271, -27693, -27631, -27655, -27694, -27383, -27401, -27525, -27257, -26729, -26850, -25742, -25498, -25469, -25005, -24750, -24265, -23856, -23917, -23834, -24703, -25205, -25560, -25911, -25673, -25881, -26165, -25930, -26795, -27158, -27775, -28001, -28390, -28299, -28158, -28409, -29036, -29161, -29433, -29924, -29400, -29995, -30551, -29852, -28483, -27351, -26118, -24900, -24527, -24196, -24062, -23887, -23399, -22881, -22527, -22269, -21252, -21495, -21585, -21457, -20668, -19578, -18198, -17371, -16154, -14669, -12824, -12065, -11232, -11564, -11817, -11481, -11315, -10937, -10271, -9229, -8538, -6969, -6385, -5410, -4676, -3997, -3299, -3104, -2941, -2475, -2537, -2427, -2500, -1519, -613, -54, 1078, 2061, 3273, 4348, 6238, 7855, 9224, 11062, 12596, 13245, 13973, 13995, 14751, 15755, 16541, 17633, 18432, 19868, 20823, 21280, 22275, 23125, 24019, 25242, 26186, 26594, 26839, 26899, 27549, 28425, 28790, 28079, 26533, 25863, 24580, 23815, 24411, 23892, 23977, 24082, 24135, 24609, 25357, 25131, 25719, 25322, 24989, 24123, 23918, 23858, 23979, 23849, 23800, 24432, 24819, 24843, 25251, 25453, 25758, 27375, 28514, 30160, 31134, 31784, 31492, 31277, 30584, 29848, 29302, 29518, 30266, 30969, 31583, 31932, 32475, 32383};