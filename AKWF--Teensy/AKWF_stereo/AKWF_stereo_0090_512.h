/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0090 512 samples */
 
const int16_t AKWF_stereo_0090_512_DATA [512] = 
{289, 1319, 2296, 3247, 4172, 5079, 5968, 6839, 7698, 8545, 9382, 10210, 11030, 11840, 12644, 13442, 14241, 15040, 15841, 16634, 17422, 18197, 18956, 19693, 20406, 21090, 21742, 22359, 22936, 23476, 23974, 24431, 24842, 25208, 25532, 25814, 26053, 26248, 26401, 26509, 26582, 26615, 26614, 26584, 26521, 26436, 26328, 26199, 26051, 25873, 25642, 25344, 24977, 24536, 24025, 23439, 22786, 22072, 21294, 20461, 19575, 18641, 17661, 16639, 15582, 14486, 13358, 12195, 11001, 9777, 8527, 7274, 6054, 4883, 3775, 2729, 1737, 803, -86, -935, -1752, -2543, -3314, -4072, -4822, -5569, -6313, -7063, -7814, -8570, -9334, -10101, -10872, -11663, -12477, -13317, -14186, -15070, -15971, -16882, -17787, -18687, -19571, -20434, -21269, -22073, -22836, -23560, -24239, -24867, -25449, -25980, -26462, -26896, -27283, -27622, -27908, -28148, -28343, -28492, -28601, -28675, -28716, -28732, -28720, -28691, -28645, -28584, -28518, -28444, -28368, -28293, -28220, -28153, -28088, -28028, -27974, -27931, -27896, -27876, -27863, -27864, -27876, -27895, -27926, -27966, -28013, -28068, -28129, -28205, -28309, -28442, -28602, -28785, -28990, -29214, -29444, -29681, -29921, -30155, -30384, -30599, -30800, -30986, -31155, -31306, -31433, -31543, -31633, -31702, -31747, -31758, -31720, -31629, -31484, -31291, -31056, -30783, -30482, -30158, -29819, -29470, -29120, -28768, -28422, -28087, -27765, -27458, -27169, -26899, -26646, -26410, -26193, -26003, -25840, -25708, -25604, -25525, -25475, -25444, -25434, -25441, -25461, -25492, -25532, -25577, -25628, -25680, -25729, -25776, -25822, -25864, -25903, -25939, -25965, -25988, -26004, -26008, -26002, -25988, -25962, -25928, -25886, -25835, -25775, -25711, -25634, -25541, -25414, -25222, -24962, -24626, -24214, -23722, -23156, -22517, -21808, -21034, -20196, -19302, -18352, -17353, -16303, -15212, -14075, -12900, -11692, -10440, -9156, -7865, -6584, -5336, -4125, -2956, -1830, -733, 1164, 2893, 4550, 6171, 7748, 9273, 10749, 12162, 13520, 14821, 16056, 17234, 18354, 19410, 20408, 21347, 22224, 23044, 23809, 24519, 25176, 25782, 26339, 26850, 27318, 27742, 28128, 28473, 28783, 29058, 29302, 29515, 29698, 29855, 29986, 30092, 30177, 30240, 30285, 30311, 30321, 30316, 30296, 30263, 30218, 30160, 30091, 30011, 29921, 29812, 29673, 29496, 29272, 28995, 28657, 28246, 27763, 27203, 26559, 25833, 25021, 24122, 23136, 22065, 20908, 19671, 18353, 16956, 15486, 13946, 12336, 10673, 8966, 7223, 5464, 3694, 1922, 168, -1569, -3279, -4949, -6583, -8170, -9702, -11184, -12607, -13969, -15274, -16519, -17701, -18824, -19887, -20889, -21832, -22713, -23534, -24301, -25008, -25663, -26267, -26821, -27330, -27796, -28221, -28609, -28960, -29278, -29563, -29816, -30038, -30234, -30406, -30559, -30696, -30818, -30927, -31023, -31107, -31183, -31247, -31304, -31352, -31395, -31433, -31464, -31493, -31517, -31539, -31559, -31578, -31602, -31627, -31650, -31673, -31695, -31715, -31732, -31751, -31766, -31782, -31799, -31817, -31834, -31852, -31871, -31890, -31910, -31930, -31949, -31968, -31985, -31999, -32009, -32015, -32019, -32021, -32021, -32019, -32018, -32015, -32012, -32011, -32010, -32011, -32015, -32020, -32024, -32032, -32041, -32051, -32063, -32081, -32102, -32129, -32162, -32201, -32241, -32285, -32331, -32377, -32423, -32467, -32510, -32549, -32586, -32621, -32656, -32689, -32718, -32742, -32758, -32766, -32767, -32760, -32745, -32725, -32694, -32658, -32617, -32568, -32515, -32454, -32390, -32320, -32248, -32170, -32089, -32002, -31907, -31806, -31705, -31599, -31494, -31390, -31283, -31177, -31072, -30964, -30854, -30744, -30629, -30514, -30397, -30278, -30157, -30032, -29904, -29770, -29616, -29430, -29206, -28934, -28603, -28206, -27741, -27198, -26575, -25870, -25080, -24205, -23245, -22197, -21062, -19849, -18550, -17176, -15731, -14207, -12616, -10969, -9272, -7546, -5799, -4041, -2290, -515};