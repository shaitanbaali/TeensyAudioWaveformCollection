/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0080 512 samples */
 
const int16_t AKWF_stereo_0080_512_DATA [512] = 
{357, 1281, 2194, 3115, 4038, 4946, 5840, 6730, 7634, 8545, 9457, 10370, 11276, 12170, 13057, 13940, 14798, 15630, 16438, 17222, 17989, 18741, 19471, 20188, 20887, 21565, 22228, 22866, 23483, 24077, 24640, 25145, 25600, 26038, 26468, 26866, 27222, 27550, 27861, 28148, 28407, 28639, 28836, 29004, 29144, 29257, 29344, 29402, 29430, 29430, 29400, 29343, 29261, 29149, 29013, 28851, 28663, 28449, 28209, 27942, 27646, 27310, 26929, 26506, 26055, 25579, 25076, 24541, 23981, 23399, 22796, 22166, 21510, 20822, 20096, 19316, 18500, 17667, 16815, 15948, 15071, 14191, 13309, 12431, 11552, 10669, 9781, 8886, 7987, 7087, 6181, 5274, 4364, 3454, 2556, 1667, 783, -86, -946, -1794, -2628, -3450, -4257, -5049, -5825, -6589, -7339, -8068, -8772, -9451, -10104, -10734, -11336, -11917, -12470, -13000, -13513, -14013, -14497, -14962, -15400, -15807, -16187, -16537, -16856, -17150, -17421, -17670, -17892, -18087, -18260, -18420, -18565, -18679, -18769, -18842, -18895, -18923, -18934, -18927, -18893, -18835, -18757, -18655, -18539, -18406, -18263, -18103, -17920, -17717, -17497, -17258, -17001, -16734, -16452, -16151, -15835, -15505, -15171, -14828, -14471, -14138, -13872, -13638, -13391, -13123, -12850, -12571, -12282, -11987, -11694, -11399, -11122, -10876, -10651, -10431, -10207, -9978, -9743, -9498, -9244, -8979, -8709, -8434, -8160, -7886, -7632, -7486, -7472, -7501, -7521, -7595, -7765, -7976, -8176, -8379, -8598, -8823, -9063, -9332, -9623, -9921, -10220, -10530, -10849, -11172, -11497, -11819, -12132, -12440, -12741, -13031, -13312, -13581, -13835, -14078, -14307, -14525, -14735, -14924, -15092, -15234, -15351, -15444, -15512, -15549, -15560, -15541, -15490, -15407, -15289, -15145, -14964, -14745, -14486, -14188, -13849, -13460, -13012, -12506, -11945, -11334, -10691, -10023, -9332, -8619, -7892, -7149, -6389, -5611, -4806, -3984, -3144, -2289, -1419, -518, 1097, 2127, 3140, 4160, 5179, 6195, 7211, 8223, 9234, 10239, 11238, 12229, 13211, 14179, 15137, 16085, 17015, 17927, 18816, 19680, 20522, 21339, 22129, 22893, 23634, 24347, 25038, 25704, 26346, 26962, 27553, 28116, 28655, 29166, 29648, 30105, 30530, 30917, 31267, 31580, 31857, 32094, 32289, 32452, 32584, 32679, 32742, 32767, 32755, 32708, 32623, 32504, 32354, 32166, 31949, 31701, 31424, 31117, 30778, 30412, 30014, 29581, 29105, 28590, 28039, 27457, 26842, 26190, 25509, 24808, 24088, 23342, 22564, 21755, 20914, 20027, 19104, 18157, 17182, 16184, 15171, 14148, 13122, 12095, 11066, 10036, 9010, 7985, 6965, 5955, 4951, 3954, 2963, 1976, 1003, 44, -905, -1838, -2755, -3654, -4535, -5399, -6242, -7064, -7866, -8643, -9397, -10128, -10836, -11517, -12173, -12805, -13406, -13982, -14530, -15052, -15549, -16025, -16479, -16912, -17320, -17704, -18064, -18397, -18701, -18979, -19234, -19465, -19670, -19848, -20001, -20126, -20226, -20302, -20354, -20382, -20387, -20369, -20334, -20283, -20205, -20104, -19985, -19842, -19679, -19503, -19312, -19104, -18876, -18631, -18369, -18091, -17794, -17485, -17158, -16817, -16461, -16092, -15715, -15329, -14929, -14540, -14198, -13880, -13564, -13248, -12942, -12643, -12339, -12030, -11720, -11412, -11123, -10860, -10617, -10378, -10145, -9917, -9693, -9469, -9242, -9012, -8782, -8547, -8314, -8081, -7858, -7712, -7664, -7658, -7668, -7746, -7921, -8145, -8378, -8630, -8911, -9213, -9540, -9896, -10272, -10657, -11052, -11461, -11884, -12311, -12737, -13159, -13573, -13979, -14376, -14761, -15132, -15481, -15808, -16114, -16395, -16653, -16892, -17101, -17280, -17432, -17550, -17638, -17694, -17710, -17693, -17639, -17546, -17415, -17242, -17032, -16779, -16485, -16148, -15769, -15343, -14867, -14332, -13740, -13092, -12391, -11648, -10869, -10055, -9215, -8355, -7478, -6585, -5677, -4746, -3801, -2844, -1872, -890, 119};