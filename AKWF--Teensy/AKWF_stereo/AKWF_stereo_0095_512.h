/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0095 512 samples */
 
const int16_t AKWF_stereo_0095_512_DATA [512] = 
{417, 1433, 2393, 3286, 4101, 4805, 5396, 5851, 6169, 6356, 6408, 6344, 6185, 5946, 5653, 5334, 5028, 4758, 4554, 4449, 4472, 4639, 4972, 5484, 6179, 7057, 8113, 9337, 10707, 12202, 13787, 15438, 17118, 18787, 20411, 21961, 23395, 24686, 25815, 26754, 27495, 28030, 28353, 28476, 28411, 28167, 27775, 27258, 26648, 25976, 25271, 24571, 23897, 23289, 22765, 22338, 22032, 21848, 21788, 21850, 22026, 22301, 22652, 23051, 23477, 23903, 24292, 24624, 24864, 24988, 24979, 24815, 24489, 23991, 23323, 22486, 21495, 20371, 19125, 17785, 16386, 14947, 13503, 12089, 10723, 9440, 8259, 7197, 6271, 5491, 4849, 4352, 3994, 3753, 3621, 3567, 3576, 3618, 3667, 3699, 3690, 3617, 3457, 3202, 2843, 2366, 1784, 1092, 301, -566, -1502, -2482, -3478, -4470, -5432, -6344, -7173, -7912, -8539, -9047, -9425, -9677, -9805, -9814, -9728, -9557, -9328, -9061, -8784, -8529, -8317, -8177, -8129, -8192, -8383, -8710, -9182, -9793, -10536, -11401, -12371, -13415, -14518, -15644, -16755, -17834, -18836, -19734, -20505, -21122, -21560, -21812, -21872, -21727, -21393, -20879, -20195, -19372, -18435, -17415, -16337, -15247, -14174, -13152, -12217, -11389, -10700, -10164, -9792, -9597, -9573, -9718, -10017, -10450, -10999, -11637, -12329, -13045, -13755, -14425, -15024, -15526, -15912, -16154, -16246, -16179, -15951, -15565, -15036, -14376, -13612, -12766, -11860, -10934, -10012, -9128, -8308, -7582, -6972, -6496, -6162, -5984, -5966, -6097, -6371, -6773, -7279, -7873, -8525, -9206, -9886, -10541, -11138, -11654, -12070, -12368, -12528, -12552, -12428, -12173, -11784, -11277, -10674, -9990, -9255, -8494, -7727, -6983, -6290, -5664, -5125, -4691, -4369, -4163, -4071, -4091, -4212, -4415, -4686, -4999, -5333, -5659, -5956, -6199, -6360, -6428, -6378, -6208, -5902, -5465, -4895, -4208, -3414, -2529, -1581, -567, -2297, -1913, -1497, -1043, -554, -35, 513, 1081, 1669, 2271, 2880, 3492, 4106, 4715, 5320, 5919, 6513, 7102, 7692, 8281, 8881, 9491, 10118, 10771, 11454, 12172, 12933, 13735, 14587, 15489, 16438, 17433, 18474, 19550, 20654, 21783, 22918, 24051, 25171, 26257, 27302, 28291, 29206, 30041, 30777, 31408, 31926, 32323, 32595, 32741, 32761, 32658, 32437, 32105, 31671, 31146, 30541, 29869, 29143, 28375, 27579, 26766, 25949, 25138, 24336, 23558, 22806, 22079, 21384, 20717, 20076, 19459, 18861, 18276, 17698, 17120, 16535, 15941, 15326, 14689, 14029, 13337, 12616, 11867, 11090, 10287, 9465, 8625, 7775, 6925, 6073, 5236, 4414, 3614, 2842, 2106, 1403, 740, 118, -467, -1013, -1524, -2005, -2455, -2888, -3302, -3707, -4109, -4511, -4920, -5338, -5772, -6222, -6690, -7175, -7677, -8194, -8722, -9256, -9794, -10330, -10855, -11369, -11862, -12330, -12770, -13178, -13551, -13887, -14185, -14448, -14676, -14871, -15037, -15179, -15300, -15406, -15502, -15591, -15679, -15768, -15862, -15959, -16065, -16174, -16285, -16397, -16502, -16597, -16674, -16728, -16751, -16735, -16676, -16565, -16396, -16168, -15878, -15522, -15104, -14624, -14089, -13505, -12876, -12216, -11534, -10840, -10153, -9479, -8834, -8232, -7680, -7195, -6783, -6450, -6204, -6049, -5985, -6011, -6124, -6319, -6588, -6925, -7315, -7749, -8214, -8699, -9189, -9672, -10138, -10574, -10972, -11326, -11628, -11875, -12064, -12196, -12271, -12294, -12270, -12202, -12099, -11969, -11819, -11658, -11493, -11329, -11175, -11035, -10913, -10810, -10728, -10668, -10627, -10604, -10593, -10590, -10589, -10585, -10573, -10548, -10501, -10431, -10333, -10204, -10043, -9848, -9621, -9364, -9079, -8769, -8443, -8101, -7752, -7402, -7054, -6715, -6392, -6086, -5800, -5538, -5300, -5084, -4891, -4718, -4557, -4411, -4269, -4127, -3977, -3817, -3637, -3432, -3200, -2936, -2627};