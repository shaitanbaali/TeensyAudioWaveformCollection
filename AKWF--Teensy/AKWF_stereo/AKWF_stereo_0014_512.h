/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0014 512 samples */
 
const int16_t AKWF_stereo_0014_512_DATA [512] = 
{375, 1069, 1752, 2443, 3143, 3846, 4554, 5267, 5972, 6660, 7342, 7996, 8636, 9302, 9969, 10634, 11293, 11945, 12592, 13236, 13875, 14511, 15144, 15792, 16369, 16963, 17589, 18234, 18795, 19387, 19995, 20591, 21184, 21772, 22351, 22928, 23504, 23968, 24497, 25044, 25578, 26105, 26623, 27136, 27643, 28139, 28631, 29116, 29596, 30056, 30399, 30851, 31201, 32191, 22538, 17443, 16014, 13934, 13774, 14220, 14697, 15692, 16152, 16916, 17465, 17969, 18421, 18683, 18963, 19060, 19143, 19120, 19029, 18896, 18682, 18369, 18068, 17769, 17429, 17096, 16755, 16382, 16016, 15647, 15289, 14937, 14603, 14268, 13894, 13610, 13346, 13105, 12886, 12692, 12523, 12375, 12254, 12157, 12083, 12041, 11993, 11950, 11981, 12028, 12097, 12191, 12053, 13375, -47, -6039, -9530, -12339, -13100, -13572, -13586, -12930, -12685, -11775, -11220, -10457, -9776, -9252, -8671, -8357, -8013, -7878, -7746, -7735, -7877, -8056, -8344, -8639, -9002, -9391, -9797, -10219, -10647, -11096, -11536, -11881, -12267, -12635, -12968, -13265, -13522, -13737, -13910, -14045, -14139, -14191, -14209, -14173, -14029, -13931, -13801, -13641, -13447, -13228, -12983, -12711, -12418, -12100, -11760, -11407, -10994, -10533, -10129, -9703, -9259, -8805, -8337, -7855, -7359, -6852, -6334, -5802, -5266, -4678, -4084, -3526, -3065, -1821, -12429, -17812, -18981, -20879, -21014, -20548, -20031, -19001, -18301, -17339, -16673, -16010, -15384, -14937, -14461, -14161, -13867, -13677, -13548, -13461, -13445, -13367, -13413, -13489, -13588, -13707, -13830, -13965, -14090, -14222, -14342, -14452, -14556, -14591, -14613, -14668, -14694, -14700, -14683, -14645, -14585, -14498, -14392, -14264, -14111, -13937, -13686, -13446, -13210, -12949, -12647, -12332, -11988, -11595, -11183, -10757, -10309, -9843, -9358, -8818, -8302, -7782, -7245, -6673, -6082, -5480, -4857, -4228, -3593, -2950, -2303, -1638, -968, -290, 9078, 9656, 10222, 10793, 11368, 11942, 12516, 13096, 13658, 14201, 14771, 15324, 15850, 16404, 16949, 17486, 18011, 18529, 19039, 19545, 20037, 20523, 21005, 21492, 21888, 22306, 22762, 23226, 23589, 23995, 24419, 24830, 25237, 25635, 26022, 26407, 26787, 27024, 27353, 27704, 28040, 28366, 28684, 28998, 29303, 29595, 29886, 30169, 30445, 30694, 30791, 31036, 31175, 32099, 18893, 19061, 23240, 18541, 16713, 15921, 14767, 15342, 14380, 14642, 14296, 14177, 14186, 13858, 13913, 13600, 13517, 13289, 13053, 12859, 12543, 12207, 11870, 11592, 11260, 10948, 10656, 10308, 9985, 9643, 9316, 8983, 8660, 8326, 7922, 7623, 7331, 7049, 6781, 6524, 6284, 6050, 5837, 5640, 5453, 5293, 5112, 4923, 4817, 4716, 4635, 4575, 4258, 5605, -10726, -9551, -7847, -14501, -15851, -17680, -19073, -18592, -19975, -19365, -19942, -19718, -19589, -19668, -19258, -19358, -19018, -19002, -18798, -18638, -18634, -18527, -18576, -18517, -18547, -18570, -18591, -18648, -18689, -18777, -18835, -18802, -18846, -18890, -18926, -18943, -18942, -18919, -18879, -18819, -18734, -18628, -18502, -18330, -18053, -17851, -17629, -17387, -17117, -16831, -16525, -16192, -15848, -15477, -15085, -14686, -14218, -13693, -13242, -12763, -12267, -11761, -11236, -10694, -10136, -9566, -8983, -8382, -7776, -7106, -6426, -5789, -5251, -3810, -17178, -16861, -12233, -16598, -17911, -18173, -18786, -17705, -17919, -17039, -16834, -16385, -15808, -15556, -14931, -14657, -14156, -13797, -13436, -13040, -12744, -12272, -11974, -11658, -11367, -11090, -10797, -10534, -10245, -9987, -9712, -9435, -9167, -8822, -8485, -8205, -7908, -7605, -7297, -6982, -6657, -6322, -5986, -5640, -5279, -4914, -4472, -4065, -3678, -3279, -2875, -2496, -2114, -1693, -1266, -836, -388, 66, 532, 1055, 1537, 2014, 2504, 3025, 3547, 4065, 4608, 5148, 5692, 6247, 6800, 7369, 7943, 8513};