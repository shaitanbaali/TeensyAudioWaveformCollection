/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0148 512 samples */
 
const int16_t AKWF_stereo_0148_512_DATA [512] = 
{26282, 30591, 29390, 29292, 29032, 28774, 28507, 28320, 28054, 27788, 27522, 27256, 26989, 26721, 26458, 26193, 25930, 25670, 25411, 25153, 24896, 24643, 24390, 24138, 23889, 23642, 23396, 23151, 22912, 22670, 22431, 22195, 21959, 21725, 21493, 21265, 21037, 20811, 20586, 20365, 20143, 19924, 19709, 19494, 19281, 19070, 18861, 18652, 18448, 18244, 18041, 17841, 17645, 17448, 17253, 17061, 16869, 16680, 16495, 16310, 16127, 15945, 15766, 15589, 15413, 15241, 15070, 14899, 14732, 14567, 14402, 14240, 14081, 13923, 13767, 13614, 13463, 13312, 13164, 13019, 12875, 12731, 12593, 12456, 12318, 12185, 12054, 11923, 11795, 11672, 11547, 11425, 11305, 11189, 11074, 10959, 10849, 10739, 10630, 10523, 10416, 10309, 10201, 10096, 9990, 9884, 9779, 9675, 9570, 9466, 9362, 9257, 9154, 9052, 8949, 8845, 8743, 8640, 8535, 8434, 8331, 8229, 8125, 8024, 7922, 7818, 7716, 7615, 7510, 7407, 7304, 7201, 7097, 6993, 6891, 6789, 6683, 6572, 6340, 6899, 852, -14508, -15894, -13817, -14475, -14412, -14301, -14303, -14274, -14255, -14244, -14237, -14238, -14243, -14251, -14267, -14288, -14313, -14341, -14375, -14413, -14456, -14501, -14553, -14605, -14662, -14724, -14788, -14855, -14925, -15000, -15077, -15156, -15240, -15324, -15411, -15502, -15595, -15688, -15783, -15879, -15975, -16072, -16172, -16272, -16373, -16476, -16579, -16682, -16788, -16894, -17002, -17110, -17220, -17330, -17441, -17553, -17667, -17781, -17895, -18011, -18128, -18245, -18363, -18483, -18602, -18724, -18847, -18969, -19091, -19216, -19342, -19467, -19594, -19721, -19849, -19977, -20108, -20239, -20369, -20502, -20635, -20768, -20901, -21037, -21171, -21307, -21444, -21582, -21719, -21859, -21998, -22137, -22279, -22420, -22562, -22704, -22846, -22991, -23135, -23279, -23425, -23571, -23716, -23863, -24011, -24158, -24307, -24455, -24593, -24762, -24903, -25052, -25063, -26011, -22435, 15334, 17872, 17193, 17159, 17029, 16896, 16757, 16665, 16526, 16381, 16239, 16093, 15944, 15794, 15650, 15505, 15361, 15225, 15090, 14956, 14824, 14700, 14574, 14452, 14335, 14223, 14109, 14000, 13897, 13793, 13693, 13600, 13508, 13416, 13331, 13251, 13170, 13095, 13025, 12957, 12890, 12828, 12773, 12714, 12663, 12617, 12574, 12529, 12496, 12462, 12428, 12402, 12383, 12360, 12341, 12332, 12322, 12315, 12315, 12316, 12320, 12329, 12341, 12356, 12375, 12400, 12429, 12458, 12491, 12531, 12571, 12616, 12667, 12721, 12775, 12837, 12902, 12968, 13040, 13119, 13197, 13279, 13367, 13460, 13553, 13653, 13757, 13863, 13973, 14090, 14209, 14329, 14458, 14591, 14725, 14862, 15007, 15153, 15299, 15448, 15599, 15747, 15894, 16047, 16195, 16342, 16494, 16645, 16793, 16942, 17094, 17240, 17388, 17538, 17687, 17832, 17979, 18126, 18271, 18417, 18563, 18707, 18847, 18992, 19135, 19273, 19413, 19555, 19692, 19827, 19964, 20100, 20232, 20365, 20499, 20630, 20758, 20872, 20699, 22375, 8637, -26829, -29691, -24482, -25652, -25136, -24511, -24153, -23722, -23315, -22929, -22551, -22190, -21842, -21504, -21181, -20872, -20572, -20282, -20006, -19740, -19483, -19235, -19002, -18774, -18556, -18348, -18148, -17954, -17770, -17596, -17426, -17266, -17114, -16965, -16824, -16692, -16563, -16437, -16317, -16201, -16085, -15971, -15865, -15760, -15657, -15558, -15464, -15369, -15278, -15193, -15110, -15026, -14951, -14875, -14802, -14733, -14668, -14604, -14541, -14485, -14429, -14375, -14325, -14279, -14232, -14191, -14152, -14115, -14079, -14047, -14020, -13990, -13965, -13946, -13924, -13906, -13892, -13879, -13867, -13861, -13856, -13851, -13849, -13851, -13855, -13858, -13867, -13877, -13889, -13902, -13919, -13937, -13955, -13978, -14003, -14029, -14056, -14088, -14120, -14151, -14190, -14227, -14264, -14307, -14351, -14394, -14441, -14489, -14533, -14595, -14644, -14699, -14673, -15197, -13085};