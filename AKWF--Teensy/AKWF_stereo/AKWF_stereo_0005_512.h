/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0005 512 samples */
 
const int16_t AKWF_stereo_0005_512_DATA [512] = 
{1915, 4431, 6517, 8275, 9770, 11067, 12239, 13361, 14468, 15581, 16684, 18185, 19839, 21452, 22993, 24338, 25565, 26676, 27664, 28519, 29256, 29884, 30417, 30869, 31251, 31568, 31829, 32040, 32210, 32341, 32443, 32516, 32566, 32594, 32600, 32587, 32555, 32510, 32454, 32390, 32323, 32255, 32192, 32139, 32097, 32069, 32052, 32042, 32028, 31997, 31937, 31838, 31694, 31503, 31260, 30961, 30598, 30164, 29644, 29028, 28307, 27473, 26533, 25489, 24334, 23044, 21725, 20308, 18889, 17418, 15898, 14369, 12842, 11360, 9963, 8718, 7688, 6958, 6561, 6517, 6785, 7322, 8065, 8966, 10109, 10706, 10609, 10705, 11154, 12586, 14185, 15873, 17369, 18815, 20242, 21614, 22879, 23983, 24911, 25652, 26220, 26625, 26889, 27019, 27026, 26915, 26700, 26395, 26011, 25566, 25081, 24557, 23988, 23334, 22559, 21632, 20530, 19236, 17748, 16061, 14194, 12155, 10139, 8692, 7365, 6378, 5471, 4736, 4311, 4219, 4427, 4908, 5660, 6673, 7932, 9384, 10975, 12616, 14249, 15816, 17376, 18112, 18964, 19647, 20407, 20966, 21295, 21301, 21065, 20593, 19858, 18826, 17467, 15725, 13535, 10944, 7542, 1999, -3869, -9122, -12953, -15902, -18324, -20347, -22032, -23440, -24622, -25620, -26477, -27216, -27855, -28407, -28878, -29269, -29587, -29842, -30054, -30238, -30273, -30360, -30421, -30540, -30713, -30977, -31229, -31504, -31697, -31759, -31910, -32029, -32181, -32321, -32423, -32509, -32582, -32642, -32693, -32729, -32754, -32767, -32765, -32753, -32729, -32694, -32646, -32581, -32520, -32454, -32374, -32281, -32168, -32042, -31904, -31750, -31578, -31383, -31155, -30973, -30780, -30500, -30210, -29846, -29498, -29165, -28844, -28539, -28253, -27994, -27765, -27563, -27381, -27211, -27047, -26883, -26712, -26520, -26294, -26016, -25663, -25223, -24690, -24054, -23321, -22485, -21533, -20461, -19257, -17899, -16399, -14738, -12906, -10902, -8707, -6299, -3698, -832, 15875, 17940, 19439, 20534, 21312, 21843, 22201, 22451, 22637, 22801, 22962, 23431, 24084, 24809, 25578, 26289, 26999, 27703, 28381, 29012, 29588, 30105, 30564, 30966, 31314, 31606, 31847, 32038, 32185, 32290, 32360, 32393, 32394, 32364, 32301, 32208, 32081, 31928, 31749, 31553, 31349, 31149, 30964, 30807, 30689, 30609, 30569, 30557, 30552, 30535, 30487, 30395, 30258, 30071, 29839, 29561, 29238, 28862, 28419, 27901, 27292, 26588, 25794, 24905, 23907, 22764, 21580, 20268, 18907, 17413, 15754, 13934, 11923, 9750, 7454, 5130, 2875, 838, -869, -2091, -2876, -3253, -3262, -2914, -2041, -1670, -2053, -1980, -1167, 1373, 4378, 7571, 10485, 13273, 15929, 18367, 20517, 22316, 23767, 24880, 25699, 26256, 26592, 26723, 26671, 26435, 26038, 25485, 24788, 23964, 23037, 22008, 20881, 19604, 18131, 16422, 14439, 12163, 9600, 6755, 3684, 422, -2484, -4167, -5451, -6177, -6698, -6963, -6874, -6431, -5653, -4536, -3024, -1038, 1426, 4072, 6757, 9367, 11821, 14077, 16135, 17808, 19320, 20649, 21834, 22838, 23642, 24241, 24655, 24898, 24978, 24893, 24642, 24208, 23577, 22778, 21624, 19581, 17226, 14274, 11261, 8143, 4718, 869, -3086, -6603, -9714, -12489, -14981, -17204, -19187, -20927, -22432, -23697, -24738, -25583, -26269, -26831, -27055, -27307, -27456, -27655, -27908, -28292, -28640, -29025, -29262, -29249, -29418, -29533, -29738, -29941, -30083, -30209, -30324, -30428, -30520, -30595, -30654, -30693, -30717, -30724, -30716, -30699, -30671, -30592, -30862, -31300, -31640, -31945, -32118, -32268, -32417, -32546, -32642, -32705, -32729, -32754, -32756, -32705, -32637, -32526, -32409, -32287, -32158, -32025, -31890, -31757, -31629, -31505, -31382, -31259, -31130, -30992, -30842, -30671, -30466, -30217, -29902, -29504, -29007, -28378, -27591, -26612, -25387, -23869, -22005, -19701, -16915, -13557, -9544, -4812, 660, 5837, 9970, 13328};