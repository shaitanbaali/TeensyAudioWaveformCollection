/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0176 512 samples */
 
const int16_t AKWF_stereo_0176_512_DATA [512] = 
{689, 2278, 3797, 5194, 6160, 7523, 8763, 9909, 10988, 12016, 13003, 13966, 14897, 15783, 16641, 17466, 18239, 18956, 19615, 20177, 20595, 20866, 20970, 20886, 20657, 20338, 19945, 19500, 19057, 18592, 18080, 17553, 17026, 16490, 16001, 15572, 15180, 14802, 14427, 14003, 13514, 12996, 12453, 11880, 11296, 10700, 10076, 9419, 8748, 8054, 7339, 6640, 5969, 5318, 4695, 4111, 3559, 3034, 2546, 2098, 1679, 1298, 931, 581, 245, -109, -520, -1014, -1594, -2268, -3027, -3856, -4744, -5675, -6615, -7550, -8451, -9283, -10051, -10759, -11415, -12037, -12636, -13185, -13650, -14016, -14259, -14363, -14351, -14266, -14119, -13879, -13584, -13232, -12825, -12412, -12032, -11701, -11460, -11288, -11132, -10939, -10684, -10324, -9812, -9147, -8343, -7388, -6287, -5068, -3723, -2269, -757, 826, 2253, 3686, 5174, 6500, 7688, 8739, 9660, 10450, 11135, 11710, 12178, 12546, 12828, 13030, 13164, 13272, 13355, 13405, 13419, 13407, 13351, 13242, 13098, 12901, 12624, 12270, 11810, 11203, 10423, 9465, 8301, 6908, 5315, 3528, 1535, -610, -2871, -5223, -7595, -9930, -12201, -14354, -16373, -18261, -19998, -21579, -22977, -24211, -25301, -26308, -27191, -27958, -28676, -29357, -29987, -30577, -31138, -31630, -32029, -32372, -32630, -32757, -32750, -32563, -32092, -31356, -30339, -29015, -27398, -25556, -23496, -21222, -18816, -16326, -13768, -11215, -8769, -6399, -4643, -2421, -249, 1737, 3604, 5368, 7045, 8628, 10134, 11590, 13003, 14390, 15746, 17031, 18221, 19282, 20189, 20901, 21384, 21630, 21630, 21396, 20970, 20364, 19582, 18668, 17605, 16386, 15057, 13643, 12132, 10581, 9002, 7381, 5714, 4029, 2348, 702, -835, -2222, -3459, -4550, -5515, -6391, -7185, -7892, -8512, -9029, -9453, -9806, -10100, -10318, -10447, -10438, -10252, -9882, -9312, -8545, -7590, -6483, -5243, -3870, -2401, -841, 15669, 14775, 13821, 12723, 11453, 10064, 8494, 6804, 5040, 3229, 1401, -419, -2241, -4056, -5845, -7576, -9218, -10762, -12200, -13543, -14812, -16041, -17213, -18291, -19259, -20103, -20807, -21366, -21828, -22223, -22561, -22892, -23229, -23528, -23800, -24017, -24125, -24118, -23997, -23731, -23295, -22721, -21979, -21020, -19851, -18515, -17019, -15415, -13801, -12201, -10628, -9063, -7878, -6280, -4575, -2922, -1315, 204, 1619, 2930, 4167, 5365, 6536, 7694, 8815, 9859, 10793, 11593, 12247, 12775, 13226, 13605, 13940, 14222, 14438, 14602, 14700, 14717, 14672, 14572, 14387, 14108, 13778, 13360, 12828, 12214, 11528, 10782, 10031, 9323, 8664, 8053, 7493, 6938, 6347, 5711, 5022, 4280, 3498, 2710, 1921, 1137, 382, -330, -983, -1553, -2020, -2386, -2660, -2866, -2984, -3033, -3023, -2960, -2864, -2714, -2504, -2267, -2013, -1773, -1576, -1446, -1400, -1443, -1561, -1729, -1931, -2141, -2341, -2539, -2703, -2791, -2821, -2747, -2535, -2201, -1780, -1317, -865, -469, -164, 26, 102, 52, -145, -521, -1091, -1857, -2806, -3901, -5105, -6371, -7660, -8945, -10216, -11475, -12725, -13922, -15026, -16034, -16911, -17641, -18229, -18722, -19110, -19420, -19728, -20069, -20451, -20894, -21433, -22058, -22730, -23493, -24330, -25181, -26009, -26756, -27298, -27613, -27680, -27471, -26999, -26340, -25512, -24500, -23363, -22120, -20756, -19300, -17828, -16309, -15228, -13655, -12043, -10511, -9050, -7662, -6327, -5053, -3846, -2656, -1447, -189, 1161, 2619, 4201, 5883, 7667, 9531, 11400, 13230, 14982, 16625, 18134, 19494, 20679, 21748, 22474, 23060, 23819, 24437, 24974, 25469, 25940, 26360, 26735, 27104, 27450, 27767, 28101, 28433, 28714, 28937, 29099, 29158, 29097, 28974, 28768, 28445, 28043, 27565, 26974, 26274, 25527, 24730, 23877, 23034, 22210, 21377, 20549, 19759, 18963, 18141, 17337, 16506};