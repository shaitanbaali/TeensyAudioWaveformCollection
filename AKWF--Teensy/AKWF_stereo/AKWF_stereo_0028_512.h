/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0028 512 samples */
 
const int16_t AKWF_stereo_0028_512_DATA [512] = 
{464, 2031, 3541, 4987, 6322, 7536, 8694, 9874, 11158, 12646, 14382, 16295, 18228, 20064, 21777, 23341, 24728, 25934, 26951, 27753, 28374, 29022, 29789, 30625, 31448, 32128, 32576, 32759, 32736, 32579, 32312, 31998, 31650, 31318, 31100, 31044, 31100, 31134, 31097, 30935, 30642, 30271, 29846, 29344, 28701, 27862, 26871, 25855, 24903, 24034, 23264, 22637, 22209, 22022, 22052, 22169, 22315, 22504, 22691, 22806, 22784, 22624, 22349, 21981, 21574, 21208, 20941, 20800, 20738, 20647, 20453, 20112, 19552, 18717, 17646, 16485, 15434, 14628, 14078, 13768, 13671, 13780, 14058, 14438, 14872, 15345, 15825, 16231, 16433, 16321, 15891, 15241, 14507, 13850, 13437, 13355, 13548, 13847, 14031, 13908, 13381, 12459, 11289, 10061, 8945, 8029, 7296, 6703, 6275, 6063, 6082, 6313, 6771, 7490, 8430, 9471, 10492, 11395, 12145, 12757, 13228, 13547, 13716, 13734, 13573, 13203, 12628, 11889, 11081, 10311, 9633, 9064, 8605, 8219, 7822, 7327, 6699, 5939, 5052, 4047, 2955, 1841, 794, -121, -923, -1706, -2548, -3521, -4720, -6179, -7906, -9867, -11942, -14014, -15995, -17788, -19329, -20592, -21546, -22186, -22763, -23519, -24423, -25414, -26396, -27239, -27855, -28263, -28549, -28803, -29108, -29461, -29732, -29833, -29720, -29368, -28793, -28115, -27552, -27311, -27506, -27982, -28306, -28349, -28195, -27930, -27640, -27389, -27187, -26981, -26720, -26404, -26077, -25814, -25693, -25780, -26147, -26826, -27730, -28678, -29490, -30038, -30271, -30241, -30062, -29876, -29800, -29858, -29980, -30084, -30137, -30119, -29986, -29726, -29358, -28888, -28286, -27499, -26519, -25453, -24490, -23775, -23347, -23144, -23188, -23410, -23670, -23815, -23735, -23446, -23040, -22592, -22188, -21908, -21704, -21552, -21416, -21240, -20954, -20518, -19932, -19181, -18288, -17361, -16405, -15380, -14211, -12867, -11365, -9788, -8221, -6709, -5262, -3861, -2474, -1008, 23733, 24435, 25091, 25835, 26589, 27075, 26992, 26202, 24775, 22954, 21110, 19637, 18801, 18652, 18995, 19475, 19756, 19671, 19182, 18342, 17361, 16514, 15990, 15778, 15709, 15505, 14961, 14078, 12981, 11795, 10692, 9836, 9177, 8554, 7865, 7086, 6333, 5799, 5604, 5690, 5929, 6135, 6084, 5634, 4726, 3429, 1989, 674, -394, -1253, -1982, -2633, -3254, -3888, -4514, -5109, -5646, -6082, -6425, -6661, -6707, -6463, -5903, -5025, -3890, -2669, -1533, -614, -4, 321, 488, 662, 969, 1426, 1995, 2618, 3212, 3817, 4743, 6122, 7837, 9685, 11385, 12695, 13417, 13387, 12653, 11468, 10183, 9066, 8172, 7400, 6561, 5539, 4346, 3029, 1672, 407, -674, -1692, -2877, -4283, -5879, -7574, -9266, -10868, -12279, -13460, -14462, -15386, -16382, -17589, -19083, -20883, -22991, -25341, -27723, -29854, -31484, -32443, -32767, -32696, -32469, -32269, -32171, -32119, -32013, -31780, -31414, -30869, -30090, -29130, -28095, -27030, -25888, -24553, -22972, -21291, -19748, -18506, -17636, -17154, -16954, -16795, -16438, -15747, -14734, -13497, -12154, -10827, -9656, -8766, -8148, -7676, -7197, -6630, -5955, -5171, -4252, -3126, -1774, -307, 1179, 2676, 4167, 5596, 6876, 7916, 8726, 9412, 10149, 11141, 12495, 14087, 15677, 17055, 18112, 18870, 19356, 19565, 19482, 19062, 18315, 17390, 16447, 15576, 14862, 14413, 14265, 14320, 14393, 14356, 14149, 13751, 13134, 12192, 10944, 9489, 7803, 5782, 3378, 652, -2227, -5050, -7650, -9957, -11984, -13732, -15227, -16526, -17694, -18769, -19699, -20388, -20704, -20571, -20078, -19456, -19015, -18967, -19214, -19451, -19440, -19068, -18371, -17473, -16534, -15671, -14846, -13819, -12380, -10428, -7928, -5010, -1885, 1207, 3973, 6231, 8080, 9800, 11691, 13904, 16099, 17782, 19078, 19813, 19818, 19132, 18183, 17528, 17564, 18301, 19459, 20726, 21900, 22929};