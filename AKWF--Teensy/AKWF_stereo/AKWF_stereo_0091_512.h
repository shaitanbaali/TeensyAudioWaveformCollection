/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0091 512 samples */
 
const int16_t AKWF_stereo_0091_512_DATA [512] = 
{3071, 4235, 3781, 3825, 4147, 4669, 5326, 6060, 6822, 7574, 8291, 8984, 9616, 10214, 10781, 11299, 11762, 12168, 12516, 12814, 13063, 13283, 13340, 13888, 15750, 13922, 13954, 14171, 14194, 14104, 13936, 13721, 13474, 13213, 12948, 12685, 12432, 12190, 11961, 11751, 11553, 11407, 11110, 10852, 10980, 10853, 10764, 10713, 10691, 10699, 10727, 10776, 10837, 10443, 13471, -5668, -9370, 6340, 1440, -1121, -2915, -4033, -4593, -4708, -4519, -4195, -3905, -3619, -3530, -3554, -3503, -3470, -3476, -3560, -3748, -4031, -4381, -4760, -4993, -6582, 8398, 96, -6002, -3600, -3254, -3551, -4325, -5338, -6475, -7646, -8784, -9843, -10800, -11650, -12389, -13023, -13569, -13945, -14546, -16688, -15241, -15160, -15501, -15589, -15542, -15396, -15182, -14920, -14629, -14327, -14016, -13704, -13409, -13116, -12857, -12549, -11292, -12192, -12312, -11959, -11697, -11498, -11457, -11082, -10603, -11305, -11220, -11172, -11177, -11223, -11300, -11403, -11523, -11653, -11791, -11932, -12070, -12202, -12328, -12446, -12555, -12641, -12803, -12891, -12879, -12949, -12996, -13024, -13036, -13032, -13017, -12990, -12959, -13124, -11675, -25704, -21035, -13513, -16479, -17384, -17606, -17324, -16750, -16031, -15264, -14504, -13789, -13099, -12529, -12032, -11584, -11209, -10899, -10647, -10448, -10294, -10182, -10090, -10117, -9889, -4260, -8567, -9458, -8616, -8387, -8407, -8601, -8882, -9213, -9557, -9891, -11219, -10603, -10403, -10842, -11182, -11456, -11594, -11956, -12604, -12014, -12120, -12271, -12362, -12417, -12443, -12447, -12433, -12409, -12378, -12341, -12303, -12269, -12236, -12204, -12174, -12147, -12122, -12100, -12081, -12064, -12043, -12066, -11873, -11787, -12009, -11952, -11930, -11924, -11930, -11943, -11962, -11983, -12005, -11499, -14731, 7717, 6396, -7167, -1760, 761, 2597, 3728, 4352, 4551, 4428, 4188, 3977, 3864, 3845, 3867, 3888, 3896, 3931, 4176, -1252, 21429, 21688, 22246, 22854, 23474, 24001, 24369, 24589, 24743, 24913, 25138, 25397, 25641, 25821, 25935, 26010, 26088, 26189, 26305, 26416, 26499, 26542, 26578, 26529, 26281, 26593, 26614, 26587, 26570, 26550, 26536, 26529, 26528, 26529, 26524, 26512, 26495, 26475, 26458, 26443, 26433, 26417, 26425, 26431, 26384, 26381, 26380, 26380, 26381, 26383, 26384, 26389, 26391, 26010, 28428, 12698, 8217, 19130, 12192, 6916, 3161, 709, -1292, -3569, -6279, -9053, -11390, -13062, -14158, -15057, -16103, -17360, -18671, -19791, -20577, -21073, -21450, -21880, -22457, -22897, -25783, -25026, -24464, -25113, -25462, -25765, -26027, -26234, -26357, -26401, -26402, -26404, -26432, -26485, -26542, -26578, -26583, -26579, -26526, -26237, -26490, -26527, -26482, -26452, -26422, -26398, -26382, -26376, -26371, -26365, -26352, -26334, -26313, -26279, -26338, -26093, -21462, -26500, -27895, -27035, -26479, -26148, -26048, -26175, -26397, -26436, -26544, -26590, -26580, -26544, -26503, -26473, -26461, -26464, -26480, -26503, -26526, -26545, -26562, -26575, -26584, -26595, -26593, -26601, -26620, -26625, -26629, -26633, -26636, -26637, -26636, -26634, -26629, -26592, -26795, -24662, -25348, -26462, -25993, -25835, -25779, -25799, -25863, -25950, -26045, -26140, -26230, -26317, -26390, -26452, -26509, -26558, -26598, -26633, -26661, -26685, -26704, -26722, -26724, -26765, -27623, -26983, -26859, -26998, -27045, -27054, -27038, -27007, -26977, -26919, -26855, -31374, -27194, -25031, -25887, -26419, -26749, -26847, -26733, -26492, -26440, -26332, -26281, -26290, -26334, -26387, -26432, -26460, -26474, -26475, -26472, -26466, -26464, -26466, -26470, -26475, -26481, -26485, -26489, -26491, -26492, -26494, -26490, -26518, -26532, -26500, -26511, -26516, -26520, -26522, -26524, -26525, -26524, -26526, -26088, -28729, -10296, -9852, -19046, -11647, -6524, -2899, -518, 1488, 3823, 6578, 9347, 11648, 13250, 14317, 15234, 16302, 17581, 18892, 19966, 21576};