/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0088 512 samples */
 
const int16_t AKWF_stereo_0088_512_DATA [512] = 
{438, 2032, 3787, 5833, 8143, 10593, 12887, 14784, 15945, 16516, 17118, 17964, 19150, 20399, 21423, 22138, 22513, 22606, 22787, 23328, 24447, 25050, 24318, 23090, 22479, 23324, 25214, 27376, 29215, 30629, 31728, 32466, 32765, 32565, 31846, 30677, 29185, 27399, 25226, 23033, 21138, 19807, 19033, 18528, 17976, 17304, 16570, 15840, 15150, 14467, 13738, 12931, 11994, 10942, 9839, 8562, 6982, 5254, 3384, 1504, -448, -2612, -5081, -7676, -9989, -11798, -13018, -13825, -14462, -15166, -16121, -17608, -19674, -21544, -22890, -23404, -23190, -22638, -22039, -21670, -21639, -21781, -21948, -21944, -21726, -21301, -20756, -20309, -19959, -19689, -19457, -19279, -19048, -18815, -18655, -18448, -18126, -17343, -16067, -14602, -13211, -12125, -11117, -9953, -8564, -7087, -5778, -4824, -4356, -4119, -3487, -2244, -721, 643, 1469, 1777, 1739, 1620, 1706, 2104, 2922, 3616, 3743, 3688, 3872, 4600, 5644, 6705, 7573, 8555, 9818, 10967, 11717, 11799, 11153, 9942, 8715, 7873, 7301, 7105, 7162, 7594, 8557, 9859, 11364, 12574, 13150, 13074, 12384, 11103, 9635, 8229, 6760, 5207, 3484, 1615, -239, -1770, -2614, -2875, -2840, -2864, -3194, -3623, -3847, -3612, -2632, -1265, 32, 850, 1003, 523, -319, -1062, -1575, -1743, -1515, -956, -520, -558, -1292, -2577, -4090, -5548, -6812, -7852, -8723, -9521, -10261, -10962, -11672, -12426, -13166, -13840, -14405, -14797, -15023, -14963, -14692, -14342, -14123, -14064, -13969, -13634, -12967, -12055, -11095, -10282, -9744, -9397, -9011, -8540, -8126, -7900, -7923, -8057, -8111, -8123, -8172, -8053, -7646, -7044, -6436, -5823, -5185, -4504, -3882, -3569, -3854, -4245, -4451, -4406, -4210, -4187, -4537, -5352, -6545, -7677, -8492, -8701, -8331, -7492, -6373, -5483, -4932, -4766, -4784, -4796, -4481, -3941, -3564, -3396, -3314, -3016, -2247, -1020, 4255, 5343, 6403, 7581, 8913, 10407, 11977, 13489, 14782, 15852, 16792, 17657, 18506, 19326, 20132, 20991, 21903, 22769, 23592, 24354, 25078, 25422, 25237, 24945, 24964, 25474, 26228, 27003, 27732, 28512, 29425, 30328, 31010, 31332, 31282, 30938, 30383, 29618, 28524, 27131, 25517, 23801, 22108, 20485, 18952, 17512, 16114, 14661, 13106, 11458, 9802, 8237, 6799, 5467, 4188, 2868, 1469, 53, -1413, -2918, -4521, -6211, -7995, -9861, -11697, -13412, -14941, -16303, -17534, -18677, -19760, -20839, -21943, -22953, -23829, -24470, -24830, -24914, -24740, -24370, -23896, -23399, -22923, -22477, -22030, -21565, -21068, -20522, -19944, -19350, -18769, -18243, -17795, -17370, -16896, -16351, -15763, -15103, -14374, -13614, -12849, -12098, -11367, -10643, -9924, -9210, -8491, -7761, -6977, -6118, -5115, -3959, -2816, -1773, -891, -156, 514, 1191, 1868, 2529, 3204, 4039, 4935, 5728, 6304, 6673, 6971, 7303, 7723, 8300, 9043, 9852, 10682, 11471, 12161, 12692, 13142, 13606, 14075, 14546, 14965, 15348, 15773, 16211, 16668, 17042, 17275, 17374, 17288, 16882, 16183, 15223, 13960, 12468, 10810, 9098, 7385, 5608, 3944, 2486, 1317, 384, -469, -1334, -2255, -3171, -3904, -4439, -4808, -5075, -5297, -5475, -5636, -5861, -6167, -6513, -6768, -6844, -6884, -7007, -7321, -7805, -8372, -8959, -9533, -10095, -10646, -11175, -11684, -12182, -12678, -13193, -13715, -14196, -14619, -14978, -15302, -15630, -15954, -16217, -16418, -16523, -16550, -16516, -16410, -16223, -15948, -15595, -15147, -14601, -14028, -13458, -12918, -12413, -11929, -11445, -10913, -10377, -9887, -9368, -8800, -8110, -7299, -6431, -5558, -4721, -3941, -3298, -2910, -2712, -2598, -2434, -2177, -1849, -1529, -1313, -1350, -1554, -1787, -1930, -1933, -1848, -1734, -1715, -1802, -1894, -1872, -1734, -1380, -842, -338, 133, 660, 1317, 2171, 3190};