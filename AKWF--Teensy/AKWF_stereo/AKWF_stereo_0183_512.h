/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0183 512 samples */
 
const int16_t AKWF_stereo_0183_512_DATA [512] = 
{334, 986, 1612, 2223, 2807, 3365, 3890, 4379, 4830, 5236, 5591, 5903, 6165, 6375, 6542, 6663, 6732, 6763, 6759, 6710, 6626, 6517, 6372, 6191, 5986, 5754, 5493, 5214, 4920, 4606, 4292, 3986, 3688, 3410, 3168, 2973, 2827, 2752, 2750, 2829, 2994, 3251, 3599, 4032, 4545, 5126, 5755, 6409, 7077, 7719, 8302, 8820, 9254, 9581, 9796, 9905, 9899, 9786, 9587, 9309, 8955, 8554, 8116, 7645, 7166, 6702, 6253, 5835, 5475, 5172, 4933, 4779, 4706, 4713, 4809, 4997, 5261, 5598, 6015, 6493, 7017, 7586, 8189, 8808, 9430, 10054, 10667, 11255, 11827, 12381, 12908, 13423, 13936, 14451, 14962, 15502, 16063, 16624, 17214, 17829, 18438, 19062, 19701, 20319, 20922, 21527, 22114, 22663, 23198, 23712, 24183, 24623, 25043, 25422, 25739, 26036, 26285, 26468, 26594, 26666, 26644, 26513, 26298, 25941, 25420, 24754, 23883, 22758, 21400, 19788, 17887, 15711, 13302, 10674, 7911, 5164, 2463, -157, -2586, -4779, -6711, -8371, -9754, -10876, -11758, -12429, -12910, -13236, -13423, -13508, -13500, -13416, -13293, -13124, -12906, -12665, -12419, -12156, -11876, -11611, -11353, -11091, -10841, -10608, -10384, -10164, -9961, -9763, -9548, -9330, -9092, -8812, -8486, -8121, -7693, -7198, -6661, -6071, -5434, -4787, -4127, -3462, -2818, -2207, -1638, -1118, -657, -267, 49, 284, 422, 470, 420, 264, 0, -381, -874, -1487, -2214, -3060, -4027, -5113, -6309, -7622, -9045, -10553, -12152, -13836, -15571, -17345, -19143, -20921, -22652, -24316, -25877, -27292, -28542, -29630, -30517, -31209, -31727, -32054, -32190, -32186, -32032, -31709, -31263, -30701, -30001, -29154, -28213, -27154, -25950, -24671, -23316, -21860, -20353, -18849, -17330, -15811, -14354, -12961, -11622, -10370, -9213, -8128, -7114, -6191, -5332, -4519, -3755, -3034, -2332, -1644, -979, -304, 11189, 10966, 10676, 10332, 9953, 9533, 9067, 8584, 8075, 7535, 6979, 6413, 5833, 5248, 4672, 4110, 3555, 3032, 2545, 2092, 1684, 1326, 1013, 737, 501, 289, 90, -106, -314, -551, -819, -1120, -1465, -1848, -2261, -2693, -3128, -3560, -3966, -4334, -4651, -4916, -5116, -5249, -5327, -5357, -5343, -5308, -5262, -5224, -5207, -5222, -5275, -5363, -5493, -5659, -5851, -6053, -6265, -6473, -6660, -6825, -6965, -7069, -7128, -7150, -7119, -7038, -6913, -6729, -6479, -6182, -5825, -5406, -4929, -4396, -3808, -3165, -2482, -1756, -996, -213, 580, 1384, 2186, 2975, 3756, 4527, 5288, 6048, 6817, 7601, 8409, 9256, 10137, 11075, 12067, 13101, 14199, 15360, 16556, 17805, 19102, 20410, 21726, 23047, 24343, 25575, 26755, 27858, 28853, 29741, 30529, 31198, 31725, 32158, 32482, 32674, 32758, 32751, 32610, 32327, 31942, 31392, 30661, 29781, 28696, 27363, 25823, 24067, 22060, 19827, 17432, 14876, 12211, 9586, 7011, 4494, 2131, -43, -2020, -3797, -5359, -6731, -7932, -8973, -9872, -10653, -11325, -11904, -12392, -12803, -13166, -13460, -13685, -13855, -13989, -14081, -14133, -14175, -14205, -14211, -14212, -14217, -14215, -14202, -14193, -14175, -14126, -14070, -13997, -13883, -13736, -13568, -13362, -13108, -12838, -12534, -12188, -11835, -11460, -11051, -10635, -10223, -9808, -9395, -9010, -8655, -8324, -8044, -7821, -7643, -7513, -7447, -7435, -7469, -7563, -7711, -7903, -8154, -8474, -8861, -9314, -9858, -10488, -11192, -11982, -12855, -13782, -14754, -15761, -16759, -17715, -18620, -19436, -20113, -20640, -21014, -21194, -21191, -21026, -20681, -20169, -19535, -18775, -17893, -16920, -15870, -14735, -13512, -12237, -10902, -9501, -8074, -6626, -5144, -3659, -2204, -769, 629, 1969, 3247, 4458, 5585, 6628, 7579, 8431, 9183, 9827, 10356, 10782, 11099, 11305, 11410, 11424, 11349};