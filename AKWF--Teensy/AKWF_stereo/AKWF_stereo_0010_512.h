/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0010 512 samples */
 
const int16_t AKWF_stereo_0010_512_DATA [512] = 
{51, 150, 245, 337, 424, 503, 587, 666, 743, 817, 887, 955, 1021, 1083, 1143, 1199, 1256, 1301, 1339, 1391, 1427, 1466, 1506, 1541, 1574, 1604, 1631, 1658, 1679, 1702, 1705, 1713, 1727, 1737, 1745, 1750, 1752, 1752, 1751, 1747, 1741, 1732, 1723, 1693, 1675, 1659, 1640, 1619, 1598, 1573, 1548, 1520, 1490, 1460, 1428, 1384, 1342, 1305, 1268, 1230, 1188, 1152, 1108, 1264, 295, 6106, 26381, 31515, 30979, 32586, 31524, 30104, 28380, 26398, 25291, 23673, 22928, 21994, 21471, 21166, 20895, 20858, 20858, 21144, 21419, 21794, 22232, 22658, 23161, 23619, 24114, 24577, 25029, 25447, 25716, 26092, 26426, 26724, 26992, 27217, 27404, 27381, 28311, 23334, 1760, -4875, -4178, -6468, -5090, -3522, -1588, 704, 1780, 3417, 3973, 4710, 4966, 4949, 4893, 4401, 3979, 3205, 2451, 1605, 628, -337, -1390, -2404, -3454, -4475, -5475, -6470, -7385, -8259, -9069, -9836, -10557, -11231, -11861, -12441, -12979, -13468, -13914, -14318, -14688, -14943, -15214, -15462, -15674, -15854, -16002, -16122, -16216, -16285, -16332, -16353, -16362, -16335, -16215, -16169, -16107, -16032, -15945, -15848, -15741, -15625, -15501, -15370, -15231, -15095, -14907, -14678, -14527, -14364, -14217, -14052, -13880, -13705, -13527, -13347, -13165, -12980, -12801, -12558, -12321, -12140, -11947, -11755, -11563, -11368, -11174, -10978, -10782, -10585, -10390, -10173, -9914, -9717, -9520, -9323, -9126, -8927, -8731, -8533, -8335, -8138, -7942, -7749, -7528, -7295, -7106, -6912, -6720, -6529, -6339, -6151, -5962, -5776, -5590, -5405, -5224, -5016, -4818, -4645, -4458, -4305, -4144, -3969, -3799, -3631, -3465, -3301, -3141, -2979, -2805, -2645, -2493, -2342, -2195, -2049, -1906, -1765, -1627, -1492, -1358, -1228, -1097, -967, -845, -725, -609, -494, -383, -275, -170, -65, 3896, 4016, 4132, 4243, 4347, 4441, 4539, 4629, 4716, 4799, 4876, 4949, 5017, 5081, 5141, 5196, 5249, 5287, 5318, 5362, 5387, 5414, 5440, 5459, 5475, 5486, 5493, 5497, 5494, 5492, 5466, 5445, 5430, 5407, 5382, 5352, 5318, 5281, 5240, 5195, 5147, 5095, 5041, 4962, 4897, 4834, 4763, 4692, 4618, 4539, 4459, 4376, 4289, 4200, 4109, 4004, 3900, 3800, 3700, 3599, 3492, 3392, 3278, 3409, 2110, 9470, 30953, 30159, 27030, 31088, 30550, 29763, 28529, 26846, 26463, 25114, 24957, 24317, 24092, 24015, 23815, 23869, 23803, 24039, 24167, 24364, 24594, 24761, 25007, 25163, 25359, 25504, 25634, 25726, 25650, 25705, 25715, 25698, 25657, 25576, 25470, 25119, 26056, 19030, -3909, -3878, -590, -5542, -5283, -4947, -4050, -2537, -2574, -1576, -1935, -1779, -2084, -2577, -2930, -3745, -4295, -5138, -5834, -6557, -7374, -8111, -8928, -9658, -10420, -11134, -11823, -12510, -13108, -13693, -14265, -14805, -15301, -15758, -16180, -16560, -16908, -17215, -17488, -17730, -17945, -18049, -18183, -18304, -18398, -18467, -18511, -18536, -18540, -18525, -18493, -18441, -18383, -18287, -18098, -17994, -17876, -17747, -17610, -17462, -17305, -17142, -16970, -16793, -16606, -16423, -16184, -15900, -15702, -15486, -15290, -15074, -14849, -14621, -14390, -14154, -13916, -13674, -13436, -13128, -12827, -12584, -12328, -12073, -11815, -11555, -11294, -11029, -10765, -10499, -10234, -9945, -9608, -9340, -9071, -8801, -8530, -8259, -7988, -7717, -7445, -7174, -6903, -6635, -6338, -6027, -5764, -5497, -5231, -4967, -4704, -4443, -4183, -3925, -3668, -3413, -3163, -2883, -2615, -2377, -2119, -1900, -1674, -1435, -1203, -972, -745, -522, -303, -83, 150, 365, 571, 773, 973, 1168, 1360, 1548, 1731, 1911, 2088, 2259, 2432, 2601, 2759, 2914, 3064, 3211, 3351, 3489, 3621, 3751};