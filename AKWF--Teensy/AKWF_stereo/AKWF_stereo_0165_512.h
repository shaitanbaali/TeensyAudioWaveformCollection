/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0165 512 samples */
 
const int16_t AKWF_stereo_0165_512_DATA [512] = 
{6906, 10111, 10183, 10962, 11657, 12343, 12998, 13633, 14279, 14896, 15473, 16048, 16603, 17112, 17606, 18085, 18536, 18981, 19458, 19943, 20395, 20841, 21260, 21600, 21880, 22176, 22478, 22795, 23138, 23477, 23799, 24144, 24494, 24812, 25174, 25946, 26711, 27254, 27737, 28160, 28512, 29035, 29705, 29875, 29396, 28539, 28049, 27875, 27936, 28107, 28275, 28481, 28720, 28955, 29184, 29450, 29715, 29928, 30307, 32574, 11248, 400, 841, -665, -1732, -2633, -3400, -4052, -4584, -5017, -5364, -5632, -5827, -5963, -6045, -6096, -6146, -6175, -6828, -8019, -8646, -9378, -10325, -10837, -11118, -11153, -10505, -9816, -9318, -8895, -8992, -9513, -10489, -11422, -11437, -10985, -10673, -10401, -10136, -9912, -9720, -9504, -9273, -9027, -8740, -8440, -8188, -7938, -7553, -7867, -5369, 507, -100, -62, 262, 683, 1145, 1617, 2082, 2563, 2394, 1932, 1861, 1959, 2150, 2328, 2841, 2401, -16307, -21217, -21340, -22339, -23059, -23673, -24177, -24598, -25004, -25345, -25597, -25823, -26000, -26098, -26129, -26135, -26087, -26022, -26008, -25997, -25927, -25834, -25706, -25502, -25260, -25043, -24819, -24565, -24323, -24072, -23783, -23497, -23224, -22907, -22704, -23362, -23908, -24039, -24032, -23939, -23738, -23941, -24408, -24421, -23973, -23237, -22614, -22125, -21829, -21582, -21285, -20974, -20671, -20362, -20024, -19691, -19387, -19008, -19410, -21610, -12409, -5328, -5512, -4411, -3476, -2607, -1786, -1023, -315, 352, 989, 1608, 2197, 2762, 3303, 3828, 4356, 4873, 5660, 6786, 7652, 8516, 9525, 10319, 11026, 11346, 10301, 9437, 9125, 9049, 9318, 9888, 10704, 11608, 11358, 10651, 10452, 10459, 10570, 10770, 11034, 11313, 11600, 11903, 12170, 12427, 12728, 13053, 13114, 14823, 7754, -3449, -2678, -3176, -3579, -3931, -4218, -4434, -4579, -4681, -4447, -3955, -3621, -3350, -3100, -2853, -2607, -2325, 25345, 24315, 23779, 23467, 23337, 23317, 23323, 23359, 23482, 23185, 22647, 22476, 22466, 22520, 22637, 22803, 22956, 23308, 23952, 24440, 24809, 25138, 25528, 25221, 23336, 21052, 19668, 18936, 18549, 18362, 18291, 18322, 18392, 18722, 19238, 19622, 19926, 20232, 20328, 19740, 19360, 19285, 19346, 19467, 19635, 19852, 20179, 19887, 25040, 29483, 29661, 30381, 30377, 30497, 30974, 31409, 31766, 32059, 32201, 33805, 12169, 613, 477, -1309, -2474, -3096, -3610, -4179, -4724, -5198, -5615, -5967, -6219, -6389, -6490, -6567, -6503, -5985, -5507, -5229, -5049, -4876, -4689, -4481, -4517, -2818, -9880, -25447, -25703, -26817, -27675, -28371, -28973, -29484, -29886, -30255, -30600, -30870, -31062, -31205, -31279, -31246, -31331, -31837, -32175, -32064, -31858, -31675, -31496, -31328, -31107, -30820, -30554, -30298, -30018, -29752, -29521, -29297, -29054, -28828, -28588, -28306, -28034, -27761, -27498, -26876, -25867, -25144, -24308, -23323, -22590, -21960, -21410, -20927, -20455, -19974, -19546, -18948, -18188, -17611, -17128, -16668, -16217, -15806, -15341, -15364, -15865, -15992, -15909, -15735, -15551, -15072, -13763, -12134, -10921, -10047, -9359, -8803, -8319, -7875, -7435, -7570, -7907, -7909, -7764, -7544, -7206, -6486, -5806, -5280, -4821, -4395, -3981, -3594, -3384, -2009, -13843, -20843, -20520, -21311, -21486, -21985, -22753, -23198, -23470, -23603, -23516, -24417, -14598, -6915, -6644, -5289, -4390, -4263, -4022, -3557, -3018, -2457, -1882, -1316, -823, -362, 81, 568, 757, 117, -237, -241, -75, 174, 457, 756, 1177, 928, 4029, 13462, 14650, 15602, 16563, 17415, 18205, 18953, 19629, 20239, 20846, 21429, 21955, 22429, 22837, 23178, 23561, 24245, 24780, 24571, 24379, 24414, 24528, 24696, 24819, 24885, 24990, 25156, 25350, 25557, 25818, 26106, 26380, 26673, 26977, 27264, 27545, 27838, 28200, 27708, 26605, 26108};