/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0169 512 samples */
 
const int16_t AKWF_stereo_0169_512_DATA [512] = 
{385, 964, 1550, 2121, 2686, 3240, 3767, 4257, 4699, 5082, 5429, 5767, 6157, 6604, 7092, 7604, 8128, 8668, 9210, 9750, 10293, 10833, 11361, 11888, 12409, 12912, 13403, 13887, 14352, 14790, 15221, 15642, 16040, 16430, 16825, 17217, 17599, 17999, 18397, 18771, 19141, 19509, 19855, 20187, 20537, 20883, 21229, 21596, 21963, 22311, 22673, 23043, 23401, 23763, 24140, 24509, 24859, 25230, 25613, 25989, 26399, 26854, 27301, 27725, 28166, 28599, 29002, 29414, 29833, 30221, 30513, 30699, 30780, 30758, 30694, 30561, 30328, 30040, 29649, 29149, 28641, 28150, 27638, 27106, 26597, 26085, 25542, 25012, 24489, 23938, 23366, 22810, 22234, 21616, 21012, 20406, 19772, 19150, 18552, 17946, 17324, 16722, 16111, 15467, 14829, 14200, 13557, 12907, 12275, 11637, 10974, 10319, 9661, 8974, 8277, 7584, 6873, 6149, 5443, 4723, 4005, 3343, 2713, 2096, 1491, 916, 340, -235, -814, -1390, -1968, -2547, -3114, -3660, -4188, -4690, -5137, -5516, -5864, -6201, -6590, -7036, -7524, -8036, -8558, -9097, -9641, -10178, -10719, -11259, -11789, -12310, -12829, -13336, -13824, -14303, -14771, -15211, -15634, -16054, -16457, -16841, -17232, -17626, -18010, -18402, -18799, -19172, -19542, -19907, -20252, -20583, -20930, -21282, -21624, -21985, -22352, -22706, -23057, -23425, -23792, -24146, -24517, -24892, -25243, -25602, -25985, -26370, -26767, -27218, -27673, -28093, -28524, -28958, -29368, -29765, -30183, -30569, -30859, -31044, -31124, -31101, -31035, -30908, -30683, -30381, -29992, -29508, -28989, -28495, -27995, -27462, -26943, -26435, -25905, -25362, -24838, -24300, -23723, -23160, -22589, -21979, -21362, -20755, -20135, -19502, -18900, -18304, -17687, -17078, -16472, -15841, -15195, -14567, -13935, -13284, -12648, -12015, -11362, -10699, -10044, -9367, -8666, -7969, -7276, -6568, -5854, -5137, -4427, -3745, -3128, -2515, -1909, -1331, -755, -172, 10701, 11991, 13260, 14493, 15710, 16886, 18005, 19054, 20000, 20797, 21418, 21878, 22292, 22718, 23159, 23603, 24042, 24506, 24961, 25399, 25852, 26301, 26721, 27158, 27605, 28037, 28470, 28935, 29408, 29859, 30328, 30789, 31200, 31571, 31894, 32103, 32160, 32099, 31954, 31756, 31552, 31348, 31111, 30855, 30637, 30408, 30173, 29976, 29775, 29538, 29316, 29093, 28835, 28572, 28329, 28080, 27813, 27587, 27473, 27481, 27617, 27859, 28134, 28421, 28754, 29094, 29407, 29737, 30076, 30367, 30497, 30436, 30208, 29833, 29406, 28926, 28386, 27851, 27289, 26681, 26088, 25520, 24935, 24335, 23765, 23199, 22614, 22063, 21547, 21029, 20512, 20023, 19525, 18998, 18487, 17973, 17379, 16665, 15870, 15005, 14094, 13196, 12308, 11418, 10552, 9701, 8839, 7974, 7122, 6269, 5394, 4527, 3658, 2766, 1875, 1004, 139, -703, -1510, -2322, -3140, -3948, -4780, -5660, -6600, -7613, -8761, -10021, -11315, -12596, -13858, -15099, -16319, -17490, -18604, -19674, -20629, -21422, -22043, -22501, -22914, -23338, -23777, -24220, -24658, -25119, -25580, -26017, -26461, -26911, -27341, -27764, -28208, -28652, -29078, -29535, -30013, -30472, -30925, -31384, -31810, -32169, -32485, -32703, -32762, -32686, -32542, -32341, -32135, -31928, -31690, -31433, -31209, -30993, -30752, -30543, -30346, -30118, -29878, -29653, -29410, -29133, -28881, -28641, -28376, -28136, -28022, -28044, -28165, -28404, -28691, -28975, -29298, -29642, -29966, -30280, -30620, -30910, -31038, -30976, -30745, -30369, -29939, -29462, -28927, -28376, -27815, -27221, -26614, -26040, -25467, -24869, -24289, -23727, -23155, -22590, -22074, -21570, -21046, -20551, -20060, -19540, -19018, -18504, -17922, -17199, -16402, -15546, -14638, -13734, -12848, -11970, -11096, -10245, -9393, -8528, -7673, -6823, -5956, -5082, -4215, -3331, -2438, -1561, -715, 111, 922, 1731, 2543, 3373, 4189, 5064, 6007, 7021, 8166, 9447};