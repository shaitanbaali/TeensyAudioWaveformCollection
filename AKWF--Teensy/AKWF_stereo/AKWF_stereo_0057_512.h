/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0057 512 samples */
 
const int16_t AKWF_stereo_0057_512_DATA [512] = 
{32, 102, 171, 240, 308, 379, 447, 517, 587, 657, 726, 798, 870, 942, 1014, 1086, 1159, 1235, 1309, 1384, 1460, 1537, 1615, 1694, 1774, 1855, 1937, 2020, 2104, 2189, 2276, 2363, 2453, 2543, 2634, 2728, 2823, 2920, 3018, 3117, 3218, 3323, 3428, 3535, 3644, 3756, 3870, 3985, 4102, 4221, 4345, 4469, 4596, 4727, 4859, 4994, 5132, 5272, 5417, 5563, 5713, 5865, 6021, 6180, 6343, 6508, 6678, 6852, 7027, 7209, 7394, 7581, 7774, 7971, 8171, 8376, 8587, 8800, 9019, 9242, 9470, 9703, 9940, 10184, 10431, 10686, 10945, 11209, 11480, 11755, 12038, 12325, 12619, 12919, 13225, 13538, 13858, 14183, 14517, 14858, 15203, 15558, 15919, 16287, 16664, 17047, 17438, 17838, 18247, 18660, 19085, 19519, 19958, 20407, 20865, 21331, 21807, 22292, 22785, 23290, 23802, 24323, 24856, 25397, 25947, 26509, 27080, 27661, 28253, 28853, 29465, 29084, 35091, 5954, -28778, -22768, -23281, -22776, -22283, -21799, -21323, -20857, -20399, -19950, -19509, -19078, -18654, -18239, -17831, -17432, -17040, -16657, -16281, -15914, -15551, -15197, -14851, -14511, -14179, -13853, -13533, -13221, -12915, -12614, -12321, -12033, -11751, -11476, -11206, -10941, -10682, -10428, -10180, -9937, -9698, -9465, -9239, -9015, -8797, -8583, -8373, -8168, -7968, -7770, -7579, -7391, -7206, -7026, -6848, -6675, -6506, -6341, -6178, -6019, -5864, -5710, -5561, -5415, -5271, -5130, -4992, -4858, -4725, -4596, -4468, -4343, -4221, -4100, -3984, -3868, -3755, -3644, -3534, -3426, -3322, -3218, -3116, -3017, -2919, -2822, -2727, -2634, -2542, -2452, -2361, -2275, -2188, -2102, -2019, -1936, -1854, -1773, -1694, -1615, -1537, -1460, -1384, -1308, -1233, -1160, -1086, -1012, -941, -869, -798, -727, -656, -586, -517, -447, -378, -309, -240, -170, -102, -32, 107, 329, 549, 767, 982, 1198, 1412, 1625, 1840, 2053, 2264, 2476, 2690, 2901, 3114, 3325, 3538, 3753, 3966, 4180, 4396, 4612, 4828, 5045, 5263, 5483, 5703, 5925, 6148, 6374, 6600, 6827, 7056, 7286, 7519, 7752, 7988, 8226, 8466, 8707, 8949, 9195, 9442, 9691, 9942, 10196, 10451, 10709, 10968, 11229, 11493, 11758, 12027, 12296, 12569, 12843, 13118, 13395, 13675, 13956, 14240, 14525, 14813, 15101, 15391, 15682, 15976, 16271, 16567, 16863, 17161, 17461, 17761, 18063, 18365, 18667, 18970, 19272, 19575, 19879, 20182, 20484, 20787, 21089, 21390, 21691, 21991, 22290, 22587, 22881, 23176, 23468, 23759, 24047, 24333, 24616, 24898, 25177, 25451, 25726, 25995, 26261, 26524, 26783, 27039, 27292, 27540, 27785, 28025, 28262, 28495, 28724, 28949, 29170, 29386, 29598, 29806, 30010, 30210, 30407, 30598, 30786, 30971, 31152, 31330, 31503, 31674, 31842, 32007, 32169, 32329, 31350, 37598, 3987, -35851, -29431, -30403, -30206, -30007, -29802, -29594, -29382, -29165, -28944, -28721, -28491, -28258, -28022, -27780, -27535, -27287, -27035, -26778, -26520, -26257, -25990, -25721, -25447, -25171, -24893, -24612, -24328, -24042, -23753, -23464, -23170, -22876, -22582, -22284, -21985, -21686, -21386, -21083, -20782, -20480, -20176, -19874, -19570, -19266, -18965, -18661, -18358, -18057, -17756, -17456, -17158, -16858, -16562, -16266, -15970, -15677, -15386, -15096, -14808, -14521, -14234, -13952, -13671, -13391, -13114, -12837, -12564, -12293, -12022, -11753, -11489, -11224, -10963, -10706, -10448, -10191, -9940, -9686, -9437, -9191, -8946, -8703, -8462, -8223, -7986, -7749, -7514, -7283, -7053, -6822, -6595, -6370, -6145, -5923, -5701, -5479, -5260, -5041, -4823, -4608, -4392, -4178, -3964, -3749, -3535, -3323, -3111, -2898, -2687, -2474, -2261, -2051, -1836, -1622, -1408, -1195, -979, -764, -545, -327, -104};