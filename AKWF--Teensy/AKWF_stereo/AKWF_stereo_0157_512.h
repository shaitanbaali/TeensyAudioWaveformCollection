/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0157 512 samples */
 
const int16_t AKWF_stereo_0157_512_DATA [512] = 
{5387, 28460, 32885, 31557, 31428, 31069, 30719, 30377, 30031, 29693, 29354, 29018, 28689, 28358, 28034, 27711, 27390, 27074, 26757, 26446, 26139, 25830, 25530, 25231, 24931, 24640, 24344, 24056, 23773, 23486, 23209, 22926, 22444, 23124, 16670, -6775, -11571, -10448, -10563, -10444, -10326, -10217, -10102, -9990, -9881, -9770, -9662, -9551, -9442, -9338, -9231, -9126, -9023, -8918, -8816, -8713, -8612, -8512, -8411, -8312, -8214, -8115, -8019, -7923, -7826, -7732, -7637, -7544, -7450, -7358, -7265, -7175, -7083, -6992, -6903, -6813, -6725, -6637, -6550, -6463, -6376, -6290, -6205, -6120, -6036, -5953, -5870, -5787, -5705, -5624, -5543, -5461, -5381, -5302, -5224, -5144, -5066, -4989, -4911, -4835, -4759, -4682, -4607, -4532, -4458, -4383, -4309, -4235, -4162, -4091, -4018, -3947, -3875, -3804, -3732, -3662, -3593, -3523, -3454, -3385, -3317, -3248, -3180, -3113, -3046, -2979, -2912, -2845, -2779, -2712, -2647, -2582, -2517, -2452, -2388, -2323, -2260, -2198, -2133, -2071, -2008, -1946, -1884, -1821, -1760, -1699, -1637, -1576, -1515, -1454, -1393, -1334, -1272, -1214, -1154, -1095, -1036, -976, -917, -858, -800, -742, -683, -627, -570, -510, -453, -396, -338, -281, -223, -166, -109, -52, 5, 60, 117, 174, 231, 286, 343, 399, 455, 511, 567, 623, 678, 735, 790, 846, 902, 958, 1013, 1069, 1125, 1180, 1235, 1291, 1346, 1402, 1458, 1513, 1569, 1626, 1680, 1735, 1792, 1846, 1901, 1959, 2014, 2069, 2126, 2181, 2237, 2293, 2349, 2405, 2461, 2517, 2574, 2631, 2688, 2744, 2752, 2969, 2507, -6278, -10803, -10402, -10596, -10700, -10804, -10909, -11012, -11120, -11227, -11337, -11449, -11560, -11674, -11790, -11906, -12025, -12144, -12265, -12388, -12511, -12639, -12765, -12894, -13030, -13110, -13402, -13026, -4469, 3318, 16784, 19380, 18612, 18549, 18350, 18154, 17965, 17771, 17582, 17396, 17208, 17025, 16843, 16662, 16485, 16306, 16132, 15957, 15785, 15616, 15446, 15282, 15116, 14953, 14793, 14631, 14474, 14320, 14164, 14013, 13860, 13589, 13998, 10248, -3405, -6188, -5523, -5576, -5494, -5415, -5337, -5258, -5181, -5104, -5026, -4951, -4873, -4797, -4724, -4647, -4572, -4498, -4422, -4349, -4276, -4203, -4129, -4056, -3983, -3911, -3839, -3767, -3696, -3624, -3554, -3483, -3412, -3342, -3271, -3201, -3131, -3061, -2991, -2922, -2854, -2785, -2715, -2647, -2579, -2509, -2442, -2374, -2306, -2239, -2170, -2103, -2036, -1968, -1901, -1834, -1767, -1700, -1634, -1567, -1499, -1434, -1367, -1301, -1235, -1169, -1104, -1037, -970, -904, -838, -772, -706, -640, -574, -509, -444, -377, -310, -244, -179, -113, -49, 17, 84, 149, 215, 282, 347, 414, 480, 547, 614, 681, 749, 815, 881, 949, 1015, 1083, 1150, 1217, 1284, 1353, 1420, 1487, 1555, 1624, 1692, 1760, 1829, 1897, 1966, 2034, 2104, 2174, 2243, 2313, 2382, 2452, 2522, 2593, 2663, 2735, 2806, 2876, 2949, 3021, 3091, 3164, 3238, 3309, 3384, 3457, 3531, 3604, 3678, 3754, 3828, 3904, 3979, 4053, 4130, 4207, 4283, 4360, 4437, 4514, 4593, 4672, 4750, 4829, 4909, 4988, 5069, 5150, 5231, 5312, 5394, 5476, 5559, 5641, 5724, 5810, 5894, 5978, 6065, 6150, 6236, 6322, 6409, 6497, 6583, 6672, 6762, 6850, 6941, 7030, 7120, 7214, 7304, 7398, 7492, 7583, 7679, 7774, 7869, 7969, 8064, 8048, 8517, 7405, -13125, -23714, -22813, -23301, -23573, -23849, -24125, -24399, -24684, -24966, -25252, -25544, -25834, -26128, -26429, -26728, -27035, -27341, -27651, -27967, -28281, -28605, -28926, -29251, -29589, -29806, -30499, -29657, -9673};