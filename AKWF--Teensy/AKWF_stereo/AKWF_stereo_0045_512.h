/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0045 512 samples */
 
const int16_t AKWF_stereo_0045_512_DATA [512] = 
{26387, 29869, 27066, 29689, 28764, 26109, 26568, 26026, 23611, 23374, 23608, 22230, 21794, 22512, 22240, 21838, 22379, 22593, 22245, 22300, 22407, 22038, 21706, 21539, 21149, 20689, 20385, 20051, 19662, 19384, 19155, 18894, 18687, 18531, 18350, 18169, 18013, 17835, 17629, 17428, 17213, 16973, 16731, 16489, 16237, 15985, 15744, 15503, 15268, 15042, 14822, 14606, 14394, 14186, 13977, 13766, 13556, 13343, 13129, 12912, 12693, 12472, 12252, 12032, 11811, 11593, 11375, 11159, 10944, 10732, 10519, 10309, 10098, 9888, 9680, 9470, 9260, 9050, 8841, 8631, 8422, 8212, 8003, 7796, 7586, 7380, 7173, 6966, 6761, 6556, 6352, 6148, 5944, 5741, 5539, 5335, 5133, 4931, 4729, 4528, 4327, 4127, 3926, 3727, 3528, 3327, 3129, 2932, 2733, 2537, 2339, 2142, 1947, 1752, 1555, 1361, 1166, 971, 778, 584, 391, 198, 6, -185, -376, -567, -758, -948, -1138, -1327, -1518, -1707, -1895, -2084, -2272, -2458, -2646, -2834, -3019, -3205, -3392, -3577, -3761, -3947, -4130, -4314, -4498, -4681, -4864, -5047, -5228, -5411, -5591, -5773, -5953, -6133, -6314, -6494, -6672, -6851, -7029, -7208, -7385, -7564, -7741, -7918, -8094, -8270, -8446, -8622, -8796, -8971, -9146, -9320, -9494, -9667, -9840, -10013, -10185, -10358, -10530, -10701, -10871, -11042, -11212, -11383, -11553, -11722, -11889, -12060, -12227, -12396, -12564, -12731, -12898, -13065, -13231, -13398, -13563, -13728, -13893, -14059, -14222, -14387, -14550, -14714, -14878, -15040, -15203, -15365, -15528, -15689, -15851, -16011, -16171, -16331, -16492, -16652, -16811, -16970, -17129, -17287, -17446, -17603, -17761, -17917, -18076, -18232, -18388, -18544, -18701, -18855, -19010, -19166, -19319, -19474, -19628, -19781, -19935, -20088, -20240, -20393, -20545, -20696, -20848, -20999, -21150, -21302, -21450, -21590, -21758, -21898, -22044, -22070, -22935, -19714, 28800, 23757, 22679, 22808, 22987, 23047, 22983, 22905, 22699, 22488, 22269, 22049, 21828, 21608, 21389, 21171, 20954, 20736, 20518, 20302, 20086, 19870, 19654, 19440, 19225, 19009, 18796, 18582, 18370, 18157, 17945, 17733, 17522, 17311, 17100, 16889, 16679, 16470, 16261, 16052, 15843, 15635, 15429, 15221, 15014, 14808, 14602, 14395, 14192, 13987, 13782, 13577, 13374, 13170, 12968, 12764, 12562, 12361, 12160, 11959, 11758, 11557, 11358, 11158, 10959, 10761, 10562, 10365, 10167, 9970, 9773, 9577, 9381, 9184, 8990, 8794, 8599, 8405, 8212, 8018, 7825, 7632, 7440, 7248, 7056, 6865, 6674, 6483, 6293, 6104, 5914, 5726, 5537, 5348, 5160, 4973, 4785, 4599, 4412, 4226, 4040, 3854, 3669, 3485, 3300, 3116, 2933, 2749, 2566, 2384, 2201, 2019, 1838, 1657, 1476, 1295, 1116, 936, 755, 577, 398, 220, 42, -135, -311, -488, -666, -841, -1018, -1193, -1369, -1544, -1718, -1893, -2067, -2239, -2413, -2587, -2758, -2931, -3104, -3275, -3446, -3618, -3788, -3958, -4128, -4298, -4467, -4636, -4804, -4974, -5141, -5308, -5476, -5643, -5810, -5976, -6142, -6307, -6473, -6638, -6802, -6967, -7131, -7295, -7458, -7622, -7785, -7947, -8109, -8270, -8432, -8594, -8755, -8915, -9075, -9236, -9395, -9555, -9714, -9873, -10030, -10189, -10347, -10505, -10662, -10819, -10974, -11132, -11287, -11443, -11598, -11753, -11908, -12063, -12217, -12372, -12524, -12677, -12830, -12983, -13136, -13287, -13439, -13591, -13743, -13893, -14044, -14194, -14344, -14493, -14643, -14793, -14940, -15090, -15238, -15386, -15534, -15681, -15828, -15975, -16122, -16268, -16414, -16559, -16705, -16850, -16995, -17140, -17284, -17426, -17571, -17715, -17857, -18001, -18143, -18286, -18428, -18569, -18711, -18852, -18993, -19134, -19274, -19414, -19554, -19694, -19831, -19962, -20120, -20245, -20382, -20354, -21438, -17175};