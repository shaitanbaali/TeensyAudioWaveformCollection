/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0062 512 samples */
 
const int16_t AKWF_stereo_0062_512_DATA [512] = 
{405, 1109, 1826, 2564, 3322, 4101, 4897, 5708, 6534, 7380, 8234, 9106, 9985, 10877, 11775, 12684, 13595, 14512, 15427, 16341, 17252, 18161, 19055, 19946, 20820, 21679, 22522, 23345, 24144, 24920, 25669, 26386, 27078, 27731, 28353, 28936, 29482, 29987, 30454, 30877, 31257, 31593, 31883, 32127, 32326, 32476, 32580, 32637, 32645, 32607, 32520, 32387, 32206, 31977, 31706, 31385, 31025, 30620, 30171, 29683, 29154, 28587, 27988, 27351, 26679, 25978, 25250, 24492, 23712, 22908, 22086, 21248, 20393, 19524, 18647, 17763, 16871, 15981, 15083, 14189, 13300, 12418, 11536, 10669, 9806, 8959, 8127, 7307, 6501, 5716, 4947, 4197, 3472, 2772, 2104, 1470, 882, 359, -30, -493, 731, 3420, 3252, 2925, 2465, 1933, 1355, 745, 112, -536, -1198, -1872, -2551, -3235, -3925, -4613, -5303, -5990, -6671, -7346, -8015, -8671, -9319, -9952, -10568, -11169, -11753, -12313, -12852, -13368, -13859, -14324, -14759, -15167, -15545, -15891, -16206, -16491, -16741, -16959, -17144, -17294, -17413, -17499, -17554, -17578, -17569, -17533, -17470, -17379, -17264, -17126, -16965, -16784, -16588, -16376, -16151, -15915, -15671, -15422, -15169, -14917, -14667, -14420, -14180, -13950, -13732, -13527, -13338, -13167, -13014, -12882, -12772, -12686, -12622, -12584, -12572, -12582, -12619, -12679, -12763, -12869, -13000, -13148, -13317, -13504, -13706, -13921, -14147, -14383, -14626, -14873, -15120, -15368, -15612, -15852, -16082, -16302, -16508, -16701, -16876, -17031, -17164, -17275, -17361, -17421, -17454, -17458, -17432, -17376, -17288, -17169, -17019, -16838, -16623, -16378, -16100, -15793, -15454, -15088, -14692, -14269, -13819, -13346, -12848, -12329, -11790, -11231, -10657, -10068, -9466, -8851, -8227, -7594, -6958, -6314, -5672, -5030, -4393, -3756, -3132, -2516, -1918, -1327, -855, -281, 334, 692, -381, -3036, -3031, -2714, -2267, -1738, -1159, -520, 12529, 13263, 13948, 14610, 15257, 15881, 16499, 17097, 17693, 18273, 18850, 19417, 19980, 20533, 21081, 21624, 22160, 22688, 23212, 23723, 24233, 24731, 25220, 25702, 26171, 26632, 27080, 27518, 27941, 28354, 28749, 29133, 29499, 29851, 30183, 30499, 30794, 31075, 31334, 31570, 31788, 31987, 32160, 32314, 32446, 32555, 32640, 32705, 32747, 32765, 32763, 32739, 32690, 32625, 32535, 32426, 32295, 32146, 31978, 31792, 31586, 31366, 31127, 30871, 30601, 30314, 30015, 29700, 29373, 29029, 28677, 28310, 27933, 27539, 27140, 26723, 26299, 25858, 25411, 24946, 24475, 23984, 23483, 22969, 22437, 21892, 21327, 20743, 20134, 19509, 18845, 18155, 17430, 16656, 15822, 14924, 13920, 12789, 11358, 10087, 5041, -3284, -5210, -6757, -7997, -9059, -9999, -10863, -11660, -12407, -13109, -13781, -14417, -15031, -15618, -16182, -16725, -17250, -17752, -18242, -18707, -19161, -19593, -20010, -20408, -20792, -21155, -21503, -21835, -22148, -22443, -22721, -22981, -23222, -23449, -23656, -23846, -24018, -24172, -24310, -24431, -24535, -24624, -24694, -24751, -24794, -24820, -24835, -24835, -24823, -24800, -24767, -24724, -24671, -24611, -24544, -24472, -24395, -24313, -24229, -24146, -24057, -23972, -23889, -23810, -23731, -23661, -23597, -23537, -23487, -23444, -23411, -23390, -23376, -23374, -23381, -23399, -23430, -23470, -23516, -23576, -23642, -23717, -23796, -23885, -23974, -24072, -24171, -24271, -24371, -24473, -24570, -24669, -24762, -24852, -24935, -25012, -25082, -25144, -25199, -25242, -25277, -25301, -25313, -25314, -25304, -25280, -25244, -25196, -25136, -25061, -24971, -24870, -24756, -24628, -24483, -24329, -24159, -23975, -23779, -23569, -23346, -23107, -22859, -22593, -22317, -22024, -21718, -21397, -21064, -20711, -20346, -19962, -19560, -19138, -18699, -18234, -17748, -17229, -16681, -16099, -15469, -14778, -14094, -12935, -10936, -8987, -7303, -3317, 4042, 6055, 7514, 8695, 9702, 10616, 11453};