/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0061 512 samples */
 
const int16_t AKWF_stereo_0061_512_DATA [512] = 
{8506, 16025, 19928, 22615, 24512, 25901, 26953, 27758, 28379, 28858, 29226, 29506, 29711, 29856, 29952, 30000, 30008, 29979, 29916, 29821, 29694, 29536, 29350, 29132, 28882, 28603, 28292, 27950, 27576, 27168, 26730, 26257, 25751, 25212, 24640, 24032, 23393, 22719, 22012, 21274, 20503, 19699, 18866, 18002, 17110, 16192, 15245, 14275, 13285, 12272, 11242, 10198, 9139, 8074, 7007, 5940, 4886, 3851, 2850, 1912, 1117, 272, 1536, 4040, 3301, 2529, 1621, 652, -341, -1348, -2360, -3365, -4362, -5347, -6314, -7267, -8201, -9110, -10002, -10873, -11718, -12545, -13345, -14123, -14879, -15614, -16324, -17011, -17678, -18322, -18944, -19546, -20126, -20685, -21226, -21747, -22249, -22732, -23195, -23641, -24071, -24482, -24880, -25257, -25622, -25973, -26308, -26628, -26933, -27226, -27506, -27773, -28028, -28272, -28504, -28723, -28934, -29132, -29320, -29500, -29669, -29829, -29980, -30122, -30256, -30381, -30498, -30608, -30710, -30805, -30891, -30972, -31046, -31111, -31171, -31225, -31273, -31314, -31349, -31379, -31402, -31420, -31433, -31440, -31440, -31435, -31426, -31410, -31391, -31364, -31334, -31297, -31255, -31210, -31158, -31101, -31039, -30971, -30897, -30820, -30737, -30649, -30555, -30456, -30352, -30241, -30126, -30006, -29879, -29746, -29609, -29465, -29316, -29162, -29000, -28833, -28661, -28481, -28296, -28105, -27906, -27704, -27494, -27277, -27053, -26825, -26589, -26345, -26097, -25840, -25579, -25310, -25033, -24748, -24459, -24161, -23857, -23546, -23228, -22904, -22572, -22231, -21886, -21533, -21173, -20806, -20431, -20050, -19662, -19266, -18864, -18456, -18040, -17617, -17191, -16754, -16312, -15864, -15409, -14949, -14483, -14010, -13532, -13050, -12560, -12067, -11568, -11063, -10557, -10045, -9529, -9011, -8489, -7963, -7437, -6909, -6378, -5849, -5319, -4789, -4263, -3739, -3219, -2707, -2202, -1708, -1229, -769, -334, 63, 407, 630, 945, -821, -2408, -2410, 24690, 25356, 26019, 26667, 27069, 27303, 27458, 27561, 27630, 27672, 27700, 27725, 27747, 27772, 27800, 27833, 27870, 27910, 27952, 27997, 28041, 28084, 28121, 28154, 28179, 28198, 28204, 28198, 28180, 28144, 28095, 28026, 27940, 27834, 27707, 27559, 27388, 27197, 26981, 26741, 26475, 26183, 25867, 25523, 25151, 24753, 24322, 23863, 23371, 22844, 22281, 21680, 21035, 20339, 19593, 18781, 17892, 16909, 15799, 14513, 12870, 11294, 4983, -4115, -5942, -7634, -8961, -10100, -11112, -12034, -12885, -13675, -14423, -15130, -15801, -16444, -17062, -17653, -18224, -18776, -19307, -19823, -20324, -20807, -21277, -21734, -22175, -22605, -23022, -23426, -23821, -24203, -24573, -24934, -25283, -25621, -25949, -26266, -26576, -26873, -27162, -27441, -27712, -27974, -28227, -28470, -28706, -28931, -29152, -29361, -29562, -29758, -29944, -30124, -30296, -30460, -30619, -30770, -30914, -31052, -31182, -31309, -31427, -31539, -31647, -31749, -31845, -31934, -32020, -32099, -32174, -32244, -32309, -32368, -32424, -32476, -32523, -32565, -32604, -32637, -32665, -32691, -32713, -32731, -32747, -32758, -32764, -32767, -32768, -32764, -32756, -32746, -32733, -32715, -32694, -32670, -32644, -32614, -32580, -32543, -32504, -32460, -32416, -32365, -32313, -32258, -32199, -32137, -32072, -32004, -31932, -31857, -31780, -31699, -31615, -31528, -31437, -31343, -31246, -31145, -31043, -30934, -30823, -30709, -30591, -30471, -30345, -30217, -30087, -29951, -29813, -29669, -29523, -29374, -29220, -29062, -28902, -28736, -28567, -28394, -28218, -28038, -27852, -27662, -27469, -27272, -27071, -26865, -26655, -26440, -26222, -25999, -25770, -25536, -25300, -25056, -24807, -24556, -24296, -24033, -23765, -23490, -23208, -22922, -22628, -22328, -22021, -21708, -21385, -21056, -20718, -20373, -20016, -19649, -19274, -18886, -18486, -18072, -17643, -17200, -16737, -16254, -15746, -15218, -14657, -14057, -13419, -12726, -11964, -11116, -10131, -8869, -7809, -1788, 1877, 17912};