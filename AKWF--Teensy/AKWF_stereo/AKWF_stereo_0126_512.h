/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0126 512 samples */
 
const int16_t AKWF_stereo_0126_512_DATA [512] = 
{741, 3712, 8645, 14572, 18635, 19099, 18516, 18805, 19101, 18353, 20378, 25569, 27982, 25101, 22700, 18621, 14323, 16357, 22480, 24375, 22423, 21387, 20697, 20159, 18276, 14440, 10589, 8710, 7734, 6001, 3258, 244, -4873, -9752, -11858, -12368, -13405, -15408, -18346, -22335, -27442, -28225, -22039, -15090, -15567, -23260, -30878, -32699, -32339, -31515, -27873, -22515, -18122, -14368, -10107, -6747, -5635, -6826, -7722, -7995, -7089, -4947, -3065, -1609, 771, 3705, 8641, 14572, 18635, 19098, 18515, 18805, 19101, 18353, 20377, 25568, 27982, 25101, 22700, 18621, 14323, 16357, 22480, 24375, 22422, 21387, 20696, 20160, 18276, 14440, 10589, 8710, 7734, 6001, 3258, 244, -4873, -9752, -11858, -12368, -13403, -15408, -18346, -22334, -27441, -28224, -22035, -15089, -15567, -23259, -30879, -32698, -32337, -31515, -27873, -22515, -18122, -14368, -10107, -6747, -5635, -6826, -7722, -7994, -7090, -4947, -3065, -1609, 771, 3705, 8641, 14572, 18635, 19099, 18516, 18805, 19101, 18353, 20377, 25568, 27982, 25101, 22699, 18621, 14323, 16357, 22480, 24375, 22423, 21387, 20695, 20159, 18276, 14440, 10589, 8710, 7734, 6001, 3258, 244, -4873, -9752, -11858, -12368, -13405, -15408, -18346, -22335, -27442, -28224, -22036, -15089, -15567, -23259, -30879, -32698, -32337, -31515, -27873, -22515, -18122, -14368, -10107, -6747, -5635, -6826, -7722, -7994, -7089, -4947, -3065, -1609, 771, 3705, 8641, 14572, 18635, 19099, 18516, 18805, 19101, 18353, 20378, 25569, 27982, 25101, 22699, 18621, 14323, 16357, 22480, 24375, 22422, 21387, 20696, 20160, 18276, 14440, 10589, 8710, 7734, 6001, 3258, 244, -4873, -9752, -11858, -12368, -13404, -15408, -18346, -22334, -27441, -28224, -22037, -15090, -15567, -23259, -30879, -32698, -32337, -31515, -27873, -22515, -18122, -14368, -10107, -6747, -5635, -6826, -7722, -7994, -7089, -4951, -3080, -1575, -7353, -7442, -5284, -1463, 2351, 5607, 8128, 11184, 13847, 14407, 15207, 18998, 22409, 21370, 19035, 15233, 11578, 14912, 22251, 24215, 21571, 21086, 21328, 21506, 20748, 17824, 15094, 14472, 16888, 18424, 17437, 13827, 7686, 1912, -1038, -3482, -6927, -9434, -10617, -13342, -18075, -19291, -13763, -8113, -8377, -14600, -21821, -24808, -25817, -28212, -29649, -28369, -25639, -23365, -19973, -15521, -13200, -13490, -12253, -9939, -8971, -8138, -6528, -6265, -7346, -7447, -5282, -1463, 2351, 5607, 8128, 11184, 13847, 14407, 15207, 18998, 22409, 21370, 19035, 15234, 11579, 14912, 22251, 24215, 21571, 21086, 21328, 21506, 20748, 17824, 15094, 14472, 16888, 18424, 17437, 13828, 7686, 1912, -1038, -3482, -6926, -9434, -10617, -13342, -18075, -19291, -13760, -8112, -8378, -14600, -21821, -24808, -25817, -28213, -29648, -28369, -25639, -23365, -19973, -15521, -13200, -13489, -12253, -9939, -8971, -8138, -6528, -6265, -7346, -7448, -5283, -1463, 2351, 5607, 8128, 11184, 13846, 14407, 15207, 18998, 22410, 21369, 19035, 15235, 11578, 14912, 22251, 24216, 21571, 21086, 21328, 21506, 20748, 17824, 15094, 14472, 16888, 18424, 17437, 13828, 7686, 1912, -1038, -3482, -6926, -9433, -10617, -13342, -18075, -19291, -13760, -8112, -8378, -14600, -21822, -24810, -25817, -28213, -29649, -28370, -25639, -23365, -19973, -15523, -13200, -13491, -12254, -9938, -8970, -8139, -6529, -6267, -7346, -7448, -5283, -1466, 2351, 5607, 8128, 11184, 13847, 14407, 15207, 18998, 22409, 21370, 19035, 15234, 11579, 14912, 22251, 24216, 21571, 21086, 21328, 21506, 20748, 17824, 15094, 14472, 16888, 18424, 17437, 13827, 7686, 1912, -1038, -3482, -6927, -9433, -10617, -13342, -18075, -19291, -13760, -8112, -8378, -14600, -21822, -24808, -25817, -28213, -29649, -28369, -25639, -23365, -19973, -15521, -13200, -13490, -12253, -9939, -8971, -8136, -6524, -6304};