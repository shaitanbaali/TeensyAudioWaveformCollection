/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0099 512 samples */
 
const int16_t AKWF_stereo_0099_512_DATA [512] = 
{556, 1452, 2692, 2598, 3342, 3553, 4291, 5760, 7368, 9349, 10548, 11016, 11831, 12197, 11803, 11781, 14141, 16900, 14389, 12376, 11839, 12645, 12095, 13031, 12659, 12675, 12855, 12286, 10273, 9554, 8163, 9233, 8779, 7481, 6249, 5515, 4888, 5484, 4710, 4910, 4352, 3037, 3665, 5039, 5258, 6465, 8608, 9637, 11434, 11111, 10138, 10199, 10334, 10982, 12558, 15082, 18061, 18899, 18635, 17378, 17843, 18285, 19361, 18955, 19311, 20136, 18460, 17441, 17494, 17629, 16147, 15470, 14615, 12150, 11837, 11509, 11562, 11750, 10789, 9792, 9630, 9927, 9341, 8325, 7602, 5844, 3849, 2410, 946, 136, 1881, 4312, 3064, 1026, -1952, -3408, -4138, -4227, -5303, -7690, -8914, -7556, -5692, -4339, -5017, -6353, -7316, -6080, -4301, -3760, -3245, -1325, 1050, 1661, 423, -566, -568, -693, -300, -836, -1827, -695, -667, 228, -284, -1992, -1920, -1881, -1705, -1880, -1381, -1786, -2433, -2226, -1420, -1850, -1251, 1375, 3734, 2190, 1146, 160, 919, 1023, -186, -1082, -1618, -3649, -4213, -4231, -4839, -4426, -2367, -1748, -2673, -5370, -7183, -8991, -9329, -9805, -10734, -10910, -10190, -7934, -8262, -8697, -8580, -8782, -6875, -4151, -5008, -6159, -6468, -6625, -6392, -6124, -6280, -6616, -7196, -7373, -7634, -7575, -6095, -4719, -5148, -5635, -3174, -106, -247, -1997, -2330, -2226, -2299, -2844, -3616, -5247, -7338, -9137, -8096, -6249, -5150, -4230, -4438, -5692, -6255, -6730, -6754, -6503, -5508, -6922, -8553, -9460, -10373, -9966, -9935, -9195, -9129, -9351, -9290, -8716, -9035, -10104, -10899, -10206, -7365, -7271, -7711, -9183, -8750, -10065, -12334, -12645, -10713, -10414, -11184, -12158, -12540, -12448, -12971, -13234, -9602, -8903, -10466, -11753, -11521, -11231, -11779, -11559, -11711, -10048, -8925, -8605, -7089, -3664, -1834, -1591, 22510, 20913, 22505, 21833, 23740, 29255, 27728, 26406, 25461, 23328, 21308, 18856, 16266, 15380, 12707, 6672, 2405, 3295, -289, -1993, -2742, -3625, -5691, -5613, -4186, -1222, -1354, -3558, -3375, -2373, -4633, -5445, -6886, -8601, -9958, -10046, -9558, -9914, -6844, -1888, -2275, -4354, -3311, 2454, 3014, 3457, 7020, 5388, 4351, 3170, 5648, 16270, 21760, 18246, 12239, 9193, 14037, 13822, 8362, 5937, 6835, 6954, 11691, 14716, 16957, 15738, 13747, 8705, 1269, -1323, -1106, -1512, -6546, -7702, -8636, -8787, -7031, -9577, -16402, -21191, -21048, -13838, -11769, -8247, -5837, -6077, -7831, -14057, -20878, -23255, -24978, -21807, -20345, -20860, -24676, -26443, -24448, -23368, -22331, -21076, -21403, -21831, -16417, -18422, -21709, -21339, -21983, -26364, -30052, -29316, -28213, -27177, -27682, -27245, -24927, -20969, -21866, -22322, -18559, -18689, -17557, -15148, -17381, -19449, -23520, -27804, -27620, -27354, -27634, -27552, -23425, -20425, -17825, -15929, -14522, -13511, -10811, -6527, -3502, -3279, -6373, -9067, -9502, -7957, -6853, -7769, -5570, 766, 4599, 7301, 7601, 14282, 20304, 18726, 16714, 10974, 7218, 2802, 4396, 2495, -3090, -3416, -2304, 70, 2640, 875, 2286, 1143, -566, -523, -2371, 342, -279, -3732, -3499, -5341, -5766, -6004, -6128, -7283, -8038, -7522, -5023, -3664, -2788, -912, 6638, 19432, 17425, 13918, 15269, 12129, 11534, 10536, 9473, 11654, 13701, 11970, 14253, 15251, 15081, 14393, 16147, 18827, 18697, 16704, 16582, 19345, 21573, 20382, 19821, 17103, 11581, 10348, 7600, 6299, 5868, 5857, 5782, 10290, 10930, 8941, 7322, 7436, 11238, 8756, 4958, -187, -397, -470, 2938, 8950, 12565, 12916, 9390, 6893, 7675, 7038, 7599, 5867, 9017, 12003, 12744, 10708, 8486, 5857, 10790, 16448, 15360, 16264, 20521, 24908, 31461, 31813, 28347, 25344};