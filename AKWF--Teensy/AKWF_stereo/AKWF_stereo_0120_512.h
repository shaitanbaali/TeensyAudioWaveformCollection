/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0120 512 samples */
 
const int16_t AKWF_stereo_0120_512_DATA [512] = 
{970, 2129, 2691, 3828, 5528, 7991, 9472, 9634, 10354, 12254, 13500, 14024, 14906, 15160, 15362, 17575, 18527, 18659, 18909, 19848, 20427, 22050, 22109, 21419, 21947, 21612, 21842, 21502, 20924, 19872, 18478, 18146, 18585, 16605, 13227, 11121, 9036, 7485, 6133, 4724, 3415, 1909, 2482, 3788, 3449, 3240, 2728, 1716, 1474, 663, 194, -872, -1195, -1017, -481, -934, -2923, -3169, -3664, -3401, -3469, -4188, -6065, -6836, -6711, -6615, -6236, -6045, -5980, -4199, -3581, -2964, -1682, -1511, -2090, -1863, -1250, -1784, -4126, -6272, -4154, -2934, -4172, -5081, -5543, -7335, -8382, -9452, -11115, -13514, -16365, -18253, -19441, -19040, -18088, -17646, -16704, -15500, -14102, -13295, -12424, -12376, -10799, -9214, -9746, -10023, -10168, -10744, -9625, -9183, -9759, -11073, -11465, -11490, -12650, -14275, -15512, -16414, -18201, -19512, -19618, -18949, -19321, -18980, -17507, -14494, -12061, -8386, -5747, -2211, 1945, 2895, 3814, 3762, 7294, 18263, 19460, 19661, 18948, 19033, 19334, 19817, 18743, 19312, 19523, 19306, 19727, 20035, 19976, 18991, 18420, 19228, 18773, 17975, 16863, 15091, 13830, 12687, 11713, 10035, 9297, 8605, 7915, 7907, 6978, 6198, 5085, 5060, 6128, 6479, 5669, 5231, 5518, 6609, 8667, 10212, 9983, 10931, 11457, 12080, 14027, 13153, 5564, 6382, 7599, 7053, 5436, 4206, 3606, 3176, 2493, 2686, 2196, 1317, 848, 1074, 1505, 492, -1988, -3454, -4133, -3987, -4221, -5521, -6919, -8473, -9629, -10736, -12605, -15196, -17298, -19085, -21313, -23377, -24940, -26971, -27960, -28663, -29576, -30940, -32247, -32705, -31955, -30315, -28436, -27565, -26367, -25839, -13699, -7674, -7612, -4247, 776, 1503, 3614, 5025, 5159, 4479, 3780, 2896, 2359, 1426, 1081, 1730, 1976, 1961, 1051, 233, 74, -217, -676, -111, -862, -1830, -2092, -1526, -3430, -3461, -3182, -2696, -1323, 826, 2295, 3727, 5562, 7271, 8402, 9710, 10360, 10602, 11286, 13067, 14830, 14908, 15544, 16479, 18684, 20311, 21568, 24131, 23588, 22984, 23976, 23781, 22091, 20954, 19836, 19665, 19994, 19910, 17896, 16086, 14919, 14373, 12767, 11268, 9829, 9244, 8815, 7870, 6749, 5535, 4375, 3649, 3412, 2825, 1499, 383, -606, -366, -1379, -1953, -2758, -3670, -5104, -4705, -3694, -4516, -6581, -6579, -6363, -6298, -6337, -6603, -6443, -5692, -5413, -4399, -3934, -3679, -452, 981, 1192, 1103, 344, -635, 112, 509, -340, -1105, -3054, -5290, -5563, -5167, -6702, -8923, -10570, -11769, -12902, -14145, -15563, -16751, -17172, -17082, -17555, -18067, -17550, -15870, -15062, -14627, -13520, -13355, -13727, -12488, -10958, -11266, -12002, -12499, -13101, -13171, -13095, -13619, -13843, -14345, -16071, -16001, -15112, -16033, -16671, -16461, -15277, -14662, -13343, -10266, -7897, -5678, -2732, -2722, -2906, -3348, 614, 11111, 11825, 13071, 13161, 13013, 14155, 15960, 16100, 15470, 15578, 15991, 16557, 16642, 16108, 16333, 16071, 15958, 16813, 17349, 17317, 16024, 15347, 14969, 13805, 12672, 11315, 9952, 9198, 8904, 8060, 6977, 5436, 6271, 8245, 8106, 7808, 8725, 8826, 9231, 10672, 11436, 11219, 10878, 11145, 12289, 13858, 13355, 6796, 7707, 7975, 9061, 8547, 7090, 5425, 4693, 4528, 3946, 2800, 1209, 1247, 2728, 2317, 1459, -1, -1263, -1717, -1239, -1661, -3069, -3317, -4008, -5967, -7382, -8005, -9497, -11974, -13771, -14991, -16673, -19258, -21978, -23678, -25003, -26291, -27434, -28897, -29895, -29218, -29053, -29603, -29854, -29572, -29364, -18296, -13132, -13297, -10486, -6730, -5830, -3460, -2255, -1170, 491, 927, 1890, 1947, 1434, 1376, 1758, 2305, 2732, 2027, 865, 229, 1029, 1175, -418, -1486, -2737, -3901, -3765};