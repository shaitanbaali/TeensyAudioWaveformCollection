/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0198 512 samples */
 
const int16_t AKWF_stereo_0198_512_DATA [512] = 
{1014, 3472, 5801, 8060, 10233, 12317, 14313, 16210, 18007, 19711, 21310, 22792, 24174, 25455, 26617, 27672, 28629, 29479, 30218, 30863, 31390, 31773, 32062, 32235, 32259, 32167, 31966, 31621, 31127, 30538, 29834, 28987, 28076, 27143, 26157, 25145, 24148, 23126, 22058, 21005, 19943, 18844, 17747, 16662, 15563, 14446, 13345, 12237, 11109, 9996, 8893, 7784, 6680, 5611, 4568, 3542, 2564, 1638, 758, -59, -808, -1496, -2125, -2691, -3211, -3707, -4183, -4643, -5082, -5496, -5881, -6232, -6546, -6828, -7076, -7290, -7475, -7627, -7738, -7813, -7864, -7890, -7887, -7875, -7855, -7817, -7801, -7808, -7834, -7893, -8005, -8170, -8384, -8666, -9013, -9413, -9841, -10256, -10639, -10978, -11284, -11558, -11787, -11984, -12154, -12275, -12357, -12400, -12392, -12324, -12215, -12051, -11809, -11504, -11131, -10671, -10125, -9502, -8783, -7955, -7037, -6017, -4872, -3622, -2272, -804, 764, 2418, 4119, 5782, 7387, 8932, 10399, 11794, 13120, 14368, 15532, 16623, 17634, 18551, 19379, 20130, 20794, 21357, 21845, 22238, 22519, 22726, 22845, 22843, 22753, 22578, 22291, 21886, 21394, 20795, 20065, 19246, 18349, 17350, 16290, 15247, 14207, 13158, 12150, 11157, 10157, 9176, 8217, 7256, 6307, 5379, 4455, 3528, 2607, 1688, 765, -158, -1072, -1984, -2900, -3799, -4681, -5547, -6387, -7196, -7966, -8694, -9379, -10020, -10615, -11179, -11722, -12255, -12794, -13347, -13897, -14437, -14979, -15505, -16004, -16498, -16980, -17434, -17871, -18298, -18699, -19062, -19417, -19763, -20076, -20381, -20693, -20990, -21281, -21603, -21938, -22275, -22657, -23081, -23526, -24004, -24538, -25087, -25631, -26147, -26596, -26957, -27268, -27519, -27680, -27780, -27831, -27797, -27673, -27494, -27234, -26866, -26424, -25908, -25276, -24526, -23698, -22753, -21662, -20476, -19173, -17715, -16128, -14430, -12572, -10583, -8473, -6225, -3851, -1371, -1149, 1497, 4006, 6440, 8782, 11012, 13127, 15112, 16963, 18684, 20267, 21705, 23009, 24174, 25188, 26061, 26803, 27411, 27885, 28240, 28453, 28507, 28457, 28289, 27979, 27567, 27064, 26443, 25711, 24913, 24026, 23026, 21983, 20926, 19832, 18724, 17641, 16562, 15476, 14437, 13428, 12431, 11478, 10574, 9707, 8878, 8112, 7397, 6722, 6107, 5559, 5063, 4628, 4268, 3967, 3714, 3520, 3378, 3275, 3216, 3196, 3211, 3258, 3342, 3445, 3545, 3640, 3726, 3788, 3825, 3834, 3805, 3729, 3613, 3446, 3220, 2939, 2597, 2186, 1708, 1168, 551, -139, -898, -1735, -2644, -3627, -4680, -5794, -6959, -8179, -9438, -10724, -12040, -13380, -14723, -16044, -17316, -18517, -19631, -20666, -21609, -22436, -23151, -23765, -24235, -24582, -24813, -24898, -24826, -24629, -24286, -23768, -23111, -22316, -21356, -20233, -18984, -17592, -16039, -14379, -12608, -10705, -8706, -6644, -4504, -2293, -51, 2197, 4394, 6512, 8544, 10471, 12288, 13988, 15558, 16991, 18295, 19466, 20493, 21380, 22136, 22750, 23209, 23545, 23744, 23789, 23723, 23531, 23193, 22747, 22205, 21551, 20787, 19954, 19037, 18022, 16950, 15822, 14621, 13380, 12164, 10955, 9753, 8604, 7497, 6423, 5403, 4444, 3539, 2694, 1919, 1205, 553, -28, -542, -991, -1373, -1687, -1933, -2112, -2222, -2271, -2266, -2212, -2113, -1974, -1802, -1602, -1377, -1127, -859, -586, -329, -94, 109, 274, 394, 466, 479, 431, 316, 131, -130, -469, -890, -1396, -1988, -2664, -3430, -4283, -5223, -6256, -7374, -8567, -9840, -11177, -12562, -14003, -15484, -16983, -18500, -20037, -21562, -23051, -24479, -25821, -27054, -28197, -29237, -30138, -30916, -31579, -32096, -32451, -32685, -32770, -32671, -32425, -32031, -31450, -30685, -29778, -28698, -27408, -25970, -24379, -22595, -20658, -18601, -16371, -14020, -11586, -9049, -6412, -3714};