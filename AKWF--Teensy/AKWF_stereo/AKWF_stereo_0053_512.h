/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0053 512 samples */
 
const int16_t AKWF_stereo_0053_512_DATA [512] = 
{683, 2134, 3448, 4682, 5850, 6949, 8004, 9024, 9891, 11562, 12993, 13825, 14733, 15586, 16406, 17192, 17941, 18658, 19341, 19985, 20595, 21168, 21707, 22218, 22700, 23153, 23578, 23970, 24328, 24654, 24947, 25208, 25442, 25648, 25828, 25980, 26106, 26209, 26291, 26355, 26408, 26449, 26481, 26502, 26507, 26498, 26474, 26435, 26382, 26312, 26225, 26120, 25996, 25853, 25692, 25519, 25333, 25138, 24931, 24713, 24483, 24237, 23980, 23710, 23427, 23133, 22826, 22503, 22174, 21832, 21484, 21136, 20784, 20437, 20070, 19733, 19377, 19030, 18683, 18331, 17982, 17634, 17240, 16854, 16444, 16016, 15586, 15145, 14709, 14278, 13847, 13417, 12986, 12551, 12113, 11675, 11233, 10791, 10346, 9891, 9425, 8961, 8493, 8039, 7590, 7227, 6009, 5386, 5155, 4856, 4576, 4303, 4035, 3771, 3512, 3255, 2995, 2735, 2479, 2225, 1981, 1744, 1513, 1284, 1052, 820, 587, 350, 112, -127, -368, -620, -874, -1128, -1408, -1561, -2393, -3338, -3538, -3853, -4149, -4444, -4742, -5040, -5341, -5644, -5956, -6301, -6642, -7014, -7395, -7794, -8218, -8632, -9075, -9521, -9976, -10434, -10896, -11357, -11823, -12293, -12769, -13255, -13749, -14250, -14756, -15260, -15761, -16254, -16739, -17220, -17694, -18166, -18633, -19097, -19557, -20014, -20469, -20922, -21378, -21833, -22285, -22732, -23170, -23600, -24019, -24433, -24839, -25238, -25629, -26008, -26376, -26729, -27071, -27399, -27720, -28023, -28311, -28574, -28811, -29008, -29165, -29315, -29416, -29504, -29557, -29582, -29579, -29546, -29481, -29387, -29265, -29112, -28927, -28707, -28445, -28142, -27797, -27413, -26994, -26512, -26001, -25446, -24838, -24202, -23521, -22803, -22061, -21286, -20483, -19652, -18792, -17878, -16944, -15971, -14961, -13934, -12854, -11842, -10308, -8496, -7549, -6488, -5450, -4420, -3399, -2379, -1395, -432, 780, -7518, -7731, -4420, -2584, -827, 3655, 4704, 5679, 6610, 7505, 8353, 9177, 10026, 10464, 13647, 16137, 16729, 17653, 18492, 19302, 20081, 20827, 21546, 22230, 22880, 23497, 24080, 24628, 25150, 25644, 26109, 26547, 26953, 27325, 27666, 27972, 28247, 28496, 28715, 28909, 29075, 29213, 29327, 29420, 29496, 29557, 29609, 29649, 29676, 29688, 29686, 29667, 29632, 29579, 29511, 29425, 29319, 29191, 29045, 28880, 28702, 28507, 28305, 28089, 27858, 27617, 27359, 27084, 26799, 26497, 26184, 25856, 25510, 25158, 24791, 24416, 24038, 23657, 23278, 22879, 22505, 22113, 21728, 21341, 20948, 20556, 20162, 19722, 19289, 18829, 18348, 17866, 17371, 16878, 16388, 15896, 15404, 14910, 14409, 13902, 13395, 12882, 12366, 11845, 11314, 10767, 10220, 9668, 9127, 8566, 8247, 5049, 3783, 3782, 3526, 3319, 3118, 2926, 2739, 2555, 2376, 2197, 2017, 1842, 1671, 1509, 1362, 1219, 1072, 924, 774, 621, 464, 306, 144, -20, -192, -372, -551, -800, -643, -2732, -5209, -5245, -5673, -6037, -6397, -6760, -7122, -7486, -7852, -8224, -8627, -9026, -9454, -9889, -10342, -10820, -11283, -11776, -12269, -12770, -13274, -13779, -14283, -14791, -15299, -15814, -16336, -16865, -17399, -17937, -18472, -19001, -19523, -20033, -20538, -21037, -21529, -22017, -22500, -22976, -23448, -23916, -24382, -24849, -25313, -25773, -26226, -26668, -27100, -27522, -27934, -28340, -28735, -29121, -29495, -29853, -30199, -30528, -30844, -31153, -31439, -31710, -31954, -32172, -32347, -32481, -32607, -32681, -32740, -32766, -32760, -32724, -32658, -32557, -32428, -32266, -32075, -31850, -31587, -31281, -30932, -30541, -30108, -29641, -29108, -28545, -27935, -27273, -26580, -25842, -25066, -24264, -23427, -22561, -21666, -20741, -19760, -18759, -17718, -16638, -15540, -14352, -13469, -10848, -7375, -6742, -5740, -4805, -3886, -2982, -2091, -1250, -527, 452, -2062, -1589, 187, 1405, 2593};