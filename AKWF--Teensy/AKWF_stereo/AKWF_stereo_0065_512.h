/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0065 512 samples */
 
const int16_t AKWF_stereo_0065_512_DATA [512] = 
{1191, 3580, 5896, 8162, 10352, 12456, 14463, 16362, 18154, 19836, 21399, 22851, 24189, 25410, 26524, 27526, 28418, 29208, 29894, 30479, 30967, 31361, 31662, 31875, 32002, 32046, 32009, 31895, 31707, 31446, 31116, 30719, 30257, 29736, 29156, 28519, 27830, 27092, 26306, 25479, 24610, 23703, 22766, 21797, 20802, 19790, 18758, 17711, 16660, 15604, 14548, 13502, 12465, 11444, 10447, 9474, 8534, 7633, 6768, 5949, 5182, 4463, 3802, 3193, 2641, 2148, 1711, 1329, 999, 716, 480, 284, 127, 7, -81, -141, -171, -174, -151, -102, -30, 61, 169, 292, 426, 567, 715, 860, 1001, 1136, 1262, 1374, 1470, 1551, 1612, 1651, 1671, 1670, 1647, 1602, 1536, 1450, 1345, 1222, 1084, 932, 768, 592, 409, 220, 31, -163, -354, -544, -728, -905, -1071, -1224, -1360, -1472, -1553, -1595, -1552, -1520, -480, 1839, 2169, 2240, 2239, 2177, 2076, 1949, 1801, 1636, 1457, 1269, 1069, 864, 657, 445, 234, 26, -178, -375, -562, -740, -903, -1051, -1182, -1293, -1385, -1456, -1502, -1528, -1528, -1503, -1457, -1390, -1301, -1193, -1068, -927, -775, -614, -447, -278, -109, 56, 213, 361, 495, 613, 715, 795, 855, 892, 903, 884, 833, 747, 620, 443, 217, -62, -400, -799, -1259, -1782, -2368, -3013, -3718, -4477, -5294, -6155, -7063, -8013, -8994, -10011, -11055, -12116, -13193, -14285, -15379, -16474, -17567, -18650, -19723, -20777, -21810, -22817, -23797, -24741, -25653, -26524, -27349, -28128, -28860, -29537, -30160, -30724, -31225, -31662, -32030, -32328, -32552, -32700, -32765, -32748, -32644, -32452, -32165, -31785, -31305, -30724, -30038, -29244, -28339, -27327, -26195, -24950, -23592, -22115, -20523, -18824, -17013, -15100, -13100, -11017, -8880, -6721, -4643, -2432, -2473, -5084, -3336, -1060, 13554, 15104, 16425, 17612, 18692, 19687, 20613, 21472, 22277, 23033, 23739, 24405, 25028, 25610, 26156, 26661, 27129, 27562, 27957, 28317, 28644, 28936, 29191, 29415, 29608, 29767, 29898, 29996, 30064, 30104, 30116, 30100, 30058, 29986, 29890, 29769, 29623, 29453, 29257, 29040, 28797, 28533, 28247, 27936, 27605, 27253, 26877, 26482, 26069, 25632, 25179, 24707, 24215, 23707, 23183, 22644, 22091, 21528, 20952, 20371, 19785, 19198, 18610, 18031, 17461, 16910, 16380, 15878, 15416, 14995, 14623, 14312, 14058, 13865, 13731, 13652, 13624, 13637, 13684, 13758, 13851, 13953, 14061, 14174, 14278, 14377, 14466, 14542, 14603, 14648, 14680, 14690, 14685, 14662, 14621, 14563, 14487, 14395, 14286, 14158, 14016, 13857, 13684, 13496, 13296, 13082, 12849, 12607, 12351, 12082, 11796, 11494, 11180, 10848, 10493, 10118, 9714, 9281, 8810, 8290, 7700, 7016, 6144, 5302, 2194, -3773, -5298, -6238, -7029, -7683, -8254, -8773, -9244, -9682, -10089, -10472, -10832, -11171, -11490, -11791, -12074, -12335, -12582, -12806, -13013, -13194, -13359, -13502, -13622, -13721, -13799, -13851, -13879, -13885, -13870, -13830, -13767, -13683, -13577, -13452, -13304, -13142, -12962, -12769, -12565, -12352, -12134, -11915, -11704, -11505, -11321, -11162, -11043, -10960, -10930, -10958, -11048, -11205, -11426, -11711, -12057, -12456, -12902, -13390, -13910, -14453, -15021, -15604, -16195, -16794, -17396, -18002, -18605, -19206, -19802, -20392, -20975, -21553, -22121, -22678, -23228, -23770, -24300, -24821, -25332, -25831, -26317, -26795, -27255, -27706, -28142, -28562, -28967, -29355, -29722, -30072, -30403, -30709, -30992, -31250, -31480, -31680, -31851, -31989, -32094, -32160, -32192, -32185, -32137, -32047, -31912, -31736, -31512, -31241, -30923, -30556, -30139, -29671, -29152, -28577, -27947, -27256, -26502, -25682, -24779, -23793, -22706, -21485, -20101, -18490, -16418, -14406, -7133, 6083, 9527, 11767};