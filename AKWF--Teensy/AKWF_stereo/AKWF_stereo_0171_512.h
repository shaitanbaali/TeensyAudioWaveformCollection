/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0171 512 samples */
 
const int16_t AKWF_stereo_0171_512_DATA [512] = 
{9846, 22838, 23010, 23401, 23655, 23772, 23777, 23694, 23561, 23395, 23188, 22958, 22672, 22331, 21938, 21479, 20964, 20398, 19807, 19201, 18578, 17920, 17205, 16443, 15678, 14906, 14116, 13485, 12898, 12274, 11645, 11024, 10393, 9737, 9155, 9116, 9297, 9133, 8765, 8290, 7725, 7534, 7883, 8009, 7846, 7544, 7136, 6669, 6212, 5773, 5323, 4849, 4340, 3800, 3249, 2685, 2123, 1523, 1737, 3262, 4402, 4790, 4831, 4657, 4365, 4003, 3591, 3145, 2684, 2201, 1702, 1199, 688, 166, -361, -895, -1437, -1978, -2521, -3071, -3625, -4184, -4749, -5303, -5898, -6259, -5385, -4132, -3650, -3616, -3796, -4100, -4471, -4900, -4561, -3398, -2770, -2697, -2874, -3195, -3592, -4041, -4524, -5022, -5506, -5976, -6457, -6959, -7350, -8497, -5489, 3848, 6315, 5852, 5913, 5783, 5580, 5308, 4983, 4616, 4210, 3771, 3303, 2809, 2289, 1746, 1184, 579, 212, 230, 96, -271, -739, -1271, -1846, -2443, -3056, -3677, -4299, -4926, -5558, -6192, -6832, -7479, -8122, -8777, -9443, -10111, -10781, -11460, -12124, -12735, -13304, -13858, -14413, -14989, -15594, -16207, -16815, -17441, -18067, -18672, -19327, -20111, -20883, -21663, -22454, -23226, -23986, -24751, -25492, -25884, -25622, -25068, -24797, -24982, -25423, -25982, -26587, -27250, -27939, -28604, -29278, -29969, -30645, -31284, -31795, -33275, -16172, 6785, 8184, 8341, 8767, 8984, 9098, 9117, 9047, 8899, 8676, 8385, 8037, 7635, 7186, 6712, 6211, 5751, 5687, 6156, 6387, 6572, 7188, 7513, 7404, 7099, 6669, 6156, 5604, 4988, 4727, 5108, 5715, 6260, 6329, 6071, 5652, 5129, 4549, 3958, 3386, 2801, 2182, 1529, 844, 154, -499, -1132, -1799, -2454, -2496, -2040, -1544, -1293, -1482, -1898, -2439, -3046, -3689, -4368, -4735, -4736, -4963, -5444, -6035, -6699, -7402, -8116, 5918, 7113, 6292, 5478, 4638, 3769, 2872, 1984, 1092, 171, -721, -1602, -2507, -3439, -4400, -5375, -6409, -6935, -6506, -6326, -6714, -7349, -8114, -8903, -9681, -10490, -11335, -12061, -12755, -13432, -14077, -14727, -15411, -15475, -14877, -14622, -14758, -15149, -15695, -16309, -16968, -17607, -18174, -18771, -19439, -20140, -20682, -22327, -9894, 8282, 9992, 10068, 10404, 10934, 11875, 12491, 12757, 12833, 12905, 13075, 13091, 12928, 12666, 12281, 12030, 12684, 13497, 13691, 13572, 13279, 12871, 12442, 12052, 11655, 11220, 10688, 10396, 11321, 12407, 12695, 12580, 12265, 11838, 11334, 10775, 10236, 9869, 9524, 9048, 8487, 7864, 7221, 6560, 5878, 5330, 4821, 4185, 3421, 2602, 1790, 1023, 273, -503, -1363, -2143, -1911, -1235, -1180, -1505, -2130, -2112, -1066, -1173, -1839, -2495, -3239, -4039, -4878, -5743, -6633, -7528, -8517, -9601, -10682, -11819, -12307, -11738, -11605, -11281, -9961, -9222, -9282, -9716, -10377, -11140, -11945, -12818, -13397, -13554, -13969, -14695, -15549, -16494, -17357, -18178, -19032, -19904, -20769, -21630, -22487, -23407, -23538, -21568, -18747, -16951, -16340, -16336, -16642, -17113, -17709, -18360, -19034, -19763, -20541, -21308, -22137, -22760, -22315, -21687, -21757, -22163, -22668, -23172, -23687, -24262, -24933, -25668, -26418, -27169, -27913, -28149, -28034, -28228, -28669, -29188, -29726, -30231, -31831, -13272, 10706, 12561, 12948, 13448, 13670, 13754, 13751, 13695, 13566, 13368, 13141, 12865, 12507, 12069, 11582, 11039, 10447, 9886, 9446, 9035, 8625, 8219, 7571, 6973, 5189, 8926, 24729, 30202, 29337, 29525, 29497, 29427, 29276, 28980, 28625, 28255, 27815, 27299, 26716, 26052, 25294, 24611, 24371, 24198, 23751, 23143, 22406, 21586, 20740, 19945, 19175, 18406, 17565, 16617, 15644, 14663, 13693, 12744, 11796, 10876, 9990, 9069, 8093, 7072, 6045, 5014, 3948};