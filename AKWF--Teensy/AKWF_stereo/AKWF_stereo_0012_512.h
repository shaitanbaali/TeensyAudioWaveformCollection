/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0012 512 samples */
 
const int16_t AKWF_stereo_0012_512_DATA [512] = 
{249, 968, -595, 12556, 25162, 24071, 26027, 27096, 26462, 26248, 24610, 23800, 22799, 21926, 21745, 21139, 21319, 21374, 21790, 22295, 22828, 23572, 24222, 25038, 25725, 26478, 27240, 27903, 28496, 29148, 29772, 30347, 30886, 31385, 31838, 32256, 32641, 32781, 32763, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32763, 32579, 32322, 32059, 31779, 31484, 31174, 30851, 30354, 29965, 29609, 29229, 28836, 28433, 28016, 27588, 27139, 26741, 26288, 25821, 25313, 24674, 24172, 23666, 23150, 22629, 22099, 21562, 21020, 20471, 19916, 19357, 18804, 18187, 17515, 16957, 16386, 15817, 15246, 14676, 14107, 13540, 12975, 12411, 11849, 11298, 10687, 10084, 9553, 9014, 8483, 7958, 7440, 6925, 6419, 5921, 5428, 4946, 4467, 3959, 3485, 3040, 2599, 2169, 1747, 1334, 935, 519, 173, -177, -549, -1264, 287, -12784, -25352, -24286, -26232, -27293, -26674, -26469, -24866, -24076, -23097, -22251, -22052, -21433, -21667, -21716, -22132, -22634, -23166, -23905, -24547, -25339, -26065, -26816, -27574, -28233, -28822, -29470, -30090, -30660, -31195, -31690, -32134, -32568, -32780, -32764, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32766, -32769, -32610, -32336, -32061, -31766, -31471, -31083, -30605, -30268, -29903, -29527, -29136, -28735, -28320, -27894, -27457, -27008, -26545, -26090, -25510, -24923, -24444, -23934, -23421, -22901, -22373, -21838, -21298, -20751, -20197, -19641, -19087, -18418, -17804, -17249, -16680, -16113, -15544, -14976, -14412, -13832, -13278, -12786, -12218, -11655, -11018, -10455, -9918, -9379, -8846, -8321, -7801, -7285, -6778, -6278, -5784, -5301, -4807, -4295, -3837, -3387, -2945, -2513, -2089, -1674, -1271, -875, -490, -109, 4184, 4861, 3215, 16556, 27120, 20974, 24267, 27641, 27058, 28147, 26769, 26847, 26350, 25772, 25988, 25273, 25560, 25341, 25563, 25774, 25931, 26372, 26603, 27092, 27401, 27822, 28267, 28613, 28937, 29318, 29718, 30076, 30422, 30753, 31047, 31330, 31576, 31804, 32000, 32193, 32251, 32262, 32374, 32442, 32486, 32507, 32505, 32481, 32432, 32363, 32269, 32153, 32038, 31741, 31488, 31309, 31092, 30859, 30609, 30339, 30053, 29748, 29427, 29090, 28735, 28366, 27813, 27373, 26968, 26537, 26091, 25635, 25164, 24681, 24172, 23718, 23210, 22685, 22119, 21414, 20856, 20292, 19719, 19141, 18556, 17965, 17370, 16772, 16169, 15566, 14966, 14306, 13589, 12992, 12386, 11781, 11177, 10577, 9979, 9385, 8796, 8211, 7629, 7060, 6435, 5818, 5278, 4731, 4194, 3667, 3148, 2635, 2134, 1642, 1158, 687, 222, -269, -725, -1150, -1568, -1975, -2369, -2754, -3122, -3506, -3818, -4131, -4465, -5139, -3505, -16767, -27263, -21113, -24413, -27797, -27237, -28339, -26996, -27090, -26615, -26062, -26261, -25535, -25873, -25649, -25870, -26080, -26236, -26672, -26896, -27366, -27714, -28135, -28579, -28923, -29246, -29625, -30023, -30377, -30721, -31048, -31338, -31619, -31862, -32086, -32278, -32468, -32524, -32532, -32643, -32706, -32749, -32767, -32763, -32735, -32691, -32621, -32518, -32417, -32258, -31937, -31761, -31570, -31357, -31126, -30879, -30611, -30328, -30025, -29707, -29369, -29030, -28593, -28061, -27674, -27259, -26832, -26388, -25934, -25465, -24983, -24489, -23984, -23464, -22952, -22309, -21660, -21125, -20557, -19987, -19411, -18827, -18238, -17644, -17047, -16448, -15845, -15246, -14530, -13874, -13280, -12675, -12072, -11470, -10871, -10277, -9671, -9091, -8579, -7991, -7410, -6757, -6181, -5634, -5087, -4549, -4020, -3500, -2985, -2482, -1989, -1504, -1032, -551, -55, 385, 815, 1235, 1643, 2040, 2427, 2800, 3163, 3514, 3859};