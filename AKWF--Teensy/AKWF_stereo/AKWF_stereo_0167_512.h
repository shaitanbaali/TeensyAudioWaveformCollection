/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0167 512 samples */
 
const int16_t AKWF_stereo_0167_512_DATA [512] = 
{713, 2546, 4978, 7412, 8961, 10556, 12043, 13636, 15950, 18584, 21259, 23648, 25536, 26709, 27807, 28890, 29834, 30190, 30432, 30823, 31427, 31382, 30875, 29999, 28648, 26823, 24765, 22598, 20730, 19208, 16868, 13817, 10920, 8222, 5244, 2618, -25, -2333, -4504, -6500, -8600, -10780, -12783, -14863, -16475, -18015, -19270, -20538, -21807, -23222, -24495, -25299, -26442, -26909, -27002, -26673, -26319, -25607, -24458, -23683, -22741, -21873, -20451, -19172, -18145, -16854, -15134, -13998, -12955, -11263, -9035, -6787, -5026, -3500, -2303, -839, 1347, 3844, 6674, 9192, 10890, 11242, 11255, 11445, 11923, 12204, 12817, 13999, 15254, 15774, 16033, 15963, 15738, 15507, 14928, 14133, 13473, 12802, 11490, 10260, 9390, 8483, 7574, 6473, 5482, 4883, 4487, 4555, 4811, 5226, 5514, 5455, 5054, 4709, 4373, 4088, 3624, 2849, 2205, 1501, 779, 149, -233, -436, -238, 61, -109, -657, -1450, -2279, -2912, -3469, -3769, -3813, -4021, -4551, -5270, -5780, -6213, -6462, -6895, -7457, -7890, -8066, -8123, -7975, -7717, -7955, -8350, -9218, -10076, -11191, -12170, -12870, -12991, -12643, -12262, -11687, -11179, -10455, -9546, -8483, -7725, -7181, -6311, -5534, -4349, -3096, -1249, 460, 1749, 2697, 3689, 5054, 6285, 7197, 8535, 9821, 10773, 11347, 11593, 11774, 11662, 11163, 10411, 9648, 9356, 9538, 9749, 9869, 10041, 10218, 10337, 10666, 11139, 11431, 11792, 12307, 13105, 13447, 13241, 12818, 11980, 11154, 10215, 9138, 7778, 6500, 4720, 2404, 379, -1066, -2444, -3793, -5002, -6687, -8158, -9268, -9982, -11053, -12232, -13563, -15105, -16154, -17052, -17607, -17888, -18371, -19176, -20558, -22138, -23185, -23114, -22801, -22100, -21322, -20905, -20347, -20225, -19645, -19553, -18928, -18150, -17213, -15882, -14434, -12221, -10986, -9570, -8188, -6198, -4794, -3897, -3072, -1762, -646, -23027, -23287, -21197, -18272, -16824, -15481, -15211, -14403, -12012, -8346, -3486, 997, 5063, 6854, 8958, 10564, 13957, 16876, 19834, 23686, 28526, 31742, 32283, 31103, 29204, 26951, 24498, 23142, 22909, 23524, 21381, 17311, 13498, 10070, 7838, 7207, 7493, 8531, 8999, 8157, 6378, 4665, 3288, 1331, -288, -930, -818, -976, -2851, -5841, -9273, -12490, -16140, -18183, -18810, -18415, -18021, -18541, -19488, -20432, -21480, -22385, -22231, -21250, -20163, -18695, -16912, -16065, -16054, -15757, -14903, -13445, -12148, -11214, -10358, -10231, -9781, -8725, -7738, -7298, -7020, -8023, -9464, -9735, -9716, -10010, -9868, -9311, -9362, -9840, -9844, -9135, -7016, -4634, -3603, -3270, -2881, -2109, -1665, -191, 1554, 3416, 5665, 7156, 8867, 11002, 14377, 17011, 19337, 21887, 25033, 27553, 28322, 28586, 28895, 28593, 28154, 27949, 28374, 29289, 29344, 28271, 26754, 25277, 24878, 25234, 25879, 26136, 26026, 24895, 23329, 22060, 21741, 21752, 21798, 22402, 23274, 23310, 21958, 19697, 16503, 13037, 9944, 7087, 4429, 2002, -1165, -5757, -10339, -14445, -17763, -20793, -23509, -25824, -27794, -28972, -29594, -29882, -30149, -30420, -30722, -31091, -31573, -31964, -32169, -32583, -32596, -32644, -32706, -32248, -31771, -31364, -30889, -30178, -29841, -29679, -28606, -27335, -26457, -25978, -25809, -25303, -24429, -23807, -23296, -22145, -20394, -18245, -16476, -14914, -12760, -9585, -6106, -1956, 2386, 6410, 9943, 12595, 15092, 17091, 19128, 20850, 22818, 25270, 27285, 28362, 28511, 28360, 28058, 27520, 26656, 26342, 25949, 25242, 24544, 23082, 21809, 21103, 20897, 19612, 18114, 16647, 15096, 14088, 12997, 12257, 11728, 10928, 9113, 6334, 3327, 937, -304, -1965, -3409, -5033, -7016, -8521, -10247, -10674, -11679, -12445, -13645, -14890, -15990, -17082, -16192, -16741, -17010, -17174, -16170, -16187, -17163, -18555, -19281, -21324};