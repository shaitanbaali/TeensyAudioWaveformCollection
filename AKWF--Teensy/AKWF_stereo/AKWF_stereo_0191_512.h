/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0191 512 samples */
 
const int16_t AKWF_stereo_0191_512_DATA [512] = 
{734, 3384, 6039, 8734, 11373, 13910, 16378, 18725, 20946, 23020, 24903, 26608, 28125, 29423, 30504, 31389, 32054, 32485, 32724, 32763, 32599, 32245, 31719, 30999, 30083, 29048, 27863, 26538, 25143, 23671, 22118, 20541, 18967, 17387, 15820, 14319, 12876, 11478, 10177, 8964, 7818, 6759, 5801, 4913, 4083, 3329, 2620, 1938, 1281, 634, -23, -702, -1412, -2166, -2975, -3847, -4782, -5787, -6862, -8003, -9207, -10462, -11762, -13094, -14440, -15784, -17120, -18422, -19659, -20841, -21941, -22921, -23795, -24549, -25140, -25591, -25897, -26024, -25974, -25776, -25408, -24847, -24146, -23306, -22298, -21162, -19940, -18611, -17190, -15746, -14275, -12782, -11323, -9919, -8573, -7308, -6168, -5153, -4257, -3515, -2928, -2485, -2192, -2056, -2058, -2187, -2439, -2794, -3229, -3732, -4282, -4854, -5421, -5973, -6485, -6927, -7289, -7555, -7697, -7716, -7600, -7334, -6919, -6361, -5662, -4814, -3844, -2760, -1562, -283, 1055, 2444, 3853, 5256, 6640, 7969, 9230, 10406, 11469, 12408, 13218, 13879, 14379, 14726, 14916, 14939, 14806, 14535, 14121, 13570, 12923, 12180, 11348, 10468, 9560, 8636, 7714, 6838, 6010, 5249, 4588, 4033, 3588, 3278, 3109, 3071, 3173, 3416, 3789, 4280, 4886, 5589, 6365, 7200, 8077, 8967, 9845, 10705, 11513, 12244, 12890, 13434, 13850, 14129, 14271, 14260, 14077, 13745, 13258, 12600, 11792, 10855, 9781, 8583, 7299, 5928, 4485, 3012, 1516, 21, -1446, -2868, -4227, -5512, -6700, -7782, -8753, -9604, -10334, -10939, -11423, -11796, -12061, -12218, -12297, -12305, -12243, -12143, -12021, -11882, -11742, -11633, -11558, -11516, -11540, -11632, -11787, -12014, -12324, -12704, -13139, -13641, -14193, -14768, -15360, -15965, -16536, -17071, -17557, -17957, -18246, -18433, -18480, -18353, -18067, -17603, -16934, -16050, -14974, -13681, -12153, -10438, -8529, -6424, -4171, -1728, -3216, -818, 1636, 4186, 6742, 9259, 11774, 14232, 16621, 18917, 21075, 23095, 24956, 26622, 28087, 29355, 30400, 31198, 31776, 32124, 32235, 32116, 31766, 31164, 30301, 29244, 27960, 26454, 24795, 22970, 20978, 18879, 16697, 14437, 12121, 9809, 7500, 5200, 2971, 830, -1230, -3180, -4993, -6682, -8235, -9639, -10906, -12030, -13015, -13875, -14609, -15220, -15734, -16156, -16482, -16742, -16946, -17089, -17186, -17262, -17311, -17326, -17342, -17351, -17340, -17322, -17312, -17285, -17232, -17182, -17109, -16991, -16847, -16673, -16431, -16145, -15808, -15394, -14902, -14353, -13728, -13006, -12226, -11377, -10444, -9449, -8412, -7323, -6193, -5059, -3912, -2765, -1643, -559, 477, 1453, 2349, 3155, 3865, 4464, 4948, 5310, 5548, 5661, 5652, 5517, 5271, 4921, 4468, 3932, 3327, 2664, 1961, 1237, 506, -212, -901, -1544, -2122, -2627, -3040, -3350, -3550, -3632, -3593, -3427, -3140, -2734, -2211, -1586, -872, -76, 783, 1690, 2630, 3578, 4519, 5434, 6301, 7103, 7827, 8452, 8962, 9353, 9615, 9729, 9701, 9532, 9215, 8747, 8155, 7434, 6591, 5652, 4629, 3535, 2392, 1221, 40, -1126, -2255, -3327, -4322, -5222, -6008, -6668, -7188, -7562, -7780, -7834, -7728, -7461, -7033, -6456, -5743, -4897, -3931, -2869, -1724, -512, 741, 2016, 3296, 4564, 5796, 6975, 8087, 9114, 10043, 10863, 11562, 12141, 12587, 12895, 13079, 13131, 13046, 12852, 12543, 12119, 11606, 11014, 10343, 9603, 8826, 8011, 7156, 6293, 5431, 4560, 3699, 2861, 2036, 1226, 450, -304, -1038, -1750, -2444, -3125, -3798, -4468, -5138, -5814, -6503, -7206, -7925, -8663, -9421, -10196, -10983, -11782, -12588, -13386, -14166, -14934, -15653, -16323, -16940, -17474, -17902, -18238, -18452, -18511, -18430, -18194, -17773, -17162, -16379, -15398, -14199, -12819, -11251, -9482, -7547, -5409};