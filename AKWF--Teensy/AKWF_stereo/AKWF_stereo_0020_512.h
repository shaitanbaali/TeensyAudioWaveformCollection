/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0020 512 samples */
 
const int16_t AKWF_stereo_0020_512_DATA [512] = 
{307, 1439, 2560, 3693, 4807, 5896, 6959, 7994, 9004, 9988, 10945, 11878, 12785, 13666, 14523, 15355, 16162, 16946, 17706, 18441, 19156, 19847, 20514, 21162, 21786, 22389, 22973, 23535, 24077, 24601, 25104, 25588, 26054, 26500, 26930, 27342, 27735, 28112, 28474, 28817, 29146, 29459, 29755, 30037, 30304, 30554, 30792, 31016, 31224, 31419, 31600, 31768, 31921, 32062, 32191, 32306, 32407, 32497, 32572, 32637, 32688, 32726, 32751, 32765, 32767, 32756, 32732, 32696, 32647, 32586, 32512, 32426, 32327, 32214, 32090, 31951, 31799, 31634, 31456, 31263, 31058, 30837, 30602, 30353, 30089, 29810, 29517, 29208, 28882, 28541, 28184, 27809, 27418, 27009, 26583, 26140, 25677, 25197, 24698, 24177, 23639, 23080, 22500, 21902, 21280, 20637, 19973, 19286, 18576, 17845, 17088, 16309, 15506, 14677, 13825, 12950, 12046, 11118, 10166, 9186, 8180, 7157, 6120, 5075, 4019, 2948, 1870, 780, -323, -1435, -2559, -3693, -4807, -5896, -6959, -7994, -9005, -9989, -10945, -11878, -12786, -13666, -14523, -15356, -16162, -16947, -17706, -18442, -19156, -19848, -20515, -21162, -21787, -22390, -22973, -23536, -24078, -24601, -25104, -25588, -26054, -26501, -26930, -27342, -27737, -28112, -28474, -28818, -29146, -29459, -29755, -30037, -30304, -30555, -30792, -31016, -31224, -31419, -31601, -31768, -31922, -32062, -32191, -32306, -32407, -32497, -32573, -32637, -32688, -32727, -32751, -32765, -32767, -32756, -32732, -32696, -32647, -32586, -32512, -32426, -32327, -32215, -32089, -31951, -31799, -31635, -31456, -31263, -31058, -30837, -30603, -30354, -30090, -29811, -29518, -29208, -28882, -28542, -28184, -27809, -27418, -27010, -26584, -26141, -25677, -25197, -24698, -24178, -23640, -23081, -22500, -21902, -21281, -20638, -19974, -19286, -18577, -17846, -17089, -16309, -15507, -14678, -13825, -12950, -12047, -11119, -10167, -9186, -8181, -7158, -6121, -5076, -4019, -2951, -1875, -767, 777, 1458, 2123, 2787, 3453, 4117, 4779, 5437, 6095, 6753, 7406, 8057, 8708, 9353, 9998, 10641, 11278, 11915, 12550, 13181, 13810, 14436, 15060, 15682, 16301, 16918, 17535, 18148, 18761, 19372, 19981, 20589, 21199, 21808, 22416, 23028, 23642, 24260, 24885, 25506, 26126, 26753, 27417, 28237, 28919, 29457, 29942, 30375, 30765, 31116, 31431, 31709, 31954, 32167, 32348, 32496, 32612, 32696, 32747, 32768, 32754, 32706, 32621, 32499, 32331, 32110, 31829, 31338, 30829, 30484, 30160, 29847, 29538, 29226, 28909, 28585, 28253, 27914, 27563, 27201, 26830, 26447, 26053, 25649, 25233, 24805, 24369, 23919, 23460, 22991, 22511, 22020, 21521, 21009, 20491, 19962, 19422, 18877, 18323, 17758, 17187, 16609, 16023, 15429, 14829, 14221, 13609, 12991, 12367, 11737, 11102, 10464, 9822, 9174, 8522, 7870, 7213, 6552, 5892, 5226, 4560, 3896, 3227, 2558, 1889, 1219, 549, -118, -787, -1457, -2123, -2789, -3455, -4118, -4780, -5438, -6096, -6754, -7407, -8058, -8708, -9353, -9999, -10641, -11280, -11916, -12550, -13182, -13811, -14436, -15061, -15683, -16302, -16919, -17535, -18149, -18761, -19372, -19981, -20590, -21199, -21808, -22416, -23028, -23642, -24260, -24886, -25506, -26126, -26753, -27417, -28238, -28919, -29457, -29942, -30375, -30765, -31116, -31431, -31709, -31954, -32167, -32348, -32496, -32612, -32696, -32747, -32768, -32754, -32706, -32621, -32499, -32331, -32110, -31829, -31338, -30829, -30484, -30160, -29847, -29538, -29226, -28909, -28585, -28253, -27914, -27563, -27202, -26830, -26448, -26053, -25649, -25233, -24806, -24369, -23919, -23461, -22992, -22511, -22020, -21522, -21010, -20490, -19962, -19423, -18877, -18323, -17759, -17188, -16609, -16023, -15429, -14829, -14222, -13610, -12991, -12368, -11738, -11103, -10465, -9823, -9175, -8523, -7871, -7213, -6553, -5893, -5227, -4561, -3897, -3228, -2559, -1890, -1221, -554, 126};