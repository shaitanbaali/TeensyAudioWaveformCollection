/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0195 512 samples */
 
const int16_t AKWF_stereo_0195_512_DATA [512] = 
{1205, 3134, 4877, 6512, 8035, 9452, 10783, 12023, 13184, 14270, 15282, 16219, 17118, 17982, 18769, 19512, 20205, 20847, 21442, 22007, 22537, 23021, 23488, 23929, 24318, 24685, 25041, 25349, 25645, 25932, 26184, 26403, 26622, 26825, 26989, 27165, 27351, 27512, 27663, 27835, 27996, 28129, 28288, 28450, 28587, 28730, 28892, 29040, 29167, 29322, 29482, 29612, 29760, 29919, 30054, 30169, 30306, 30408, 30496, 30612, 30723, 30802, 30903, 30996, 31042, 31080, 31135, 31166, 31166, 31192, 31215, 31203, 31207, 31225, 31223, 31204, 31207, 31195, 31137, 31092, 31042, 30945, 30827, 30717, 30577, 30392, 30219, 30021, 29766, 29494, 29208, 28874, 28488, 28099, 27685, 27221, 26767, 26311, 25810, 25313, 24811, 24264, 23681, 23098, 22472, 21785, 21095, 20372, 19598, 18814, 18021, 17194, 16340, 15494, 14638, 13747, 12854, 11955, 11016, 10042, 9058, 8039, 6971, 5883, 4764, 3593, 2426, 1303, 200, -879, -1927, -2962, -3985, -4996, -5994, -6980, -7956, -8921, -9874, -10816, -11744, -12652, -13530, -14376, -15195, -15987, -16734, -17454, -18146, -18793, -19418, -20020, -20572, -21099, -21618, -22105, -22560, -23015, -23450, -23845, -24222, -24582, -24901, -25188, -25476, -25738, -25959, -26189, -26412, -26601, -26786, -26983, -27164, -27324, -27504, -27665, -27798, -27948, -28093, -28201, -28325, -28460, -28573, -28679, -28810, -28944, -29058, -29211, -29390, -29558, -29737, -29937, -30120, -30268, -30438, -30601, -30719, -30837, -30957, -31039, -31088, -31149, -31188, -31179, -31180, -31170, -31117, -31042, -30977, -30892, -30769, -30669, -30570, -30435, -30315, -30219, -30089, -29977, -29891, -29798, -29697, -29630, -29561, -29456, -29369, -29297, -29196, -29078, -28972, -28839, -28653, -28465, -28243, -27949, -27609, -27231, -26779, -26246, -25678, -25047, -24316, -23529, -22678, -21724, -20664, -19521, -18255, -16831, -15290, -13617, -11770, -9772, -7634, -5311, -2958, -764, 7931, 10015, 11923, 13722, 15405, 16982, 18463, 19828, 21098, 22278, 23353, 24326, 25246, 26113, 26865, 27547, 28153, 28667, 29105, 29484, 29780, 29974, 30122, 30214, 30218, 30177, 30105, 29954, 29776, 29573, 29315, 29020, 28748, 28483, 28196, 27939, 27712, 27470, 27231, 27036, 26856, 26676, 26559, 26475, 26394, 26347, 26348, 26359, 26375, 26441, 26526, 26590, 26682, 26790, 26879, 26962, 27084, 27188, 27290, 27421, 27548, 27646, 27769, 27904, 28015, 28132, 28272, 28401, 28505, 28636, 28766, 28854, 28945, 29037, 29096, 29128, 29171, 29194, 29165, 29137, 29091, 28983, 28842, 28692, 28495, 28237, 27973, 27678, 27325, 26955, 26581, 26167, 25713, 25261, 24785, 24253, 23719, 23171, 22569, 21956, 21327, 20649, 19937, 19224, 18469, 17659, 16844, 16002, 15114, 14208, 13281, 12314, 11313, 10312, 9302, 8269, 7240, 6226, 5208, 4189, 3188, 2180, 1153, 125, -924, -2006, -3077, -4101, -5084, -6024, -6920, -7790, -8633, -9463, -10283, -11093, -11897, -12700, -13500, -14294, -15098, -15910, -16717, -17519, -18332, -19147, -19953, -20771, -21588, -22382, -23183, -23983, -24752, -25507, -26257, -26966, -27629, -28280, -28886, -29423, -29937, -30425, -30852, -31235, -31602, -31916, -32152, -32368, -32545, -32649, -32718, -32765, -32755, -32677, -32583, -32426, -32199, -31961, -31683, -31333, -30968, -30586, -30153, -29696, -29255, -28807, -28325, -27877, -27447, -27001, -26578, -26203, -25837, -25474, -25167, -24888, -24611, -24383, -24200, -24032, -23877, -23776, -23693, -23608, -23573, -23574, -23584, -23621, -23707, -23811, -23916, -24068, -24254, -24430, -24626, -24853, -25050, -25265, -25500, -25727, -25938, -26168, -26385, -26546, -26696, -26824, -26896, -26920, -26918, -26857, -26717, -26544, -26310, -25973, -25569, -25102, -24534, -23854, -23103, -22248, -21268, -20204, -19052, -17780, -16390, -14920, -13340, -11625, -9820, -7908, -5852, -3677, -1392, 1047, 3505, 5827};