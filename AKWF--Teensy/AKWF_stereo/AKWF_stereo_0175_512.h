/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0175 512 samples */
 
const int16_t AKWF_stereo_0175_512_DATA [512] = 
{740, 2121, 3517, 4911, 6249, 7500, 8636, 9647, 10522, 11295, 11988, 12626, 13223, 13760, 14367, 14694, 14674, 15307, 15857, 16374, 16823, 17224, 17592, 17944, 18337, 18768, 19217, 19663, 20088, 20452, 20735, 20960, 21127, 21201, 21200, 21131, 20970, 20732, 20467, 20181, 19879, 19621, 19400, 19185, 19006, 18870, 18759, 18658, 18598, 18556, 18482, 18385, 18281, 18137, 17930, 17687, 17375, 16942, 16432, 15833, 15104, 14231, 13234, 12087, 10822, 9498, 8149, 6822, 5589, 4461, 3443, 2558, 1819, 1220, 703, 325, 52, -193, -484, -875, -1408, -2090, -2884, -3757, -4653, -5536, -6381, -7168, -7886, -8507, -9011, -9364, -9565, -9617, -9519, -9309, -9006, -8611, -8116, -7522, -6792, -5955, -5036, -4016, -2922, -1818, -739, 303, 1282, 2166, 2928, 3597, 4189, 4705, 5167, 5593, 6023, 6500, 7066, 7740, 8526, 9410, 10375, 11391, 12424, 13505, 14266, 15169, 16077, 16805, 17315, 17548, 17511, 17219, 16693, 15972, 15096, 14058, 12846, 11485, 10009, 8449, 6882, 5378, 3947, 2622, 1393, 203, -1000, -2235, -3515, -4862, -6268, -7735, -9300, -10986, -12831, -14857, -17045, -19315, -21550, -23697, -25677, -27453, -28971, -30204, -31188, -31929, -32416, -32682, -32768, -32681, -32452, -32195, -31884, -31535, -31209, -30871, -30453, -29971, -29403, -28700, -27863, -26955, -25957, -24832, -23632, -22365, -20999, -19537, -18026, -16456, -14815, -13173, -11523, -9842, -8188, -6581, -5017, -3528, -2146, -887, 320, 1244, 1345, 2146, 2727, 3078, 3181, 3050, 2733, 2296, 1813, 1345, 926, 565, 256, -22, -287, -567, -872, -1224, -1669, -2226, -2926, -3818, -4881, -6075, -7335, -8565, -9695, -10658, -11404, -11927, -12264, -12414, -12390, -12212, -11899, -11470, -10966, -10432, -9881, -9341, -8834, -8342, -7843, -7336, -6796, -6188, -5498, -4722, -3829, -2827, -1742, -518, 25879, 24623, 23316, 21961, 20646, 19369, 18091, 16844, 15614, 14363, 13103, 11879, 10670, 9464, 8275, 7012, 5599, 4092, 2412, 575, -1377, -3337, -5220, -6970, -8518, -9864, -11024, -12017, -12866, -13573, -14137, -14580, -14921, -15222, -15498, -15761, -16000, -16172, -16232, -16122, -15796, -15286, -14632, -13880, -13101, -12352, -11639, -10939, -10271, -9619, -8910, -8159, -7374, -6544, -5677, -4778, -3826, -2814, -1752, -670, 399, 1392, 2304, 3033, 3116, 3757, 4373, 4965, 5509, 5973, 6374, 6718, 7044, 7393, 7779, 8232, 8730, 9216, 9643, 9973, 10166, 10226, 10230, 10177, 10077, 9946, 9769, 9515, 9182, 8801, 8372, 7929, 7486, 7063, 6700, 6384, 6112, 5878, 5703, 5643, 5727, 5967, 6364, 6849, 7345, 7763, 8037, 8110, 7995, 7718, 7311, 6807, 6267, 5705, 5144, 4625, 4188, 3881, 3739, 3774, 3931, 4148, 4431, 4732, 5034, 5354, 5681, 6086, 6547, 7023, 7467, 7804, 8002, 8029, 7858, 7489, 6928, 6168, 5207, 4071, 2798, 1394, -20, -1341, -2558, -3566, -4338, -4928, -5393, -5804, -6219, -6676, -7200, -7813, -8524, -9360, -10389, -11662, -13184, -14921, -16765, -18635, -20447, -22162, -23748, -25202, -26563, -27884, -29116, -30183, -31061, -31714, -32152, -32467, -32636, -32685, -32700, -32685, -32613, -32520, -32422, -32300, -32198, -32197, -32257, -32342, -32475, -32584, -32544, -32295, -31835, -31106, -30106, -28948, -27663, -26253, -24798, -23300, -21725, -20101, -18503, -16946, -15371, -14007, -13308, -11848, -10376, -8898, -7420, -5945, -4525, -3154, -1789, -419, 983, 2467, 4054, 5723, 7472, 9252, 11035, 12790, 14475, 16063, 17544, 18874, 20044, 21040, 21841, 22566, 22735, 23039, 23591, 24126, 24738, 25402, 26085, 26806, 27532, 28212, 28871, 29517, 30108, 30619, 31069, 31403, 31550, 31549, 31415, 31123, 30702, 30207, 29612, 28870, 28024, 27012};