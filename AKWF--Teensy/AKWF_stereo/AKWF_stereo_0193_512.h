/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0193 512 samples */
 
const int16_t AKWF_stereo_0193_512_DATA [512] = 
{2197, 7303, 12173, 16735, 20779, 24175, 26866, 28821, 30090, 30737, 30828, 30460, 29751, 28788, 27631, 26401, 25156, 23906, 22702, 21598, 20576, 19647, 18865, 18216, 17688, 17312, 17085, 16961, 16911, 16920, 16911, 16803, 16565, 16138, 15454, 14502, 13309, 11876, 10246, 8531, 6790, 5097, 3554, 2217, 1102, 210, -473, -1022, -1501, -1980, -2538, -3231, -4081, -5096, -6243, -7472, -8711, -9880, -10910, -11751, -12371, -12767, -12974, -13060, -13096, -13168, -13381, -13801, -14456, -15377, -16540, -17860, -19251, -20628, -21859, -22830, -23484, -23758, -23602, -23038, -22120, -20881, -19390, -17788, -16132, -14501, -13002, -11658, -10477, -9483, -8663, -7970, -7376, -6870, -6412, -5975, -5569, -5182, -4797, -4412, -4030, -3626, -3178, -2686, -2128, -1506, -839, -164, 469, 990, 1314, 1361, 1057, 348, -785, -2317, -4194, -6301, -8477, -10547, -12317, -13610, -14269, -14179, -13285, -11563, -9061, -5917, -2293, 1587, 5484, 9178, 12455, 15167, 17222, 18573, 19229, 19246, 18698, 17673, 16298, 14690, 12937, 11150, 9426, 7803, 6326, 5048, 3975, 3113, 2488, 2105, 1960, 2052, 2380, 2911, 3602, 4413, 5275, 6110, 6852, 7442, 7832, 7988, 7922, 7659, 7241, 6756, 6282, 5893, 5662, 5643, 5852, 6275, 6883, 7608, 8357, 9063, 9644, 10028, 10186, 10120, 9849, 9413, 8901, 8382, 7917, 7568, 7373, 7319, 7361, 7454, 7502, 7402, 7071, 6438, 5447, 4080, 2381, 415, -1723, -3900, -5983, -7862, -9431, -10623, -11406, -11788, -11820, -11561, -11096, -10531, -9956, -9446, -9071, -8872, -8851, -8997, -9299, -9712, -10185, -10697, -11214, -11700, -12146, -12551, -12894, -13159, -13353, -13454, -13425, -13262, -12965, -12512, -11918, -11242, -10527, -9829, -9258, -8903, -8820, -9072, -9697, -10653, -11878, -13268, -14663, -15878, -16747, -17089, -16736, -15584, -13575, -10685, -6979, -2517, -1229, 3996, 9130, 14097, 18667, 22674, 26015, 28625, 30535, 31802, 32503, 32755, 32701, 32441, 32049, 31640, 31252, 30878, 30500, 30114, 29644, 29031, 28299, 27399, 26295, 25044, 23675, 22188, 20621, 19037, 17425, 15759, 14063, 12310, 10431, 8409, 6261, 3957, 1515, -973, -3469, -5894, -8138, -10135, -11828, -13172, -14173, -14857, -15272, -15506, -15646, -15763, -15941, -16233, -16643, -17162, -17764, -18372, -18903, -19309, -19527, -19503, -19248, -18806, -18213, -17544, -16926, -16429, -16106, -16030, -16208, -16586, -17095, -17665, -18158, -18442, -18444, -18080, -17287, -16080, -14526, -12681, -10651, -8606, -6656, -4904, -3466, -2372, -1624, -1208, -1059, -1085, -1189, -1293, -1306, -1172, -866, -384, 260, 1028, 1868, 2736, 3591, 4389, 5115, 5748, 6271, 6676, 6944, 7045, 6949, 6612, 5983, 5028, 3727, 2078, 109, -2098, -4438, -6771, -8919, -10709, -11984, -12600, -12469, -11542, -9834, -7443, -4495, -1194, 2232, 5578, 8623, 11193, 13175, 14497, 15158, 15211, 14742, 13862, 12722, 11453, 10153, 8924, 7832, 6882, 6062, 5362, 4726, 4104, 3471, 2802, 2091, 1352, 616, -85, -722, -1265, -1708, -2062, -2352, -2610, -2884, -3205, -3603, -4083, -4631, -5200, -5734, -6151, -6380, -6351, -6004, -5319, -4304, -2995, -1462, 203, 1894, 3511, 4982, 6237, 7256, 8046, 8644, 9112, 9521, 9937, 10430, 11023, 11706, 12462, 13223, 13887, 14373, 14595, 14465, 13941, 13039, 11789, 10252, 8563, 6848, 5218, 3804, 2703, 1945, 1541, 1453, 1587, 1833, 2074, 2178, 2032, 1568, 741, -447, -1946, -3682, -5550, -7442, -9253, -10890, -12288, -13412, -14253, -14826, -15157, -15302, -15304, -15191, -15003, -14774, -14502, -14197, -13891, -13591, -13308, -13103, -13024, -13100, -13377, -13903, -14655, -15607, -16705, -17823, -18813, -19542, -19834, -19512, -18460, -16602, -13877, -10320, -5941};