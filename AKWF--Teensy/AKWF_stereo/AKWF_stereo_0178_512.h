/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0178 512 samples */
 
const int16_t AKWF_stereo_0178_512_DATA [512] = 
{429, 1324, 2217, 3124, 4038, 4955, 5882, 6811, 7727, 8626, 9504, 10330, 11162, 11996, 12821, 13576, 14299, 15006, 15719, 16486, 17269, 17996, 18642, 19191, 19659, 20071, 20494, 20894, 21277, 21624, 21913, 22138, 22355, 22566, 22739, 22872, 22977, 23039, 23058, 23079, 23091, 23058, 22998, 22925, 22823, 22695, 22580, 22453, 22287, 22116, 21945, 21752, 21549, 21367, 21166, 20957, 20770, 20582, 20374, 20186, 20002, 19803, 19616, 19459, 19301, 19130, 18983, 18839, 18683, 18552, 18450, 18346, 18239, 18153, 18067, 17969, 17898, 17851, 17798, 17749, 17719, 17677, 17609, 17552, 17492, 17412, 17338, 17271, 17185, 17075, 16971, 16854, 16711, 16571, 16427, 16243, 16034, 15822, 15586, 15318, 15050, 14759, 14422, 14078, 13715, 13319, 12908, 12484, 12022, 11519, 10998, 10448, 9859, 9257, 8644, 8006, 7343, 6666, 5951, 5188, 4410, 3620, 2814, 2006, 1191, 340, -540, -1429, -2315, -3177, -4017, -4857, -5718, -6619, -7553, -8503, -9444, -10369, -11274, -12167, -13056, -13946, -14820, -15671, -16502, -17309, -18087, -18856, -19609, -20322, -21006, -21671, -22297, -22886, -23467, -24016, -24509, -24975, -25410, -25794, -26138, -26462, -26741, -26955, -27148, -27306, -27406, -27472, -27510, -27489, -27408, -27313, -27174, -26985, -26784, -26540, -26229, -25897, -25550, -25164, -24742, -24310, -23843, -23323, -22813, -22306, -21768, -21218, -20668, -20092, -19497, -18933, -18376, -17795, -17221, -16664, -16124, -15616, -15160, -14713, -14237, -13775, -13354, -12978, -12666, -12396, -12085, -11679, -11265, -10884, -10598, -10462, -10447, -10468, -10472, -10463, -10449, -10452, -10506, -10592, -10667, -10722, -10783, -10838, -10903, -10981, -11038, -11058, -11064, -11059, -11038, -11008, -10964, -10883, -10765, -10633, -10475, -10274, -10035, -9755, -9425, -9058, -8675, -8260, -7796, -7297, -6760, -6177, -5564, -4925, -4243, -3520, -2778, -2012, -1223, -393, -222, 46, 344, 687, 1069, 1484, 1931, 2402, 2903, 3436, 4002, 4583, 5189, 5816, 6471, 7132, 7820, 8541, 9279, 10049, 10847, 11648, 12456, 13277, 14105, 14928, 15769, 16598, 17442, 18300, 19151, 19976, 20804, 21625, 22430, 23223, 24014, 24785, 25517, 26237, 26935, 27587, 28207, 28810, 29361, 29852, 30334, 30786, 31173, 31535, 31859, 32111, 32308, 32501, 32637, 32721, 32769, 32740, 32614, 32472, 32307, 32081, 31803, 31473, 31049, 30550, 30080, 29643, 29171, 28666, 28077, 27338, 26471, 25572, 24652, 23700, 22755, 21784, 20732, 19632, 18534, 17415, 16266, 15130, 13975, 12779, 11588, 10406, 9212, 8006, 6809, 5610, 4407, 3232, 2086, 946, -180, -1272, -2347, -3403, -4427, -5434, -6428, -7388, -8315, -9202, -10047, -10861, -11648, -12402, -13123, -13805, -14441, -15045, -15623, -16162, -16662, -17135, -17570, -17967, -18345, -18703, -19019, -19298, -19553, -19778, -19965, -20149, -20317, -20445, -20558, -20666, -20753, -20822, -20903, -20974, -21015, -21062, -21112, -21134, -21151, -21185, -21195, -21202, -21224, -21238, -21228, -21235, -21247, -21239, -21246, -21278, -21307, -21330, -21379, -21427, -21444, -21461, -21478, -21470, -21455, -21455, -21444, -21393, -21343, -21277, -21177, -21071, -20969, -20829, -20636, -20424, -20168, -19877, -19594, -19303, -18985, -18663, -18334, -17967, -17568, -17163, -16732, -16260, -15794, -15321, -14808, -14269, -13721, -13150, -12569, -12019, -11471, -10895, -10305, -9707, -9112, -8539, -7998, -7453, -6865, -6262, -5681, -5146, -4680, -4247, -3760, -3155, -2506, -1877, -1363, -1023, -822, -671, -497, -285, -67, 109, 216, 278, 338, 413, 481, 514, 497, 446, 402, 379, 359, 309, 207, 70, -51, -100, -89, -66, -83, -181, -351, -547, -721, -853, -950, -1035, -1120, -1200, -1257, -1280, -1268, -1229, -1170, -1088, -979, -835, -660, -449};