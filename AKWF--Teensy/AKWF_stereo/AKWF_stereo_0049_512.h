/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0049 512 samples */
 
const int16_t AKWF_stereo_0049_512_DATA [512] = 
{25255, 32563, 28854, 32081, 31834, 28895, 29489, 29383, 26876, 26631, 27308, 26090, 25670, 26756, 26829, 26559, 27386, 27982, 27859, 28139, 28566, 28448, 28311, 28392, 28241, 27972, 27881, 27776, 27593, 27526, 27530, 27495, 27512, 27594, 27649, 27701, 27782, 27840, 27866, 27894, 27909, 27895, 27875, 27856, 27824, 27792, 27771, 27752, 27735, 27731, 27732, 27737, 27747, 27760, 27772, 27783, 27793, 27799, 27803, 27804, 27803, 27799, 27794, 27789, 27784, 27779, 27776, 27774, 27773, 27773, 27775, 27776, 27778, 27781, 27783, 27784, 27785, 27785, 27785, 27785, 27785, 27784, 27783, 27782, 27782, 27780, 27780, 27780, 27780, 27780, 27781, 27782, 27782, 27782, 27782, 27782, 27783, 27783, 27782, 27782, 27782, 27782, 27782, 27782, 27782, 27782, 27782, 27782, 27782, 27780, 26922, 31639, 3949, -36373, -28748, -30346, -32813, -30057, -28809, -29927, -28079, -26330, -27186, -26840, -25570, -26220, -26997, -26578, -26890, -27835, -27941, -27922, -28418, -28568, -28338, -28359, -28361, -28091, -27910, -27849, -27682, -27542, -27536, -27518, -27495, -27557, -27633, -27677, -27746, -27822, -27859, -27884, -27910, -27909, -27888, -27870, -27845, -27811, -27784, -27765, -27747, -27736, -27736, -27739, -27746, -27757, -27771, -27782, -27792, -27801, -27806, -27808, -27808, -27805, -27801, -27796, -27790, -27786, -27782, -27779, -27778, -27777, -27778, -27780, -27782, -27783, -27786, -27788, -27789, -27791, -27790, -27791, -27790, -27789, -27788, -27788, -27787, -27785, -27786, -27785, -27785, -27785, -27786, -27785, -27786, -27788, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27788, -27787, -27785, -27785, -27786, -27788, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, -27787, 22595, 19531, 18269, 18626, 18969, 19219, 19362, 19431, 19460, 19470, 19472, 19472, 19472, 19472, 19473, 19474, 19475, 19477, 19477, 19478, 19479, 19480, 19481, 19482, 19484, 19484, 19485, 19486, 19487, 19487, 19488, 19489, 19490, 19492, 19492, 19493, 19493, 19494, 19495, 19495, 19496, 19497, 19498, 19499, 19499, 19500, 19500, 19501, 19501, 19502, 19502, 19503, 19503, 19504, 19504, 19505, 19506, 19506, 19507, 19507, 19508, 19508, 19508, 19509, 19509, 19510, 19510, 19510, 19511, 19511, 19511, 19513, 19513, 19513, 19514, 19514, 19514, 19515, 19515, 19515, 19515, 19516, 19516, 19516, 19517, 19517, 19517, 19517, 19518, 19518, 19518, 19518, 19519, 19519, 19519, 19519, 19519, 19520, 19521, 19521, 19521, 19521, 19521, 19522, 19522, 19522, 19522, 19522, 19523, 19521, 18781, 22938, -1969, -25369, -17327, -18539, -18817, -19122, -19313, -19413, -19456, -19474, -19479, -19479, -19479, -19480, -19479, -19480, -19481, -19482, -19484, -19484, -19485, -19486, -19487, -19488, -19489, -19489, -19491, -19492, -19493, -19493, -19494, -19495, -19495, -19496, -19497, -19498, -19499, -19500, -19500, -19501, -19501, -19502, -19503, -19503, -19503, -19504, -19504, -19505, -19507, -19507, -19508, -19508, -19509, -19509, -19509, -19510, -19510, -19510, -19511, -19512, -19511, -19513, -19514, -19514, -19515, -19514, -19515, -19516, -19515, -19516, -19517, -19516, -19517, -19518, -19517, -19517, -19518, -19519, -19518, -19519, -19520, -19520, -19519, -19521, -19522, -19521, -19521, -19522, -19523, -19522, -19523, -19522, -19523, -19524, -19523, -19523, -19524, -19524, -19525, -19524, -19525, -19524, -19525, -19526, -19525, -19525, -19526, -19525, -19526, -19527, -19526, -19526, -19526, -19527, -19526, -19528, -19529, -19528, -19528, -19528, -19528, -19529, -19528, -19529, -19530, -19529, -19529, -19529, -19529, -19529, -19530, -19529, -19530, -19531, -19530, -19530, -19530, -19530, -19530, -19530, -19530, -19530, -19530, -19530};