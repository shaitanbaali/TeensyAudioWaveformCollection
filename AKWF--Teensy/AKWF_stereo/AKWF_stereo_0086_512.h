/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0086 512 samples */
 
const int16_t AKWF_stereo_0086_512_DATA [512] = 
{23095, 28073, 19241, 14641, 11414, 7005, 6727, 8224, 9653, 7586, 6027, 6017, 5988, 5989, 9547, 14097, 12447, 11190, 10516, 10200, 10110, 10823, 3764, 3196, 5582, 7012, 8215, 9117, 9799, 11922, 12034, 11818, 12606, 5617, 3771, 6269, 8075, 6033, 4281, 4724, 5562, 4289, 6861, 15909, 9570, 4649, 5214, 4759, 4430, 3988, 4218, 3078, 2059, 1625, 1305, 1253, 1033, 3288, 3269, -361, 17, 160, 154, 660, 5704, 62, -6473, -8462, -6082, -7375, -5924, -3375, 37, -1685, -2509, -1907, -2352, -2119, -1044, -2901, -3139, -1965, -1438, -654, -1717, 8197, 17660, 13572, 11222, 9677, 8684, 8159, 7979, 7914, 6478, 5907, 6616, -459, -2559, 1029, 13720, 11286, 6977, 4619, 2755, 342, 1381, -3329, -7539, -5342, -4615, -3650, -3058, -2908, -1319, -450, -936, -953, -932, -1000, -1083, -1455, -4183, -3548, -2745, -2248, -2050, -2208, 19501, 20475, 8446, 8455, 1749, -5240, -2881, -157, 2467, 642, -1033, -1273, -1017, -861, 1265, 4278, 1317, 825, 1334, 1485, 1623, 2177, -5158, -6054, -4012, -2926, -2068, -1504, -1172, -129, -681, -1434, -179, -7029, -8793, -6261, -4444, -6473, -8201, -7713, -6733, -8355, -3479, 11421, 10127, 6941, 4939, 3498, 2219, 1726, 1922, 895, -2, 12, -17, 71, -242, 4036, 5205, 2809, 1579, 869, 360, 636, 5619, 9, -6456, -8377, -5935, -7142, -5727, -2555, 2391, 797, -411, -551, -534, -719, -220, -2411, -2894, -1907, -1529, -990, -1484, 3607, 8202, -1594, -2432, -2108, -2019, -1927, -1877, -1632, -3023, -3590, -3192, -10347, -12245, -9273, -922, -3807, -7506, -7500, -10539, -12522, -10003, -14066, -17891, -15497, -14687, -13713, -13187, -13053, -12202, -11905, -12982, -12617, -12267, -12140, -12099, -12450, -15175, -14547, -13745, -13302, -13022, -12885, 16388, 24139, 19773, 24413, 29689, 32752, 31420, 28871, 28459, 25886, 26650, 29072, 29654, 29805, 28594, 27018, 27160, 28142, 29317, 29957, 29714, 29313, 18978, 17456, 18798, 18481, 17880, 17399, 17401, 17156, 16756, 17534, 18694, 9631, 6950, 8099, 7024, 6353, 6019, 6055, 6328, 5459, 8396, 18165, 8595, 4671, 7346, 7522, 6832, 5540, 5977, 6614, 5731, 5547, 5440, 5235, 5065, 4712, 4950, 5865, 6115, 6179, 5834, 6033, 11999, 5209, -2082, -4736, -3196, -4109, -5902, -6708, -6844, -6608, -6097, -5309, -5046, -5468, -5958, -5639, -5255, -5092, -5119, -5148, -7325, 4716, 16501, 13343, 15056, 17347, 18825, 18677, 17388, 17075, 16206, 15583, 17916, 9844, 7450, 7911, 4470, 3453, 3694, 4740, 5855, 5707, 7325, 442, -5811, -3899, -4417, -5139, -5685, -5775, -5740, -6521, -5998, -5468, -5379, -5407, -5423, -5354, -4958, -5133, -5410, -5567, -5788, -6125, 21294, 22882, 11686, 17383, 13197, 8955, 8699, 7020, 8193, 5028, 4197, 4849, 5517, 5506, 4690, 3928, 4727, 5745, 6628, 6991, 6572, 6155, -4136, -5662, -4410, -4865, -5577, -6091, -6038, -6097, -6399, -5595, -4597, -13770, -16515, -15375, -16427, -17071, -17400, -17375, -17017, -18417, -12764, 4805, 2708, 2632, 4705, 6737, 7476, 6526, 5648, 5025, 3643, 4784, 6181, 6786, 6549, 5145, 4326, 4548, 5079, 5701, 5901, 6375, 12302, 5312, -2132, -4774, -3085, -3837, -5546, -6493, -6967, -6839, -6279, -5316, -5042, -5366, -5799, -5504, -5153, -5000, -5004, -5154, -6472, -390, 4764, -6682, -5499, -3888, -4181, -5392, -6532, -5250, -5140, -5774, -5100, -14446, -17372, -16436, -18352, -18483, -17988, -17479, -16661, -17276, -16003, -22859, -28970, -26996, -27607, -28514, -29208, -29342, -29131, -29727, -29068, -28632, -28686, -28829, -28894, -28798, -28341, -28470, -28739, -28995, -29159, -29172};