/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0122 512 samples */
 
const int16_t AKWF_stereo_0122_512_DATA [512] = 
{246, 950, 1682, 2451, 3256, 4097, 4974, 5884, 6830, 7811, 8820, 9861, 10931, 12024, 13145, 14291, 15454, 16640, 17841, 19047, 20262, 21478, 22684, 23876, 25033, 26146, 27208, 28201, 29113, 29942, 30671, 31298, 31818, 32225, 32520, 32701, 32767, 32719, 32561, 32295, 31920, 31441, 30865, 30192, 29425, 28577, 27645, 26637, 25563, 24428, 23236, 21996, 20708, 19382, 18030, 16642, 15232, 13813, 12376, 10933, 9489, 8042, 6602, 5172, 3750, 2349, 963, -405, -1746, -3065, -4361, -5629, -6868, -8083, -9265, -10416, -11536, -12618, -13671, -14687, -15660, -16599, -17495, -18344, -19151, -19913, -20622, -21284, -21893, -22448, -22951, -23395, -23784, -24117, -24395, -24618, -24786, -24897, -24955, -24956, -24902, -24792, -24626, -24403, -24125, -23791, -23404, -22964, -22473, -21932, -21343, -20712, -20039, -19323, -18569, -17784, -16968, -16124, -15261, -14376, -13483, -12585, -11685, -10790, -9908, -9037, -8188, -7362, -6559, -5782, -5031, -4307, -3616, -2951, -2314, -1713, -1140, -596, -84, 402, 860, 1293, 1705, 2098, 2472, 2828, 3170, 3498, 3811, 4111, 4400, 4675, 4934, 5179, 5412, 5626, 5824, 6008, 6170, 6315, 6438, 6536, 6614, 6665, 6688, 6684, 6653, 6590, 6497, 6377, 6225, 6046, 5834, 5597, 5329, 5031, 4705, 4350, 3966, 3560, 3129, 2676, 2206, 1722, 1229, 728, 227, -272, -772, -1265, -1745, -2213, -2668, -3102, -3517, -3915, -4289, -4642, -4972, -5279, -5568, -5837, -6084, -6314, -6527, -6723, -6902, -7065, -7214, -7345, -7461, -7561, -7646, -7713, -7766, -7803, -7825, -7834, -7829, -7813, -7784, -7741, -7692, -7632, -7562, -7486, -7403, -7315, -7228, -7139, -7048, -6958, -6871, -6781, -6689, -6593, -6490, -6380, -6259, -6122, -5970, -5800, -5609, -5398, -5161, -4897, -4604, -4278, -3923, -3533, -3106, -2643, -2142, -1600, -1023, -393, -1612, -1016, -390, 275, 976, 1714, 2490, 3301, 4146, 5027, 5938, 6884, 7859, 8862, 9894, 10955, 12035, 13140, 14266, 15403, 16553, 17714, 18875, 20037, 21179, 22298, 23388, 24432, 25424, 26362, 27228, 28018, 28731, 29358, 29898, 30346, 30697, 30950, 31109, 31173, 31137, 31004, 30780, 30461, 30049, 29551, 28964, 28295, 27551, 26733, 25847, 24897, 23888, 22827, 21721, 20568, 19377, 18160, 16910, 15637, 14348, 13038, 11719, 10393, 9057, 7722, 6389, 5055, 3732, 2417, 1109, -186, -1469, -2741, -3994, -5232, -6451, -7646, -8822, -9972, -11092, -12185, -13241, -14258, -15241, -16182, -17076, -17927, -18732, -19486, -20191, -20843, -21443, -21989, -22479, -22916, -23300, -23626, -23896, -24113, -24273, -24377, -24425, -24417, -24351, -24228, -24050, -23814, -23520, -23172, -22766, -22311, -21804, -21245, -20639, -19993, -19305, -18578, -17822, -17034, -16223, -15396, -14553, -13700, -12845, -11988, -11140, -10305, -9483, -8685, -7907, -7152, -6427, -5729, -5058, -4419, -3808, -3221, -2667, -2140, -1640, -1166, -716, -288, 119, 506, 879, 1238, 1584, 1923, 2256, 2584, 2908, 3228, 3546, 3859, 4165, 4465, 4755, 5035, 5303, 5553, 5786, 6001, 6194, 6366, 6513, 6630, 6720, 6781, 6810, 6806, 6767, 6693, 6582, 6431, 6242, 6014, 5750, 5449, 5111, 4739, 4336, 3905, 3451, 2975, 2483, 1975, 1453, 923, 390, -147, -686, -1214, -1741, -2258, -2759, -3243, -3707, -4148, -4566, -4958, -5323, -5663, -5973, -6257, -6518, -6753, -6965, -7158, -7329, -7477, -7607, -7715, -7803, -7870, -7916, -7945, -7955, -7946, -7922, -7883, -7834, -7774, -7702, -7624, -7543, -7455, -7371, -7284, -7197, -7112, -7030, -6948, -6867, -6786, -6702, -6619, -6530, -6434, -6331, -6219, -6093, -5953, -5795, -5613, -5411, -5182, -4926, -4637, -4316, -3961, -3567, -3135, -2666, -2148};