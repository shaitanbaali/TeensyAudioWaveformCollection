/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0011 512 samples */
 
const int16_t AKWF_stereo_0011_512_DATA [512] = 
{5328, 26928, 30104, 30499, 32672, 31193, 29482, 27249, 24628, 23030, 21086, 20025, 18885, 18173, 17772, 17482, 17380, 18534, 12672, -9993, -12876, -12687, -14818, -12381, -9671, -6313, -2655, -203, 2634, 4424, 6243, 7539, 8483, 9307, 9659, 9999, 10002, 9927, 9695, 9328, 8883, 8277, 7663, 6970, 6260, 5534, 4777, 4037, 3307, 2598, 1913, 1302, 743, 158, -388, -916, -1413, -1886, -2336, -2744, -3137, -3505, -3850, -4172, -4473, -4753, -5014, -5257, -5481, -5687, -5886, -6056, -6193, -6345, -6481, -6604, -6717, -6819, -6910, -6990, -7061, -7123, -7171, -7221, -7231, -7233, -7255, -7264, -7266, -7262, -7250, -7232, -7207, -7175, -7139, -7098, -7054, -6968, -6896, -6837, -6771, -6702, -6633, -6567, -6488, -6408, -6324, -6239, -6153, -6064, -5939, -5842, -5754, -5661, -5568, -5476, -5384, -5293, -5200, -5108, -5017, -4927, -4831, -4715, -4628, -4542, -4456, -4371, -4287, -4203, -4122, -4040, -3961, -3882, -3807, -3721, -3630, -3558, -3485, -3413, -3339, -3270, -3200, -3130, -3061, -2993, -2926, -2861, -2787, -2714, -2651, -2586, -2523, -2457, -2405, -2344, -2282, -2220, -2161, -2100, -2038, -1976, -1917, -1858, -1802, -1745, -1688, -1633, -1579, -1525, -1471, -1419, -1367, -1317, -1267, -1218, -1170, -1123, -1077, -1031, -988, -945, -902, -860, -820, -779, -741, -709, -673, -639, -605, -571, -539, -508, -478, -449, -421, -395, -367, -345, -328, -305, -282, -262, -241, -221, -205, -188, -171, -155, -140, -125, -121, -109, -97, -86, -76, -66, -57, -50, -43, -37, -31, -25, -23, -28, -24, -21, -19, -18, -17, -17, -17, -19, -19, -22, -22, -29, -38, -40, -44, -48, -52, -59, -62, -68, -74, -78, -87, -90, -101, -115, -117, -130, -132, -144, 7949, 31126, 24106, 18725, 24931, 23831, 22989, 21360, 18702, 18149, 16249, 15959, 15125, 14743, 14616, 14217, 14080, 15175, 7654, -16783, -9859, -4251, -10581, -9301, -8359, -6567, -3912, -3363, -1429, -1231, -436, -180, -201, -19, -415, -475, -916, -1239, -1631, -2108, -2445, -2865, -3180, -3550, -3875, -4181, -4505, -4776, -5040, -5264, -5515, -5744, -5917, -6133, -6317, -6495, -6652, -6799, -6936, -7046, -7160, -7262, -7360, -7451, -7535, -7615, -7689, -7761, -7827, -7889, -7952, -7996, -8017, -8066, -8109, -8147, -8179, -8209, -8234, -8252, -8263, -8273, -8271, -8272, -8230, -8185, -8164, -8129, -8089, -8043, -7990, -7929, -7861, -7786, -7706, -7619, -7526, -7385, -7263, -7153, -7036, -6913, -6785, -6663, -6525, -6386, -6244, -6097, -5948, -5793, -5598, -5435, -5279, -5119, -4957, -4795, -4633, -4471, -4307, -4142, -3980, -3818, -3646, -3453, -3293, -3133, -2973, -2815, -2657, -2499, -2346, -2192, -2039, -1887, -1739, -1578, -1413, -1270, -1126, -982, -840, -701, -562, -423, -287, -153, -20, 112, 253, 391, 516, 642, 768, 898, 1007, 1128, 1247, 1366, 1480, 1596, 1711, 1826, 1937, 2045, 2147, 2252, 2353, 2452, 2549, 2642, 2738, 2826, 2914, 3001, 3085, 3166, 3243, 3318, 3391, 3461, 3528, 3593, 3657, 3714, 3772, 3827, 3877, 3919, 3965, 4006, 4046, 4084, 4117, 4148, 4176, 4202, 4224, 4242, 4261, 4273, 4275, 4283, 4289, 4291, 4291, 4290, 4282, 4275, 4264, 4251, 4236, 4218, 4186, 4162, 4137, 4108, 4078, 4046, 4011, 3971, 3933, 3891, 3846, 3801, 3749, 3688, 3637, 3582, 3526, 3469, 3408, 3346, 3283, 3217, 3151, 3081, 3013, 2937, 2857, 2783, 2707, 2631, 2554, 2473, 2395, 2312, 2230, 2149, 2062, 1980, 1887, 1794, 1714, 1618, 1536, 1442};