/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0180 512 samples */
 
const int16_t AKWF_stereo_0180_512_DATA [512] = 
{1879, 4947, 7771, 10482, 12997, 15289, 17354, 19158, 20730, 22072, 23173, 24073, 24786, 25301, 25672, 25914, 26048, 26070, 25995, 25832, 25561, 25237, 24860, 24408, 23915, 23410, 22860, 22262, 21671, 21057, 20410, 19744, 19073, 18374, 17642, 16918, 16171, 15387, 14596, 13803, 12972, 12144, 11309, 10445, 9570, 8699, 7812, 6894, 5975, 5032, 4058, 3066, 2069, 1048, 24, -970, -1905, -2761, -3490, -4043, -4386, -4481, -4310, -3875, -3174, -2221, -1067, 258, 1708, 3212, 4736, 6231, 7659, 8993, 10190, 11242, 12167, 12947, 13601, 14156, 14619, 15007, 15356, 15664, 15932, 16181, 16409, 16607, 16780, 16936, 17049, 17104, 17124, 17087, 16976, 16810, 16590, 16299, 15943, 15547, 15107, 14607, 14083, 13540, 12955, 12343, 11726, 11088, 10412, 9728, 9017, 8266, 7501, 6718, 5904, 5066, 4220, 3367, 2500, 1646, 804, -37, -873, -1691, -2502, -3322, -4137, -4961, -5799, -6642, -7500, -8383, -9279, -10195, -11133, -12074, -13039, -14024, -15002, -16004, -17008, -18006, -18995, -19970, -20903, -21769, -22567, -23279, -23865, -24330, -24691, -24930, -25043, -25076, -25030, -24885, -24689, -24443, -24129, -23737, -23304, -22791, -22150, -21408, -20555, -19526, -18364, -17058, -15574, -13944, -12207, -10321, -8315, -6255, -4139, -1982, 157, 2249, 4287, 6224, 8028, 9690, 11198, 12536, 13700, 14685, 15491, 16135, 16608, 16907, 17062, 17064, 16916, 16629, 16214, 15666, 14976, 14179, 13265, 12209, 11047, 9781, 8391, 6901, 5331, 3680, 1954, 183, -1626, -3478, -5333, -7178, -9019, -10821, -12586, -14312, -15973, -17581, -19133, -20608, -22030, -23399, -24699, -25926, -27105, -28208, -29210, -30130, -30951, -31628, -32153, -32536, -32739, -32736, -32576, -32248, -31737, -31098, -30375, -29531, -28630, -27707, -26733, -25703, -24643, -23496, -22201, -20762, -19134, -17253, -15102, -12725, -10124, -7278, -4313, -1199, -2191, -296, 1497, 3252, 4897, 6412, 7789, 8994, 10049, 10941, 11663, 12241, 12676, 12980, 13199, 13352, 13483, 13616, 13793, 14052, 14409, 14916, 15578, 16399, 17378, 18499, 19740, 21047, 22403, 23778, 25101, 26370, 27564, 28632, 29555, 30369, 31029, 31518, 31875, 32092, 32137, 32066, 31874, 31531, 31065, 30514, 29848, 29048, 28185, 27230, 26159, 25020, 23823, 22533, 21157, 19743, 18273, 16717, 15125, 13498, 11808, 10077, 8335, 6566, 4757, 2962, 1164, -637, -2426, -4196, -5949, -7675, -9364, -11010, -12612, -14157, -15634, -17020, -18298, -19473, -20521, -21430, -22210, -22870, -23401, -23820, -24166, -24417, -24603, -24758, -24870, -24934, -24996, -25051, -25066, -25080, -25100, -25098, -25075, -25066, -25040, -24969, -24880, -24746, -24506, -24149, -23669, -22998, -22091, -20982, -19633, -18014, -16187, -14164, -11966, -9643, -7259, -4863, -2487, -170, 2035, 4116, 6061, 7827, 9441, 10899, 12196, 13348, 14360, 15244, 16019, 16672, 17219, 17679, 18034, 18289, 18471, 18573, 18583, 18525, 18406, 18207, 17936, 17618, 17238, 16771, 16255, 15674, 15005, 14265, 13465, 12582, 11605, 10576, 9474, 8299, 7080, 5832, 4549, 3259, 1988, 761, -404, -1473, -2430, -3268, -3968, -4533, -4974, -5308, -5552, -5721, -5836, -5927, -6017, -6120, -6254, -6436, -6666, -6960, -7320, -7743, -8213, -8730, -9278, -9829, -10370, -10891, -11356, -11740, -12050, -12265, -12365, -12359, -12254, -12048, -11756, -11399, -10988, -10543, -10093, -9662, -9269, -8909, -8627, -8402, -8247, -8176, -8166, -8207, -8302, -8427, -8563, -8693, -8818, -8923, -8988, -9034, -9053, -9037, -9014, -8989, -8960, -8932, -8925, -8939, -8964, -9013, -9088, -9177, -9286, -9424, -9578, -9745, -9942, -10165, -10406, -10675, -10980, -11298, -11630, -11985, -12328, -12632, -12891, -13056, -13085, -12959, -12640, -12083, -11279, -10243, -8979, -7482, -5837, -4030};