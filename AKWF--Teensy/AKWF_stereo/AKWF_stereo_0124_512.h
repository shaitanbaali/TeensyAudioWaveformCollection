/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0124 512 samples */
 
const int16_t AKWF_stereo_0124_512_DATA [512] = 
{565, 1493, 2466, 3361, 4121, 4931, 5824, 6774, 7794, 8871, 10012, 11138, 12214, 13344, 14521, 15721, 16854, 17778, 18623, 19422, 20155, 20894, 21611, 22332, 23136, 24031, 24904, 25758, 26641, 27530, 28303, 28947, 29533, 30095, 30692, 31329, 31942, 32491, 32765, 32678, 32218, 31547, 30946, 29655, 25820, 21031, 16528, 12363, 8514, 4919, 1517, -1581, -4325, -6702, -8755, -10590, -12252, -13728, -15001, -16142, -17388, -18669, -19757, -20623, -21272, -21695, -21960, -22158, -22211, -22107, -21953, -21900, -22014, -22170, -22195, -22050, -21909, -22039, -22289, -22367, -22225, -22007, -21804, -21657, -21592, -21532, -21451, -21410, -21411, -21453, -21500, -21489, -21423, -21500, -21620, -21537, -21235, -20802, -20332, -19813, -19277, -18708, -17985, -17122, -16226, -15365, -14430, -13290, -11974, -10669, -9540, -8673, -7943, -7164, -6375, -5594, -4787, -3930, -2988, -1947, -830, 374, 1673, 2983, 4188, 5209, 6079, 6892, 7637, 8401, 9139, 9731, 10186, 10599, 10992, 11341, 11629, 11756, 11598, 11269, 10633, 9626, 8524, 7333, 6096, 4923, 4045, 3502, 3209, 3134, 3271, 3375, 3072, 2623, 2320, 2182, 2169, 2225, 2257, 2343, 2593, 3028, 3666, 4482, 5326, 5880, 6196, 6439, 6544, 6481, 6278, 6018, 5817, 5664, 5355, 4914, 4507, 4120, 3712, 3286, 2546, 1575, 666, -64, -770, -1597, -2421, -3074, -3568, -3997, -4376, -4830, -5422, -6060, -6578, -6984, -7511, -8306, -8933, -9217, -9178, -8876, -8409, -7850, -7184, -6420, -5543, -4742, -4228, -3764, -3157, -2430, -1703, -1063, -405, 106, 500, 781, 883, 791, 571, 368, 206, 61, -99, -262, -353, -299, -105, 124, 376, 617, 738, 879, 1122, 1369, 1512, 1542, 1602, 1712, 1731, 1646, 1541, 1488, 1516, 1401, 975, 421, -102, -658, -1110, -1346, -1383, -1225, -845, -212, -741, -429, 32, 636, 1309, 2057, 2885, 3795, 4814, 5942, 7058, 8126, 9264, 10525, 11924, 13419, 14720, 15608, 16390, 17245, 18069, 18849, 19618, 20318, 20880, 21457, 22198, 23053, 23893, 24712, 25499, 26248, 26969, 27654, 28283, 28875, 29470, 29957, 30148, 30140, 30076, 30105, 30346, 30115, 27589, 24144, 20883, 17894, 15236, 12693, 10030, 7401, 4971, 2761, 652, -1459, -3461, -5291, -6985, -8498, -9894, -11303, -12674, -13960, -15135, -16186, -17094, -17837, -18458, -18908, -19162, -19381, -19623, -19807, -19845, -19708, -19623, -19849, -20205, -20498, -20745, -20918, -21006, -21034, -21109, -21249, -21322, -21415, -21671, -21977, -22220, -22431, -22697, -22943, -23185, -23399, -23444, -23246, -22845, -22348, -21760, -21022, -20092, -19107, -18332, -17687, -16929, -15963, -14923, -13953, -12962, -11986, -11097, -10279, -9494, -8674, -7800, -6926, -6105, -5260, -4373, -3456, -2445, -1292, -31, 1253, 2500, 3681, 4780, 5863, 6931, 7780, 8407, 9065, 9739, 10209, 10453, 10474, 10374, 10263, 10168, 9990, 9502, 8802, 8071, 7188, 5971, 4750, 3679, 2838, 2314, 1994, 1666, 1360, 1174, 1156, 1331, 1679, 1834, 1684, 1600, 1708, 2047, 2558, 3091, 3670, 4370, 5197, 6043, 6797, 7528, 8291, 8862, 9142, 9185, 8948, 8467, 7917, 7411, 6785, 6000, 5190, 4471, 3834, 3194, 2449, 1656, 891, -73, -1060, -1855, -2711, -3714, -4722, -5619, -6458, -7383, -8267, -8985, -9496, -9741, -9737, -9592, -9311, -8857, -8368, -8055, -7832, -7586, -7260, -6850, -6336, -5793, -5263, -4654, -3882, -3016, -2081, -1154, -297, 433, 913, 1290, 1599, 1746, 1656, 1300, 964, 791, 711, 700, 820, 1070, 1379, 1689, 1987, 2267, 2539, 2791, 2793, 2541, 2254, 1988, 1695, 1399, 1008, 452, -138, -688, -1053, -1180, -1176, -1145, -1206, -1216, -1003};