/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0063 512 samples */
 
const int16_t AKWF_stereo_0063_512_DATA [512] = 
{850, 2737, 4648, 6578, 8515, 10434, 12331, 14178, 15979, 17717, 19382, 20974, 22483, 23895, 25219, 26443, 27563, 28581, 29493, 30293, 30984, 31564, 32029, 32384, 32623, 32748, 32759, 32654, 32438, 32105, 31663, 31106, 30436, 29658, 28771, 27773, 26679, 25479, 24184, 22800, 21327, 19773, 18150, 16463, 14716, 12939, 11121, 9298, 7481, 5705, 4001, 2506, 989, 3371, 4755, 3248, 1889, 429, -1027, -2436, -3786, -5071, -6278, -7409, -8461, -9437, -10332, -11157, -11906, -12589, -13206, -13761, -14257, -14703, -15099, -15450, -15761, -16036, -16280, -16497, -16689, -16862, -17019, -17162, -17294, -17419, -17537, -17650, -17760, -17869, -17976, -18079, -18179, -18277, -18367, -18450, -18525, -18587, -18630, -18658, -18662, -18639, -18585, -18497, -18370, -18198, -17979, -17708, -17380, -16993, -16539, -16015, -15422, -14752, -14006, -13178, -12272, -11279, -10214, -9062, -7843, -6559, -5221, -3857, -2518, -1235, -538, -3796, -3721, -2079, -430, 1369, 3223, 5098, 6982, 8834, 10662, 12438, 14155, 15801, 17379, 18862, 20261, 21564, 22764, 23863, 24856, 25737, 26508, 27165, 27706, 28134, 28442, 28636, 28710, 28667, 28508, 28230, 27837, 27327, 26703, 25965, 25120, 24163, 23103, 21938, 20676, 19323, 17884, 16363, 14774, 13124, 11421, 9693, 7939, 6200, 4500, 2923, 1415, 1119, 4326, 3756, 2257, 786, -732, -2217, -3665, -5044, -6354, -7587, -8742, -9814, -10807, -11718, -12549, -13307, -13987, -14600, -15143, -15623, -16044, -16410, -16724, -16990, -17215, -17401, -17554, -17675, -17769, -17844, -17898, -17937, -17963, -17979, -17988, -17993, -17992, -17988, -17982, -17973, -17963, -17950, -17931, -17907, -17873, -17830, -17772, -17699, -17606, -17488, -17341, -17164, -16949, -16694, -16393, -16043, -15638, -15177, -14652, -14061, -13403, -12667, -11860, -10976, -10013, -8972, -7863, -6678, -5440, -4143, -2966, -1563, -1950, -4281, -3131, -1585, 14174, 15659, 16953, 18150, 19256, 20293, 21269, 22186, 23058, 23878, 24656, 25392, 26082, 26726, 27335, 27895, 28411, 28884, 29313, 29692, 30028, 30311, 30550, 30737, 30876, 30965, 31004, 30995, 30938, 30830, 30678, 30475, 30229, 29936, 29599, 29219, 28796, 28329, 27822, 27267, 26675, 26027, 25341, 24587, 23790, 22915, 21970, 20918, 19758, 18430, 16871, 14848, 12836, 2136, -6258, -8004, -9843, -11202, -12338, -13312, -14175, -14939, -15640, -16271, -16860, -17397, -17902, -18370, -18811, -19223, -19615, -19984, -20337, -20674, -20995, -21306, -21603, -21891, -22171, -22444, -22710, -22971, -23226, -23476, -23723, -23966, -24201, -24435, -24663, -24884, -25098, -25307, -25505, -25693, -25871, -26036, -26184, -26316, -26431, -26527, -26600, -26647, -26668, -26665, -26626, -26556, -26454, -26316, -26136, -25919, -25654, -25349, -24994, -24591, -24128, -23617, -23035, -22391, -21671, -20864, -19962, -18938, -17766, -16388, -14706, -12629, -9008, 3698, 9114, 11047, 12970, 14540, 15903, 17143, 18265, 19309, 20269, 21171, 22008, 22796, 23530, 24212, 24851, 25438, 25983, 26475, 26926, 27323, 27677, 27979, 28233, 28441, 28598, 28704, 28760, 28768, 28725, 28636, 28496, 28311, 28076, 27799, 27471, 27097, 26680, 26214, 25702, 25139, 24530, 23857, 23139, 22339, 21476, 20514, 19450, 18234, 16833, 15075, 13096, 8382, -4177, -8169, -9882, -11437, -12660, -13702, -14614, -15418, -16144, -16801, -17405, -17954, -18468, -18935, -19377, -19785, -20168, -20524, -20862, -21179, -21477, -21759, -22026, -22282, -22529, -22761, -22984, -23200, -23410, -23612, -23809, -24002, -24189, -24370, -24548, -24721, -24888, -25049, -25206, -25355, -25496, -25625, -25746, -25854, -25950, -26029, -26089, -26132, -26154, -26149, -26123, -26069, -25984, -25866, -25714, -25528, -25298, -25032, -24717, -24357, -23944, -23479, -22951, -22364, -21699, -20956, -20122, -19172, -18081, -16846, -15130, -11593, -3524, 6756, 9519, 11770};