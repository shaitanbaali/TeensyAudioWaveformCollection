/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0150 512 samples */
 
const int16_t AKWF_stereo_0150_512_DATA [512] = 
{-30669, -26597, -25980, -26418, -26342, -25997, -25455, -24790, -24051, -23277, -22496, -21725, -20979, -20266, -19591, -18959, -18373, -17827, -17326, -16867, -16444, -16058, -15707, -15384, -15090, -14819, -14570, -14339, -14126, -13927, -13738, -13560, -13390, -13228, -13070, -12917, -12766, -12619, -12474, -12330, -12186, -12043, -11901, -11758, -11615, -11470, -11326, -11183, -11038, -10892, -10747, -10601, -10454, -10307, -10159, -10011, -9864, -9716, -9568, -9419, -9271, -9123, -8974, -8825, -8677, -8528, -8381, -8232, -8083, -7935, -7787, -7638, -7492, -7344, -7194, -7046, -6899, -6751, -6603, -6454, -6308, -6160, -6012, -5865, -5717, -5569, -5421, -5274, -5126, -4978, -4830, -4682, -4536, -4387, -4239, -4093, -3945, -3797, -3649, -3502, -3354, -3206, -3059, -2911, -2763, -2616, -2469, -2320, -2172, -2025, -1878, -1730, -1583, -1435, -1287, -1139, -991, -844, -697, -548, -400, -254, -105, 40, 186, 334, 483, 631, 778, 925, 1073, 1221, 1368, 1516, 1664, 1811, 1959, 2107, 2254, 2402, 2550, 2697, 2845, 2993, 3140, 3289, 3435, 3582, 3730, 3878, 4026, 4173, 4322, 4469, 4616, 4764, 4912, 5059, 5208, 5355, 5503, 5650, 5798, 5946, 6092, 6241, 6389, 6537, 6684, 6832, 6979, 7127, 7275, 7422, 7570, 7718, 7865, 8012, 8160, 8307, 8456, 8604, 8750, 8898, 9047, 9195, 9343, 9489, 9638, 9784, 9932, 10080, 10228, 10376, 10523, 10671, 10819, 10966, 11114, 11262, 11409, 11557, 11705, 11852, 12000, 12148, 12295, 12442, 12590, 12737, 12885, 13033, 13180, 13328, 13476, 13623, 13771, 13919, 14066, 14214, 14362, 14510, 14657, 14805, 14952, 15099, 15247, 15396, 15543, 15690, 15839, 15986, 16134, 16282, 16430, 16577, 16724, 16872, 17020, 17167, 17315, 17463, 17610, 17758, 17906, 18053, 18201, 18352, 18527, 18382, 20824, 9341, 4686, 6470, 6397, 6553, -28769, -26307, -25859, -26024, -25892, -25602, -25198, -24722, -24203, -23662, -23118, -22581, -22056, -21553, -21070, -20613, -20182, -19776, -19395, -19038, -18703, -18389, -18096, -17819, -17560, -17313, -17078, -16855, -16642, -16437, -16239, -16047, -15859, -15676, -15495, -15317, -15141, -14966, -14793, -14620, -14448, -14276, -14104, -13934, -13760, -13587, -13414, -13243, -13070, -12896, -12721, -12548, -12373, -12199, -12025, -11851, -11675, -11500, -11325, -11150, -10975, -10799, -10624, -10448, -10273, -10099, -9924, -9748, -9572, -9397, -9222, -9048, -8874, -8698, -8522, -8347, -8173, -7999, -7824, -7647, -7473, -7298, -7122, -6949, -6774, -6598, -6424, -6250, -6074, -5900, -5725, -5550, -5376, -5201, -5026, -4852, -4676, -4501, -4327, -4152, -3978, -3803, -3628, -3453, -3278, -3103, -2929, -2755, -2579, -2405, -2230, -2054, -1881, -1706, -1530, -1355, -1180, -1006, -833, -657, -481, -307, -131, 40, 212, 388, 563, 738, 914, 1087, 1262, 1437, 1612, 1788, 1962, 2136, 2311, 2485, 2661, 2836, 3011, 3185, 3360, 3534, 3708, 3885, 4059, 4234, 4408, 4584, 4758, 4933, 5107, 5282, 5457, 5631, 5807, 5982, 6156, 6330, 6505, 6681, 6857, 7030, 7204, 7379, 7554, 7729, 7904, 8079, 8253, 8428, 8604, 8778, 8953, 9128, 9302, 9476, 9651, 9827, 10002, 10177, 10351, 10525, 10701, 10876, 11050, 11225, 11400, 11574, 11749, 11924, 12099, 12274, 12449, 12624, 12798, 12973, 13148, 13322, 13496, 13671, 13847, 14022, 14197, 14371, 14546, 14720, 14895, 15070, 15244, 15418, 15594, 15769, 15943, 16119, 16293, 16467, 16642, 16817, 16991, 17167, 17342, 17516, 17690, 17865, 18041, 18216, 18390, 18564, 18739, 18914, 19089, 19265, 19439, 19614, 19787, 19963, 20138, 20313, 20487, 20662, 20837, 21011, 21187, 21363, 21536, 21718, 21958, 21449, 26976, 18, -11008, -7019, -7357, -7164};