/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0101 512 samples */
 
const int16_t AKWF_stereo_0101_512_DATA [512] = 
{3062, 7089, 15477, 25032, 26372, 18641, 12063, 10695, 10004, 11607, 14259, 11378, 6270, 496, -2778, -1962, -1670, -5690, -10700, -10194, -8870, -7393, -1168, 4568, 6481, 6678, 2217, -6964, -8182, 1581, 11715, 14639, 8272, -1178, -7126, -3013, 6256, 10534, 7548, 1337, -4273, -4173, -4224, -7760, -15522, -18888, -17240, -14716, -14397, -10232, -978, 7429, 7546, 3329, 1190, 3004, 9362, 12723, 13535, 13373, 11190, 10782, 8665, 3539, -943, -3032, -2080, -1088, 1791, 5113, 2292, -892, -2650, -8328, -16705, -15610, -5496, 1695, 1371, -3978, -3445, 1036, 4706, 9459, 16187, 16896, 12061, 4069, -3820, -10698, -9773, -1413, 5644, 5836, 2208, -4147, -4437, -1002, 1488, 666, -244, 320, -3185, -9386, -16765, -26071, -26227, -15141, -3622, 2703, 4717, 4858, 3095, 2611, 5772, 8919, 11077, 11236, 4688, -3254, -4603, -1134, -827, -8443, -12034, -4560, 3814, 4507, 3594, 5274, 8878, 12399, 17850, 24619, 25006, 14437, 2004, -4076, -4444, -1807, 655, -15, -4792, -10935, -14093, -9953, 3499, 14513, 18165, 15204, 8494, 1848, -1656, -48, 2489, 2473, 466, -1176, -1178, -2747, -9927, -13272, -7173, 1782, 6035, 4969, 7855, 8918, 1330, -6002, -1872, 7525, 13295, 10063, 5434, 631, -9713, -22273, -18812, -6134, 1786, -2130, -4519, -4524, -5883, -7482, -8049, -3759, 273, -5757, -15783, -16123, -14351, -16048, -15893, -10492, -4261, -357, 3362, 5268, 6129, 6200, 4668, 5505, 7355, 5436, 4142, 3417, -189, -9523, -6819, 8883, 18671, 15510, 9023, 4275, -693, -3180, -3526, -682, 3790, 5074, -398, -6351, -11711, -9515, -4355, 2338, 2745, -737, -5429, -8062, -11512, -8146, -6654, -8683, -12405, -13405, -15801, -16702, -16028, -11061, -4194, -260, -668, -2584, -3363, -3576, -6026, -2391, 7089, 14316, 14913, 7467, -180, -1667, 2857, -5662, -7076, -7587, -1197, 2950, -921, -5686, 1679, 12359, 19600, 20678, 14912, 6470, 4655, 3986, -732, -12742, -22425, -22229, -19714, -10961, -4259, 3574, 11095, 9082, 1676, -201, 827, 8451, 18602, 28601, 25615, 11112, -3351, -16611, -24444, -20555, -14638, -8993, 2906, 6645, 3111, 4180, 15101, 19025, 13919, 9585, 10352, 9231, 4032, -8883, -14961, -12016, -15422, -24189, -24504, -22818, -18554, -10031, 1488, 11280, 13984, 11971, 9628, 10881, 10520, 3281, -2197, -5851, -10960, -16061, -19767, -22708, -20970, -15516, -6321, 5975, 15065, 15822, 11530, 9956, 10164, 3038, -5144, -6820, -4618, -7985, -20558, -21811, -11750, -241, 8877, 15795, 20012, 19959, 24781, 30846, 28169, 20745, 9446, -929, -6385, -12240, -10899, -8125, -5094, -10579, -16633, -9139, 137, 3547, 6138, 3192, -1511, -6555, -7923, -6533, -5930, -5504, -5221, -8023, -13042, -26802, -30885, -14538, -3395, -665, 1799, 3250, 4512, 3591, 4503, 13252, 22471, 25951, 19165, 11692, 3799, -10908, -17809, -10368, -1830, -83, -3136, -5569, -4308, -3573, 1988, 9311, 12341, 12156, 8307, 5353, 3484, 350, -5987, -7126, -6921, -10247, -19423, -21831, -15216, -4996, 2539, 3759, -337, -6933, -11311, -6962, 2639, 9461, 5355, -4123, -9957, -9451, -540, 6773, 14418, 19959, 22687, 20399, 9308, -10211, -15636, -8827, -2904, -6421, -11003, -9930, 965, 7999, 13707, 16579, 16466, 13829, 11047, 8634, 9718, 15761, 17380, 11849, 1608, -4967, -8446, -7154, -106, 11487, 24336, 27401, 16229, 4718, -3983, -10644, -12965, -11440, -14274, -22014, -27409, -25359, -20730, -18676, -15596, -7802, -1263, -125, 28, 1997, 3040, 4793, 3934, -3394, -6722, -2353, 940, -3563, -10164, -7606, -4152, 211, 9258, 16746, 16932, 2353, -15530, -11841, 9383, 26294, 21998, 7860, 5962, 7191, 6322, 8432, 12269, 10094};