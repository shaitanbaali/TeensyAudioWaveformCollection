/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0097 512 samples */
 
const int16_t AKWF_stereo_0097_512_DATA [512] = 
{918, 2773, 4971, 7229, 9338, 11876, 15675, 20534, 24894, 28371, 31120, 32475, 32720, 31569, 29262, 26830, 24055, 20516, 16590, 12450, 7965, 3684, 306, -2227, -4170, -5606, -6331, -7125, -9048, -12521, -16867, -20216, -22137, -22946, -23456, -23133, -21748, -19355, -16011, -12576, -10239, -8659, -6982, -4332, -1549, 102, 948, 1974, 3403, 3273, 1052, -2166, -5444, -8447, -10292, -10968, -9909, -7414, -4387, -1351, 876, 1111, -228, -1744, -3514, -5588, -7771, -9637, -10463, -9427, -7566, -4740, -707, 4421, 9142, 12459, 14603, 15365, 15605, 15331, 15789, 16522, 16607, 16294, 16540, 17050, 17207, 17419, 18409, 19226, 18438, 15314, 10173, 4168, -1548, -5607, -7882, -8867, -8607, -7476, -6881, -7224, -8828, -11158, -13314, -14890, -15949, -16636, -17374, -17058, -15474, -13810, -13085, -13348, -14106, -14952, -15335, -14929, -13218, -9904, -6427, -3110, -277, 1419, 1623, 680, -87, -133, 985, 2805, 4957, 7180, 9268, 11813, 15632, 20502, 24843, 28300, 31043, 32406, 32660, 31519, 29232, 26814, 24054, 20537, 16633, 12489, 7974, 3646, 210, -2364, -4310, -5716, -6388, -7130, -9014, -12454, -16766, -20090, -22000, -22816, -23360, -23089, -21759, -19410, -16093, -12653, -10285, -8676, -6977, -4322, -1549, 74, 895, 1898, 3313, 3180, 986, -2166, -5366, -8320, -10149, -10837, -9802, -7335, -4345, -1343, 866, 1080, -279, -1812, -3599, -5688, -7884, -9758, -10591, -9560, -7690, -4850, -794, 4344, 9046, 12340, 14477, 15237, 15488, 15242, 15742, 16520, 16652, 16383, 16651, 17167, 17323, 17531, 18502, 19283, 18459, 15319, 10176, 4153, -1591, -5658, -7926, -8898, -8623, -7477, -6871, -7192, -8777, -11107, -13288, -14893, -15984, -16693, -17452, -17152, -15560, -13863, -13089, -13310, -14050, -14888, -15282, -14890, -13182, -9888, -6448, -3167, -367, 1297, 1482, 528, -233, -220, 13738, 7362, 2013, -1139, -2902, -3012, -595, 2977, 5836, 9162, 13213, 15965, 17009, 14963, 11306, 7796, 6191, 7352, 9919, 11632, 11630, 11757, 10480, 7191, 2652, -1796, -3172, -426, 3720, 6119, 4927, 2077, -2455, -8380, -15056, -21224, -24490, -23972, -20579, -16985, -14943, -14702, -17146, -20991, -24406, -27551, -28226, -26190, -20406, -11660, -1736, 5050, 7943, 9326, 11052, 11933, 13648, 15765, 16718, 16478, 15242, 12073, 7594, 2174, -2800, -4137, -1889, 1373, 5864, 10510, 12322, 11829, 9052, 4437, -667, -6437, -11836, -14418, -13421, -9926, -3835, 3597, 11468, 19717, 26734, 30341, 30425, 28454, 24244, 18624, 10722, 1398, -7324, -13729, -17330, -19378, -20285, -19246, -16139, -10748, -5472, -2319, -158, -271, -2789, -8012, -13312, -17823, -22138, -24234, -24704, -24372, -22863, -20557, -15874, -9897, -4087, 724, 4571, 8103, 10495, 12042, 15311, 17957, 19175, 20067, 19891, 17922, 13585, 7279, 1979, -1201, -3022, -3181, -809, 2687, 5446, 8737, 12838, 15706, 16928, 15077, 11586, 8181, 6582, 7635, 10053, 11622, 11513, 11560, 10247, 6967, 2478, -1875, -3159, -377, 3755, 6116, 4923, 2098, -2374, -8210, -14808, -20941, -24245, -23842, -20594, -17152, -15242, -15080, -17543, -21357, -24694, -27736, -28284, -26129, -20235, -11429, -1506, 5240, 8039, 9302, 10942, 11786, 13492, 15611, 16604, 16425, 15273, 12178, 7747, 2362, -2574, -3893, -1639, 1608, 6046, 10649, 12430, 11875, 9007, 4286, -892, -6664, -12000, -14474, -13347, -9726, -3530, 3952, 11803, 19995, 26939, 30480, 30514, 28508, 24282, 18649, 10726, 1381, -7352, -13760, -17385, -19449, -20346, -19291, -16169, -10772, -5487, -2338, -233, -432, -3046, -8356, -13722, -18229, -22495, -24528, -24912, -24468, -22840, -20433, -15682, -9686, -3908, 843, 4636, 8127, 10496, 12042, 15323, 17987, 19235, 20175, 20079, 17983};