/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0032 512 samples */
 
const int16_t AKWF_stereo_0032_512_DATA [512] = 
{765, 2325, 4167, 6441, 8842, 10828, 12426, 13712, 14678, 15508, 16354, 17074, 17266, 16941, 16610, 16508, 16525, 16444, 16371, 16494, 17058, 17712, 18120, 18586, 19140, 19697, 19993, 20006, 19996, 19941, 20074, 20704, 21428, 21625, 21361, 20405, 18764, 17689, 17397, 17080, 16363, 15429, 14654, 14189, 14038, 14246, 14830, 15471, 16059, 16789, 17686, 18976, 20541, 22162, 23733, 24772, 25012, 25090, 25539, 25643, 24658, 22764, 20834, 19442, 18547, 18027, 17861, 17863, 17747, 17379, 17063, 17283, 17688, 17621, 17161, 16578, 16183, 15989, 15793, 15750, 15732, 15298, 14610, 13806, 12927, 11784, 10279, 8714, 7381, 6483, 5806, 5169, 4667, 4295, 4112, 4235, 4216, 3811, 3450, 3402, 3801, 4458, 4923, 5102, 5503, 5932, 5960, 5356, 4021, 2740, 1844, 1018, 186, -615, -1378, -2041, -2752, -4116, -6194, -8578, -10902, -12978, -14241, -14105, -12756, -10620, -8501, -6594, -4994, -3977, -3514, -3430, -3521, -3637, -3676, -3821, -4294, -4825, -5146, -5390, -5724, -5941, -5663, -5130, -4758, -4726, -5187, -6205, -7636, -9187, -10406, -11321, -12171, -13345, -14875, -16333, -17343, -18069, -18867, -19563, -19552, -18776, -17865, -17054, -16455, -16318, -16331, -16096, -15806, -15632, -15493, -15041, -14403, -13912, -13346, -12714, -11971, -11005, -10044, -9357, -8623, -7729, -6928, -6394, -6045, -5887, -6316, -7055, -7594, -7775, -7590, -7213, -6996, -7021, -7060, -7314, -7826, -8546, -9629, -10693, -11286, -11442, -11190, -10574, -9868, -9189, -8043, -6358, -8193, -13199, -16460, -18571, -20076, -21262, -22578, -24253, -26264, -28271, -30023, -31409, -32257, -32661, -32745, -31898, -29841, -27425, -25462, -23964, -22508, -20650, -18340, -15689, -12693, -9766, -7458, -5932, -4875, -4006, -3583, -3727, -4143, -4456, -4662, -5210, -6006, -6544, -6407, -5797, -5164, -4503, -3632, -2767, -2165, -1673, -1117, -339, 19917, 17660, 15268, 12001, 8118, 4196, 633, -2052, -4027, -5918, -8252, -10894, -12343, -11604, -10257, -9285, -8185, -7270, -7146, -8062, -9763, -11249, -11643, -11174, -9903, -8934, -8692, -8300, -8254, -8875, -9238, -8563, -6801, -4778, -3367, -3109, -3956, -5793, -7784, -8791, -7799, -4297, 720, 5585, 9197, 11984, 14227, 15606, 16096, 15950, 15625, 15883, 16924, 17479, 17059, 16147, 15158, 14132, 13230, 13070, 13876, 15259, 16486, 16740, 15887, 14722, 13560, 12193, 11513, 11639, 11606, 10978, 9720, 7623, 4973, 2448, 590, -428, -540, 258, 1135, 1493, 1391, 750, 552, 1470, 2835, 3724, 3793, 3229, 1979, 588, -747, -2288, -3548, -4519, -5692, -7257, -8559, -9077, -9112, -9735, -11168, -13376, -15843, -17469, -17845, -17310, -16478, -15731, -15444, -15267, -14951, -15255, -16832, -19904, -23931, -27911, -30897, -32392, -32765, -32546, -32245, -32221, -32294, -31821, -27390, -21897, -17781, -14367, -11847, -10424, -10183, -11022, -12266, -13414, -14742, -15871, -16314, -16437, -16425, -15157, -12717, -10375, -8465, -6799, -4966, -1988, 1857, 5683, 9410, 12699, 15039, 16318, 17007, 17106, 16430, 15027, 13015, 10727, 8228, 5445, 2782, 569, -959, -1829, -1905, -891, 767, 1760, 1764, 1112, 517, 329, -88, -978, -2104, -2319, -1607, -1458, -2550, -4403, -5898, -6075, -5128, -4229, -4072, -3988, -2870, -1077, 531, 2049, 3392, 4239, 4903, 5227, 4906, 3664, 1634, -510, -2073, -3003, -3638, -4205, -4191, -3238, -1681, -171, 1078, 1416, 1339, 1800, 2273, 2210, 1338, 177, 33, 1092, 2632, 4203, 5524, 5389, 4265, 3318, 3014, 4256, 6424, 8583, 10712, 11969, 11959, 12235, 13011, 12925, 12047, 11383, 10964, 11001, 11446, 12239, 13187, 13843, 14245, 14592, 15452, 17416, 19470, 20625, 20858, 20612, 20463, 20706, 21522, 22591, 22875, 21790};