/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0123 512 samples */
 
const int16_t AKWF_stereo_0123_512_DATA [512] = 
{623, 1729, 2832, 3975, 5301, 6646, 7761, 8603, 9551, 10888, 12424, 14172, 16219, 18217, 19910, 21232, 22384, 23615, 24659, 25438, 26400, 27752, 29266, 30682, 31862, 32639, 32717, 32054, 31067, 30065, 28822, 27309, 25815, 24449, 23206, 22246, 21708, 21527, 21513, 21473, 21135, 20423, 19411, 18274, 17408, 16873, 15742, 12793, 8912, 5714, 3162, 945, -1051, -2945, -4777, -6583, -8381, -10083, -11688, -13331, -15075, -16722, -18232, -19744, -21283, -22591, -23601, -24367, -24844, -24998, -24962, -24844, -24573, -24036, -23260, -22173, -20625, -18851, -17641, -17203, -17129, -17316, -17487, -17400, -16878, -15863, -14587, -13234, -11865, -10592, -9692, -8986, -8289, -7999, -8163, -8441, -8533, -8225, -7498, -6478, -5296, -4047, -2815, -1655, -646, -9, 256, 370, 594, 811, 48, -2273, -4572, -6201, -7448, -8457, -9139, -9451, -9632, -9624, -9276, -8859, -8544, -7739, -6268, -4946, -3887, -3165, -2460, -1370, 100, 1749, 3548, 5107, 6098, 6804, 7935, 9474, 11058, 12710, 14530, 16279, 17815, 19074, 20028, 20826, 21428, 22028, 22998, 24340, 25694, 26866, 27915, 28569, 28600, 27979, 27023, 26079, 25045, 23879, 22496, 20940, 19494, 18466, 17963, 17812, 17847, 17935, 17834, 17457, 16871, 16289, 15893, 15606, 14578, 11753, 8296, 5611, 3395, 1493, -21, -1301, -2461, -3633, -4777, -5728, -6655, -7819, -9127, -10423, -11754, -13224, -14822, -16276, -17456, -18410, -19005, -19210, -19241, -19263, -19338, -19347, -19242, -18993, -18487, -17837, -17357, -17275, -17564, -17926, -18165, -18258, -18051, -17490, -16817, -16230, -15757, -15330, -15247, -15655, -16156, -16657, -17150, -17597, -17986, -18209, -17997, -17166, -15818, -14181, -12444, -10729, -9336, -8334, -7448, -6430, -5305, -4748, -5585, -6736, -7436, -8118, -8871, -9544, -9959, -10022, -9871, -9630, -9133, -8461, -7695, -6269, -4185, -2575, -1436, -402, -1542, -883, -269, 246, 657, 1050, 1400, 1818, 2676, 3956, 5385, 7075, 9171, 11367, 13456, 15459, 17345, 18898, 20047, 20978, 21765, 22430, 23277, 24391, 25619, 26805, 27693, 28189, 28620, 29187, 29589, 29579, 29102, 28178, 26888, 25625, 24662, 23850, 23158, 22700, 22436, 22101, 21676, 21511, 21799, 22203, 21894, 19727, 16485, 13769, 11431, 9161, 6970, 4813, 2625, 557, -1312, -3138, -5068, -7017, -8692, -10108, -11439, -12843, -14456, -16077, -17753, -19546, -21150, -22328, -23113, -23624, -23893, -23995, -23903, -23361, -22059, -20248, -18668, -17700, -17437, -17717, -18094, -18446, -18804, -18782, -18226, -17338, -16245, -14983, -13683, -12510, -11441, -10466, -9726, -9366, -9260, -9025, -8562, -8168, -7830, -7555, -7183, -6411, -5318, -4289, -3356, -2313, -1012, 270, 581, -774, -2337, -3457, -4402, -5266, -6040, -6825, -7485, -7879, -8058, -8290, -8600, -8258, -6975, -5764, -4950, -4349, -3744, -3062, -2178, -1239, -409, 291, 850, 1498, 2591, 4091, 5636, 7278, 9224, 11265, 13246, 15051, 16470, 17548, 18292, 18850, 19411, 19991, 20693, 21520, 22396, 23324, 23992, 24205, 24348, 24745, 25114, 25073, 24702, 23928, 22683, 21400, 20409, 19699, 19113, 18679, 18444, 18255, 18050, 17946, 18200, 18737, 18768, 17043, 14319, 12130, 10404, 8843, 7279, 5643, 3985, 2393, 955, -386, -1782, -3141, -4261, -5208, -6084, -7061, -8327, -9735, -11371, -13193, -14821, -16087, -17123, -17959, -18433, -18674, -18902, -18971, -18624, -17848, -16968, -16318, -16155, -16658, -17550, -18425, -19077, -19555, -19782, -19775, -19569, -19146, -18687, -18377, -18047, -17577, -17169, -17021, -17091, -17341, -17625, -17622, -17221, -16622, -15846, -14719, -13249, -11697, -10103, -8300, -6427, -5120, -5151, -5745, -6118, -6338, -6625, -7196, -7837, -8269, -8503, -8650, -8738, -8819, -8787, -7973, -6149, -4433, -3123, -2220};