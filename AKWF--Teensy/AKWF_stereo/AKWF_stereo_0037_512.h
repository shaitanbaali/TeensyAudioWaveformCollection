/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0037 512 samples */
 
const int16_t AKWF_stereo_0037_512_DATA [512] = 
{362, 1693, 3027, 4318, 5500, 6480, 7211, 7779, 8476, 9564, 10412, 11028, 11491, 12071, 12754, 13338, 13921, 14529, 15114, 15810, 16440, 16889, 17372, 17991, 18698, 19513, 20473, 21635, 22931, 24317, 25484, 26435, 27292, 28025, 28804, 29592, 30420, 31206, 31935, 32520, 32724, 32759, 32684, 32540, 32314, 31966, 31604, 31145, 30661, 30061, 29354, 28537, 27763, 27064, 26400, 25590, 24618, 23650, 22789, 21947, 21197, 20606, 20095, 19776, 19701, 19625, 19514, 19359, 19213, 19081, 18934, 18927, 19130, 19545, 19952, 20397, 20851, 21222, 21802, 22442, 23134, 23998, 24828, 25476, 26036, 26567, 27034, 27371, 27603, 27783, 27765, 27697, 27820, 27933, 27752, 27082, 26140, 25229, 24418, 23450, 22281, 20985, 19381, 17666, 16015, 14284, 12661, 10987, 9241, 7597, 6186, 4901, 3325, 1138, -559, -1849, -2884, -3870, -4831, -5781, -6705, -7557, -8288, -8930, -9492, -9990, -10535, -11079, -11481, -11983, -12793, -13704, -14608, -15437, -16204, -16975, -17709, -18531, -19521, -20548, -21580, -22580, -23580, -24526, -25313, -25947, -26489, -27043, -27408, -27607, -27735, -27949, -28181, -28113, -27867, -27553, -27165, -26688, -26079, -25333, -24538, -23844, -23193, -22585, -22087, -21820, -21642, -21451, -21338, -21246, -21128, -21109, -21299, -21450, -21492, -21589, -21776, -22130, -22585, -23188, -23823, -24525, -25159, -25538, -25918, -26228, -26559, -26844, -26962, -27053, -27041, -26871, -26607, -26341, -25957, -25420, -24795, -23941, -23115, -22392, -21606, -20740, -19834, -18919, -17989, -17017, -16005, -15055, -14136, -13207, -12293, -11392, -10601, -9894, -9264, -8879, -8670, -8420, -7986, -7722, -7657, -7586, -7375, -7210, -7131, -7148, -7272, -7496, -7867, -8254, -8654, -9026, -9362, -9948, -10492, -10839, -11127, -11365, -11466, -11487, -11472, -11473, -11434, -11428, -11483, -11321, -10804, -10064, -9160, -8170, -7196, -6194, -5041, -3798, -2473, -957, 32741, 32572, 32421, 32509, 32632, 32086, 30970, 29763, 28489, 27452, 26680, 25509, 24284, 23404, 22633, 21994, 21157, 19734, 17855, 15541, 12874, 10593, 8743, 6899, 5076, 2688, -327, -3007, -5077, -7036, -8002, -8832, -10793, -12651, -14478, -16454, -18268, -19835, -21018, -21570, -21822, -21551, -20892, -20147, -19418, -18257, -16697, -15149, -13732, -12546, -11687, -10453, -9292, -8467, -7298, -5836, -4223, -2662, -1160, 447, 1931, 3193, 4383, 5325, 6419, 7839, 9544, 11143, 12164, 12574, 13167, 14442, 15797, 16933, 18380, 20198, 22290, 24338, 25411, 25918, 26183, 26559, 27197, 26885, 25964, 25242, 24533, 23873, 23012, 21454, 19729, 18351, 17484, 16623, 15663, 14263, 12342, 9796, 7219, 4949, 3127, 1179, -884, -2507, -3648, -4700, -5861, -7404, -9105, -10449, -11406, -12311, -13104, -14078, -14891, -15615, -16957, -18567, -20114, -21269, -21795, -22339, -23297, -24066, -24659, -25665, -26396, -26463, -26406, -25677, -24964, -24612, -24270, -24197, -24275, -23910, -23415, -23133, -22680, -21463, -19725, -17804, -15825, -13765, -11685, -10107, -8839, -7897, -7234, -6174, -5480, -5435, -5261, -4884, -4350, -3441, -2268, -887, 386, 1321, 2150, 2713, 2965, 2383, 1681, 1011, 489, 354, 166, 128, 209, 222, 720, 1653, 2047, 1774, 1541, 1092, 213, -1248, -3122, -4845, -6210, -7942, -8879, -9767, -10848, -11452, -12252, -13396, -14322, -15210, -15860, -16573, -17545, -18581, -19491, -20418, -21085, -21173, -20759, -19673, -18216, -17282, -17095, -16748, -16300, -15861, -15243, -14574, -13614, -12204, -10402, -9090, -8463, -7875, -7164, -6467, -5636, -4566, -3550, -2536, -1386, -531, 69, 871, 1863, 2574, 3395, 4172, 4800, 5522, 6124, 6548, 7165, 8459, 10308, 12308, 14169, 15941, 17526, 19001, 20788, 22282, 23509, 24879, 25909, 26429, 26604, 27098, 27506, 28243, 29226, 30069, 31207, 32276};