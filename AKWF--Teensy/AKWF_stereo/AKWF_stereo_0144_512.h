/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0144 512 samples */
 
const int16_t AKWF_stereo_0144_512_DATA [512] = 
{588, 1558, 2469, 3456, 4520, 5583, 6550, 7332, 7923, 8386, 8802, 9229, 9667, 10077, 10425, 10700, 10916, 11096, 11249, 11378, 11488, 11594, 11710, 11840, 11966, 12060, 12108, 12115, 12106, 12106, 12126, 12161, 12203, 12252, 12321, 12417, 12536, 12662, 12788, 12917, 13070, 13262, 13493, 13749, 14010, 14271, 14550, 14866, 15226, 15622, 16032, 16441, 16857, 17295, 17762, 18263, 18774, 19280, 19783, 20297, 20840, 21415, 22004, 22579, 23121, 23623, 24094, 24550, 24998, 25435, 25855, 26256, 26640, 27007, 27358, 27693, 28007, 28297, 28562, 28798, 29004, 29182, 29326, 29439, 29524, 29583, 29614, 29611, 29574, 29504, 29406, 29288, 29151, 28996, 28815, 28608, 28369, 28108, 27827, 27526, 27203, 26855, 26481, 26087, 25676, 25249, 24807, 24348, 23867, 23364, 22844, 22315, 21783, 21245, 20699, 20142, 19563, 18962, 18344, 17707, 17060, 16408, 15757, 15116, 14479, 13835, 13178, 12499, 11799, 11090, 10379, 9667, 8945, 8207, 7448, 6675, 5895, 5118, 4337, 3537, 2712, 1866, 1015, 178, -633, -1416, -2182, -2948, -3717, -4475, -5212, -5927, -6625, -7324, -8035, -8763, -9503, -10242, -10965, -11667, -12345, -12998, -13635, -14267, -14898, -15528, -16147, -16746, -17328, -17904, -18483, -19071, -19663, -20240, -20794, -21323, -21835, -22342, -22855, -23374, -23895, -24406, -24905, -25394, -25867, -26324, -26764, -27180, -27577, -27959, -28330, -28694, -29053, -29400, -29732, -30052, -30355, -30643, -30919, -31176, -31417, -31639, -31842, -32029, -32202, -32357, -32497, -32614, -32702, -32755, -32768, -32746, -32694, -32616, -32519, -32408, -32283, -32143, -31978, -31776, -31524, -31217, -30858, -30460, -30032, -29579, -29096, -28567, -27988, -27365, -26705, -26021, -25313, -24572, -23790, -22963, -22101, -21210, -20287, -19317, -18292, -17203, -16074, -14932, -13791, -12648, -11495, -10310, -9107, -7905, -6701, -5482, -4230, -2944, -1674, -467, -1091, 117, 1252, 2399, 3576, 4726, 5770, 6631, 7297, 7818, 8268, 8709, 9149, 9562, 9915, 10191, 10404, 10581, 10725, 10830, 10883, 10884, 10844, 10784, 10709, 10615, 10490, 10329, 10140, 9942, 9747, 9555, 9358, 9148, 8936, 8731, 8546, 8387, 8247, 8125, 8026, 7959, 7935, 7960, 8025, 8128, 8270, 8456, 8685, 8962, 9278, 9626, 10005, 10426, 10890, 11397, 11938, 12506, 13095, 13710, 14351, 15021, 15707, 16400, 17092, 17777, 18457, 19138, 19812, 20482, 21141, 21780, 22403, 23005, 23584, 24139, 24669, 25172, 25653, 26106, 26528, 26918, 27271, 27588, 27875, 28134, 28366, 28572, 28744, 28881, 28983, 29053, 29093, 29105, 29086, 29036, 28950, 28832, 28679, 28494, 28284, 28045, 27777, 27481, 27156, 26802, 26419, 26005, 25558, 25084, 24579, 24047, 23494, 22913, 22308, 21677, 21020, 20335, 19626, 18887, 18126, 17346, 16547, 15740, 14926, 14099, 13263, 12412, 11547, 10676, 9804, 8934, 8068, 7202, 6334, 5471, 4612, 3760, 2915, 2066, 1211, 357, -482, -1277, -2021, -2724, -3393, -4035, -4656, -5248, -5807, -6333, -6827, -7298, -7752, -8192, -8617, -9032, -9431, -9816, -10189, -10547, -10896, -11242, -11589, -11935, -12280, -12619, -12957, -13297, -13645, -14007, -14380, -14756, -15134, -15510, -15888, -16276, -16676, -17092, -17520, -17959, -18406, -18862, -19322, -19782, -20242, -20699, -21159, -21622, -22092, -22565, -23037, -23506, -23973, -24437, -24891, -25338, -25772, -26190, -26593, -26982, -27356, -27718, -28065, -28398, -28715, -29009, -29279, -29523, -29737, -29921, -30078, -30207, -30311, -30385, -30430, -30445, -30432, -30388, -30308, -30188, -30027, -29832, -29600, -29337, -29035, -28684, -28283, -27831, -27336, -26810, -26250, -25650, -25006, -24310, -23567, -22788, -21968, -21102, -20184, -19205, -18177, -17121, -16041, -14933, -13787, -12590, -11353, -10098, -8838, -7571, -6282, -4957, -3616, -2277};