/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0108 256 samples */
 
const int16_t AKWF_stereo_0108_256_DATA [256] = 
{1167, 3312, 5255, 7306, 9277, 11274, 13123, 14699, 16267, 17687, 18909, 20027, 20936, 22022, 22899, 23834, 24821, 25732, 26533, 27247, 27936, 28473, 28957, 29366, 29775, 30223, 30765, 31261, 31723, 32026, 32223, 32326, 32343, 32300, 32232, 32189, 32226, 32376, 32500, 32600, 32706, 32739, 32665, 32526, 32320, 32134, 31979, 31782, 31537, 31282, 31022, 30749, 30569, 30398, 30253, 30085, 29969, 29835, 29719, 29605, 29402, 29169, 28910, 28743, 28494, 28116, 27752, 27340, 26831, 26353, 25831, 25282, 24765, 24169, 23695, 23289, 22902, 22424, 21823, 21191, 20645, 20027, 19477, 18959, 18507, 18087, 17686, 17467, 17464, 17612, 17718, 17745, 17980, 18216, 18262, 18045, 17934, 18030, 18069, 18065, 18057, 17948, 17766, 17470, 17111, 16653, 16205, 15635, 15003, 14149, 13257, 12318, 11153, 9986, 8825, 7506, 6200, 5087, 4264, 3625, 2887, 2470, 1937, 1362, 579, -194, -930, -1390, -1976, -2372, -2768, -3324, -3769, -4410, -5025, -5483, -5854, -6122, -6694, -7298, -7993, -8750, -9412, -10186, -10909, -11754, -12691, -13617, -14588, -15435, -16178, -16857, -17301, -17587, -17791, -17843, -17900, -17867, -17583, -17345, -17219, -17031, -16881, -16747, -16587, -16524, -16559, -16635, -16893, -17014, -17087, -17269, -17507, -17655, -17831, -18023, -18256, -18255, -18287, -18245, -18381, -18565, -18821, -19141, -19659, -20233, -20789, -21442, -22047, -22518, -22794, -22882, -23070, -23198, -23327, -23657, -23988, -24440, -24940, -25340, -25707, -25980, -26155, -26424, -26849, -27284, -27713, -28064, -28473, -28735, -28861, -28902, -28921, -28904, -28912, -28967, -29086, -29283, -29448, -29625, -29679, -29628, -29469, -29301, -29052, -28766, -28459, -28097, -27677, -27184, -26649, -26039, -25317, -24598, -23886, -23154, -22449, -21737, -20997, -20164, -19270, -18337, -17359, -16334, -15308, -14421, -13592, -12518, -11299, -9976, -8708, -7315, -5727, -4115, -2531, -766};