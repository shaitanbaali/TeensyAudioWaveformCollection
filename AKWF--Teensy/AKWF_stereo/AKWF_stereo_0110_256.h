/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0110 256 samples */
 
const int16_t AKWF_stereo_0110_256_DATA [256] = 
{12073, 12076, 12078, 12079, 12082, 12111, 11953, 13923, 14690, 14523, 14553, 14552, 14565, 14560, 14482, 19176, 21114, 20756, 20820, 20819, 20827, 20757, 22212, 22629, 22531, 22545, 22543, 22540, 22557, 22441, 22970, 24225, 23909, 24870, 27136, 26978, 27001, 26999, 26996, 26993, 27009, 26899, 27411, 28365, 28252, 28269, 28265, 28261, 28258, 28253, 28250, 28246, 28256, 28192, 28388, 32370, 32844, 32718, 32738, 32734, 32731, 32728, 32723, 32720, 32716, 32712, 32708, 32704, 32700, 32696, 32693, 32610, 33027, 29884, 27808, 28206, 28127, 28122, 28117, 28112, 28108, 28102, 28098, 28093, 28081, 28127, 27025, 26704, 26772, 26754, 26749, 26745, 26701, 26912, 25901, 23562, 23889, 23281, 22048, 22162, 22136, 22131, 22126, 22121, 22090, 22231, 21519, 20201, 20346, 20313, 20299, 20318, 20281, 16271, 13765, 13855, 13840, 13831, 13824, 13808, 13888, 11738, 11153, 11282, 11254, 11199, 11252, 11372, -6806, -13157, -11896, -12137, -12139, -12167, -12010, -13977, -14743, -14577, -14606, -14607, -14645, -14497, -15380, -19579, -21108, -20798, -20860, -20859, -20867, -20797, -22249, -22667, -22568, -22582, -22580, -22577, -22594, -22478, -23005, -24262, -23930, -24977, -27217, -26995, -27031, -27028, -27025, -27022, -27033, -26950, -27942, -28373, -28284, -28295, -28291, -28288, -28285, -28281, -28277, -28273, -28282, -28230, -28373, -32250, -32885, -32734, -32759, -32755, -32752, -32748, -32744, -32740, -32736, -32732, -32729, -32726, -32721, -32717, -32713, -32635, -33033, -30108, -27855, -28228, -28155, -28149, -28145, -28139, -28134, -28130, -28125, -28120, -28108, -28154, -27054, -26733, -26801, -26782, -26778, -26774, -26731, -26940, -25931, -23616, -23823, -23800, -22425, -22119, -22185, -22167, -22162, -22158, -22134, -22235, -20799, -20267, -20378, -20354, -20338, -20358, -20320, -16320, -13818, -13908, -13893, -13884, -13877, -13862, -13940, -11794, -11211, -11340, -11313, -11309, -11304, -11301};