/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0002 512 samples */
 
const int16_t AKWF_stereo_0002_512_DATA [512] = 
{742, 2956, 5056, 7094, 9069, 10976, 12822, 14597, 16308, 17954, 19526, 21070, 21436, 21089, 20864, 20651, 20463, 20297, 20150, 20021, 19907, 19806, 19717, 19640, 19570, 19510, 19457, 19410, 19369, 19333, 19301, 19274, 19250, 19229, 19210, 19195, 19181, 19169, 19159, 19150, 19143, 19137, 19132, 19127, 19124, 19121, 19119, 19118, 19117, 19117, 19117, 19117, 19117, 19118, 19119, 19121, 19122, 19124, 19126, 19128, 19106, 19503, 17674, 9043, 20311, 19063, 19285, 19273, 19261, 19253, 19244, 19236, 19232, 19228, 19224, 19222, 19221, 19220, 19220, 19220, 19221, 19222, 19225, 19205, 19161, 19119, 19078, 19037, 18997, 18956, 18916, 18877, 18837, 18797, 18758, 18720, 18681, 18642, 18604, 18567, 18529, 18492, 18455, 18417, 18380, 18344, 18307, 18270, 18234, 18197, 18162, 18126, 18090, 18055, 18020, 17985, 17950, 17915, 17881, 17846, 17811, 17777, 17743, 17709, 17675, 17641, 17609, 17575, 17542, 17508, 17476, 17443, 17410, 17378, 17344, 17316, 17250, 17060, 18635, -17788, -32678, -28258, -27656, -26667, -26006, -25401, -24733, -24169, -23681, -23316, -23069, -22844, -22646, -22471, -22317, -22180, -22061, -21955, -21861, -21779, -21705, -21641, -21585, -21535, -21491, -21452, -21418, -21388, -21362, -21340, -21319, -21302, -21286, -21273, -21261, -21251, -21242, -21235, -21229, -21223, -21220, -21216, -21213, -21210, -21208, -21207, -21205, -21205, -21204, -21204, -21205, -21205, -21207, -21208, -21208, -21210, -21211, -21213, -21215, -21217, -21219, -21221, -21223, -21225, -21227, -21230, -21232, -21235, -21237, -21241, -21243, -21246, -21249, -21251, -21255, -21258, -21261, -21264, -21268, -21271, -21273, -21277, -21280, -21284, -21287, -21291, -21294, -21298, -21301, -21305, -21308, -21312, -21317, -21320, -21324, -21327, -21331, -21336, -21340, -21343, -21347, -21352, -21355, -21360, -21364, -21354, -21398, -21198, -18954, -16196, -13605, -11052, -8566, -6139, -3781, -1435, -5356, -7609, -9845, -12110, -14396, -16701, -19025, -21342, -23693, -25968, -26317, -25907, -25658, -25416, -25203, -25013, -24847, -24700, -24570, -24455, -24354, -24265, -24186, -24117, -24057, -24003, -23955, -23914, -23878, -23845, -23817, -23793, -23772, -23753, -23736, -23721, -23709, -23699, -23690, -23682, -23676, -23670, -23666, -23663, -23659, -23656, -23654, -23653, -23652, -23651, -23652, -23651, -23652, -23653, -23654, -23655, -23657, -23658, -23659, -23662, -23640, -23188, -25928, 7044, 27191, 22913, 22900, 22310, 21789, 21336, 20875, 20487, 20185, 19910, 19669, 19456, 19268, 19102, 18957, 18828, 18714, 18614, 18528, 18432, 18324, 18225, 18132, 18045, 17962, 17884, 17811, 17740, 17674, 17611, 17549, 17491, 17434, 17380, 17327, 17276, 17226, 17178, 17131, 17085, 17040, 16996, 16953, 16910, 16868, 16828, 16786, 16746, 16707, 16667, 16629, 16590, 16553, 16515, 16478, 16441, 16405, 16368, 16332, 16296, 16261, 16225, 16190, 16155, 16120, 16085, 16051, 16016, 15983, 15949, 15914, 15885, 15829, 15494, 17719, -16746, -34363, -29581, -29053, -28068, -27409, -26805, -26140, -25577, -25092, -24728, -24481, -24257, -24061, -23887, -23733, -23598, -23479, -23374, -23281, -23199, -23126, -23063, -23007, -22958, -22915, -22877, -22844, -22814, -22784, -22760, -22744, -20937, -18194, -15669, -13168, -10729, -8355, -6041, -3779, -1591, 540, 2605, 4603, 6544, 8418, 10227, 11977, 13662, 15280, 16824, 18394, 19041, 18704, 18464, 18245, 18049, 17877, 17725, 17591, 17473, 17370, 17280, 17199, 17129, 17068, 17014, 16966, 16925, 16889, 16858, 16830, 16807, 16787, 16769, 16754, 16741, 16730, 16722, 16714, 16708, 16703, 16699, 16696, 16694, 16692, 16692, 16692, 16692, 16693, 16694, 16696, 16698, 16701, 16703, 16706, 16710, 16713, 16715, 16719, 16724, 16727, 16730, 16734, 16727, 16777, 16504, 14853, 12968, 11089, 9165, 7197, 5192, 3152, 1071, -1037, -3236};