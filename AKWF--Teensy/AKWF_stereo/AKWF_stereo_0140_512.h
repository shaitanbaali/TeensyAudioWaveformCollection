/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0140 512 samples */
 
const int16_t AKWF_stereo_0140_512_DATA [512] = 
{537, 2347, 3949, 5347, 6738, 8214, 9664, 11092, 12445, 13667, 14846, 15988, 17182, 18492, 19746, 20836, 21781, 22583, 23268, 23898, 24512, 25109, 25742, 26359, 26869, 27270, 27629, 28036, 28470, 28869, 29226, 29535, 29821, 30107, 30425, 30751, 31030, 31276, 31495, 31703, 31901, 32086, 32261, 32424, 32590, 32727, 32769, 32762, 32754, 32746, 32732, 32679, 32603, 32544, 32485, 32434, 32390, 32328, 32221, 32108, 32053, 32086, 32128, 32163, 32201, 32223, 32186, 32120, 32080, 32041, 31961, 31846, 31712, 31565, 31419, 31302, 31223, 31174, 31145, 31125, 31095, 31035, 30944, 30812, 30652, 30456, 30245, 30056, 29891, 29741, 29612, 29504, 29352, 29106, 28854, 28629, 28382, 28093, 27751, 27395, 27036, 26591, 26050, 25503, 24980, 24513, 24056, 23553, 22997, 22410, 21846, 21276, 20636, 19907, 19113, 18259, 17409, 16520, 15501, 14406, 13248, 11963, 10476, 8873, 7220, 5365, 3263, 1247, -571, -2347, -3954, -5354, -6744, -8218, -9668, -11094, -12448, -13667, -14846, -15988, -17182, -18490, -19745, -20834, -21780, -22581, -23266, -23896, -24510, -25106, -25740, -26357, -26866, -27267, -27624, -28033, -28467, -28865, -29222, -29531, -29817, -30105, -30423, -30747, -31026, -31272, -31492, -31701, -31897, -32082, -32257, -32421, -32588, -32725, -32767, -32759, -32750, -32743, -32729, -32677, -32600, -32540, -32482, -32431, -32388, -32324, -32218, -32103, -32048, -32082, -32124, -32159, -32197, -32219, -32180, -32115, -32074, -32035, -31956, -31840, -31706, -31558, -31412, -31296, -31218, -31168, -31139, -31119, -31088, -31027, -30937, -30805, -30645, -30449, -30238, -30048, -29883, -29733, -29604, -29498, -29344, -29099, -28847, -28621, -28375, -28086, -27744, -27386, -27029, -26583, -26043, -25495, -24972, -24505, -24048, -23543, -22988, -22401, -21838, -21268, -20629, -19899, -19105, -18250, -17402, -16513, -15496, -14401, -13244, -11960, -10473, -8869, -7219, -5367, -3271, -1222, -12155, -10612, -8971, -7186, -5117, -2390, 3615, 9114, 11769, 13669, 15241, 16612, 17854, 19018, 20100, 21094, 21989, 22776, 23477, 24113, 24702, 25246, 25745, 26203, 26615, 26987, 27341, 27690, 28032, 28361, 28670, 28953, 29213, 29459, 29697, 29909, 30093, 30275, 30454, 30606, 30726, 30825, 30925, 31035, 31155, 31260, 31332, 31384, 31421, 31444, 31455, 31437, 31399, 31361, 31309, 31238, 31156, 31055, 30930, 30803, 30687, 30576, 30467, 30360, 30259, 30157, 30048, 29955, 29882, 29816, 29739, 29657, 29569, 29469, 29371, 29287, 29238, 29230, 29252, 29274, 29271, 29237, 29185, 29123, 29059, 28988, 28914, 28849, 28795, 28751, 28721, 28690, 28648, 28603, 28574, 28551, 28514, 28443, 28324, 28170, 28008, 27819, 27604, 27390, 27189, 26999, 26801, 26577, 26319, 26034, 25737, 25417, 25059, 24657, 24227, 23777, 23305, 22781, 22190, 21536, 20810, 19995, 19087, 18132, 17120, 16011, 14793, 13483, 12094, 10578, 8939, 7156, 5094, 2375, -3618, -9109, -11757, -13652, -15221, -16587, -17828, -18991, -20073, -21068, -21961, -22747, -23448, -24084, -24675, -25217, -25716, -26174, -26586, -26958, -27311, -27661, -28003, -28332, -28637, -28920, -29181, -29426, -29662, -29874, -30057, -30239, -30418, -30569, -30690, -30790, -30888, -31000, -31120, -31225, -31297, -31349, -31386, -31409, -31419, -31402, -31364, -31326, -31274, -31204, -31121, -31019, -30895, -30766, -30648, -30535, -30424, -30314, -30210, -30105, -29995, -29898, -29823, -29754, -29675, -29591, -29502, -29400, -29301, -29216, -29167, -29160, -29181, -29203, -29201, -29167, -29116, -29056, -28992, -28922, -28849, -28784, -28733, -28691, -28663, -28634, -28594, -28550, -28522, -28501, -28467, -28398, -28281, -28129, -27967, -27781, -27565, -27353, -27154, -26964, -26768, -26545, -26287, -26003, -25708, -25391, -25033, -24634, -24205, -23755, -23286, -22762, -22172, -21520, -20795, -19982, -19078, -18123, -17113, -16008, -14796, -13460};