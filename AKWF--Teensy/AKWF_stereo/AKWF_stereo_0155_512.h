/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0155 512 samples */
 
const int16_t AKWF_stereo_0155_512_DATA [512] = 
{22113, 29799, 21927, 21088, 20511, 19515, 18409, 17527, 16769, 16066, 15389, 14713, 14063, 13464, 12933, 12471, 12085, 11764, 11508, 11312, 11170, 11074, 11020, 10996, 10996, 11013, 11040, 11072, 11104, 11131, 11150, 11161, 11157, 11141, 11113, 11071, 11015, 10948, 10871, 10782, 10686, 10582, 10472, 10357, 10239, 10118, 9996, 9875, 9750, 9627, 9506, 9385, 9267, 9148, 9031, 8915, 8801, 8686, 8573, 8459, 8346, 8234, 8121, 8009, 7895, 7782, 7667, 7552, 7438, 7321, 7203, 7085, 6966, 6848, 6728, 6607, 6486, 6364, 6243, 6120, 5998, 5874, 5751, 5628, 5502, 5379, 5255, 5130, 5004, 4880, 4755, 4631, 4505, 4380, 4254, 4128, 4002, 3877, 3752, 3626, 3498, 3372, 3246, 3121, 2993, 2866, 2739, 2613, 2485, 2358, 2232, 2103, 1976, 1850, 1721, 1593, 1467, 1339, 1210, 1084, 956, 829, 700, 573, 446, 318, 189, 62, -63, -190, -319, -447, -574, -701, -830, -957, -1085, -1211, -1340, -1468, -1594, -1722, -1851, -1977, -2104, -2233, -2359, -2486, -2614, -2740, -2867, -2994, -3122, -3247, -3373, -3499, -3627, -3753, -3878, -4003, -4129, -4255, -4380, -4506, -4632, -4756, -4881, -5005, -5131, -5255, -5379, -5503, -5629, -5752, -5875, -5998, -6121, -6244, -6365, -6487, -6608, -6729, -6848, -6967, -7086, -7204, -7322, -7439, -7553, -7668, -7782, -7896, -8010, -8122, -8234, -8347, -8460, -8574, -8686, -8801, -8916, -9031, -9148, -9267, -9386, -9507, -9628, -9751, -9875, -9997, -10119, -10239, -10357, -10473, -10582, -10686, -10782, -10872, -10949, -11015, -11071, -11114, -11142, -11158, -11161, -11151, -11132, -11105, -11073, -11041, -11013, -10997, -10997, -11020, -11075, -11170, -11313, -11509, -11765, -12085, -12472, -12933, -13465, -14064, -14713, -15390, -16066, -16769, -17528, -18410, -19516, -20511, -21088, -21928, -29799, -22113, 21286, 29995, 21241, 20950, 20681, 19218, 17582, 16485, 15809, 15318, 14867, 14384, 13892, 13434, 13030, 12685, 12396, 12154, 11956, 11799, 11679, 11593, 11535, 11498, 11478, 11468, 11466, 11465, 11463, 11457, 11445, 11426, 11397, 11359, 11312, 11253, 11186, 11111, 11028, 10936, 10839, 10735, 10628, 10517, 10405, 10288, 10171, 10053, 9934, 9816, 9698, 9579, 9462, 9345, 9227, 9112, 8996, 8880, 8765, 8649, 8533, 8418, 8302, 8187, 8069, 7952, 7834, 7716, 7598, 7479, 7357, 7237, 7116, 6994, 6872, 6748, 6625, 6500, 6376, 6250, 6126, 6001, 5875, 5748, 5622, 5495, 5369, 5241, 5114, 4987, 4860, 4732, 4605, 4476, 4348, 4220, 4090, 3962, 3834, 3705, 3576, 3447, 3319, 3188, 3059, 2930, 2800, 2671, 2540, 2410, 2281, 2150, 2020, 1891, 1759, 1629, 1500, 1368, 1238, 1108, 977, 847, 716, 586, 455, 325, 194, 64, -65, -195, -326, -456, -587, -717, -848, -978, -1109, -1239, -1369, -1501, -1630, -1760, -1891, -2021, -2151, -2282, -2411, -2541, -2671, -2801, -2931, -3060, -3189, -3320, -3448, -3576, -3706, -3835, -3963, -4091, -4221, -4349, -4477, -4606, -4733, -4861, -4987, -5115, -5242, -5370, -5496, -5622, -5749, -5876, -6002, -6127, -6251, -6377, -6501, -6625, -6749, -6873, -6995, -7117, -7238, -7358, -7479, -7599, -7717, -7835, -7953, -8070, -8187, -8303, -8418, -8534, -8650, -8765, -8881, -8996, -9112, -9228, -9346, -9463, -9579, -9698, -9817, -9934, -10054, -10172, -10289, -10406, -10518, -10629, -10736, -10840, -10937, -11029, -11112, -11187, -11253, -11312, -11359, -11398, -11426, -11445, -11457, -11464, -11466, -11466, -11469, -11478, -11498, -11536, -11594, -11680, -11799, -11956, -12154, -12396, -12686, -13031, -13434, -13893, -14384, -14868, -15319, -15810, -16486, -17582, -19219, -20681, -20950, -21242, -29995, -21287};