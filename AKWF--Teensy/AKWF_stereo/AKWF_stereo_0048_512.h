/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0048 512 samples */
 
const int16_t AKWF_stereo_0048_512_DATA [512] = 
{19151, 34205, 28876, 30945, 31130, 28257, 28022, 28024, 25867, 25311, 26036, 25252, 24830, 25893, 26271, 26096, 26821, 27505, 27446, 27601, 27969, 27863, 27639, 27634, 27480, 27189, 27055, 26963, 26804, 26741, 26767, 26768, 26803, 26899, 26976, 27035, 27114, 27172, 27193, 27208, 27214, 27191, 27161, 27134, 27099, 27065, 27042, 27026, 27015, 27013, 27019, 27029, 27041, 27056, 27070, 27082, 27090, 27096, 27098, 27097, 27094, 27089, 27082, 27076, 27071, 27066, 27064, 27062, 27062, 27064, 27065, 27068, 27070, 27072, 27075, 27077, 27077, 27077, 27077, 27077, 27076, 27075, 27073, 27072, 27071, 27071, 27071, 27071, 27071, 27071, 27072, 27072, 27072, 27072, 27073, 27074, 27074, 27074, 27073, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 27072, 26409, 30103, 11142, -34117, -28763, -29101, -31969, -29746, -27974, -29134, -27733, -25698, -26367, -26328, -25000, -25372, 18336, 21085, 18045, 18654, 18994, 19255, 19408, 19482, 19514, 19524, 19525, 19525, 19524, 19523, 19523, 19523, 19523, 19523, 19523, 19524, 19524, 19524, 19524, 19525, 19525, 19525, 19525, 19525, 19526, 19527, 19527, 19527, 19527, 19527, 19528, 19528, 19528, 19528, 19528, 19528, 19528, 19529, 19529, 19529, 19529, 19529, 19529, 19529, 19530, 19530, 19530, 19530, 19530, 19530, 19530, 19530, 19530, 19531, 19531, 19531, 19531, 19531, 19531, 19531, 19531, 19531, 19531, 19532, 19532, 19532, 19532, 19532, 19532, 19532, 19532, 19532, 19532, 19532, 19532, 19532, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19534, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19535, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19536, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 19537, 18927, 22476, 4042, -25752, -17508, -18530, -18765, -19084, -19291, -19400, -19450, -19470, -19476, -19476, -19476, -19477};