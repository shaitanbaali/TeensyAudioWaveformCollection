/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0188 512 samples */
 
const int16_t AKWF_stereo_0188_512_DATA [512] = 
{233, 878, 1508, 2142, 2776, 3405, 4034, 4659, 5284, 5911, 6536, 7159, 7783, 8401, 9010, 9614, 10211, 10796, 11374, 11951, 12525, 13096, 13680, 14276, 14873, 15492, 16123, 16751, 17385, 18029, 18656, 19267, 19877, 20468, 21022, 21565, 22092, 22584, 23054, 23523, 23970, 24385, 24804, 25216, 25593, 25962, 26333, 26678, 26989, 27303, 27599, 27848, 28092, 28328, 28515, 28698, 28872, 29006, 29112, 29223, 29309, 29348, 29393, 29425, 29413, 29381, 29352, 29300, 29224, 29188, 29172, 29150, 29165, 29217, 29268, 29313, 29385, 29442, 29447, 29445, 29412, 29309, 29188, 29030, 28801, 28530, 28240, 27898, 27496, 27090, 26655, 26164, 25661, 25150, 24602, 24019, 23444, 22848, 22206, 21564, 20919, 20234, 19529, 18836, 18120, 17369, 16632, 15886, 15107, 14324, 13538, 12762, 11977, 11192, 10377, 9554, 8719, 7908, 7067, 6242, 5427, 4583, 3725, 2878, 2032, 1181, 326, -519, -1364, -2202, -3034, -3871, -4693, -5502, -6294, -7073, -7836, -8587, -9324, -10050, -10767, -11473, -12166, -12852, -13527, -14185, -14828, -15456, -16066, -16646, -17214, -17764, -18282, -18783, -19276, -19744, -20187, -20631, -21063, -21471, -21886, -22307, -22714, -23118, -23542, -23960, -24358, -24769, -25175, -25548, -25909, -26265, -26574, -26860, -27137, -27374, -27565, -27754, -27918, -28032, -28138, -28238, -28300, -28342, -28410, -28487, -28565, -28701, -28883, -29079, -29305, -29574, -29841, -30083, -30338, -30571, -30739, -30881, -30991, -31018, -31012, -30973, -30870, -30714, -30547, -30344, -30076, -29802, -29516, -29177, -28810, -28445, -28041, -27583, -27126, -26644, -26105, -25552, -24993, -24396, -23764, -23142, -22501, -21821, -21144, -20468, -19758, -19032, -18321, -17594, -16837, -16102, -15367, -14612, -13871, -13151, -12430, -11711, -11023, -10346, -9665, -9006, -8369, -7729, -7096, -6488, -5888, -5284, -4691, -4092, -3477, -2864, -2255, -1638, -1012, -376, -4004, -3368, -2763, -2162, -1566, -987, -411, 168, 750, 1340, 1943, 2569, 3211, 3869, 4543, 5225, 5912, 6602, 7284, 7961, 8626, 9274, 9910, 10540, 11154, 11770, 12384, 12991, 13602, 14224, 14843, 15460, 16090, 16721, 17336, 17957, 18573, 19168, 19745, 20318, 20867, 21379, 21885, 22374, 22826, 23265, 23704, 24122, 24514, 24917, 25310, 25667, 26027, 26386, 26702, 27014, 27317, 27577, 27802, 28025, 28220, 28365, 28519, 28667, 28782, 28894, 29022, 29142, 29249, 29406, 29589, 29770, 29990, 30247, 30494, 30729, 30983, 31208, 31371, 31518, 31623, 31643, 31638, 31591, 31465, 31294, 31106, 30870, 30575, 30284, 29969, 29597, 29211, 28814, 28368, 27869, 27363, 26817, 26201, 25570, 24920, 24211, 23470, 22735, 21969, 21161, 20368, 19568, 18732, 17899, 17075, 16270, 15464, 14674, 13864, 13054, 12242, 11463, 10657, 9872, 9105, 8315, 7511, 6720, 5933, 5138, 4336, 3548, 2758, 1970, 1192, 409, -365, -1120, -1857, -2576, -3277, -3953, -4611, -5256, -5886, -6504, -7113, -7713, -8309, -8903, -9492, -10083, -10675, -11263, -11860, -12464, -13062, -13663, -14270, -14870, -15453, -16040, -16616, -17168, -17719, -18264, -18791, -19308, -19832, -20346, -20840, -21341, -21841, -22316, -22781, -23249, -23680, -24096, -24509, -24891, -25236, -25584, -25914, -26200, -26483, -26764, -27011, -27241, -27495, -27761, -28029, -28354, -28725, -29109, -29521, -29974, -30425, -30843, -31266, -31658, -31972, -32247, -32479, -32615, -32709, -32765, -32753, -32688, -32619, -32519, -32364, -32212, -32052, -31841, -31603, -31365, -31081, -30731, -30373, -29977, -29507, -29014, -28505, -27947, -27345, -26752, -26139, -25485, -24841, -24204, -23539, -22867, -22222, -21566, -20882, -20223, -19565, -18878, -18197, -17530, -16847, -16152, -15481, -14817, -14138, -13480, -12842, -12196, -11551, -10932, -10317, -9688, -9073, -8450, -7809, -7168, -6537, -5898, -5253, -4611};