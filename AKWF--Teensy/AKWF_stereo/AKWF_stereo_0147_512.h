/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0147 512 samples */
 
const int16_t AKWF_stereo_0147_512_DATA [512] = 
{1959, 6625, 11086, 14909, 17676, 19760, 21811, 23861, 25816, 27606, 29212, 30615, 31713, 32448, 32761, 32602, 31999, 31064, 29967, 28823, 27656, 26380, 24800, 22722, 20205, 17487, 14571, 11384, 7946, 4468, 1235, -1340, -3021, -3637, -3667, -3831, -4021, -4382, -5021, -5794, -6788, -8025, -9279, -10412, -11411, -12310, -13121, -13780, -14093, -13808, -12814, -11216, -9231, -7134, -5180, -3583, -2249, -859, 532, 1574, 2033, 1967, 1644, 1358, 1342, 1707, 2463, 3541, 4831, 6208, 7540, 8674, 9536, 10143, 10589, 10949, 11184, 11249, 11057, 10497, 9601, 8521, 7439, 6487, 5724, 5143, 4639, 4087, 3580, 3280, 2963, 2275, 979, -905, -3050, -5058, -6685, -7886, -8785, -9553, -10403, -11598, -13148, -14771, -16464, -18288, -20101, -21833, -23486, -25014, -26391, -27610, -28604, -29293, -29599, -29488, -28961, -28044, -26812, -25331, -23526, -21249, -18543, -15693, -12939, -10547, -8585, -5932, -2285, 1971, 6219, 9976, 12827, 14980, 17077, 19240, 21290, 23218, 25025, 26680, 28062, 29080, 29649, 29685, 29214, 28392, 27429, 26465, 25499, 24416, 23037, 21166, 18863, 16395, 13761, 10887, 7798, 4632, 1714, -638, -2174, -2876, -2792, -2451, -2216, -2203, -2515, -3050, -3845, -4936, -6066, -7017, -7783, -8420, -8985, -9456, -9640, -9243, -8136, -6362, -4086, -1629, 594, 2243, 3446, 4527, 5475, 6091, 6208, 5845, 5230, 4647, 4318, 4350, 4763, 5508, 6479, 7538, 8530, 9297, 9760, 9963, 10030, 10026, 9891, 9538, 8841, 7755, 6369, 4836, 3311, 1919, 714, -285, -1129, -1978, -2809, -3405, -3900, -4658, -5886, -7546, -9367, -11023, -12315, -13212, -13826, -14338, -14940, -15904, -17213, -18590, -20037, -21605, -23168, -24630, -25985, -27221, -28308, -29218, -29931, -30376, -30472, -30162, -29444, -28328, -26845, -25050, -22883, -20179, -17064, -13838, -10870, -8446, -5901, -2301, 2854, 6975, 10878, 14261, 16707, 18403, 20007, 21764, 23597, 25410, 27154, 28788, 30196, 31295, 32066, 32483, 32560, 32374, 32044, 31658, 31225, 30669, 29829, 28507, 26666, 24454, 21944, 19128, 16040, 12828, 9698, 6894, 4588, 3040, 2118, 1091, -161, -1618, -3246, -4759, -6032, -7146, -8122, -9027, -10003, -11145, -12466, -13909, -15316, -16471, -17210, -17509, -17393, -16917, -16168, -15290, -14335, -13169, -11742, -10198, -8689, -7256, -5843, -4382, -2808, -1104, 700, 2476, 4125, 5598, 6869, 7930, 8814, 9591, 10335, 11068, 11677, 12039, 12094, 11789, 11155, 10331, 9517, 8857, 8363, 7945, 7436, 6622, 5486, 4229, 2877, 1268, -682, -2840, -4975, -6884, -8439, -9614, -10499, -11216, -11911, -12771, -13837, -14860, -15721, -16523, -17301, -18100, -19026, -20128, -21377, -22726, -24045, -25146, -25847, -26018, -25619, -24699, -23392, -21856, -20136, -18112, -15736, -13195, -10709, -8525, -6890, -5024, -2328, 969, 4354, 7392, 9687, 11271, 12765, 14513, 16385, 18282, 20179, 22011, 23624, 24910, 25829, 26345, 26465, 26302, 26016, 25721, 25408, 24967, 24234, 23008, 21239, 19118, 16727, 14070, 11208, 8273, 5501, 3120, 1301, 161, -246, -321, -549, -1062, -1818, -2572, -3173, -3680, -4112, -4484, -4927, -5563, -6438, -7526, -8664, -9592, -10109, -10152, -9722, -8878, -7770, -6599, -5416, -4063, -2483, -795, 843, 2317, 3653, 4922, 6173, 7417, 8635, 9793, 10844, 11744, 12438, 12903, 13165, 13294, 13379, 13444, 13369, 13008, 12250, 11080, 9592, 7958, 6367, 4953, 3745, 2658, 1510, 31, -1832, -3789, -5723, -7747, -9913, -12141, -14259, -16103, -17577, -18670, -19468, -20093, -20667, -21370, -22231, -23023, -23653, -24209, -24721, -25214, -25769, -26450, -27251, -28109, -28928, -29556, -29815, -29569, -28771, -27453, -25709, -23681, -21435, -18832, -15854, -12685, -9601, -6934, -4391, -1069};