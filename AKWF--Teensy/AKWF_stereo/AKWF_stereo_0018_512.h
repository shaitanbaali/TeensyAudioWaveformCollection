/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0018 512 samples */
 
const int16_t AKWF_stereo_0018_512_DATA [512] = 
{2502, 4384, 5357, 6378, 6443, 6901, 6825, 6894, 6912, 6831, 6936, 6906, 7056, 7165, 7360, 7596, 7801, 8149, 8495, 8907, 9335, 9799, 10293, 10438, 12977, 3787, -25215, -13449, -6883, -4505, 5984, 11474, 16773, 20152, 21217, 22861, 22678, 23217, 22936, 22776, 22700, 22283, 22215, 21960, 22035, 22055, 22173, 22420, 22645, 23030, 23376, 23896, 24153, 20842, 16626, 12484, 8517, 1183, -758, 1662, 1928, 4064, 6844, 8888, 11313, 12884, 14440, 15610, 16559, 17428, 17433, 20812, 5689, -19544, -16610, -20255, -23336, -21796, -21789, -19713, -18685, -17921, -16782, -17383, -15647, 20668, 28936, 27370, 32121, 31317, 29191, 26781, 22239, 19872, 16057, 13811, 11461, 9393, 8189, 6709, 6134, 5426, 5204, 5181, 5289, 5663, 6077, 6752, 7437, 8248, 9128, 10034, 11018, 11993, 12994, 14070, 14850, 11772, 7836, 3924, 1265, -11001, -24857, -16965, -15034, -12498, -5346, -1461, 3355, 6039, 5506, 3392, 222, -2982, -7066, -10606, -14123, -17630, -17528, -14764, -12223, -8922, -5251, -2044, 896, 3073, 5003, 6662, 7990, 9268, 8790, 7002, 6485, -345, -17605, -12343, -10846, -11481, -8087, -6809, -5270, -4509, -4791, -4630, -5367, -5596, -6176, -6608, -6933, -7336, -7500, -7772, -7861, -7951, -7978, -7928, -7883, -7753, -7629, -7456, -7275, -7065, -6821, -6601, -6358, -6121, -5873, -5626, -5379, -5130, -4886, -4641, -4402, -4166, -3924, -3678, -3477, -3270, -3401, -1273, -11380, -28075, -25207, -27208, -28723, -26607, -25763, -23397, -21889, -20652, -19221, -18891, -17513, 3067, 7739, 6641, 9778, 8789, 6942, 5253, 2430, 1022, -1112, -2395, -3684, -4819, -5506, -6330, -6698, -7135, -7329, -7442, -7501, -7405, -7320, -7112, -6905, -6640, -6347, -6048, -5718, -5396, -5054, -4722, -4386, -4062, -3742, -3688, -1994, -8753, -22766, -14461, -11409, -9469, -3795, -762, 9219, 10483, 10846, 11868, 11449, 12017, 11758, 11854, 11912, 11792, 12006, 11938, 12156, 12250, 12440, 12658, 12793, 13092, 13331, 13640, 13929, 14236, 14559, 14469, 17088, 6259, -22926, 2919, 10791, 3674, 11651, 13737, 18062, 20966, 20808, 22654, 21459, 22102, 21427, 21118, 21056, 20352, 20360, 19894, 19963, 19850, 19825, 19954, 19949, 20163, 20237, 20523, 20421, 16334, 12621, 9980, 7255, 299, 286, 4098, 2463, 3155, 5061, 5781, 7482, 7952, 8731, 9120, 9333, 9670, 9043, 12250, -4534, -27377, -14597, -16960, -23281, -21057, -22470, -20109, -19578, -19391, -18255, -19636, -17494, 21850, 20717, 9317, 18906, 18613, 16379, 15322, 10309, 9940, 6695, 6005, 4855, 3741, 3772, 2894, 3234, 2978, 3253, 3532, 3731, 4209, 4513, 5094, 5540, 6077, 6620, 7116, 7678, 8163, 8667, 9231, 9410, 5358, 1665, -1042, -2569, -15667, -28287, -12522, -12148, -14696, -8925, -7773, -3785, -2323, -4191, -6426, -9228, -11354, -14850, -17506, -20313, -23169, -21932, -18889, -17600, -15646, -12899, -10560, -8197, -6546, -4965, -3503, -2306, -997, -1643, -3103, -2289, -8679, -24865, -12045, -9310, -13299, -10029, -9434, -7622, -6438, -6690, -5860, -6495, -6164, -6454, -6535, -6476, -6662, -6487, -6592, -6449, -6389, -6287, -6114, -6009, -5801, -5651, -5449, -5261, -5054, -4819, -4626, -4407, -4206, -3991, -3780, -3571, -3355, -3142, -2926, -2711, -2493, -2265, -2027, -1830, -1621, -1784, 654, -11000, -26814, -15952, -17074, -21033, -18505, -18790, -16231, -15108, -14296, -12874, -13096, -11426, 10633, 9368, 2961, 8446, 8424, 7241, 6779, 4204, 4117, 2520, 2221, 1694, 1183, 1267, 879, 1123, 1055, 1257, 1466, 1639, 1971, 2177, 2515, 2776, 3072, 3367, 3626, 3911, 4149, 4401, 4623, 4839, 5037, 5220, 5107, 6905, -1247, -14967, 1016, 3440, 697, 5208, 6361};