/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0112 512 samples */
 
const int16_t AKWF_stereo_0112_512_DATA [512] = 
{470, 1444, 2404, 3366, 4321, 5276, 6228, 7180, 8122, 9037, 9940, 10809, 11644, 12485, 13324, 14179, 14990, 15783, 16561, 17320, 18065, 18794, 19488, 20170, 20794, 21400, 22012, 22638, 23215, 23758, 24297, 24812, 25308, 25786, 26239, 26675, 27096, 27421, 27778, 28127, 28490, 28839, 29132, 29418, 29692, 29951, 30211, 30459, 30712, 30955, 31127, 31394, 31610, 32367, 25531, 21981, 21059, 19718, 19813, 20342, 21017, 22040, 22811, 23823, 24685, 25725, 26542, 27458, 28023, 28423, 28386, 27023, 26130, 22217, 14541, 15201, 15315, 15499, 15679, 15859, 15998, 16110, 16219, 16317, 16415, 16506, 16602, 16686, 16737, 16837, 16935, 17092, 17229, 17342, 17464, 17584, 17706, 17831, 17952, 18077, 18181, 18263, 18377, 18479, 18632, 18724, 18613, 19514, 9929, 5582, 2983, 838, 115, -429, -674, -470, -570, -171, -88, 134, 313, 385, 509, 457, 443, 329, 218, 99, -100, -219, -330, -444, -458, -510, -386, -313, -135, 87, 170, 569, 469, 673, 428, -116, -839, -2984, -5583, -9929, -19514, -18614, -18724, -18632, -18480, -18377, -18264, -18181, -18077, -17952, -17832, -17706, -17585, -17464, -17343, -17230, -17092, -16935, -16837, -16737, -16687, -16602, -16507, -16416, -16318, -16219, -16111, -15999, -15860, -15680, -15500, -15315, -15202, -14541, -22217, -26130, -27023, -28386, -28423, -28023, -27458, -26542, -25725, -24685, -23823, -22811, -22040, -21017, -20342, -19813, -19718, -21059, -21981, -25531, -32367, -31610, -31394, -31127, -30955, -30712, -30459, -30211, -29951, -29692, -29418, -29132, -28839, -28490, -28127, -27778, -27421, -27096, -26675, -26239, -25786, -25308, -24813, -24298, -23758, -23215, -22639, -22012, -21401, -20794, -20171, -19488, -18794, -18065, -17320, -16561, -15783, -14991, -14180, -13325, -12486, -11645, -10809, -9940, -9037, -8122, -7181, -6229, -5276, -4322, -3367, -2405, -1445, -471, 400, 1215, 2023, 2830, 3631, 4431, 5225, 6019, 6802, 7555, 8329, 9091, 9813, 10544, 11272, 12025, 12727, 13416, 14096, 14759, 15411, 16054, 16667, 17282, 17849, 18429, 19026, 19644, 20216, 20764, 21319, 21856, 22383, 22903, 23408, 23903, 24392, 24775, 25219, 25667, 26144, 26621, 27036, 27454, 27866, 28257, 28667, 29056, 29459, 29831, 30107, 30505, 30814, 31805, 22648, 23049, 26268, 23190, 22249, 21882, 21507, 22094, 21819, 22324, 22224, 22764, 22619, 23153, 22757, 22349, 21359, 18101, 21216, 21303, 11598, 12382, 12525, 12779, 13025, 13279, 13502, 13682, 13866, 14028, 14192, 14340, 14484, 14604, 14671, 14798, 14911, 15083, 15225, 15326, 15433, 15530, 15623, 15720, 15806, 15894, 15956, 15996, 16077, 16149, 16288, 16367, 16231, 17263, 5739, 6615, 7852, 3149, 2192, 883, -130, 180, -831, -376, -827, -730, -668, -763, -487, -575, -356, -302, -193, -4, 3, 192, 301, 355, 574, 486, 762, 667, 729, 826, 375, 830, -181, 129, -884, -2192, -3150, -7853, -6616, -5740, -17263, -16232, -16368, -16289, -16150, -16077, -15996, -15957, -15894, -15806, -15720, -15624, -15531, -15434, -15326, -15226, -15084, -14912, -14798, -14671, -14605, -14484, -14340, -14192, -14028, -13867, -13682, -13502, -13280, -13026, -12779, -12525, -12383, -11599, -21304, -21216, -18102, -21359, -22350, -22757, -23154, -22619, -22764, -22224, -22324, -21819, -22094, -21507, -21882, -22250, -23191, -26268, -23049, -22649, -31805, -30814, -30505, -30107, -29831, -29459, -29056, -28668, -28257, -27866, -27455, -27036, -26621, -26144, -25667, -25220, -24776, -24393, -23904, -23408, -22903, -22384, -21856, -21319, -20764, -20216, -19645, -19027, -18430, -17849, -17283, -16667, -16055, -15412, -14760, -14096, -13417, -12728, -12025, -11273, -10545, -9813, -9092, -8330, -7556, -6803, -6020, -5226, -4432, -3632, -2831, -2024, -1215, -401};