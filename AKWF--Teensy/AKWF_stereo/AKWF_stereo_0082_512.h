/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0082 512 samples */
 
const int16_t AKWF_stereo_0082_512_DATA [512] = 
{95, 296, 486, 670, 849, 1032, 1218, 1407, 1601, 1799, 1997, 2192, 2391, 2585, 2775, 2960, 3139, 3311, 3477, 3635, 3785, 3918, 4114, 3964, 3917, 4576, 4645, 4748, 4815, 4867, 4913, 4952, 4986, 5018, 5047, 5072, 5097, 5119, 5140, 5156, 5175, 5197, 5220, 5245, 5269, 5296, 5325, 5356, 5389, 5423, 5475, 5476, 4728, 4873, 5164, 5373, 5550, 5695, 5814, 5918, 6008, 6088, 6161, 6229, 6291, 6351, 6409, 6435, 6507, 6563, 6607, 6648, 6684, 6718, 6749, 6776, 6801, 6821, 6896, 6667, 3127, 7462, 7977, 8071, 8007, 7878, 7733, 7599, 7477, 7369, 7276, 7197, 7131, 7074, 7032, 6967, 6911, 6900, 6888, 6877, 6868, 6861, 6855, 6850, 6847, 6846, 6699, 7496, 1403, -2562, -1407, -1126, -860, -735, -647, -883, -1345, -340, -397, -561, -806, -1046, -1202, -1486, -1574, -1511, -1639, -1774, -1941, -2129, -2328, -2531, -2733, -2928, -3115, -3293, -3462, -3623, -3775, -3920, -4055, -4176, -4286, -4383, -4467, -4538, -4597, -4644, -4679, -4707, -4708, -4773, -5047, -4957, -4864, -4787, -4719, -4661, -4609, -4563, -4523, -4487, -4455, -4428, -4407, -4390, -4378, -4381, -4371, -4374, -4385, -4402, -4424, -4452, -4485, -4521, -4561, -4613, -4572, -5015, -6020, -4429, -4474, -4483, -4569, -4671, -4774, -4872, -4962, -5043, -5116, -5181, -5237, -5285, -5326, -5373, -5408, -5425, -5440, -5450, -5458, -5463, -5463, -5461, -5456, -5450, -5460, -5333, -7387, -7556, -6786, -6337, -5974, -5707, -5512, -5372, -5271, -5201, -5152, -5119, -5099, -5090, -5075, -5142, -5111, -5076, -5090, -5103, -5120, -5139, -5158, -5177, -5198, -5216, -5464, -4235, -18085, -8677, -4084, -3352, -2783, -2467, -2227, -2018, -2185, -1781, -1309, -971, -757, -644, -574, -575, -597, -453, -288, -96, 1241, 1727, 2053, 2206, 2273, 2371, 2567, 2842, 3130, 3364, 3520, 3631, 3745, 3900, 4094, 4298, 4477, 4617, 4731, 4840, 4964, 5108, 5251, 5424, 5563, 5600, 5702, 5804, 5917, 6033, 6145, 6246, 6339, 6427, 6515, 6605, 6697, 6786, 6870, 6950, 7025, 7099, 7173, 7248, 7321, 7392, 7461, 7526, 7590, 7654, 7717, 7784, 7942, 7989, 8017, 8053, 8095, 8138, 8183, 8230, 8277, 8323, 8370, 8415, 8460, 8504, 8548, 8592, 8630, 8668, 8707, 8744, 8779, 8814, 8848, 8879, 8910, 8940, 8962, 9020, 9478, 8977, 8939, 8951, 8982, 9017, 9054, 9089, 9121, 9150, 9176, 9199, 9220, 9239, 9255, 9273, 9289, 9298, 9307, 9315, 9321, 9327, 9331, 9335, 9338, 9340, 9210, 9912, 4531, 882, 1250, 247, -932, -1852, -2123, -2350, -2811, -1346, -1771, -2484, -3179, -3562, -3626, -3520, -3487, -3622, -3842, -4058, -4180, -4206, -4200, -4242, -4361, -4533, -4698, -4807, -4855, -4875, -4909, -4979, -5080, -5186, -5271, -5327, -5363, -5400, -5452, -5517, -5587, -5647, -5695, -5723, -5722, -5772, -5827, -5882, -5932, -5974, -6009, -6041, -6075, -6111, -6147, -6184, -6217, -6248, -6276, -6305, -6337, -6368, -6399, -6429, -6457, -6484, -6512, -6538, -6567, -6594, -6632, -6609, -6519, -6744, -6769, -6799, -6819, -6837, -6853, -6869, -6884, -6900, -6916, -6932, -6947, -6962, -6978, -6991, -7004, -7019, -7033, -7045, -7057, -7070, -7081, -7091, -7101, -7111, -7118, -7141, -6897, -6883, -6984, -7044, -7094, -7131, -7159, -7181, -7198, -7211, -7221, -7228, -7235, -7241, -7246, -7242, -7248, -7257, -7259, -7259, -7260, -7260, -7260, -7260, -7259, -7258, -7460, -6359, -18577, -10587, -7469, -7750, -7302, -6063, -4408, -3077, -3005, -2689, -2401, -1988, -1297, -494, 138, 422, 425, 344, 425, 765};