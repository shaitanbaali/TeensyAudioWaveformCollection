/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0132 512 samples */
 
const int16_t AKWF_stereo_0132_512_DATA [512] = 
{438, 1977, 3502, 4983, 6415, 7802, 9165, 10512, 11875, 13245, 14609, 15973, 17342, 18713, 20107, 21500, 22851, 24184, 25520, 26859, 28204, 29539, 30819, 31863, 32548, 32765, 32480, 31799, 30666, 28694, 26148, 23269, 20279, 17411, 14694, 12076, 9542, 7109, 4813, 2700, 748, -1050, -2684, -4157, -5472, -6695, -7936, -9209, -10470, -11644, -12659, -13476, -14107, -14575, -14896, -15069, -15087, -14989, -14880, -14816, -14765, -14677, -14585, -14537, -14536, -14542, -14507, -14394, -14186, -13892, -13552, -13197, -12858, -12567, -12340, -12194, -12144, -12204, -12469, -13042, -13885, -14846, -15745, -16448, -16920, -17160, -17198, -17061, -16758, -16299, -15699, -14992, -14195, -13302, -12326, -11276, -10179, -9120, -8136, -7235, -6373, -5461, -4433, -3264, -1951, -525, 988, 2578, 4242, 5976, 7784, 9599, 11362, 13061, 14703, 16277, 17750, 19102, 20353, 21525, 22568, 23501, 24339, 25065, 25651, 25941, 25771, 25190, 24237, 22988, 21454, 19622, 17664, 15731, 13950, 12429, 11179, 9984, 8775, 7607, 6586, 5791, 5232, 4820, 4455, 4154, 3954, 3899, 4018, 4330, 4693, 5026, 5358, 5720, 6143, 6595, 7048, 7435, 7693, 7832, 7818, 7673, 7414, 7095, 6768, 6287, 5622, 4843, 4044, 3297, 2598, 1967, 1421, 884, 316, -252, -808, -1362, -1982, -2724, -3633, -4814, -6420, -8292, -10186, -11876, -13248, -14267, -14942, -15291, -15386, -15334, -15148, -14896, -14626, -14328, -13989, -13574, -13076, -12528, -12090, -11768, -11506, -11265, -10979, -10656, -10357, -10113, -9916, -9728, -9526, -9317, -9103, -8867, -8600, -8296, -7962, -7608, -7231, -6800, -6278, -5647, -4973, -4302, -3655, -3069, -2576, -2203, -1970, -1889, -1963, -2252, -2881, -3883, -5176, -6640, -8126, -9483, -10611, -11453, -11995, -12261, -12281, -12073, -11653, -11110, -10506, -9830, -9058, -8172, -7160, -6031, -4824, -3591, -2324, -955, -482, 1227, 2890, 4428, 5835, 7151, 8428, 9697, 10987, 12276, 13537, 14791, 16073, 17404, 18801, 20228, 21640, 23037, 24422, 25796, 27159, 28507, 29801, 30866, 31601, 31911, 31787, 31341, 30499, 28853, 26644, 24119, 21512, 19057, 16777, 14606, 12496, 10416, 8381, 6433, 4549, 2726, 1001, -614, -2119, -3550, -4991, -6441, -7843, -9129, -10239, -11142, -11851, -12390, -12797, -13085, -13263, -13357, -13420, -13469, -13475, -13421, -13372, -13368, -13417, -13493, -13554, -13550, -13445, -13229, -12945, -12653, -12400, -12212, -12106, -12087, -12152, -12311, -12650, -13248, -14090, -15055, -15991, -16779, -17361, -17712, -17835, -17742, -17444, -16964, -16347, -15646, -14876, -14029, -13142, -12227, -11297, -10404, -9540, -8692, -7827, -6885, -5821, -4622, -3293, -1870, -390, 1143, 2731, 4383, 6115, 7897, 9690, 11471, 13225, 14936, 16570, 18075, 19469, 20767, 21854, 22769, 23547, 24201, 24719, 25004, 24990, 24670, 23999, 23015, 21733, 20057, 18143, 16146, 14204, 12464, 10968, 9617, 8366, 7227, 6252, 5488, 4959, 4529, 4049, 3583, 3219, 3045, 3095, 3363, 3763, 4228, 4759, 5361, 6036, 6746, 7484, 8138, 8597, 8887, 8959, 8838, 8537, 8111, 7623, 7024, 6340, 5631, 4966, 4379, 3861, 3408, 3018, 2527, 1860, 1101, 297, -535, -1443, -2448, -3580, -4939, -6606, -8451, -10268, -11877, -13188, -14179, -14866, -15259, -15452, -15629, -15770, -15884, -15957, -15958, -15870, -15654, -15289, -14787, -14230, -13639, -13032, -12410, -11755, -11076, -10466, -9989, -9634, -9345, -9085, -8884, -8747, -8640, -8525, -8364, -8139, -7832, -7434, -6925, -6300, -5566, -4782, -3983, -3216, -2542, -2002, -1622, -1426, -1420, -1611, -2056, -2837, -3976, -5377, -6875, -8302, -9517, -10466, -11168, -11651, -11960, -12122, -12132, -11972, -11671, -11259, -10738, -10096, -9324, -8402, -7332, -6141, -4868, -3514, -2022};