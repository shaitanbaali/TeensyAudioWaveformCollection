/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0017 512 samples */
 
const int16_t AKWF_stereo_0017_512_DATA [512] = 
{871, 2328, 3713, 5019, 6328, 7621, 8951, 10186, 11448, 12656, 13813, 14968, 16002, 17017, 18044, 19142, 20347, 21564, 22747, 23863, 24887, 25847, 26694, 27546, 28340, 29003, 29658, 30243, 30746, 31178, 31559, 32000, 32223, 32425, 32642, 32750, 32759, 32667, 32500, 32281, 31988, 31597, 31117, 30556, 29929, 29097, 28338, 27703, 27143, 26631, 26143, 25638, 25061, 24424, 23743, 23029, 22241, 21345, 20281, 19240, 18122, 16901, 15628, 14384, 13163, 11915, 10614, 9268, 7902, 6511, 5092, 3680, 2299, 880, -541, -1938, -3327, -4693, -6010, -7209, -8292, -9292, -10323, -11182, -12064, -13029, -13958, -14846, -15726, -16612, -17493, -18370, -19250, -20123, -20942, -21696, -22305, -22885, -23516, -24127, -24743, -25361, -25948, -26480, -26981, -27472, -27940, -28373, -28795, -29042, -29253, -29336, -29212, -28930, -28520, -28004, -27410, -26752, -26022, -25202, -24345, -23459, -22415, -21468, -20539, -19610, -18663, -17632, -16534, -15447, -14403, -13392, -12415, -11446, -10444, -9506, -8551, -7640, -6775, -5941, -5148, -4391, -3616, -2742, -1772, -751, 287, 1301, 2223, 3050, 3805, 4534, 5213, 5836, 6420, 6947, 7403, 7795, 8153, 8528, 8855, 9140, 9352, 9484, 9523, 9476, 9376, 9253, 9085, 8854, 8572, 8259, 7889, 7448, 7055, 6755, 6558, 6425, 6324, 6227, 6108, 5947, 5762, 5568, 5328, 5000, 4648, 4263, 3817, 3313, 2792, 2323, 1888, 1423, 895, 310, -311, -974, -1663, -2340, -3034, -3775, -4547, -5331, -6116, -6887, -7613, -8226, -8726, -9158, -9565, -9945, -10339, -10758, -11168, -11543, -11926, -12331, -12743, -13167, -13609, -14058, -14467, -14798, -15022, -15263, -15508, -15757, -16021, -16295, -16547, -16748, -16920, -17086, -17237, -17368, -17470, -17458, -17409, -17181, -16748, -16152, -15421, -14589, -13677, -12702, -11661, -10526, -9356, -8135, -6874, -5635, -4389, -3147, -1885, -508, 7679, 8992, 10331, 11684, 12994, 14287, 15636, 16931, 18120, 19239, 20323, 21431, 22476, 23391, 24311, 25289, 26254, 27193, 28069, 28783, 29404, 30117, 30695, 31216, 31684, 32051, 32307, 32477, 32542, 32535, 32484, 32476, 32098, 31690, 31362, 30942, 30430, 29820, 29162, 28448, 27615, 26669, 25673, 24621, 23497, 22110, 20873, 19801, 18731, 17628, 16536, 15478, 14482, 13486, 12507, 11553, 10530, 9431, 8226, 7137, 6004, 4814, 3646, 2569, 1468, 275, -936, -2117, -3273, -4454, -5658, -6864, -8049, -9262, -10449, -11651, -12857, -14046, -15177, -16186, -17135, -18075, -19055, -19760, -20486, -21301, -22043, -22728, -23448, -24170, -24837, -25489, -26153, -26788, -27355, -27868, -28262, -28693, -29178, -29604, -30028, -30450, -30817, -31137, -31479, -31834, -32137, -32393, -32659, -32698, -32726, -32655, -32462, -32218, -31872, -31403, -30835, -30182, -29418, -28542, -27657, -26717, -25492, -24398, -23324, -22219, -21047, -19756, -18454, -17234, -16019, -14759, -13497, -12246, -10959, -9774, -8603, -7488, -6396, -5322, -4308, -3352, -2365, -1298, -243, 743, 1715, 2687, 3582, 4409, 5192, 5973, 6658, 7255, 7836, 8344, 8766, 9141, 9498, 9867, 10106, 10264, 10379, 10454, 10450, 10373, 10273, 10147, 9929, 9631, 9317, 8996, 8595, 8109, 7723, 7442, 7189, 6905, 6648, 6428, 6228, 6029, 5862, 5725, 5536, 5279, 5088, 4904, 4660, 4389, 4154, 4005, 3823, 3544, 3244, 2967, 2694, 2380, 2037, 1701, 1317, 880, 443, 15, -437, -907, -1338, -1672, -1978, -2313, -2640, -2912, -3182, -3458, -3703, -3908, -4181, -4479, -4734, -5008, -5306, -5601, -5848, -6028, -6165, -6398, -6619, -6812, -7013, -7221, -7386, -7513, -7668, -7848, -7987, -8095, -8173, -8127, -8074, -7857, -7544, -7189, -6732, -6164, -5497, -4741, -3889, -2924, -1952, -903, 260, 1404, 2556, 3733, 4976, 6355};