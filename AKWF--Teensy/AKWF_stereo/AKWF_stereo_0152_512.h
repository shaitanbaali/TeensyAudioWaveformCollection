/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0152 512 samples */
 
const int16_t AKWF_stereo_0152_512_DATA [512] = 
{30357, 29753, 29161, 28568, 27974, 27380, 26785, 26192, 25598, 25003, 24411, 23816, 23222, 22629, 22035, 21441, 20847, 20252, 19658, 19070, 18454, 18020, 17851, 17664, 17479, 17295, 17110, 16925, 16742, 16557, 16372, 16188, 16004, 15819, 15634, 15449, 15265, 15080, 14896, 14712, 14527, 14343, 14159, 13974, 13789, 13605, 13421, 13236, 13051, 12867, 12683, 12497, 12313, 12128, 11945, 11759, 11575, 11392, 11207, 11022, 10838, 10653, 10469, 10284, 10100, 9915, 9731, 9546, 9362, 9177, 8993, 8808, 8624, 8439, 8254, 8070, 7886, 7702, 7517, 7332, 7148, 6964, 6779, 6595, 6410, 6225, 6041, 5856, 5672, 5488, 5303, 5118, 4934, 4749, 4565, 4381, 4196, 4011, 3827, 3643, 3459, 3274, 3088, 2905, 2720, 2535, 2352, 2167, 1981, 1798, 1613, 1429, 1244, 1059, 875, 691, 506, 323, 131, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -2, 5, -104, -298, -480, -665, -849, -1033, -1218, -1403, -1587, -1772, -1956, -2140, -2325, -2509, -2693, -2879, -3062, -3247, -3433, -3617, -3801, -3985, -4170, -4354, -4539, -4723, -4907, -5092, -5277, -5461, -5646, -5830, -6014, -6199, -6383, -6568, -6753, -6938, -7122, -7306, -7490, -7675, -7860, -8044, -8228, -8413, -8597, -8781, -8967, -9150, -9336, -9520, -9705, -9889, -10074, -10257, -10443, -10627, -10811, -10996, -11180, -11365, -11549, -11733, -11918, -12102, -12287, -12471, -12656, -12841, -13025, -13210, -13394, -13578, -13763, -13947, -14132, -14317, -14500, -14685, -14870, -15054, -15239, -15423, -15607, -15793, -15977, -16161, -16346, -16530, -16715, -16899, -17083, -17268, -17452, -17638, -17826, -17989, -18368, -18982, -19572, -20165, -20760, -21355, -21948, -22542, -23137, -23729, -24324, -24917, -25511, -26105, -26699, -27292, -27887, -28481, -29044, -29588, -30811, -4992, 32477, 31396, 30337, 29274, 28213, 27150, 26085, 25025, 23962, 22897, 21837, 20774, 19710, 18649, 17586, 16522, 15460, 14397, 13333, 12283, 11169, 10481, 10410, 10295, 10187, 10079, 9971, 9864, 9757, 9649, 9542, 9434, 9326, 9220, 9111, 9004, 8896, 8789, 8681, 8574, 8467, 8359, 8251, 8144, 8036, 7929, 7821, 7714, 7606, 7499, 7391, 7283, 7176, 7068, 6961, 6853, 6746, 6638, 6530, 6424, 6316, 6208, 6101, 5993, 5885, 5778, 5671, 5563, 5456, 5348, 5241, 5133, 5026, 4918, 4810, 4703, 4596, 4488, 4381, 4273, 4166, 4058, 3950, 3843, 3736, 3628, 3520, 3413, 3306, 3198, 3090, 2983, 2875, 2767, 2660, 2553, 2445, 2338, 2230, 2123, 2015, 1907, 1799, 1692, 1585, 1477, 1370, 1262, 1154, 1047, 940, 832, 725, 617, 509, 402, 295, 189, 76, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 3, -61, -174, -280, -388, -494, -602, -710, -817, -925, -1033, -1140, -1247, -1355, -1462, -1570, -1677, -1785, -1892, -2000, -2108, -2215, -2323, -2430, -2538, -2645, -2753, -2860, -2968, -3075, -3183, -3291, -3398, -3505, -3613, -3721, -3829, -3935, -4043, -4151, -4258, -4366, -4474, -4581, -4688, -4795, -4903, -5011, -5118, -5226, -5333, -5441, -5548, -5656, -5764, -5871, -5978, -6086, -6193, -6301, -6409, -6516, -6623, -6731, -6838, -6946, -7053, -7161, -7268, -7376, -7483, -7591, -7699, -7806, -7914, -8021, -8129, -8236, -8344, -8452, -8559, -8666, -8774, -8881, -8989, -9096, -9205, -9312, -9419, -9527, -9634, -9742, -9850, -9956, -10064, -10172, -10279, -10398, -10456, -11016, -12126, -13180, -14241, -15304, -16368, -17429, -18493, -19556, -20617, -21681, -22744, -23804, -24869, -25931, -26993, -28057, -29120, -30148, -31154, -32911, -5378};