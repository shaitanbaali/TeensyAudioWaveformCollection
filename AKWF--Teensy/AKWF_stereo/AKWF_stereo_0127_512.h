/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0127 512 samples */
 
const int16_t AKWF_stereo_0127_512_DATA [512] = 
{1736, 1971, 2649, 3556, 6401, 6660, 6892, 8494, 11858, 13654, 15637, 19278, 20872, 21131, 20348, 19541, 18946, 19638, 20982, 24123, 29014, 32849, 32064, 30654, 29819, 28057, 25974, 24039, 21190, 18975, 16954, 15289, 13343, 12034, 10895, 9101, 7179, 5659, 4916, 7555, 6018, 5094, 2112, -1825, -3078, -4062, -5093, -4199, -2551, -711, -219, -37, 2002, 1897, -1734, -2557, 283, -1716, -2313, -2595, -2530, -1277, -536, 530, 4050, 5818, 7009, 5749, 5363, 5513, 7191, 9142, 8144, 7774, 8081, 7073, 4666, 2058, -224, -1247, -1957, -3649, -6765, -7392, -6944, -6523, -7422, -7980, -9409, -11291, -11722, -11222, -10889, -11284, -11543, -12251, -13082, -13289, -16010, -18409, -16805, -16430, -16990, -17803, -17725, -17212, -16906, -18279, -17553, -17122, -17584, -17686, -17897, -17341, -15499, -14203, -14170, -15305, -11507, -8311, -4914, -2830, -1196, -314, -1335, -1676, -208, 1267, 1893, 1852, 2866, 2648, 2337, 1715, 483, 59, 411, 1192, 956, -709, -389, 254, -362, -1322, -2016, -2995, -1592, 430, -516, -2745, -3680, -4067, -5382, -5115, -5283, -6798, -8093, -8385, -4775, -4685, -5294, -4142, -4455, -4382, -2355, -14, 2238, 3358, 4105, 5142, 5846, 9023, 11686, 15331, 18673, 19569, 19621, 18816, 17361, 16263, 15881, 15437, 14863, 14615, 14688, 14182, 15522, 16079, 14612, 12152, 10207, 9483, 10173, 10485, 9445, 8085, 5832, 3620, -570, -3679, -5799, -7666, -6986, -5237, -8293, -10368, -11236, -12578, -15938, -18381, -20185, -21494, -22459, -22833, -21814, -21103, -20148, -18140, -17398, -17284, -14144, -9921, -8817, -6757, -3661, -1767, -1013, -232, -161, -322, -1981, -3241, -1456, -1392, -1842, -2833, -3717, -3780, -2957, -2399, -2387, -3678, -6007, -7563, -8584, -6950, -6888, -7416, -7726, -7626, -7230, -8204, -9158, -7148, -4280, -1760, -6896, -6045, -3236, -2197, -1217, 1356, 1754, 2599, 3724, 5002, 7368, 9405, 14214, 18039, 19346, 20761, 22386, 24131, 25454, 25764, 27945, 28783, 28351, 28408, 27883, 28741, 29527, 27715, 26122, 26286, 26617, 25401, 24637, 21654, 19228, 16695, 14263, 9423, 5215, 3452, 2104, 27, -725, -905, -718, -691, -215, -236, -3674, -3129, -4507, -5633, -5089, -5230, -6845, -6424, -5324, -5881, -5543, -4276, -6220, -6841, -5354, -1833, 134, 3397, 4166, 5973, 7100, 8189, 10066, 11378, 13258, 16106, 13596, 11424, 9755, 7798, 6730, 4782, 1665, -781, -3316, -4586, -5455, -5486, -5429, -6370, -7242, -8170, -12492, -13756, -13762, -14227, -14784, -15503, -14983, -15390, -16877, -16910, -16796, -16459, -16258, -16196, -15867, -15592, -15652, -17738, -21221, -22306, -22267, -21263, -20053, -19093, -17624, -14799, -12557, -11039, -8958, -8070, -6221, -4897, -3327, -3116, -3766, -3525, -2340, -2701, -4535, -5231, -4578, -4808, -4216, -4116, -4210, -3551, -3076, -2730, -2592, -3005, -2396, 319, 283, 248, 225, -60, -878, -2192, -3534, -4167, -5977, -6293, -3029, -1588, -970, -1233, -1931, -2641, -2667, -3742, -3846, -2623, -2008, -2043, 401, 2779, 4053, 4367, 4506, 5189, 6131, 6414, 6975, 9359, 11916, 12213, 12214, 11554, 12934, 14146, 13891, 14198, 13726, 13684, 15020, 16362, 16245, 15772, 14403, 13830, 12377, 11301, 11661, 10595, 11830, 12019, 9563, 7733, 4997, 3802, 2847, 1710, 2634, 2507, 556, -1287, -3030, -5003, -7886, -10532, -13410, -14093, -12592, -14139, -13794, -11785, -11551, -10887, -10483, -11041, -11625, -12160, -11293, -9273, -8511, -6895, -3942, -2976, -1840, -1386, -1703, -1727, 38, 1369, 1186, 293, -1198, -3202, -2032, -1676, -2961, -4430, -6055, -7964, -9941, -11210, -11998, -12945, -14080, -14677, -14343, -16274, -14421, -13407, -11241, -8327};