/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0162 512 samples */
 
const int16_t AKWF_stereo_0162_512_DATA [512] = 
{933, 2430, 3898, 5365, 6820, 8261, 9687, 11086, 12461, 13809, 15121, 16402, 17649, 18855, 20027, 21158, 22245, 23295, 24303, 25267, 26192, 27076, 27915, 28715, 29473, 30190, 30874, 31445, 31850, 32224, 32504, 32674, 32757, 32759, 32683, 32529, 32303, 32010, 31654, 31246, 30790, 30290, 29754, 29184, 28587, 27968, 27329, 26675, 26010, 25337, 24659, 23981, 23301, 22625, 21955, 21290, 20634, 19991, 19357, 18736, 18129, 17536, 16959, 16398, 15853, 15325, 14815, 14320, 13845, 13386, 12945, 12523, 12116, 11727, 11356, 11001, 10663, 10343, 10037, 9747, 9473, 9214, 8969, 8740, 8524, 8320, 8131, 7954, 7787, 7481, 7168, 6852, 6466, 6038, 5576, 5080, 4546, 3979, 3381, 2755, 2107, 1439, 754, 59, -646, -1360, -2075, -2792, -3507, -4217, -4929, -5517, -6021, -6529, -6945, -7290, -7575, -7800, -7963, -8066, -8111, -8101, -8042, -7936, -7787, -7599, -7376, -7121, -6837, -6528, -6195, -5843, -5474, -5091, -4693, -4296, -4045, -3791, -3558, -3402, -3293, -3229, -3210, -3238, -3311, -3429, -3586, -3777, -4002, -4255, -4533, -4835, -5156, -5495, -5848, -6211, -6584, -6965, -7350, -7738, -8129, -8518, -8907, -9292, -9673, -10049, -10420, -10783, -11138, -11487, -11826, -12156, -12477, -12787, -13089, -13380, -13660, -13931, -14191, -14440, -14678, -14908, -15126, -15334, -15532, -15720, -15899, -16069, -16228, -16379, -16521, -16655, -16780, -16897, -17006, -17108, -17202, -17289, -17369, -17442, -17509, -17570, -17624, -17674, -17717, -17756, -17789, -17818, -17842, -17861, -17876, -17888, -17895, -17900, -17901, -17897, -17891, -17883, -17871, -17857, -17841, -17822, -17801, -17778, -17753, -17726, -17698, -17667, -17636, -17603, -17569, -17534, -17498, -17460, -17422, -17384, -17342, -17307, -17242, -16949, -16551, -16109, -15536, -14842, -14050, -13167, -12194, -11131, -9988, -8777, -7500, -6174, -4804, -3400, -1972, -493, -8472, -6816, -5190, -3560, -1939, -328, 1268, 2841, 4393, 5920, 7414, 8878, 10309, 11701, 13059, 14378, 15655, 16895, 18094, 19249, 20365, 21440, 22470, 23463, 24414, 25322, 26194, 26992, 27689, 28353, 28951, 29476, 29943, 30351, 30703, 31002, 31247, 31445, 31597, 31707, 31779, 31816, 31820, 31795, 31743, 31667, 31570, 31453, 31320, 31172, 31011, 30839, 30657, 30466, 30270, 30068, 29861, 29652, 29439, 29226, 29014, 28800, 28588, 28377, 28170, 27965, 27761, 27561, 27366, 27174, 26987, 26804, 26625, 26451, 26283, 26119, 25960, 25806, 25657, 25513, 25375, 25241, 25113, 24989, 24870, 24756, 24646, 24542, 24438, 24076, 23688, 23278, 22733, 22102, 21399, 20622, 19769, 18848, 17861, 16815, 15721, 14581, 13405, 12200, 10969, 9718, 8456, 7183, 5907, 4636, 3351, 2278, 1345, 399, -391, -1062, -1635, -2107, -2475, -2743, -2913, -2991, -2986, -2902, -2747, -2525, -2245, -1911, -1528, -1103, -639, -142, 382, 930, 1505, 2078, 2397, 2719, 3005, 3160, 3231, 3225, 3140, 2975, 2731, 2412, 2026, 1579, 1075, 522, -73, -710, -1379, -2075, -2798, -3538, -4293, -5062, -5836, -6615, -7397, -8177, -8952, -9723, -10484, -11236, -11978, -12706, -13420, -14120, -14802, -15469, -16118, -16749, -17361, -17956, -18530, -19086, -19624, -20140, -20639, -21120, -21580, -22022, -22446, -22852, -23241, -23611, -23964, -24301, -24622, -24927, -25216, -25490, -25750, -25995, -26227, -26445, -26650, -26844, -27025, -27194, -27352, -27500, -27637, -27764, -27882, -27990, -28090, -28182, -28265, -28339, -28408, -28469, -28523, -28572, -28614, -28650, -28680, -28706, -28727, -28742, -28753, -28761, -28764, -28763, -28760, -28753, -28742, -28728, -28712, -28693, -28672, -28649, -28623, -28595, -28564, -28542, -28464, -28082, -27675, -27186, -26542, -25780, -24913, -23946, -22879, -21715, -20464, -19137, -17739, -16286, -14785, -13243, -11674, -10046};