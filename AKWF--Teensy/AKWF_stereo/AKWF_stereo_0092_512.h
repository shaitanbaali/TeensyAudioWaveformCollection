/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0092 512 samples */
 
const int16_t AKWF_stereo_0092_512_DATA [512] = 
{289, 795, 1293, 1797, 2303, 2820, 3348, 3877, 4417, 4965, 5519, 6082, 6649, 7221, 7801, 8390, 8980, 9576, 10178, 10788, 11402, 12020, 12635, 13326, 14214, 15058, 15810, 16553, 17313, 18089, 18861, 19617, 20358, 21078, 21776, 22458, 23122, 23774, 24417, 25043, 25666, 26285, 26898, 27506, 28108, 28711, 29308, 29900, 30485, 31067, 31655, 32155, 32251, 32285, 32468, 32644, 32743, 32768, 32736, 32683, 32629, 32540, 32425, 32301, 32171, 32034, 31883, 31722, 31545, 31339, 31104, 30845, 30560, 30248, 29909, 29546, 29155, 28740, 28300, 27841, 27365, 26868, 26355, 25831, 25297, 24751, 24202, 23645, 23083, 22519, 21951, 21381, 20809, 20236, 19660, 19068, 18452, 17849, 17253, 16652, 16047, 15439, 14826, 14216, 13602, 12988, 12377, 11762, 11147, 10534, 9921, 9305, 8693, 8083, 7473, 6869, 6264, 5663, 5068, 4475, 3890, 3311, 2730, 2194, 1728, 1236, 721, 208, -298, -794, -1293, -1798, -2304, -2821, -3349, -3877, -4417, -4966, -5520, -6083, -6650, -7222, -7802, -8390, -8981, -9577, -10179, -10788, -11403, -12021, -12635, -13327, -14215, -15059, -15810, -16553, -17314, -18090, -18861, -19617, -20358, -21078, -21776, -22458, -23123, -23774, -24417, -25043, -25666, -26285, -26898, -27507, -28108, -28711, -29308, -29900, -30486, -31067, -31655, -32155, -32251, -32285, -32468, -32644, -32743, -32768, -32736, -32683, -32629, -32540, -32425, -32301, -32171, -32034, -31883, -31722, -31545, -31339, -31104, -30845, -30561, -30248, -29909, -29546, -29155, -28741, -28300, -27841, -27365, -26868, -26355, -25831, -25297, -24751, -24202, -23645, -23083, -22519, -21951, -21381, -20810, -20237, -19661, -19068, -18453, -17849, -17253, -16652, -16048, -15439, -14827, -14216, -13603, -12988, -12378, -11762, -11147, -10534, -9921, -9306, -8694, -8084, -7473, -6869, -6265, -5664, -5069, -4476, -3891, -3311, -2731, -2195, -1729, -1238, -724, -202, 1041, 1615, 2176, 2734, 3291, 3844, 4396, 4942, 5487, 6029, 6568, 7106, 7642, 8176, 8711, 9245, 9777, 10311, 10844, 11377, 11912, 12448, 12984, 13514, 14022, 14535, 15062, 15591, 16118, 16647, 17175, 17704, 18238, 18772, 19310, 19850, 20390, 20931, 21475, 22017, 22560, 23102, 23644, 24184, 24724, 25264, 25804, 26344, 26881, 27420, 27963, 28476, 28830, 29143, 29488, 29792, 30026, 30198, 30327, 30441, 30547, 30582, 30547, 30472, 30374, 30261, 30130, 29974, 29788, 29568, 29313, 29029, 28718, 28383, 28023, 27637, 27220, 26777, 26306, 25813, 25302, 24770, 24222, 23659, 23083, 22496, 21905, 21309, 20710, 20114, 19517, 18924, 18338, 17755, 17179, 16617, 16062, 15515, 14975, 14441, 13914, 13395, 12879, 12368, 11860, 11352, 10847, 10341, 9833, 9324, 8811, 8295, 7777, 7252, 6723, 6192, 5654, 5112, 4568, 4017, 3464, 2910, 2351, 1788, 1215, 646, 81, -483, -1050, -1613, -2176, -2735, -3292, -3845, -4397, -4943, -5488, -6030, -6569, -7107, -7643, -8177, -8711, -9245, -9778, -10312, -10844, -11378, -11913, -12448, -12985, -13515, -14022, -14535, -15063, -15591, -16119, -16647, -17175, -17704, -18238, -18773, -19310, -19851, -20391, -20932, -21475, -22017, -22560, -23103, -23644, -24184, -24725, -25265, -25804, -26344, -26882, -27420, -27963, -28476, -28830, -29143, -29488, -29792, -30026, -30198, -30327, -30441, -30547, -30582, -30547, -30472, -30374, -30261, -30130, -29974, -29788, -29568, -29313, -29029, -28718, -28383, -28023, -27637, -27221, -26778, -26306, -25813, -25302, -24770, -24222, -23659, -23083, -22497, -21905, -21309, -20710, -20114, -19517, -18925, -18338, -17755, -17180, -16617, -16063, -15515, -14976, -14442, -13915, -13395, -12879, -12369, -11860, -11353, -10848, -10341, -9833, -9325, -8812, -8295, -7777, -7253, -6724, -6193, -5655, -5113, -4569, -4018, -3465, -2911, -2352, -1788, -1216, -648, -85, 490};