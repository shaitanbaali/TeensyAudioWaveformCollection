/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0129 512 samples */
 
const int16_t AKWF_stereo_0129_512_DATA [512] = 
{1546, 3829, 6052, 8182, 10133, 11875, 13380, 14658, 15833, 16932, 17905, 18943, 20159, 21434, 22722, 23984, 25081, 26066, 27042, 27911, 28396, 28397, 28084, 27570, 26987, 26387, 25378, 23729, 21950, 20264, 18796, 17493, 16194, 14727, 13123, 11463, 9703, 7812, 5815, 3689, 1386, -1021, -3427, -5859, -8259, -10412, -12191, -13646, -14946, -16204, -17369, -18324, -19274, -20270, -21326, -22580, -24003, -25392, -26653, -27845, -29072, -30276, -31314, -32136, -32648, -32769, -32571, -32102, -31437, -30696, -29972, -29330, -28798, -28262, -27630, -26887, -26112, -25368, -24505, -23354, -21904, -20206, -18352, -16493, -14629, -12768, -10939, -9179, -7608, -6250, -5051, -3904, -2694, -1368, -73, 1105, 2261, 3496, 4870, 6428, 8128, 9850, 11450, 12838, 14005, 14983, 15858, 16541, 16948, 17178, 17284, 17304, 17242, 16994, 16712, 16605, 16573, 16550, 16511, 16456, 16347, 16138, 15598, 14577, 13203, 11691, 10150, 8585, 6904, 5138, 3396, 1731, 236, -994, -2095, -3298, -4504, -5552, -6468, -7449, -8551, -9850, -11305, -12711, -13853, -14637, -15003, -14968, -14689, -13967, -12772, -11365, -9817, -8183, -6565, -4993, -3396, -1870, -417, 1137, 2747, 4333, 5819, 7117, 8401, 9903, 11688, 13623, 15553, 17346, 18926, 20270, 21467, 22502, 23168, 23299, 23158, 22938, 22641, 22202, 21607, 21013, 20560, 20332, 20299, 20403, 20615, 20964, 21306, 21480, 21463, 21140, 20520, 19697, 18774, 17847, 16926, 15925, 14842, 13888, 13110, 12458, 11853, 11204, 10404, 9386, 8190, 6816, 5222, 3378, 1328, -728, -2679, -4518, -6240, -7843, -9270, -10452, -11430, -12289, -13108, -13913, -14669, -15427, -16296, -17278, -18319, -19326, -20279, -21271, -22357, -23425, -24342, -25032, -25457, -25554, -25300, -24759, -23974, -23058, -21985, -20757, -19797, -19135, -18579, -17969, -17110, -15943, -14547, -13033, -11433, -9636, -7622, -5428, -3099, -684, -2139, 35, 2022, 3944, 5768, 7474, 9016, 10406, 11786, 13144, 14389, 15670, 17074, 18505, 19894, 21207, 22357, 23369, 24325, 25125, 25542, 25493, 25178, 24727, 24295, 23962, 23340, 22198, 20997, 19869, 18857, 17942, 16982, 15763, 14283, 12663, 10950, 9160, 7312, 5343, 3221, 1018, -1186, -3399, -5557, -7451, -8993, -10304, -11558, -12805, -13966, -14943, -15997, -17196, -18495, -19892, -21331, -22694, -23934, -25116, -26306, -27445, -28446, -29318, -29993, -30351, -30438, -30322, -30063, -29736, -29392, -29052, -28710, -28275, -27712, -27008, -26199, -25397, -24514, -23423, -22145, -20753, -19233, -17602, -15845, -14038, -12237, -10468, -8871, -7441, -6110, -4853, -3602, -2284, -964, 332, 1680, 3130, 4706, 6437, 8231, 9915, 11416, 12729, 13880, 14897, 15841, 16647, 17254, 17734, 18116, 18419, 18649, 18739, 18788, 18944, 19174, 19388, 19483, 19478, 19329, 18985, 18328, 17350, 16164, 14853, 13484, 12107, 10601, 8948, 7288, 5630, 4071, 2732, 1525, 269, -999, -2177, -3285, -4441, -5699, -7178, -8765, -10210, -11347, -12140, -12555, -12622, -12522, -12037, -11089, -9924, -8617, -7202, -5833, -4636, -3494, -2364, -1243, -22, 1296, 2670, 4064, 5431, 6847, 8507, 10458, 12540, 14577, 16427, 18013, 19253, 20273, 21141, 21661, 21679, 21486, 21290, 21032, 20698, 20354, 20048, 19865, 19873, 20037, 20299, 20615, 20960, 21125, 20983, 20616, 20001, 19183, 18263, 17368, 16631, 16004, 15350, 14664, 14051, 13515, 13009, 12490, 11901, 11081, 10007, 8765, 7340, 5679, 3764, 1691, -368, -2313, -4074, -5631, -7060, -8368, -9482, -10459, -11348, -12196, -13033, -13891, -14830, -15911, -17129, -18422, -19696, -20918, -22107, -23296, -24431, -25376, -26027, -26370, -26414, -26237, -25893, -25400, -24859, -24186, -23343, -22756, -22405, -22121, -21790, -21243, -20362, -19141, -17664, -16007, -14098, -11910, -9522, -7001, -4428};