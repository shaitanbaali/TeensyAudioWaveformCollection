/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0160 512 samples */
 
const int16_t AKWF_stereo_0160_512_DATA [512] = 
{403, 1128, 1877, 2666, 3488, 4340, 5219, 6117, 7035, 7966, 8906, 9854, 10805, 11751, 12697, 13635, 14562, 15478, 16378, 17258, 18122, 18964, 19778, 20571, 21335, 22071, 22779, 23455, 24101, 24714, 25298, 25846, 26362, 26845, 27294, 27709, 28092, 28441, 28757, 29040, 29292, 29513, 29700, 29856, 29983, 30081, 30151, 30192, 30204, 30192, 30153, 30088, 29999, 29887, 29751, 29594, 29417, 29220, 29002, 28767, 28512, 28243, 27957, 27656, 27341, 27012, 26669, 26315, 25949, 25573, 25188, 24792, 24388, 23976, 23559, 23132, 22700, 22266, 21824, 21378, 20928, 20476, 20021, 19565, 19106, 18647, 18186, 17725, 17263, 16804, 16345, 15887, 15430, 14976, 14524, 14074, 13627, 13183, 12742, 12304, 11872, 11442, 11016, 10597, 10134, 9551, 8961, 8330, 7627, 6873, 6073, 5226, 4335, 3399, 2425, 1418, 382, -677, -1752, -2844, -3943, -5047, -6154, -7254, -8344, -9427, -10493, -11540, -12569, -13571, -14547, -15496, -16414, -17300, -18154, -18970, -19752, -20498, -21203, -21873, -22502, -23091, -23644, -24157, -24628, -25063, -25459, -25814, -26134, -26416, -26661, -26871, -27045, -27185, -27292, -27365, -27407, -27417, -27399, -27351, -27275, -27173, -27043, -26889, -26712, -26511, -26288, -26047, -25784, -25501, -25202, -24885, -24550, -24203, -23840, -23463, -23075, -22674, -22262, -21843, -21412, -20972, -20525, -20071, -19610, -19146, -18672, -18213, -17814, -17418, -17037, -16694, -16376, -16081, -15811, -15564, -15343, -15146, -14970, -14815, -14678, -14559, -14455, -14366, -14291, -14227, -14176, -14132, -14099, -14072, -14055, -14041, -14033, -14032, -14036, -14024, -13954, -13879, -13786, -13659, -13507, -13330, -13131, -12907, -12660, -12392, -12103, -11795, -11472, -11134, -10782, -10422, -10050, -9669, -9283, -8892, -8495, -8097, -7695, -7294, -6894, -6495, -6096, -5702, -5309, -4920, -4538, -4159, -3785, -3423, -3030, -2522, -2027, -1492, -901, -253, -7242, -6129, -5006, -3848, -2665, -1457, -230, 1007, 2256, 3514, 4769, 6024, 7277, 8516, 9746, 10961, 12153, 13329, 14481, 15604, 16702, 17769, 18804, 19808, 20777, 21708, 22606, 23465, 24285, 25068, 25812, 26516, 27181, 27806, 28391, 28939, 29446, 29915, 30347, 30739, 31094, 31416, 31698, 31946, 32160, 32341, 32489, 32604, 32688, 32743, 32766, 32764, 32733, 32676, 32594, 32487, 32357, 32204, 32030, 31836, 31621, 31387, 31137, 30868, 30584, 30286, 29972, 29645, 29306, 28955, 28592, 28220, 27839, 27447, 27050, 26644, 26233, 25816, 25392, 24965, 24534, 24098, 23660, 23221, 22779, 22335, 21892, 21447, 21003, 20560, 20118, 19677, 19237, 18799, 18364, 17933, 17504, 17078, 16657, 16238, 15825, 15416, 15009, 14612, 14168, 13601, 13028, 12412, 11721, 10982, 10190, 9353, 8470, 7543, 6575, 5575, 4545, 3492, 2421, 1334, 239, -857, -1958, -3050, -4134, -5207, -6264, -7301, -8317, -9306, -10268, -11202, -12101, -12969, -13800, -14595, -15352, -16071, -16749, -17388, -17986, -18542, -19059, -19534, -19967, -20361, -20713, -21024, -21296, -21529, -21724, -21881, -22001, -22085, -22134, -22148, -22129, -22078, -21995, -21880, -21736, -21564, -21367, -21139, -20889, -20614, -20315, -19995, -19652, -19288, -18908, -18508, -18090, -17657, -17207, -16743, -16266, -15776, -15274, -14761, -14237, -13704, -13163, -12612, -12054, -11493, -10914, -10398, -10101, -9824, -9608, -9523, -9532, -9625, -9807, -10075, -10429, -10864, -11374, -11949, -12586, -13281, -14023, -14810, -15638, -16498, -17388, -18306, -19241, -20197, -21168, -22145, -23135, -24127, -25129, -26068, -26783, -27467, -28086, -28564, -28939, -29219, -29402, -29487, -29475, -29373, -29185, -28921, -28586, -28184, -27723, -27207, -26644, -26037, -25394, -24718, -24012, -23285, -22535, -21769, -20992, -20204, -19410, -18612, -17811, -17012, -16216, -15423, -14636, -13865, -13061, -12145, -11245, -10310, -9322, -8275};