/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0031 512 samples */
 
const int16_t AKWF_stereo_0031_512_DATA [512] = 
{712, 1754, 2767, 3772, 4761, 5735, 6692, 7627, 8544, 9444, 10321, 11183, 12029, 12860, 13685, 14505, 15318, 16138, 16961, 17786, 18617, 19446, 20271, 21092, 21903, 22700, 23487, 24257, 25011, 25749, 26465, 27154, 27808, 28414, 28963, 29448, 29864, 30195, 30395, 30523, 30593, 30610, 30582, 30511, 30406, 30268, 30106, 29928, 29744, 29566, 29404, 29262, 29179, 29197, 29248, 29331, 29440, 29571, 29715, 29867, 30019, 30165, 30295, 30402, 30477, 30513, 30502, 30438, 30320, 30145, 29917, 29641, 29322, 28970, 28592, 28198, 27792, 27384, 26976, 26573, 26179, 25797, 25434, 25095, 24784, 24507, 24263, 24052, 23868, 23702, 23547, 23390, 23222, 23035, 22819, 22570, 22282, 21951, 21575, 21150, 20678, 20161, 19595, 18990, 18347, 17672, 16975, 16260, 15530, 14797, 14062, 13332, 12613, 11905, 11209, 10528, 9858, 9193, 8535, 7878, 7219, 6558, 5889, 5215, 4530, 3834, 3125, 2401, 1660, 903, 127, -666, -1473, -2293, -3125, -3963, -4809, -5663, -6520, -7381, -8247, -9112, -9980, -10845, -11703, -12552, -13387, -14201, -14996, -15766, -16509, -17226, -17917, -18580, -19221, -19839, -20439, -21022, -21592, -22151, -22704, -23251, -23793, -24333, -24865, -25394, -25918, -26435, -26948, -27453, -27949, -28437, -28908, -29358, -29785, -30183, -30549, -30884, -31185, -31455, -31694, -31904, -32084, -32237, -32362, -32459, -32531, -32584, -32622, -32648, -32669, -32687, -32706, -32725, -32741, -32756, -32764, -32767, -32764, -32758, -32746, -32727, -32700, -32658, -32593, -32496, -32358, -32170, -31929, -31631, -31281, -30887, -30451, -29986, -29495, -28983, -28453, -27904, -27336, -26752, -26153, -25538, -24916, -24288, -23657, -23029, -22403, -21782, -21167, -20557, -19951, -19353, -18754, -18157, -17562, -16955, -16343, -15767, -15116, -14508, -13817, -13125, -12421, -11643, -10837, -9996, -9124, -8218, -7287, -6334, -5358, -4366, -3362, -2346, -1327, -284, 28467, 28521, 28553, 28572, 28586, 28594, 28596, 28592, 28575, 28537, 28478, 28396, 28292, 28172, 28032, 27868, 27682, 27462, 27202, 26895, 26533, 26107, 25618, 25064, 24450, 23785, 23068, 22321, 21558, 20785, 20023, 19282, 18563, 17871, 17204, 16561, 15945, 15324, 14666, 14027, 13409, 12812, 12240, 11689, 11160, 10651, 10152, 9657, 9165, 8666, 8163, 7659, 7170, 6716, 6266, 5820, 5374, 4929, 4477, 4018, 3552, 3081, 2614, 2158, 1719, 1307, 925, 578, 272, 13, -202, -366, -480, -552, -587, -596, -589, -585, -602, -653, -758, -936, -1205, -1577, -2071, -2685, -3418, -4269, -5213, -6235, -7321, -8445, -9592, -10752, -11902, -13033, -14139, -15203, -16223, -17197, -18121, -18997, -19833, -20627, -21385, -22110, -22803, -23467, -24111, -24736, -25347, -25951, -26547, -27140, -27724, -28296, -28861, -29413, -29953, -30480, -30987, -31460, -31886, -32245, -32519, -32697, -32769, -32736, -32604, -32382, -32083, -31713, -31286, -30800, -30255, -29653, -28997, -28297, -27561, -26801, -26027, -25252, -24484, -23730, -23000, -22293, -21611, -20963, -20348, -19763, -19207, -18671, -18154, -17649, -17148, -16649, -16151, -15644, -15123, -14582, -14013, -13413, -12775, -12097, -11384, -10640, -9865, -9070, -8261, -7445, -6637, -5846, -5085, -4369, -3706, -3104, -2571, -2105, -1707, -1377, -1106, -898, -745, -653, -612, -617, -660, -722, -788, -843, -874, -873, -835, -768, -681, -589, -506, -442, -404, -392, -401, -415, -427, -426, -402, -353, -275, -165, -21, 156, 370, 620, 905, 1218, 1555, 1912, 2285, 2672, 3075, 3499, 3947, 4431, 4961, 5542, 6181, 6876, 7632, 8444, 9313, 10244, 11236, 12286, 13395, 14551, 15734, 16940, 18138, 19225, 20348, 21299, 22262, 23101, 23822, 24517, 25121, 25648, 26107, 26506, 26861, 27176, 27461, 27714, 27935, 28125, 28278, 28392};