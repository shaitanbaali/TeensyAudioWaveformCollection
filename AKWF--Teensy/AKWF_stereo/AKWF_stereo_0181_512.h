/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0181 512 samples */
 
const int16_t AKWF_stereo_0181_512_DATA [512] = 
{960, 2853, 4731, 6616, 8468, 10270, 12005, 13634, 15166, 16591, 17889, 19068, 20144, 21110, 21968, 22751, 23468, 24116, 24718, 25304, 25863, 26391, 26925, 27448, 27932, 28400, 28850, 29249, 29593, 29911, 30178, 30369, 30529, 30655, 30713, 30725, 30719, 30648, 30529, 30382, 30167, 29860, 29497, 29050, 28478, 27807, 27043, 26146, 25120, 24003, 22767, 21392, 19913, 18321, 16599, 14745, 12789, 10721, 8536, 6296, 4007, 1667, -676, -3005, -5323, -7605, -9840, -12033, -14167, -16248, -18277, -20231, -22109, -23911, -25607, -27180, -28644, -29967, -31184, -31749, -31710, -31719, -31719, -31719, -31719, -31719, -31719, -31719, -31719, -31719, -31719, -31719, -31718, -31714, -31731, -31076, -29955, -28814, -27555, -26215, -24837, -23378, -21816, -20208, -18518, -16700, -14787, -12774, -10638, -8390, -6087, -3723, -1293, 1160, 3611, 6036, 8420, 10723, 12931, 15035, 17018, 18874, 20595, 22185, 23639, 24951, 26125, 27174, 28094, 28882, 29557, 30102, 30514, 30839, 31063, 31173, 31211, 31180, 31053, 30838, 30563, 30202, 29727, 29188, 28572, 27852, 27057, 26214, 25298, 24310, 23306, 22266, 21170, 20056, 18927, 17760, 16554, 15341, 14101, 12813, 11526, 10248, 8940, 7620, 6318, 5003, 3651, 2293, 911, -503, -1941, -3406, -4899, -6399, -7897, -9373, -10796, -12163, -13448, -14632, -15706, -16672, -17507, -18219, -18819, -19296, -19644, -19895, -20046, -20082, -20030, -19909, -19705, -19423, -19109, -18764, -18384, -18010, -17663, -17334, -17034, -16800, -16617, -16469, -16386, -16360, -16363, -16403, -16489, -16585, -16674, -16777, -16867, -16911, -16926, -16911, -16840, -16711, -16550, -16345, -16080, -15797, -15502, -15184, -14861, -14569, -14297, -14038, -13831, -13663, -13512, -13399, -13320, -13250, -13180, -13130, -13079, -13008, -12943, -12874, -12776, -12663, -12527, -12336, -12076, -11747, -11310, -10735, -10031, -9181, -8159, -6977, -5644, -4163, -2549, -797, 761, -647, -1930, -3139, -4267, -5318, -6304, -7224, -8093, -8916, -9682, -10403, -11078, -11697, -12251, -12737, -13151, -13470, -13685, -13800, -13790, -13633, -13344, -12908, -12304, -11557, -10668, -9640, -8490, -7258, -5964, -4623, -3286, -1987, -749, 388, 1383, 2236, 2925, 3434, 3773, 3945, 3963, 3849, 3622, 3307, 2932, 2516, 2081, 1645, 1221, 823, 464, 150, -109, -305, -426, -469, -419, -271, -19, 344, 808, 1370, 2017, 2718, 3454, 4191, 4887, 5519, 6055, 6464, 6732, 6851, 6818, 6638, 6326, 5914, 5411, 4915, 4463, 3996, 3559, 3186, 2881, 2660, 2537, 2507, 2566, 2710, 2942, 3239, 3586, 3994, 4435, 4964, 5572, 6196, 6835, 7496, 8175, 8875, 9597, 10356, 11161, 12008, 12910, 13887, 14926, 16023, 17179, 18381, 19602, 20846, 22101, 23320, 24495, 25628, 26674, 27608, 28447, 29154, 29688, 30080, 30298, 30308, 30121, 29758, 29190, 28405, 27465, 26350, 25063, 23677, 22189, 20588, 18937, 17246, 15498, 13713, 11937, 10156, 8364, 6596, 4862, 3142, 1454, -186, -1799, -3382, -4936, -6477, -8007, -9534, -11068, -12604, -14141, -15687, -17226, -18738, -20223, -21651, -23021, -24324, -25561, -26715, -27775, -28758, -29646, -30407, -31066, -31636, -32085, -32402, -32636, -32753, -32725, -32594, -32361, -31990, -31496, -30932, -30251, -29472, -28647, -27751, -26760, -25740, -24674, -23515, -22296, -21025, -19657, -18190, -16663, -15053, -13357, -11630, -9891, -8142, -6410, -4745, -3164, -1671, -310, 909, 1996, 2940, 3733, 4401, 4946, 5380, 5732, 6012, 6238, 6440, 6625, 6809, 7018, 7260, 7535, 7861, 8242, 8670, 9146, 9677, 10244, 10839, 11468, 12120, 12779, 13445, 14117, 14783, 15420, 16040, 16613, 17100, 17508, 17810, 17959, 17963, 17801, 17446, 16889, 16153, 15228, 14112, 12856, 11477, 9985, 8429, 6854, 5272, 3706, 2166};