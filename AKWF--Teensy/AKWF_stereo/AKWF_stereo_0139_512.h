/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0139 512 samples */
 
const int16_t AKWF_stereo_0139_512_DATA [512] = 
{792, 2379, 3874, 5316, 6700, 8026, 9300, 10516, 11679, 12791, 13850, 14860, 15823, 16737, 17608, 18437, 19222, 19969, 20679, 21351, 21990, 22596, 23169, 23714, 24230, 24719, 25181, 25621, 26037, 26431, 26805, 27159, 27494, 27812, 28113, 28399, 28669, 28925, 29168, 29398, 29615, 29822, 30016, 30202, 30378, 30542, 30699, 30848, 30988, 31121, 31246, 31365, 31476, 31582, 31680, 31774, 31862, 31944, 32022, 32094, 32162, 32225, 32284, 32340, 32390, 32438, 32481, 32521, 32558, 32591, 32621, 32648, 32672, 32693, 32711, 32727, 32740, 32750, 32758, 32765, 32767, 32767, 32767, 32765, 32759, 32751, 32742, 32731, 32717, 32702, 32686, 32667, 32647, 32625, 32601, 32576, 32549, 32520, 32490, 32458, 32425, 32391, 32356, 32318, 32278, 32238, 32197, 32154, 32109, 32064, 32017, 31968, 31920, 31868, 31817, 31763, 31708, 31652, 31596, 31538, 31478, 31417, 31356, 31292, 31228, 31163, 31096, 31028, 30959, 30890, 30818, 29641, 35489, 2607, -36342, -30347, -31539, -31597, -31653, -31709, -31765, -31817, -31869, -31920, -31970, -32018, -32065, -32111, -32154, -32198, -32239, -32280, -32318, -32356, -32391, -32426, -32460, -32491, -32521, -32549, -32576, -32602, -32625, -32647, -32667, -32686, -32702, -32717, -32731, -32743, -32752, -32759, -32765, -32767, -32767, -32767, -32765, -32758, -32750, -32740, -32726, -32711, -32693, -32671, -32648, -32620, -32591, -32557, -32521, -32481, -32437, -32390, -32339, -32284, -32225, -32161, -32093, -32021, -31942, -31860, -31773, -31679, -31580, -31474, -31362, -31245, -31118, -30985, -30846, -30697, -30540, -30374, -30198, -30014, -29818, -29611, -29393, -29164, -28921, -28664, -28394, -28108, -27807, -27488, -27153, -26799, -26425, -26029, -25613, -25174, -24709, -24221, -23704, -23159, -22586, -21980, -21340, -20667, -19957, -19209, -18423, -17594, -16721, -15806, -14843, -13832, -12772, -11659, -10495, -9278, -8003, -6675, -5291, -3848, -2353, -765, 583, 1765, 2894, 4000, 5076, 6124, 7145, 8134, 9094, 10026, 10926, 11800, 12644, 13457, 14243, 15002, 15732, 16436, 17114, 17765, 18393, 18994, 19572, 20129, 20662, 21172, 21663, 22133, 22583, 23015, 23428, 23824, 24202, 24565, 24911, 25243, 25559, 25861, 26150, 26426, 26690, 26941, 27180, 27409, 27626, 27834, 28031, 28219, 28398, 28568, 28729, 28882, 29026, 29164, 29293, 29416, 29532, 29641, 29745, 29841, 29932, 30016, 30095, 30169, 30238, 30302, 30361, 30415, 30465, 30510, 30551, 30588, 30620, 30649, 30675, 30696, 30714, 30728, 30740, 30747, 30752, 30754, 30752, 30747, 30740, 30729, 30716, 30701, 30684, 30662, 30639, 30614, 30586, 30556, 30523, 30489, 30453, 30413, 30373, 30330, 30285, 30239, 30190, 30139, 30088, 30033, 29978, 29920, 29861, 29800, 29736, 29673, 29608, 29541, 29472, 29401, 29329, 29257, 29182, 29106, 29028, 28949, 28869, 28788, 28705, 28621, 28536, 28449, 28361, 28271, 28182, 27078, 32411, 2252, -33463, -27992, -29108, -29183, -29257, -29331, -29402, -29473, -29542, -29610, -29674, -29738, -29802, -29862, -29921, -29978, -30035, -30088, -30141, -30191, -30240, -30286, -30331, -30374, -30414, -30453, -30490, -30525, -30556, -30586, -30614, -30639, -30662, -30684, -30702, -30718, -30730, -30740, -30747, -30752, -30754, -30752, -30747, -30739, -30729, -30713, -30696, -30675, -30649, -30620, -30587, -30550, -30509, -30464, -30415, -30360, -30301, -30237, -30167, -30094, -30014, -29930, -29839, -29742, -29639, -29530, -29414, -29290, -29161, -29024, -28879, -28726, -28565, -28394, -28216, -28028, -27830, -27623, -27404, -27176, -26937, -26685, -26420, -26145, -25856, -25553, -25236, -24905, -24558, -24196, -23817, -23421, -23008, -22576, -22125, -21655, -21163, -20653, -20119, -19562, -18985, -18382, -17754, -17102, -16425, -15719, -14990, -14230, -13443, -12630, -11785, -10912, -10011, -9078, -8117, -7127, -6106, -5058, -3981, -2875, -1745, -564};