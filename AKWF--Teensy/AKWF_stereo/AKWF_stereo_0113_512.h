/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0113 512 samples */
 
const int16_t AKWF_stereo_0113_512_DATA [512] = 
{426, 1359, 2329, 3302, 4286, 5320, 6406, 7492, 8573, 9662, 10764, 11869, 12945, 13968, 14945, 15899, 16844, 17760, 18608, 19357, 20024, 20635, 21215, 21764, 22264, 22707, 23095, 23437, 23762, 24108, 24504, 24951, 25448, 26022, 26708, 27493, 28394, 29261, 29980, 30596, 31121, 31545, 31891, 32182, 32426, 32616, 32740, 32760, 32659, 32470, 32226, 31910, 31497, 31014, 30494, 29932, 29363, 28804, 28235, 27625, 26994, 26363, 25734, 25107, 24468, 23826, 23195, 22579, 21979, 21373, 20790, 20266, 19786, 19304, 18813, 18329, 17865, 17453, 17113, 16848, 16641, 16477, 16371, 16332, 16351, 16423, 16529, 16641, 16734, 16793, 16803, 16758, 16652, 16451, 16158, 15770, 15306, 14760, 14116, 13371, 12537, 11638, 10697, 9730, 8742, 7758, 6808, 5923, 5129, 4428, 3837, 3388, 3076, 2877, 2761, 2686, 2617, 2539, 2439, 2260, 1934, 1646, 1413, 1198, 973, 715, 436, 147, -148, -437, -716, -973, -1199, -1414, -1647, -1935, -2261, -2440, -2540, -2618, -2687, -2761, -2878, -3077, -3388, -3838, -4429, -5130, -5924, -6808, -7759, -8743, -9731, -10697, -11639, -12538, -13372, -14116, -14760, -15306, -15771, -16159, -16452, -16652, -16759, -16803, -16793, -16734, -16642, -16530, -16423, -16351, -16333, -16371, -16478, -16642, -16849, -17113, -17453, -17866, -18330, -18813, -19304, -19786, -20266, -20790, -21374, -21979, -22580, -23195, -23826, -24468, -25107, -25734, -26363, -26994, -27625, -28235, -28805, -29363, -29932, -30494, -31014, -31497, -31910, -32226, -32470, -32659, -32760, -32740, -32616, -32426, -32182, -31891, -31545, -31121, -30596, -29980, -29261, -28394, -27493, -26708, -26022, -25448, -24951, -24505, -24108, -23763, -23438, -23096, -22707, -22264, -21764, -21215, -20636, -20024, -19358, -18608, -17761, -16845, -15900, -14946, -13968, -12946, -11870, -10764, -9663, -8574, -7493, -6407, -5321, -4287, -3303, -2330, -1360, -427, 572, 1891, 3395, 4943, 6395, 7751, 9080, 10364, 11664, 13075, 14593, 16161, 17636, 18943, 20228, 21552, 22925, 24363, 25817, 27205, 28490, 29627, 30571, 31298, 31660, 31733, 31678, 31551, 31466, 31480, 31580, 31665, 31630, 31468, 31269, 31170, 31250, 31433, 31533, 31276, 30796, 30130, 29314, 28382, 27408, 26537, 25827, 25121, 24207, 22928, 21205, 19053, 16678, 14286, 11987, 9829, 7848, 6068, 4544, 3222, 2024, 965, 37, -725, -1251, -1677, -2137, -2707, -3335, -3940, -4490, -4946, -5299, -5481, -5423, -5102, -4694, -4328, -3903, -3375, -2772, -2094, -1329, -490, 431, 1342, 2231, 3096, 3916, 4696, 5379, 5986, 6553, 7063, 7527, 7897, 8144, 8302, 8505, 8859, 9245, 9530, 9660, 9648, 9551, 9397, 9145, 8794, 8328, 7726, 7004, 6299, 5729, 5223, 4645, 4005, 3335, 2607, 1751, 849, 78, -570, -1023, -1324, -1404, -1254, -906, -340, 339, 905, 1253, 1403, 1323, 1023, 569, -79, -850, -1752, -2608, -3336, -4006, -4646, -5223, -5730, -6300, -7005, -7727, -8329, -8795, -9146, -9398, -9552, -9648, -9661, -9531, -9245, -8860, -8506, -8303, -8145, -7898, -7528, -7064, -6554, -5987, -5380, -4697, -3917, -3097, -2232, -1343, -432, 489, 1328, 2093, 2771, 3374, 3902, 4327, 4693, 5101, 5422, 5480, 5299, 4945, 4489, 3939, 3334, 2706, 2136, 1676, 1250, 724, -38, -966, -2024, -3223, -4545, -6069, -7848, -9830, -11987, -14287, -16678, -19054, -21205, -22928, -24207, -25121, -25828, -26538, -27408, -28382, -29314, -30130, -30796, -31276, -31533, -31433, -31251, -31170, -31269, -31468, -31630, -31665, -31580, -31480, -31466, -31551, -31678, -31733, -31660, -31298, -30571, -29627, -28490, -27205, -25817, -24363, -22925, -21552, -20229, -18944, -17636, -16161, -14593, -13076, -11664, -10365, -9081, -7752, -6396, -4944, -3396, -1892, -573};