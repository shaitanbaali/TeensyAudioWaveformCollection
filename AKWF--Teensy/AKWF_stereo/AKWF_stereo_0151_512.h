/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0151 512 samples */
 
const int16_t AKWF_stereo_0151_512_DATA [512] = 
{30435, 30119, 29809, 29499, 29188, 28877, 28567, 28256, 27945, 27635, 27324, 27013, 26703, 26393, 26082, 25771, 25461, 25149, 24839, 24528, 24217, 23906, 23596, 23286, 22975, 22665, 22353, 22042, 21732, 21421, 21110, 20800, 20490, 20179, 19868, 19556, 19247, 18937, 18625, 18315, 18004, 17693, 17382, 17072, 16761, 16451, 16140, 15829, 15519, 15209, 14897, 14586, 14276, 13964, 13654, 13343, 13033, 12723, 12411, 12101, 11790, 11480, 11169, 10859, 10548, 10237, 9928, 9609, 9357, 9178, 8993, 8808, 8624, 8439, 8254, 8070, 7886, 7702, 7517, 7332, 7148, 6964, 6779, 6595, 6410, 6225, 6041, 5856, 5672, 5488, 5303, 5118, 4934, 4749, 4565, 4381, 4196, 4011, 3827, 3643, 3459, 3274, 3088, 2905, 2720, 2535, 2352, 2167, 1981, 1798, 1613, 1429, 1244, 1059, 875, 691, 506, 323, 131, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -2, 5, -104, -298, -480, -665, -849, -1033, -1218, -1403, -1587, -1772, -1956, -2140, -2325, -2509, -2693, -2879, -3062, -3247, -3433, -3617, -3801, -3985, -4170, -4354, -4539, -4723, -4907, -5092, -5277, -5461, -5646, -5830, -6014, -6199, -6383, -6568, -6753, -6938, -7122, -7306, -7490, -7675, -7860, -8044, -8228, -8413, -8597, -8781, -8967, -9152, -9330, -9566, -9882, -10193, -10503, -10813, -11125, -11435, -11745, -12056, -12367, -12677, -12989, -13298, -13609, -13920, -14230, -14541, -14852, -15163, -15474, -15785, -16094, -16405, -16716, -17026, -17337, -17648, -17959, -18270, -18580, -18891, -19202, -19512, -19822, -20134, -20445, -20755, -21065, -21376, -21687, -21997, -22308, -22619, -22930, -23240, -23551, -23862, -24172, -24482, -24794, -25104, -25415, -25726, -26036, -26347, -26658, -26968, -27279, -27590, -27900, -28211, -28522, -28831, -29143, -29454, -29733, -29997, -30924, -4981, 32658, 32249, 31848, 31446, 31046, 30643, 30241, 29839, 29438, 29035, 28634, 28232, 27829, 27428, 27027, 26624, 26223, 25820, 25418, 25017, 24614, 24213, 23811, 23409, 23007, 22605, 22202, 21801, 21399, 20997, 20595, 20195, 19792, 19390, 18988, 18585, 18184, 17783, 17380, 16979, 16577, 16174, 15773, 15372, 14968, 14568, 14166, 13764, 13363, 12960, 12558, 12156, 11754, 11351, 10951, 10548, 10147, 9746, 9342, 8941, 8539, 8136, 7735, 7333, 6931, 6529, 6131, 5713, 5445, 5352, 5241, 5133, 5026, 4918, 4810, 4703, 4596, 4488, 4381, 4273, 4166, 4058, 3950, 3843, 3736, 3628, 3520, 3413, 3306, 3198, 3090, 2983, 2875, 2767, 2660, 2553, 2445, 2338, 2230, 2123, 2015, 1907, 1799, 1692, 1585, 1477, 1370, 1262, 1154, 1047, 940, 832, 725, 617, 509, 402, 295, 189, 76, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 3, -61, -174, -280, -388, -494, -602, -710, -817, -925, -1033, -1140, -1247, -1355, -1462, -1570, -1677, -1785, -1892, -2000, -2108, -2215, -2323, -2430, -2538, -2645, -2753, -2860, -2968, -3075, -3183, -3291, -3398, -3505, -3613, -3721, -3829, -3935, -4043, -4151, -4258, -4366, -4474, -4581, -4688, -4795, -4903, -5011, -5118, -5226, -5337, -5429, -5657, -6072, -6471, -6873, -7274, -7677, -8078, -8480, -8883, -9284, -9687, -10089, -10490, -10892, -11293, -11696, -12097, -12500, -12901, -13304, -13706, -14107, -14510, -14910, -15313, -15715, -16117, -16518, -16920, -17322, -17724, -18126, -18527, -18929, -19332, -19733, -20136, -20537, -20938, -21340, -21743, -22144, -22546, -22949, -23350, -23752, -24155, -24556, -24958, -25360, -25761, -26164, -26566, -26968, -27369, -27771, -28173, -28575, -28977, -29378, -29780, -30183, -30584, -30987, -31388, -31757, -32107, -33174, -5350};