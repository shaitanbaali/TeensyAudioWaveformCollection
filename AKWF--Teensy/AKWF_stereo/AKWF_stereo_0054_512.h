/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0054 512 samples */
 
const int16_t AKWF_stereo_0054_512_DATA [512] = 
{6561, 7937, 7969, 8263, 8509, 8746, 8970, 9206, 9425, 9651, 9880, 10113, 10350, 10589, 10833, 11080, 11328, 11577, 11828, 12080, 12334, 12590, 12847, 13106, 13365, 13624, 13886, 14148, 14409, 14672, 14935, 15197, 15461, 15724, 15987, 16252, 16515, 16779, 17042, 17305, 17568, 17831, 18093, 18355, 18617, 18877, 19138, 19398, 19658, 19916, 20175, 20432, 20689, 20945, 21199, 21454, 21707, 21958, 22210, 22461, 22710, 22958, 23205, 23451, 23695, 23938, 24181, 24422, 24661, 24899, 25136, 25372, 25606, 25839, 26069, 26298, 26526, 26752, 26977, 27200, 27421, 27641, 27859, 28074, 28289, 28502, 28712, 28921, 29128, 29332, 29537, 29736, 29935, 30133, 30327, 30519, 30710, 30899, 31084, 31269, 31450, 31629, 31807, 31982, 32155, 32325, 32434, 32909, 30398, 29123, 29014, 28836, 28729, 28638, 28555, 28485, 28424, 28369, 28321, 28276, 28207, 28285, 27570, 23550, 20054, 19431, 11713, 5, -2345, -3615, -6219, -8952, -10207, -11734, -15403, -19674, -22748, -24796, -26120, -27352, -28626, -29784, -30636, -31172, -31527, -31843, -32150, -32400, -32553, -32618, -32647, -32674, -32702, -32708, -32679, -32622, -32551, -32476, -32394, -32297, -32182, -32051, -31908, -31761, -31603, -31433, -31254, -31064, -30866, -30663, -30453, -30235, -30010, -29781, -29546, -29308, -29066, -28821, -28571, -28320, -28065, -27808, -27551, -27290, -27028, -26764, -26500, -26235, -25968, -25700, -25430, -25161, -24890, -24618, -24346, -24072, -23797, -23522, -23245, -22968, -22689, -22410, -22130, -21848, -21566, -21284, -20998, -20713, -20426, -20139, -19850, -19561, -19271, -18979, -18687, -18393, -18099, -17805, -17508, -17211, -16914, -16614, -16315, -16016, -15715, -15414, -15113, -14810, -14508, -14205, -13902, -13599, -13294, -12989, -12682, -12374, -12065, -11758, -11450, -11142, -10836, -10528, -10221, -9916, -9610, -9304, -9001, -8698, -8395, -8090, -7793, -7490, -7190, -6849, -6763, -5558, 293, 638, 976, 1320, 1661, 1998, 2329, 2660, 2992, 3324, 3657, 3991, 4326, 4661, 4997, 5333, 5667, 6000, 6332, 6663, 6993, 7323, 7654, 7984, 8313, 8640, 8969, 9295, 9622, 9949, 10273, 10596, 10920, 11243, 11565, 11886, 12207, 12527, 12846, 13163, 13481, 13798, 14113, 14427, 14742, 15055, 15367, 15679, 15990, 16300, 16609, 16917, 17225, 17531, 17836, 18142, 18445, 18747, 19050, 19351, 19651, 19951, 20249, 20546, 20842, 21138, 21433, 21726, 22018, 22310, 22601, 22891, 23181, 23469, 23754, 24040, 24325, 24609, 24891, 25173, 25453, 25733, 26012, 26289, 26566, 26841, 27114, 27389, 27661, 27931, 28203, 28469, 28737, 29005, 29269, 29532, 29795, 30057, 30317, 30576, 30833, 31090, 31346, 31600, 31853, 32105, 32285, 32902, 29962, 28498, 28414, 28308, 27998, 26939, 25645, 23819, 22212, 20790, 19676, 18810, 18120, 17633, 16937, 15009, 13188, 13632, 4390, -11767, -16553, -18668, -20176, -20692, -20312, -20234, -21821, -23970, -25418, -26173, -26499, -26874, -27410, -27945, -28294, -28431, -28470, -28523, -28611, -28677, -28677, -28615, -28534, -28463, -28403, -28330, -28231, -28112, -27986, -27860, -27733, -27596, -27444, -27283, -27112, -26944, -26764, -26578, -26385, -26186, -25980, -25771, -25556, -25336, -25111, -24882, -24649, -24414, -24175, -23932, -23686, -23439, -23188, -22935, -22680, -22423, -22163, -21902, -21640, -21375, -21110, -20841, -20571, -20301, -20030, -19756, -19481, -19203, -18925, -18645, -18363, -18082, -17798, -17512, -17225, -16937, -16647, -16356, -16063, -15769, -15474, -15176, -14877, -14578, -14277, -13974, -13670, -13364, -13056, -12748, -12438, -12127, -11815, -11500, -11185, -10869, -10550, -10233, -9912, -9590, -9267, -8944, -8619, -8293, -7964, -7634, -7302, -6966, -6629, -6293, -5955, -5615, -5275, -4934, -4592, -4251, -3907, -3564, -3221, -2876, -2530, -2183, -1837, -1489, -1144, -784, -479, -127};