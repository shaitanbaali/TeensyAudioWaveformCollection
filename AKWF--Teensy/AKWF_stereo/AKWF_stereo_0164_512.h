/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0164 512 samples */
 
const int16_t AKWF_stereo_0164_512_DATA [512] = 
{124, 542, 992, 1419, 1659, 1797, 1968, 2215, 2549, 2951, 3410, 3925, 4494, 5096, 5734, 6415, 7128, 7871, 8643, 9438, 10247, 11069, 11909, 12757, 13602, 14458, 15303, 16090, 16826, 17530, 18212, 18912, 19633, 20352, 21071, 21813, 22556, 23280, 24020, 24762, 25485, 26202, 26920, 27613, 28270, 28933, 29546, 29927, 29999, 29868, 29722, 29641, 29691, 29806, 29968, 30207, 30483, 30774, 31124, 31524, 31925, 32284, 32919, 30910, 22671, 15650, 10297, 6362, 3242, 522, -1817, -3744, -5242, -6372, -7191, -7752, -8106, -8300, -8367, -8336, -8242, -8164, -8336, -8680, -9019, -9438, -9874, -10215, -10423, -10527, -10749, -10937, -10934, -10846, -10830, -10974, -11331, -11696, -11931, -12029, -12000, -11852, -11625, -11334, -10972, -10551, -10086, -9579, -9037, -8462, -7876, -7268, -6648, -6130, -5836, -5768, -5888, -5978, -5963, -5846, -5643, -5364, -5014, -4679, -4525, -4446, -4326, -4120, -3828, -3495, -2943, -5261, -11528, -16139, -19621, -22027, -23952, -25591, -26931, -27979, -28779, -29324, -29660, -29849, -29895, -29795, -29615, -29356, -29004, -28617, -28230, -27806, -27321, -26819, -26275, -25660, -25026, -24380, -23692, -22957, -22213, -21437, -20603, -19759, -18906, -18022, -17279, -16824, -16426, -15969, -15458, -14871, -14259, -13800, -13435, -13042, -12583, -12073, -11497, -10935, -10546, -10114, -9597, -9009, -8383, -7761, -7108, -6416, -5710, -5079, -4874, -4979, -5102, -5136, -5052, -4863, -4596, -4271, -3877, -3410, -2877, -2290, -1653, -975, -270, 462, 1221, 1996, 2771, 3548, 4332, 5123, 5926, 6736, 7551, 8377, 9188, 9720, 9808, 9766, 9772, 9903, 10141, 10445, 10825, 11164, 11213, 11139, 11136, 11238, 11456, 11771, 12152, 12581, 13072, 13610, 14156, 14715, 15304, 15891, 16557, 16792, 13505, 9506, 6755, 4702, 3258, 2025, 1024, 249, -293, -604, -713, -691, -526, -225, 21285, 21516, 21520, 21454, 21223, 20934, 20686, 20512, 20459, 20494, 20578, 20740, 20933, 21008, 21029, 21117, 21272, 21477, 21752, 22074, 22412, 22777, 23185, 23608, 24026, 24484, 24896, 24927, 24413, 23588, 22768, 22117, 21651, 21308, 21064, 20944, 20917, 20953, 21087, 21294, 21539, 21818, 22007, 22032, 22024, 22068, 22174, 22324, 22514, 22748, 22996, 23245, 23537, 23841, 24146, 24401, 24481, 24474, 24495, 24566, 24645, 24703, 25025, 23068, 15681, 9294, 4407, 798, -2048, -4509, -6614, -8362, -9755, -10843, -11673, -12293, -12743, -13049, -13239, -13341, -13366, -13314, -13224, -13116, -12965, -12780, -12565, -12321, -11980, -11895, -15454, -20148, -23253, -25614, -27263, -28646, -29824, -30786, -31511, -32058, -32441, -32651, -32753, -32759, -32652, -32471, -32340, -32269, -32163, -32039, -31856, -31587, -31274, -30935, -30535, -30074, -29602, -29091, -28515, -27927, -27334, -26703, -26046, -25400, -24725, -24002, -23289, -22566, -21802, -21032, -20271, -19486, -18683, -17908, -17136, -16343, -15559, -14783, -13995, -13195, -12417, -11632, -10851, -10093, -9335, -8559, -7796, -7033, -6292, -5747, -5354, -4963, -4530, -4059, -3559, -3042, -2521, -1984, -1421, -832, -231, 371, 979, 1592, 2151, 2541, 2849, 3168, 3534, 3948, 4396, 4876, 5379, 5904, 6456, 7025, 7601, 8169, 8862, 8411, 4914, 1894, -299, -1847, -3048, -4273, -5425, -6357, -7060, -7543, -7846, -8011, -8051, -7978, -7815, -7576, -7397, -7347, -7289, -7158, -6949, -6671, -6333, -5953, -5553, -5120, -4643, -4144, -3792, -3630, -3480, -3281, -3019, -2658, -2245, -1788, -1287, -756, -200, 395, 1025, 1681, 2360, 3057, 3768, 4487, 5204, 5917, 6630, 7343, 8055, 8754, 9431, 10086, 10741, 11401, 11941, 12281, 12566, 12863, 13201, 13580, 13960, 14328, 14721, 15152, 15609, 16094, 16623, 17174, 17731, 18316, 18918, 19516, 20120, 20752};