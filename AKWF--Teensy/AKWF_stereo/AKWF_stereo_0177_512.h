/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0177 512 samples */
 
const int16_t AKWF_stereo_0177_512_DATA [512] = 
{382, 1734, 3213, 4496, 5922, 7433, 8993, 10836, 12761, 14277, 15680, 17200, 18678, 20366, 21925, 22880, 23814, 24812, 25556, 26417, 27054, 27297, 27808, 28201, 28161, 28165, 28168, 28209, 28375, 28462, 28655, 28773, 28738, 28884, 28982, 29142, 29463, 29593, 29789, 30071, 30303, 30576, 30853, 30945, 30877, 30773, 30487, 30094, 29772, 29376, 28863, 28402, 27599, 26591, 25987, 25295, 24162, 23105, 22206, 21244, 20285, 19340, 18255, 17296, 16162, 14932, 14281, 13379, 11918, 11085, 10561, 9677, 8807, 8018, 7335, 7090, 6924, 6373, 6145, 6163, 6007, 6255, 6611, 6567, 6912, 7592, 8281, 9141, 9953, 10546, 11044, 11493, 11987, 12235, 12125, 12298, 12325, 12014, 11685, 11257, 10851, 10385, 9603, 8457, 7550, 6971, 6280, 5629, 5232, 5071, 5122, 5189, 5129, 5108, 5231, 5468, 5870, 6134, 6108, 6191, 6050, 5297, 4817, 4383, 3364, 2306, 1205, -261, -1694, -3060, -4682, -6623, -8542, -10274, -11966, -13598, -15238, -16640, -17841, -19219, -20323, -21165, -22583, -23531, -23835, -24716, -25359, -25575, -26133, -26478, -26503, -26590, -26808, -27044, -26759, -26391, -26401, -26651, -26989, -27109, -27005, -27106, -27448, -27786, -28004, -28120, -28361, -28555, -28633, -28958, -29549, -29995, -30241, -30520, -30628, -30754, -30851, -30759, -30748, -30644, -30152, -29557, -29015, -28418, -27676, -26804, -25864, -24744, -23589, -22515, -21367, -20276, -19283, -18196, -17033, -16024, -15030, -14067, -13522, -13132, -12514, -11643, -10885, -10612, -10434, -10141, -9926, -9576, -9057, -9161, -9698, -9731, -9582, -9469, -9401, -9788, -9905, -9705, -9649, -9490, -9393, -9403, -9246, -8972, -8477, -8436, -8558, -8107, -7664, -7365, -7180, -6989, -6571, -6098, -5845, -5704, -5723, -5855, -5622, -5003, -5073, -5587, -5494, -5307, -5284, -5337, -5369, -5174, -4966, -4726, -4193, -3539, -2960, -2414, -1401, -348, 12346, 12801, 12940, 13034, 13688, 13953, 13985, 14441, 14849, 14917, 15191, 15326, 15210, 15290, 15611, 15563, 15463, 15583, 15404, 15307, 15490, 15797, 16267, 16500, 16659, 17111, 17363, 17842, 18477, 18751, 19236, 19775, 19780, 19931, 20507, 20631, 20350, 20344, 20406, 20342, 20513, 20572, 20613, 20829, 20861, 20900, 21016, 21335, 22128, 23084, 23714, 24135, 24523, 25211, 26325, 26984, 27210, 27557, 27416, 27007, 26961, 26947, 26237, 24986, 23879, 22705, 21335, 20068, 18482, 16693, 15180, 13424, 11419, 9822, 8546, 7305, 6332, 5289, 4432, 3974, 3591, 3584, 3411, 2999, 3384, 3727, 3859, 4453, 4814, 4671, 4276, 3923, 3843, 3336, 2011, 812, -309, -1845, -3534, -4959, -6392, -8159, -9800, -11696, -13216, -14203, -15289, -16029, -16382, -16486, -16217, -15656, -15008, -14295, -13220, -12179, -11572, -10866, -9939, -8899, -8486, -8915, -9104, -9019, -9442, -10223, -10695, -11308, -12216, -13197, -14192, -15224, -16232, -17037, -17683, -18089, -18426, -18556, -18492, -18653, -18558, -18227, -18674, -18606, -17852, -17805, -17616, -17591, -18283, -18683, -18911, -19251, -19896, -20795, -21099, -21302, -21952, -22762, -23449, -23914, -24389, -24784, -25171, -25584, -25543, -25352, -25441, -25241, -25274, -25930, -25957, -25603, -26083, -26654, -26860, -27404, -28019, -28540, -29442, -30570, -31113, -31202, -31536, -32085, -32645, -32738, -32496, -32202, -31638, -30794, -29880, -28670, -27132, -25699, -23998, -22178, -20534, -18546, -16743, -15504, -13823, -11591, -9563, -8065, -6811, -5876, -5027, -3646, -2312, -1984, -1887, -1350, -1055, -623, -105, 35, 781, 1663, 2020, 2280, 3060, 4063, 4722, 5682, 7215, 8256, 9160, 10760, 12482, 13852, 14999, 16184, 17284, 18358, 19375, 19782, 19735, 19544, 19387, 19525, 19204, 18067, 17288, 16834, 16176, 15393, 14697, 14116, 13214, 12315, 12259, 12518, 12159, 11846, 12277, 12474};