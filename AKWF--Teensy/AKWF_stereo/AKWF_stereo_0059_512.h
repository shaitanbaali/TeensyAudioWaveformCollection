/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0059 512 samples */
 
const int16_t AKWF_stereo_0059_512_DATA [512] = 
{983, 2594, 4202, 5824, 7442, 9053, 10647, 12213, 13750, 15254, 16714, 18133, 19504, 20820, 22084, 23291, 24434, 25516, 26533, 27478, 28356, 29160, 29888, 30541, 31112, 31603, 32012, 32335, 32569, 32715, 32768, 32727, 32589, 32352, 32012, 31566, 31014, 30351, 29574, 28682, 27669, 26533, 25277, 23891, 22376, 20737, 18965, 17065, 15047, 12908, 10665, 8352, 5984, 3821, 3293, 1705, 1291, 1156, 1100, 1054, 1009, 964, 922, 881, 843, 808, 776, 748, 726, 709, 697, 693, 696, 706, 724, 752, 788, 832, 886, 950, 1022, 1104, 1195, 1296, 1407, 1525, 1653, 1790, 1936, 2088, 2249, 2418, 2593, 2775, 2964, 3157, 3357, 3561, 3769, 3981, 4196, 4412, 4633, 4853, 5076, 5300, 5520, 5743, 5963, 6182, 6399, 6612, 6823, 7030, 7230, 7427, 7618, 7804, 7982, 8152, 8317, 8473, 8621, 8759, 8888, 9008, 9116, 9214, 9302, 9376, 9440, 9492, 9531, 9556, 9567, 9565, 9551, 9520, 9474, 9414, 9338, 9247, 9139, 9016, 8876, 8719, 8546, 8355, 8147, 7922, 7679, 7420, 7142, 6848, 6534, 6205, 5858, 5494, 5115, 4719, 4308, 3884, 3447, 2998, 2541, 2078, 1615, 1161, 728, 362, -8, 1092, 1958, 1465, 1014, 470, -119, -743, -1395, -2066, -2757, -3460, -4172, -4896, -5626, -6359, -7097, -7835, -8573, -9309, -10042, -10769, -11491, -12204, -12908, -13603, -14285, -14955, -15611, -16249, -16873, -17478, -18063, -18629, -19174, -19695, -20193, -20667, -21114, -21534, -21927, -22289, -22623, -22925, -23193, -23429, -23630, -23797, -23926, -24019, -24072, -24085, -24058, -23990, -23878, -23722, -23521, -23276, -22983, -22641, -22250, -21810, -21319, -20775, -20181, -19531, -18828, -18071, -17258, -16388, -15465, -14485, -13451, -12366, -11224, -10036, -8803, -7527, -6222, -4902, -3606, -2292, -1732, -2998, -1996, -496, 10432, 11895, 13187, 14387, 15513, 16578, 17595, 18565, 19496, 20391, 21249, 22077, 22875, 23637, 24370, 25072, 25740, 26376, 26976, 27540, 28070, 28560, 29011, 29421, 29788, 30109, 30388, 30617, 30796, 30926, 31003, 31027, 30995, 30907, 30761, 30554, 30288, 29960, 29567, 29108, 28583, 27987, 27320, 26575, 25750, 24839, 23833, 22719, 21487, 20102, 18528, 16688, 14530, 11148, 2740, 3501, 4981, 5721, 6267, 6781, 7237, 7636, 7993, 8310, 8593, 8845, 9072, 9275, 9456, 9621, 9769, 9904, 10028, 10142, 10250, 10352, 10449, 10543, 10637, 10729, 10824, 10918, 11014, 11115, 11217, 11325, 11437, 11552, 11673, 11799, 11930, 12064, 12203, 12350, 12498, 12651, 12808, 12969, 13134, 13303, 13472, 13645, 13821, 13998, 14176, 14353, 14531, 14710, 14887, 15065, 15239, 15413, 15583, 15751, 15916, 16077, 16234, 16386, 16533, 16675, 16813, 16943, 17068, 17186, 17297, 17401, 17497, 17584, 17664, 17735, 17798, 17851, 17893, 17928, 17951, 17966, 17969, 17960, 17940, 17909, 17867, 17812, 17745, 17665, 17571, 17465, 17344, 17207, 17057, 16891, 16708, 16508, 16292, 16058, 15802, 15527, 15230, 14910, 14565, 14193, 13790, 13354, 12883, 12366, 11802, 11176, 10472, 9670, 8722, 7492, 6208, 319, -4912, -6006, -7276, -8294, -9193, -10017, -10784, -11505, -12190, -12847, -13477, -14087, -14676, -15249, -15807, -16349, -16877, -17395, -17899, -18390, -18873, -19343, -19802, -20251, -20687, -21113, -21526, -21929, -22320, -22699, -23065, -23417, -23758, -24084, -24396, -24694, -24977, -25244, -25495, -25729, -25946, -26145, -26326, -26487, -26630, -26751, -26852, -26930, -26988, -27022, -27031, -27018, -26980, -26915, -26825, -26706, -26561, -26387, -26182, -25949, -25683, -25386, -25055, -24689, -24288, -23849, -23369, -22849, -22285, -21674, -21011, -20292, -19509, -18657, -17722, -16684, -15519, -14182, -12542, -10752, -6428, 3710, 6955, 8809};