/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0102 512 samples */
 
const int16_t AKWF_stereo_0102_512_DATA [512] = 
{959, 4511, 7540, 9433, 10526, 11525, 12677, 13836, 14621, 15052, 15400, 15962, 16830, 17682, 18134, 18304, 18740, 20207, 22523, 24826, 26559, 27832, 28638, 28810, 28344, 27745, 27616, 27906, 28305, 28815, 29457, 30073, 30593, 30857, 30726, 30274, 29327, 27885, 26199, 24546, 23105, 21740, 20665, 20031, 19622, 19173, 18528, 17850, 17114, 16265, 15267, 14371, 13840, 13363, 12760, 12125, 11610, 11052, 10442, 10068, 9978, 10146, 10581, 11123, 11547, 11626, 10983, 9219, 6646, 3868, 1247, -1131, -3276, -5221, -7084, -8960, -10825, -12635, -14426, -16016, -17253, -17959, -17918, -17439, -17176, -17051, -16742, -16386, -16275, -16355, -16320, -15933, -15268, -14608, -14222, -14108, -13672, -12833, -12306, -12834, -14231, -15733, -17196, -18750, -20264, -21633, -22805, -23712, -24290, -24815, -25526, -26104, -26387, -26758, -27608, -28462, -29061, -29708, -30557, -31521, -32348, -32774, -32530, -31540, -30063, -28669, -27516, -26480, -25860, -25643, -25499, -25080, -24083, -22247, -19617, -16631, -13468, -10122, -6707, -3618, -1104, 1087, 3611, 6628, 9411, 11372, 12870, 14366, 15599, 16435, 17090, 17616, 17671, 17194, 16760, 16691, 16961, 17234, 17196, 17134, 17795, 19257, 20741, 21565, 21588, 20837, 19434, 17684, 15852, 14118, 12513, 11076, 10116, 9789, 10082, 10608, 11018, 11067, 10717, 10118, 9275, 8351, 7840, 7589, 6880, 5475, 4153, 3343, 2869, 2552, 2355, 2388, 2680, 3332, 4035, 4260, 3940, 3563, 3447, 3336, 2602, 1584, 804, 200, -566, -1521, -2340, -2973, -3752, -4618, -5196, -5470, -5612, -5524, -4961, -4118, -3848, -4306, -4600, -4458, -4097, -3822, -3719, -3803, -4245, -4984, -5554, -5374, -4895, -5041, -6147, -8034, -10764, -14132, -17344, -20078, -22425, -24497, -26125, -27237, -27879, -27968, -27637, -27193, -26895, -26616, -25481, -23205, -20558, -18353, -16133, -13366, -10424, -7668, -5024, -2156, -11035, -11110, -11052, -11008, -11569, -12921, -14550, -15872, -16752, -17240, -17602, -17999, -18030, -17398, -16781, -16962, -17497, -18138, -19011, -19732, -19714, -18983, -18266, -17615, -16087, -13141, -9461, -6622, -5387, -4755, -3653, -1957, -356, 709, 1922, 3560, 5416, 7344, 8894, 9655, 9814, 9533, 8694, 7511, 6758, 6488, 6045, 4798, 2753, -13, -3234, -6426, -9310, -11195, -11464, -10343, -8524, -6623, -4930, -3887, -3853, -4440, -5434, -6674, -7994, -8857, -8796, -7736, -6049, -4072, -2215, -799, 323, 1386, 2405, 3238, 3838, 4045, 3440, 2063, 693, -864, -2766, -4632, -5998, -6780, -7454, -8032, -8000, -7347, -6519, -5909, -5538, -5402, -5787, -6633, -7325, -7759, -8236, -9062, -9668, -9454, -8972, -8557, -8023, -7314, -6599, -6278, -6517, -6978, -7333, -7417, -7022, -6411, -6308, -7368, -9282, -10988, -12023, -12490, -12328, -11321, -9651, -8032, -6500, -4611, -2518, -537, 976, 2445, 4004, 5553, 7248, 9429, 11887, 14048, 15764, 17238, 18768, 20947, 23880, 27257, 30415, 32206, 32664, 32193, 30908, 28984, 26545, 23797, 20834, 17771, 14764, 11507, 7987, 4906, 3315, 3384, 4002, 4165, 4526, 5435, 6124, 5548, 3831, 1870, 63, -1356, -1967, -1776, -1054, 20, 1059, 1812, 2179, 2364, 2640, 3284, 4166, 4918, 5561, 6250, 6848, 7142, 7180, 6953, 6588, 6260, 6206, 6642, 7417, 8255, 8647, 8536, 8422, 8374, 7929, 7122, 6532, 6779, 7672, 8913, 10282, 11545, 12582, 13404, 13605, 12609, 10901, 9558, 8916, 8788, 8735, 8617, 7950, 6622, 5375, 4449, 3623, 2629, 1682, 1554, 2154, 2348, 1749, 621, -449, -1441, -2325, -2688, -2257, -1376, -244, 778, 1529, 2334, 3532, 4470, 4558, 4026, 3090, 1929, 671, -615, -2240, -4197, -6063, -7276, -7588, -7547, -7611, -7813, -8462, -9422, -10350, -10885};