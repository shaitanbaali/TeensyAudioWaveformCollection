/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0040 512 samples */
 
const int16_t AKWF_stereo_0040_512_DATA [512] = 
{685, 2404, 3948, 5510, 6902, 7985, 8812, 9257, 9762, 10234, 10597, 11201, 12063, 12722, 13142, 13594, 13747, 13822, 13770, 13747, 13790, 13661, 13705, 13946, 14348, 14762, 15214, 15495, 15716, 16334, 16967, 17576, 18399, 19432, 20442, 21419, 22282, 23093, 24203, 25342, 26121, 26571, 26920, 27481, 28164, 29030, 29872, 30484, 30723, 30886, 31252, 31558, 31658, 31317, 30730, 30502, 30478, 30358, 30119, 29888, 29761, 29541, 29534, 29891, 30307, 30431, 30317, 29954, 29596, 29135, 28640, 28288, 27937, 27563, 27131, 26887, 26932, 26731, 26161, 25524, 25134, 25013, 24910, 24513, 24172, 24134, 24081, 23978, 23659, 23314, 23270, 23225, 23053, 22797, 22417, 21951, 21659, 21232, 20537, 19596, 18356, 17315, 16409, 15457, 14611, 13872, 13194, 12545, 11815, 10843, 9837, 8829, 7783, 6602, 5576, 5019, 4305, 3593, 2989, 2454, 2033, 1453, 836, 399, 50, -520, -1454, -2786, -4524, -6205, -7937, -9504, -10777, -12021, -13341, -14644, -15860, -16988, -18008, -19170, -20471, -21593, -22455, -23273, -24237, -25314, -26496, -27326, -27731, -28092, -28392, -28824, -28739, -28194, -27768, -27322, -26917, -26281, -25205, -23912, -22731, -21459, -20188, -18748, -17279, -16168, -15210, -14662, -14300, -13945, -13683, -13440, -13125, -12976, -13111, -13293, -13646, -14217, -14938, -15831, -16781, -17658, -18140, -18420, -18684, -18899, -19007, -18934, -18769, -19314, -20759, -22027, -23037, -23802, -24229, -24624, -25085, -25552, -25805, -25846, -26520, -27705, -28655, -29495, -30008, -30240, -30552, -31022, -31571, -32296, -32758, -32393, -31052, -29529, -28227, -26758, -24954, -23075, -21462, -20074, -18821, -17524, -16041, -14844, -13832, -12918, -12230, -11828, -11491, -10911, -10460, -10702, -11364, -11989, -12734, -13564, -14141, -14494, -14601, -14568, -14193, -13510, -12880, -12324, -11891, -11445, -10645, -9560, -8600, -8043, -7245, -5851, -4578, -3530, -2373, -901, 1799, -1425, -4027, -6244, -7701, -8002, -7975, -7377, -6042, -5401, -5496, -5630, -5345, -4417, -3350, -2904, -2748, -2867, -3203, -2968, -2656, -2122, -528, 1451, 2727, 3010, 2988, 2738, 1987, 631, -1151, -2849, -3465, -3192, -2276, -1349, -311, 799, 1721, 2442, 3270, 3994, 4490, 4509, 3855, 2789, 2226, 2228, 1849, 1934, 2534, 2863, 3295, 3732, 3766, 3551, 3730, 4515, 5381, 6402, 8280, 10511, 12146, 13383, 14288, 15657, 17364, 19152, 20764, 21973, 22657, 22414, 21696, 20805, 20249, 20487, 21672, 23080, 24230, 25085, 26166, 27119, 26824, 25759, 24132, 22174, 20548, 18655, 16204, 13569, 11397, 9702, 8045, 6038, 3142, -451, -4318, -8243, -11774, -14312, -15967, -17162, -18061, -19034, -19886, -20679, -21647, -21374, -20932, -20686, -20655, -20888, -21241, -21491, -21976, -22936, -23962, -24851, -23468, -20885, -18470, -16513, -14512, -12424, -10927, -9650, -8969, -8656, -7703, -7380, -7237, -6889, -6514, -5240, -3518, -2058, -934, -681, -817, -282, 282, 580, 1287, 2241, 2406, 1970, 1639, 1333, 1229, 1766, 1018, -370, -1852, -3138, -4780, -7094, -9273, -10907, -11259, -10545, -9685, -9560, -9996, -10345, -9477, -7737, -6667, -6448, -6838, -7060, -6921, -7170, -7316, -7443, -7409, -7067, -6187, -5066, -4747, -4981, -5372, -6192, -6862, -7566, -8664, -9368, -9765, -10315, -10853, -12155, -14232, -16394, -18674, -21137, -23909, -26461, -28168, -29269, -29773, -29800, -28798, -27915, -27738, -27387, -26866, -25462, -22717, -20006, -17489, -14967, -12775, -10365, -7603, -5917, -5108, -4418, -2986, -365, 2728, 5437, 7796, 9453, 10697, 12552, 14887, 17308, 19890, 22016, 23566, 24926, 25836, 26287, 26694, 27649, 28632, 29196, 29848, 30863, 31854, 32654, 32630, 31949, 30805, 29583, 28213, 26803, 24770, 22009, 19446, 17968, 17057, 15375, 12852, 10110, 7608, 4920};