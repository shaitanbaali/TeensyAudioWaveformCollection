/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0003 512 samples */
 
const int16_t AKWF_stereo_0003_512_DATA [512] = 
{1513, 4776, 6593, 8270, 9763, 11138, 12423, 13629, 14771, 15859, 16893, 17881, 18826, 19725, 20588, 21411, 22195, 22944, 23656, 24331, 24972, 25579, 26150, 26686, 27187, 27654, 28088, 28485, 28849, 29178, 29473, 29734, 29961, 30153, 30311, 30435, 30526, 30582, 30604, 30593, 30549, 30472, 30362, 30219, 30045, 29840, 29602, 29332, 29034, 28704, 28344, 27957, 27540, 27095, 26624, 26123, 25598, 25048, 24472, 23872, 23250, 22604, 21938, 21250, 20540, 19814, 19069, 18303, 17523, 16727, 15915, 15090, 14251, 13399, 12537, 11664, 10781, 9891, 8992, 8085, 7175, 6258, 5336, 4414, 3487, 2558, 1632, 703, -223, -1146, -2069, -2987, -3900, -4810, -5711, -6607, -7497, -8376, -9247, -10111, -10962, -11803, -12633, -13450, -14255, -15049, -15826, -16591, -17341, -18075, -18795, -19500, -20186, -20857, -21512, -22148, -22768, -23369, -23952, -24519, -25065, -25593, -26103, -26594, -27066, -27519, -27953, -28366, -28763, -29139, -29495, -29834, -30153, -30452, -30733, -30995, -31237, -31462, -31667, -31856, -32026, -32176, -32310, -32426, -32524, -32607, -32672, -32720, -32751, -32766, -32766, -32750, -32719, -32673, -32612, -32537, -32447, -32344, -32228, -32098, -31956, -31801, -31633, -31455, -31265, -31063, -30851, -30628, -30396, -30153, -29902, -29640, -29370, -29093, -28806, -28511, -28210, -27901, -27585, -27263, -26934, -26598, -26259, -25913, -25562, -25208, -24848, -24483, -24116, -23744, -23369, -22991, -22609, -22227, -21840, -21451, -21062, -20670, -20276, -19882, -19486, -19089, -18694, -18296, -17897, -17500, -17102, -16704, -16308, -15912, -15517, -15124, -14730, -14337, -13947, -13558, -13170, -12786, -12402, -12020, -11641, -11263, -10889, -10518, -10147, -9781, -9417, -9056, -8698, -8343, -7991, -7642, -7297, -6955, -6617, -6282, -5950, -5624, -5299, -4979, -4664, -4350, -4042, -3738, -3438, -3141, -2850, -2562, -2279, -2000, -1723, -1454, -1188, -926, -670, -412, -22656, -22264, -21877, -21487, -21096, -20701, -20305, -19910, -19511, -19112, -18714, -18315, -17914, -17514, -17114, -16715, -16316, -15917, -15519, -15124, -14728, -14334, -13942, -13550, -13161, -12775, -12389, -12007, -11625, -11246, -10871, -10498, -10126, -9759, -9394, -9032, -8674, -8318, -7965, -7617, -7271, -6928, -6591, -6255, -5924, -5597, -5274, -4954, -4639, -4327, -4020, -3717, -3416, -3121, -2832, -2545, -2263, -1986, -1713, -1444, -1180, -919, -622, -588, 1376, 4427, 6168, 7788, 9241, 10587, 11853, 13047, 14184, 15271, 16307, 17302, 18256, 19167, 20043, 20883, 21685, 22454, 23188, 23885, 24550, 25183, 25778, 26341, 26871, 27365, 27826, 28253, 28646, 29006, 29330, 29620, 29877, 30098, 30287, 30440, 30559, 30645, 30697, 30714, 30698, 30650, 30567, 30452, 30304, 30123, 29911, 29667, 29393, 29086, 28750, 28385, 27988, 27565, 27114, 26633, 26128, 25596, 25036, 24453, 23847, 23215, 22563, 21889, 21192, 20478, 19743, 18987, 18217, 17429, 16625, 15808, 14975, 14128, 13272, 12403, 11522, 10635, 9736, 8831, 7921, 7004, 6081, 5157, 4228, 3297, 2366, 1433, 501, -427, -1355, -2280, -3199, -4117, -5026, -5931, -6830, -7718, -8599, -9473, -10334, -11185, -12027, -12855, -13672, -14477, -15266, -16044, -16808, -17554, -18287, -19004, -19704, -20389, -21056, -21706, -22339, -22954, -23551, -24131, -24691, -25232, -25756, -26261, -26745, -27212, -27658, -28085, -28495, -28883, -29252, -29603, -29933, -30245, -30538, -30811, -31065, -31301, -31518, -31716, -31896, -32057, -32201, -32326, -32434, -32525, -32598, -32654, -32695, -32717, -32726, -32716, -32692, -32653, -32598, -32529, -32445, -32348, -32236, -32112, -31974, -31823, -31660, -31485, -31298, -31100, -30891, -30672, -30441, -30200, -29951, -29691, -29422, -29145, -28859, -28566, -28265, -27957, -27640, -27318, -26990, -26654, -26314, -25967, -25615, -25259, -24898, -24533, -24164, -23791, -23416, -23029};