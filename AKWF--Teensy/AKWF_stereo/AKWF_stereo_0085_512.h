/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0085 512 samples */
 
const int16_t AKWF_stereo_0085_512_DATA [512] = 
{385, 1223, 1907, 2500, 3044, 3554, 4038, 4503, 4955, 5387, 5798, 6208, 6601, 6987, 7360, 7727, 8084, 8435, 8777, 9113, 9425, 9855, 9634, 9973, 10891, 11116, 11400, 11649, 11877, 12096, 12293, 12499, 12698, 12884, 13068, 13237, 13397, 13551, 13693, 13828, 13925, 14221, 13382, 12335, 13171, 13653, 14062, 14377, 14619, 14806, 14953, 15068, 15162, 15237, 15303, 15360, 15409, 15453, 15493, 15530, 15565, 15598, 15627, 15657, 15688, 15712, 15702, 15765, 15793, 15811, 15831, 15848, 15861, 15872, 15884, 15889, 15847, 16200, 14772, 11111, 17075, 17112, 17208, 17076, 16894, 16700, 16425, 16255, 16131, 16010, 15895, 15792, 15691, 15597, 15507, 15421, 15233, 15709, 13303, -3531, -3654, -2301, -1558, -1127, -969, -985, -1083, -1211, -1344, -1484, -1637, -1809, -2031, -2150, -2985, -3524, -2575, -3061, -3602, -4222, -4800, -5242, -5878, -6090, -6220, -6525, -6819, -7124, -7433, -7732, -8009, -8253, -8461, -8636, -8778, -8860, -8916, -8982, -9041, -9080, -9102, -9014, -9440, -9645, -9292, -9060, -8847, -8657, -8489, -8339, -8204, -8077, -7964, -7860, -7766, -7680, -7608, -7549, -7500, -7464, -7439, -7427, -7425, -7434, -7452, -7485, -7534, -7562, -7616, -7672, -7731, -7797, -7861, -7925, -7992, -8054, -8146, -7974, -9014, -9743, -7730, -7882, -7860, -7923, -7988, -8053, -8135, -8160, -8169, -8169, -8154, -8132, -8101, -8062, -8016, -7963, -7964, -7554, -9125, -13070, -11224, -9985, -8995, -8255, -7707, -7306, -7014, -6801, -6644, -6528, -6445, -6386, -6342, -6311, -6290, -6275, -6268, -6264, -6266, -6266, -6272, -6266, -6368, -6294, -6259, -6263, -6266, -6268, -6268, -6268, -6263, -6252, -6297, -5906, -7213, -25395, -8988, -5104, -3981, -3405, -3219, -3118, -3236, -3125, -2813, -2519, -2241, -1992, -1790, -1630, -1502, -1392, -1283, -1154, -1060, -594, 1343, 2296, 2996, 3648, 4390, 5236, 6105, 6898, 7565, 8128, 8647, 9193, 9779, 10371, 10923, 11412, 11840, 12243, 12647, 13066, 13493, 13884, 14319, 14652, 14891, 15207, 15517, 15835, 16134, 16420, 16683, 16929, 17168, 17401, 17635, 17856, 18066, 18265, 18450, 18628, 18806, 18952, 19228, 19522, 19576, 19664, 19753, 19848, 19946, 20047, 20144, 20237, 20328, 20413, 20494, 20574, 20648, 20717, 20781, 20841, 20897, 20948, 20993, 21037, 21077, 21110, 21142, 21166, 21186, 21202, 21218, 21228, 21235, 21237, 21239, 21233, 21232, 21179, 21338, 21764, 21016, 20983, 20943, 20924, 20911, 20895, 20884, 20855, 20821, 20782, 20738, 20692, 20639, 20585, 20526, 20464, 20306, 20724, 18611, 3552, 2516, 1556, -871, -3312, -4752, -4960, -4518, -4288, -4761, -5809, -6898, -7520, -7563, -7064, -7651, -8118, -6695, -7471, -8144, -8640, -8861, -8948, -9019, -9218, -9459, -9621, -9687, -9680, -9679, -9751, -9904, -10095, -10258, -10352, -10383, -10344, -10326, -10396, -10514, -10634, -10715, -10764, -10719, -10692, -10745, -10791, -10838, -10871, -10889, -10898, -10906, -10916, -10934, -10950, -10961, -10962, -10958, -10956, -10954, -10956, -10959, -10959, -10956, -10950, -10943, -10936, -10930, -10925, -10921, -10911, -10900, -10891, -10876, -10862, -10852, -10836, -10816, -10827, -10686, -10583, -10810, -10773, -10753, -10722, -10687, -10650, -10609, -10571, -10535, -10499, -10459, -10420, -10380, -10342, -10300, -10257, -10207, -10205, -9966, -9434, -9604, -9702, -9769, -9807, -9821, -9815, -9796, -9769, -9733, -9693, -9650, -9605, -9559, -9509, -9460, -9408, -9357, -9307, -9254, -9201, -9149, -9097, -9034, -8989, -8940, -8885, -8831, -8777, -8721, -8667, -8611, -8555, -8559, -8117, -9532, -25865, -11508, -9193, -9273, -8727, -7325, -5556, -4219, -3767, -3961, -4181, -3920, -3084, -2016, -1173, -815, -870, -1027, -980, -675, 132};