/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0173 512 samples */
 
const int16_t AKWF_stereo_0173_512_DATA [512] = 
{964, 3541, 7143, 11368, 15653, 19447, 22383, 24275, 25209, 25400, 25160, 24870, 24894, 25405, 26380, 27571, 28577, 29030, 28681, 27429, 25211, 22174, 18645, 15038, 11833, 9364, 7653, 6529, 5761, 4980, 3804, 1993, -524, -3623, -6953, -10093, -12728, -14775, -16353, -17662, -18966, -20482, -22370, -24594, -26974, -29261, -31167, -32399, -32765, -32170, -30484, -27711, -24101, -20174, -16510, -13655, -11828, -10890, -10589, -10644, -10336, -9636, -9565, -9887, -10245, -10430, -10096, -8912, -6655, -3303, 1002, 5911, 10896, 15394, 18996, 21494, 22868, 23278, 22902, 21965, 20741, 19446, 18278, 17326, 16561, 15928, 15433, 15048, 14760, 14578, 14504, 14527, 14685, 15013, 15452, 15873, 16126, 15917, 14928, 12938, 9870, 5818, 1188, -3430, -7466, -10502, -12332, -12948, -12477, -11186, -9462, -7709, -6276, -5383, -5088, -5349, -6079, -7137, -8333, -9499, -10603, -11641, -12571, -13354, -13919, -14141, -13920, -13166, -11829, -9898, -7464, -4668, -1733, 1085, 3553, 5454, 6600, 6885, 6299, 4965, 3071, 877, -1328, -3281, -4763, -5621, -5715, -5052, -3790, -2117, -257, 1632, 3472, 5193, 6810, 8290, 9508, 10310, 10588, 10275, 9393, 7971, 6037, 3622, 895, -1962, -4641, -6835, -8356, -9154, -9215, -8468, -7395, -6259, -4819, -3021, -855, 1563, 4039, 6325, 8208, 9519, 10114, 9848, 8612, 6385, 3321, -211, -3710, -6614, -8507, -9172, -8567, -6789, -4068, -697, 2901, 6436, 9668, 12418, 14619, 16260, 17284, 17642, 17227, 15902, 13559, 10243, 6189, 1768, -2465, -5997, -8560, -10001, -10339, -9766, -8567, -7063, -5608, -4456, -3747, -3514, -3677, -4131, -4815, -5751, -7029, -8758, -10961, -13542, -16319, -19062, -21517, -23443, -24680, -25112, -24626, -23200, -20951, -18103, -15020, -12122, -9689, -7822, -6476, -5537, -4772, -4034, -2766, -819, 263, 421, 106, -454, -800, -404, -9450, -10860, -11152, -10387, -8741, -6536, -4014, -1386, 1281, 3939, 6537, 9055, 11509, 13886, 16205, 18351, 20187, 21494, 22131, 22369, 21334, 18390, 14085, 8924, 3774, -415, -2942, -3500, -2166, 499, 3604, 6231, 7686, 7670, 6338, 4168, 1706, -655, -2675, -4209, -5327, -6233, -7249, -8651, -10580, -12977, -15583, -18006, -19837, -20746, -20379, -18555, -15367, -11258, -6843, -2856, 88, 1686, 1825, 664, -1281, -3508, -5767, -7635, -8902, -9540, -9605, -9187, -8377, -7248, -5791, -3981, -1880, 371, 2548, 4386, 5641, 6213, 6066, 5169, 3582, 1508, -742, -2842, -4504, -5522, -5819, -5415, -4385, -2860, -979, 1100, 3228, 5286, 7189, 8807, 10055, 10864, 11156, 10810, 9688, 7695, 4928, 1676, -1599, -4375, -6118, -6549, -5208, -2084, 1234, 4282, 7083, 9531, 11691, 13587, 15218, 16490, 17285, 17484, 16957, 15589, 13338, 10342, 6862, 3369, 438, -1472, -1997, -942, 1606, 5277, 9534, 13809, 17528, 20232, 21598, 21479, 19840, 16787, 12693, 8047, 3307, -1149, -5085, -8396, -11039, -13027, -14464, -15380, -15804, -15665, -14831, -13294, -11115, -8491, -5799, -3613, -2465, -2730, -4555, -7790, -12075, -16957, -21839, -26176, -29483, -31567, -32354, -31945, -30587, -28506, -25952, -23037, -19690, -15893, -11767, -7657, -3940, -955, 1103, 2200, 2408, 1804, 492, -1328, -3387, -5392, -7017, -7920, -7936, -7031, -5220, -2616, 566, 4080, 7578, 10834, 13757, 16327, 18679, 20965, 23175, 25154, 26621, 27220, 26709, 25056, 22505, 19430, 16335, 13716, 11816, 10605, 9823, 9141, 8312, 7231, 5928, 4516, 3213, 2301, 1989, 2362, 3400, 4880, 6425, 7650, 8184, 7712, 6085, 3344, -384, -4811, -9433, -13694, -17074, -19151, -19846, -19350, -18130, -16761, -15720, -15168, -14989, -14852, -14281, -12994, -10376, -6467, -3444, -1850, -1606, -2740, -4852, -7357};