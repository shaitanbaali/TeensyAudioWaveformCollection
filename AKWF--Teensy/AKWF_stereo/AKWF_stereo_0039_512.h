/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0039 512 samples */
 
const int16_t AKWF_stereo_0039_512_DATA [512] = 
{760, 3242, 5627, 7956, 10236, 12469, 14642, 16721, 18694, 20540, 22232, 23768, 25157, 26398, 27511, 28498, 29360, 30113, 30767, 31341, 31840, 32228, 32498, 32668, 32753, 32765, 32695, 32526, 32248, 31871, 31424, 30936, 30422, 29893, 29338, 28742, 28103, 27422, 26696, 25932, 25126, 24290, 23443, 22591, 21738, 20890, 20056, 19250, 18466, 17698, 16956, 16248, 15580, 14958, 14395, 13897, 13464, 13078, 12740, 12463, 12240, 12063, 11921, 11806, 11718, 11650, 11599, 11582, 11620, 11719, 11897, 12164, 12508, 12906, 13344, 13819, 14333, 14882, 15453, 16041, 16637, 17233, 17826, 18390, 18909, 19360, 19717, 19966, 20099, 20130, 20097, 20022, 19903, 19739, 19556, 19372, 19189, 18980, 18727, 18431, 18101, 17741, 17347, 16926, 16478, 16005, 15508, 14998, 14476, 13938, 13388, 12828, 12263, 11682, 11084, 10479, 9886, 9307, 8720, 8112, 7488, 6854, 6205, 5540, 4861, 4179, 3531, 2931, 2372, 1834, 1299, 783, 290, -182, -637, -1085, -1537, -1983, -2420, -2858, -3295, -3714, -4095, -4425, -4710, -4958, -5180, -5380, -5569, -5752, -5930, -6078, -6185, -6261, -6316, -6357, -6378, -6395, -6440, -6554, -6750, -7011, -7328, -7681, -8063, -8488, -8970, -9499, -10071, -10679, -11312, -11968, -12629, -13290, -13958, -14676, -15486, -16374, -17310, -18279, -19280, -20295, -21317, -22340, -23362, -24383, -25416, -26444, -27438, -28376, -29237, -29998, -30651, -31161, -31547, -31881, -32155, -32366, -32507, -32563, -32534, -32432, -32249, -31971, -31619, -31213, -30763, -30248, -29679, -29119, -28599, -28121, -27683, -27282, -26935, -26665, -26488, -26405, -26417, -26523, -26715, -26980, -27315, -27711, -28138, -28575, -29002, -29412, -29788, -30117, -30377, -30550, -30616, -30546, -30349, -30039, -29624, -29114, -28509, -27816, -27042, -26207, -25304, -24259, -23054, -21705, -20223, -18612, -16887, -15047, -13071, -10966, -8753, -6446, -4076, -1615, 8595, 8406, 8259, 8092, 7850, 7521, 7094, 6601, 6099, 5591, 5042, 4440, 3822, 3219, 2635, 2050, 1458, 863, 275, -306, -899, -1505, -2122, -2761, -3433, -4114, -4796, -5464, -6102, -6718, -7320, -7911, -8466, -8967, -9424, -9827, -10174, -10447, -10613, -10668, -10606, -10410, -10072, -9563, -8866, -7972, -6900, -5709, -4440, -3089, -1665, -165, 1448, 3171, 4979, 6855, 8757, 10659, 12555, 14418, 16253, 18061, 19825, 21542, 23195, 24755, 26206, 27521, 28687, 29716, 30612, 31366, 31976, 32431, 32704, 32759, 32550, 32074, 31352, 30409, 29265, 27938, 26438, 24766, 22921, 20935, 18823, 16594, 14292, 11939, 9536, 7108, 4678, 2281, -75, -2389, -4665, -6892, -9056, -11151, -13082, -14829, -16497, -18141, -19753, -21287, -22715, -23999, -25088, -25949, -26583, -27001, -27236, -27319, -27263, -27092, -26826, -26468, -26024, -25513, -24940, -24300, -23611, -22901, -22179, -21443, -20696, -19889, -18995, -18030, -16992, -15888, -14760, -13639, -12537, -11466, -10419, -9381, -8344, -7323, -6352, -5461, -4643, -3896, -3197, -2524, -1893, -1282, -645, 55, 863, 1797, 2831, 3936, 5094, 6292, 7509, 8753, 10002, 11232, 12394, 13396, 14216, 14866, 15344, 15659, 15844, 15941, 15990, 15986, 15911, 15755, 15518, 15216, 14868, 14449, 13906, 13233, 12463, 11600, 10628, 9505, 8203, 6728, 5107, 3360, 1503, -425, -2399, -4389, -6353, -8264, -10097, -11760, -13242, -14581, -15751, -16771, -17652, -18410, -19073, -19664, -20199, -20665, -21034, -21290, -21406, -21392, -21249, -20963, -20517, -19907, -19154, -18279, -17283, -16149, -14856, -13421, -11873, -10241, -8530, -6772, -5045, -3388, -1817, -346, 1022, 2291, 3452, 4504, 5452, 6311, 7114, 7864, 8545, 9174, 9768, 10317, 10810, 11224, 11542, 11760, 11865, 11855, 11756, 11597, 11410, 11211, 10987, 10740, 10460, 10140, 9794, 9453, 9127, 8826};