/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_stereo_0087 512 samples */
 
const int16_t AKWF_stereo_0087_512_DATA [512] = 
{301, 759, 1209, 1665, 2124, 2587, 3055, 3525, 3996, 4470, 4947, 5428, 5902, 6397, 6785, 7158, 7584, 8037, 8499, 8977, 9458, 9940, 10424, 10908, 11392, 11870, 12341, 12838, 13650, 14349, 14941, 15469, 15961, 16417, 16857, 17289, 17709, 18125, 18538, 18953, 19364, 19777, 20193, 20605, 21025, 21445, 21864, 22289, 22714, 23144, 23571, 24001, 24439, 24872, 25314, 25751, 26191, 26636, 27071, 27516, 27958, 28410, 28852, 29316, 29850, 30308, 30747, 31159, 31540, 32085, 32040, 30993, 30337, 29743, 29230, 28736, 28259, 27806, 27358, 26925, 26496, 26058, 25624, 25183, 24745, 24307, 23862, 23403, 22926, 22436, 21930, 21414, 20885, 20341, 19790, 19221, 18639, 18045, 17439, 16825, 16204, 15575, 14936, 14296, 13652, 13002, 12353, 11704, 11056, 10410, 9766, 9128, 8493, 7866, 7202, 6552, 5925, 5312, 4712, 4122, 3541, 2971, 2406, 1847, 1295, 747, 198, -314, -722, -1186, -1677, -2189, -2715, -3251, -3796, -4342, -4894, -5451, -6008, -6572, -7139, -7705, -8278, -8857, -9433, -10017, -10601, -11186, -11779, -12372, -12967, -13566, -14163, -14762, -15364, -15964, -16563, -17165, -17767, -18364, -18963, -19559, -20153, -20745, -21333, -21919, -22507, -23085, -23675, -24215, -24982, -25883, -26604, -27263, -27877, -28447, -29005, -29542, -30072, -30601, -31111, -31642, -32148, -32728, -32038, -31220, -30667, -30192, -29753, -29357, -28977, -28620, -28280, -27945, -27620, -27283, -26950, -26622, -26293, -25970, -25627, -25277, -24915, -24536, -24144, -23732, -23381, -23008, -22563, -22078, -21568, -21060, -20552, -20050, -19567, -19074, -18569, -18052, -17523, -16989, -16453, -15912, -15373, -14839, -14306, -13776, -13260, -12724, -12166, -11637, -11121, -10625, -10138, -9661, -9195, -8734, -8280, -7834, -7395, -6959, -6528, -6098, -5676, -5254, -4832, -4411, -3992, -3570, -3150, -2727, -2302, -1872, -1442, -1009, -575, -133, 932, 1395, 1848, 2303, 2756, 3211, 3667, 4123, 4576, 5030, 5485, 5940, 6395, 6848, 7313, 7779, 8237, 8694, 9149, 9602, 10056, 10507, 10956, 11410, 11859, 12308, 12760, 13206, 13620, 14044, 14479, 14920, 15366, 15813, 16262, 16714, 17164, 17616, 18068, 18518, 18969, 19419, 19870, 20318, 20769, 21218, 21666, 22117, 22563, 23013, 23461, 23907, 24357, 24802, 25250, 25697, 26142, 26590, 27036, 27484, 27927, 28378, 28817, 29279, 29811, 30267, 30695, 31097, 31479, 31975, 32077, 31481, 31096, 30644, 30107, 29482, 28841, 28248, 27702, 27184, 26645, 26056, 25439, 24816, 24222, 23663, 23122, 22572, 21997, 21404, 20803, 20213, 19636, 19069, 18504, 17927, 17341, 16751, 16163, 15582, 15006, 14432, 13852, 13268, 12684, 12097, 11515, 10935, 10360, 9781, 9200, 8619, 8039, 7460, 6886, 6315, 5742, 5166, 4591, 4014, 3440, 2868, 2295, 1722, 1150, 577, 8, -564, -1149, -1725, -2299, -2871, -3441, -4009, -4579, -5147, -5712, -6280, -6846, -7413, -7981, -8546, -9113, -9681, -10247, -10816, -11381, -11947, -12516, -13082, -13649, -14215, -14782, -15348, -15917, -16483, -17048, -17616, -18180, -18744, -19311, -19875, -20442, -21006, -21569, -22132, -22698, -23260, -23822, -24390, -24929, -25458, -26003, -26552, -27111, -27668, -28231, -28792, -29356, -29921, -30478, -31047, -31600, -32201, -31932, -31551, -31259, -30881, -30398, -29876, -29369, -28923, -28518, -28111, -27671, -27179, -26670, -26178, -25717, -25290, -24860, -24417, -23951, -23468, -22990, -22513, -22126, -21734, -21274, -20774, -20256, -19750, -19261, -18794, -18340, -17887, -17431, -16969, -16500, -16032, -15565, -15098, -14633, -14168, -13701, -13234, -12770, -12310, -11854, -11394, -10934, -10475, -10012, -9550, -9091, -8632, -8173, -7715, -7257, -6799, -6342, -5884, -5429, -4974, -4517, -4061, -3607, -3151, -2696, -2242, -1786, -1331, -877, -422, 29, 488};