/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0796 256 samples */
 
const int16_t AKWF_0796_256_DATA [256] = 
{214, 678, 1115, 1536, 1941, 2331, 2708, 3070, 3468, 3580, 6577, 9940, 12112, 14314, 16409, 18403, 20279, 22031, 23643, 25103, 26413, 27568, 28560, 29401, 30090, 30629, 31026, 31289, 31423, 31436, 31334, 31133, 30834, 30447, 29983, 29447, 28848, 28195, 27493, 26751, 25970, 25157, 24317, 23452, 22564, 21659, 20736, 19795, 18841, 17871, 16886, 15889, 14878, 13852, 12815, 11760, 10696, 9622, 8535, 7441, 6343, 5239, 4135, 3036, 1940, 856, -214, -1267, -2297, -3301, -4274, -5207, -6104, -6955, -7755, -8503, -9195, -9824, -10391, -10890, -11319, -11677, -11962, -12172, -12307, -12365, -12345, -12251, -12078, -11833, -11515, -11125, -10666, -10140, -9550, -8900, -8190, -7429, -6618, -5757, -4857, -3917, -2942, -1939, -912, 139, 1203, 2284, 3371, 4459, 5551, 6636, 7712, 8780, 9832, 10862, 11871, 12857, 13811, 14735, 15626, 16477, 17293, 18065, 18791, 19474, 20106, 20688, 21217, 21693, 22114, 22477, 22781, 23026, 23212, 23334, 23394, 23392, 23328, 23199, 23006, 22749, 22429, 22045, 21601, 21092, 20523, 19895, 19206, 18461, 17661, 16805, 15899, 14944, 13937, 12887, 11797, 10663, 9493, 8290, 7052, 5790, 4501, 3187, 1861, 517, -840, -2203, -3572, -4944, -6309, -7673, -9028, -10368, -11695, -13002, -14284, -15546, -16780, -17979, -19147, -20281, -21372, -22427, -23436, -24401, -25320, -26191, -27009, -27779, -28494, -29155, -29764, -30315, -30812, -31253, -31637, -31964, -32236, -32451, -32610, -32716, -32765, -32759, -32704, -32595, -32436, -32227, -31973, -31671, -31322, -30933, -30501, -30029, -29522, -28976, -28400, -27789, -27148, -26481, -25788, -25072, -24335, -23578, -22805, -22016, -21216, -20402, -19584, -18757, -17923, -17091, -16257, -15422, -14592, -13766, -12947, -12136, -11334, -10543, -9766, -9002, -8252, -7522, -6807, -6109, -5434, -4775, -4139, -3523, -2925, -2350, -1796, -1263, -750, -248};