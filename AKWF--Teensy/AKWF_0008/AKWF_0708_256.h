/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0708 256 samples */
 
const int16_t AKWF_0708_256_DATA [256] = 
{1393, 6373, 10640, 13954, 16105, 17051, 16895, 15841, 14149, 12082, 9889, 7750, 5808, 4158, 2840, 1878, 1273, 1005, 1058, 1407, 2031, 2904, 4000, 5299, 6765, 8361, 10042, 11740, 13380, 14882, 16153, 17124, 17754, 18042, 18058, 17930, 17846, 18020, 18652, 19873, 21709, 24048, 26635, 29140, 31192, 32463, 32738, 31936, 30123, 27473, 24240, 20704, 17103, 13660, 10531, 7798, 5519, 3698, 2305, 1305, 643, 250, 61, 3, -1, -29, -153, -451, -991, -1841, -3061, -4695, -6781, -9326, -12291, -15620, -19176, -22765, -26163, -29093, -31283, -32530, -32709, -31841, -30082, -27724, -25130, -22647, -20577, -19092, -18220, -17875, -17878, -18011, -18077, -17916, -17435, -16606, -15455, -14040, -12450, -10767, -9069, -7433, -5906, -4531, -3347, -2377, -1645, -1177, -995, -1124, -1584, -2395, -3563, -5074, -6903, -8971, -11161, -13309, -15190, -16546, -17112, -16653, -15016, -12171, -8264, -3583, 1464, 6390, 10748, 14179, 16450, 17507, 17423, 16373, 14586, 12290, 9704, 6978, 4235, 1553, -1038, -3515, -5860, -8082, -10161, -12079, -13824, -15363, -16669, -17717, -18483, -18960, -19161, -19115, -18877, -18521, -18132, -17790, -17552, -17439, -17410, -17368, -17158, -16597, -15516, -13814, -11484, -8658, -5606, -2660, -191, 1477, 2147, 1753, 389, -1744, -4365, -7159, -9853, -12198, -14013, -15190, -15664, -15426, -14502, -12949, -10850, -8293, -5400, -2286, 924, 4090, 7093, 9809, 12112, 13909, 15108, 15642, 15471, 14587, 13034, 10894, 8321, 5540, 2806, 431, -1286, -2110, -1891, -629, 1536, 4324, 7374, 10337, 12899, 14873, 16211, 16973, 17308, 17401, 17420, 17489, 17673, 17977, 18354, 18736, 19032, 19167, 19075, 18718, 18074, 17144, 15946, 14500, 12838, 10992, 8976, 6813, 4523, 2097, -447, -3091, -5818, -8562, -11223, -13666, -15695, -17086, -17605, -17047, -15291, -12339, -8353, -3522};