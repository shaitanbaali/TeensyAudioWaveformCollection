/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0714 256 samples */
 
const int16_t AKWF_0714_256_DATA [256] = 
{11616, 17596, 19888, 23074, 26307, 29240, 32503, 32615, 32204, 32011, 31682, 31457, 31150, 30885, 30625, 30317, 30081, 29771, 29514, 29235, 28945, 28693, 28388, 28135, 27845, 27566, 27302, 27004, 26748, 26454, 26183, 25910, 25619, 25359, 25065, 24799, 24518, 24234, 23969, 23675, 23415, 23127, 22853, 22580, 22291, 22028, 21738, 21468, 21191, 20909, 20643, 20353, 20087, 19804, 19528, 19258, 18971, 18706, 18421, 18148, 17875, 17591, 17326, 17041, 16772, 16494, 16214, 15950, 15660, 15398, 15118, 14831, 14590, 14135, 14611, 9027, -234, -1314, -1511, -2009, -2448, -2863, -3302, -3728, -4154, -4587, -5008, -5441, -5864, -6290, -6721, -7143, -7572, -7994, -8420, -8846, -9269, -9697, -10117, -10545, -10967, -11390, -11818, -12236, -12662, -13083, -13506, -13929, -14350, -14774, -15194, -15618, -16038, -16457, -16882, -17299, -17723, -18144, -18550, -19019, -19223, -19031, -18903, -18758, -18619, -18478, -18334, -18195, -18051, -17911, -17770, -17626, -17486, -17343, -17202, -17060, -16917, -16777, -16633, -16492, -16349, -16207, -16066, -15922, -15783, -15639, -15498, -15357, -15213, -15074, -14930, -14790, -14647, -14505, -14365, -14220, -14082, -13937, -13797, -13657, -13513, -13376, -13230, -13091, -12949, -12806, -12668, -12523, -12387, -12242, -12102, -11963, -11817, -11683, -11536, -11399, -11258, -11114, -10978, -10832, -10696, -10554, -10414, -10276, -10130, -9997, -9850, -9714, -9574, -9429, -9297, -9149, -9014, -8874, -8730, -8598, -8450, -8318, -8173, -8035, -7900, -7750, -7623, -7473, -7340, -7202, -7056, -6927, -6776, -6648, -6503, -6363, -6232, -6081, -5957, -5807, -5673, -5537, -5386, -5264, -5111, -4985, -4843, -4698, -4575, -4417, -4298, -4146, -4011, -3883, -3724, -3613, -3452, -3328, -3191, -3037, -2929, -2756, -2650, -2496, -2354, -2246, -2062, -1975, -1798, -1676, -1560, -1364, -1313, -1089, -1008, -887, -627, -736, -194, -1051};