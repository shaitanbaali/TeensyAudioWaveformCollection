/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0780 256 samples */
 
const int16_t AKWF_0780_256_DATA [256] = 
{1248, 4007, 6423, 8596, 10539, 12294, 13877, 15308, 16605, 17789, 18864, 19851, 20752, 21578, 22340, 23044, 23691, 24292, 24848, 25364, 25845, 26292, 26709, 27098, 27464, 27804, 28124, 28424, 28707, 28972, 29222, 29458, 29681, 29891, 30090, 30278, 30455, 30625, 30785, 30938, 31082, 31220, 31350, 31475, 31595, 31707, 31811, 31901, 31976, 32040, 32093, 32139, 32178, 32211, 32239, 32262, 32282, 32298, 32311, 32323, 32333, 32340, 32346, 32350, 32354, 32356, 32355, 32355, 32356, 32354, 32351, 32349, 32346, 32342, 32337, 32333, 32328, 32323, 32318, 32312, 32307, 32301, 32295, 32288, 32281, 32275, 32268, 32261, 32253, 32247, 32240, 32232, 32225, 32217, 32210, 32202, 32194, 32187, 32179, 32171, 32164, 32155, 32147, 32140, 32132, 32124, 32116, 32108, 32099, 32091, 32082, 32075, 32067, 32058, 32050, 32042, 32033, 32025, 32017, 32009, 32000, 31992, 31983, 31976, 31966, 31695, 32980, 28213, -29021, -33786, -32496, -32765, -32767, -32768, -32767, -32767, -32767, -32765, -32762, -32759, -32755, -32750, -32746, -32741, -32735, -32729, -32722, -32716, -32710, -32703, -32695, -32688, -32680, -32672, -32664, -32656, -32648, -32640, -32631, -32621, -32613, -32605, -32595, -32587, -32577, -32566, -32557, -32547, -32537, -32527, -32517, -32507, -32496, -32485, -32475, -32464, -32452, -32440, -32429, -32417, -32405, -32393, -32379, -32366, -32352, -32338, -32323, -32308, -32292, -32275, -32257, -32239, -32219, -32198, -32176, -32152, -32127, -32099, -32070, -32038, -32003, -31964, -31921, -31874, -31821, -31761, -31694, -31619, -31532, -31433, -31318, -31191, -31058, -30921, -30776, -30625, -30468, -30303, -30131, -29950, -29761, -29562, -29353, -29133, -28900, -28656, -28399, -28125, -27837, -27530, -27206, -26861, -26493, -26103, -25685, -25238, -24760, -24250, -23700, -23108, -22472, -21783, -21037, -20231, -19351, -18397, -17355, -16210, -14958, -13583, -12060, -10379, -8517, -6442, -4137, -1495};