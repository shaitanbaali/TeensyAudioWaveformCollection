/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0756 256 samples */
 
const int16_t AKWF_0756_256_DATA [256] = 
{11699, 15977, 11984, 13769, 14523, 1227, -16738, -14153, -13810, -12850, -13392, -12775, -12294, -12164, -12117, -12141, -12190, -12253, -12311, -12349, -12349, -12308, -12249, -12235, -12314, -12094, -13157, -6214, 16691, 14650, 12145, 13976, 14119, 14280, 14426, 14630, 14856, 15103, 15356, 15604, 15834, 16025, 16150, 16166, 16009, 15596, 14867, 13874, 12779, 11802, 11120, 10793, 10786, 11062, 11567, 12261, 13099, 14044, 15060, 16119, 17203, 18296, 19385, 20466, 21541, 22591, 23610, 24594, 25547, 26454, 27313, 28127, 28891, 29598, 30237, 30819, 31330, 31770, 32138, 32424, 32625, 32738, 32757, 32681, 32514, 32257, 31918, 31497, 31001, 30436, 29800, 29094, 28326, 27498, 26619, 25681, 24690, 23650, 22561, 21430, 20263, 19058, 17820, 16568, 15279, 13982, 12681, 11392, 10132, 8957, 7898, 7005, 6377, 6107, 6223, 6569, 6923, 7167, 7283, 7290, 7223, 7107, 6951, 6765, 6557, 6329, 6087, 5828, 5559, 5279, 4993, 4698, 4399, 4095, 3788, 3476, 3168, 2860, 2557, 2265, 1995, 1761, 1586, 1500, 1548, 1787, 2294, 3139, 4353, 5855, 7388, 8600, 8914, 2397, -7987, -9305, -7731, -6448, -4843, -3515, -2540, -1927, -1600, -1496, -1543, -1692, -1909, -2168, -2453, -2753, -3058, -3368, -3679, -3986, -4292, -4594, -4891, -5181, -5463, -5736, -6000, -6249, -6481, -6699, -6894, -7060, -7192, -7279, -7298, -7219, -7013, -6683, -6307, -6094, -6258, -6826, -7695, -8758, -9952, -11229, -12558, -13901, -15239, -16572, -17888, -19178, -20434, -21659, -22840, -23983, -25073, -26110, -27093, -28015, -28870, -29665, -30381, -31013, -31562, -32020, -32374, -32622, -32751, -32753, -32624, -32369, -31991, -31492, -30881, -30152, -29311, -28365, -27311, -26153, -24898, -23554, -22119, -20612, -19038, -17418, -15797, -14195, -12718, -11527, -10819, -10836, -11868, -13780, -15528, -16219, -16119, -15709, -15176, -14502, -14528, -11247};