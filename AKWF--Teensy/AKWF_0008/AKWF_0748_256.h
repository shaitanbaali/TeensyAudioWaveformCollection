/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0748 256 samples */
 
const int16_t AKWF_0748_256_DATA [256] = 
{1179, 3119, 4934, 6672, 8324, 9895, 11387, 12796, 14133, 15406, 16620, 17796, 18941, 20055, 21142, 22191, 23200, 24169, 25088, 25922, 26643, 27240, 27716, 28077, 28317, 28440, 28454, 28375, 28219, 28002, 27733, 27420, 27067, 26681, 26264, 25816, 25343, 24842, 24316, 23770, 23200, 22606, 21996, 21368, 20723, 20066, 19394, 18712, 18026, 17329, 16629, 15934, 15202, 15101, 15722, 16129, 16494, 16836, 17171, 17500, 17825, 18144, 18449, 18739, 19005, 19242, 19446, 19615, 19748, 19842, 19898, 19918, 19903, 19854, 19776, 19666, 19527, 19352, 19140, 18865, 18594, 17883, 15785, 13740, 11785, 9798, 7766, 5664, 3502, 1305, -916, -3131, -5319, -7467, -9540, -11526, -13420, -15206, -16893, -18485, -19980, -21391, -22721, -23962, -25116, -26171, -27104, -27904, -28556, -29042, -29357, -29487, -29425, -29189, -28805, -28299, -27717, -26662, -24791, -22593, -20388, -18192, -16024, -13903, -11836, -9817, -7859, -5960, -4116, -2338, -622, 1030, 2610, 4117, 5552, 6899, 8159, 9328, 10395, 11362, 12227, 12990, 13658, 14236, 14779, 14794, 13887, 13105, 12357, 11615, 10876, 10134, 9394, 8654, 7914, 7178, 6447, 5719, 4999, 4286, 3579, 2882, 2193, 1511, 841, 181, -466, -1100, -1715, -2309, -2870, -3396, -3871, -4281, -4620, -4888, -5089, -5228, -5310, -5337, -5331, -5326, -5348, -5404, -5489, -5604, -5755, -5938, -6145, -6361, -6573, -6771, -6946, -7096, -7218, -7311, -7376, -7412, -7421, -7405, -7365, -7302, -7220, -7118, -6998, -6861, -6710, -6547, -6346, -6437, -7306, -8572, -9868, -11188, -12513, -13847, -15181, -16511, -17843, -19166, -20482, -21794, -23091, -24364, -25607, -26795, -27921, -28967, -29909, -30740, -31441, -32001, -32412, -32668, -32769, -32721, -32528, -32198, -31735, -31147, -30444, -29625, -28701, -27666, -26625, -24923, -21998, -19316, -16755, -14268, -11841, -9485, -7202, -4988, -2852, -755};