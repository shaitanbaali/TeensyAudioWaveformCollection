/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0798 256 samples */
 
const int16_t AKWF_0798_256_DATA [256] = 
{1037, 3684, 6338, 9008, 11651, 14232, 16712, 19043, 21198, 23144, 24846, 26288, 27451, 28319, 28890, 29162, 29142, 28836, 28263, 27445, 26401, 25159, 23751, 22200, 20543, 18811, 17026, 15223, 13428, 11657, 9940, 8287, 6710, 5226, 3835, 2539, 1343, 241, -776, -1710, -2574, -3380, -4134, -4851, -5541, -6212, -6876, -7539, -8204, -8881, -9567, -10260, -10965, -11672, -12375, -13071, -13748, -14397, -15011, -15577, -16084, -16525, -16889, -17168, -17356, -17447, -17438, -17325, -17110, -16793, -16376, -15869, -15273, -14596, -13850, -13044, -12185, -11291, -10366, -9423, -8478, -7533, -6603, -5698, -4820, -3977, -3180, -2425, -1718, -1063, -456, 100, 608, 1073, 1495, 1879, 2229, 2549, 2842, 3115, 3370, 3609, 3839, 4059, 4272, 4480, 4682, 4881, 5074, 5260, 5438, 5608, 5766, 5911, 6037, 6142, 6247, 5899, 4336, 1893, -861, -3739, -6693, -9667, -12620, -15517, -18302, -20934, -23380, -25592, -27544, -29213, -30570, -31608, -32318, -32698, -32754, -32497, -31944, -31116, -30038, -28744, -27258, -25615, -23856, -22002, -20092, -18161, -16226, -14321, -12468, -10678, -8971, -7358, -5839, -4423, -3107, -1885, -754, 296, 1280, 2203, 3080, 3928, 4750, 5562, 6376, 7194, 8027, 8877, 9742, 10629, 11530, 12439, 13353, 14261, 15151, 16018, 16846, 17622, 18338, 18980, 19536, 20001, 20363, 20616, 20757, 20781, 20689, 20481, 20161, 19734, 19205, 18587, 17884, 17108, 16275, 15392, 14471, 13529, 12573, 11615, 10669, 9740, 8837, 7971, 7143, 6359, 5624, 4935, 4296, 3705, 3160, 2659, 2199, 1772, 1378, 1013, 667, 341, 28, -274, -569, -859, -1148, -1435, -1721, -2007, -2291, -2570, -2846, -3113, -3370, -3615, -3845, -4056, -4247, -4415, -4556, -4672, -4759, -4819, -4850, -4853, -4830, -4782, -4711, -4620, -4512, -4389, -4257, -4115, -3967, -3837, -3190, -1334};