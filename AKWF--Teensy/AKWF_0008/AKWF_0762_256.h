/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0762 256 samples */
 
const int16_t AKWF_0762_256_DATA [256] = 
{32, 88, 138, 186, 231, 273, 312, 349, 384, 417, 447, 476, 503, 528, 552, 574, 595, 615, 634, 650, 667, 683, 697, 710, 723, 735, 746, 756, 766, 775, 784, 792, 799, 806, 813, 819, 825, 832, 841, 856, 879, 920, 982, 1075, 1205, 1379, 1604, 1878, 2195, 2547, 2920, 3302, 3683, 4053, 4402, 4725, 5010, 5249, 5437, 5570, 5652, 5693, 5703, 5699, 5691, 5692, 5708, 5742, 5794, 5860, 5933, 6005, 6066, 6110, 6128, 6118, 6074, 6002, 5907, 5794, 5666, 5524, 5368, 5192, 4992, 4764, 4507, 4223, 3916, 3595, 3265, 2942, 2632, 2347, 2098, 1893, 1742, 1653, 1631, 1683, 1816, 2030, 2329, 2711, 3179, 3729, 4356, 5058, 5833, 6675, 7581, 8546, 9564, 10637, 11758, 12921, 14129, 15373, 16644, 17943, 19253, 20563, 21863, 23134, 24363, 25540, 26647, 27676, 28620, 29467, 30208, 30827, 31305, 31626, 31775, 31744, 31534, 31152, 30610, 29926, 29115, 28196, 27181, 26082, 24912, 23674, 22377, 21033, 19637, 18199, 16724, 15209, 13662, 12088, 10481, 8848, 7194, 5512, 3813, 2094, 353, -1401, -3172, -4963, -6761, -8572, -10395, -12212, -14025, -15821, -17579, -19295, -20950, -22525, -24016, -25409, -26689, -27857, -28904, -29823, -30618, -31286, -31826, -32244, -32537, -32711, -32769, -32717, -32556, -32292, -31930, -31474, -30927, -30297, -29587, -28803, -27955, -27049, -26094, -25104, -24085, -23048, -22007, -20966, -19934, -18920, -17926, -16958, -16021, -15116, -14244, -13410, -12610, -11847, -11122, -10430, -9774, -9153, -8563, -8006, -7479, -6981, -6511, -6068, -5650, -5257, -4886, -4536, -4208, -3899, -3608, -3335, -3077, -2835, -2608, -2394, -2192, -2004, -1826, -1659, -1503, -1355, -1216, -1087, -965, -850, -742, -641, -545, -456, -372, -294, -220, -150, -84, -22};