/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0777 256 samples */
 
const int16_t AKWF_0777_256_DATA [256] = 
{414, 1235, 2033, 2822, 3598, 4361, 5108, 5836, 6547, 7241, 7917, 8578, 9223, 9853, 10473, 11085, 11688, 12285, 12880, 13472, 14065, 14659, 15253, 15854, 16456, 17062, 17677, 18296, 18923, 19562, 20214, 20885, 21579, 22297, 23036, 23797, 24575, 25371, 26184, 27008, 27842, 28680, 29503, 30258, 30886, 31380, 31776, 32121, 32424, 32651, 32761, 32743, 32627, 32452, 32248, 32012, 31738, 31422, 31075, 30721, 30374, 30034, 29701, 29368, 29036, 28717, 28418, 28137, 27878, 27637, 27413, 27213, 27037, 26891, 26769, 26675, 26603, 26552, 26520, 26502, 26497, 26495, 26491, 26476, 26443, 26388, 26303, 26181, 26019, 25810, 25549, 25237, 24874, 24456, 23988, 23473, 22912, 22312, 21678, 21012, 20325, 19619, 18899, 18174, 17443, 16712, 15987, 15265, 14547, 13838, 13132, 12430, 11731, 11032, 10332, 9628, 8913, 8191, 7461, 6715, 5959, 5191, 4408, 3617, 2817, 2008, 1197, 384, -429, -1234, -2034, -2825, -3602, -4364, -5110, -5839, -6549, -7244, -7920, -8579, -9225, -9855, -10476, -11087, -11688, -12287, -12882, -13473, -14067, -14661, -15256, -15854, -16457, -17063, -17678, -18296, -18924, -19562, -20214, -20886, -21579, -22296, -23035, -23797, -24572, -25369, -26181, -27006, -27840, -28677, -29501, -30255, -30883, -31377, -31774, -32119, -32423, -32649, -32758, -32741, -32626, -32451, -32245, -32012, -31737, -31421, -31075, -30720, -30373, -30033, -29699, -29366, -29036, -28717, -28415, -28136, -27877, -27635, -27413, -27211, -27036, -26888, -26768, -26673, -26600, -26550, -26517, -26501, -26495, -26493, -26489, -26473, -26442, -26387, -26303, -26182, -26019, -25809, -25549, -25238, -24875, -24457, -23991, -23476, -22913, -22315, -21681, -21015, -20328, -19621, -18902, -18175, -17446, -16715, -15990, -15266, -14549, -13840, -13133, -12432, -11734, -11035, -10334, -9629, -8916, -8194, -7463, -6719, -5962, -5194, -4412, -3621, -2820, -2014, -1204, -376};