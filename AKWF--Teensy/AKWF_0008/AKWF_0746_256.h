/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0746 256 samples */
 
const int16_t AKWF_0746_256_DATA [256] = 
{724, 2534, 4298, 6025, 7680, 9245, 10707, 12049, 13267, 14355, 15301, 16104, 16759, 17265, 17625, 17847, 17945, 17934, 17840, 17692, 17520, 17354, 17226, 17161, 17180, 17323, 17439, 17675, 18124, 18637, 19242, 19928, 20698, 21542, 22453, 23425, 24439, 25476, 26513, 27513, 28439, 29251, 29898, 30342, 30549, 30487, 30147, 29530, 28660, 27566, 26305, 24943, 23541, 22181, 20929, 19839, 18963, 18332, 17961, 17841, 17960, 18284, 18775, 19388, 20079, 20802, 21522, 22207, 22830, 23371, 23818, 24158, 24384, 24490, 24471, 24321, 24036, 23619, 23069, 22397, 21616, 20738, 19815, 18749, 17608, 16613, 15621, 14679, 13811, 13040, 12373, 11826, 11393, 11078, 10881, 10795, 10819, 10941, 11160, 11461, 11832, 12247, 12686, 13114, 13488, 13766, 13904, 13859, 13594, 13083, 12310, 11277, 10009, 8534, 6908, 5196, 3461, 1779, 221, -1161, -2315, -3211, -3839, -4200, -4311, -4206, -3926, -3510, -3009, -2464, -1914, -1391, -922, -525, -216, -5, 98, 89, -38, -291, -671, -1178, -1812, -2565, -3419, -4363, -5369, -6405, -7451, -8468, -9422, -10297, -11064, -11707, -12219, -12585, -12825, -13092, -13091, -13146, -13014, -12778, -12502, -12183, -11836, -11474, -11126, -10823, -10600, -10500, -10565, -10838, -11353, -12132, -13188, -14541, -16041, -17692, -19631, -21611, -23597, -25511, -27282, -28860, -30191, -31249, -32024, -32513, -32760, -32635, -32324, -31953, -31432, -30829, -30185, -29531, -28899, -28309, -27777, -27320, -26947, -26663, -26478, -26400, -26434, -26576, -26658, -26963, -27360, -27796, -28258, -28721, -29156, -29535, -29833, -30022, -30083, -30005, -29777, -29395, -28860, -28173, -27344, -26379, -25282, -24067, -22742, -21317, -19818, -18260, -16673, -15099, -13571, -12149, -10700, -9512, -8583, -7863, -7383, -7142, -7125, -7295, -7610, -8004, -8413, -8764, -8996, -9048, -8876, -8453, -7764, -6818, -5634, -4241, -2690, -981};