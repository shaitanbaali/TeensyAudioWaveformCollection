/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0761 256 samples */
 
const int16_t AKWF_0761_256_DATA [256] = 
{2295, 6009, 9513, 12811, 15821, 18493, 20786, 22671, 24152, 25242, 25961, 26347, 26436, 26272, 25891, 25335, 24640, 23833, 22945, 22000, 21015, 20010, 18999, 17990, 16994, 16020, 15069, 14149, 13263, 12408, 11590, 10810, 10064, 9356, 8683, 8043, 7438, 6865, 6323, 5813, 5330, 4874, 4445, 4040, 3658, 3301, 2962, 2644, 2345, 2063, 1799, 1550, 1316, 1096, 890, 696, 513, 343, 181, 30, -112, -245, -370, -488, -599, -703, -800, -892, -978, -1058, -1134, -1205, -1272, -1335, -1394, -1448, -1501, -1550, -1595, -1638, -1678, -1715, -1751, -1784, -1815, -1845, -1872, -1898, -1922, -1945, -1966, -1986, -2004, -2022, -2038, -2054, -2068, -2082, -2094, -2106, -2117, -2127, -2137, -2146, -2154, -2163, -2170, -2177, -2183, -2189, -2195, -2200, -2205, -2210, -2214, -2217, -2222, -2224, -2228, -2231, -2233, -2236, -2239, -2241, -2243, -2244, -2246, -2248, -2250, -2251, -2252, -2253, -2254, -2254, -2255, -2256, -2256, -2256, -2258, -2259, -2259, -2260, -2259, -2259, -2259, -2259, -2259, -2259, -2259, -2259, -2259, -2259, -2259, -2260, -2259, -2258, -2258, -2259, -2258, -2256, -2257, -2256, -2255, -2256, -2255, -2254, -2254, -2253, -2254, -2253, -2253, -2252, -2251, -2251, -2250, -2250, -2249, -2249, -2249, -2248, -2247, -2246, -2246, -2246, -2245, -2245, -2244, -2243, -2243, -2243, -2242, -2241, -2240, -2233, -2212, -2158, -2046, -1842, -1507, -1018, -359, 464, 1434, 2532, 3734, 5015, 6355, 7712, 9034, 10272, 11374, 12297, 13016, 13516, 13793, 13852, 13695, 13317, 12707, 11850, 10723, 9301, 7569, 5513, 3128, 446, -2503, -5665, -8952, -12292, -15597, -18764, -21726, -24409, -26749, -28719, -30301, -31483, -32279, -32696, -32754, -32480, -31897, -31033, -29906, -28531, -26922, -25068, -22970, -20617, -17989, -15096, -11949, -8576, -5035, -1306};