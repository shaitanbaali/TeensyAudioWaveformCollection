/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0774 256 samples */
 
const int16_t AKWF_0774_256_DATA [256] = 
{546, 3401, 7967, 12257, 15080, 16936, 18444, 19728, 20723, 21336, 21510, 21305, 20915, 20590, 20496, 20717, 21387, 22625, 24279, 25958, 27335, 28262, 28706, 28612, 27943, 26971, 26241, 26026, 26104, 26083, 25695, 24818, 23448, 21644, 19479, 17032, 14431, 11840, 9459, 7456, 5864, 4625, 3658, 2912, 2401, 2170, 2227, 2517, 3012, 3758, 4590, 4755, 2381, -4706, -14955, -23999, -29472, -31571, -31383, -29935, -27968, -25939, -24139, -22756, -21903, -21625, -21879, -22552, -23473, -24465, -25362, -26024, -26347, -26269, -25797, -24980, -23845, -22386, -20597, -18508, -15976, -12546, -7939, -2914, 939, 2648, 2423, 942, -1013, -2612, -3267, -2824, -1499, 383, 2558, 4851, 7090, 8947, 9789, 9011, 6758, 4047, 2215, 2191, 3821, 6114, 8130, 9476, 10267, 10826, 11368, 11934, 12651, 13770, 14996, 14946, 11041, 2625, -6585, -13206, -16626, -17613, -17113, -15834, -14206, -12440, -10660, -9015, -7528, -5272, -2103, 393, 1502, 1900, 2612, 4290, 6828, 9507, 11655, 13029, 13778, 14255, 14742, 15405, 16502, 18274, 20520, 22683, 24310, 25227, 25437, 24884, 23514, 21807, 20760, 20864, 21697, 22551, 22944, 22675, 21729, 20192, 18170, 15780, 13182, 10573, 8179, 6169, 4573, 3326, 2337, 1553, 1001, 739, 769, 1037, 1522, 2272, 3110, 3238, 632, -6827, -17155, -25904, -30970, -32720, -32286, -30693, -28663, -26635, -24893, -23610, -22884, -22745, -23132, -23923, -24948, -26038, -27043, -27836, -28325, -28457, -28225, -27655, -26764, -25542, -23996, -22154, -19972, -17288, -14088, -10782, -7997, -6072, -4940, -4401, -4226, -4118, -3831, -3302, -2637, -2008, -1558, -1368, -1480, -1931, -2802, -4154, -5857, -7581, -8915, -9514, -9195, -7974, -6098, -3873, -1398, 1447, 4667, 7974, 11354, 15092, 18436, 18780, 13859, 5983, -921, -5285, -7299, -7710, -7209, -6256, -5090, -3789, -2385, -915};