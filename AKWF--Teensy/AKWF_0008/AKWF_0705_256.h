/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0705 256 samples */
 
const int16_t AKWF_0705_256_DATA [256] = 
{2507, 6121, 9585, 12937, 16126, 19118, 21879, 24366, 26565, 28451, 30002, 31214, 32080, 32597, 32774, 32622, 32156, 31395, 30367, 29100, 27621, 25967, 24175, 22273, 20304, 18304, 16298, 14327, 12421, 10598, 8890, 7314, 5881, 4608, 3500, 2556, 1779, 1159, 688, 355, 141, 28, -2, 26, 93, 175, 250, 298, 299, 237, 97, -131, -459, -891, -1424, -2061, -2794, -3612, -4506, -5457, -6449, -7463, -8475, -9464, -10409, -11283, -12065, -12737, -13277, -13668, -13898, -13954, -13831, -13525, -13036, -12367, -11529, -10535, -9398, -8140, -6784, -5352, -3875, -2382, -898, 542, 1908, 3177, 4316, 5300, 6111, 6727, 7133, 7319, 7278, 7007, 6509, 5794, 4872, 3757, 2476, 1049, -498, -2127, -3813, -5522, -7210, -8851, -10408, -11842, -13130, -14239, -15142, -15821, -16256, -16435, -16349, -15996, -15379, -14502, -13380, -12034, -10475, -8740, -6855, -4846, -2755, -618, 1533, 3655, 5713, 7675, 9500, 11162, 12635, 13887, 14906, 15674, 16179, 16418, 16390, 16101, 15560, 14782, 13790, 12600, 11245, 9756, 8159, 6492, 4793, 3088, 1421, -175, -1675, -3044, -4256, -5291, -6126, -6749, -7152, -7324, -7268, -6987, -6490, -5789, -4901, -3848, -2652, -1336, 64, 1526, 3019, 4508, 5969, 7373, 8689, 9898, 10977, 11906, 12673, 13266, 13677, 13905, 13951, 13820, 13519, 13063, 12465, 11743, 10919, 10013, 9045, 8044, 7029, 6020, 5044, 4116, 3252, 2469, 1776, 1183, 693, 306, 21, -168, -273, -307, -283, -221, -141, -62, -9, -3, -66, -219, -483, -872, -1405, -2092, -2939, -3954, -5133, -6474, -7970, -9605, -11363, -13226, -15163, -17151, -19161, -21151, -23095, -24956, -26692, -28275, -29669, -30837, -31754, -32392, -32726, -32739, -32418, -31753, -30739, -29380, -27688, -25665, -23338, -20734, -17868, -14786, -11525, -8115, -4613, -981};