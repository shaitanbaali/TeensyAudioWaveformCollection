/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0790 256 samples */
 
const int16_t AKWF_0790_256_DATA [256] = 
{138, 406, 658, 901, 1138, 1364, 1583, 1790, 1991, 2182, 2358, 2527, 2689, 2841, 2983, 3118, 3243, 3358, 3463, 3559, 3647, 3729, 3808, 3877, 3932, 3975, 4006, 4026, 4051, 4000, 4419, 5795, 7167, 8462, 9688, 10841, 11918, 12924, 13865, 14741, 15564, 16334, 17057, 17742, 18385, 18999, 19579, 20133, 20659, 21166, 21651, 22114, 22562, 22993, 23407, 23808, 24195, 24570, 24936, 25289, 25630, 25962, 26285, 26599, 26904, 27201, 27490, 27771, 28043, 28309, 28569, 28822, 29068, 29306, 29538, 29765, 29986, 30199, 30408, 30612, 30808, 31000, 31187, 31362, 31526, 31690, 31846, 31990, 32118, 32232, 32331, 32415, 32488, 32549, 32599, 32640, 32675, 32702, 32724, 32742, 32753, 32765, 32746, 32601, 32306, 31479, 29889, 27683, 24945, 21810, 18269, 14361, 10314, 6356, 2546, -963, -4150, -7024, -9534, -11755, -13683, -15342, -16791, -18026, -19092, -20009, -20787, -21459, -22032, -22522, -22941, -23297, -23597, -23849, -24055, -24223, -24353, -24451, -24522, -24565, -24585, -24584, -24564, -24531, -24481, -24418, -24344, -24259, -24165, -24065, -23957, -23842, -23721, -23595, -23463, -23327, -23188, -23045, -22899, -22746, -22594, -22439, -22281, -22119, -21956, -21791, -21622, -21454, -21282, -21108, -20933, -20756, -20578, -20398, -20215, -20032, -19848, -19661, -19474, -19285, -19094, -18904, -18710, -18517, -18321, -18125, -17927, -17729, -17530, -17329, -17127, -16925, -16720, -16516, -16310, -16103, -15896, -15687, -15478, -15268, -15056, -14844, -14633, -14417, -14203, -13988, -13771, -13555, -13337, -13117, -12898, -12677, -12456, -12232, -12010, -11786, -11561, -11335, -11104, -10877, -10647, -10412, -10163, -9907, -9641, -9368, -9089, -8803, -8507, -8204, -7895, -7582, -7267, -6950, -6627, -6303, -5978, -5654, -5330, -5008, -4686, -4363, -4040, -3721, -3399, -3082, -2770, -2457, -2151, -1847, -1552, -1254, -962, -679, -398, -120};