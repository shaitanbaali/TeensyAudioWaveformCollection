/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0765 256 samples */
 
const int16_t AKWF_0765_256_DATA [256] = 
{296, 1001, 1690, 2376, 3052, 3715, 4364, 4993, 5601, 6187, 6747, 7283, 7794, 8275, 8730, 9158, 9559, 9933, 10285, 10612, 10917, 11202, 11467, 11714, 11945, 12162, 12367, 12565, 12764, 12969, 13190, 13431, 13701, 14000, 14330, 14688, 15072, 15479, 15900, 16334, 16774, 17216, 17656, 18092, 18521, 18938, 19344, 19736, 20114, 20477, 20826, 21158, 21476, 21777, 22063, 22336, 22593, 22837, 23068, 23285, 23491, 23685, 23867, 24040, 24203, 24355, 24499, 24635, 24762, 24882, 24995, 25101, 25201, 25294, 25383, 25466, 25543, 25616, 25685, 25749, 25810, 25867, 25920, 25971, 26018, 26060, 26096, 26121, 26128, 26111, 26063, 25979, 25856, 25692, 25490, 25250, 24979, 24681, 24362, 24026, 23680, 23328, 22972, 22618, 22265, 21908, 21537, 21134, 20680, 20155, 19538, 18812, 17969, 17001, 15910, 14701, 13375, 11948, 10436, 8847, 7204, 5526, 3822, 2114, 416, -1265, -2913, -4523, -6090, -7602, -9061, -10465, -11806, -13089, -14315, -15478, -16585, -17636, -18630, -19572, -20464, -21304, -22100, -22849, -23555, -24222, -24850, -25440, -25998, -26522, -27013, -27478, -27913, -28322, -28709, -29071, -29411, -29732, -30033, -30315, -30581, -30830, -31065, -31286, -31494, -31687, -31870, -32042, -32203, -32352, -32488, -32605, -32696, -32753, -32767, -32733, -32647, -32505, -32311, -32067, -31780, -31454, -31100, -30722, -30328, -29924, -29513, -29101, -28693, -28291, -27897, -27514, -27142, -26785, -26440, -26110, -25794, -25494, -25207, -24935, -24677, -24432, -24201, -23982, -23775, -23579, -23395, -23221, -23056, -22895, -22736, -22571, -22391, -22191, -21965, -21708, -21419, -21099, -20747, -20372, -19976, -19564, -19141, -18712, -18282, -17854, -17431, -17012, -16594, -16173, -15741, -15290, -14812, -14304, -13764, -13191, -12586, -11957, -11307, -10643, -9974, -9301, -8633, -7973, -7325, -6691, -6073, -5463, -4859, -4256, -3645, -3023, -2386, -1733, -1067, -374};