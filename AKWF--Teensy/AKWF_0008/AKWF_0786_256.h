/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0786 256 samples */
 
const int16_t AKWF_0786_256_DATA [256] = 
{81, 227, 378, 536, 701, 874, 1057, 1246, 1439, 1623, 1783, 1901, 1968, 1981, 1947, 1875, 1778, 1666, 1547, 1428, 1309, 1192, 1081, 987, 895, 837, 840, 874, 942, 1057, 1226, 1451, 1691, 1905, 2080, 2212, 2303, 2389, 2257, 3038, 5029, 3812, 4175, 5100, 5710, 6164, 6579, 7058, 7687, 8611, 9919, 11465, 12948, 14129, 14930, 15363, 15471, 15301, 14979, 14656, 14403, 14252, 14202, 14248, 14380, 14576, 14831, 15133, 15467, 15839, 16240, 16662, 17109, 17580, 18059, 18564, 19085, 19607, 20141, 20701, 21261, 21830, 22417, 22999, 23597, 24220, 24858, 25503, 26182, 26930, 27713, 28618, 29813, 31765, 32582, 32503, 32620, 33212, 21528, 13016, 15305, 14448, 15093, 15110, 14860, 14946, 15195, 15229, 15092, 14653, 13852, 12794, 11429, 9866, 8482, 7498, 6820, 6314, 5894, 5445, 4870, 4057, 3459, 4111, 4215, 647, 977, 1729, 1058, 297, -218, -627, -976, -1344, -1783, -2345, -3121, -4165, -5404, -6690, -7839, -8761, -9428, -9843, -10038, -10034, -9867, -9610, -9347, -9117, -8947, -8840, -8797, -8811, -8880, -8992, -9145, -9331, -9546, -9781, -10034, -10307, -10595, -10897, -11207, -11529, -11866, -12209, -12556, -12910, -13278, -13649, -14012, -14386, -14761, -15145, -15539, -15918, -16305, -16704, -17096, -17488, -17882, -18277, -18689, -19101, -19517, -19934, -20351, -20789, -21259, -21740, -22225, -22751, -23365, -24054, -24980, -26280, -27114, -27074, -27075, -27192, -27254, -27272, -27430, -23924, -12928, -7066, -9180, -10007, -9142, -8933, -9305, -9628, -9722, -9660, -9529, -9412, -9391, -9482, -9619, -9729, -9775, -9772, -9741, -9680, -9561, -9368, -9100, -8765, -8380, -7962, -7505, -6999, -6444, -5844, -5224, -4611, -4026, -3488, -3015, -2608, -2261, -1965, -1710, -1486, -1290, -1112, -954, -811, -677, -550, -428, -306, -181, -50};