/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0745 256 samples */
 
const int16_t AKWF_0745_256_DATA [256] = 
{571, 2369, 3973, 5406, 6646, 7680, 8497, 9086, 9440, 9554, 9431, 9077, 8510, 7759, 6858, 5854, 4801, 3751, 2759, 1880, 1153, 616, 296, 207, 357, 745, 1369, 2218, 3282, 4554, 6014, 7648, 9434, 11334, 13309, 15309, 17259, 19092, 20726, 22078, 23079, 23668, 23802, 23471, 22688, 21502, 19983, 18232, 16370, 14512, 12788, 11317, 10184, 9466, 9203, 9407, 10059, 11113, 12513, 14180, 16031, 17994, 19989, 21953, 23840, 25600, 27207, 28640, 29876, 30907, 31722, 32308, 32658, 32770, 32644, 32288, 31718, 30962, 30055, 29041, 27973, 26900, 25874, 24946, 24152, 23525, 23084, 22839, 22791, 22931, 23248, 23728, 24351, 25101, 25956, 26893, 27888, 28898, 29883, 30790, 31550, 32093, 32343, 32227, 31677, 30641, 29093, 27024, 24460, 21469, 18123, 14538, 10851, 7180, 3669, 448, -2395, -4775, -6643, -7991, -8830, -9203, -9174, -8817, -8217, -7453, -6606, -5743, -4920, -4187, -3576, -3116, -2829, -2733, -2843, -3171, -3730, -4526, -5556, -6818, -8293, -9949, -11757, -13666, -15618, -17565, -19446, -21204, -22800, -24192, -25348, -26257, -26908, -27296, -27427, -27308, -26946, -26351, -25539, -24528, -23336, -22003, -20567, -19082, -17621, -16253, -15061, -14130, -13530, -13325, -13554, -14234, -15351, -16856, -18685, -20735, -22885, -25022, -27018, -28755, -30147, -31118, -31627, -31666, -31252, -30431, -29259, -27817, -26183, -24433, -22646, -20883, -19193, -17622, -16197, -14939, -13870, -12999, -12338, -11896, -11682, -11700, -11947, -12416, -13091, -13942, -14936, -16026, -17158, -18282, -19342, -20284, -21070, -21661, -22032, -22168, -22064, -21718, -21135, -20325, -19298, -18063, -16639, -15041, -13289, -11422, -9480, -7513, -5595, -3794, -2190, -868, 103, 663, 772, 415, -391, -1598, -3139, -4910, -6789, -8663, -10400, -11885, -13027, -13755, -14025, -13827, -13181, -12129, -10732, -9067, -7216, -5255, -3264, -1265};