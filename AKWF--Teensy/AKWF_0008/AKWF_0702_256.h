/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0702 256 samples */
 
const int16_t AKWF_0702_256_DATA [256] = 
{1329, 4205, 6685, 8908, 10902, 12694, 14303, 15735, 17007, 18129, 19100, 19932, 20626, 21184, 21611, 21740, 22736, 18432, 9472, 5924, 2854, 364, -1763, -3635, -5294, -6777, -8110, -9305, -10375, -11334, -12184, -12932, -13582, -14137, -14602, -14976, -15264, -15400, -15836, -14212, -9250, -7234, -5615, -4279, -3124, -2106, -1185, -333, 449, 1180, 1860, 2496, 3093, 3651, 4176, 4671, 5136, 5573, 5983, 6368, 6730, 7069, 7386, 7680, 7954, 8210, 8444, 8661, 8857, 9035, 9196, 9340, 9465, 9574, 9667, 9744, 9803, 9848, 9887, 9844, 10266, 10984, 11275, 11521, 11723, 11895, 12041, 12210, 12378, 12510, 12634, 12748, 12854, 12955, 13047, 13135, 13218, 13297, 13371, 13441, 13507, 13570, 13630, 13685, 13738, 13789, 13836, 13879, 13920, 13960, 13996, 14030, 14060, 14089, 14115, 14138, 14161, 14181, 14197, 14212, 14225, 14235, 14243, 14249, 14254, 14254, 14164, 14630, 11140, 6265, 4374, 2629, 1208, -21, -1114, -2095, -2986, -3803, -4551, -5242, -5880, -6469, -7015, -7521, -7985, -8416, -8812, -9175, -9509, -9812, -10088, -10337, -10559, -10756, -10929, -11079, -11206, -11312, -11396, -11459, -11563, -11289, -12754, -16868, -18471, -19779, -20858, -21781, -22600, -23337, -24006, -24621, -25188, -25715, -26206, -26663, -27091, -27493, -27870, -28224, -28558, -28873, -29166, -29445, -29705, -29951, -30182, -30399, -30602, -30792, -30972, -31139, -31295, -31441, -31576, -31702, -31820, -31927, -32028, -32120, -32203, -32281, -32349, -32413, -32471, -32521, -32567, -32608, -32642, -32671, -32696, -32718, -32735, -32747, -32756, -32760, -32683, -33097, -29826, -22553, -19957, -18011, -16276, -14806, -13505, -12344, -11295, -10336, -9458, -8649, -7902, -7211, -6567, -5969, -5415, -4900, -4420, -3974, -3561, -3176, -2822, -2496, -2195, -1920, -1669, -1443, -1239, -1049, -875, -727, -607, -515, -449, -403, -376, -364};