/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0728 256 samples */
 
const int16_t AKWF_0728_256_DATA [256] = 
{1964, 5681, 9322, 12975, 16209, 22096, 9658, 1657, 6809, 9456, 12481, 15251, 19753, 2734, -6872, -9265, -12158, 6341, 3091, -4160, -3439, -5887, -9365, -12615, -15892, -19164, -22444, -25697, -29015, -32115, -30182, -26651, -23427, -20149, -16869, -13583, -10306, -7048, -3681, -807, -527, -576, -560, -564, 1959, 5358, 9820, 4794, 3024, 7282, 10353, 13599, 16854, 20106, 23350, 26536, 30099, 29860, 26259, 23080, 19829, 16569, 13315, 10062, 6808, 3562, 262, -718, -562, -600, -603, -605, -606, -608, -609, -610, -612, -613, -613, -614, -614, -615, -617, -616, -617, -618, -618, -617, -618, -620, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -620, -619, -617, -618, -617, -617, -617, -617, -617, -617, -618, -617, -616, -616, -617, -616, -616, -616, -616, -617, -616, -614, -615, -615, -614, -614, -614, -614, -615, -614, -613, -614, -613, -613, -613, -613, -614, -613, -612, -613, -612, -612, -612, -612, -613, -612, -611, -610, -611, -610, -610, -610, -610, -611, -610, -609, -610, -609, -609, -609, -609, -610, -609, -608, -609, -608, -608, -608, -608, -608, -609, -607, -606, -607, -606, -606, -606, -606, -607, -606, -605, -606, -605, -605, -605, -605, -606, -605, -604, -605, -605, -604, -604, -604, -605, -604, -603, -602, -603, -602, -602, -602, -602, -603, -602, -601, -602, -601, -601, -601, -601, -602, -601, -600, -599, -600, -599, -599, -599, -599, -600, -599, -598, -599, -598, -598, -598, -598, -599, -598, -598, -597, -598, -597, -597, -597, -597, -598, -596, -595, -596, -595, -595, -595, -595, -596, -595, -594};