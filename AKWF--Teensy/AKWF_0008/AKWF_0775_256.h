/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0775 256 samples */
 
const int16_t AKWF_0775_256_DATA [256] = 
{206, 919, 1703, 2558, 3468, 4419, 5398, 6387, 7380, 8366, 9335, 10290, 11223, 12133, 13027, 13903, 14762, 15613, 16455, 17290, 18124, 18958, 19791, 20623, 21454, 22278, 23097, 23904, 24693, 25463, 26205, 26914, 27586, 28214, 28795, 29324, 29795, 30208, 30564, 30858, 31093, 31270, 31393, 31467, 31495, 31483, 31437, 31366, 31275, 31172, 31064, 30960, 30862, 30780, 30718, 30677, 30664, 30679, 30724, 30800, 30902, 31029, 31179, 31346, 31525, 31713, 31902, 32085, 32257, 32414, 32546, 32650, 32721, 32755, 32750, 32702, 32610, 32474, 32295, 32073, 31813, 31513, 31180, 30817, 30427, 30013, 29582, 29135, 28672, 28201, 27716, 27218, 26706, 26174, 25615, 25019, 24371, 23659, 22859, 21962, 20994, 19988, 18963, 17937, 16916, 15907, 14919, 13960, 13030, 12137, 11288, 10509, 9759, 8973, 8183, 7431, 6708, 6014, 5345, 4694, 4070, 3473, 2908, 2380, 1890, 1429, 956, 424, -194, -898, -1686, -2542, -3450, -4404, -5383, -6374, -7367, -8356, -9325, -10280, -11215, -12127, -13021, -13898, -14758, -15609, -16453, -17290, -18125, -18959, -19791, -20625, -21457, -22281, -23101, -23908, -24699, -25468, -26211, -26920, -27593, -28221, -28801, -29330, -29802, -30216, -30572, -30866, -31100, -31279, -31403, -31475, -31503, -31491, -31445, -31374, -31284, -31181, -31073, -30968, -30872, -30790, -30725, -30687, -30674, -30689, -30735, -30810, -30912, -31039, -31189, -31355, -31535, -31722, -31911, -32095, -32267, -32424, -32556, -32659, -32730, -32765, -32759, -32712, -32620, -32483, -32304, -32083, -31821, -31521, -31188, -30825, -30434, -30023, -29591, -29143, -28681, -28209, -27723, -27225, -26714, -26180, -25620, -25024, -24377, -23664, -22863, -21965, -20998, -19989, -18961, -17935, -16912, -15902, -14913, -13951, -13020, -12128, -11276, -10497, -9747, -8959, -8168, -7415, -6694, -5998, -5328, -4677, -4052, -3456, -2890, -2360, -1871, -1410, -939, -395};