/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0719 256 samples */
 
const int16_t AKWF_0719_256_DATA [256] = 
{492, 1768, 2667, 3457, 2976, 7543, 18794, 22315, 26927, 32550, 29560, 27732, 26375, 25167, 24082, 23086, 22162, 21291, 20467, 19685, 18935, 18214, 17524, 16855, 16209, 15585, 14977, 14389, 13818, 13261, 12720, 12193, 11679, 11179, 10690, 10213, 9748, 9295, 8850, 8419, 7996, 7583, 7181, 6788, 6404, 6030, 5664, 5307, 4960, 4620, 4289, 3968, 3653, 3347, 3050, 2761, 2479, 2205, 1939, 1682, 1431, 1188, 953, 726, 506, 294, 90, -107, -297, -479, -655, -823, -983, -1136, -1282, -1421, -1552, -1676, -1794, -1903, -2006, -2101, -2190, -2270, -2345, -2412, -2472, -2524, -2569, -2608, -2640, -2664, -2705, -2559, -3319, -3512, -2421, -2639, -2721, -2784, -2841, -2893, -2940, -2984, -3025, -3064, -3101, -3137, -3170, -3204, -3235, -3266, -3296, -3325, -3353, -3380, -3407, -3433, -3458, -3483, -3508, -3532, -3555, -3579, -3601, -3623, -3645, -3667, -3688, -3709, -3729, -3748, -3769, -3788, -3807, -3826, -3844, -3863, -3881, -3898, -3915, -3933, -3950, -3966, -3983, -3999, -4015, -4031, -4046, -4062, -4077, -4091, -4107, -4121, -4135, -4150, -4163, -4177, -4190, -4204, -4217, -4229, -4242, -4255, -4268, -4280, -4292, -4304, -4315, -4327, -4339, -4349, -4360, -4371, -4382, -4392, -4403, -4413, -4423, -4432, -4442, -4452, -4461, -4470, -4480, -4488, -4497, -4506, -4514, -4522, -4530, -4539, -4546, -4554, -4561, -4568, -4575, -4582, -4589, -4596, -4603, -4609, -4615, -4622, -4628, -4633, -4639, -4644, -4650, -4656, -4661, -4665, -4670, -4675, -4679, -4683, -4688, -4692, -4695, -4700, -4703, -4707, -4710, -4713, -4716, -4719, -4722, -4724, -4727, -4729, -4732, -4734, -4736, -4737, -4739, -4740, -4741, -4742, -4744, -4745, -4746, -4746, -4747, -4748, -4747, -4747, -4747, -4748, -4747, -4747, -4746, -4745, -4715, -4854, -4215, -1169};