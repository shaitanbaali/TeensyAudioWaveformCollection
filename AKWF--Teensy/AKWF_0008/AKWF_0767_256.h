/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0767 256 samples */
 
const int16_t AKWF_0767_256_DATA [256] = 
{416, 1322, 2192, 3048, 3886, 4706, 5511, 6294, 7058, 7806, 8534, 9243, 9938, 10611, 11265, 11906, 12529, 13134, 13722, 14294, 14850, 15389, 15910, 16422, 16915, 17393, 17858, 18309, 18744, 19165, 19574, 19969, 20351, 20721, 21077, 21421, 21755, 22076, 22389, 22690, 22982, 23267, 23541, 23806, 24060, 24305, 24538, 24762, 24973, 25175, 25366, 25546, 25713, 25864, 25993, 26099, 26174, 26213, 26216, 26184, 26121, 26022, 25890, 25729, 25542, 25332, 25100, 24849, 24583, 24303, 24011, 23709, 23400, 23084, 22762, 22435, 22102, 21761, 21405, 21031, 20635, 20213, 19761, 19280, 18770, 18232, 17670, 17083, 16481, 15863, 15227, 14583, 13932, 13274, 12613, 11950, 11287, 10631, 9977, 9326, 8682, 8047, 7415, 6792, 6178, 5571, 4973, 4382, 3801, 3229, 2666, 2111, 1566, 1029, 500, -19, -531, -1034, -1530, -2023, -2511, -2999, -3491, -3989, -4506, -5046, -5604, -6188, -6800, -7433, -8085, -8756, -9440, -10134, -10835, -11539, -12246, -12954, -13657, -14353, -15041, -15720, -16389, -17044, -17689, -18318, -18932, -19531, -20116, -20684, -21237, -21775, -22297, -22802, -23293, -23767, -24226, -24669, -25096, -25508, -25905, -26284, -26650, -27001, -27333, -27652, -27957, -28248, -28529, -28795, -29049, -29292, -29523, -29745, -29956, -30157, -30350, -30532, -30706, -30873, -31031, -31179, -31322, -31457, -31582, -31702, -31814, -31920, -32019, -32111, -32195, -32274, -32348, -32415, -32478, -32532, -32582, -32626, -32663, -32697, -32724, -32747, -32763, -32767, -32757, -32731, -32678, -32598, -32485, -32341, -32167, -31969, -31741, -31489, -31215, -30920, -30605, -30266, -29900, -29509, -29087, -28629, -28139, -27617, -27060, -26477, -25867, -25230, -24575, -23899, -23207, -22500, -21775, -21033, -20271, -19483, -18669, -17830, -16957, -16058, -15136, -14191, -13226, -12249, -11257, -10257, -9255, -8246, -7243, -6247, -5254, -4274, -3307, -2350, -1412, -470};