/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0742 256 samples */
 
const int16_t AKWF_0742_256_DATA [256] = 
{791, 1986, 3203, 4460, 5748, 7063, 8400, 9749, 11107, 12468, 13822, 15168, 16498, 17804, 19084, 20332, 21539, 22705, 23823, 24886, 25896, 26845, 27729, 28551, 29301, 29980, 30589, 31124, 31582, 31967, 32275, 32509, 32668, 32753, 32765, 32706, 32578, 32383, 32123, 31801, 31421, 30984, 30495, 29956, 29370, 28745, 28079, 27377, 26649, 25890, 25109, 24310, 23495, 22667, 21835, 20996, 20156, 19321, 18490, 17669, 16862, 16067, 15293, 14539, 13805, 13099, 12418, 11764, 11144, 10554, 9996, 9473, 8984, 8531, 8114, 7733, 7387, 7079, 6805, 6567, 6364, 6196, 6062, 5960, 5890, 5850, 5840, 5858, 5903, 5973, 6067, 6184, 6321, 6478, 6652, 6842, 7046, 7262, 7491, 7728, 7973, 8223, 8475, 8723, 8958, 9176, 9365, 9518, 9630, 9695, 9712, 9675, 9583, 9433, 9223, 8950, 8609, 8201, 7724, 7175, 6555, 5865, 5103, 4274, 3379, 2418, 1398, 323, -807, -1982, -3202, -4461, -5748, -7064, -8401, -9749, -11108, -12468, -13822, -15168, -16499, -17804, -19085, -20333, -21538, -22705, -23823, -24886, -25896, -26845, -27729, -28551, -29301, -29980, -30589, -31124, -31582, -31967, -32275, -32509, -32668, -32753, -32765, -32706, -32578, -32382, -32123, -31801, -31420, -30983, -30494, -29956, -29370, -28745, -28079, -27378, -26648, -25890, -25109, -24310, -23495, -22668, -21834, -20995, -20156, -19321, -18490, -17670, -16862, -16068, -15293, -14538, -13805, -13098, -12418, -11765, -11144, -10555, -9997, -9474, -8985, -8532, -8115, -7734, -7388, -7079, -6805, -6568, -6365, -6197, -6062, -5960, -5891, -5851, -5840, -5859, -5904, -5974, -6068, -6185, -6322, -6479, -6653, -6843, -7047, -7263, -7491, -7729, -7973, -8224, -8477, -8723, -8959, -9177, -9366, -9519, -9630, -9696, -9712, -9676, -9584, -9434, -9223, -8950, -8609, -8202, -7725, -7176, -6556, -5866, -5104, -4274, -3380, -2421, -1404, -308};