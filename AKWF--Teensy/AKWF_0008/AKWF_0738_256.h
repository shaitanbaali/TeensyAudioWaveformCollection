/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0738 256 samples */
 
const int16_t AKWF_0738_256_DATA [256] = 
{332, 911, 1381, 1786, 1989, 3133, 5489, 7450, 9181, 10667, 11400, 11893, 13114, 10812, 6456, 8893, 10342, 11667, 12822, 13819, 14670, 15372, 15967, 16264, 15925, 15742, 15675, 15658, 15678, 15730, 15809, 15913, 16035, 16163, 16297, 16421, 16518, 15950, 19535, -16686, -33278, -26238, -24253, -21883, -19727, -17744, -15887, -14143, -12500, -10941, -9462, -8059, -6723, -5453, -4246, -3098, -2012, -981, -3, 920, 1786, 2613, 3696, 4672, 5494, 6228, 6879, 7465, 7928, 8609, 9745, 10666, 11428, 12054, 12547, 12808, 13604, 10983, 5509, 5569, 5335, 5161, 4950, 4679, 4344, 3891, 3569, 3227, 2126, 1195, 398, -329, -992, -1599, -2151, -2654, -3107, -3512, -3872, -4201, -4555, -4629, -4279, -4011, -3788, -3597, -3435, -3295, -3174, -3075, -2993, -2928, -2879, -2847, -2833, -2838, -2937, -2440, -11818, -14321, -12318, -11475, -10594, -9804, -9097, -8445, -7548, -6766, -6139, -5605, -5154, -4774, -4515, -4036, -3104, -2388, -1819, -1422, -1708, -2181, -1876, -5043, -10223, -8566, -7859, -7239, -6751, -6385, -6133, -5995, -5926, -6130, -6933, -7547, -8013, -8400, -8715, -8968, -9163, -9302, -9392, -9444, -9461, -9458, -9454, -9450, -9448, -9443, -9439, -9436, -9433, -9429, -9426, -9421, -9417, -9415, -9411, -9409, -9404, -9402, -9401, -9397, -9394, -9391, -9389, -9387, -9384, -9379, -9382, -9370, -9051, -8788, -8630, -8509, -8424, -8354, -8360, -8101, -7340, -6745, -6264, -5874, -5573, -5456, -4736, -7537, -12394, -10447, -9476, -8618, -7911, -7350, -6912, -6645, -6289, -5989, -6483, -6835, -7082, -7287, -7451, -7583, -7682, -7751, -7791, -7804, -7789, -7762, -7781, -7532, -6993, -6061, -4560, -3486, -2663, -1900, -1220, -611, -62, 432, 872, 1262, 1606, 1894, 2062, 2799, -6367, -8681, -6520, -5541, -4545, -3660, -2865, -2133, -1167, -318};