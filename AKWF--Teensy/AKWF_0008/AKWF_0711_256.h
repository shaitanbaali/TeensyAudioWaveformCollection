/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0711 256 samples */
 
const int16_t AKWF_0711_256_DATA [256] = 
{32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32206, 35244, 12577, -2373, 536, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -55, 252, -1057, -6607, -6479, -6488, -6494, -6494, -6494, -6494, -6494, -6458, -6650, -5893, -174, 54, -18, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 13, -32, 81, 5634, 6520, 6301, 6342, 6342, 6342, 6322, 6407, 6126, 529, -140, 33, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -535, 2373, -21004, -34947, -32163, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32673, -32188, -34853, -10387, 2115, -470, 0, 0, 0, 0, 0};