/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0739 256 samples */
 
const int16_t AKWF_0739_256_DATA [256] = 
{1201, 4306, 6631, 8469, 9964, 11301, 12441, 13397, 14189, 14842, 15500, 16247, 16973, 17664, 18356, 19024, 19725, 20285, 20882, 21622, 22643, 23586, 24437, 25396, 26362, 27302, 28251, 29074, 29768, 30496, 31125, 31688, 32181, 32517, 32679, 32735, 32770, 32733, 32598, 32431, 32186, 31776, 31362, 31006, 30738, 30493, 30223, 29942, 29730, 29542, 29399, 29326, 29216, 29153, 29139, 29181, 29154, 29059, 28959, 28814, 28570, 28277, 28064, 27819, 27517, 27176, 26609, 25926, 25312, 24555, 23752, 22997, 22177, 21246, 20246, 19335, 18333, 17464, 17494, 17777, 16903, 16125, 15321, 14243, 13233, 12126, 10866, 9489, 8259, 7029, 5656, 4423, 245, -1869, -4962, -13444, -17486, -19964, -21593, -22483, -22950, -23191, -23041, -22820, -22837, -23069, -23447, -23961, -24745, -25612, -26260, -27075, -28207, -29013, -29771, -30468, -31017, -31237, -31139, -31170, -31121, -30826, -30442, -29889, -29494, -29128, -28651, -28229, -27643, -26978, -26415, -25910, -25384, -24702, -23961, -23173, -22366, -21537, -20578, -19426, -18217, -16994, -15735, -14496, -13238, -12139, -11052, -9871, -8467, -7213, -6116, -4979, -3904, -2922, -1992, -1244, -675, -110, 317, 653, 900, 976, 872, 661, 438, 155, -218, -599, -1033, -1613, -2169, -2638, -2991, -3287, -3582, -3855, -4032, -4154, -4205, -4161, -4126, -4021, -3837, -3584, -3370, -3204, -3027, -2873, -2801, -2755, -2616, -2489, -2399, -2336, -2479, -2715, -2871, -3147, -3451, -3687, -3971, -4350, -4774, -5089, -5477, -5715, -5031, -4074, -4255, -4320, -4394, -4724, -4944, -5210, -5616, -6129, -6479, -6816, -7279, -7597, -10845, -12022, -14163, -21678, -24777, -26352, -27074, -27059, -26627, -25959, -24911, -23791, -22905, -22245, -21729, -21354, -21250, -21243, -21018, -20967, -21241, -21203, -21125, -20997, -20737, -20153, -19274, -18511, -17660, -16583, -15436, -14141, -12955, -12202, -9534, -2458};