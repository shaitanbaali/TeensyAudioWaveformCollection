/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0734 256 samples */
 
const int16_t AKWF_0734_256_DATA [256] = 
{2637, 6977, 11228, 15492, 19729, 24095, 27135, 32260, 17893, 1342, 6506, 8125, 10304, 12477, 14655, 16833, 19005, 21184, 23361, 25533, 27704, 29856, 32149, 31471, 29062, 26931, 24745, 22561, 20379, 18192, 16010, 13828, 11641, 9459, 7276, 5112, 2845, 1132, 1081, 1091, 1081, 1079, 1076, 1073, 1072, 1070, 1068, 1067, 1065, 1064, 1062, 1061, 1060, 1059, 1058, 1057, 1057, 1055, 1055, 1054, 1054, 1053, 1051, 1052, 1051, 1049, 1050, 1050, 1049, 1048, 1049, 1049, 1047, 1024, 1119, 661, -1964, -2237, -958, -3587, -5718, -7932, -10144, -12352, -14564, -16776, -18982, -21194, -23404, -25608, -27774, -30189, -29653, -29019, -7734, -551, -4848, -6769, -9062, -11359, -13651, -15944, -18242, -20093, -24763, -9337, 276, -4015, -5627, -7649, -9677, -11705, -13728, -15756, -17784, -19806, -21835, -23848, -25891, -27851, -26553, -25342, -19223, 3179, 5091, 8419, -1100, -2564, 2918, 6957, 11221, 15492, 19729, 24095, 27135, 32260, 17893, 1342, 6506, 8125, 10304, 12477, 14655, 16833, 19005, 21184, 23361, 25533, 27704, 29856, 32149, 31471, 29062, 26931, 24745, 22561, 20379, 18192, 16010, 13828, 11641, 9459, 7276, 5112, 2845, 1132, 1081, 1091, 1081, 1079, 1076, 1073, 1072, 1070, 1068, 1067, 1065, 1064, 1062, 1061, 1060, 1059, 1058, 1057, 1057, 1055, 1055, 1054, 1054, 1053, 1051, 1052, 1051, 1049, 1050, 1050, 1049, 1048, 1049, 1049, 1047, 1024, 1119, 662, -1964, -2236, -958, -3587, -5718, -7932, -10144, -12351, -14564, -16775, -18980, -21192, -23402, -25607, -27773, -30187, -29652, -29018, -7733, -551, -4848, -6769, -9062, -11359, -13651, -15944, -18242, -20093, -24763, -9337, 276, -4015, -5627, -7649, -9677, -11705, -13728, -15756, -17784, -19806, -21835, -23848, -25891, -27851, -26553, -25342, -19223, 3179, 5091, 8412, -1119, -2505};