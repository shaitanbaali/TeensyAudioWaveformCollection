/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0764 256 samples */
 
const int16_t AKWF_0764_256_DATA [256] = 
{1884, 4920, 7749, 10399, 12817, 14965, 16806, 18303, 19442, 20216, 20633, 20721, 20516, 20065, 19411, 18597, 17658, 16619, 15505, 14348, 13187, 12083, 11109, 10337, 9832, 9630, 9725, 10066, 10557, 11074, 11479, 11650, 11500, 10992, 10135, 8986, 7635, 6183, 4729, 3373, 2182, 1211, 496, 52, -120, -29, 306, 860, 1602, 2501, 3519, 4618, 5769, 6933, 8075, 9170, 10187, 11101, 11896, 12551, 13053, 13397, 13574, 13584, 13432, 13121, 12660, 12061, 11338, 10506, 9581, 8586, 7535, 6447, 5345, 4241, 3153, 2102, 1093, 142, -739, -1550, -2280, -2929, -3502, -4009, -4462, -4886, -5305, -5747, -6246, -6825, -7510, -8323, -9274, -10370, -11615, -12995, -14502, -16118, -17814, -19565, -21345, -23109, -24829, -26469, -27986, -29350, -30528, -31483, -32191, -32626, -32768, -32599, -32110, -31296, -30155, -28693, -26928, -24865, -22536, -19970, -17188, -14236, -11156, -7978, -4763, -1552, 1614, 4673, 7587, 10314, 12795, 15001, 16892, 18431, 19605, 20405, 20840, 20937, 20735, 20281, 19621, 18799, 17856, 16815, 15706, 14560, 13414, 12324, 11358, 10582, 10057, 9816, 9853, 10122, 10530, 10961, 11286, 11388, 11184, 10637, 9759, 8601, 7255, 5815, 4382, 3052, 1891, 954, 276, -129, -260, -126, 254, 855, 1643, 2588, 3653, 4797, 5990, 7192, 8370, 9496, 10540, 11477, 12290, 12958, 13469, 13817, 13996, 14004, 13844, 13525, 13053, 12441, 11703, 10854, 9912, 8897, 7826, 6715, 5589, 4462, 3349, 2272, 1237, 259, -648, -1484, -2238, -2910, -3504, -4028, -4495, -4927, -5346, -5779, -6256, -6801, -7438, -8186, -9055, -10056, -11191, -12453, -13837, -15329, -16905, -18544, -20218, -21890, -23531, -25104, -26567, -27891, -29040, -29978, -30683, -31125, -31284, -31142, -30692, -29925, -28839, -27440, -25744, -23758, -21510, -19029, -16336, -13476, -10487, -7406, -4289, -1111};