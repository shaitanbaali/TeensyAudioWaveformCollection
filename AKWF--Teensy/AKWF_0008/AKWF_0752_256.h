/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0752 256 samples */
 
const int16_t AKWF_0752_256_DATA [256] = 
{536, 1363, 2101, 2788, 3430, 4035, 4609, 5152, 5671, 6168, 6643, 7099, 7539, 7960, 8367, 8759, 9138, 9503, 9856, 10195, 10525, 10842, 11148, 11445, 11731, 12007, 12273, 12531, 12778, 13017, 13247, 13468, 13681, 13884, 14080, 14269, 14448, 14620, 14783, 14938, 15086, 15226, 15358, 15484, 15601, 15711, 15813, 15908, 15996, 16075, 16108, 16375, 15235, 13194, 12494, 11860, 11352, 10917, 10529, 10180, 9859, 9562, 9284, 9023, 8776, 8541, 8317, 8102, 7896, 7698, 7504, 7318, 7137, 6960, 6790, 6624, 6460, 6301, 6144, 5990, 5841, 5694, 5548, 5406, 5266, 5127, 4991, 4856, 4722, 4592, 4462, 4334, 4207, 4083, 3962, 3847, 3752, 3496, 6587, 8932, 9939, 10848, 11589, 12223, 12782, 13283, 13733, 14144, 14520, 14865, 15184, 15478, 15747, 15997, 16228, 16439, 16634, 16812, 16973, 17121, 17252, 17369, 17473, 17561, 17638, 17701, 17750, 17788, 17812, 17823, 17823, 17748, 17967, 17103, 3438, -763, 640, 649, 577, 590, 313, 1447, 4940, 6245, 7283, 8122, 8831, 9444, 9985, 10465, 10891, 11273, 11613, 11913, 12177, 12407, 12604, 12769, 12903, 13008, 13064, 13167, 13000, 8228, 5493, 4057, 2865, 1948, 1234, 694, 313, 77, -8, 48, -3333, -5439, -9044, -12310, -14092, -15697, -17077, -18304, -19416, -20437, -21380, -22257, -23077, -23844, -24565, -25246, -25886, -26490, -27062, -27601, -28110, -28590, -29043, -29468, -29869, -30243, -30594, -30922, -31225, -31507, -31767, -32003, -32220, -32333, -32877, -31632, -17984, -14672, -16194, -16316, -16406, -16566, -16395, -17865, -21415, -22766, -23904, -24832, -25624, -26315, -26929, -27472, -27958, -28391, -28774, -29112, -29367, -29811, -28965, -26980, -26346, -25770, -25264, -24928, -24149, -18878, -15964, -14186, -12696, -11491, -10499, -9696, -9064, -8591, -8276, -8044, -7794, -7729, -4885, -2549, -1412, -344};