/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0717 256 samples */
 
const int16_t AKWF_0717_256_DATA [256] = 
{764, 1973, 3058, 4066, 4998, 5864, 6670, 7416, 8109, 8752, 9345, 9891, 10394, 10850, 11266, 11643, 11978, 12274, 12530, 12748, 12929, 13073, 13183, 13314, 12992, 18760, 23346, 25198, 26872, 28195, 29285, 30189, 30938, 31545, 32023, 32381, 32501, 33247, 28992, 23143, 21143, 19264, 17754, 16449, 15291, 14254, 13304, 12433, 11631, 10886, 10191, 9547, 8943, 8380, 7854, 7363, 6905, 6479, 6083, 5716, 5379, 5068, 4783, 4526, 4293, 4086, 3904, 3746, 3612, 3502, 3416, 3339, 3373, 3031, 1461, 815, -1098, -2158, -3727, -6394, -7184, -7845, -7861, -9476, -13532, -14923, -16046, -16919, -17622, -18193, -18656, -19019, -19293, -19512, -19470, -20282, -22035, -22626, -23136, -23544, -23889, -24191, -24458, -24697, -24911, -25105, -25281, -25438, -25581, -25708, -25822, -25921, -26009, -26084, -26148, -26198, -26238, -26266, -26131, -26927, -20313, -12910, -10241, -7719, -5676, -3898, -2322, -900, 400, 1593, 2697, 3723, 4675, 5565, 6396, 7168, 7891, 8566, 9192, 9775, 10315, 10816, 11256, 11614, 11941, 12235, 12495, 12717, 12904, 13054, 13171, 13307, 12988, 18755, 23342, 25194, 26867, 28191, 29280, 30184, 30934, 31541, 32018, 32376, 32496, 33243, 28988, 23138, 21139, 19259, 17750, 16445, 15287, 14249, 13300, 12429, 11628, 10881, 10187, 9543, 8938, 8375, 7850, 7358, 6901, 6475, 6078, 5712, 5375, 5063, 4779, 4522, 4288, 4082, 3900, 3742, 3608, 3498, 3412, 3335, 3368, 3027, 1456, 812, -1101, -2161, -3731, -6398, -7189, -7849, -7865, -9481, -13536, -14927, -16050, -16924, -17626, -18197, -18660, -19024, -19298, -19515, -19474, -20287, -22039, -22630, -23141, -23549, -23893, -24195, -24463, -24701, -24916, -25110, -25284, -25443, -25585, -25712, -25826, -25926, -26013, -26088, -26151, -26203, -26242, -26270, -26132, -26946, -20184, -12632, -9923, -7368, -5306, -3521, -1945, -504};