/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0726 256 samples */
 
const int16_t AKWF_0726_256_DATA [256] = 
{-233, -1072, -1885, -2691, -3487, -4277, -5059, -5833, -6598, -7358, -8105, -8846, -9125, -12244, 1074, 15803, 14179, 15319, 16012, 16694, 17363, 18023, 18668, 19304, 19925, 20534, 21132, 21715, 22285, 22842, 23384, 23913, 24429, 24929, 25416, 25889, 26345, 26787, 27216, 27628, 28026, 28409, 28775, 29127, 29462, 29782, 30085, 30374, 30646, 30902, 31142, 31366, 31574, 31765, 31940, 32098, 32240, 32364, 32474, 32565, 32639, 32697, 32738, 32762, 32768, 32760, 32731, 32687, 32626, 32547, 32449, 32337, 32207, 32056, 31889, 31704, 31501, 31282, 31045, 30788, 30514, 30221, 29909, 29581, 29233, 28868, 28482, 28080, 27657, 27219, 26756, 26277, 25781, 25263, 24726, 24170, 23594, 22999, 22384, 21747, 21092, 20415, 19715, 18996, 18254, 17489, 16703, 15891, 15054, 13814, 15007, -2757, -12387, -9588, -9228, -8475, -7712, -6940, -6162, -5372, -4575, -3770, -2953, -2130, -1296, -451, 448, 1351, 2202, 3038, 3866, 4687, 5495, 6299, 7095, 7880, 8660, 9431, 10191, 10569, 13343, 4031, -13940, -12587, -13646, -14322, -14987, -15640, -16282, -16914, -17532, -18139, -18735, -19316, -19887, -20443, -20986, -21518, -22035, -22540, -23032, -23509, -23973, -24422, -24858, -25280, -25687, -26080, -26460, -26825, -27175, -27509, -27831, -28138, -28427, -28704, -28965, -29212, -29444, -29660, -29861, -30049, -30220, -30377, -30518, -30644, -30754, -30850, -30930, -30996, -31046, -31080, -31101, -31104, -31095, -31068, -31026, -30970, -30898, -30811, -30708, -30592, -30459, -30311, -30148, -29970, -29778, -29570, -29345, -29108, -28854, -28584, -28302, -28002, -27688, -27361, -27019, -26661, -26290, -25902, -25501, -25086, -24656, -24213, -23754, -23284, -22797, -22295, -21783, -21257, -20717, -20163, -19597, -19017, -18426, -17822, -17204, -16577, -15936, -15283, -14620, -13945, -13258, -12289, -13141, -5320, 13621, 11166, 10420, 9370, 8257, 7066, 5768, 4283, 1859, 519};