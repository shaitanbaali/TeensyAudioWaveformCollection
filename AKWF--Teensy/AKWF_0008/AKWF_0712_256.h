/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0712 256 samples */
 
const int16_t AKWF_0712_256_DATA [256] = 
{297, 761, 1220, 1680, 2138, 2597, 3056, 3514, 3973, 4432, 4887, 5345, 5805, 6261, 6718, 7176, 7633, 8089, 8545, 9001, 9457, 9914, 10370, 10824, 11280, 11735, 12190, 12645, 13099, 13554, 14009, 14461, 14915, 15369, 15822, 16276, 16728, 17182, 17636, 18087, 18541, 18993, 19445, 19896, 20349, 20799, 21251, 21704, 22153, 22604, 23055, 23505, 23955, 24404, 24856, 25305, 25755, 26203, 26652, 27104, 27549, 28000, 28448, 28895, 29347, 29791, 30241, 30688, 31132, 31586, 32006, 32546, 32363, 31690, 31131, 30543, 29954, 29373, 28785, 28201, 27616, 27028, 26445, 25858, 25276, 24688, 24103, 23520, 22935, 22351, 21764, 21180, 20597, 20012, 19429, 18844, 18260, 17676, 17093, 16510, 15928, 15346, 14761, 14180, 13597, 13015, 12436, 11853, 11270, 10690, 10109, 9527, 8948, 8368, 7786, 7208, 6627, 6048, 5470, 4890, 4311, 3732, 3153, 2575, 1998, 1419, 841, 264, -312, -888, -1464, -2041, -2616, -3192, -3769, -4344, -4920, -5496, -6069, -6644, -7220, -7793, -8367, -8940, -9513, -10088, -10661, -11234, -11805, -12378, -12950, -13521, -14095, -14664, -15237, -15808, -16379, -16950, -17520, -18090, -18661, -19228, -19798, -20367, -20938, -21504, -22074, -22642, -23210, -23779, -24345, -24914, -25481, -26047, -26615, -27179, -27748, -28311, -28879, -29445, -30007, -30578, -31137, -31694, -32298, -32729, -32246, -31781, -31310, -30848, -30376, -29910, -29443, -28972, -28506, -28036, -27570, -27101, -26630, -26164, -25695, -25229, -24759, -24290, -23824, -23357, -22888, -22419, -21954, -21486, -21019, -20552, -20084, -19618, -19152, -18684, -18218, -17752, -17287, -16821, -16355, -15889, -15423, -14958, -14491, -14027, -13563, -13096, -12633, -12169, -11704, -11240, -10775, -10312, -9848, -9386, -8923, -8459, -7996, -7533, -7072, -6610, -6146, -5685, -5223, -4762, -4300, -3839, -3378, -2917, -2456, -1996, -1535, -1074, -616, -148};