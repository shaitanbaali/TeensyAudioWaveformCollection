/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0709 256 samples */
 
const int16_t AKWF_0709_256_DATA [256] = 
{18975, 35236, 32204, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32761, 32686, 33190, 22229, 19067, 19788, 19660, 19660, 19660, 19660, 19660, 19660, 19491, 20431, 10220, 5775, 6723, 6553, 6553, 6553, 6553, 6664, 6088, 8579, 20306, 11492, 5579, 6762, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6580, 6451, 6933, 14286, 7501, -1993, -7298, -6382, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6199, -8160, 5459, 21173, 19329, 19659, 19660, 19660, 19660, 19660, 19660, 19660, 19491, 20431, 10220, 5775, 6723, 6553, 6553, 6553, 6553, 6553, 6315, 7588, 271, -7599, -6313, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6472, -6522, -7106, 24181, 30716, 18263, 20616, 12859, 5755, 6728, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6546, 6471, 6975, -3985, -7146, -6426, -6553, -6553, -6553, -6553, -6553, -6554, -6722, -5783, -15994, -20438, -19490, -19660, -19660, -19660, -19660, -19440, -20584, -15197, 5892, 6742, 6464, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6553, 6580, 6451, 6933, 14286, 7501, -1993, -7298, -6382, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6553, -6376, -7398, -394, 6854, -5629, -6841, -6485, -6553, -6553, -6553, -6553, -6554, -6722, -5783, -15994, -20438, -19490, -19660, -19660, -19660, -19660, -19660, -19899, -18625, -25943, -33813, -32527, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767};