/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0800 256 samples */
 
const int16_t AKWF_0800_256_DATA [256] = 
{571, 1536, 2548, 3610, 4713, 5856, 7043, 8271, 9544, 10853, 12185, 13535, 14894, 16248, 17598, 18936, 20250, 21538, 22790, 23994, 25148, 26242, 27270, 28228, 29109, 29904, 30614, 31228, 31744, 32159, 32468, 32670, 32763, 32747, 32621, 32383, 32036, 31579, 31016, 30350, 29580, 28712, 27752, 26700, 25563, 24348, 23055, 21692, 20270, 18785, 17248, 15670, 14047, 12391, 10708, 8999, 7275, 5544, 3806, 2072, 348, -1368, -3066, -4740, -6391, -8006, -9585, -11127, -12620, -14065, -15462, -16800, -18084, -19310, -20468, -21564, -22594, -23552, -24443, -25262, -26008, -26682, -27282, -27807, -28260, -28639, -28943, -29176, -29336, -29424, -29443, -29395, -29280, -29100, -28858, -28556, -28197, -27782, -27316, -26801, -26240, -25636, -24993, -24316, -23606, -22867, -22106, -21323, -20519, -19696, -18823, -17884, -16883, -15818, -14699, -13540, -12345, -11131, -9916, -8707, -7524, -6383, -5293, -4273, -3337, -2493, -1757, -1133, -634, -266, -31, 66, 26, -151, -465, -909, -1479, -2166, -2961, -3856, -4838, -5893, -7011, -8178, -9374, -10592, -11813, -13021, -14207, -15352, -16443, -17472, -18424, -19287, -20055, -20718, -21265, -21683, -21947, -22044, -21972, -21743, -21365, -20838, -20156, -19312, -18315, -17178, -15910, -14522, -13027, -11430, -9746, -7993, -6177, -4316, -2429, -519, 1394, 3292, 5172, 7014, 8801, 10532, 12189, 13761, 15246, 16631, 17907, 19073, 20120, 21046, 21849, 22526, 23077, 23502, 23804, 23982, 24042, 23986, 23819, 23544, 23169, 22696, 22134, 21491, 20771, 19984, 19137, 18234, 17282, 16292, 15268, 14217, 13149, 12066, 10977, 9889, 8804, 7729, 6670, 5630, 4616, 3632, 2678, 1763, 886, 51, -737, -1476, -2166, -2803, -3385, -3912, -4380, -4790, -5139, -5426, -5652, -5816, -5918, -5956, -5932, -5848, -5700, -5491, -5224, -4898, -4516, -4080, -3590, -3049, -2455, -1806, -1092, -281};