/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0797 256 samples */
 
const int16_t AKWF_0797_256_DATA [256] = 
{431, 1382, 2317, 3248, 4166, 5064, 5935, 6769, 7560, 8303, 8991, 9621, 10190, 10694, 11138, 11517, 11836, 12099, 12311, 12474, 12600, 12693, 12762, 12815, 12860, 12906, 12961, 13032, 13126, 13249, 13406, 13601, 13837, 14116, 14437, 14811, 15242, 15726, 16260, 16839, 17466, 18144, 18869, 19649, 20481, 21360, 22282, 23237, 24208, 25182, 26141, 27065, 27943, 28760, 29504, 30171, 30757, 31259, 31682, 32026, 32296, 32499, 32642, 32728, 32766, 32760, 32718, 32641, 32536, 32402, 32241, 32053, 31836, 31588, 31305, 30982, 30615, 30200, 29731, 29204, 28617, 27965, 27245, 26463, 25612, 24697, 23724, 22690, 21606, 20480, 19315, 18123, 16913, 15690, 14469, 13256, 12056, 10883, 9736, 8620, 7541, 6495, 5480, 4500, 3544, 2608, 1690, 781, -126, -1031, -1946, -2870, -3805, -4754, -5716, -6686, -7666, -8647, -9623, -10592, -11542, -12465, -13359, -14210, -15012, -15760, -16445, -17063, -17610, -18082, -18476, -18794, -19034, -19199, -19292, -19317, -19281, -19191, -19053, -18876, -18669, -18441, -18200, -17955, -17713, -17481, -17267, -17076, -16908, -16770, -16661, -16582, -16532, -16506, -16505, -16522, -16553, -16592, -16633, -16668, -16693, -16700, -16683, -16638, -16557, -16440, -16279, -16077, -15831, -15540, -15209, -14842, -14440, -14015, -13570, -13116, -12663, -12219, -11796, -11406, -11057, -10760, -10524, -10356, -10261, -10247, -10313, -10461, -10690, -10996, -11374, -11817, -12318, -12865, -13446, -14053, -14672, -15291, -15898, -16481, -17030, -17534, -17985, -18376, -18701, -18955, -19135, -19240, -19272, -19229, -19118, -18941, -18703, -18414, -18077, -17702, -17296, -16868, -16425, -15977, -15528, -15087, -14660, -14252, -13864, -13503, -13168, -12861, -12580, -12324, -12091, -11877, -11676, -11486, -11300, -11111, -10915, -10706, -10477, -10223, -9940, -9621, -9261, -8860, -8414, -7919, -7377, -6783, -6142, -5453, -4717, -3939, -3122, -2270, -1390, -467};