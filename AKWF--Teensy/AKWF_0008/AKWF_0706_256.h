/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0706 256 samples */
 
const int16_t AKWF_0706_256_DATA [256] = 
{1075, 2638, 4168, 5704, 7239, 8774, 10312, 11846, 13382, 14921, 16455, 17992, 19529, 21063, 22600, 24137, 25671, 27208, 28578, 31023, 28835, 8931, 10226, 11895, 13384, 14918, 16456, 17992, 19526, 20638, 24467, 13703, -832, 3073, 4166, 5704, 7239, 8774, 10312, 11844, 13127, 16122, -2152, -7899, -4762, -3514, -1976, -439, 1093, 2631, 4168, 5701, 7239, 8776, 10310, 11848, 13384, 14918, 16456, 17992, 19526, 20212, 26334, 3272, -27337, -21063, -20410, -18871, -17337, -15801, -14263, -12729, -11193, -9655, -8122, -6584, -5047, -3513, -1976, -439, 1093, 2631, 4168, 5701, 7239, 8777, 10310, 11848, 13384, 14918, 16456, 17992, 19526, 20639, 24467, 13703, -832, 3072, 4166, 5704, 7239, 8774, 10312, 11843, 13127, 16122, -2152, -7899, -4761, -3513, -1976, -439, 1093, 2631, 4168, 5702, 7240, 8777, 10310, 11848, 13385, 14918, 16456, 17992, 19526, 20213, 26334, 3272, -27337, -21063, -20410, -18871, -17337, -15801, -14264, -12730, -11193, -9656, -8122, -6585, -5047, -3514, -1976, -439, 1093, 2631, 4000, 6446, 4258, -15645, -14350, -12681, -11191, -9658, -8120, -6584, -5050, -3937, -109, -10873, -25408, -21504, -20410, -18871, -17337, -15801, -14264, -12729, -11193, -9656, -8122, -6584, -5047, -3514, -1976, -439, 1093, 2631, 4168, 5701, 7239, 8776, 10310, 11848, 13384, 14918, 16456, 17992, 19526, 20212, 26334, 3272, -27337, -21063, -20410, -18871, -17337, -15801, -14263, -12729, -11193, -9655, -8122, -6584, -5047, -3513, -1976, -439, 1093, 2631, 4001, 6446, 4258, -15645, -14350, -12681, -11192, -9658, -8120, -6584, -5050, -3938, -110, -10873, -25408, -21504, -20410, -18871, -17337, -15801, -14263, -12732, -11448, -8455, -26728, -32475, -29339, -28090, -26553, -25015, -23482, -21945, -20408, -18874, -17337, -15800, -14266, -12727, -11192, -9658, -8120, -6584, -5050, -3514, -1984, -420};