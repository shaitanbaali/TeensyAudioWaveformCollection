/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0718 256 samples */
 
const int16_t AKWF_0718_256_DATA [256] = 
{896, 2525, 4044, 5500, 6895, 8236, 9525, 10762, 11955, 13105, 14210, 15276, 16304, 17293, 18247, 19167, 20050, 20901, 21719, 22503, 23258, 23982, 24673, 25337, 25969, 26571, 27146, 27691, 28206, 28695, 29153, 29585, 29989, 30364, 30712, 31034, 31326, 31592, 31831, 32042, 32226, 32384, 32514, 32618, 32694, 32647, 33160, 29540, 23900, 20988, 18358, 16088, 14035, 12150, 10401, 8752, 7196, 5719, 4307, 2956, 1661, 411, -789, -1948, -3072, -4156, -5206, -6224, -7211, -8167, -9097, -9997, -10872, -11722, -12546, -13347, -14125, -14878, -15611, -16322, -17009, -17677, -18325, -18950, -19557, -20145, -20711, -21259, -21787, -22296, -22788, -23260, -23712, -24148, -24565, -24963, -25344, -25707, -26052, -26380, -26689, -26980, -27255, -27512, -27751, -27974, -28179, -28367, -28537, -28690, -28826, -28945, -29047, -29131, -29199, -29249, -29192, -29649, -27414, -20418, -16722, -13649, -10984, -8606, -6435, -4418, -2536, -762, 920, 2517, 4041, 5500, 6895, 8236, 9525, 10762, 11955, 13105, 14210, 15276, 16304, 17293, 18247, 19167, 20050, 20901, 21719, 22503, 23258, 23982, 24673, 25337, 25969, 26571, 27146, 27691, 28206, 28695, 29154, 29585, 29989, 30364, 30712, 31034, 31326, 31592, 31831, 32042, 32226, 32384, 32514, 32618, 32694, 32647, 33160, 29540, 23900, 20988, 18359, 16088, 14035, 12150, 10401, 8752, 7196, 5719, 4307, 2956, 1661, 411, -789, -1948, -3072, -4156, -5206, -6224, -7211, -8167, -9097, -9997, -10872, -11722, -12546, -13347, -14125, -14878, -15611, -16322, -17009, -17677, -18325, -18950, -19557, -20145, -20711, -21259, -21787, -22296, -22787, -23259, -23712, -24148, -24565, -24963, -25344, -25707, -26052, -26380, -26689, -26980, -27255, -27512, -27751, -27974, -28179, -28367, -28537, -28690, -28826, -28945, -29047, -29131, -29199, -29249, -29192, -29649, -27414, -20418, -16722, -13649, -10984, -8606, -6435, -4421, -2543, -740};