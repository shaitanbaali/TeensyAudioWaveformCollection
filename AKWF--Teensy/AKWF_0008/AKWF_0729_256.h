/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0729 256 samples */
 
const int16_t AKWF_0729_256_DATA [256] = 
{787, 2109, 3406, 4704, 6002, 7311, 8562, 10537, 11888, 12870, 13926, 14971, 16017, 17060, 18106, 19150, 20193, 21238, 22281, 23323, 24367, 25410, 26451, 27494, 28513, 29654, 30090, 29016, 27966, 26916, 25864, 24813, 23758, 22706, 21654, 20599, 19547, 18470, 17469, 16395, 1670, -2113, -2526, -4816, 1481, 4028, -304, -1601, -2728, -3897, -5059, -6218, -7379, -8539, -9696, -10857, -12017, -13173, -14333, -15490, -16647, -17806, -18962, -20117, -21276, -22431, -23586, -24743, -25897, -27051, -28208, -29360, -30498, -31715, -32562, -31576, -30371, -29220, -28054, -26887, -25724, -24558, -23391, -22228, -21061, -19896, -18732, -17567, -16402, -15239, -14073, -12909, -11746, -10580, -9417, -8255, -7090, -5928, -4767, -3603, -2442, -1293, -70, 553, 500, 515, 517, 519, 520, 521, 522, 524, 525, 526, 526, 527, 527, 527, 529, 530, 529, 530, 531, 531, 531, 530, 531, 532, 532, 532, 532, 532, 532, 532, 532, 532, 532, 532, 532, 532, 532, 532, 532, 531, 530, 531, 531, 531, 531, 531, 531, 531, 531, 531, 531, 530, 529, 530, 530, 530, 530, 530, 530, 530, 530, 528, 527, 528, 528, 528, 528, 528, 527, 528, 527, 526, 527, 527, 527, 527, 527, 526, 527, 526, 525, 526, 526, 526, 526, 526, 526, 526, 525, 524, 525, 525, 525, 525, 525, 524, 534, 499, 664, 1832, 3118, 4374, 5639, 6904, 8165, 9431, 10606, 12348, 11648, 1485, 2442, 3605, 4672, 5655, 7317, 5766, -1133, -1980, -3109, -5670, 1607, 7726, 6347, 6362, 6161, 5960, 5758, 5557, 5283, 5466, 3448, -1186, 971, 1488, -95, -1280, -2508, 867, 2727, 3691, 5986, -1278, -5450, -4291, -4202, -3949, -3696, -3413, -3319, -2409, 1425, 12};