/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0794 256 samples */
 
const int16_t AKWF_0794_256_DATA [256] = 
{114, 370, 625, 878, 1133, 1390, 1649, 1909, 2170, 2433, 2698, 2965, 3233, 3496, 3901, 3406, 8202, 11233, 8108, 8098, 7809, 7532, 7261, 6990, 6723, 6455, 6190, 5926, 5663, 5402, 5140, 5041, 3931, 11067, 18388, 19947, 21658, 23001, 24163, 25198, 26140, 27007, 27815, 28574, 29293, 29973, 30625, 31250, 31837, 32476, 32579, 31942, 31357, 30765, 30172, 29573, 28973, 28371, 27759, 27144, 26520, 25887, 25243, 24588, 23918, 23232, 22529, 21801, 21051, 20270, 19451, 18590, 17673, 16684, 15599, 14346, 13124, 5372, 3872, 4814, 5190, 5658, 6129, 6599, 7073, 7549, 8019, 8484, 8943, 9393, 9838, 10269, 10638, 11480, 5352, 2738, 2875, 2414, 2049, 1689, 1336, 987, 642, 303, -32, -363, -689, -1012, -1329, -1643, -1953, -2260, -2563, -2863, -3159, -3450, -3740, -4026, -4308, -4588, -4864, -5137, -5410, -5677, -5941, -6204, -6462, -6719, -6975, -7226, -7474, -7722, -7966, -8209, -8449, -8686, -8923, -9156, -9387, -9616, -9843, -10069, -10293, -10515, -10733, -10952, -11167, -11381, -11595, -11805, -12014, -12220, -12426, -12631, -12834, -13034, -13233, -13432, -13628, -13823, -14017, -14209, -14400, -14589, -14778, -14966, -15152, -15335, -15518, -15702, -15881, -16060, -16241, -16416, -16591, -16770, -16948, -16857, -16644, -16460, -16270, -16078, -15887, -15695, -15502, -15308, -15116, -14923, -14728, -14532, -14338, -14142, -13944, -13748, -13550, -13353, -13154, -12955, -12755, -12556, -12354, -12153, -11951, -11748, -11547, -11342, -11137, -10933, -10727, -10521, -10314, -10107, -9899, -9689, -9481, -9270, -9058, -8847, -8633, -8421, -8206, -7991, -7776, -7560, -7341, -7123, -6905, -6686, -6464, -6245, -6022, -5798, -5574, -5350, -5123, -4896, -4667, -4438, -4208, -3976, -3744, -3513, -3278, -3043, -2807, -2570, -2331, -2091, -1851, -1609, -1365, -1120, -875, -628, -383, -129};