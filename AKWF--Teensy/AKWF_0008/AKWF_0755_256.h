/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0755 256 samples */
 
const int16_t AKWF_0755_256_DATA [256] = 
{1756, 8094, 11011, 10538, 11727, 18154, 14677, 969, 8841, 10863, 10541, 10956, 15443, 8347, -9804, -9816, -11188, 331, 7955, -4761, -6963, -6918, -11371, -10485, -11256, -15910, -20984, -25165, -28944, -32167, -31890, -27930, -24134, -19729, -14699, -10616, -10520, -10762, -7546, -2526, -634, -1252, -1043, -1108, 1926, 7937, 11152, 8837, 3582, 9768, 11139, 10362, 12310, 17498, 22194, 26220, 29943, 31272, 27665, 23612, 19277, 14218, 10451, 10617, 10634, 7300, 1911, -1613, -1101, -1147, -1178, -1174, -1180, -1180, -1186, -1188, -1189, -1192, -1194, -1195, -1196, -1196, -1200, -1199, -1200, -1201, -1201, -1200, -1201, -1205, -1206, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1205, -1206, -1205, -1201, -1200, -1201, -1200, -1200, -1200, -1200, -1200, -1200, -1201, -1200, -1200, -1201, -1200, -1200, -1200, -1200, -1201, -1200, -1196, -1195, -1196, -1195, -1195, -1195, -1195, -1196, -1195, -1193, -1194, -1194, -1193, -1193, -1193, -1193, -1194, -1191, -1191, -1191, -1190, -1191, -1190, -1190, -1191, -1189, -1188, -1189, -1188, -1188, -1188, -1188, -1189, -1188, -1186, -1187, -1186, -1186, -1186, -1186, -1187, -1186, -1184, -1183, -1184, -1183, -1183, -1183, -1183, -1184, -1183, -1180, -1181, -1182, -1181, -1181, -1181, -1182, -1180, -1179, -1180, -1179, -1179, -1179, -1179, -1179, -1180, -1177, -1176, -1177, -1176, -1176, -1176, -1176, -1177, -1174, -1172, -1174, -1173, -1175, -1174, -1175, -1174, -1172, -1171, -1172, -1171, -1171, -1171, -1171, -1171, -1172, -1169, -1167, -1168, -1167, -1167, -1167, -1167, -1168, -1167, -1165, -1164, -1165, -1164, -1164, -1164, -1164, -1165, -1164, -1163, -1165, -1164, -1164, -1164, -1165, -1164, -1162, -1160, -1161, -1160, -1160, -1160, -1160, -1156, -1181, -1010};