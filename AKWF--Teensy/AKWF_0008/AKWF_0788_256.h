/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0788 256 samples */
 
const int16_t AKWF_0788_256_DATA [256] = 
{36, 114, 188, 257, 323, 386, 444, 502, 557, 608, 657, 703, 748, 791, 830, 869, 908, 941, 975, 1007, 1037, 1065, 1091, 1116, 1142, 1167, 1188, 1209, 1230, 1248, 1266, 1283, 1299, 1314, 1329, 1343, 1355, 1366, 1378, 1389, 1399, 1408, 1416, 1424, 1430, 1436, 1442, 1448, 1452, 1457, 1461, 1463, 1465, 1467, 1467, 1466, 1469, 1534, 1617, 1688, 1753, 1812, 1865, 1913, 1956, 1995, 2030, 2062, 2091, 2118, 2141, 2163, 2183, 2199, 2215, 2230, 2242, 2254, 2263, 2272, 2282, 2295, 2320, 2381, 2498, 2700, 3010, 3437, 3957, 4528, 5109, 5660, 6156, 6563, 6853, 7020, 7084, 7086, 7076, 7087, 7137, 7225, 7333, 7430, 7489, 7491, 7422, 7292, 7122, 6921, 6687, 6408, 6070, 5672, 5224, 4748, 4274, 3838, 3469, 3197, 3046, 3039, 3189, 3509, 4000, 4663, 5488, 6463, 7581, 8826, 10183, 11646, 13198, 14832, 16539, 18295, 20084, 21880, 23636, 25324, 26909, 28356, 29646, 30758, 31661, 32321, 32696, 32760, 32507, 31957, 31143, 30106, 28887, 27521, 26028, 24434, 22754, 20995, 19178, 17306, 15383, 13421, 11427, 9395, 7343, 5265, 3163, 1051, -1076, -3219, -5365, -7520, -9674, -11808, -13917, -15975, -17957, -19850, -21625, -23268, -24770, -26116, -27299, -28323, -29183, -29881, -30424, -30814, -31060, -31168, -31144, -30999, -30737, -30367, -29897, -29334, -28685, -27958, -27161, -26305, -25397, -24449, -23475, -22480, -21477, -20478, -19487, -18510, -17556, -16629, -15730, -14862, -14026, -13227, -12463, -11733, -11036, -10375, -9746, -9149, -8584, -8047, -7540, -7059, -6604, -6174, -5767, -5382, -5019, -4673, -4348, -4042, -3751, -3474, -3215, -2970, -2737, -2516, -2306, -2110, -1923, -1746, -1577, -1420, -1269, -1125, -992, -861, -740, -624, -515, -410, -311, -218, -128, -41};