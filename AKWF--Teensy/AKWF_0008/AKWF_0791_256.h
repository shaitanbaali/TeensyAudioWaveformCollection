/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0791 256 samples */
 
const int16_t AKWF_0791_256_DATA [256] = 
{261, 660, 1038, 1405, 1759, 2101, 2428, 2741, 3041, 3329, 3605, 3869, 4121, 4377, 4674, 4919, 5220, 7018, 9321, 11472, 13604, 15602, 17443, 19182, 20816, 22316, 23688, 24786, 25813, 27775, 28975, 30038, 30730, 31359, 31841, 32211, 32433, 32502, 32531, 32438, 32485, 32568, 32636, 32671, 32694, 32737, 32769, 32725, 32565, 32320, 32058, 31815, 31549, 31204, 30778, 30265, 29766, 29264, 28709, 28103, 27508, 27006, 26637, 26367, 26135, 25917, 25729, 25590, 25477, 25221, 24804, 24337, 23837, 23345, 22794, 22193, 21503, 20739, 19957, 19170, 18353, 17456, 16541, 15724, 14944, 14330, 13676, 12970, 12707, 12188, 11785, 11441, 11087, 10678, 10237, 9812, 9432, 9082, 8707, 8278, 7804, 7248, 6598, 5901, 5106, 4215, 3170, 2361, 1806, 1366, 1047, 879, 736, 700, 738, 940, 598, -237, -326, -862, -965, -1225, -1445, -1701, -2041, -2426, -2847, -3280, -3727, -4206, -4728, -5338, -5981, -6503, -7035, -7488, -7892, -8284, -8674, -9061, -9425, -9758, -10078, -10410, -10785, -11211, -11675, -12143, -12598, -13031, -13457, -13904, -14389, -14918, -15439, -15963, -16499, -17022, -17551, -18098, -18669, -19246, -19802, -20313, -20756, -21137, -21465, -21764, -22044, -22311, -22563, -22762, -22840, -22919, -22987, -23053, -23130, -23228, -23339, -23453, -23556, -23637, -23698, -23716, -23721, -23774, -23832, -23900, -23976, -24052, -24123, -24176, -24217, -24249, -24277, -24306, -24340, -24326, -24357, -24422, -24356, -24262, -24134, -23962, -23744, -23485, -23204, -22531, -22319, -22232, -21869, -21465, -21041, -20599, -20146, -19673, -19194, -18707, -18212, -17719, -17231, -16747, -16266, -15782, -15299, -14811, -14314, -13805, -13287, -12760, -12222, -11680, -11133, -10582, -10034, -9491, -8953, -8426, -7904, -7392, -6891, -6395, -5907, -5423, -4936, -4452, -3988, -3524, -3082, -2665, -2241, -1812, -1384, -961, -546, -130};