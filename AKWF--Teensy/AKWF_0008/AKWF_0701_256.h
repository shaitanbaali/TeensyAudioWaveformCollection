/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0701 256 samples */
 
const int16_t AKWF_0701_256_DATA [256] = 
{4413, 11252, 13172, 14838, 16008, 16894, 17578, 18107, 18511, 18812, 19029, 18382, 22841, 1672, -31827, -22682, -20568, -17915, -15590, -13505, -11600, -9850, -8236, -6733, -5333, -4027, -2802, -1654, -580, 430, 1378, 2269, 3107, 3891, 4627, 5318, 5963, 6565, 7129, 7652, 8138, 8589, 9003, 9385, 9735, 10053, 10341, 10600, 10829, 11030, 11206, 11355, 11479, 11577, 11652, 11683, 11802, 11304, 9770, 8824, 8010, 7288, 6631, 6023, 5452, 4916, 4405, 3921, 3457, 3014, 2588, 2179, 1786, 1406, 1040, 688, 346, 17, -299, -608, -905, -1193, -1471, -1740, -2000, -2251, -2494, -2729, -2957, -3174, -3385, -3588, -3784, -3973, -4155, -4329, -4497, -4657, -4811, -4959, -5099, -5234, -5362, -5484, -5600, -5709, -5814, -5912, -6003, -6090, -6169, -6245, -6314, -6378, -6436, -6489, -6536, -6579, -6615, -6646, -6673, -6694, -6710, -6722, -6728, -6729, -6728, -6727, -6727, -6724, -6723, -6722, -6721, -6720, -6718, -6717, -6717, -6715, -6713, -6713, -6711, -6711, -6709, -6707, -6707, -6706, -6704, -6703, -6703, -6701, -6699, -6698, -6697, -6697, -6695, -6693, -6693, -6691, -6689, -6687, -6686, -6686, -6684, -6682, -6682, -6680, -6680, -6678, -6676, -6676, -6675, -6673, -6672, -6671, -6670, -6670, -6668, -6666, -6666, -6664, -6662, -6662, -6661, -6659, -6658, -6656, -6656, -6656, -6654, -6652, -6652, -6651, -6649, -6648, -6646, -6646, -6645, -6643, -6642, -6640, -6638, -6639, -6636, -6635, -6635, -6633, -6631, -6631, -6629, -6629, -6628, -6625, -6625, -6625, -6624, -6621, -6621, -6620, -6618, -6617, -6616, -6615, -6615, -6613, -6611, -6611, -6611, -6609, -6607, -6605, -6605, -6605, -6604, -6602, -6601, -6600, -6598, -6597, -6597, -6596, -6595, -6592, -6590, -6590, -6588, -6588, -6588, -6559, -6697, -5777, -4207, -3301, -2463, -1711, -1021, -361};