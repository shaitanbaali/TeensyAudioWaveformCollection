/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0731 256 samples */
 
const int16_t AKWF_0731_256_DATA [256] = 
{1553, 4179, 6752, 9332, 11909, 14490, 17074, 19650, 22229, 24812, 27364, 30011, 32296, 30528, 27779, 25233, 22651, 20063, 17475, 14894, 12304, 9717, 7135, 4551, 1977, -668, -1534, -1405, -1438, -1440, -1442, -1444, -1445, -1446, -1448, -1449, -1450, -1451, -1452, -1452, -1453, -1453, -1454, -1453, -1454, -1453, -1454, -1454, -1455, -1454, -1455, -1454, -1453, -1454, -1453, -1453, -1453, -1454, -1453, -1452, -1453, -1452, -1453, -1452, -1451, -1452, -1451, -1451, -1450, -1451, -1450, -1449, -1450, -1449, -1446, -1452, -1411, -1293, -1179, -1064, -949, -834, -719, -605, -490, -375, -260, -147, -25, 49, -54, -172, -285, -400, -514, -628, -742, -857, -971, -1085, -1199, -1315, -1424, -1443, -1440, -1441, -1440, -1440, -1439, -1440, -1439, -1439, -1438, -1439, -1438, -1437, -1438, -1438, -1437, -1436, -1437, -1436, -1434, -1435, -1434, -1433, -1434, -1433, -1433, -1433, -1432, -1432, -1431, -1432, -1431, -1430, -1431, -1430, -1429, -1430, -1428, -1427, -1428, -1432, -1410, -1817, -2495, -3130, -3774, -4418, -5060, -5704, -6347, -6990, -7634, -8277, -8904, -9616, -9708, -9007, -8372, -7728, -7082, -6436, -5790, -5144, -4498, -3853, -3207, -2568, -1897, -1402, -1393, -1395, -1392, -1391, -1390, -1390, -1389, -1387, -1387, -1386, -1386, -1385, -1384, -1384, -1383, -1383, -1383, -1381, -1380, -1380, -1380, -1379, -1379, -1378, -1379, -1378, -1378, -1377, -1376, -1377, -1375, -1374, -1375, -1374, -1373, -1374, -1373, -1372, -1373, -1372, -1371, -1372, -1371, -1370, -1371, -1370, -1369, -1370, -1369, -1360, -1346, -1333, -1320, -1306, -1294, -1280, -1267, -1254, -1241, -1228, -1215, -1200, -1199, -1213, -1225, -1238, -1250, -1263, -1275, -1287, -1300, -1312, -1324, -1337, -1350, -1359, -1358, -1359, -1358, -1357, -1358, -1338, -1440, -889};