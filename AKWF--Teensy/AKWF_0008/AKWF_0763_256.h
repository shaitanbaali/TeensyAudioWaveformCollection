/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0763 256 samples */
 
const int16_t AKWF_0763_256_DATA [256] = 
{454, 1771, 3291, 5035, 6984, 9118, 11403, 13785, 16222, 18656, 21022, 23277, 25368, 27247, 28886, 30254, 31328, 32105, 32581, 32767, 32682, 32349, 31799, 31060, 30166, 29151, 28036, 26852, 25622, 24362, 23091, 21824, 20569, 19339, 18138, 16971, 15846, 14762, 13721, 12727, 11778, 10872, 10014, 9197, 8423, 7691, 6997, 6342, 5725, 5141, 4590, 4072, 3583, 3123, 2690, 2282, 1898, 1538, 1198, 878, 579, 296, 32, -216, -450, -670, -877, -1071, -1251, -1420, -1575, -1717, -1847, -1961, -2062, -2146, -2215, -2269, -2306, -2327, -2334, -2326, -2305, -2273, -2233, -2187, -2138, -2088, -2041, -1998, -1962, -1934, -1916, -1908, -1911, -1926, -1950, -1986, -2029, -2081, -2138, -2201, -2268, -2337, -2409, -2481, -2553, -2624, -2693, -2762, -2829, -2893, -2955, -3015, -3072, -3126, -3178, -3227, -3274, -3318, -3360, -3400, -3437, -3472, -3505, -3537, -3566, -3594, -3619, -3644, -3668, -3689, -3709, -3728, -3746, -3763, -3784, -3808, -3841, -3889, -3955, -4048, -4172, -4335, -4541, -4796, -5101, -5462, -5877, -6346, -6863, -7421, -8012, -8619, -9234, -9839, -10419, -10967, -11466, -11909, -12288, -12594, -12827, -12985, -13068, -13082, -13030, -12919, -12759, -12555, -12317, -12050, -11763, -11462, -11151, -10835, -10519, -10204, -9893, -9589, -9294, -9007, -8732, -8466, -8212, -7969, -7737, -7517, -7307, -7108, -6920, -6741, -6572, -6413, -6262, -6120, -5986, -5859, -5740, -5629, -5522, -5422, -5328, -5241, -5157, -5079, -5005, -4936, -4871, -4809, -4751, -4697, -4646, -4598, -4552, -4509, -4468, -4428, -4391, -4354, -4319, -4284, -4251, -4217, -4185, -4152, -4120, -4088, -4057, -4027, -3997, -3969, -3942, -3917, -3894, -3872, -3853, -3835, -3820, -3806, -3795, -3786, -3778, -3773, -3767, -3761, -3748, -3720, -3662, -3558, -3383, -3115, -2729, -2201, -1508, -603};