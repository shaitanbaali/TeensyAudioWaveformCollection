/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0757 256 samples */
 
const int16_t AKWF_0757_256_DATA [256] = 
{188, 771, 1293, 1767, 2193, 2572, 2904, 3190, 3437, 3648, 3832, 3996, 4146, 4291, 4437, 4590, 4753, 4929, 5122, 5331, 5558, 5804, 6068, 6354, 6665, 6999, 7360, 7749, 8165, 8612, 9087, 9588, 10118, 10671, 11247, 11844, 12460, 13091, 13735, 14388, 15054, 15725, 16399, 17075, 17754, 18431, 19103, 19775, 20436, 21093, 21742, 22378, 23006, 23622, 24223, 24813, 25389, 25950, 26495, 27025, 27534, 28016, 28463, 28861, 29193, 29440, 29590, 29627, 29543, 29331, 28989, 28522, 27933, 27222, 26389, 25437, 24361, 23165, 21844, 20403, 18851, 17191, 15436, 13608, 11712, 9775, 7822, 5865, 3933, 2050, 223, -1522, -3177, -4736, -6187, -7529, -8762, -9881, -10893, -11801, -12602, -13309, -13921, -14447, -14889, -15253, -15546, -15770, -15932, -16037, -16088, -16089, -16047, -15965, -15843, -15689, -15505, -15292, -15054, -14794, -14516, -14219, -13906, -13582, -13245, -12898, -12546, -12184, -11818, -11447, -11075, -10700, -10325, -9951, -9577, -9206, -8838, -8472, -8113, -7757, -7405, -7062, -6723, -6392, -6069, -5752, -5444, -5145, -4856, -4575, -4308, -4058, -3829, -3628, -3461, -3335, -3252, -3217, -3230, -3298, -3415, -3585, -3804, -4069, -4379, -4729, -5119, -5540, -5994, -6477, -6984, -7512, -8061, -8626, -9203, -9794, -10394, -11003, -11616, -12234, -12855, -13477, -14099, -14720, -15339, -15954, -16568, -17176, -17778, -18376, -18964, -19547, -20124, -20691, -21249, -21799, -22341, -22874, -23396, -23909, -24413, -24906, -25387, -25859, -26321, -26772, -27212, -27641, -28059, -28467, -28863, -29247, -29621, -29984, -30334, -30674, -31003, -31319, -31624, -31913, -32177, -32409, -32597, -32722, -32769, -32727, -32581, -32324, -31953, -31457, -30824, -30049, -29122, -28039, -26809, -25441, -23956, -22386, -20754, -19094, -17437, -15799, -14207, -12682, -11229, -9861, -8583, -7390, -6284, -5259, -4304, -3414, -2587, -1814, -1096, -416};