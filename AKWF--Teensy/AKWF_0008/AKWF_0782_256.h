/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0782 256 samples */
 
const int16_t AKWF_0782_256_DATA [256] = 
{2368, 8644, 13137, 16594, 19298, 21455, 23203, 24631, 25819, 26819, 27661, 28381, 28997, 29529, 29991, 30391, 30741, 31047, 31315, 31548, 31754, 31933, 32088, 32224, 32341, 32440, 32525, 32595, 32652, 32697, 32731, 32753, 32765, 32767, 32761, 32745, 32720, 32686, 32644, 32594, 32534, 32467, 32392, 32307, 32215, 32113, 32003, 31885, 31756, 31618, 31470, 31313, 31145, 30966, 30776, 30574, 30362, 30136, 29898, 29647, 29382, 29103, 28810, 28501, 28177, 27836, 27480, 27106, 26716, 26307, 25879, 25436, 24971, 24487, 23986, 23465, 22924, 22366, 21788, 21192, 20579, 19947, 19299, 18637, 17960, 17269, 16568, 15856, 15137, 14412, 13680, 12950, 12220, 11490, 10768, 10052, 9347, 8655, 7981, 7322, 6685, 6068, 5477, 4913, 4376, 3868, 3392, 2945, 2530, 2152, 1801, 1484, 1199, 945, 720, 526, 358, 216, 98, 2, -74, -135, -179, -211, -232, -244, -251, -253, -252, -253, -257, -266, -283, -309, -347, -402, -469, -556, -663, -795, -950, -1132, -1342, -1582, -1850, -2153, -2487, -2851, -3249, -3679, -4139, -4631, -5152, -5700, -6277, -6879, -7502, -8148, -8811, -9489, -10185, -10889, -11603, -12323, -13046, -13770, -14494, -15213, -15928, -16635, -17332, -18018, -18693, -19350, -19995, -20623, -21232, -21826, -22401, -22955, -23493, -24010, -24507, -24986, -25446, -25885, -26307, -26710, -27094, -27462, -27812, -28145, -28462, -28762, -29047, -29318, -29573, -29815, -30044, -30259, -30462, -30652, -30831, -30999, -31156, -31302, -31438, -31563, -31679, -31786, -31884, -31973, -32053, -32123, -32186, -32240, -32287, -32324, -32353, -32374, -32386, -32390, -32384, -32369, -32345, -32311, -32266, -32211, -32144, -32064, -31970, -31861, -31737, -31594, -31433, -31250, -31042, -30807, -30541, -30239, -29896, -29506, -29059, -28548, -27958, -27274, -26479, -25541, -24432, -23106, -21496, -19523, -17070, -13962, -9968, -4447};