/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0771 256 samples */
 
const int16_t AKWF_0771_256_DATA [256] = 
{653, 2657, 4595, 6510, 8388, 10218, 11995, 13709, 15359, 16940, 18444, 19874, 21223, 22488, 23676, 24782, 25801, 26744, 27608, 28393, 29104, 29743, 30310, 30810, 31245, 31617, 31933, 32191, 32395, 32553, 32664, 32734, 32766, 32762, 32730, 32672, 32588, 32484, 32364, 32234, 32092, 31948, 31802, 31654, 31507, 31369, 31239, 31115, 31002, 30898, 30806, 30723, 30648, 30582, 30519, 30462, 30405, 30345, 30281, 30205, 30111, 29997, 29855, 29682, 29470, 29215, 28909, 28546, 28121, 27630, 27062, 26420, 25693, 24879, 23974, 22975, 21878, 20686, 19393, 18002, 16516, 14935, 13262, 11512, 9677, 7774, 5819, 3809, 1765, -296, -2371, -4437, -6481, -8490, -10445, -12334, -14145, -15858, -17468, -18966, -20338, -21585, -22695, -23665, -24499, -25191, -25743, -26161, -26443, -26595, -26619, -26522, -26310, -25980, -25542, -25003, -24362, -23630, -22813, -21913, -20940, -19905, -18809, -17666, -16484, -15272, -14044, -12807, -11568, -10349, -9154, -7992, -6877, -5812, -4805, -3868, -2999, -2205, -1492, -856, -301, 172, 564, 878, 1121, 1293, 1395, 1434, 1413, 1342, 1216, 1045, 834, 588, 312, 11, -310, -646, -995, -1353, -1716, -2077, -2440, -2797, -3146, -3485, -3814, -4133, -4440, -4735, -5016, -5285, -5543, -5788, -6023, -6249, -6461, -6664, -6858, -7045, -7224, -7395, -7557, -7715, -7866, -8009, -8151, -8291, -8429, -8569, -8713, -8865, -9031, -9212, -9413, -9636, -9886, -10168, -10487, -10843, -11242, -11687, -12177, -12717, -13308, -13946, -14634, -15370, -16148, -16966, -17820, -18704, -19613, -20540, -21474, -22411, -23343, -24259, -25156, -26017, -26835, -27608, -28321, -28972, -29553, -30054, -30474, -30808, -31049, -31196, -31245, -31195, -31045, -30791, -30432, -29969, -29399, -28726, -27945, -27059, -26069, -24975, -23780, -22487, -21097, -19616, -18050, -16402, -14680, -12896, -11049, -9156, -7227, -5270, -3301, -1279};