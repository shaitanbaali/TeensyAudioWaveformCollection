/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0751 256 samples */
 
const int16_t AKWF_0751_256_DATA [256] = 
{919, 2547, 4242, 5337, 5301, 5313, 5297, 5385, 6042, 6776, 7490, 8210, 8930, 9648, 10368, 11088, 11805, 12525, 13245, 13963, 14682, 15403, 16122, 16840, 17559, 18278, 18998, 19718, 20436, 21150, 21895, 22474, 22498, 22488, 22500, 22463, 21697, 20722, 19788, 18848, 17906, 16963, 16023, 15080, 14138, 13198, 12256, 11314, 10375, 9432, 8490, 7550, 6607, 5665, 4725, 3782, 2841, 1906, 945, 91, -17, 6, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 11, -39, 537, 1646, 2684, 3737, 4790, 5841, 6892, 7946, 8997, 10050, 11102, 12153, 13206, 14259, 15309, 16362, 17415, 18466, 19518, 20572, 21621, 22674, 23720, 24803, 25180, 25125, 25137, 25137, 25137, 25122, 25192, 24645, 23277, 21972, 20660, 19347, 18032, 16718, 15405, 14089, 12776, 11463, 10147, 8835, 7521, 6205, 4891, 3577, 2262, 951, -364, -1679, -2990, -4301, -5639, -6703, -7506, -8341, -9167, -9996, -10825, -11652, -12481, -13310, -14136, -14966, -15793, -16621, -17450, -18276, -19104, -19932, -20761, -21588, -22418, -23245, -24072, -24884, -25788, -25855, -24733, -23651, -22563, -21472, -20383, -19293, -18202, -17113, -16022, -14932, -13844, -12753, -11662, -10574, -9482, -8392, -7304, -6212, -5122, -4034, -2942, -1865, -721, 18, -6, -2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, -11, 33, -865, -2335, -3713, -5111, -6508, -7902, -9300, -10697, -12091, -13491, -14885, -16281, -17679, -19075, -20471, -21868, -23263, -24660, -26058, -27452, -28850, -30227, -31692, -32710, -31483, -29796, -28197, -26576, -24959, -23340, -21720, -20104, -18484, -16865, -15248, -13628, -12008, -10392, -8770, -7152, -5535, -3918, -2305, -658};