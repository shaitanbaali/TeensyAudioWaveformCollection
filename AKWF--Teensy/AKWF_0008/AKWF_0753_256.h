/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0753 256 samples */
 
const int16_t AKWF_0753_256_DATA [256] = 
{4243, 16597, 24181, 22661, 15178, 11977, 15131, 23536, 30063, 31375, 29600, 28081, 28577, 30479, 32189, 32774, 32504, 32182, 32275, 32606, 32697, 32224, 31242, 30017, 28785, 27584, 26303, 24815, 23088, 21173, 19165, 17111, 15005, 12824, 10559, 8231, 5887, 3547, 1216, -1103, -3435, -5763, -8277, -11039, -13173, -14632, -15921, -17719, -19784, -21839, -23269, -24146, -24882, -25730, -26683, -27543, -28131, -28422, -28525, -28557, -28552, -28462, -28222, -27814, -27269, -26638, -25942, -25172, -24319, -23380, -22368, -21310, -20209, -19070, -17906, -16720, -15523, -14320, -13113, -11915, -10744, -9591, -8469, -7173, -4484, 1187, 12398, 22667, 24177, 17633, 12322, 13325, 20546, 28468, 31442, 30316, 28398, 28185, 29789, 31725, 32708, 32639, 32253, 32198, 32498, 32721, 32449, 31610, 30434, 29191, 27985, 26747, 25341, 23688, 21824, 19844, 17799, 15714, 13563, 11320, 9011, 6670, 4323, 1991, -327, -2660, -4986, -7385, -10155, -12542, -14213, -15441, -17081, -19067, -21205, -22870, -23889, -24633, -25428, -26365, -27281, -27969, -28353, -28503, -28550, -28559, -28506, -28321, -27967, -27462, -26857, -26181, -25437, -24615, -23701, -22712, -21668, -20579, -19453, -18297, -17115, -15924, -14722, -13514, -12313, -11131, -9972, -8842, -7676, -5625, -1205, 8118, 20122, 24675, 20322, 13369, 12292, 17625, 26257, 31035, 30953, 28928, 28010, 29132, 31143, 32517, 32741, 32367, 32164, 32381, 32686, 32608, 31941, 30846, 29602, 28383, 27173, 25836, 24264, 22466, 20512, 18483, 16417, 14290, 12074, 9790, 7451, 5103, 2770, 444, -1883, -4210, -6554, -9217, -11834, -13730, -15025, -16474, -18379, -20509, -22395, -23603, -24390, -25146, -26044, -26992, -27773, -28257, -28471, -28540, -28560, -28536, -28401, -28104, -27644, -27067, -26412, -25694, -24898, -24014, -23050, -22021, -20946, -19834, -18685, -17511, -16323, -15122, -13916, -12713, -11521, -10356, -9215, -8103, -6578, -2831};