/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0704 256 samples */
 
const int16_t AKWF_0704_256_DATA [256] = 
{507, 1288, 2045, 2795, 3538, 4271, 5000, 5716, 6426, 7131, 7826, 8516, 9200, 9876, 10548, 11214, 11871, 12529, 13179, 13823, 14464, 15101, 15732, 16358, 16979, 17594, 18208, 18810, 19409, 20003, 20590, 21166, 21737, 22298, 22850, 23394, 23921, 24439, 24947, 25437, 25914, 26376, 26817, 27243, 27651, 28036, 28398, 28740, 29058, 29351, 29618, 29858, 30069, 30253, 30406, 30528, 30620, 30679, 30704, 30697, 30655, 30581, 30473, 30329, 30149, 29937, 29689, 29407, 29091, 28740, 28359, 27946, 27498, 27022, 26518, 25982, 25420, 24834, 24222, 23587, 22933, 22256, 21564, 20855, 20131, 19393, 18647, 17893, 17130, 16364, 15594, 14825, 14058, 13292, 12534, 11783, 11038, 10307, 9590, 8886, 8198, 7529, 6875, 6246, 5637, 5051, 4488, 3950, 3438, 2951, 2491, 2056, 1653, 1272, 919, 595, 297, 26, -221, -443, -642, -817, -972, -1106, -1219, -1315, -1393, -1458, -1511, -1550, -1581, -1604, -1622, -1635, -1646, -1658, -1673, -1690, -1712, -1744, -1786, -1838, -1904, -1983, -2082, -2196, -2333, -2488, -2668, -2869, -3096, -3348, -3626, -3932, -4265, -4624, -5012, -5431, -5875, -6345, -6845, -7371, -7923, -8502, -9104, -9728, -10378, -11047, -11735, -12444, -13165, -13902, -14653, -15413, -16183, -16961, -17739, -18523, -19306, -20086, -20862, -21633, -22392, -23142, -23876, -24596, -25298, -25978, -26637, -27271, -27878, -28457, -29006, -29522, -30006, -30455, -30865, -31240, -31576, -31872, -32127, -32339, -32510, -32639, -32724, -32765, -32763, -32718, -32629, -32499, -32325, -32110, -31852, -31556, -31220, -30843, -30429, -29980, -29494, -28975, -28424, -27842, -27230, -26591, -25924, -25236, -24523, -23787, -23034, -22262, -21473, -20673, -19857, -19029, -18195, -17349, -16498, -15642, -14780, -13917, -13054, -12190, -11325, -10466, -9607, -8753, -7902, -7058, -6219, -5389, -4564, -3747, -2930, -2176, -1024, -229};