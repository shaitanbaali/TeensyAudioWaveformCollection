/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0787 256 samples */
 
const int16_t AKWF_0787_256_DATA [256] = 
{53, 177, 299, 424, 547, 677, 806, 938, 1070, 1206, 1343, 1482, 1622, 1762, 1906, 2053, 2199, 2349, 2499, 2652, 2807, 2965, 3123, 3286, 3451, 3615, 3785, 3953, 4125, 4311, 4459, 4719, 8406, 11248, 13166, 14938, 16537, 18028, 19433, 20761, 22028, 23247, 24413, 25537, 26620, 27665, 28673, 29638, 30534, 31321, 31962, 32422, 32693, 32768, 32656, 32369, 31917, 31320, 30593, 29753, 28819, 27798, 26709, 25562, 24365, 23140, 21888, 20615, 19335, 18057, 16777, 15508, 14260, 13030, 11825, 10648, 9496, 8382, 7299, 6249, 5238, 4262, 3325, 2426, 1559, 730, -62, -821, -1542, -2228, -2883, -3506, -4097, -4658, -5188, -5690, -6164, -6609, -7031, -7427, -7797, -8145, -8472, -8776, -9062, -9327, -9574, -9802, -10012, -10207, -10388, -10551, -10699, -10836, -10959, -11067, -11164, -11251, -11327, -11393, -11447, -11491, -11528, -11556, -11576, -11588, -11592, -11590, -11583, -11570, -11549, -11523, -11489, -11453, -11411, -11366, -11311, -11257, -11198, -11135, -11069, -11001, -10930, -10855, -10778, -10698, -10616, -10532, -10447, -10359, -10271, -10180, -10088, -9993, -9898, -9804, -9708, -9610, -9510, -9411, -9314, -9214, -9114, -9013, -8912, -8810, -8711, -8611, -8509, -8407, -8307, -8204, -8101, -8001, -7900, -7799, -7700, -7600, -7502, -7403, -7303, -7204, -7106, -7009, -6912, -6816, -6718, -6621, -6526, -6431, -6336, -6242, -6149, -6055, -5961, -5869, -5777, -5686, -5592, -5501, -5411, -5319, -5228, -5138, -5048, -4957, -4870, -4782, -4691, -4602, -4514, -4423, -4335, -4246, -4155, -4066, -3978, -3889, -3798, -3709, -3619, -3529, -3439, -3348, -3254, -3162, -3071, -2979, -2886, -2793, -2698, -2603, -2510, -2413, -2315, -2215, -2119, -2021, -1921, -1820, -1718, -1615, -1513, -1411, -1303, -1195, -1088, -980, -871, -760, -647, -533, -418, -302, -183, -63};