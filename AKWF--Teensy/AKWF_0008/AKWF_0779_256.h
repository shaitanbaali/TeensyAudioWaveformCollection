/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0779 256 samples */
 
const int16_t AKWF_0779_256_DATA [256] = 
{688, 1877, 3020, 4145, 5245, 6324, 7381, 8412, 9421, 10408, 11369, 12309, 13227, 14118, 14989, 15838, 16661, 17464, 18246, 19002, 19739, 20453, 21144, 21807, 22442, 23050, 23635, 24195, 24730, 25245, 25736, 26206, 26656, 27084, 27493, 27884, 28256, 28610, 28949, 29269, 29572, 29860, 30132, 30389, 30632, 30860, 31074, 31273, 31459, 31633, 31792, 31940, 32074, 32195, 32306, 32405, 32490, 32564, 32627, 32677, 32717, 32744, 32761, 32766, 32760, 32743, 32715, 32675, 32624, 32561, 32487, 32401, 32303, 32194, 32072, 31938, 31794, 31636, 31464, 31282, 31085, 30874, 30651, 30415, 30162, 29896, 29616, 29319, 29008, 28680, 28335, 27973, 27596, 27199, 26784, 26350, 25896, 25422, 24927, 24411, 23872, 23312, 22726, 22117, 21481, 20819, 20132, 19417, 18681, 17924, 17145, 16342, 15521, 14675, 13806, 12918, 12005, 11069, 10112, 9130, 8127, 7102, 6051, 4980, 3888, 2770, 1632, 472, -705, -1873, -3019, -4146, -5246, -6324, -7382, -8412, -9422, -10409, -11369, -12310, -13228, -14119, -14990, -15838, -16662, -17464, -18246, -19003, -19740, -20453, -21144, -21807, -22442, -23050, -23636, -24195, -24731, -25245, -25736, -26206, -26656, -27086, -27494, -27885, -28257, -28611, -28949, -29269, -29572, -29861, -30133, -30389, -30633, -30860, -31074, -31273, -31460, -31633, -31793, -31940, -32074, -32196, -32306, -32404, -32490, -32564, -32627, -32678, -32717, -32744, -32762, -32767, -32761, -32743, -32715, -32675, -32624, -32561, -32487, -32401, -32303, -32194, -32072, -31940, -31794, -31635, -31465, -31282, -31086, -30874, -30651, -30415, -30162, -29896, -29616, -29319, -29008, -28680, -28336, -27973, -27596, -27199, -26784, -26350, -25897, -25422, -24927, -24412, -23873, -23312, -22726, -22117, -21482, -20820, -20133, -19418, -18681, -17924, -17145, -16344, -15521, -14675, -13807, -12919, -12005, -11069, -10113, -9131, -8128, -7103, -6053, -4981, -3889, -2773, -1638, -457};