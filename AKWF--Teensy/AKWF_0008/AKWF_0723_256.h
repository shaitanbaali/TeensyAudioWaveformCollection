/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0723 256 samples */
 
const int16_t AKWF_0723_256_DATA [256] = 
{25441, 25246, 25055, 24864, 24672, 24478, 24283, 24090, 23894, 23700, 23506, 23309, 23113, 22918, 22722, 22525, 22329, 22133, 21935, 21739, 21542, 21344, 21148, 20952, 20754, 20558, 20360, 20163, 19966, 19769, 19572, 19375, 19177, 18980, 18784, 18586, 18390, 18192, 17995, 17798, 17602, 17404, 17209, 17011, 16814, 16618, 16421, 16225, 16028, 15831, 15634, 15438, 15242, 15046, 14849, 14653, 14457, 14260, 14064, 13869, 13673, 13476, 13280, 13084, 12889, 12692, 12498, 12302, 12105, 11910, 11714, 11518, 11323, 11129, 10932, 10738, 10542, 10347, 9925, 10941, 4798, -10508, -10297, -10531, -10777, -10989, -11198, -11410, -11623, -11835, -12050, -12266, -12482, -12701, -12921, -13142, -13366, -13590, -13816, -14046, -14276, -14510, -14746, -14985, -15226, -15470, -15718, -15969, -16225, -16483, -16746, -17014, -17285, -17562, -17845, -18133, -18427, -18727, -19034, -19348, -19670, -20000, -20337, -20684, -21040, -21406, -21783, -22173, -22575, -22988, -23414, -23857, -24313, -24786, -25277, -25783, -26309, -26856, -27420, -28004, -28610, -29230, -29865, -30505, -31134, -31733, -32256, -32638, -32764, -32445, -31369, -28943, -24921, -15129, 8705, 10074, 9447, 9370, 9181, 8992, 8803, 8615, 8425, 8235, 8044, 7853, 7661, 7470, 7277, 7085, 6893, 6702, 6509, 6317, 6124, 5931, 5739, 5545, 5352, 5160, 4966, 4773, 4580, 4387, 4194, 4001, 3807, 3615, 3422, 3228, 3035, 2842, 2649, 2456, 2262, 2069, 1877, 1684, 1490, 1296, 1104, 911, 718, 525, 331, 139, -52, -245, -438, -631, -824, -1017, -1211, -1405, -1596, -1790, -1983, -2176, -2369, -2563, -2755, -2950, -3142, -3336, -3529, -3724, -3917, -4110, -4305, -4499, -4692, -4886, -5081, -5275, -5470, -5665, -5861, -6056, -6252, -6449, -6643, -6839, -7036, -7233, -7430, -7628, -7825, -8023, -8223, -8421, -8622, -8822, -9023, -9224, -9424, -9632};