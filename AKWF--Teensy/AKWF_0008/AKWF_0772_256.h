/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0772 256 samples */
 
const int16_t AKWF_0772_256_DATA [256] = 
{208, 955, 1727, 2545, 3405, 4303, 5238, 6208, 7209, 8239, 9291, 10364, 11454, 12554, 13663, 14775, 15881, 16982, 18070, 19141, 20193, 21215, 22205, 23163, 24082, 24959, 25797, 26588, 27330, 28024, 28668, 29264, 29809, 30304, 30750, 31150, 31500, 31805, 32067, 32283, 32459, 32593, 32687, 32746, 32768, 32756, 32711, 32635, 32526, 32384, 32213, 32013, 31784, 31528, 31244, 30933, 30596, 30232, 29844, 29432, 28994, 28533, 28051, 27549, 27024, 26483, 25923, 25346, 24758, 24157, 23542, 22922, 22290, 21654, 21019, 20381, 19742, 19108, 18479, 17858, 17246, 16641, 16050, 15474, 14912, 14366, 13839, 13330, 12841, 12371, 11923, 11497, 11091, 10710, 10349, 10010, 9691, 9393, 9115, 8855, 8613, 8387, 8175, 7977, 7791, 7610, 7437, 7268, 7100, 6931, 6762, 6581, 6390, 6188, 5968, 5730, 5470, 5185, 4873, 4532, 4157, 3750, 3305, 2821, 2300, 1734, 1128, 480, -213, -947, -1720, -2540, -3401, -4299, -5234, -6202, -7204, -8234, -9285, -10359, -11450, -12549, -13658, -14771, -15877, -16977, -18065, -19136, -20187, -21210, -22200, -23158, -24078, -24955, -25793, -26582, -27324, -28018, -28664, -29259, -29804, -30299, -30746, -31145, -31494, -31800, -32062, -32277, -32452, -32588, -32683, -32741, -32764, -32751, -32706, -32630, -32521, -32379, -32208, -32008, -31779, -31522, -31239, -30928, -30590, -30227, -29839, -29426, -28989, -28527, -28046, -27544, -27020, -26478, -25918, -25342, -24754, -24152, -23538, -22917, -22285, -21649, -21014, -20375, -19736, -19103, -18474, -17853, -17240, -16636, -16045, -15468, -14906, -14360, -13834, -13324, -12835, -12366, -11918, -11492, -11087, -10705, -10344, -10005, -9687, -9388, -9110, -8851, -8609, -8383, -8171, -7973, -7785, -7606, -7434, -7263, -7096, -6927, -6757, -6576, -6385, -6182, -5963, -5727, -5465, -5179, -4868, -4527, -4153, -3745, -3300, -2817, -2295, -1731, -1127, -465};