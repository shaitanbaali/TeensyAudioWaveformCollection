/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0759 256 samples */
 
const int16_t AKWF_0759_256_DATA [256] = 
{117, 553, 977, 1395, 1809, 2218, 2622, 3021, 3415, 3805, 4190, 4570, 4946, 5316, 5682, 6044, 6402, 6755, 7103, 7447, 7788, 8123, 8454, 8781, 9105, 9423, 9738, 10049, 10355, 10658, 10956, 11251, 11542, 11829, 12112, 12391, 12666, 12938, 13206, 13470, 13730, 13986, 14239, 14488, 14734, 14976, 15214, 15449, 15680, 15908, 16132, 16352, 16569, 16783, 16992, 17198, 17402, 17601, 17798, 17990, 18180, 18365, 18547, 18726, 18902, 19075, 19244, 19410, 19572, 19731, 19887, 20039, 20188, 20334, 20476, 20615, 20751, 20884, 21014, 21140, 21262, 21382, 21499, 21612, 21722, 21828, 21932, 22032, 22130, 22223, 22314, 22402, 22486, 22568, 22651, 22740, 22844, 22969, 23121, 23302, 23506, 23726, 23953, 24170, 24367, 24527, 24641, 24699, 24693, 24620, 24474, 24258, 23969, 23608, 23181, 22690, 22136, 21525, 20862, 20148, 19389, 18592, 17756, 16889, 15993, 15069, 14125, 13163, 12182, 11190, 10187, 9174, 8156, 7134, 6106, 5082, 4057, 3032, 2014, 999, -11, -1011, -2007, -2994, -3969, -4936, -5893, -6836, -7770, -8691, -9598, -10494, -11375, -12243, -13097, -13936, -14761, -15572, -16367, -17146, -17912, -18661, -19394, -20113, -20816, -21503, -22174, -22829, -23468, -24091, -24696, -25287, -25862, -26419, -26961, -27487, -27994, -28488, -28965, -29425, -29868, -30295, -30703, -31090, -31449, -31777, -32068, -32315, -32511, -32655, -32741, -32768, -32738, -32649, -32505, -32306, -32058, -31764, -31425, -31048, -30635, -30190, -29716, -29216, -28693, -28152, -27593, -27019, -26434, -25837, -25231, -24620, -24001, -23379, -22755, -22128, -21501, -20874, -20247, -19622, -19000, -18378, -17761, -17148, -16537, -15932, -15332, -14735, -14144, -13558, -12977, -12402, -11832, -11267, -10709, -10157, -9609, -9069, -8533, -8004, -7481, -6962, -6451, -5946, -5444, -4950, -4462, -3977, -3500, -3028, -2562, -2101, -1645, -1196, -752, -305};