/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0740 256 samples */
 
const int16_t AKWF_0740_256_DATA [256] = 
{1266, 4252, 6596, 8542, 10160, 11512, 12654, 13626, 14466, 15239, 16006, 16728, 17425, 18119, 18835, 19557, 20221, 20907, 21633, 22396, 23200, 24038, 24899, 25779, 26656, 27516, 28354, 29146, 29882, 30552, 31141, 31649, 32062, 32381, 32604, 32731, 32766, 32715, 32586, 32390, 32137, 31844, 31528, 31198, 30871, 30555, 30265, 30005, 29784, 29599, 29452, 29342, 29260, 29195, 29143, 29093, 29031, 28947, 28834, 28681, 28481, 28225, 27913, 27536, 27097, 26598, 26035, 25412, 24745, 24025, 23260, 22463, 21634, 20780, 19904, 19010, 18104, 17191, 16261, 15322, 14370, 13407, 12426, 11430, 10386, 9280, 8150, 6988, 5790, 4553, 3271, 1891, 374, -726, -4019, -12430, -16410, -18909, -20452, -21299, -21675, -21756, -21697, -21639, -21688, -21901, -22316, -22933, -23721, -24634, -25622, -26625, -27586, -28462, -29221, -29839, -30303, -30614, -30772, -30794, -30693, -30488, -30196, -29836, -29423, -28971, -28485, -27973, -27436, -26881, -26290, -25672, -25017, -24317, -23571, -22767, -21912, -20965, -19897, -18773, -17594, -16370, -15090, -13800, -12583, -11360, -10148, -8945, -7762, -6611, -5506, -4448, -3462, -2561, -1743, -1025, -413, 94, 484, 764, 932, 992, 952, 813, 593, 295, -70, -479, -922, -1383, -1841, -2282, -2693, -3061, -3375, -3628, -3815, -3934, -3989, -3983, -3920, -3818, -3675, -3512, -3335, -3159, -2998, -2853, -2737, -2657, -2619, -2625, -2674, -2771, -2911, -3090, -3301, -3543, -3810, -4091, -4386, -4692, -4994, -5294, -5592, -5876, -6154, -6423, -6684, -6938, -7194, -7445, -7703, -7972, -8251, -8553, -8876, -9226, -9603, -10069, -10663, -10830, -13176, -20625, -23667, -25266, -25907, -25855, -25335, -24512, -23558, -22605, -21755, -21081, -20607, -20338, -20244, -20287, -20405, -20546, -20654, -20689, -20617, -20414, -20072, -19585, -18965, -18196, -17297, -16313, -15262, -14164, -12964, -12128, -9459, -2335};