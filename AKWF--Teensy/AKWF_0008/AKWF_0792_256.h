/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0792 256 samples */
 
const int16_t AKWF_0792_256_DATA [256] = 
{44, 173, 297, 417, 534, 651, 764, 873, 980, 1083, 1183, 1281, 1377, 1469, 1558, 1644, 1727, 1808, 1886, 1960, 2032, 2100, 2166, 2229, 2290, 2347, 2401, 2455, 2514, 2536, 2716, 3223, 3732, 4237, 4742, 5245, 5744, 6243, 6738, 7230, 7719, 8205, 8687, 9166, 9643, 10116, 10585, 11052, 11512, 11972, 12428, 12877, 13326, 13771, 14210, 14648, 15082, 15511, 15937, 16359, 16776, 17191, 17603, 18008, 18412, 18812, 19208, 19601, 19989, 20373, 20756, 21133, 21507, 21878, 22245, 22609, 22969, 23325, 23677, 24027, 24373, 24716, 25055, 25390, 25723, 26052, 26377, 26700, 27019, 27335, 27647, 27957, 28263, 28566, 28865, 29162, 29456, 29747, 30034, 30319, 30599, 30877, 31154, 31425, 31695, 31963, 32215, 32449, 32876, 26509, 20121, 15342, 10940, 7094, 3696, 710, -1933, -4271, -6336, -8171, -9797, -11239, -12522, -13659, -14667, -15565, -16360, -17064, -17687, -18238, -18719, -19145, -19515, -19836, -20114, -20350, -20552, -20718, -20852, -20961, -21042, -21100, -21135, -21150, -21148, -21127, -21090, -21039, -20975, -20896, -20808, -20708, -20596, -20475, -20346, -20208, -20064, -19912, -19754, -19589, -19418, -19242, -19060, -18875, -18686, -18491, -18292, -18091, -17887, -17678, -17468, -17254, -17038, -16823, -16601, -16379, -16156, -15932, -15706, -15478, -15250, -15019, -14789, -14557, -14324, -14092, -13859, -13627, -13392, -13157, -12924, -12688, -12455, -12221, -11987, -11753, -11519, -11287, -11054, -10822, -10591, -10360, -10128, -9899, -9670, -9444, -9217, -8990, -8765, -8541, -8319, -8097, -7877, -7658, -7439, -7222, -7007, -6794, -6582, -6370, -6160, -5954, -5748, -5542, -5340, -5138, -4939, -4741, -4547, -4353, -4160, -3971, -3782, -3596, -3412, -3229, -3050, -2873, -2697, -2523, -2353, -2183, -2016, -1853, -1691, -1531, -1374, -1221, -1069, -919, -774, -630, -489, -352, -216, -81};