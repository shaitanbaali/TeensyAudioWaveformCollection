/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0720 256 samples */
 
const int16_t AKWF_0720_256_DATA [256] = 
{100, 427, 742, 1054, 1363, 1667, 1969, 2266, 2559, 2850, 3136, 3419, 3698, 3975, 4247, 4517, 4782, 5045, 5305, 5561, 5814, 6064, 6311, 6555, 6796, 7033, 7269, 7500, 7729, 7955, 8179, 8398, 8617, 8830, 9042, 9252, 9458, 9661, 9862, 10059, 10254, 10448, 10637, 10825, 11009, 11192, 11372, 11548, 11722, 11894, 12062, 12228, 12393, 12554, 12713, 12870, 13022, 13173, 13323, 13469, 13612, 13754, 13892, 14028, 14162, 14293, 14423, 14549, 14672, 14794, 14913, 15030, 15144, 15256, 15364, 15472, 15576, 15678, 15778, 15877, 15971, 16063, 16153, 16241, 16327, 16409, 16491, 16569, 16645, 16719, 16790, 16859, 16925, 16989, 17052, 17111, 17168, 17223, 17275, 17326, 17374, 17419, 17462, 17503, 17542, 17577, 17612, 17643, 17672, 17699, 17723, 17745, 17766, 17784, 17799, 17812, 17823, 17831, 17836, 17840, 17917, 17563, 18888, 31001, 29406, 24882, 22549, 20353, 18413, 16652, 15021, 13489, 12048, 10676, 9365, 8112, 6904, 5741, 4620, 3533, 2480, 1460, 467, -496, -1433, -2348, -3238, -4104, -4950, -5776, -6580, -7366, -8133, -8881, -9612, -10326, -11022, -11703, -12366, -13013, -13647, -14264, -14866, -15454, -16026, -16583, -17128, -17657, -18174, -18676, -19164, -19638, -20100, -20547, -20983, -21405, -21812, -22208, -22591, -22960, -23318, -23662, -23993, -24313, -24619, -24912, -25194, -25463, -25719, -25964, -26196, -26415, -26622, -26816, -27000, -27171, -27329, -27476, -27610, -27732, -27842, -27939, -28024, -28098, -28159, -28209, -28246, -28265, -28273, -28339, -26038, -23710, -22464, -21327, -20337, -19435, -18602, -17823, -17086, -16386, -15717, -15073, -14454, -13857, -13276, -12715, -12169, -11636, -11118, -10611, -10116, -9632, -9159, -8694, -8239, -7793, -7354, -6924, -6501, -6084, -5675, -5272, -4876, -4488, -4102, -3724, -3351, -2984, -2621, -2265, -1912, -1565, -1223, -884, -551, -216};