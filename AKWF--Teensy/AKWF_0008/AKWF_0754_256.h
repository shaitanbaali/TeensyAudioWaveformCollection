/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0754 256 samples */
 
const int16_t AKWF_0754_256_DATA [256] = 
{188, 234, 356, 451, 408, 26855, 32545, 29607, 28401, 27018, 25708, 24462, 23274, 22139, 21024, 19943, 18884, 17848, 16826, 15824, 14833, 13861, 12901, 11958, 11029, 10118, 9216, 8334, 7475, 6635, 5817, 5031, 4274, 3562, 2898, 2284, 1743, 1280, 921, 689, 615, 723, 976, 1314, 1681, 1832, 1438, 1029, 1302, 2380, 5091, 9786, -6713, -7792, -2973, -1650, -1042, -1222, -1736, -1794, -1464, -1106, -814, -638, -640, -814, -1125, -1551, -2060, -2647, -3290, -3993, -4734, -5512, -6324, -7159, -8012, -8893, -9793, -10703, -11640, -12590, -13557, -14535, -15539, -16559, -17586, -18641, -19722, -20824, -21957, -23131, -24343, -25631, -27002, -28445, -29476, -33879, -18173, 1817, -1153, 575, 10519, 10572, 9824, 9297, 8737, 8213, 7737, 7322, 6960, 6656, 6414, 6230, 6112, 6062, 6079, 6168, 6330, 6568, 6887, 7281, 7758, 8322, 8966, 9691, 10501, 11392, 12357, 13387, 14463, 15570, 16672, 17718, 18638, 19349, 19815, 20013, 19917, 19530, 18898, 18094, 17216, 16347, 15562, 14885, 14339, 13902, 13542, 13240, 12981, 12753, 12550, 12361, 12180, 11998, 11806, 11592, 11345, 11039, 10648, 10097, 9276, 8065, 6445, 4775, 3461, 2544, 1918, 1469, 1130, 867, 661, 497, 371, 275, 205, 160, 135, 129, 80, 465, -1384, -836, 39, -160, -170, -227, -313, -432, -590, -794, -1065, -1423, -1908, -2622, -3712, -5334, -7277, -8887, -9947, -10629, -11086, -11431, -11709, -11950, -12175, -12404, -12646, -12922, -13257, -13671, -14205, -14931, -15905, -17093, -18347, -19401, -19970, -19889, -19139, -17789, -16058, -14202, -12405, -10750, -9301, -8094, -7152, -6494, -6131, -6077, -6337, -6926, -7846, -9117, -10576, -12078, -13637, -15258, -16931, -18665, -20460, -22299, -24180, -26076, -27940, -29711, -31255, -32370, -32716, -31729, -28598, -20895, -10417, -9299};