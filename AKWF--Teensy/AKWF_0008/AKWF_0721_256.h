/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0721 256 samples */
 
const int16_t AKWF_0721_256_DATA [256] = 
{24175, 32641, 31985, 29298, 27921, 26705, 25642, 24685, 23800, 22974, 22197, 21458, 20752, 20076, 19425, 18796, 18190, 17600, 17028, 16472, 15929, 15401, 14886, 14380, 13888, 13406, 12934, 12471, 12018, 11574, 11137, 10709, 10288, 9876, 9471, 9072, 8680, 8295, 7917, 7545, 7179, 6818, 6465, 6116, 5773, 5437, 5104, 4778, 4457, 4140, 3829, 3524, 3223, 2926, 2635, 2348, 2066, 1789, 1516, 1248, 985, 724, 470, 220, -26, -268, -505, -739, -968, -1193, -1414, -1630, -1843, -2051, -2256, -2457, -2654, -2846, -3034, -3219, -3399, -3576, -3749, -3919, -4083, -4244, -4401, -4555, -4705, -4851, -4993, -5131, -5266, -5396, -5523, -5646, -5765, -5881, -5993, -6101, -6205, -6307, -6403, -6497, -6586, -6672, -6754, -6832, -6908, -6979, -7047, -7111, -7171, -7227, -7280, -7329, -7375, -7416, -7454, -7489, -7521, -7548, -7572, -7591, -7608, -7621, -7630, -7674, -7453, -9780, -10676, -9705, -9333, -9036, -8775, -8544, -8331, -8133, -7948, -7772, -7605, -7445, -7290, -7142, -6999, -6860, -6725, -6594, -6466, -6342, -6221, -6102, -5986, -5873, -5762, -5653, -5547, -5442, -5340, -5240, -5141, -5045, -4950, -4856, -4764, -4675, -4585, -4498, -4413, -4328, -4245, -4164, -4083, -4005, -3926, -3850, -3775, -3701, -3628, -3556, -3486, -3417, -3349, -3281, -3216, -3151, -3087, -3024, -2962, -2901, -2842, -2783, -2726, -2669, -2613, -2559, -2505, -2453, -2401, -2350, -2301, -2251, -2204, -2158, -2111, -2066, -2022, -1979, -1937, -1896, -1856, -1816, -1778, -1740, -1703, -1667, -1633, -1598, -1566, -1533, -1502, -1471, -1442, -1414, -1386, -1359, -1333, -1308, -1283, -1260, -1238, -1216, -1195, -1175, -1157, -1138, -1120, -1104, -1089, -1074, -1061, -1047, -1036, -1024, -1013, -1004, -995, -988, -980, -974, -969, -965, -961, -958, -957, -956};