/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0715 256 samples */
 
const int16_t AKWF_0715_256_DATA [256] = 
{4081, 3109, 3499, 3267, 3404, 3357, 3358, 3385, 3357, 3394, 3346, 3426, 3320, 3421, 3535, 2772, 5299, 18102, 17652, 18410, 18576, 19186, 19558, 19926, 20470, 20759, 21290, 21656, 22073, 22553, 22888, 23399, 23753, 24203, 24638, 25006, 25497, 25849, 26317, 26721, 27118, 27589, 27944, 28420, 28801, 29224, 29670, 30038, 30513, 30879, 31325, 31746, 32114, 32645, 32628, 32290, 31978, 31656, 31375, 31020, 30754, 30406, 30107, 29808, 29460, 29196, 28836, 28557, 28237, 27907, 27633, 27271, 27007, 26663, 26356, 26068, 25710, 25454, 25092, 24809, 24501, 24155, 23900, 23526, 23266, 22930, 22608, 22342, 21962, 21726, 21358, 21068, 20783, 20405, 20190, 19784, 19537, 19222, 18845, 18670, 18191, 18023, 17700, 16960, 18377, 11262, 1137, 3060, 2474, 2642, 2604, 2551, 2621, 2547, 2589, 2561, 2561, 2564, 2551, 2557, 2541, 2559, 2522, 2561, 2518, 2538, 2551, 2474, 2605, 2448, 2437, 2964, 1193, -11849, -11699, -12132, -12170, -12627, -12798, -13040, -13385, -13528, -13891, -14082, -14354, -14644, -14836, -15168, -15360, -15652, -15907, -16129, -16438, -16635, -16937, -17169, -17417, -17704, -17910, -18213, -18432, -18700, -18964, -19187, -19482, -19694, -19975, -20220, -20460, -20742, -20957, -21245, -21475, -21731, -22000, -22220, -22509, -22730, -22998, -23250, -23484, -23767, -23983, -24262, -24499, -24745, -25018, -25236, -25521, -25747, -26006, -26268, -26481, -26811, -26731, -26444, -26189, -25916, -25677, -25386, -25154, -24872, -24614, -24367, -24076, -23848, -23556, -23311, -23052, -22770, -22540, -22244, -22011, -21735, -21467, -21230, -20934, -20711, -20420, -20172, -19919, -19630, -19410, -19107, -18875, -18607, -18330, -18106, -17799, -17585, -17293, -17037, -16801, -16495, -16292, -15980, -15751, -15495, -15197, -15002, -14670, -14472, -14181, -13907, -13711, -13355, -13202, -12863, -12625, -12429, -12025, -11964, -11537, -11174, -11817, -8349};