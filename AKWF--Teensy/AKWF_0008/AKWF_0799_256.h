/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0799 256 samples */
 
const int16_t AKWF_0799_256_DATA [256] = 
{881, 3114, 5287, 7435, 9542, 11600, 13602, 15531, 17390, 19168, 20851, 22442, 23934, 25314, 26586, 27746, 28787, 29711, 30515, 31195, 31756, 32192, 32506, 32698, 32767, 32716, 32544, 32253, 31849, 31327, 30694, 29952, 29101, 28149, 27097, 25945, 24705, 23374, 21957, 20463, 18893, 17255, 15563, 13814, 12018, 10187, 8319, 6427, 4522, 2605, 689, -1212, -3102, -4967, -6795, -8589, -10334, -12022, -13654, -15217, -16704, -18120, -19449, -20692, -21849, -22910, -23877, -24747, -25518, -26189, -26763, -27234, -27607, -27882, -28059, -28141, -28128, -28024, -27831, -27550, -27188, -26744, -26223, -25628, -24963, -24232, -23440, -22587, -21682, -20728, -19726, -18684, -17605, -16488, -15319, -14058, -12686, -11211, -9631, -7959, -6216, -4414, -2574, -725, 1117, 2927, 4671, 6337, 7895, 9319, 10597, 11711, 12640, 13381, 13920, 14256, 14386, 14313, 14043, 13583, 12945, 12146, 11195, 10115, 8926, 7643, 6293, 4894, 3461, 2023, 594, -811, -2170, -3472, -4709, -5862, -6931, -7906, -8780, -9556, -10229, -10791, -11229, -11518, -11649, -11634, -11493, -11239, -10865, -10363, -9731, -8975, -8110, -7146, -6086, -4937, -3708, -2398, -1024, 409, 1896, 3425, 4992, 6592, 8208, 9835, 11467, 13086, 14691, 16270, 17809, 19304, 20744, 22113, 23409, 24620, 25734, 26749, 27650, 28431, 29088, 29611, 29997, 30241, 30340, 30290, 30088, 29735, 29230, 28574, 27774, 26834, 25754, 24545, 23209, 21754, 20192, 18527, 16771, 14939, 13034, 11066, 9056, 7002, 4920, 2825, 720, -1380, -3463, -5527, -7559, -9545, -11487, -13371, -15187, -16937, -18608, -20194, -21695, -23103, -24410, -25623, -26729, -27728, -28621, -29402, -30070, -30628, -31072, -31403, -31623, -31729, -31727, -31614, -31396, -31074, -30647, -30112, -29460, -28674, -27741, -26655, -25432, -24092, -22646, -21106, -19476, -17744, -15917, -13999, -11995, -9929, -7817, -5666, -3495, -1263};