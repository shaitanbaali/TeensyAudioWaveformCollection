/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0730 256 samples */
 
const int16_t AKWF_0730_256_DATA [256] = 
{426, 1675, 2834, 4421, 1489, 948, 2480, 3576, 4740, 5905, 7067, 8231, 9395, 10556, 11719, 12883, 14043, 15206, 16369, 17528, 18691, 19853, 21012, 22174, 23334, 24493, 25654, 26813, 27971, 29132, 30282, 31459, 32541, 31828, 30572, 29421, 28252, 27082, 25910, 24742, 23571, 22399, 21230, 20060, 18888, 17720, 16550, 15380, 14212, 13042, 11871, 10704, 9534, 8365, 7199, 6029, 4862, 3696, 2527, 1373, 152, -665, -652, -656, -660, -662, -663, -665, -667, -667, -668, -669, -669, -670, -671, -672, -673, -672, -673, -674, -674, -673, -674, -675, -674, -674, -674, -674, -674, -674, -674, -674, -674, -674, -674, -674, -674, -674, -675, -674, -673, -674, -673, -673, -673, -673, -673, -674, -673, -672, -673, -673, -672, -672, -672, -673, -671, -670, -671, -670, -670, -670, -671, -670, -670, -682, -626, -1321, -2630, -3855, -5017, -6699, -2857, -1868, -3399, -4402, -5486, -6570, -7477, -9487, -3533, 1648, 162, 1121, 2204, 3979, -428, -2291, -341, 850, 2157, 3467, 4776, 6082, 7393, 8701, 9992, 11257, 12951, 1021, -3104, -3567, -5163, -5152, -1480, -2701, -3764, -4835, -5912, -6910, -8440, -7707, 3144, 186, -3367, -6730, -10109, -13585, -16538, -17775, -18819, -19905, -20978, -22054, -23128, -24200, -25276, -26349, -27421, -28495, -29542, -30720, -31121, -30000, -28924, -27842, -26761, -25677, -24593, -23511, -22427, -21342, -20261, -19177, -18092, -17011, -15927, -14844, -13763, -12679, -11596, -10516, -9433, -8351, -7271, -6189, -5107, -4028, -2948, -1872, -769, -419, -471, -456, -454, -452, -451, -449, -448, -446, -445, -444, -443, -442, -441, -440, -440, -439, -439, -439, -438, -438, -437, -435, -436, -436, -435, -434, -435, -434, -434, -433, -434, -433, -434, -433};