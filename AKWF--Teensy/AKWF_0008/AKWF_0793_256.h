/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0793 256 samples */
 
const int16_t AKWF_0793_256_DATA [256] = 
{756, 1964, 3042, 4039, 4962, 5821, 6623, 7370, 8072, 8728, 9342, 9918, 10458, 10964, 11436, 11879, 12289, 12674, 13027, 13317, 13575, 13814, 14030, 14226, 14398, 14547, 14674, 14778, 14861, 14933, 14970, 14862, 20073, 23552, 25051, 26429, 27532, 28464, 29265, 29954, 30550, 31062, 31494, 31857, 32152, 32383, 32548, 32589, 33022, 29204, 24652, 23096, 21592, 20377, 19325, 18387, 17538, 16762, 16043, 15376, 14754, 14167, 13617, 13098, 12605, 12140, 11699, 11279, 10879, 10500, 10140, 9799, 9472, 9163, 8869, 8590, 8325, 8075, 7838, 7614, 7403, 7204, 7018, 6845, 6682, 6530, 6391, 6262, 6144, 6037, 5940, 5856, 5780, 5715, 5659, 5614, 5580, 5531, 5639, 5015, 3785, 3585, 2939, 1687, 519, 498, -639, -2846, -3503, -4056, -4450, -4728, -4951, -4754, -7312, -9777, -10612, -11439, -12092, -12648, -13128, -13544, -13908, -14226, -14499, -14734, -14934, -15097, -15225, -15321, -15413, -15310, -16037, -17380, -17789, -18172, -18478, -18742, -18973, -19181, -19370, -19543, -19702, -19850, -19986, -20113, -20232, -20341, -20445, -20540, -20630, -20714, -20791, -20863, -20929, -20990, -21047, -21098, -21144, -21185, -21223, -21254, -21282, -21306, -21325, -21340, -21350, -21356, -21333, -21388, -21448, -14387, -10071, -8142, -6314, -4800, -3476, -2286, -1202, -207, 719, 1726, 1779, 7408, 14298, 14057, 21090, 29490, 31300, 33164, 26987, 19781, 17220, 14993, 13294, 11912, 10767, 9803, 8987, 8298, 7715, 7225, 6820, 6488, 6224, 6022, 5872, 5795, 5678, 4187, 2593, 752, -1517, -3777, -4408, -4723, -8296, -11003, -12118, -13071, -13780, -14323, -14724, -15016, -15138, -15393, -17102, -17978, -18463, -18875, -19213, -19501, -19751, -19972, -20166, -20338, -20492, -20628, -20748, -20854, -20945, -21024, -21089, -21145, -21189, -21222, -21246, -21167, -21605, -19798, -11378, -7968, -5618, -3653, -1995, -516};