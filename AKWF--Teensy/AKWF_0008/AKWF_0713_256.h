/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0713 256 samples */
 
const int16_t AKWF_0713_256_DATA [256] = 
{72, 254, 434, 614, 793, 974, 1151, 1333, 1512, 1692, 1873, 2050, 2233, 2407, 2591, 2770, 2943, 3135, 3296, 3489, 3710, 3709, 4478, 9216, 13241, 17383, 21444, 25482, 29873, 32767, 32107, 31821, 31439, 31095, 30728, 30368, 30007, 29644, 29282, 28919, 28559, 28193, 27832, 27467, 27105, 26743, 26377, 26016, 25650, 25288, 24924, 24560, 24199, 23831, 23471, 23104, 22743, 22379, 22012, 21656, 21286, 20926, 20562, 20198, 19838, 19469, 19112, 18745, 18384, 18024, 17653, 17301, 16932, 16572, 16212, 15844, 15490, 15118, 14766, 14399, 14037, 13685, 13309, 12963, 12590, 12234, 11878, 11504, 11165, 10782, 10438, 10076, 9696, 9379, 8966, 8618, 8386, 7582, 3462, 2977, 2391, 1889, 1281, 752, 196, -376, -903, -1482, -2021, -2578, -3138, -3680, -4247, -4787, -5348, -5899, -6448, -7008, -7549, -8110, -8657, -9207, -9763, -10307, -10864, -11410, -11962, -12512, -13059, -13613, -14157, -14712, -15258, -15805, -16356, -16901, -17451, -17998, -18546, -19091, -19641, -20180, -20764, -20744, -20514, -20339, -20159, -19966, -19786, -19597, -19411, -19228, -19037, -18856, -18668, -18483, -18297, -18108, -17926, -17737, -17552, -17365, -17178, -16994, -16805, -16622, -16434, -16249, -16064, -15874, -15692, -15503, -15320, -15134, -14946, -14762, -14575, -14392, -14203, -14018, -13834, -13647, -13463, -13276, -13091, -12906, -12721, -12537, -12350, -12166, -11982, -11796, -11611, -11426, -11243, -11056, -10873, -10688, -10503, -10321, -10134, -9951, -9768, -9582, -9399, -9213, -9031, -8847, -8662, -8480, -8295, -8113, -7928, -7744, -7562, -7378, -7196, -7011, -6829, -6646, -6464, -6280, -6098, -5915, -5731, -5550, -5367, -5184, -5003, -4820, -4638, -4456, -4274, -4092, -3909, -3728, -3546, -3365, -3183, -3001, -2820, -2637, -2457, -2276, -2093, -1913, -1731, -1551, -1370, -1190, -1010, -828, -648, -467, -287, -104};