/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0770 256 samples */
 
const int16_t AKWF_0770_256_DATA [256] = 
{91, 433, 773, 1124, 1483, 1846, 2222, 2601, 2986, 3381, 3782, 4187, 4602, 5022, 5451, 5886, 6328, 6777, 7232, 7697, 8166, 8642, 9124, 9612, 10109, 10610, 11120, 11634, 12155, 12680, 13211, 13747, 14292, 14840, 15393, 15953, 16514, 17082, 17655, 18231, 18811, 19393, 19980, 20572, 21167, 21762, 22364, 22966, 23568, 24173, 24780, 25388, 25997, 26610, 27219, 27829, 28436, 29035, 29628, 30195, 30727, 31219, 31661, 32034, 32341, 32567, 32710, 32767, 32736, 32617, 32413, 32118, 31739, 31276, 30738, 30123, 29434, 28684, 27868, 26992, 26065, 25086, 24061, 22997, 21897, 20767, 19610, 18428, 17228, 16020, 14797, 13565, 12337, 11113, 9892, 8681, 7483, 6300, 5134, 3987, 2864, 1765, 688, -357, -1373, -2360, -3319, -4248, -5145, -6010, -6843, -7642, -8407, -9143, -9847, -10518, -11159, -11769, -12346, -12892, -13413, -13900, -14361, -14792, -15199, -15580, -15934, -16264, -16571, -16852, -17111, -17352, -17567, -17763, -17941, -18100, -18239, -18361, -18467, -18556, -18629, -18687, -18732, -18764, -18781, -18787, -18783, -18770, -18742, -18703, -18656, -18600, -18534, -18459, -18378, -18289, -18194, -18093, -17985, -17872, -17754, -17630, -17503, -17371, -17237, -17097, -16954, -16810, -16664, -16512, -16360, -16208, -16053, -15896, -15738, -15580, -15422, -15261, -15101, -14938, -14776, -14615, -14453, -14292, -14133, -13972, -13811, -13651, -13493, -13333, -13174, -13017, -12859, -12702, -12547, -12390, -12236, -12081, -11926, -11774, -11619, -11465, -11312, -11161, -11008, -10855, -10702, -10548, -10395, -10239, -10085, -9930, -9773, -9616, -9457, -9295, -9133, -8971, -8808, -8641, -8474, -8303, -8127, -7954, -7777, -7597, -7413, -7229, -7039, -6845, -6651, -6452, -6248, -6041, -5829, -5614, -5395, -5173, -4946, -4712, -4475, -4232, -3982, -3727, -3470, -3205, -2936, -2660, -2379, -2093, -1798, -1497, -1192, -879, -562, -232};