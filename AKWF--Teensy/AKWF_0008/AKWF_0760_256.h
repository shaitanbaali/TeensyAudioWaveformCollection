/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0760 256 samples */
 
const int16_t AKWF_0760_256_DATA [256] = 
{381, 1055, 1661, 2220, 2730, 3196, 3620, 4002, 4346, 4654, 4926, 5167, 5378, 5559, 5713, 5842, 5946, 6028, 6089, 6129, 6150, 6154, 6141, 6112, 6068, 6011, 5940, 5857, 5763, 5658, 5543, 5418, 5284, 5142, 4992, 4834, 4669, 4499, 4322, 4139, 3951, 3757, 3559, 3356, 3149, 2938, 2724, 2506, 2284, 2059, 1832, 1602, 1369, 1133, 897, 657, 416, 173, -72, -319, -567, -818, -1069, -1321, -1575, -1830, -2086, -2344, -2602, -2861, -3122, -3382, -3644, -3907, -4170, -4434, -4700, -4965, -5231, -5499, -5765, -6034, -6303, -6572, -6843, -7113, -7384, -7657, -7928, -8202, -8476, -8751, -9025, -9302, -9577, -9844, -10085, -10273, -10375, -10357, -10188, -9847, -9321, -8613, -7730, -6690, -5523, -4247, -2888, -1477, -30, 1431, 2886, 4327, 5739, 7107, 8433, 9706, 10919, 12078, 13174, 14207, 15181, 16093, 16945, 17740, 18478, 19161, 19793, 20374, 20906, 21392, 21835, 22237, 22599, 22924, 23213, 23469, 23693, 23888, 24055, 24193, 24309, 24401, 24469, 24518, 24547, 24557, 24550, 24527, 24487, 24435, 24368, 24288, 24197, 24094, 23981, 23857, 23724, 23583, 23434, 23276, 23107, 22913, 22681, 22389, 22014, 21538, 20944, 20221, 19376, 18407, 17329, 16160, 14912, 13603, 12253, 10872, 9475, 8079, 6684, 5304, 3949, 2615, 1312, 44, -1191, -2392, -3554, -4683, -5775, -6832, -7857, -8848, -9808, -10739, -11643, -12520, -13373, -14202, -15011, -15801, -16572, -17328, -18071, -18798, -19517, -20225, -20924, -21619, -22308, -22993, -23677, -24360, -25042, -25729, -26417, -27108, -27804, -28501, -29198, -29891, -30568, -31212, -31791, -32269, -32605, -32762, -32710, -32429, -31915, -31175, -30226, -29092, -27808, -26399, -24896, -23333, -21727, -20106, -18491, -16891, -15324, -13802, -12328, -10912, -9561, -8271, -7047, -5893, -4803, -3780, -2824, -1930, -1099, -315};