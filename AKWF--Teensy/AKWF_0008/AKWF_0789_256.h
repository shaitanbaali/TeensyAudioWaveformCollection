/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0789 256 samples */
 
const int16_t AKWF_0789_256_DATA [256] = 
{153, 479, 784, 1076, 1355, 1622, 1877, 2119, 2348, 2564, 2769, 2963, 3145, 3314, 3474, 3623, 3759, 3883, 3999, 4103, 4196, 4279, 4351, 4412, 4463, 4504, 4535, 4570, 4526, 4854, 6311, 7778, 9103, 10306, 11379, 12320, 13123, 13786, 14314, 14710, 14984, 15152, 15230, 15243, 15219, 15174, 15125, 15097, 15105, 15151, 15248, 15397, 15598, 15845, 16133, 16453, 16801, 17163, 17530, 17899, 18259, 18609, 18951, 19290, 19629, 19977, 20347, 20735, 21149, 21588, 22052, 22537, 23042, 23559, 24082, 24606, 25126, 25628, 26104, 26553, 26967, 27343, 27683, 27990, 28268, 28524, 28770, 29009, 29245, 29484, 29737, 29997, 30264, 30540, 30817, 31093, 31367, 31635, 31884, 32115, 32318, 32491, 32628, 32719, 32764, 32758, 32700, 32584, 32405, 32164, 31856, 31483, 31036, 30516, 29919, 29246, 28488, 27654, 26734, 25729, 24642, 23471, 22211, 20868, 19441, 17929, 16339, 14680, 12956, 11190, 9385, 7557, 5729, 3908, 2114, 365, -1339, -2989, -4567, -6084, -7529, -8901, -10202, -11435, -12602, -13710, -14757, -15753, -16701, -17607, -18472, -19305, -20107, -20880, -21627, -22345, -23031, -23688, -24313, -24904, -25463, -25983, -26470, -26919, -27333, -27713, -28061, -28377, -28664, -28927, -29162, -29377, -29570, -29742, -29904, -30050, -30186, -30309, -30428, -30541, -30648, -30753, -30856, -30953, -31044, -31131, -31207, -31270, -31322, -31358, -31371, -31363, -31332, -31275, -31193, -31074, -30927, -30749, -30541, -30301, -30029, -29728, -29397, -29036, -28645, -28229, -27786, -27318, -26827, -26308, -25773, -25217, -24642, -24051, -23444, -22821, -22187, -21542, -20888, -20228, -19562, -18888, -18212, -17535, -16860, -16184, -15510, -14838, -14172, -13511, -12855, -12210, -11569, -10935, -10320, -9706, -9103, -8515, -7935, -7372, -6822, -6280, -5755, -5244, -4745, -4258, -3789, -3329, -2887, -2459, -2041, -1637, -1252, -879, -520, -169};