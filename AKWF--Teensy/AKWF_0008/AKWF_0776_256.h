/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0776 256 samples */
 
const int16_t AKWF_0776_256_DATA [256] = 
{698, 1827, 2961, 4110, 5255, 6390, 7508, 8600, 9664, 10703, 11711, 12698, 13664, 14609, 15541, 16464, 17375, 18283, 19184, 20078, 20971, 21857, 22730, 23595, 24441, 25266, 26068, 26836, 27569, 28261, 28907, 29501, 30042, 30524, 30947, 31307, 31604, 31835, 32002, 32101, 32130, 32087, 31983, 31833, 31650, 31452, 31249, 31057, 30877, 30718, 30588, 30488, 30419, 30385, 30379, 30385, 30389, 30383, 30365, 30333, 30290, 30237, 30173, 30099, 30012, 29913, 29795, 29656, 29495, 29307, 29090, 28842, 28561, 28246, 27898, 27519, 27108, 26670, 26205, 25717, 25212, 24691, 24155, 23613, 23064, 22510, 21954, 21394, 20830, 20259, 19675, 19071, 18442, 17769, 17041, 16239, 15370, 14465, 13550, 12643, 11758, 10901, 10083, 9316, 8611, 7974, 7407, 6917, 6500, 6085, 5638, 5198, 4786, 4388, 4001, 3619, 3243, 2877, 2529, 2217, 1958, 1759, 1594, 1416, 1189, 890, 516, 70, -440, -1000, -1602, -2236, -2889, -3552, -4220, -4884, -5546, -6202, -6850, -7495, -8136, -8775, -9417, -10062, -10713, -11371, -12037, -12708, -13388, -14072, -14755, -15440, -16116, -16782, -17436, -18067, -18675, -19253, -19798, -20306, -20776, -21203, -21589, -21935, -22242, -22512, -22755, -22976, -23187, -23399, -23611, -23822, -24029, -24231, -24424, -24608, -24790, -24976, -25164, -25359, -25564, -25783, -26020, -26291, -26609, -26976, -27390, -27840, -28318, -28812, -29312, -29802, -30280, -30730, -31149, -31529, -31862, -32147, -32381, -32559, -32683, -32752, -32767, -32731, -32645, -32514, -32340, -32130, -31886, -31613, -31314, -30995, -30659, -30306, -29942, -29561, -29166, -28755, -28318, -27852, -27348, -26787, -26158, -25443, -24645, -23793, -22913, -22020, -21124, -20227, -19331, -18442, -17553, -16660, -15775, -14923, -14116, -13299, -12456, -11639, -10863, -10122, -9415, -8738, -8087, -7467, -6875, -6298, -5727, -5154, -4558, -3901, -3154, -2307, -1374, -345};