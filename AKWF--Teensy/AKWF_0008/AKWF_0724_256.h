/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0724 256 samples */
 
const int16_t AKWF_0724_256_DATA [256] = 
{24562, 24371, 24183, 23994, 23804, 23612, 23421, 23228, 23035, 22841, 22647, 22453, 22258, 22063, 21867, 21671, 21475, 21280, 21083, 20887, 20690, 20493, 20295, 20099, 19902, 19705, 19507, 19309, 19113, 18915, 18718, 18520, 18322, 18125, 17928, 17731, 17533, 17335, 17137, 16941, 16743, 16545, 16349, 16152, 15954, 15756, 15560, 15362, 15166, 14969, 14771, 14574, 14377, 14180, 13983, 13787, 13590, 13393, 13196, 12999, 12802, 12606, 12410, 12214, 12016, 11820, 11624, 11428, 11232, 11036, 10839, 10643, 10447, 10251, 10054, 9860, 9664, 9469, 9273, 9077, 8881, 8685, 8490, 8295, 8099, 7903, 7709, 7512, 7318, 7123, 6927, 6732, 6538, 6342, 6148, 5953, 5758, 5563, 5369, 5173, 4979, 4783, 4589, 4395, 4200, 4006, 3812, 3617, 3422, 3228, 3035, 2840, 2645, 2451, 2256, 2063, 1869, 1676, 1482, 1287, 1093, 899, 705, 511, 319, 123, -69, -262, -456, -650, -843, -1038, -1231, -1424, -1620, -1813, -2007, -2201, -2395, -2589, -2783, -2977, -3171, -3365, -3559, -3753, -3948, -4142, -4337, -4532, -4726, -4921, -5117, -5312, -5507, -5702, -5898, -6094, -6289, -6487, -6684, -6880, -7076, -7274, -7471, -7669, -7868, -8065, -8265, -8466, -8665, -8865, -9067, -9269, -9470, -9673, -9876, -10081, -10286, -10491, -10698, -10906, -11114, -11324, -11535, -11747, -11959, -12175, -12391, -12609, -12827, -13049, -13272, -13496, -13722, -13951, -14183, -14417, -14653, -14892, -15134, -15379, -15627, -15879, -16136, -16394, -16659, -16928, -17200, -17479, -17762, -18051, -18345, -18647, -18955, -19271, -19593, -19924, -20263, -20613, -20970, -21338, -21716, -22106, -22510, -22923, -22750, -26578, 12270, 28233, 24563, 24549, 27014, 14685, -16743, -13762, -26049, -24777, -25599, -26126, -26671, -27236, -27821, -28424, -29047, -29683, -30325, -30965, -31578, -32129, -32558, -32765, -32584, -31744, -29816, -25771};