/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0769 256 samples */
 
const int16_t AKWF_0769_256_DATA [256] = 
{2128, 6189, 9864, 13379, 16879, 19628, 22087, 24128, 25266, 25717, 25792, 25404, 24530, 23658, 23073, 22212, 21234, 20422, 19238, 18277, 17890, 17647, 17454, 17171, 16785, 16580, 16804, 17136, 17576, 17821, 18136, 18621, 18795, 18925, 19093, 18371, 17290, 16529, 15493, 13753, 12264, 11041, 9799, 7859, 6348, 5219, 4214, 3678, 3454, 3676, 4360, 5168, 6043, 7274, 8351, 8951, 9767, 10264, 9979, 10127, 10556, 10621, 11085, 11705, 12051, 12344, 12320, 11636, 10848, 10305, 9672, 9286, 8661, 7371, 5920, 5009, 4175, 2651, 473, -2059, -4478, -6453, -8157, -9577, -10744, -11519, -12597, -13607, -14259, -14478, -14368, -13766, -13092, -12351, -11302, -9501, -7353, -4486, -1638, 815, 3417, 6598, 9587, 12316, 14605, 16506, 17464, 17870, 17492, 16822, 16158, 15205, 13338, 11391, 9512, 7759, 6415, 5052, 3147, 1769, 538, -1503, -3801, -5998, -8118, -9913, -11316, -12972, -14410, -15475, -15946, -16315, -16460, -16249, -15819, -14991, -13883, -12947, -11818, -10050, -7997, -5590, -2645, 211, 2375, 4503, 7227, 9869, 12122, 14484, 17099, 19540, 21523, 22831, 23927, 24625, 25199, 25448, 24819, 24077, 23047, 21522, 19683, 17753, 15926, 14211, 12894, 11763, 10138, 8380, 6597, 4528, 2125, -313, -3193, -6350, -9505, -12571, -15168, -17778, -20715, -22677, -23811, -24449, -25022, -25129, -24941, -24551, -23823, -22829, -21998, -21069, -19880, -18637, -17674, -16554, -15473, -13875, -12286, -11146, -10453, -9612, -8251, -7143, -6134, -5237, -4448, -3926, -3556, -3097, -3051, -3214, -3419, -3844, -4145, -4987, -5736, -6018, -6496, -6962, -7335, -7377, -7697, -8303, -8642, -8832, -9138, -9905, -11018, -12169, -13788, -15763, -17811, -19807, -22034, -23899, -25364, -27235, -29356, -30479, -31129, -31896, -32516, -32748, -32554, -31671, -30236, -28410, -26129, -23813, -20689, -16752, -13015, -9364, -5370, -1608};