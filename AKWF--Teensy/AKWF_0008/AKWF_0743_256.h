/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0743 256 samples */
 
const int16_t AKWF_0743_256_DATA [256] = 
{245, 648, 1035, 1417, 1798, 2180, 2567, 2960, 3364, 3780, 4210, 4657, 5122, 5606, 6111, 6638, 7184, 7754, 8344, 8952, 9582, 10229, 10890, 11569, 12258, 12955, 13661, 14370, 15079, 15789, 16491, 17184, 17867, 18534, 19183, 19811, 20413, 20990, 21536, 22048, 22526, 22967, 23367, 23726, 24043, 24313, 24539, 24719, 24852, 24936, 24975, 24964, 24907, 24804, 24655, 24461, 24225, 23947, 23628, 23271, 22878, 22449, 21989, 21499, 20979, 20434, 19863, 19268, 18652, 18015, 17357, 16683, 15990, 15279, 14553, 13810, 13051, 12278, 11487, 10679, 9859, 9020, 8164, 7294, 6407, 5505, 4592, 3663, 2724, 1778, 821, -138, -1098, -2060, -3014, -3959, -4893, -5808, -6702, -7570, -8405, -9205, -9965, -10677, -11340, -11948, -12497, -12982, -13401, -13749, -14024, -14224, -14346, -14388, -14349, -14231, -14031, -13750, -13391, -12952, -12439, -11853, -11194, -10470, -9685, -8838, -7938, -6990, -5995, -4964, -3900, -2806, -1692, -562, 579, 1722, 2864, 4002, 5124, 6229, 7312, 8365, 9386, 10369, 11309, 12204, 13048, 13833, 14563, 15230, 15829, 16359, 16818, 17199, 17503, 17727, 17868, 17924, 17895, 17778, 17574, 17280, 16899, 16428, 15870, 15225, 14494, 13682, 12786, 11811, 10764, 9642, 8450, 7199, 5886, 4519, 3106, 1646, 149, -1375, -2929, -4500, -6081, -7671, -9259, -10837, -12404, -13948, -15463, -16949, -18393, -19791, -21142, -22434, -23665, -24834, -25930, -26955, -27904, -28772, -29559, -30263, -30879, -31411, -31855, -32210, -32478, -32659, -32754, -32763, -32690, -32536, -32303, -31994, -31612, -31160, -30641, -30061, -29421, -28728, -27985, -27193, -26362, -25495, -24592, -23664, -22712, -21739, -20755, -19758, -18755, -17754, -16752, -15756, -14774, -13802, -12847, -11915, -11004, -10119, -9264, -8436, -7641, -6882, -6152, -5456, -4796, -4166, -3569, -3004, -2468, -1959, -1477, -1018, -580, -151};