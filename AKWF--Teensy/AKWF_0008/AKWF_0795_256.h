/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0795 256 samples */
 
const int16_t AKWF_0795_256_DATA [256] = 
{808, 2275, 2848, 9370, 18870, 23494, 27501, 31184, 32250, 29379, 26765, 24324, 22006, 19811, 17709, 15697, 13764, 11896, 10090, 8343, 6655, 4946, 3625, 3554, 3565, 3554, 3549, 3545, 3542, 3538, 3535, 3533, 3530, 3529, 3526, 3524, 3522, 3521, 3519, 3517, 3515, 3515, 3513, 3511, 3511, 3510, 3508, 3507, 3506, 3505, 3504, 3503, 3502, 3500, 3500, 3499, 3497, 3497, 3496, 3495, 3495, 3494, 3492, 3491, 3491, 3489, 3488, 3488, 3488, 3487, 3486, 3485, 3484, 3484, 3482, 3481, 3481, 3480, 3480, 3479, 3477, 3477, 3476, 3475, 3474, 3473, 3472, 3471, 3470, 3470, 3469, 3469, 3467, 3466, 3466, 3465, 3464, 3463, 3462, 3461, 3461, 3460, 3459, 3458, 3457, 3456, 3455, 3454, 3454, 3452, 3451, 3451, 3451, 3451, 3450, 3449, 3448, 3447, 3446, 3445, 3444, 3443, 3442, 3441, 3441, 3440, 3440, 3439, 3437, 3436, 3436, 3435, 3434, 3433, 3432, 3431, 3431, 3431, 3429, 3428, 3428, 3426, 3425, 3425, 3424, 3423, 3421, 3421, 3420, 3420, 3419, 3418, 3417, 3416, 3416, 3415, 3413, 3413, 3412, 3410, 3410, 3410, 3410, 3409, 3409, 3407, 3406, 3401, 3415, 3365, 2756, 2041, 1354, 664, -26, -715, -1382, -2139, -2738, 2150, 2541, 1613, 1035, 397, -239, -871, -1504, -2137, -2768, -3399, -4028, -4657, -5287, -5913, -6540, -7167, -7790, -8415, -9040, -9661, -10283, -10905, -11526, -12146, -12766, -13383, -14000, -14618, -15233, -15849, -16465, -17077, -17690, -18304, -18915, -19527, -20138, -20747, -21358, -21967, -22574, -23180, -23785, -24428, -24171, -23477, -22871, -22248, -21625, -21003, -20380, -19759, -19137, -18515, -17895, -17274, -16653, -16033, -15413, -14793, -14175, -13555, -12936, -12318, -11700, -11081, -10467, -9671, -10156, -361, 5710, 5276, 6166, 6838, 7896, 1373};