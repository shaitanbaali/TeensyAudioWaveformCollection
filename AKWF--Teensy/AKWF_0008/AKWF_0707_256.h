/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0707 256 samples */
 
const int16_t AKWF_0707_256_DATA [256] = 
{2415, 5897, 9238, 12480, 15573, 18487, 21194, 23651, 25848, 27761, 29370, 30672, 31659, 32331, 32693, 32756, 32535, 32046, 31312, 30361, 29216, 27909, 26477, 24941, 23342, 21712, 20074, 18465, 16909, 15427, 14043, 12777, 11635, 10634, 9777, 9066, 8500, 8073, 7776, 7598, 7523, 7536, 7618, 7750, 7911, 8081, 8240, 8370, 8453, 8473, 8418, 8278, 8043, 7710, 7280, 6751, 6130, 5428, 4652, 3818, 2943, 2041, 1137, 249, -604, -1400, -2118, -2741, -3250, -3631, -3871, -3960, -3893, -3664, -3276, -2732, -2038, -1210, -257, 799, 1938, 3143, 4384, 5633, 6871, 8064, 9185, 10214, 11121, 11885, 12487, 12910, 13138, 13165, 12981, 12588, 11984, 11182, 10189, 9019, 7694, 6235, 4664, 3016, 1314, -411, -2120, -3790, -5387, -6875, -8233, -9432, -10447, -11262, -11858, -12224, -12354, -12243, -11896, -11315, -10515, -9511, -8320, -6966, -5479, -3881, -2210, -496, 1230, 2929, 4572, 6128, 7561, 8848, 9963, 10882, 11590, 12073, 12319, 12328, 12096, 11631, 10939, 10036, 8942, 7671, 6253, 4716, 3084, 1392, -325, -2045, -3729, -5346, -6873, -8278, -9538, -10636, -11549, -12267, -12782, -13086, -13179, -13065, -12753, -12252, -11578, -10751, -9790, -8717, -7563, -6348, -5101, -3853, -2625, -1443, -338, 676, 1579, 2350, 2982, 3460, 3780, 3940, 3940, 3786, 3484, 3047, 2487, 1821, 1067, 245, -625, -1523, -2428, -3322, -4181, -4992, -5739, -6407, -6989, -7477, -7865, -8156, -8349, -8452, -8473, -8425, -8320, -8175, -8010, -7841, -7690, -7577, -7522, -7544, -7661, -7888, -8239, -8725, -9351, -10126, -11044, -12106, -13303, -14622, -16048, -17566, -19147, -20771, -22411, -24030, -25606, -27103, -28484, -29726, -30793, -31653, -32286, -32663, -32765, -32576, -32082, -31277, -30155, -28720, -26982, -24945, -22633, -20070, -17268, -14273, -11112, -7820, -4444, -945};