/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0710 256 samples */
 
const int16_t AKWF_0710_256_DATA [256] = 
{1060, 2727, 4361, 5998, 7636, 9274, 10914, 12551, 14189, 15830, 17466, 19105, 20746, 22381, 24021, 25662, 27297, 28932, 30553, 32289, 31819, 30009, 28411, 26771, 25131, 23495, 21855, 20216, 18580, 16939, 15301, 13664, 12023, 10386, 8748, 7107, 5471, 3832, 2192, 570, -1132, -2346, -2720, -3137, -3549, -3957, -4367, -4777, -5186, -5595, -6000, -6434, -6316, -5864, -5464, -5054, -4644, -4235, -3825, -3415, -3010, -2587, -2239, -2379, -2598, -2798, -3003, -3209, -3413, -3618, -3823, -4027, -4232, -4437, -4641, -4846, -5052, -5255, -5461, -5666, -5870, -6075, -6275, -6504, -6181, -5524, -4920, -4305, -3691, -3077, -2462, -1847, -1233, -618, -5, 609, 1224, 1838, 2452, 3068, 3682, 4296, 4911, 5504, 6213, 6189, 4910, 3690, 2463, 1235, 6, -1223, -2450, -3679, -4905, -6156, -6858, -7226, -7644, -8054, -8463, -8872, -9283, -9692, -10094, -10530, -10817, -10130, -9282, -8470, -7652, -6831, -6013, -5193, -4373, -3555, -2735, -1915, -1097, -279, 541, 1359, 2179, 2999, 3817, 4635, 5445, 6313, 6076, 5172, 4373, 3553, 2734, 1915, 1095, 276, -542, -1362, -2181, -3000, -3820, -4638, -5457, -6277, -7096, -7915, -8735, -9540, -10422, -10816, -10372, -9969, -9560, -9151, -8742, -8331, -7922, -7512, -7096, -6712, -5775, -4503, -3285, -2054, -826, 400, 1631, 2860, 4075, 5346, 6390, 5972, 5315, 4713, 4100, 3484, 2870, 2256, 1641, 1027, 412, -202, -815, -1430, -2045, -2658, -3273, -3889, -4502, -5116, -5726, -6365, -6452, -6205, -6010, -5805, -5600, -5395, -5190, -4985, -4781, -4576, -4371, -4166, -3961, -3756, -3551, -3347, -3142, -2937, -2732, -2534, -2298, -2307, -2733, -3140, -3549, -3958, -4368, -4779, -5187, -5596, -6001, -6435, -6317, -5865, -5465, -5055, -4645, -4236, -3826, -3417, -3000, -2619, -2091, -554};