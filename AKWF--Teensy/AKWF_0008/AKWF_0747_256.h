/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0747 256 samples */
 
const int16_t AKWF_0747_256_DATA [256] = 
{5788, 2932, 5161, 6658, 8036, 9486, 10991, 12493, 13950, 15333, 16622, 17818, 18925, 19940, 20875, 21735, 22523, 23251, 23919, 24532, 25097, 25616, 26091, 26529, 26931, 27298, 27635, 27940, 28218, 28472, 28699, 28903, 29086, 29248, 29390, 29513, 29617, 29705, 29776, 29830, 29869, 29894, 29904, 29901, 29883, 29854, 29812, 29758, 29692, 29614, 29525, 29427, 29318, 29198, 29070, 28931, 28784, 28627, 28462, 28288, 28092, 28175, 26731, 22498, 23032, 23554, 21727, 20060, 18561, 16981, 15338, 13691, 12081, 10539, 9084, 7713, 6428, 5228, 4099, 3040, 2048, 1111, 228, -605, -1396, -2146, -2857, -3535, -4180, -4795, -5385, -5947, -6485, -7003, -7497, -7972, -8429, -8867, -9288, -9692, -10081, -10456, -10816, -11162, -11494, -11812, -12119, -12414, -12696, -12967, -13226, -13475, -13712, -13939, -14156, -14362, -14559, -14745, -14921, -15090, -15248, -15396, -15538, -15669, -15792, -15906, -16013, -16111, -16200, -16282, -16357, -16423, -16482, -16534, -16579, -16615, -16646, -16670, -16686, -16697, -16700, -16698, -16688, -16673, -16651, -16625, -16592, -16554, -16510, -16461, -16406, -16346, -16282, -16212, -16138, -16058, -15974, -15886, -15794, -15697, -15597, -15491, -15383, -15270, -15154, -15035, -14912, -14785, -14655, -14522, -14387, -14248, -14106, -13962, -13815, -13665, -13514, -13359, -13203, -13046, -12884, -12722, -12558, -12392, -12225, -12057, -11885, -11712, -11539, -11365, -11188, -11012, -10834, -10656, -10476, -10296, -10116, -9934, -9751, -9570, -9387, -9204, -9021, -8838, -8654, -8471, -8287, -8104, -7921, -7738, -7555, -7373, -7191, -7010, -6830, -6649, -6469, -6291, -6112, -5935, -5758, -5582, -5407, -5235, -5061, -4890, -4720, -4549, -4381, -4214, -4049, -3884, -3720, -3558, -3398, -3239, -3080, -2925, -2770, -2617, -2466, -2316, -2167, -2020, -1876, -1731, -1590, -1450, -1311, -1175, -1041, -907, -761, -961, 759, 3503};