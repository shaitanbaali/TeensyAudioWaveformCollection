/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0766 256 samples */
 
const int16_t AKWF_0766_256_DATA [256] = 
{1699, 4230, 6781, 9419, 11933, 14304, 16728, 19204, 21638, 23854, 25734, 27136, 28060, 28582, 28818, 29057, 29418, 29738, 29905, 29975, 29924, 29912, 29959, 29877, 29698, 29577, 29216, 28415, 27133, 25398, 23411, 21471, 19593, 17760, 15942, 14130, 12273, 10283, 8253, 6248, 4401, 2837, 1475, 234, -808, -1606, -2173, -2385, -2286, -2150, -2134, -2049, -1798, -1460, -1035, -429, 325, 1102, 1651, 1882, 1769, 1408, 995, 452, -146, -745, -1461, -2357, -3430, -4546, -5542, -6206, -6385, -6301, -6184, -6198, -6478, -7115, -7986, -9030, -10180, -11326, -12402, -13326, -14146, -15204, -16406, -17524, -18368, -18930, -19240, -19363, -19473, -19639, -19856, -20192, -20606, -20964, -21106, -21097, -20884, -20545, -20014, -19265, -18478, -17780, -17165, -16302, -15118, -13644, -11947, -10193, -8520, -7027, -5627, -4320, -3106, -1865, -619, 739, 2066, 3231, 4400, 5494, 6556, 7643, 8892, 10280, 11607, 12851, 14015, 15099, 16000, 16635, 17047, 17232, 17129, 16813, 16378, 15823, 15214, 14716, 14196, 13423, 12577, 11864, 11222, 10606, 10017, 9473, 9099, 9005, 9168, 9583, 10078, 10662, 11561, 12687, 13862, 15086, 16228, 17241, 18306, 19383, 20455, 21551, 22502, 23181, 23621, 23677, 23292, 22557, 21583, 20478, 19383, 18556, 17968, 17472, 17018, 16428, 15681, 15055, 14689, 14641, 14806, 15002, 15078, 15093, 15016, 14892, 14638, 14252, 13807, 13261, 12505, 11567, 10147, 8079, 5558, 2843, -117, -3110, -5988, -8699, -11518, -14456, -17351, -20146, -22618, -24657, -26174, -27103, -27566, -27778, -27861, -27945, -28253, -28669, -29055, -29524, -29928, -30064, -30103, -30054, -29919, -29859, -29928, -30154, -30663, -31404, -32106, -32610, -32760, -32558, -32318, -32229, -32167, -31904, -31488, -31020, -30575, -30086, -29310, -28115, -26432, -24393, -22053, -19700, -17491, -15421, -13312, -11106, -8652, -6027, -3373, -769};