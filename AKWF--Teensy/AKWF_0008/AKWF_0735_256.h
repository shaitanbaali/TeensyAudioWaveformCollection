/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0735 256 samples */
 
const int16_t AKWF_0735_256_DATA [256] = 
{895, 656, 1740, 2840, 3932, 5026, 6122, 7214, 8308, 9403, 10494, 11587, 12681, 13772, 14864, 15957, 17046, 18138, 19230, 20319, 21411, 22501, 23589, 24680, 25769, 26856, 27946, 29034, 30120, 31188, 32374, 32237, 31019, 29947, 28848, 27747, 26649, 25549, 24448, 23350, 22250, 21149, 20053, 18952, 17852, 16755, 15655, 14555, 13459, 12360, 11260, 10165, 9066, 7968, 6872, 5774, 4677, 3583, 2484, 1400, 254, -514, -501, -504, -509, -510, -512, -514, -515, -515, -517, -518, -518, -519, -519, -520, -521, -520, -521, -523, -522, -523, -522, -523, -524, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -523, -524, -523, -523, -522, -523, -522, -522, -522, -522, -522, -522, -523, -522, -521, -520, -521, -520, -520, -520, -520, -520, -521, -520, -519, -520, -520, -519, -519, -519, -519, -519, -520, -519, -518, -519, -518, -518, -518, -518, -518, -519, -518, -517, -518, -517, -517, -517, -517, -517, -518, -517, -515, -516, -515, -515, -515, -515, -515, -516, -515, -515, -514, -515, -514, -514, -514, -514, -514, -515, -514, -513, -514, -513, -513, -513, -513, -513, -514, -513, -512, -513, -512, -512, -512, -512, -512, -513, -512, -510, -511, -511, -524, -464, -970, -2145, -3256, -4376, -5390, -7098, -5355, -1108, -2758, -3691, -4736, -5782, -6825, -7871, -8916, -9958, -11004, -12048, -13090, -14135, -15179, -16220, -17265, -18308, -19349, -20393, -21435, -22476, -23519, -24559, -25600, -26642, -27682, -28723, -29759, -30798, -31852, -31381, -30233, -29204, -28150, -27100, -26047, -24994, -23944, -22891, -21838, -20788, -19735, -18683, -17633, -16340, -16583, -8787, 2091, 1758, 4135, -944, -3991, -756};