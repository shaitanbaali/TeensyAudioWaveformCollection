/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0758 256 samples */
 
const int16_t AKWF_0758_256_DATA [256] = 
{535, 1826, 3110, 4428, 5784, 7185, 8636, 10129, 11665, 13236, 14823, 16422, 18010, 19557, 21051, 22464, 23768, 24956, 26009, 26916, 27679, 28297, 28771, 29110, 29320, 29411, 29393, 29275, 29066, 28777, 28418, 27997, 27521, 27000, 26440, 25847, 25229, 24589, 23933, 23268, 22595, 21918, 21244, 20572, 19906, 19251, 18603, 17966, 17338, 16715, 16092, 15464, 14820, 14154, 13463, 12734, 11965, 11152, 10287, 9369, 8395, 7360, 6270, 5126, 3929, 2692, 1418, 115, -1204, -2537, -3881, -5224, -6568, -7909, -9240, -10564, -11876, -13170, -14448, -15706, -16937, -18144, -19323, -20469, -21586, -22668, -23715, -24729, -25705, -26645, -27551, -28419, -29245, -30023, -30739, -31375, -31915, -32336, -32622, -32759, -32739, -32556, -32212, -31715, -31071, -30290, -29388, -28373, -27259, -26065, -24796, -23466, -22093, -20677, -19234, -17775, -16300, -14821, -13348, -11881, -10428, -8997, -7585, -6203, -4853, -3528, -2232, -954, 319, 1595, 2892, 4221, 5586, 6997, 8457, 9958, 11502, 13081, 14676, 16283, 17877, 19433, 20934, 22351, 23663, 24856, 25913, 26826, 27594, 28216, 28694, 29037, 29252, 29346, 29331, 29216, 29011, 28725, 28369, 27950, 27477, 26958, 26400, 25808, 25193, 24555, 23900, 23236, 22564, 21890, 21217, 20546, 19881, 19227, 18581, 17945, 17318, 16696, 16073, 15446, 14803, 14137, 13446, 12718, 11950, 11138, 10273, 9355, 8381, 7347, 6258, 5114, 3918, 2680, 1407, 105, -1215, -2548, -3891, -5234, -6578, -7919, -9249, -10573, -11886, -13178, -14457, -15715, -16945, -18153, -19332, -20478, -21594, -22676, -23722, -24737, -25713, -26653, -27559, -28426, -29252, -30031, -30745, -31380, -31916, -32332, -32611, -32740, -32708, -32514, -32155, -31642, -30979, -30179, -29257, -28223, -27091, -25877, -24590, -23245, -21856, -20427, -18973, -17504, -16022, -14539, -13064, -11595, -10143, -8715, -7308, -5931, -4587, -3272, -1987, -695};