/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0773 256 samples */
 
const int16_t AKWF_0773_256_DATA [256] = 
{980, 3044, 4905, 6528, 7838, 8830, 9626, 10423, 11351, 12420, 13703, 15426, 17563, 19758, 21755, 23487, 24967, 26154, 26893, 27240, 27715, 28667, 29813, 30778, 31407, 31658, 31525, 31024, 30182, 29015, 27578, 25972, 24351, 22866, 21564, 20406, 19357, 18402, 17581, 16969, 16603, 16449, 16454, 16706, 17257, 17632, 16758, 12075, 3171, -4629, -9243, -12015, -13739, -14838, -15568, -16085, -16512, -16975, -17595, -18448, -19560, -20904, -22399, -23950, -25468, -26868, -28068, -29006, -29656, -30046, -30187, -30028, -29522, -28707, -27553, -25678, -22575, -18525, -15093, -13371, -12913, -13139, -13778, -14305, -14249, -13507, -12244, -10666, -8880, -6920, -4854, -2835, -1316, -1008, -2026, -3561, -4569, -4270, -2642, -635, 1031, 2208, 3073, 3925, 4903, 5925, 6961, 8340, 10143, 11412, 10238, 4120, -3480, -8187, -10875, -12519, -13530, -14144, -14472, -14554, -14416, -14117, -13901, -13359, -10951, -8914, -8426, -8301, -7701, -6181, -3803, -1248, 897, 2544, 3820, 5002, 6286, 7674, 9274, 11449, 14160, 16858, 19170, 21031, 22495, 23521, 23868, 23624, 23749, 24922, 26607, 28133, 29253, 29914, 30110, 29873, 29234, 28220, 26897, 25383, 23851, 22450, 21217, 20116, 19100, 18152, 17327, 16712, 16340, 16169, 16160, 16403, 16947, 17299, 16308, 11188, 2064, -5459, -9801, -12401, -14005, -15025, -15710, -16216, -16668, -17188, -17894, -18854, -20077, -21533, -23140, -24811, -26465, -28021, -29413, -30587, -31508, -32189, -32625, -32768, -32592, -32114, -31326, -30061, -28161, -25870, -23814, -22330, -21264, -20466, -19904, -19410, -18783, -17982, -17111, -16304, -15650, -15193, -14962, -14980, -15322, -16109, -17309, -18676, -19887, -20685, -20907, -20499, -19578, -18382, -16988, -15170, -12769, -10099, -7417, -4145, -341, 2054, -264, -6288, -10656, -13045, -14358, -15068, -15427, -15573, -15551, -15338, -14911, -14279, -13661, -12529, -8713, -4812, -2701, -973};