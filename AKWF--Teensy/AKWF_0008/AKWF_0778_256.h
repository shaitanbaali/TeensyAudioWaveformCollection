/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0778 256 samples */
 
const int16_t AKWF_0778_256_DATA [256] = 
{847, 2246, 3588, 4906, 6189, 7438, 8650, 9819, 10951, 12044, 13091, 14101, 15070, 15996, 16884, 17735, 18544, 19320, 20059, 20761, 21432, 22069, 22675, 23252, 23799, 24318, 24811, 25279, 25723, 26143, 26540, 26916, 27274, 27611, 27930, 28231, 28516, 28785, 29040, 29280, 29506, 29720, 29921, 30111, 30291, 30459, 30619, 30768, 30909, 31041, 31166, 31282, 31393, 31496, 31592, 31683, 31768, 31847, 31921, 31991, 32056, 32116, 32173, 32224, 32274, 32317, 32359, 32397, 32432, 32463, 32491, 32519, 32542, 32562, 32580, 32595, 32608, 32619, 32627, 32632, 32634, 32634, 32630, 32622, 32611, 32593, 32570, 32542, 32510, 32451, 32361, 32247, 32100, 31919, 31699, 31436, 31124, 30769, 30491, 30038, 29207, 28663, 28162, 27533, 26798, 26006, 25134, 24312, 23455, 22582, 21692, 20815, 19831, 18784, 17704, 16643, 15537, 14379, 13171, 11911, 10612, 9280, 7909, 6515, 5103, 3678, 2254, 838, -566, -1949, -3308, -4640, -5936, -7198, -8425, -9608, -10754, -11860, -12922, -13945, -14926, -15865, -16766, -17629, -18450, -19237, -19987, -20699, -21380, -22028, -22644, -23230, -23785, -24311, -24814, -25289, -25738, -26166, -26569, -26952, -27315, -27657, -27982, -28288, -28577, -28851, -29110, -29353, -29584, -29801, -30006, -30200, -30382, -30553, -30714, -30867, -31011, -31145, -31272, -31391, -31502, -31607, -31705, -31798, -31884, -31965, -32041, -32112, -32178, -32239, -32295, -32350, -32399, -32444, -32486, -32525, -32560, -32592, -32622, -32648, -32673, -32694, -32712, -32728, -32742, -32753, -32761, -32766, -32768, -32767, -32765, -32758, -32747, -32730, -32707, -32679, -32646, -32586, -32496, -32381, -32234, -32050, -31827, -31559, -31243, -30884, -30603, -30144, -29308, -28757, -28245, -27609, -26865, -26032, -25164, -24325, -23447, -22549, -21626, -20699, -19714, -18634, -17525, -16434, -15301, -14119, -12890, -11615, -10303, -8960, -7584, -6187, -4776, -3357, -1944, -509};