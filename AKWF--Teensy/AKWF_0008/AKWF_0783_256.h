/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0783 256 samples */
 
const int16_t AKWF_0783_256_DATA [256] = 
{1241, 3109, 4783, 6319, 7736, 9054, 10281, 11429, 12510, 13531, 14498, 15417, 16294, 17130, 17933, 18701, 19438, 20148, 20829, 21483, 22113, 22719, 23298, 23856, 24392, 24905, 25396, 25865, 26313, 26742, 27151, 27539, 27909, 28261, 28595, 28912, 29211, 29493, 29762, 30015, 30253, 30477, 30687, 30885, 31071, 31244, 31406, 31557, 31697, 31827, 31947, 32058, 32161, 32253, 32337, 32414, 32482, 32543, 32596, 32641, 32680, 32711, 32735, 32754, 32765, 32768, 32765, 32756, 32741, 32717, 32687, 32652, 32608, 32557, 32500, 32433, 32361, 32280, 32192, 32095, 31988, 31874, 31751, 31617, 31474, 31319, 31154, 30977, 30788, 30586, 30370, 30140, 29895, 29634, 29357, 29061, 28745, 28411, 28055, 27676, 27274, 26847, 26392, 25911, 25400, 24856, 24281, 23670, 23023, 22339, 21612, 20845, 20034, 19177, 18272, 17318, 16310, 15247, 14130, 12947, 11699, 10385, 8993, 7519, 5961, 4303, 2544, 668, -1266, -3102, -4780, -6320, -7738, -9053, -10281, -11430, -12511, -13531, -14498, -15417, -16295, -17131, -17934, -18702, -19438, -20148, -20830, -21484, -22115, -22719, -23299, -23857, -24392, -24905, -25396, -25865, -26314, -26743, -27151, -27539, -27910, -28261, -28595, -28912, -29211, -29494, -29763, -30015, -30253, -30478, -30688, -30886, -31071, -31244, -31406, -31557, -31697, -31827, -31948, -32059, -32161, -32254, -32338, -32414, -32483, -32543, -32596, -32641, -32680, -32712, -32736, -32754, -32765, -32768, -32765, -32756, -32741, -32718, -32688, -32652, -32608, -32557, -32499, -32434, -32361, -32280, -32192, -32095, -31990, -31875, -31751, -31617, -31474, -31319, -31154, -30978, -30788, -30587, -30371, -30141, -29896, -29635, -29357, -29062, -28746, -28411, -28055, -27677, -27275, -26848, -26394, -25912, -25400, -24856, -24282, -23670, -23023, -22339, -21613, -20846, -20035, -19176, -18272, -17319, -16311, -15247, -14130, -12946, -11699, -10385, -8994, -7518, -5961, -4308, -2554, -641};