/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0727 256 samples */
 
const int16_t AKWF_0727_256_DATA [256] = 
{7988, 8514, 9025, 9534, 10038, 10539, 11038, 11532, 12023, 12512, 12996, 13477, 13954, 14428, 14899, 15367, 15832, 16294, 16754, 17210, 17665, 18116, 18563, 19010, 19453, 19894, 20332, 20768, 21200, 21631, 22061, 22486, 22912, 23334, 23755, 24174, 24591, 25006, 25419, 25830, 26240, 26648, 27054, 27460, 27863, 28266, 28668, 29067, 29465, 29863, 30261, 30656, 31051, 31445, 31838, 32226, 32646, 32563, 32105, 31695, 31270, 30837, 30398, 29953, 29499, 29039, 28569, 28092, 27608, 27113, 26608, 26094, 25568, 25030, 24481, 23917, 23339, 22746, 22137, 21508, 20862, 20191, 19496, 18777, 18023, 17236, 16409, 15532, 14600, 13597, 12500, 11207, 10256, 6655, -2193, -1457, -964, -459, 65, 596, 1131, 1671, 2222, 2770, 3320, 3865, 4405, 4943, 5476, 5902, 6997, 4974, -2939, -2978, -3508, -3969, -4425, -4877, -5323, -5768, -6207, -6644, -7078, -7509, -7935, -8357, -8778, -9194, -9608, -10019, -10426, -10831, -11231, -11630, -12026, -12418, -12807, -13196, -13579, -13961, -14339, -14714, -15090, -15460, -15827, -16193, -16556, -16916, -17276, -17632, -17985, -18336, -18685, -19032, -19377, -19719, -20059, -20396, -20733, -21066, -21398, -21727, -22055, -22381, -22704, -23027, -23346, -23664, -23980, -24295, -24606, -24918, -25227, -25533, -25840, -26143, -26446, -26744, -27050, -27332, -27145, -26807, -26501, -26184, -25867, -25547, -25225, -24903, -24577, -24250, -23920, -23588, -23254, -22919, -22580, -22240, -21898, -21554, -21206, -20858, -20505, -20151, -19796, -19436, -19075, -18712, -18346, -17976, -17604, -17230, -16852, -16474, -16090, -15703, -15316, -14925, -14531, -14133, -13733, -13329, -12923, -12511, -12098, -11681, -11261, -10837, -10411, -9979, -9545, -9106, -8663, -8217, -7768, -7315, -6857, -6393, -5928, -5458, -4983, -4504, -4021, -3531, -2975, -2876, -676, 5825, 2753, 2439, 1915, 1418, 925, 437, -47, -526, -1002, -1483};