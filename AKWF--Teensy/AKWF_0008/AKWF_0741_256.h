/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0741 256 samples */
 
const int16_t AKWF_0741_256_DATA [256] = 
{603, 1897, 3137, 4351, 5533, 6681, 7794, 8865, 9897, 10887, 11830, 12731, 13586, 14392, 15153, 15866, 16530, 17148, 17720, 18242, 18721, 19154, 19542, 19889, 20193, 20456, 20681, 20869, 21021, 21139, 21225, 21282, 21309, 21311, 21289, 21244, 21180, 21097, 20996, 20883, 20757, 20621, 20476, 20325, 20168, 20008, 19846, 19684, 19524, 19366, 19211, 19063, 18920, 18785, 18657, 18538, 18430, 18332, 18244, 18168, 18104, 18052, 18013, 17985, 17970, 17968, 17978, 18000, 18034, 18080, 18137, 18204, 18282, 18370, 18467, 18574, 18688, 18811, 18939, 19073, 19214, 19359, 19508, 19660, 19815, 19971, 20129, 20288, 20446, 20604, 20759, 20913, 21063, 21210, 21354, 21492, 21626, 21754, 21877, 21993, 22102, 22204, 22299, 22386, 22466, 22537, 22600, 22654, 22700, 22738, 22767, 22787, 22799, 22801, 22796, 22782, 22760, 22730, 22692, 22649, 22599, 22545, 22484, 22417, 22343, 22263, 22177, 22083, 21983, 21871, 21741, 21592, 21417, 21217, 20988, 20730, 20440, 20117, 19763, 19371, 18944, 18480, 17976, 17432, 16850, 16226, 15562, 14859, 14114, 13332, 12515, 11659, 10771, 9852, 8900, 7922, 6920, 5891, 4845, 3782, 2702, 1611, 511, -597, -1707, -2818, -3931, -5036, -6136, -7228, -8306, -9373, -10426, -11457, -12472, -13467, -14435, -15384, -16306, -17201, -18071, -18912, -19722, -20506, -21260, -21981, -22675, -23339, -23971, -24576, -25151, -25697, -26214, -26704, -27167, -27605, -28017, -28406, -28771, -29114, -29437, -29740, -30024, -30292, -30544, -30779, -31002, -31213, -31413, -31603, -31786, -31960, -32128, -32291, -32441, -32569, -32669, -32736, -32766, -32756, -32702, -32604, -32459, -32266, -32023, -31726, -31375, -30966, -30498, -29971, -29382, -28733, -28023, -27251, -26422, -25534, -24591, -23596, -22548, -21453, -20317, -19137, -17921, -16675, -15397, -14095, -12775, -11437, -10088, -8733, -7373, -6015, -4663, -3320, -1993, -656};