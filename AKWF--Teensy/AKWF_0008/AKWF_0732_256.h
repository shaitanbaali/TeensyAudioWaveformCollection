/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0732 256 samples */
 
const int16_t AKWF_0732_256_DATA [256] = 
{760, 3195, 5581, 7974, 10365, 12757, 15154, 17543, 19936, 22331, 24718, 27106, 29465, 32023, 31446, 28793, 26456, 24054, 21654, 19258, 16858, 14457, 12063, 9661, 7262, 4869, 2489, 6, -1943, -2039, -2018, -2030, -2031, -2033, -2035, -2036, -2038, -2039, -2039, -2040, -2042, -2041, -2042, -2043, -2042, -2042, -2042, -2042, -2042, -2042, -2042, -2042, -2042, -2042, -2043, -2042, -2041, -2041, -2042, -2041, -2039, -2040, -2039, -2038, -2039, -2039, -2038, -2038, -2037, -2035, -2036, -2035, -2034, -2035, -2034, -2034, -2033, -2031, -2032, -2031, -2030, -2030, -2029, -2030, -2028, -2027, -2028, -2027, -2027, -2026, -2026, -2025, -2023, -2024, -2023, -2022, -2022, -2021, -2022, -2020, -2019, -2019, -2018, -2019, -2018, -2018, -2017, -2017, -2016, -2014, -2015, -2014, -2013, -2013, -2012, -2013, -2011, -2010, -2010, -2009, -2010, -2009, -2009, -2008, -2006, -2006, -2005, -2006, -2005, -2004, -2004, -2001, -1996, -1992, -1989, -1987, -1985, -1984, -1983, -1983, -1984, -1984, -1986, -1988, -1991, -1995, -1995, -1994, -1994, -1994, -1993, -1992, -1993, -1992, -1992, -1991, -1989, -1989, -1988, -1989, -1988, -1987, -1987, -1986, -1986, -1985, -1984, -1985, -1984, -1984, -1982, -1981, -1981, -1980, -1981, -1980, -1979, -1979, -1978, -1978, -1977, -1976, -1976, -1975, -1976, -1974, -1973, -1973, -1972, -1973, -1972, -1971, -1971, -1971, -1970, -1969, -1969, -1968, -1967, -1968, -1967, -1967, -1966, -1964, -1965, -1964, -1963, -1963, -1962, -1963, -1961, -1960, -1960, -1959, -1959, -1959, -1959, -1958, -1956, -1957, -1956, -1956, -1955, -1954, -1955, -1953, -1952, -1952, -1951, -1952, -1951, -1951, -1950, -1948, -1949, -1948, -1948, -1947, -1946, -1947, -1946, -1946, -1945, -1943, -1944, -1943, -1942, -1942, -1941, -1942, -1940, -1912, -2030, -1398, 1522, 1394};