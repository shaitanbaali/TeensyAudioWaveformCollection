/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0703 256 samples */
 
const int16_t AKWF_0703_256_DATA [256] = 
{452, 1589, 2626, 3605, 4522, 5393, 6216, 6992, 7731, 8436, 9106, 9741, 10351, 10934, 11493, 12026, 12537, 13027, 13496, 13946, 14379, 14794, 15192, 15577, 15946, 16298, 16639, 16967, 17284, 17585, 17877, 18155, 18424, 18682, 18928, 19170, 19396, 19616, 19828, 20028, 20221, 20407, 20583, 20753, 20915, 21069, 21216, 21356, 21490, 21617, 21738, 21852, 21960, 22062, 22156, 22246, 22331, 22410, 22483, 22551, 22614, 22673, 22725, 22772, 22816, 22856, 22889, 22917, 22944, 22963, 22978, 22991, 22999, 23003, 23003, 23002, 22992, 22982, 22967, 22949, 22926, 22900, 22869, 22837, 22799, 22762, 22720, 22674, 22623, 22572, 22517, 22460, 22400, 22334, 22268, 22198, 22126, 21876, 22754, 18241, 1781, -86, -1619, -2722, -3598, -4321, -4939, -5481, -5964, -6394, -6784, -7138, -7463, -7762, -8041, -8297, -8535, -8759, -8966, -9163, -9347, -9519, -9682, -9833, -9978, -10113, -10239, -10360, -10473, -10581, -10683, -10778, -10868, -10952, -11032, -11107, -11178, -11244, -11306, -11365, -11420, -11470, -11518, -11563, -11603, -11643, -11678, -11711, -11739, -11766, -11790, -11812, -11830, -11848, -11863, -11876, -11885, -11893, -11901, -11905, -11908, -11909, -11907, -11904, -11899, -11892, -11885, -11876, -11864, -11854, -11838, -11823, -11808, -11788, -11767, -11749, -11727, -11704, -11680, -11655, -11629, -11602, -11573, -11542, -11512, -11480, -11447, -11414, -11378, -11343, -11308, -11269, -11232, -11192, -11154, -11113, -11072, -11028, -10984, -10943, -10900, -10853, -10809, -10762, -10717, -10669, -10620, -10571, -10523, -10472, -10420, -10370, -10320, -10269, -10215, -10163, -10108, -10054, -10000, -9946, -9890, -9835, -9780, -9724, -9665, -9608, -9550, -9493, -9435, -9376, -9318, -9258, -9198, -9270, -8314, -11717, -27022, -12830, -10992, -9212, -7936, -6894, -6015, -5269, -4604, -4002, -3462, -2972, -2521, -2108, -1724, -1368, -1039, -731, -442, -166};