/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0744 256 samples */
 
const int16_t AKWF_0744_256_DATA [256] = 
{634, 2287, 4024, 5851, 7710, 9562, 11350, 13016, 14516, 15812, 16883, 17722, 18341, 18765, 19035, 19189, 19274, 19337, 19412, 19526, 19698, 19928, 20221, 20564, 20944, 21351, 21777, 22215, 22667, 23138, 23638, 24173, 24750, 25369, 26024, 26701, 27377, 28028, 28622, 29127, 29516, 29773, 29879, 29831, 29636, 29309, 28862, 28321, 27706, 27031, 26307, 25549, 24748, 23904, 23019, 22082, 21102, 20092, 19062, 18037, 17047, 16124, 15301, 14604, 14044, 13636, 13364, 13210, 13140, 13108, 13067, 12969, 12773, 12447, 11974, 11350, 10589, 9724, 8788, 7826, 6888, 6012, 5237, 4590, 4082, 3719, 3496, 3399, 3413, 3526, 3723, 3995, 4341, 4763, 5261, 5844, 6513, 7262, 8086, 8968, 9884, 10804, 11699, 12536, 13289, 13938, 14469, 14877, 15172, 15363, 15473, 15523, 15532, 15521, 15498, 15471, 15438, 15390, 15325, 15235, 15118, 14976, 14817, 14660, 14526, 14436, 14415, 14479, 14638, 14889, 15219, 15593, 15972, 16307, 16546, 16634, 16529, 16195, 15615, 14781, 13711, 12436, 10989, 9422, 7788, 6126, 4478, 2880, 1344, -112, -1491, -2807, -4059, -5257, -6412, -7523, -8587, -9596, -10538, -11408, -12195, -12896, -13516, -14068, -14568, -15043, -15522, -16025, -16583, -17214, -17926, -18721, -19591, -20518, -21488, -22472, -23447, -24403, -25319, -26190, -27019, -27806, -28555, -29275, -29962, -30612, -31219, -31757, -32204, -32536, -32728, -32762, -32628, -32327, -31873, -31298, -30640, -29952, -29286, -28697, -28232, -27928, -27804, -27867, -28106, -28497, -29002, -29578, -30181, -30765, -31299, -31749, -32106, -32357, -32505, -32559, -32529, -32425, -32255, -32020, -31718, -31338, -30876, -30319, -29658, -28891, -28023, -27063, -26033, -24957, -23861, -22778, -21729, -20734, -19809, -18951, -18154, -17411, -16696, -15992, -15284, -14546, -13778, -12973, -12131, -11259, -10367, -9457, -8539, -7607, -6649, -5655, -4602, -3463, -2222, -825};