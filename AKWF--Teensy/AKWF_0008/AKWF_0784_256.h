/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0784 256 samples */
 
const int16_t AKWF_0784_256_DATA [256] = 
{627, 2014, 3354, 4672, 5959, 7214, 8435, 9615, 10759, 11864, 12927, 13952, 14938, 15883, 16793, 17665, 18499, 19299, 20065, 20795, 21496, 22164, 22800, 23409, 23989, 24542, 25070, 25571, 26049, 26503, 26935, 27345, 27736, 28106, 28457, 28790, 29105, 29403, 29686, 29951, 30202, 30440, 30663, 30872, 31070, 31253, 31426, 31586, 31735, 31873, 32000, 32118, 32224, 32321, 32407, 32485, 32553, 32612, 32661, 32701, 32732, 32753, 32765, 32767, 32760, 32742, 32716, 32678, 32629, 32569, 32496, 32412, 32314, 32202, 32074, 31929, 31766, 31585, 31380, 31150, 30896, 30609, 30290, 29930, 29525, 29068, 28551, 27961, 27285, 26507, 25599, 24535, 23272, 21768, 20037, 18115, 16042, 13875, 11651, 9402, 7168, 4965, 2811, 736, -1243, -3147, -3493, -1581, 467, 2312, 4022, 5565, 6925, 8097, 9059, 9793, 10276, 10484, 10397, 10000, 9309, 8387, 7297, 6090, 4805, 3467, 2103, 728, -649, -2010, -3353, -4674, -5960, -7216, -8436, -9616, -10760, -11864, -12927, -13952, -14939, -15884, -16793, -17666, -18499, -19299, -20065, -20795, -21496, -22164, -22800, -23409, -23989, -24542, -25070, -25571, -26049, -26503, -26935, -27346, -27735, -28106, -28457, -28789, -29105, -29403, -29686, -29951, -30202, -30440, -30663, -30872, -31069, -31253, -31425, -31586, -31735, -31873, -32000, -32117, -32224, -32320, -32407, -32485, -32553, -32611, -32660, -32701, -32732, -32753, -32764, -32766, -32760, -32742, -32715, -32677, -32629, -32568, -32496, -32412, -32314, -32201, -32073, -31928, -31766, -31583, -31380, -31150, -30896, -30609, -30288, -29930, -29525, -29067, -28551, -27961, -27285, -26506, -25599, -24535, -23273, -21768, -20036, -18115, -16042, -13875, -11651, -9402, -7169, -4966, -2812, -737, 1242, 3146, 3489, 1576, -472, -2317, -4026, -5569, -6929, -8100, -9062, -9795, -10278, -10486, -10399, -10002, -9311, -8389, -7298, -6092, -4808, -3472, -2111, -711};