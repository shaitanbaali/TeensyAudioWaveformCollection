/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0716 256 samples */
 
const int16_t AKWF_0716_256_DATA [256] = 
{310, 980, 1669, 2284, 2896, 3480, 4025, 4575, 5072, 5578, 6050, 6504, 6955, 7366, 7789, 8176, 8557, 8931, 9274, 9627, 9946, 10267, 10571, 10859, 11151, 11410, 11679, 11924, 12161, 12396, 12603, 12823, 13014, 13204, 13387, 13549, 13720, 13860, 14009, 14141, 14258, 14385, 14475, 14586, 14668, 14744, 14828, 14867, 14946, 14972, 15008, 15066, 15022, 15180, 14695, 18517, 21352, 22322, 23353, 24222, 24900, 25586, 26148, 26676, 27184, 27604, 28047, 28412, 28776, 29116, 29404, 29717, 29956, 30217, 30442, 30634, 30854, 30993, 31178, 31304, 31420, 31559, 31602, 31733, 31759, 31798, 31912, 31637, 32602, 27394, 21885, 20367, 18550, 17130, 15942, 14779, 13812, 12859, 11993, 11199, 10407, 9711, 9004, 8358, 7738, 7125, 6570, 6000, 5481, 4967, 4467, 4001, 3528, 3095, 2655, 2240, 1841, 1439, 1073, 696, 343, 0, -340, -655, -979, -1277, -1576, -1864, -2136, -2415, -2665, -2924, -3166, -3398, -3633, -3844, -4065, -4264, -4462, -4656, -4831, -5015, -5176, -5343, -5497, -5638, -5787, -5911, -6047, -6163, -6275, -6390, -6479, -6584, -6664, -6748, -6828, -6885, -6962, -7003, -7062, -7107, -7129, -7187, -7178, -7219, -7281, -7035, -7933, -11138, -11973, -12823, -13421, -13981, -14456, -14862, -15253, -15574, -15888, -16158, -16402, -16629, -16818, -17000, -17148, -17282, -17394, -17487, -17559, -17606, -17684, -17554, -18117, -19451, -19755, -20133, -20389, -20623, -20845, -21014, -21203, -21349, -21498, -21641, -21756, -21893, -21991, -22105, -22207, -22294, -22399, -22468, -22561, -22632, -22704, -22784, -22833, -22911, -22957, -23017, -23075, -23110, -23175, -23199, -23252, -23287, -23312, -23364, -23367, -23417, -23427, -23447, -23483, -23468, -23521, -23499, -23522, -23543, -23497, -23577, -23498, -23449, -23841, -22475, -14568, -12194, -10139, -8631, -7181, -5976, -4883, -3831, -2934, -2025, -1221, -437};