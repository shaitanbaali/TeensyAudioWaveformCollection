/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0722 256 samples */
 
const int16_t AKWF_0722_256_DATA [256] = 
{25993, 31122, 28711, 28567, 28642, 28686, 28356, 29940, 33043, 32701, 32758, 32754, 32749, 32743, 32738, 32731, 32726, 32718, 32719, 32673, 32604, 32605, 32597, 32589, 32581, 32574, 32566, 32558, 32550, 32543, 32535, 32527, 32518, 32510, 32501, 32493, 32485, 32476, 32468, 32459, 32451, 32442, 32434, 32426, 32417, 32409, 32400, 32391, 32383, 32374, 32365, 32357, 32348, 32340, 32331, 32322, 32314, 32305, 32297, 32288, 32279, 32271, 32262, 32254, 32245, 32236, 32228, 32219, 32211, 32202, 32193, 32185, 32176, 32168, 32159, 32150, 32142, 32133, 32124, 32116, 32107, 32099, 32052, 31630, 34132, -281, -17634, -13426, -12459, -12821, -12431, -15785, -17412, -17074, -17137, -17138, -17137, -17138, -17137, -17136, -17134, -17133, -17131, -17129, -17127, -17124, -17121, -17119, -17116, -17113, -17110, -17106, -17102, -17099, -17095, -17091, -17087, -17083, -17079, -17075, -17071, -17067, -17063, -17058, -17054, -17050, -17045, -17041, -17037, -17032, -17028, -17024, -17019, -17015, -17011, -17006, -17001, -16997, -16993, -16988, -16983, -16979, -16975, -16970, -16966, -16962, -16956, -16953, -16948, -16943, -16939, -16934, -16929, -16925, -16921, -16916, -16911, -16907, -16903, -16898, -16894, -16889, -16884, -16880, -16875, -16871, -16866, -16862, -16857, -16853, -16848, -16844, -16839, -16834, -16830, -16826, -16821, -16816, -16812, -16808, -16803, -16799, -16794, -16790, -16785, -16781, -16776, -16772, -16767, -16762, -16758, -16753, -16749, -16744, -16740, -16735, -16731, -16727, -16722, -16718, -16713, -16709, -16704, -16699, -16696, -16691, -16686, -16682, -16677, -16673, -16668, -16664, -16659, -16655, -16650, -16646, -16641, -16637, -16633, -16628, -16624, -16619, -16614, -16611, -16606, -16601, -16597, -16592, -16588, -16584, -16579, -16575, -16570, -16566, -16561, -16557, -16552, -16548, -16543, -16539, -16535, -16530, -16526, -16516, -16442, -16901, -6830, -3923, -4581, -4460, -4456, -4453, -4451, -4448, -4445, -4443};