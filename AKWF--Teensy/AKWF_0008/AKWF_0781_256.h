/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0781 256 samples */
 
const int16_t AKWF_0781_256_DATA [256] = 
{3536, 10591, 15256, 18632, 21128, 23018, 24483, 25634, 26558, 27310, 27927, 28443, 28878, 29244, 29502, 29659, 29761, 29828, 29873, 29905, 29927, 29941, 29950, 29956, 29960, 29960, 29960, 29959, 29956, 29952, 29950, 29945, 29938, 29934, 29927, 29921, 29916, 29909, 29903, 29896, 29889, 29882, 29875, 29868, 29861, 29854, 29846, 29838, 29831, 29824, 29816, 29808, 29800, 29793, 29785, 29777, 29769, 29762, 29754, 29746, 29739, 29731, 29723, 29715, 29707, 29699, 29692, 29684, 29676, 29667, 29660, 29651, 29644, 29636, 29629, 29620, 29613, 29604, 29597, 29588, 29581, 29572, 29565, 29557, 29549, 29541, 29533, 29525, 29517, 29510, 29501, 29494, 29485, 29478, 29469, 29462, 29454, 29446, 29438, 29430, 29422, 29414, 29406, 29398, 29391, 29382, 29375, 29366, 29359, 29350, 29342, 29334, 29326, 29318, 29310, 29303, 29294, 29287, 29279, 29271, 29263, 29255, 29247, 29238, 29231, 29222, 29215, 29207, 29200, 29190, 29183, 28071, 33981, 1188, -37673, -31628, -32763, -32767, -32768, -32767, -32767, -32768, -32766, -32764, -32761, -32758, -32753, -32749, -32744, -32740, -32734, -32729, -32722, -32717, -32710, -32704, -32697, -32689, -32683, -32675, -32668, -32660, -32652, -32645, -32637, -32629, -32621, -32613, -32605, -32596, -32589, -32580, -32571, -32563, -32556, -32546, -32538, -32529, -32521, -32513, -32504, -32496, -32487, -32478, -32469, -32460, -32451, -32443, -32436, -32427, -32418, -32409, -32400, -32392, -32383, -32374, -32365, -32356, -32348, -32339, -32330, -32321, -32312, -32304, -32295, -32286, -32277, -32268, -32259, -32251, -32240, -32231, -32222, -32213, -32205, -32195, -32185, -32176, -32166, -32157, -32147, -32137, -32127, -32116, -32105, -32094, -32082, -32071, -32058, -32044, -32030, -32013, -31995, -31975, -31951, -31922, -31886, -31841, -31782, -31701, -31586, -31415, -31142, -30763, -30318, -29790, -29161, -28397, -27461, -26298, -24818, -22915, -20400, -17002, -12307, -5204};