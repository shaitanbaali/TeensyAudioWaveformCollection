/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0785 256 samples */
 
const int16_t AKWF_0785_256_DATA [256] = 
{339, 1142, 1922, 2699, 3468, 4230, 4987, 5735, 6478, 7214, 7943, 8666, 9382, 10090, 10792, 11489, 12175, 12856, 13529, 14193, 14851, 15500, 16138, 16770, 17392, 18004, 18608, 19202, 19784, 20358, 20920, 21471, 22013, 22541, 23060, 23566, 24060, 24543, 25014, 25472, 25918, 26352, 26772, 27181, 27577, 27958, 28328, 28685, 29026, 29357, 29673, 29975, 30264, 30540, 30800, 31047, 31279, 31496, 31699, 31887, 32059, 32214, 32352, 32472, 32575, 32657, 32717, 32755, 32768, 32753, 32709, 32630, 32511, 32345, 32126, 31842, 31479, 31015, 30433, 29746, 28977, 28162, 27341, 26543, 25778, 25049, 24344, 23640, 22924, 22201, 21347, 21409, 22536, 23454, 24663, 25075, 24942, 24300, 23193, 21837, 20481, 19270, 18234, 17339, 16520, 15732, 14976, 14256, 13585, 12975, 12413, 11884, 11368, 10839, 10279, 9677, 9028, 8337, 7611, 6853, 6075, 5281, 4476, 3668, 2859, 2049, 1244, 442, -353, -1141, -1924, -2701, -3470, -4233, -4989, -5737, -6480, -7217, -7945, -8667, -9384, -10091, -10794, -11490, -12175, -12856, -13530, -14193, -14850, -15500, -16138, -16770, -17392, -18003, -18607, -19201, -19784, -20356, -20919, -21471, -22011, -22540, -23058, -23564, -24058, -24541, -25013, -25471, -25916, -26349, -26771, -27179, -27575, -27956, -28326, -28683, -29024, -29354, -29671, -29973, -30262, -30538, -30798, -31045, -31277, -31494, -31697, -31885, -32057, -32213, -32350, -32471, -32573, -32655, -32716, -32754, -32767, -32752, -32707, -32629, -32510, -32345, -32126, -31842, -31479, -31016, -30433, -29746, -28978, -28163, -27342, -26544, -25779, -25050, -24345, -23641, -22925, -22201, -21348, -21413, -22539, -23458, -24666, -25077, -24944, -24302, -23195, -21839, -20483, -19272, -18236, -17342, -16524, -15736, -14981, -14260, -13589, -12978, -12416, -11888, -11371, -10842, -10282, -9680, -9031, -8340, -7614, -6856, -6078, -5285, -4479, -3671, -2862, -2053, -1250, -435};