/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0768 256 samples */
 
const int16_t AKWF_0768_256_DATA [256] = 
{268, 1181, 2030, 2841, 3608, 4329, 5003, 5628, 6205, 6731, 7206, 7632, 8006, 8327, 8602, 8828, 9007, 9146, 9245, 9309, 9345, 9356, 9352, 9337, 9312, 9286, 9259, 9242, 9234, 9241, 9261, 9298, 9355, 9432, 9528, 9645, 9777, 9927, 10094, 10274, 10466, 10668, 10879, 11094, 11312, 11532, 11750, 11970, 12181, 12392, 12597, 12801, 13005, 13208, 13410, 13618, 13833, 14057, 14288, 14528, 14779, 15040, 15311, 15591, 15882, 16179, 16486, 16797, 17113, 17430, 17750, 18068, 18384, 18698, 19001, 19294, 19576, 19846, 20102, 20343, 20568, 20780, 20978, 21165, 21339, 21505, 21663, 21818, 21970, 22123, 22272, 22423, 22581, 22742, 22909, 23075, 23249, 23425, 23603, 23782, 23960, 24137, 24316, 24492, 24658, 24817, 24968, 25106, 25232, 25343, 25439, 25515, 25571, 25604, 25615, 25600, 25565, 25499, 25404, 25281, 25127, 24942, 24724, 24474, 24188, 23866, 23505, 23108, 22670, 22191, 21671, 21110, 20506, 19854, 19161, 18423, 17639, 16807, 15931, 15005, 14030, 13012, 11945, 10832, 9681, 8490, 7262, 6011, 4732, 3436, 2134, 822, -484, -1777, -3056, -4312, -5541, -6746, -7912, -9044, -10141, -11194, -12212, -13189, -14126, -15028, -15895, -16725, -17520, -18290, -19028, -19744, -20436, -21106, -21757, -22393, -23010, -23612, -24197, -24765, -25313, -25842, -26349, -26834, -27296, -27733, -28145, -28530, -28890, -29225, -29535, -29822, -30086, -30329, -30551, -30754, -30942, -31110, -31268, -31413, -31549, -31675, -31794, -31911, -32022, -32131, -32239, -32341, -32440, -32533, -32612, -32682, -32734, -32763, -32766, -32740, -32682, -32584, -32442, -32257, -32027, -31747, -31420, -31040, -30608, -30126, -29591, -29005, -28365, -27676, -26937, -26150, -25315, -24434, -23512, -22552, -21551, -20521, -19461, -18373, -17265, -16138, -14994, -13845, -12683, -11521, -10366, -9212, -8069, -6941, -5827, -4738, -3674, -2635, -1630, -642};