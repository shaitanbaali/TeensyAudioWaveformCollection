/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0737 256 samples */
 
const int16_t AKWF_0737_256_DATA [256] = 
{1444, 1472, 1498, 1525, 1551, 1577, 1602, 1627, 1651, 1676, 1701, 1724, 1747, 1771, 1796, 1818, 1840, 1864, 1888, 1910, 1933, 1955, 1977, 2000, 2022, 2045, 2067, 2090, 2112, 2134, 2155, 2177, 2200, 2222, 2244, 2266, 2288, 2310, 2332, 2354, 2375, 2397, 2419, 2441, 2462, 2484, 2506, 2528, 2550, 2571, 2592, 2615, 2636, 2658, 2679, 2701, 2723, 2744, 2765, 2787, 2809, 3182, 1316, 11461, 24928, 23313, 23994, 24317, 24638, 24958, 25278, 25597, 25918, 26237, 26556, 26874, 27193, 27512, 27830, 28148, 28466, 28783, 29101, 29419, 29736, 30054, 30369, 30685, 31003, 31320, 31636, 31952, 32234, 32736, 31208, 30240, 30202, 29974, 29773, 29573, 29373, 29173, 28973, 28772, 28572, 28371, 28171, 27972, 27771, 27571, 27371, 27171, 26970, 26771, 26570, 26371, 26171, 25971, 25771, 25572, 25372, 25173, 24972, 24773, 24573, 24373, 24175, 23975, 23775, 23576, 23378, 23179, 22979, 22779, 22580, 22382, 22183, 21984, 21785, 21587, 21387, 21189, 20990, 20791, 20593, 20395, 20197, 19998, 19800, 19600, 19163, 20016, 15220, -9215, -20184, -18878, -19333, -19475, -19617, -19759, -19899, -20041, -20180, -20320, -20459, -20598, -20736, -20874, -21012, -21149, -21286, -21424, -21561, -21698, -21834, -21971, -22108, -22243, -22380, -22515, -22651, -22787, -22922, -23058, -23193, -23328, -23464, -23599, -23734, -23870, -24005, -24140, -24274, -24409, -24543, -24678, -24813, -24948, -25082, -25217, -25351, -25485, -25619, -25754, -25889, -26022, -26157, -26291, -26425, -26559, -26693, -26826, -26961, -27095, -27228, -27362, -27497, -27630, -27764, -27897, -28031, -28164, -28298, -28431, -28557, -28843, -28647, -28286, -27962, -27630, -27298, -26967, -26637, -26307, -25976, -25644, -25312, -24983, -24653, -24321, -23990, -23660, -23329, -22999, -22668, -22338, -22008, -21678, -21347, -21018, -20687, -20358, -20028, -19698, -19370, -19034};