/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0736 256 samples */
 
const int16_t AKWF_0736_256_DATA [256] = 
{8376, 20530, 28367, 30760, 27282, 18558, 6198, -7472, -19970, -28981, -32833, -30839, -23488, -11450, -773, 1556, 3617, 5596, 7354, 8894, 10206, 11272, 12079, 12632, 12927, 12970, 12773, 12349, 11716, 10896, 9913, 8794, 7562, 6253, 4889, 3500, 2120, 768, -529, -1746, -2867, -3876, -4754, -5497, -6096, -6547, -6851, -7012, -7037, -6937, -6724, -6413, -6015, -5553, -5045, -4508, -3962, -3426, -2913, -2442, -2029, -1685, -1422, -1192, -2788, -5295, -7628, -9930, -12127, -14185, -16068, -17736, -19165, -20325, -21188, -21740, -21964, -21851, -21397, -20603, -19481, -18038, -16295, -14281, -12014, -9537, -6886, -4095, -1215, 1706, 4633, 7505, 10276, 12910, 15347, 17552, 19486, 21109, 22394, 23313, 23847, 23979, 23705, 23024, 21937, 20460, 18614, 16418, 13905, 11121, 8094, 4856, 1619, -2425, -7089, -9376, -9312, -7489, -4866, -2483, -1177, -1334, -2805, -4946, -6806, -7398, -6035, -2624, 7475, 18892, 26206, 28594, 25478, 17392, 5794, -7148, -19081, -27761, -31579, -30584, -23420, -11399, -754, 1646, 3775, 5814, 7625, 9209, 10555, 11647, 12470, 13028, 13319, 13350, 13132, 12680, 12015, 11157, 10135, 8975, 7704, 6356, 4959, 3543, 2140, 774, -529, -1745, -2871, -3884, -4770, -5523, -6134, -6598, -6917, -7094, -7136, -7050, -6850, -6551, -6165, -5711, -5208, -4672, -4123, -3578, -3054, -2567, -2132, -1762, -1467, -1204, -2659, -4961, -7093, -9191, -11182, -13043, -14739, -16233, -17507, -18560, -19175, -20457, -21530, -21282, -20866, -20096, -19006, -17602, -15908, -13948, -11742, -9328, -6746, -4024, -1215, 1636, 4495, 7303, 10015, 12593, 14983, 17145, 19049, 20647, 21916, 22829, 23364, 23508, 23252, 22596, 21542, 20101, 18298, 16147, 13682, 10946, 7968, 4777, 1585, -2424, -7034, -9208, -9023, -7124, -4514, -2254, -1170, -1611, -3366, -5719, -7660, -8189, -6599, -2565};