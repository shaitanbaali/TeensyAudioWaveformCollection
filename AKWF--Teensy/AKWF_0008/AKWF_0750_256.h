/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0750 256 samples */
 
const int16_t AKWF_0750_256_DATA [256] = 
{2532, 7364, 10003, 10348, 9517, 9234, 10783, 14373, 18898, 22552, 24074, 23439, 21765, 20811, 21875, 25009, 28994, 31930, 32357, 30185, 26519, 23073, 21286, 21363, 22220, 22218, 20092, 15865, 10818, 6680, 4811, 5397, 7164, 8263, 7326, 4169, -55, -3596, -5146, -4460, -2629, -1442, -2130, -4713, -8056, -10386, -10404, -8053, -4546, -1785, -1239, -3000, -5975, -8460, -9038, -7512, -4993, -3141, -3236, -5291, -8047, -9797, -9216, -6145, -1878, 1692, 3180, 2378, 401, -1018, -593, 1891, 5329, 7916, 8398, 6749, 4091, 2187, 2334, 4588, 7734, 9870, 9540, 6661, 2332, -1727, -4076, -4508, -4108, -4510, -6980, -11496, -16771, -21079, -23058, -22524, -20745, -19577, -20382, -23346, -27319, -30549, -31727, -30610, -28291, -26557, -26643, -28569, -31201, -32769, -31973, -28759, -24343, -20628, -19082, -19807, -21702, -23074, -22505, -19798, -16068, -12982, -11817, -12592, -14051, -14484, -12578, -8173, -2561, 2354, 5188, 5732, 5093, 5004, 6751, 10540, 15267, 19125, 20853, 20426, 18961, 18219, 19497, 22845, 27045, 30198, 30842, 28889, 25443, 22218, 20651, 20951, 22028, 22247, 20344, 16338, 11511, 7595, 5946, 6750, 8738, 10054, 9333, 6392, 2381, -947, -2286, -1390, 646, 2040, 1556, -826, -3970, -6104, -5928, -3384, 310, 3254, 3984, 2401, -396, -2710, -3119, -1427, 1254, 3263, 3322, 1418, -1192, -2798, -2079, 1123, 5520, 9215, 10824, 10138, 8271, 6958, 7485, 10065, 13595, 16268, 16833, 15260, 12673, 10836, 11043, 13352, 16549, 18731, 18441, 15596, 11296, 7260, 4929, 4509, 4918, 4518, 2043, -2480, -7769, -12098, -14101, -13598, -11855, -10727, -11580, -14597, -18626, -21918, -23164, -22120, -19878, -18227, -18401, -20420, -23151, -24821, -24133, -21030, -16731, -13138, -11718, -12573, -14603, -16114, -15688, -13129, -9550, -6620, -5614, -6551, -8177, -8789, -7069, -2734};