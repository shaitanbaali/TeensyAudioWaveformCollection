/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0725 256 samples */
 
const int16_t AKWF_0725_256_DATA [256] = 
{25401, 25207, 25017, 24827, 24634, 24441, 24246, 24053, 23859, 23665, 23470, 23276, 23080, 22884, 22687, 22492, 22296, 22100, 21903, 21706, 21510, 21313, 21117, 20920, 20723, 20526, 20329, 20132, 19936, 19739, 19541, 19345, 19147, 18950, 18753, 18557, 18359, 18163, 17966, 17769, 17573, 17376, 17179, 16982, 16785, 16588, 16392, 16196, 15999, 15803, 15606, 15410, 15214, 15017, 14821, 14625, 14429, 14233, 14036, 13841, 13646, 13449, 13253, 13058, 12789, 12800, 12085, -8268, -13775, -12909, -13345, -13573, -13803, -14034, -14268, -14503, -14742, -14982, -15225, -15471, -15720, -15973, -16229, -16488, -16752, -17021, -17293, -17572, -17855, -18143, -18437, -18738, -19045, -19360, -19682, -20012, -20350, -20698, -21054, -21422, -21799, -22187, -22590, -23002, -23430, -23874, -24329, -24803, -25294, -25800, -26328, -26874, -27438, -28025, -28629, -29249, -29883, -30523, -31152, -31748, -32269, -32646, -32763, -32429, -31326, -28836, -24881, -14404, 11523, 12617, 12044, 11960, 11772, 11584, 11394, 11205, 11014, 10823, 10632, 10441, 10248, 10058, 9866, 9673, 9481, 9288, 9095, 8901, 8709, 8516, 8322, 8129, 7936, 7742, 7549, 7355, 7162, 6968, 6775, 6582, 6388, 6194, 6001, 5807, 5613, 5421, 5226, 5033, 4839, 4645, 4452, 4259, 4065, 3872, 3678, 3485, 3293, 3099, 2905, 2712, 2518, 2326, 2133, 1939, 1747, 1554, 1360, 1167, 975, 781, 588, 396, 202, 10, -182, -375, -568, -760, -954, -1146, -1339, -1533, -1726, -1918, -2111, -2305, -2498, -2692, -2884, -3078, -3271, -3465, -3657, -3852, -4044, -4238, -4434, -4626, -4821, -5015, -5209, -5403, -5599, -5793, -5988, -6183, -6378, -6575, -6770, -6965, -7163, -7360, -7558, -7755, -7952, -8151, -8350, -8548, -8749, -8951, -9150, -9352, -9554, -9757, -9960, -10166, -10370, -10576, -10784, -10992, -11201, -11412, -11623, -11837, -12049, -12268};