/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0733 256 samples */
 
const int16_t AKWF_0733_256_DATA [256] = 
{958, 3482, 5956, 8437, 10916, 13396, 15880, 18357, 20837, 23320, 25794, 28219, 30955, 31011, 28276, 25842, 23361, 20873, 18385, 15903, 13414, 10926, 8444, 5956, 3470, 1003, -1533, -3789, -4077, -4019, -4037, -4039, -4041, -4042, -4043, -4044, -4043, -4045, -4046, -4045, -4045, -4045, -4045, -4046, -4045, -4043, -4043, -4044, -4043, -4041, -4042, -4041, -4039, -4040, -4038, -4038, -4036, -4035, -4035, -4035, -4034, -4032, -4032, -4031, -4029, -4029, -4028, -4026, -4025, -4024, -4023, -4022, -4022, -4021, -4020, -4019, -4017, -4016, -4015, -4014, -4013, -4012, -4011, -4010, -4009, -4008, -4007, -4006, -4005, -4004, -4002, -4001, -4000, -3999, -3998, -3996, -3996, -3996, -3995, -3993, -3992, -3991, -3990, -3989, -3988, -3986, -3985, -3984, -3983, -3982, -3981, -3980, -3979, -3978, -3977, -3976, -3974, -3974, -3973, -3971, -3970, -3969, -3968, -3968, -3967, -3965, -3964, -3963, -3957, -3951, -3987, -2208, 454, 2964, 5509, 8045, 10585, 13127, 15657, 17955, 21918, 3232, -1682, 2382, 4521, 6956, 9391, 11819, 14256, 16689, 19117, 21552, 23984, 26384, 28914, 30897, 29020, 26463, 24057, 21619, 19175, 16738, 14300, 11858, 9421, 6983, 4542, 2107, -302, -2869, -4146, -4029, -4057, -4060, -4062, -4063, -4063, -4063, -4065, -4066, -4065, -4065, -4065, -4065, -4065, -4065, -4065, -4065, -4066, -4064, -4063, -4064, -4063, -4062, -4063, -4061, -4061, -4060, -4058, -4058, -4056, -4056, -4054, -4054, -4053, -4052, -4051, -4050, -4048, -4048, -4048, -4047, -4045, -4044, -4043, -4042, -4069, -3948, -4670, -7191, -9681, -12173, -14668, -17160, -19657, -22148, -24641, -26993, -30192, -29991, -5368, -3800, -4365, -4360, -4453, -4546, -4640, -4734, -4827, -4921, -5015, -5126, -5039, -5949, -7690, -4915, -5212, -5084, -4776, -2502, 146, 2711, 5102, 8729, 6399, -2307};