/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1605 256 samples */
 
const int16_t AKWF_1605_256_DATA [256] = 
{650, 1980, 3194, 4494, 5905, 7242, 8443, 9706, 11001, 12274, 13386, 14422, 15473, 16441, 17437, 18463, 19440, 20399, 21270, 22150, 23132, 24123, 25032, 25853, 26588, 27272, 27887, 28516, 29153, 29705, 30216, 30700, 31184, 31563, 31854, 32108, 32338, 32538, 32677, 32745, 32768, 32739, 32690, 32602, 32420, 32254, 32011, 31673, 31367, 31000, 30620, 30230, 29772, 29292, 28799, 28248, 27655, 27103, 26521, 25876, 25241, 24563, 23860, 23108, 22348, 21564, 20724, 19887, 19102, 18289, 17424, 16597, 15900, 15179, 14390, 13711, 13014, 12285, 11574, 10931, 10338, 9693, 9005, 8419, 7840, 7256, 6677, 6112, 5583, 5043, 4496, 4037, 3632, 3223, 2845, 2445, 2080, 1758, 1430, 1115, 847, 620, 355, 157, 10, -170, -330, -530, -708, -763, -810, -814, -777, -741, -780, -772, -697, -682, -657, -601, -540, -465, -406, -357, -262, -187, -88, -6, 5, 87, 186, 261, 356, 405, 464, 539, 600, 656, 681, 696, 771, 779, 740, 776, 813, 809, 762, 707, 529, 329, 169, -11, -158, -356, -621, -848, -1116, -1431, -1759, -2081, -2446, -2846, -3224, -3633, -4038, -4497, -5044, -5584, -6113, -6678, -7256, -7841, -8419, -9006, -9694, -10339, -10932, -11574, -12286, -13014, -13711, -14391, -15179, -15901, -16598, -17425, -18290, -19103, -19888, -20725, -21564, -22348, -23108, -23860, -24564, -25241, -25876, -26521, -27103, -27655, -28248, -28799, -29292, -29772, -30230, -30620, -31000, -31367, -31673, -32011, -32254, -32420, -32602, -32690, -32739, -32768, -32745, -32677, -32538, -32338, -32108, -31854, -31563, -31184, -30700, -30216, -29705, -29153, -28517, -27888, -27272, -26588, -25853, -25032, -24123, -23132, -22150, -21270, -20399, -19440, -18463, -17438, -16442, -15473, -14423, -13387, -12275, -11001, -9707, -8444, -7242, -5906, -4495, -3195, -1981, -651};