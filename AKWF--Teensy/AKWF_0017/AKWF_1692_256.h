/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1692 256 samples */
 
const int16_t AKWF_1692_256_DATA [256] = 
{1623, 6112, 10439, 14437, 17961, 21160, 24121, 26810, 29078, 30920, 32226, 32759, 32557, 31914, 31140, 30345, 29549, 29019, 28880, 29031, 29336, 29433, 29241, 28782, 27982, 27023, 25900, 24647, 23475, 22351, 21211, 20201, 19428, 18844, 18339, 17669, 16752, 15796, 15217, 15024, 14715, 14414, 14338, 14002, 13230, 11991, 10348, 8516, 6730, 5130, 3613, 2192, 1111, 283, -536, -1306, -1991, -2464, -2652, -2481, -1777, -541, 1105, 3126, 5494, 8026, 10463, 12629, 14386, 15800, 17019, 18071, 18757, 19086, 18978, 18255, 16917, 15193, 13434, 11721, 10028, 8644, 7789, 7379, 7250, 7053, 6664, 6072, 5201, 4182, 2994, 1643, 358, -884, -2192, -3398, -4430, -5269, -5943, -6644, -7354, -7914, -7949, -7537, -7254, -6978, -6504, -6245, -6331, -6775, -7479, -8263, -8942, -9388, -9683, -9788, -9462, -8805, -8063, -7224, -6285, -5167, -3817, -2235, -257, 2164, 4932, 8026, 11392, 14818, 18075, 20970, 23393, 25415, 27177, 28653, 29628, 30098, 29989, 29144, 27583, 25570, 23473, 21393, 19335, 17584, 16312, 15403, 14657, 13780, 12716, 11480, 10022, 8495, 6874, 5161, 3575, 2095, 602, -754, -1901, -2850, -3654, -4525, -5465, -6322, -6714, -6706, -6887, -7125, -7182, -7483, -8162, -9206, -10508, -11896, -13207, -14333, -15391, -16347, -16942, -17229, -17429, -17527, -17490, -17230, -16692, -15870, -14610, -12859, -10716, -8191, -5335, -2348, 500, 2989, 4981, 6572, 7919, 9029, 9719, 9988, 9766, 8870, 7273, 5179, 2931, 635, -1690, -3731, -5266, -6417, -7365, -8400, -9604, -10959, -12497, -14059, -15667, -17329, -18829, -20202, -21591, -22832, -23822, -24554, -25052, -25538, -26033, -26391, -26223, -25591, -25066, -24517, -23728, -23126, -22843, -22887, -23203, -23615, -24001, -24197, -24284, -24214, -23691, -22832, -21862, -20851, -19791, -18529, -17009, -15178, -12821, -9885, -6460, -2506};