/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1664 256 samples */
 
const int16_t AKWF_1664_256_DATA [256] = 
{1214, 3022, 4721, 6358, 7929, 9438, 10886, 12271, 13602, 14875, 16091, 17256, 18371, 19434, 20452, 21425, 22349, 23234, 24079, 24882, 25650, 26381, 27076, 27739, 28370, 28970, 29542, 30085, 30601, 31093, 31558, 32000, 32423, 32725, 32746, 32534, 32181, 31734, 31222, 30667, 30082, 29477, 28861, 28237, 27610, 26988, 26370, 25763, 25170, 24591, 24031, 23494, 22979, 22491, 22032, 21602, 21203, 20839, 20507, 20210, 19950, 19724, 19536, 19383, 19267, 19186, 19142, 19130, 19153, 19208, 19295, 19412, 19558, 19731, 19930, 20155, 20401, 20670, 20957, 21263, 21587, 21923, 22275, 22637, 23011, 23394, 23782, 24179, 24579, 24982, 25389, 25797, 26204, 26612, 27017, 27417, 27820, 28054, 27839, 27228, 26355, 25291, 24081, 22763, 21352, 19865, 18322, 16725, 15087, 13426, 11737, 10036, 8337, 6636, 4949, 3286, 1649, 50, -1445, -2792, -4001, -5080, -6050, -6914, -7680, -8360, -8959, -9481, -9933, -10321, -10645, -10912, -11122, -11280, -11388, -11445, -11456, -11421, -11341, -11218, -11049, -10841, -10587, -10291, -9952, -9570, -9143, -8672, -8156, -7593, -6985, -6326, -5618, -4859, -4045, -3177, -2252, -1265, -219, 864, 1971, 2563, 1746, -328, -3007, -5808, -8514, -11021, -13301, -15350, -17174, -18801, -20250, -21536, -22684, -23708, -24621, -25439, -26172, -26827, -27416, -27945, -28419, -28846, -29229, -29572, -29880, -30154, -30400, -30618, -30810, -30979, -31128, -31255, -31363, -31454, -31529, -31587, -31630, -31659, -31673, -31673, -31661, -31635, -31596, -31546, -31482, -31406, -31318, -31218, -31104, -30979, -30839, -30687, -30522, -30342, -30149, -29941, -29717, -29478, -29224, -28951, -28662, -28355, -28028, -27681, -27315, -26926, -26516, -26081, -25620, -25135, -24621, -24079, -23507, -22903, -22264, -21592, -20881, -20130, -19340, -18505, -17623, -16696, -15715, -14679, -13589, -12436, -11220, -9938, -8582, -7152, -5645, -4053, -2378, -568};