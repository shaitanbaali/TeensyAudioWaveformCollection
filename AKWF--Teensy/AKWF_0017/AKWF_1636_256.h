/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1636 256 samples */
 
const int16_t AKWF_1636_256_DATA [256] = 
{10956, 21921, 23020, 25357, 27029, 28375, 29456, 30312, 30989, 31517, 31922, 32227, 32449, 32602, 32702, 32754, 32769, 32753, 32712, 32651, 32572, 32479, 32372, 32257, 32137, 32007, 31873, 31735, 31593, 31448, 31300, 31151, 30999, 30847, 30693, 30539, 30385, 30227, 30071, 29915, 29759, 29600, 29444, 29285, 29126, 28968, 28811, 28653, 28493, 28336, 28177, 28018, 27860, 27692, 27537, 27378, 24944, 21326, 18482, 16094, 14107, 12444, 11054, 9885, 8897, 8060, 7347, 6733, 6204, 5741, 5335, 4977, 4654, 4364, 4100, 3855, 3629, 3417, 3216, 3022, 2840, 2666, 2504, 2282, 3480, 5734, 7458, 8922, 8675, 7166, 5998, 4955, 5332, 6714, 7740, 8566, 9189, 9644, 9992, 10253, 10388, 10428, 10446, 10554, 10515, 10355, 10235, 10139, 9713, 9101, 8620, 8220, 7858, 7513, 7290, 6846, 2557, -3161, -7609, -11314, -14354, -16837, -18890, -20563, -19624, -17299, -15553, -14090, -12885, -11899, -11088, -10419, -9872, -9422, -9052, -8750, -8502, -8298, -8130, -7993, -7879, -7787, -7711, -7650, -7598, -7557, -7522, -7496, -7472, -7452, -7437, -7426, -7416, -7407, -7401, -7395, -7390, -7388, -7385, -7383, -7380, -7379, -7378, -7378, -7376, -7377, -7377, -7376, -7376, -7371, -7365, -7397, -5564, -2400, 105, 2177, 3876, 5269, 6414, 7368, 6261, 3718, 1751, 116, -3505, -8062, -11661, -14623, -15366, -14618, -14093, -13649, -13279, -12976, -12724, -12516, -12392, -12321, -12260, -12208, -12163, -12127, -12096, -12070, -12115, -12202, -12268, -12321, -12364, -12394, -12409, -12491, -11362, -9279, -7652, -6245, -6511, -8009, -9137, -10141, -10184, -9419, -8844, -8364, -7998, -7728, -7502, -7319, -7267, -7294, -7310, -7321, -7482, -7742, -7931, -8150, -9689, -11786, -13421, -14778, -15925, -16896, -17690, -18334, -19588, -21139, -22359, -23372, -24202, -24854, -25458, -25634, -20203, -12620, -6755, -1812};