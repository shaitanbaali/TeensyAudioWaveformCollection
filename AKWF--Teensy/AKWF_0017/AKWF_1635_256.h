/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1635 256 samples */
 
const int16_t AKWF_1635_256_DATA [256] = 
{16006, 27120, 24984, 25311, 25251, 25190, 25129, 25065, 25001, 24938, 24873, 24808, 24741, 24675, 24610, 24543, 24475, 24406, 24340, 24270, 24201, 24132, 24063, 23993, 23923, 23855, 23783, 23713, 23643, 23571, 23502, 23430, 23359, 23290, 23218, 23145, 23077, 23004, 22930, 22859, 22788, 22717, 22643, 22570, 22500, 22428, 22357, 22273, 21998, 21666, 21346, 21024, 20702, 20380, 20058, 19735, 19410, 19090, 18767, 18445, 18120, 17799, 17476, 17153, 16832, 16508, 16185, 15863, 15543, 15222, 14898, 14577, 14255, 13931, 13609, 13288, 12967, 12645, 12323, 12001, 11681, 11358, 11038, 10717, 10394, 10072, 9752, 9432, 9113, 8489, 9946, -1111, 3795, 8620, 7388, 7472, 7406, 7341, 7272, 7204, 7136, 7068, 7006, 7097, 7228, 7348, 7472, 7594, 7716, 7840, 7964, 8085, 8206, 8327, 8451, 8573, 8695, 8816, 8938, 9059, 9181, 9301, 9421, 9543, 9665, 9786, 9906, 10026, 10146, 10268, 10389, 10509, 10628, 10748, 10869, 10987, 11109, 11229, 11350, 11463, 11386, 11246, 11117, 10988, 10858, 10727, 10598, 10468, 10337, 10207, 10076, 9947, 9815, 9686, 9555, 9425, 9294, 9164, 9034, 8905, 8774, 8644, 8516, 8386, 8257, 8125, 7997, 7868, 7739, 7609, 7480, 7351, 7220, 7091, 6964, 6835, 6704, 6577, 6448, 6320, 6190, 6062, 5934, 5805, 5675, 5548, 5420, 5280, 5019, 5788, -9262, -14851, -13709, -13923, -13927, -13927, -13930, -13933, -13932, -13933, -13934, -13934, -13933, -13933, -13932, -13931, -13930, -13927, -13924, -13922, -13920, -13918, -13914, -14163, -12820, -23192, -30985, -29647, -29999, -30074, -30154, -30232, -30308, -30388, -30464, -30540, -30618, -30693, -30768, -30844, -30919, -30992, -31068, -31142, -31216, -31290, -31365, -31437, -31512, -31585, -31658, -31732, -31804, -31878, -31950, -32024, -32097, -32169, -32242, -32314, -32386, -32460, -32530, -32585, -32750, -32229};