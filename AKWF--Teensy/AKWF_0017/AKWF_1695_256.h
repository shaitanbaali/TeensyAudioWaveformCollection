/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1695 256 samples */
 
const int16_t AKWF_1695_256_DATA [256] = 
{1149, 2988, 4711, 6340, 7852, 9237, 10487, 11594, 12557, 13380, 14062, 14615, 15044, 15358, 15569, 15688, 15728, 15700, 15615, 15485, 15319, 15125, 14910, 14680, 14441, 14194, 13940, 13682, 13419, 13152, 12881, 12607, 12330, 12053, 11779, 11507, 11248, 11004, 10779, 10582, 10418, 10292, 10210, 10178, 10198, 10274, 10409, 10601, 10851, 11158, 11519, 11931, 12393, 12901, 13453, 14048, 14682, 15356, 16072, 16824, 17613, 18439, 19292, 20165, 21046, 21907, 22717, 23436, 24005, 24355, 24408, 24059, 23269, 22226, 21001, 19561, 17920, 16125, 14220, 12272, 10338, 8461, 6692, 5068, 3608, 2340, 1279, 426, -208, -626, -831, -826, -618, -216, 370, 1128, 2041, 3088, 4247, 5492, 6784, 8088, 9355, 10519, 11508, 12228, 12550, 12327, 11670, 10821, 9765, 8498, 7066, 5522, 3939, 2385, 909, -437, -1620, -2621, -3424, -4024, -4430, -4640, -4669, -4527, -4227, -3780, -3195, -2485, -1659, -724, 305, 1420, 2604, 3832, 5085, 6327, 7522, 8630, 9606, 10403, 10980, 11296, 11311, 11004, 10441, 9680, 8707, 7536, 6195, 4709, 3121, 1466, -231, -1936, -3628, -5290, -6899, -8445, -9922, -11315, -12625, -13853, -14994, -16057, -17044, -17960, -18815, -19617, -20369, -21082, -21764, -22415, -23047, -23661, -24257, -24842, -25415, -25976, -26529, -27071, -27602, -28125, -28638, -29141, -29635, -30120, -30590, -31045, -31476, -31874, -32225, -32508, -32700, -32770, -32681, -32391, -31855, -31028, -29914, -28598, -27112, -25444, -23613, -21655, -19595, -17477, -15343, -13219, -11142, -9144, -7242, -5464, -3830, -2349, -1036, 102, 1063, 1845, 2450, 2885, 3152, 3262, 3223, 3046, 2742, 2318, 1787, 1158, 437, -366, -1246, -2200, -3215, -4291, -5414, -6571, -7751, -8925, -10057, -11114, -12042, -12778, -13262, -13418, -13163, -12524, -11675, -10618, -9329, -7836, -6178, -4402, -2561, -658};