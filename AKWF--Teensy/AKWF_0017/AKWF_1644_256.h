/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1644 256 samples */
 
const int16_t AKWF_1644_256_DATA [256] = 
{226, 1027, 1851, 2724, 3645, 4615, 5639, 6706, 7813, 8950, 10097, 11242, 12361, 13429, 14428, 15335, 16129, 16799, 17340, 17755, 18060, 18259, 18362, 18373, 18304, 18176, 18014, 17841, 17684, 17556, 17468, 17426, 17434, 17497, 17618, 17801, 18042, 18333, 18671, 19049, 19461, 19900, 20361, 20835, 21313, 21783, 22235, 22652, 23014, 23294, 23457, 23460, 23275, 22905, 22376, 21712, 20925, 20018, 18990, 17862, 16660, 15410, 14137, 12852, 11564, 10288, 9031, 7804, 6617, 5470, 4365, 3304, 2282, 1298, 354, -558, -1443, -2302, -3142, -3969, -4784, -5594, -6402, -7208, -8021, -8838, -9660, -10491, -11326, -12163, -13006, -13847, -14682, -15512, -16325, -17119, -17891, -18629, -19328, -19983, -20582, -21121, -21593, -21988, -22303, -22530, -22664, -22700, -22634, -22464, -22185, -21796, -21299, -20693, -19981, -19168, -18259, -17261, -16186, -15033, -13817, -12547, -11226, -9866, -8475, -7053, -5615, -4163, -2703, -1243, 210, 1655, 3078, 4479, 5853, 7189, 8490, 9749, 10961, 12129, 13249, 14318, 15343, 16323, 17257, 18156, 19019, 19850, 20658, 21447, 22219, 22984, 23742, 24493, 25241, 25976, 26688, 27366, 27980, 28500, 28884, 29078, 29049, 28812, 28403, 27853, 27171, 26346, 25367, 24247, 23021, 21711, 20336, 18911, 17431, 15904, 14346, 12760, 11155, 9541, 7910, 6269, 4625, 2973, 1326, -310, -1939, -3549, -5136, -6699, -8227, -9718, -11171, -12581, -13952, -15287, -16583, -17847, -19084, -20291, -21473, -22630, -23757, -24852, -25911, -26920, -27878, -28774, -29596, -30340, -30997, -31557, -32016, -32370, -32613, -32744, -32762, -32666, -32457, -32139, -31716, -31189, -30569, -29859, -29064, -28199, -27267, -26276, -25239, -24163, -23056, -21929, -20790, -19645, -18507, -17378, -16265, -15179, -14118, -13088, -12096, -11138, -10218, -9337, -8490, -7680, -6901, -6149, -5422, -4715, -4018, -3331, -2644, -1951, -1247, -506};