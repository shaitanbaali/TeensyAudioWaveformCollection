/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1634 256 samples */
 
const int16_t AKWF_1634_256_DATA [256] = 
{11307, 20934, 18862, 18957, 18696, 18413, 18106, 17811, 17526, 17251, 16986, 16727, 16475, 16231, 15996, 15766, 15544, 15328, 15115, 14910, 14708, 14509, 14315, 14124, 13937, 13752, 13568, 13387, 13208, 13032, 12856, 12683, 12509, 12337, 12167, 11996, 11827, 11659, 11489, 11320, 11152, 10988, 10803, 10914, 11232, 11518, 11809, 12100, 12390, 12678, 12966, 13254, 13540, 13824, 14108, 14389, 14669, 14948, 15225, 15501, 15774, 16045, 16314, 16580, 16847, 17107, 17369, 17627, 17880, 18135, 18385, 18633, 18878, 19120, 19359, 19594, 19826, 20056, 20283, 20508, 20728, 20944, 21157, 21367, 21573, 21777, 21974, 22171, 22363, 22551, 22736, 22915, 23091, 23263, 23433, 23596, 23756, 23910, 24062, 24211, 24353, 24490, 24626, 24756, 24880, 25001, 25119, 25230, 25338, 25440, 25537, 25631, 25720, 25803, 25883, 25955, 26026, 26091, 26151, 26206, 26255, 26299, 26341, 26376, 26407, 26431, 26451, 26467, 26477, 26481, 26482, 26426, 26521, 25634, 15390, 3131, -5139, -11360, -15755, -19552, -22795, -25487, -27616, -29233, -30413, -31257, -31842, -32235, -32493, -32649, -32733, -32766, -32763, -32729, -32668, -32585, -32482, -32356, -32209, -32043, -31852, -31641, -31409, -31153, -30877, -30583, -30268, -29937, -29590, -29229, -28855, -28470, -28076, -27676, -27270, -26859, -26447, -26033, -25618, -25207, -24795, -24387, -23982, -23580, -23183, -22790, -22403, -22021, -21643, -21269, -20901, -20537, -20176, -19821, -19471, -19122, -18778, -18437, -18097, -17760, -17425, -17093, -16762, -16432, -16103, -15775, -15448, -15120, -14796, -14468, -14142, -13816, -13490, -13162, -12834, -12506, -12179, -11851, -11521, -11194, -10864, -10533, -10203, -9873, -9544, -9213, -8884, -8554, -8225, -7895, -7568, -7241, -6913, -6588, -6265, -5942, -5621, -5301, -4982, -4666, -4354, -4042, -3732, -3427, -3126, -2825, -2529, -2238, -1948, -1665, -1386, -1111, -842, -580, -323, -74};