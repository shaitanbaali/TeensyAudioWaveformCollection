/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1697 256 samples */
 
const int16_t AKWF_1697_256_DATA [256] = 
{634, 2058, 3527, 5058, 6633, 8246, 9886, 11537, 13197, 14855, 16494, 18113, 19697, 21231, 22712, 24126, 25460, 26709, 27862, 28907, 29842, 30656, 31341, 31895, 32314, 32597, 32744, 32757, 32638, 32392, 32028, 31553, 30971, 30293, 29522, 28663, 27726, 26714, 25633, 24492, 23292, 22036, 20734, 19385, 17997, 16579, 15132, 13662, 12182, 10694, 9208, 7736, 6277, 4843, 3444, 2080, 758, -516, -1745, -2920, -4036, -5100, -6107, -7065, -7979, -8844, -9661, -10434, -11160, -11844, -12490, -13096, -13661, -14188, -14670, -15111, -15508, -15857, -16159, -16413, -16615, -16769, -16874, -16930, -16941, -16909, -16835, -16718, -16561, -16368, -16139, -15882, -15600, -15290, -14957, -14598, -14213, -13805, -13373, -12917, -12442, -11946, -11432, -10906, -10369, -9826, -9280, -8733, -8188, -7657, -7140, -6643, -6174, -5735, -5323, -4948, -4611, -4315, -4064, -3860, -3704, -3597, -3542, -3542, -3597, -3709, -3876, -4099, -4380, -4715, -5101, -5539, -6024, -6554, -7125, -7731, -8369, -9038, -9727, -10437, -11164, -11896, -12633, -13370, -14103, -14827, -15534, -16217, -16872, -17494, -18076, -18614, -19100, -19532, -19906, -20220, -20491, -20718, -20882, -20974, -21005, -20979, -20893, -20747, -20532, -20245, -19883, -19448, -18937, -18351, -17690, -16949, -16133, -15249, -14295, -13283, -12223, -11112, -9962, -8782, -7569, -6342, -5105, -3859, -2612, -1369, -121, 1123, 2363, 3599, 4823, 6030, 7222, 8388, 9528, 10636, 11698, 12710, 13664, 14546, 15355, 16085, 16726, 17278, 17735, 18092, 18356, 18523, 18599, 18583, 18478, 18284, 18003, 17638, 17195, 16672, 16073, 15395, 14637, 13806, 12905, 11936, 10908, 9825, 8693, 7526, 6330, 5114, 3895, 2678, 1476, 305, -827, -1912, -2935, -3893, -4775, -5568, -6273, -6895, -7401, -7791, -8070, -8238, -8291, -8219, -8018, -7684, -7220, -6630, -5916, -5084, -4138, -3084, -1932, -660};