/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1682 256 samples */
 
const int16_t AKWF_1682_256_DATA [256] = 
{1625, 6805, 11452, 15348, 17235, 18689, 20102, 20159, 19568, 19085, 18600, 18127, 17669, 17224, 16791, 16369, 15960, 15563, 15176, 14801, 14436, 14080, 13735, 13400, 13072, 12755, 12447, 12144, 11852, 11567, 11290, 11021, 10759, 10503, 10255, 10012, 9777, 9546, 9288, 9176, 8301, 1311, -1061, 9516, 8222, 8210, 8017, 7830, 7647, 7469, 7295, 7127, 6964, 6802, 6646, 6494, 6346, 6201, 6060, 5924, 5790, 5659, 5531, 5406, 5286, 5168, 5053, 4940, 4831, 4724, 4618, 4518, 4417, 4321, 4227, 4134, 4044, 3950, 3885, 3719, 2843, 1431, -600, -3296, -8733, 2233, 4221, 3634, 3606, 3531, 3457, 3385, 3314, 3244, 3177, 3111, 3047, 2983, 2922, 2862, 2802, 2745, 2688, 2633, 2340, 3605, -2887, -14478, -12536, -12271, -11768, -11285, -10821, -10375, -9946, -9536, -9141, -8761, -8397, -8047, -7711, -7387, -7077, -6778, -6454, -6361, -4447, -669, 2427, 5149, 7628, 9470, 9416, 9033, 8734, 8431, 8137, 7853, 7582, 7320, 7067, 6822, 6587, 6360, 6142, 5931, 5727, 5532, 5343, 5160, 4985, 4815, 4651, 4494, 4343, 4195, 4055, 3918, 3787, 3659, 3536, 3418, 3305, 3195, 3089, 2985, 2851, 2862, 2107, -4765, -7022, 3668, 2486, 2584, 2497, 2415, 2335, 2258, 2184, 2113, 2044, 1976, 1912, 1851, 1791, 1731, 1676, 1623, 1570, 1519, 1471, 1423, 1379, 1335, 1292, 1251, 1212, 1174, 1137, 1101, 1067, 1035, 1002, 970, 941, 912, 884, 857, 831, 806, 780, 366, 2492, -16378, -26144, -23595, -23529, -23089, -22656, -22232, -21815, -21406, -21005, -20612, -20225, -19845, -19474, -19107, -18749, -18396, -18051, -17713, -17618, -15975, -22095, -33321, -31020, -30404, -29555, -28734, -27939, -27167, -26419, -25696, -24993, -24312, -23653, -23011, -22391, -21787, -21181, -20715, -18392, -15078, -10348, -3806};