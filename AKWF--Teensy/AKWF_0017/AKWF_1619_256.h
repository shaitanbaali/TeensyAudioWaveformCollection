/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1619 256 samples */
 
const int16_t AKWF_1619_256_DATA [256] = 
{2490, 6720, 8977, 12134, 13994, 18959, 26204, 32877, 28371, 16354, 13810, 16950, 18274, 16477, 12610, 12266, 12028, 9555, 5961, 1634, 1047, 5120, 8900, 11728, 12348, 12252, 15701, 18180, 17469, 14305, 14896, 26036, 33110, 27841, 20253, 14590, 12600, 9540, 7199, 3394, -165, -3771, -11954, -15208, -10603, -2077, -476, -229, -951, -139, 2807, 4172, 4402, 4764, 3024, -5195, -12620, -15489, -14973, -14187, -14824, -17238, -17533, -14997, -12949, -9941, -3531, 1392, 1324, -1573, -4328, -5173, -3957, -4513, -7329, -9403, -11055, -13548, -14010, -10589, -5674, -1533, 207, 130, 1380, 4370, 5985, 5936, 5558, 3567, -606, -4788, -7592, -7661, -5689, -5105, -4762, -2023, 62, 930, 3673, 5551, 6285, 7279, 5754, 2632, 2392, 2798, 1279, 830, 1126, 471, 189, 479, 284, 1435, 3571, 3495, 2367, 1347, -59, -2264, -3528, -3722, -3300, -2837, -4791, -7738, -10043, -10644, -8884, -5865, -4370, -2684, -2028, -674, 1941, 2759, 2432, 1174, 537, 1108, 872, 230, -1348, -3863, -5533, -3523, -2953, -5420, -4419, -1811, 0, 747, 1159, 618, 916, 2210, 2777, 2263, -77, -1947, -2409, -4052, -5441, -8216, -10476, -10365, -8298, -5415, -3055, -3088, -3717, -3624, -2649, -509, 1121, 2147, 3253, 3782, 1920, 347, 458, 251, 333, 1050, 925, 1017, 2568, 2608, 2291, 5045, 7253, 6535, 5691, 4269, 1369, 195, -1364, -4373, -5152, -5379, -7300, -7884, -5524, -1574, 2818, 5333, 5892, 6045, 4912, 1956, 196, 241, -921, -4665, -9589, -13547, -13968, -11544, -9703, -7897, -5028, -3789, -5018, -4706, -2241, 811, 1801, -2155, -8802, -12533, -14485, -17101, -17614, -15294, -14114, -14772, -15565, -13587, -7119, 1688, 4892, 4328, 4370, 3188, 517, -1118, -199, -574, -1057, -8733, -14905, -13255, -5501, -246};