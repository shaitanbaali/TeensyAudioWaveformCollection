/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1651 256 samples */
 
const int16_t AKWF_1651_256_DATA [256] = 
{1860, 4342, 6268, 7724, 8943, 10150, 11504, 12994, 14580, 16218, 17854, 19367, 20766, 22241, 23941, 26037, 28614, 30981, 32072, 30938, 27125, 20994, 13279, 4835, -3561, -11881, -19867, -26530, -31123, -32881, -32222, -29764, -26579, -23769, -21560, -19654, -17716, -15338, -12336, -8976, -5175, -721, 4493, 10678, 17474, 23754, 28376, 30502, 29996, 27580, 24267, 21122, 18603, 16484, 14632, 12812, 10843, 8818, 6786, 4756, 2728, 694, -1331, -3350, -5384, -7408, -9415, -11419, -13421, -15483, -17569, -19567, -21549, -23619, -25803, -28342, -30988, -32654, -32631, -30222, -25064, -18262, -11193, -5263, -1126, 1539, 3189, 4466, 5903, 7448, 8998, 10549, 12072, 13562, 15040, 16558, 18175, 19891, 21621, 23315, 24967, 26555, 28154, 29840, 30840, 30121, 26838, 20536, 11824, 2031, -7421, -15370, -21876, -26947, -30357, -32088, -31919, -29874, -26737, -23427, -20736, -18911, -17496, -15759, -12940, -8635, -3156, 2966, 9067, 14600, 19480, 23660, 26737, 28462, 28586, 27061, 24389, 21269, 18392, 15972, 13907, 12057, 10212, 8246, 6225, 4189, 2150, 118, -1916, -3938, -5968, -7997, -10011, -11964, -13892, -15890, -18046, -20376, -22773, -25093, -27149, -28784, -30119, -30944, -30603, -28551, -24304, -17875, -10330, -3097, 2480, 5856, 7467, 8036, 8460, 9408, 10793, 12424, 14172, 15848, 17334, 18675, 20085, 21765, 23861, 26436, 29035, 30910, 31313, 29890, 26856, 22247, 16195, 8817, -30, -9774, -18967, -26225, -30563, -32004, -31248, -29285, -27114, -24967, -22609, -20186, -17731, -15362, -13388, -11360, -8487, -4127, 2221, 10149, 18187, 24905, 28944, 30060, 28937, 26533, 23927, 21654, 19548, 17529, 15515, 13437, 11345, 9312, 7320, 5323, 3298, 1284, -749, -2781, -4809, -6828, -8861, -10885, -12919, -14924, -16777, -18603, -20623, -22962, -25847, -29098, -31828, -32869, -32210, -29057, -24063, -18331, -12882, -8217, -4260, -870};