/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1650 256 samples */
 
const int16_t AKWF_1650_256_DATA [256] = 
{749, 2544, 4298, 6011, 7640, 9153, 10538, 11764, 12865, 13853, 14719, 15483, 16146, 16714, 17199, 17610, 17955, 18250, 18503, 18721, 18921, 19013, 19001, 18999, 18995, 18991, 18986, 18987, 18953, 18842, 18724, 18609, 18501, 18408, 18329, 18260, 18199, 18150, 18112, 18085, 18071, 18068, 18077, 18097, 18127, 18167, 18213, 18267, 18330, 18405, 18489, 18576, 18662, 18738, 18801, 18843, 18849, 18840, 18790, 18691, 18542, 18346, 18130, 17892, 17621, 17306, 16932, 16486, 15961, 15338, 14613, 13771, 12806, 11711, 10489, 9114, 7578, 5906, 4127, 2282, 417, -1458, -3284, -5021, -6641, -8095, -9364, -10424, -11253, -11860, -12262, -12468, -12500, -12378, -12124, -11765, -11329, -10839, -10317, -9789, -9273, -8788, -8333, -7891, -7457, -7020, -6569, -6090, -5566, -4983, -4324, -3577, -2733, -1782, -710, 477, 1770, 3154, 4606, 6115, 7666, 9229, 10787, 12316, 13782, 15184, 16484, 17695, 18649, 18782, 18754, 18759, 18756, 18752, 18750, 18746, 18742, 18738, 18734, 18727, 18717, 18741, 17510, 15266, 12790, 10021, 7001, 3812, 500, -2862, -6195, -9452, -12584, -15515, -18208, -20619, -22780, -24759, -26521, -28064, -29390, -30490, -31367, -32032, -32481, -32721, -32758, -32602, -32262, -31713, -30914, -29878, -28639, -27243, -25705, -24078, -22405, -20718, -19072, -17495, -16014, -14669, -13486, -12442, -11521, -10727, -10051, -9489, -9034, -8668, -8385, -8170, -8011, -7897, -7816, -7755, -7729, -7765, -7856, -7994, -8172, -8380, -8609, -8849, -9090, -9320, -9535, -9725, -9881, -10001, -10085, -10135, -10153, -10140, -10101, -10039, -9959, -9864, -9758, -9647, -9535, -9426, -9323, -9217, -9088, -8943, -8787, -8627, -8472, -8328, -8202, -8102, -8035, -8005, -8016, -8073, -8178, -8360, -8618, -8929, -9267, -9605, -9912, -10162, -10323, -10367, -10268, -9999, -9545, -8887, -8011, -6926, -5648, -4213, -2647, -938};