/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1677 256 samples */
 
const int16_t AKWF_1677_256_DATA [256] = 
{14143, 16421, 15917, 16021, 16032, 16031, 16077, 15920, 15017, 14891, 14930, 14927, 14936, 14936, 14963, 14904, 14017, 13782, 13838, 13833, 13843, 13839, 13885, 13707, 13294, 13296, 13308, 13311, 13321, 13314, 13370, 13141, 12255, 12186, 12210, 12212, 12217, 12219, 12240, 12187, 11739, 11655, 11682, 11680, 11688, 11688, 11705, 11684, 10810, 10516, 10582, 10573, 10580, 10581, 10616, 10465, 10038, 10025, 10037, 10038, 10042, 10037, 10086, 9905, 9011, 8897, 8926, 8923, 8931, 8930, 8943, 8910, 8468, 8352, 8382, 8381, 8384, 8373, 8448, 8073, 7242, 7245, 7256, 7255, 7257, 7247, 7306, 7063, 6178, 6111, 6130, 6130, 6135, 6130, 6150, 6088, 5634, 5558, 5579, 5576, 5577, 5574, 5590, 5556, 4679, 4398, 4452, 4442, 4445, 4440, 4473, 4315, 3887, 3878, 3883, 3883, 3882, 3874, 3921, 3725, 2827, 2719, 2746, 2740, 2739, 2734, 2760, 2671, 1775, 1559, 1603, 1593, 1593, 1592, 1599, 1597, 1169, 997, 1029, 1023, 1022, 1016, 1045, 916, 472, 442, 450, 447, 448, 432, 485, 267, -1090, -1325, -1275, -1288, -1287, -1293, -1282, -1327, -2214, -2486, -2437, -2448, -2447, -2465, -2403, -2736, -3591, -3610, -3607, -3616, -3616, -3624, -3605, -3706, -4160, -4213, -4201, -4209, -4214, -4221, -4197, -4300, -5202, -5409, -5370, -5386, -5387, -5397, -5365, -5569, -5980, -5982, -5984, -5988, -5995, -6017, -5934, -6348, -7673, -7758, -7737, -7752, -7756, -7780, -7696, -8089, -10353, -10727, -10652, -10678, -10683, -10701, -10677, -10774, -12111, -12505, -12436, -12461, -12468, -12550, -12207, -13984, -18219, -18277, -18254, -18280, -18289, -18340, -18155, -19032, -22636, -23000, -22922, -22955, -22964, -23001, -22896, -23335, -26946, -27736, -27583, -27624, -27631, -27652, -27626, -27699, -30293, -31242, -31071, -31108, -31115, -30672, -32941, -21763};