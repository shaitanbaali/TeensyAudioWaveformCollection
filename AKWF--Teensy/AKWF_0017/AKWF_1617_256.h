/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1617 256 samples */
 
const int16_t AKWF_1617_256_DATA [256] = 
{2424, 5804, 8047, 10419, 11642, 11579, 12451, 15130, 17884, 20543, 24356, 26938, 27138, 27322, 26842, 24893, 24042, 25239, 26531, 27551, 29641, 30422, 27721, 24764, 22282, 18452, 15976, 16824, 18029, 17507, 16723, 15548, 11786, 7542, 5620, 4401, 3244, 3109, 3156, 2434, 1093, 209, 276, 432, 303, 69, -794, -816, 705, 1720, 1853, 2003, 1819, 868, 263, 748, 1321, 2276, 4457, 6132, 6369, 6425, 6563, 6426, 6412, 6991, 7735, 8282, 9104, 9734, 9565, 9251, 9057, 8941, 8750, 8123, 7405, 6697, 5758, 4894, 4612, 4704, 3700, 1197, 1134, 3642, 4699, 4614, 4876, 5727, 6672, 7385, 8100, 8738, 8939, 9052, 9243, 9555, 9739, 9130, 8300, 7752, 7015, 6420, 6420, 6563, 6430, 6369, 6154, 4527, 2326, 1336, 769, 264, 836, 1800, 2006, 1854, 1732, 751, -787, -820, 54, 298, 431, 285, 199, 1052, 2400, 3146, 3113, 3225, 4359, 5584, 7451, 11645, 15474, 16706, 17476, 18037, 16876, 15959, 18337, 22190, 24695, 27615, 30388, 29706, 27597, 26556, 25286, 24054, 24839, 26798, 27329, 27134, 26972, 24468, 20640, 17959, 15220, 12506, 11581, 11650, 10479, 8112, 5862, 2595, -1705, -4825, -7312, -9845, -11515, -12774, -14396, -16317, -18182, -20537, -23474, -25621, -27381, -29150, -29653, -29528, -29845, -30316, -30749, -31394, -32379, -32769, -32642, -32557, -31166, -28864, -27396, -26424, -25401, -24445, -23659, -22470, -20457, -18504, -16490, -14115, -12105, -10035, -7955, -6860, -6342, -5185, -3136, -964, -892, -3029, -5103, -6310, -6834, -7876, -9930, -12021, -14009, -16384, -18421, -20356, -22391, -23622, -24404, -25354, -26378, -27347, -28773, -31064, -32531, -32643, -32765, -32419, -31436, -30773, -30338, -29868, -29533, -29648, -29207, -27473, -25700, -23597, -20671, -18276, -16402, -14484, -12839, -11571, -9946, -7442, -4954, -1824};