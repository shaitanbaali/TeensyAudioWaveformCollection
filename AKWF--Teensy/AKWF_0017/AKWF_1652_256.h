/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1652 256 samples */
 
const int16_t AKWF_1652_256_DATA [256] = 
{1024, 2631, 4193, 5713, 7154, 8484, 9692, 10752, 11697, 12532, 13255, 13877, 14412, 14857, 15229, 15536, 15789, 15999, 16177, 16332, 16471, 16585, 16655, 16688, 16686, 16656, 16602, 16530, 16445, 16352, 16258, 16164, 16078, 16002, 15939, 15885, 15843, 15812, 15790, 15778, 15775, 15781, 15791, 15808, 15829, 15853, 15876, 15899, 15919, 15935, 15947, 15954, 15959, 15960, 15956, 15951, 15944, 15931, 15915, 15893, 15863, 15832, 15830, 15850, 15876, 15885, 15860, 15775, 15610, 15343, 14955, 14426, 13738, 12880, 11847, 10609, 9171, 7554, 5793, 3932, 2017, 94, -1793, -3603, -5291, -6811, -8121, -9210, -10045, -10636, -11001, -11159, -11135, -10958, -10659, -10271, -9829, -9369, -8917, -8503, -8154, -7890, -7712, -7605, -7554, -7540, -7539, -7526, -7475, -7359, -7150, -6823, -6358, -5735, -4938, -3960, -2810, -1512, -88, 1434, 3040, 4688, 6353, 7998, 9588, 11101, 12511, 13785, 14909, 15896, 16809, 17359, 17348, 17347, 17347, 17344, 17341, 17338, 17335, 17329, 17323, 17332, 16763, 15761, 14663, 13421, 12047, 10542, 8909, 7162, 5310, 3363, 1315, -809, -3007, -5268, -7633, -10126, -12707, -15322, -17932, -20477, -22892, -25160, -27206, -28990, -30470, -31602, -32363, -32734, -32711, -32320, -31594, -30591, -29340, -27900, -26332, -24682, -23012, -21382, -19817, -18377, -17090, -15906, -14812, -13806, -12881, -12043, -11290, -10615, -10007, -9465, -8979, -8543, -8155, -7801, -7495, -7259, -7093, -6989, -6943, -6947, -6996, -7084, -7202, -7340, -7496, -7661, -7829, -7996, -8174, -8363, -8561, -8760, -8955, -9144, -9318, -9473, -9606, -9711, -9783, -9822, -9823, -9778, -9670, -9510, -9306, -9070, -8812, -8547, -8287, -8045, -7832, -7661, -7539, -7473, -7473, -7556, -7717, -7937, -8191, -8455, -8700, -8898, -9023, -9047, -8944, -8689, -8270, -7667, -6867, -5880, -4725, -3425, -2019, -487};