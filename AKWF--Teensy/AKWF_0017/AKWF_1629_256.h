/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1629 256 samples */
 
const int16_t AKWF_1629_256_DATA [256] = 
{4724, 6180, 6074, 6251, 6383, 6514, 6645, 6775, 6903, 7033, 7159, 7286, 7412, 7538, 7664, 7790, 7914, 8039, 8164, 8287, 8410, 8534, 8656, 8780, 8902, 9025, 9146, 9268, 9390, 9512, 9635, 9754, 9877, 9999, 10119, 10239, 10362, 10482, 10602, 10722, 10843, 10964, 11083, 11202, 11324, 11444, 11566, 11675, 11591, 11452, 11325, 11194, 11065, 10934, 10805, 10674, 10543, 10414, 10284, 10154, 10021, 9892, 9762, 9631, 9502, 9372, 9241, 9111, 8982, 8854, 8722, 8593, 8463, 8332, 8203, 8074, 7946, 7816, 7686, 7557, 7428, 7297, 7170, 7042, 6911, 6782, 6654, 6526, 6401, 5968, 7617, -3248, 1851, 6867, 5829, 6105, 6232, 6358, 6481, 6606, 6730, 6856, 6977, 7102, 7226, 7349, 7472, 7595, 7717, 7840, 7963, 8086, 8206, 8328, 8451, 8573, 8695, 8816, 8937, 9059, 9181, 9301, 9422, 9543, 9664, 9786, 9907, 10026, 10147, 10268, 10388, 10509, 10628, 10748, 10870, 10988, 11109, 11229, 11350, 11463, 11386, 11245, 11117, 10987, 10858, 10727, 10598, 10468, 10337, 10206, 10077, 9947, 9815, 9685, 9554, 9425, 9295, 9164, 9035, 8906, 8775, 8644, 8516, 8387, 8256, 8125, 7998, 7868, 7739, 7610, 7480, 7351, 7221, 7092, 6964, 6835, 6705, 6577, 6448, 6320, 6190, 6061, 5934, 5805, 5675, 5548, 5419, 5281, 5019, 5788, -9262, -14851, -13709, -13923, -13926, -13926, -13929, -13932, -13932, -13933, -13933, -13933, -13932, -13932, -13931, -13930, -13928, -13926, -13924, -13922, -13920, -13917, -13914, -14162, -12819, -23190, -30983, -29645, -29998, -30073, -30153, -30230, -30307, -30386, -30463, -30539, -30615, -30692, -30767, -30842, -30917, -30991, -31066, -31141, -31214, -31289, -31364, -31436, -31510, -31584, -31657, -31730, -31803, -31877, -31949, -32022, -32095, -32167, -32240, -32312, -32385, -32458, -32529, -32583, -32749, -32228};