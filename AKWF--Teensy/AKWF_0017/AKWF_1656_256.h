/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1656 256 samples */
 
const int16_t AKWF_1656_256_DATA [256] = 
{6250, 17474, 25709, 30301, 31742, 30802, 27663, 23464, 19809, 17204, 15072, 12734, 10158, 7531, 4934, 2364, -204, -2788, -5389, -7969, -10415, -12665, -15183, -18530, -22447, -25478, -26365, -25028, -20547, -11767, 485, 11532, 16647, 15597, 10176, 1822, -8697, -17449, -20528, -17889, -12579, -7311, -2325, 2086, 5541, 7690, 8152, 6683, 3584, -151, -3734, -6741, -7977, -6554, -2764, 2205, 7524, 12598, 15645, 15174, 11603, 7250, 4076, 1557, -2725, -10453, -19912, -26528, -27289, -23038, -16072, -8128, 515, 9490, 18676, 26307, 27734, 20243, 6434, -7539, -18182, -25009, -26155, -20511, -9684, 2542, 13917, 23693, 30143, 32177, 30623, 27755, 24719, 21535, 18451, 15742, 13355, 10960, 8418, 5812, 3219, 649, -1934, -4494, -7034, -9589, -12170, -14646, -17193, -20318, -24244, -27247, -26631, -21729, -13746, -4184, 6497, 15380, 18065, 13197, 3859, -5614, -13903, -19636, -20630, -16036, -8603, -2275, 1744, 4246, 6125, 7447, 7466, 5458, 1521, -2922, -6165, -7791, -7446, -4575, 756, 6748, 11298, 13849, 14516, 13376, 10397, 6144, 1434, -3284, -8535, -15022, -22264, -27171, -26667, -20793, -11709, -1610, 8637, 17398, 23240, 25690, 23016, 13416, -1935, -16592, -24644, -25765, -21584, -13440, -1987, 10039, 20161, 27769, 32113, 32563, 29513, 25224, 21768, 19222, 16889, 14349, 11783, 9225, 6650, 4078, 1495, -1080, -3673, -6237, -8681, -11064, -13716, -16737, -19865, -22751, -25432, -27070, -24974, -17450, -6207, 4460, 12134, 16330, 15482, 8480, -2647, -12489, -17904, -19284, -17427, -12596, -5714, 541, 4583, 6622, 7326, 7040, 5616, 2940, -938, -5070, -7595, -7744, -5703, -1733, 4119, 10479, 14541, 14924, 12718, 10002, 7729, 4909, 17, -7355, -15398, -21499, -24762, -24969, -21850, -15609, -6866, 3352, 14562, 23912, 27359, 23805, 15043, 3394, -10268, -22338, -27613, -24606, -15958, -4996};