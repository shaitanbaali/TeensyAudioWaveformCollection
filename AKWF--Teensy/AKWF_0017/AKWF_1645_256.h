/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1645 256 samples */
 
const int16_t AKWF_1645_256_DATA [256] = 
{792, 2647, 4465, 6280, 8078, 9858, 11612, 13328, 15010, 16647, 18230, 19760, 21226, 22622, 23949, 25196, 26359, 27437, 28421, 29312, 30108, 30804, 31396, 31882, 32263, 32537, 32708, 32768, 32717, 32558, 32291, 31919, 31443, 30866, 30186, 29405, 28532, 27568, 26517, 25388, 24179, 22895, 21545, 20130, 18655, 17136, 15569, 13961, 12323, 10654, 8964, 7263, 5548, 3833, 2124, 423, -1263, -2926, -4569, -6177, -7746, -9280, -10762, -12196, -13584, -14909, -16170, -17373, -18504, -19567, -20563, -21487, -22334, -23108, -23800, -24416, -24957, -25422, -25809, -26118, -26350, -26506, -26590, -26601, -26544, -26419, -26229, -25977, -25663, -25292, -24869, -24396, -23876, -23310, -22702, -22054, -21369, -20657, -19920, -19153, -18365, -17556, -16728, -15888, -15034, -14171, -13307, -12437, -11569, -10704, -9836, -8975, -8121, -7275, -6439, -5614, -4800, -3998, -3209, -2431, -1666, -919, -185, 535, 1240, 1935, 2619, 3288, 3947, 4596, 5233, 5862, 6480, 7087, 7688, 8282, 8870, 9453, 10029, 10601, 11166, 11728, 12287, 12841, 13384, 13923, 14455, 14983, 15505, 16019, 16526, 17023, 17507, 17979, 18437, 18883, 19314, 19725, 20115, 20483, 20827, 21141, 21431, 21687, 21914, 22103, 22252, 22360, 22425, 22446, 22421, 22347, 22222, 22043, 21807, 21515, 21168, 20763, 20298, 19777, 19193, 18548, 17844, 17078, 16256, 15379, 14444, 13454, 12412, 11315, 10172, 8986, 7754, 6482, 5171, 3827, 2457, 1060, -362, -1795, -3247, -4708, -6168, -7630, -9088, -10533, -11964, -13377, -14759, -16116, -17437, -18716, -19957, -21148, -22286, -23371, -24394, -25348, -26237, -27052, -27789, -28452, -29031, -29527, -29938, -30260, -30490, -30630, -30679, -30634, -30495, -30262, -29932, -29509, -28996, -28388, -27690, -26904, -26029, -25068, -24027, -22905, -21708, -20441, -19100, -17692, -16228, -14700, -13123, -11499, -9827, -8116, -6373, -4603, -2817, -979};