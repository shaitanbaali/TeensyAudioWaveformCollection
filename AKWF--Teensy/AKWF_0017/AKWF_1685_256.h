/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1685 256 samples */
 
const int16_t AKWF_1685_256_DATA [256] = 
{1425, 3098, 4547, 6270, 7984, 9669, 11305, 12874, 14376, 15805, 17155, 18431, 19632, 20754, 21804, 22784, 23691, 24533, 25309, 26021, 26674, 27268, 27806, 28291, 28725, 29109, 29445, 29736, 29984, 30191, 30359, 30487, 30578, 30635, 30657, 30648, 30608, 30538, 30439, 30313, 30161, 29985, 29783, 29559, 29311, 29045, 28757, 28449, 28124, 27782, 27421, 27046, 26656, 26250, 25832, 25399, 24955, 24501, 24035, 23557, 23073, 22578, 22075, 21564, 21047, 20522, 19992, 19457, 18917, 18371, 17823, 17272, 16716, 16157, 15599, 15038, 14475, 13914, 13350, 12788, 12228, 11666, 11105, 10549, 9992, 9439, 8889, 8341, 7799, 7260, 6725, 6194, 5668, 5148, 4633, 4124, 3620, 3125, 2635, 2151, 1676, 1208, 748, 295, -148, -586, -1012, -1431, -1845, -2250, -2651, -3051, -3447, -3841, -4236, -4625, -5014, -5397, -5777, -6154, -6527, -6895, -7259, -7619, -7976, -8332, -8683, -9031, -9380, -9723, -10067, -10412, -10754, -11098, -11442, -11786, -12132, -12482, -12833, -13190, -13551, -13919, -14296, -14683, -15081, -15498, -15938, -16408, -16927, -17551, -18125, -20414, -22708, -23338, -23990, -24537, -25030, -25485, -25912, -26317, -26704, -27072, -27426, -27769, -28098, -28418, -28728, -29027, -29315, -29591, -29853, -30102, -30338, -30561, -30771, -30970, -31157, -31333, -31500, -31657, -31805, -31942, -32070, -32188, -32295, -32393, -32479, -32555, -32620, -32673, -32716, -32745, -32763, -32768, -32760, -32738, -32702, -32652, -32585, -32505, -32407, -32295, -32163, -32015, -31850, -31665, -31461, -31238, -30999, -30740, -30464, -30170, -29860, -29533, -29193, -28836, -28466, -28082, -27685, -27276, -26856, -26424, -25980, -25526, -25061, -24588, -24104, -23610, -23109, -22599, -22078, -21551, -21016, -20471, -19919, -19358, -18789, -18214, -17628, -17034, -16432, -15821, -15198, -14568, -13926, -13271, -12604, -11920, -11220, -10501, -9753, -8973, -8151, -7261, -6282, -4939};