/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1642 256 samples */
 
const int16_t AKWF_1642_256_DATA [256] = 
{65, 223, 361, 558, 829, 1076, 1299, 1502, 1688, 1855, 2005, 2170, 2370, 2554, 2722, 2875, 3012, 3142, 3240, 3508, 4204, 4916, 5545, 6122, 6646, 7118, 7547, 8092, 8755, 9357, 9899, 10392, 10842, 11248, 11611, 12039, 12569, 13054, 13495, 13893, 14254, 14585, 14869, 15277, 15958, 16613, 17200, 17735, 18218, 18655, 19055, 19586, 20222, 20792, 21307, 21776, 22199, 22582, 22924, 23379, 23968, 24506, 24990, 25429, 25826, 26186, 26502, 26906, 27469, 27994, 28465, 28891, 29276, 29627, 29935, 30278, 30747, 31197, 31600, 31964, 32283, 32574, 32816, 30657, 26225, 22236, 18623, 15322, 12327, 9612, 7137, 4908, 2910, 1090, -558, -2054, -3417, -4650, -5776, -6735, -7475, -8131, -8730, -9274, -9766, -10213, -10617, -10963, -11256, -11522, -11764, -11983, -12180, -12359, -12520, -12648, -12740, -12823, -12899, -12967, -13027, -13080, -13129, -13156, -13156, -13154, -13150, -13148, -13143, -13138, -13133, -13117, -13076, -13032, -12992, -12957, -12922, -12889, -12859, -12792, -12688, -12593, -12506, -12425, -12353, -12286, -12225, -12135, -12006, -11886, -11777, -11676, -11585, -11501, -11424, -11341, -11239, -11142, -11055, -10974, -10900, -10832, -10771, -10704, -10616, -10530, -10453, -10382, -10315, -10255, -10199, -10128, -10043, -9965, -9892, -9826, -9764, -9708, -9658, -9581, -9462, -9349, -9247, -9154, -9070, -8991, -8917, -8885, -8932, -8989, -9035, -9077, -9115, -9148, -9178, -9163, -9108, -9059, -9013, -8972, -8932, -8896, -8868, -8719, -8422, -8149, -7902, -7675, -7469, -7281, -7108, -6979, -6909, -6852, -6798, -6749, -6705, -6662, -6627, -6574, -6470, -6368, -6275, -6190, -6111, -6040, -5976, -5878, -5747, -5626, -5517, -5418, -5326, -5242, -5176, -4954, -4510, -4098, -3723, -3383, -3074, -2791, -2536, -2304, -2093, -1901, -1725, -1566, -1422, -1291, -1171, -978, -725, -498, -292, -99};