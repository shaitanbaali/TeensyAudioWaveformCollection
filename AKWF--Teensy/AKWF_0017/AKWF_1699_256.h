/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1699 256 samples */
 
const int16_t AKWF_1699_256_DATA [256] = 
{11870, 23632, 28551, 29323, 27553, 24381, 20374, 16128, 12152, 8894, 6416, 4438, 2914, 1852, 1121, 655, 371, 206, 124, 118, 183, 374, 649, 1011, 1532, 2106, 2519, 2813, 3048, 3069, 2924, 2783, 2798, 2740, 2560, 2336, 2172, 2046, 1879, 1681, 1490, 1321, 1173, 1038, 912, 801, 705, 622, 554, 498, 452, 414, 385, 360, 341, 325, 313, 303, 297, 305, 329, 352, 359, 357, 349, 339, 327, 316, 307, 298, 290, 283, 278, 272, 269, 260, 245, 231, 214, 198, 184, 172, 162, 154, 147, 141, 136, 133, 131, 130, 129, 130, 130, 130, 136, 147, 159, 171, 183, 193, 201, 209, 214, 219, 224, 226, 228, 230, 235, 249, 267, 288, 305, 285, 375, 306, 353, 831, 1428, 1917, 2294, 2713, 3442, 4050, 6030, 9956, 12626, 14213, 14630, 14058, 13170, 12376, 11375, 10272, 9200, 8202, 7434, 7142, 6924, 6512, 6022, 5526, 5043, 4759, 4683, 4542, 4362, 4118, 3832, 3563, 3338, 3187, 3286, 3321, 3185, 2983, 2755, 2528, 2317, 2128, 1964, 1826, 1709, 1612, 1534, 1452, 1318, 1154, 981, 810, 652, 509, 377, 258, 156, 69, -3, -61, -109, -148, -180, -204, -222, -238, -249, -258, -266, -286, -318, -353, -388, -421, -449, -473, -494, -510, -523, -534, -541, -553, -594, -656, -707, -736, -759, -786, -830, -859, -874, -903, -941, -975, -1005, -1029, -1050, -1115, -1233, -1372, -1511, -1657, -1820, -1981, -2103, -2165, -2409, -2756, -2926, -3156, -3633, -4180, -4869, -4963, -10020, -19163, -23285, -24547, -24481, -23492, -21653, -19541, -17824, -16382, -20528, -27334, -30978, -32595, -32487, -30456, -27178, -23474, -19768, -16329, -13211, -10292, -7975, -3489};