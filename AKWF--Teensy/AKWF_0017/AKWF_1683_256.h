/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1683 256 samples */
 
const int16_t AKWF_1683_256_DATA [256] = 
{18069, 32926, 32219, 31771, 31338, 30848, 30367, 29880, 29399, 28920, 28441, 27966, 27489, 27018, 26549, 26079, 25617, 25153, 24688, 24232, 23775, 23320, 22868, 22417, 21970, 21527, 21082, 20641, 20201, 19765, 19331, 18896, 18468, 18041, 17612, 17188, 16768, 16346, 15929, 15512, 15098, 14690, 14280, 13873, 13466, 13063, 12665, 12263, 11870, 11471, 10906, 11434, 2899, -13734, -14908, -14638, -14840, -15127, 1451, 13579, 11936, 11781, 11003, 10917, 27486, 30373, 29420, 29056, 28584, 28092, 27358, 28309, 21260, 4095, 4931, 4233, 3759, 3291, 2840, 2377, 1924, 1470, 1027, 580, 135, -306, -743, -1179, -1615, -2046, -2477, -2902, -3327, -3751, -4171, -4587, -5003, -5417, -5829, -6238, -6645, -7050, -7453, -7852, -8251, -8648, -9044, -9436, -9825, -10213, -10599, -10984, -11366, -11746, -12124, -12499, -12873, -13248, -13616, -13988, -14358, -14722, -15092, -15461, -15823, -16126, -16972, -16484, 369, 2596, 1838, 1552, 1146, 729, 315, -97, -510, -919, -1328, -1735, -2141, -2543, -2945, -3347, -3740, -4138, -4532, -4924, -5312, -5701, -6087, -6471, -6853, -7234, -7612, -7988, -8365, -8737, -9107, -9478, -9845, -10212, -10575, -10938, -11299, -11658, -12016, -12372, -12726, -13084, -13046, -15455, -3013, 8174, 5846, 5877, 5532, 5158, 4725, 5096, -9126, -24528, -23869, -23917, -23972, -23981, -23988, -24006, -24012, -23945, -24336, -24018, -7050, -3772, -4331, -4303, -4393, -4494, -4598, -4697, -4802, -4908, -5012, -5120, -5224, -5331, -5441, -5546, -5658, -5767, -5876, -5988, -6098, -6212, -6324, -6437, -6552, -6666, -6781, -6897, -7012, -7131, -7247, -7364, -7483, -7601, -7721, -7844, -7964, -8085, -8206, -8328, -8452, -8575, -8699, -8824, -8948, -9073, -9201, -9326, -9451, -9578, -9706, -9835, -9961, -10092, -10219, -10348, -10483, -10615, -10747, -10887, -11017, -11162, -11445, -11694};