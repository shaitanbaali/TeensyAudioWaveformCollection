/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1662 256 samples */
 
const int16_t AKWF_1662_256_DATA [256] = 
{2079, 2614, 2493, 2532, 2530, 2549, 2470, 2831, 5173, 5576, 5472, 5494, 5496, 5525, 5358, 6435, 8259, 8157, 8157, 8159, 8159, 8206, 7967, 9285, 12699, 12766, 12725, 12736, 12737, 12767, 12623, 13291, 16210, 16533, 16441, 16458, 16459, 16463, 16429, 16549, 17799, 18091, 18018, 18028, 18023, 18053, 17890, 18856, 20810, 20753, 20747, 20749, 20746, 20755, 20694, 20956, 21872, 21917, 21897, 21901, 21890, 21894, 21832, 22105, 23707, 23952, 23882, 23895, 23892, 23895, 23858, 23946, 25235, 25604, 25519, 25531, 25530, 25530, 25484, 25696, 26222, 26223, 26216, 26214, 26204, 26210, 26161, 26390, 27349, 27443, 27412, 27412, 27409, 27409, 27391, 27436, 27850, 27940, 27916, 27913, 27906, 27914, 27852, 28186, 28834, 28807, 28805, 28803, 28797, 28800, 28775, 28868, 29171, 29181, 29172, 29169, 29166, 29166, 29142, 29236, 29775, 29851, 29829, 29831, 29826, 29825, 29815, 29830, 30057, 30120, 30100, 30101, 30096, 30100, 30068, 30226, 30600, 30597, 30593, 30591, 30589, 30590, 30569, 30653, 30983, 31007, 30996, 30996, 30992, 30532, 32934, 22678, -31116, -33160, -32560, -32736, -32736, -32734, -32740, -32706, -32626, -32628, -32628, -32628, -32627, -32623, -32635, -32576, -32337, -32319, -32323, -32321, -32321, -32316, -32330, -32260, -31705, -31599, -31623, -31616, -31614, -31605, -31617, -31578, -29863, -29232, -29367, -29331, -29326, -29308, -29369, -28992, -28028, -28012, -28017, -28003, -27999, -27968, -28075, -27506, -24908, -24617, -24683, -24660, -24654, -24625, -24686, -24405, -22059, -21542, -21655, -21621, -21606, -21596, -21602, -21551, -20620, -20291, -20348, -20328, -20326, -20285, -20409, -19691, -17494, -17388, -17415, -17405, -17388, -17365, -17417, -17152, -15821, -15642, -15673, -15658, -15657, -15620, -15669, -15428, -12376, -11538, -11708, -11654, -11654, -11601, -11857, -10337, -6755, -6784, -6777, -6765, -6766, -6704, -6992, -5354};