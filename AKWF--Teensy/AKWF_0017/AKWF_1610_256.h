/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1610 256 samples */
 
const int16_t AKWF_1610_256_DATA [256] = 
{1523, 4238, 6862, 9442, 11957, 14396, 16746, 18981, 21072, 22947, 24609, 26087, 27387, 28522, 29509, 30357, 31077, 31683, 32135, 32644, 32210, 26458, 20744, 17026, 14098, 11683, 9940, 5358, -2920, -8870, -13349, -16972, -19940, -22337, -24228, -25660, -26673, -27318, -27637, -27670, -27423, -26864, -26030, -24957, -23673, -22211, -20582, -18802, -16883, -14814, -12598, -10246, -7749, -5145, -2481, 199, 2821, 5326, 7677, 9826, 11749, 13442, 14894, 16115, 17124, 17926, 18554, 19098, 19570, 19965, 20289, 20547, 20746, 20891, 20924, 21180, 19722, 11444, 3862, -1348, -5622, -9239, -12309, -14874, -16973, -18635, -19903, -20834, -21471, -21862, -22045, -22045, -21883, -21564, -21089, -20449, -19623, -18593, -17333, -15822, -14051, -12014, -9729, -7250, -4626, -1933, 750, 3369, 5865, 8187, 10319, 12240, 13939, 15429, 16711, 17797, 18708, 19456, 19999, 20341, 20525, 20581, 20533, 20389, 20165, 20140, 14730, 6863, 1852, -2120, -5448, -8282, -10661, -12623, -14195, -15407, -16308, -16940, -17345, -17561, -17616, -17530, -17318, -16980, -16515, -15911, -15153, -14223, -13101, -11774, -10235, -8488, -6563, -4504, -2350, -173, 1972, 4045, 5996, 7800, 9443, 10909, 12200, 13322, 14280, 15089, 15762, 16312, 16755, 17106, 17375, 17578, 17725, 17824, 17887, 17899, 17932, 18115, 12688, 5043, 100, -3947, -7395, -10403, -13005, -15221, -17073, -18528, -19586, -20311, -20742, -20912, -20842, -20547, -20030, -19287, -18306, -17071, -15566, -13791, -11743, -9443, -6944, -4293, -1568, 1144, 3794, 6319, 8670, 10830, 12773, 14490, 15994, 17286, 18378, 19291, 20043, 20651, 21138, 21519, 21813, 22035, 22193, 22296, 22346, 22276, 22552, 19270, 10200, 3450, -1527, -5648, -9146, -12108, -14555, -16526, -18052, -19163, -19957, -20529, -20890, -21059, -21046, -20857, -20485, -19914, -19125, -18087, -16786, -15207, -13345, -11228, -8896, -6398, -3800, -1088};