/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1630 256 samples */
 
const int16_t AKWF_1630_256_DATA [256] = 
{1080, 3362, 5604, 7853, 10074, 12320, 14568, 16798, 19048, 21286, 23522, 24904, 31714, -772, -35879, -29420, -27971, -25791, -23600, -21406, -19210, -17011, -14824, -12619, -10416, -8203, -6125, -3390, -1798, -1970, -1932, -1928, -1926, -1924, -1920, -1919, -1918, -1916, -1913, -1911, -1910, -1908, -1907, -1906, -1905, -1904, -1903, -1903, -1902, -1901, -1901, -1900, -1899, -1763, -2419, -115, 26758, 27813, 25060, 23150, 21104, 19038, 16974, 14923, 12873, 10810, 8746, 6687, 4621, 2631, 303, -1926, -1907, -1911, -1918, -1921, -1922, -1924, -1927, -1928, -1931, -1932, -1931, -1932, -1933, -1935, -1936, -1937, -1937, -1936, -1935, -1936, -1936, -1935, -1936, -1938, -1938, -1937, -1936, -1937, -1937, -1936, -1935, -1936, -1934, -1934, -1933, -1932, -1933, -1932, -1931, -1931, -1930, -1931, -1930, -1929, -1929, -1929, -1928, -1927, -1927, -1926, -1925, -1925, -1924, -1924, -1923, -1924, -1923, -1923, -1922, -1921, -1922, -1920, -1919, -1919, -1919, -1918, -1918, -1917, -1916, -1917, -1916, -1916, -1915, -1873, -1912, -2144, 24327, 28682, 25282, 23482, 21423, 19368, 17310, 15258, 13197, 11137, 9082, 7020, 4946, 2935, 770, -1737, -1977, -1920, -1937, -1940, -1942, -1944, -1947, -1948, -1951, -1952, -1952, -1953, -1952, -1954, -1956, -1955, -1955, -1955, -1955, -1956, -1955, -1954, -1957, -1957, -1956, -1957, -1957, -1956, -1955, -1956, -1955, -1954, -1955, -1954, -1954, -1953, -1952, -1953, -1952, -1951, -1951, -1950, -1951, -1949, -1948, -1948, -1947, -1947, -1947, -1947, -1946, -1946, -1945, -1944, -1944, -1944, -1943, -1942, -1942, -1941, -1940, -1940, -1939, -1939, -1938, -1938, -1938, -1938, -1937, -1936, -1936, -1936, -1935, -1933, -1933, -1933, -1933, -1932, -1931, -1931, -1930, -1930, -1929, -1929, -1929, -1928, -1928, -1930, -1930, -1906, -2031, -1177};