/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1661 256 samples */
 
const int16_t AKWF_1661_256_DATA [256] = 
{10416, 8338, 8914, 8835, 8892, 8930, 8960, 8984, 9013, 9040, 9066, 9072, 9105, 9117, 9121, 9143, 9157, 9159, 9162, 9170, 9189, 9191, 9198, 9198, 9198, 9198, 9198, 9198, 9198, 9221, 9094, 10077, 11346, 11234, 11255, 11258, 11245, 11260, 11145, 11827, 13164, 13124, 13116, 13119, 13115, 13111, 13112, 13110, 13102, 13104, 13092, 13085, 13083, 13096, 12995, 13921, 14878, 14759, 14779, 14775, 14772, 14731, 14832, 14139, 12984, 13042, 13032, 13027, 13020, 13019, 12919, 13447, 14711, 14709, 14697, 14696, 14697, 14673, 14750, 13734, 12851, 12968, 12942, 12938, 12930, 12891, 13003, 12105, 10914, 11013, 10990, 10990, 10982, 10981, 10977, 10960, 10954, 10949, 10951, 10946, 10920, 11350, 9256, 20874, 34004, 32464, 32726, 32735, 32735, 32736, 32735, 32733, 32734, 32733, 32733, 32733, 32734, 32733, 32731, 32732, 32731, 32731, 32732, 32731, 32729, 32729, 32732, 32715, 32672, 32671, 32671, 32671, 32670, 32670, 32667, 32696, 32716, 32713, 32712, 32713, 32713, 32712, 32712, 32705, 32695, 32696, 32695, 32695, 32696, 32694, 32693, 32694, 32694, 32692, 32691, 32692, 32691, 32690, 32689, 32689, 32690, 32689, 32688, 32689, 32688, 32687, 32685, 32701, 32716, 32714, 32715, 32714, 32712, 31928, 36292, 11599, -35816, -32068, -32708, -32722, -32722, -32722, -32722, -32722, -32722, -32722, -32722, -32722, -32722, -32722, -32723, -32722, -32722, -32721, -32722, -32721, -32721, -32722, -32721, -32719, -32720, -32720, -32719, -32720, -32718, -32717, -32718, -32717, -32718, -32716, -32715, -32716, -32715, -32716, -32715, -32714, -32714, -32715, -32713, -32712, -32713, -32712, -32713, -32711, -32710, -32710, -32711, -32709, -32708, -32709, -32709, -32708, -32707, -32708, -32708, -32707, -32706, -32705, -32706, -32705, -32703, -32704, -32704, -32703, -32703, -32702, -32702, -32703, -32701, -32700, -32701, -32701, -32698, -32467, -33715, -26526};