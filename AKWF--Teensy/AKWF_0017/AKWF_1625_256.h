/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1625 256 samples */
 
const int16_t AKWF_1625_256_DATA [256] = 
{392, 1451, 2330, 3087, 3744, 4416, 5161, 6093, 7243, 8511, 9790, 10982, 11979, 12778, 13435, 14021, 14549, 15037, 15507, 15978, 16490, 17059, 17703, 18352, 18981, 19570, 20094, 20504, 20772, 20877, 20831, 20687, 20554, 20567, 20780, 21175, 21676, 22131, 22445, 22530, 22362, 21973, 21357, 20615, 19811, 19003, 18202, 17500, 16959, 16565, 16306, 16176, 16095, 15992, 15792, 15485, 15025, 14466, 13819, 13186, 12609, 12176, 11916, 11770, 11635, 11394, 11011, 10458, 9759, 8984, 8167, 7256, 6299, 5295, 4306, 3380, 2511, 1765, 1081, 487, -55, -641, -1295, -2019, -2883, -3811, -4624, -5266, -5677, -5862, -5923, -6037, -6245, -6597, -7087, -7706, -8333, -8958, -9511, -9930, -10271, -10567, -10845, -11143, -11502, -11880, -12258, -12652, -13082, -13595, -14220, -14886, -15497, -15953, -16215, -16275, -16166, -15907, -15592, -15311, -15125, -15112, -15225, -15434, -15608, -15623, -15510, -15217, -14820, -14367, -13912, -13408, -12974, -12605, -12375, -12320, -12418, -12628, -12918, -13200, -13428, -13520, -13448, -13225, -12780, -12243, -11679, -11164, -10802, -10543, -10353, -10180, -9923, -9578, -9161, -8666, -8081, -7470, -6842, -6196, -5548, -4932, -4358, -3916, -3654, -3578, -3651, -3794, -3909, -3892, -3633, -3163, -2581, -1880, -1220, -610, -92, 301, 653, 1020, 1474, 1975, 2509, 3052, 3527, 3949, 4392, 4858, 5378, 5962, 6549, 7077, 7441, 7630, 7644, 7576, 7513, 7525, 7687, 7978, 8369, 8792, 9166, 9419, 9531, 9568, 9579, 9631, 9748, 9947, 10250, 10565, 10844, 10991, 11040, 11055, 11111, 11244, 11526, 11825, 12036, 12179, 11382, 14871, 1723, -33212, -30848, -29738, -28342, -26992, -25947, -25226, -24763, -24438, -24073, -23452, -22544, -21398, -20072, -18675, -17332, -16123, -14998, -13959, -12909, -11824, -10637, -9401, -8203, -7110, -6084, -5093, -4095, -3027, -1890, -702};