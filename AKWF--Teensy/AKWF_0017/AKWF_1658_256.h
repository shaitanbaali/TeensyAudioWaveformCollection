/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1658 256 samples */
 
const int16_t AKWF_1658_256_DATA [256] = 
{1039, 2501, 2833, 2816, 3066, 3741, 4652, 5702, 6789, 7796, 8747, 9705, 10662, 11612, 12572, 13531, 14489, 15448, 16397, 17333, 18255, 19177, 20122, 21126, 22143, 23115, 24095, 25168, 26369, 27808, 29384, 30519, 30556, 28943, 25487, 20504, 14410, 7777, 1106, -5551, -12065, -18019, -23042, -26815, -29239, -30444, -30681, -30240, -29306, -27831, -25963, -23944, -21980, -20185, -18574, -17150, -15928, -14859, -13986, -13285, -12508, -11375, -9631, -7286, -4410, -937, 3174, 7901, 13440, 19376, 24818, 28879, 30895, 30740, 28965, 26357, 23781, 21812, 20350, 19207, 18221, 17163, 15956, 14721, 13475, 12218, 10969, 9724, 8478, 7244, 5999, 4757, 3516, 2271, 1032, -202, -1446, -2686, -3928, -5172, -6405, -7644, -8886, -10125, -11365, -12605, -13839, -15093, -16345, -17583, -18799, -19938, -20935, -21965, -23223, -24841, -27010, -29577, -31865, -32823, -32543, -30374, -26479, -21716, -16783, -12284, -8270, -4695, -1631, 838, 2674, 3771, 4290, 4555, 4886, 5493, 6353, 7385, 8484, 9557, 10549, 11511, 12461, 13400, 14347, 15313, 16287, 17253, 18202, 19109, 19910, 20633, 21445, 22500, 23905, 25696, 27627, 29281, 30230, 30172, 29167, 27216, 24262, 20304, 15409, 9558, 3079, -3577, -9999, -16006, -21545, -26351, -29983, -32141, -32603, -31527, -29473, -27081, -24950, -23236, -21799, -20546, -19313, -17959, -16473, -14956, -13535, -12308, -11400, -10950, -10496, -9305, -6746, -2324, 3868, 10938, 17713, 23083, 26493, 28194, 28543, 28025, 27146, 26003, 24482, 22766, 21015, 19373, 17943, 16708, 15580, 14468, 13284, 12061, 10817, 9561, 8307, 7060, 5820, 4581, 3339, 2095, 853, -388, -1624, -2866, -4106, -5348, -6588, -7824, -9062, -10303, -11550, -12801, -14047, -15274, -16487, -17632, -18740, -19907, -21212, -22722, -24405, -26132, -27757, -29092, -30054, -30769, -30943, -30124, -27944, -24112, -18695, -12464, -6507, -1786};