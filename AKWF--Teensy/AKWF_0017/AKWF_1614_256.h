/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1614 256 samples */
 
const int16_t AKWF_1614_256_DATA [256] = 
{29067, 27099, 27174, 26617, 26137, 25782, 25339, 25173, 24814, 24476, 23604, 22828, 22625, 21845, 21487, 21209, 20850, 20496, 20142, 19785, 19454, 19196, 18821, 18372, 18019, 17665, 17310, 17027, 16746, 16206, 15447, 15073, 14630, 14259, 13999, 13669, 13337, 12835, 12348, 12090, 11635, 11300, 11035, 10690, 10334, 9980, 9627, 9273, 8916, 8613, 8352, 7997, 7316, 7093, 6811, 6364, 5961, 5694, 5538, 5434, 5119, 4747, 4185, 3839, 3659, 3478, 2798, 1208, 279, 279, 1213, 2801, 3479, 3660, 3839, 4186, 4748, 5118, 5435, 5539, 5694, 5963, 6366, 6810, 7093, 7318, 7998, 8353, 8614, 8916, 9273, 9626, 9982, 10335, 10690, 11035, 11301, 11636, 12090, 12351, 12836, 13337, 13670, 14000, 14259, 14632, 15075, 15447, 16209, 16746, 17028, 17312, 17666, 18019, 18373, 18821, 19197, 19454, 19787, 20144, 20498, 20851, 21211, 21488, 21846, 22629, 22829, 23607, 24477, 24814, 25172, 25339, 25783, 26139, 26617, 27008, 27486, 27901, -19742, -29987, -26740, -26721, -26030, -25448, -24909, -23912, -23405, -23045, -22690, -22339, -21941, -21497, -21159, -20862, -20556, -20215, -19858, -19504, -19151, -18797, -18442, -18085, -17753, -17253, -16461, -15923, -15435, -14939, -14443, -13945, -13462, -12835, -12203, -11790, -11324, -10712, -10092, -9472, -8938, -8450, -7952, -7458, -6947, -6413, -5881, -5355, -4718, -3887, -3300, -2238, -1584, -1296, -1001, -733, -375, -94, 94, 95, -92, -371, -728, -998, -1291, -1578, -2225, -3287, -3880, -4707, -5346, -5875, -6407, -6938, -7451, -7946, -8442, -8932, -9463, -10082, -10704, -11317, -11784, -12198, -12824, -13454, -13940, -14436, -14932, -15431, -15916, -16451, -17244, -17749, -18079, -18438, -18792, -19146, -19500, -19853, -20210, -20553, -20858, -21154, -21492, -21934, -22333, -22686, -23038, -23401, -23902, -24896, -25444, -26018, -26708, -26933, -29046, -23340};