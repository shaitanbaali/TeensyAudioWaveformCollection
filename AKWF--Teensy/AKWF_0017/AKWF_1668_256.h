/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1668 256 samples */
 
const int16_t AKWF_1668_256_DATA [256] = 
{17803, 18071, 18334, 18596, 18858, 19121, 19385, 19648, 19910, 20174, 20436, 20700, 20963, 21225, 21488, 21752, 22015, 22278, 22541, 22803, 23066, 23330, 23592, 23856, 24118, 24382, 24646, 24908, 25170, 25433, 25697, 25960, 26223, 26486, 26748, 27012, 27274, 27538, 27801, 28063, 28327, 28590, 28852, 29115, 29379, 29642, 29905, 30168, 30431, 30693, 30957, 31220, 31483, 31746, 32009, 32268, 32548, 32722, 32506, 32262, 32026, 31788, 31550, 31313, 31074, 30836, 30598, 30360, 30122, 29884, 29645, 29407, 29169, 28931, 28693, 28454, 28216, 27978, 27740, 27502, 27265, 27027, 26788, 26550, 26312, 26073, 25836, 25597, 25359, 25121, 24883, 24645, 24406, 24168, 23931, 23693, 23454, 23216, 22978, 22740, 22502, 22264, 22025, 21787, 21549, 21311, 21073, 20834, 20597, 20359, 20121, 19882, 19645, 19406, 19168, 18930, 18691, 18453, 17708, 20255, -5559, -18846, -16357, -17063, -17279, -17492, -17707, -17923, -18137, -18351, -18567, -18781, -18996, -19211, -19427, -19639, -19855, -20071, -20284, -20499, -20715, -20928, -21143, -21359, -21573, -21788, -22004, -22218, -22432, -22648, -22863, -23076, -23291, -23507, -23721, -23935, -24151, -24365, -24580, -24796, -25011, -25224, -25440, -25655, -25868, -26083, -26299, -26513, -26728, -26944, -27157, -27372, -27588, -27802, -28016, -28232, -28447, -28660, -28876, -29091, -29305, -29520, -29736, -29946, -30175, -30314, -30114, -29890, -29672, -29454, -29235, -29015, -28796, -28577, -28358, -28139, -27920, -27701, -27482, -27263, -27043, -26825, -26605, -26386, -26167, -25949, -25729, -25510, -25292, -25072, -24852, -24634, -24415, -24195, -23977, -23757, -23538, -23320, -23100, -22881, -22662, -22442, -22223, -22005, -21785, -21566, -21348, -21127, -20909, -20690, -20470, -20251, -20033, -19813, -19594, -19375, -19155, -18937, -18718, -18498, -18279, -18061, -17840, -17622, -17403, -17183, -16766, -17659, -12329, 869, -188, -1, 0, 0, 0, 0};