/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1649 256 samples */
 
const int16_t AKWF_1649_256_DATA [256] = 
{32154, 32247, 32352, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32328, 31847, 34478, 22517, -31691, -33017, -32621, -32766, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32756, -32556, -33565, -21008, 28368, 33367, 32055, 32332, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32331, 32334, 31314, 36871, -10658, -37098, -31803, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32767, -32761, -32358, -34547, -21747};