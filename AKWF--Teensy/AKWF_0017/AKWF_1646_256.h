/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1646 256 samples */
 
const int16_t AKWF_1646_256_DATA [256] = 
{293, 788, 1245, 1680, 2094, 2494, 2883, 3257, 3613, 3940, 4228, 4474, 4687, 4882, 5079, 5289, 5518, 5761, 6016, 6283, 6565, 6866, 7184, 7516, 7848, 8178, 8509, 8846, 9195, 9562, 9947, 10355, 10786, 11236, 11696, 12150, 12581, 12984, 13362, 13733, 14114, 14519, 14950, 15402, 15862, 16324, 16784, 17245, 17703, 18159, 18605, 19033, 19445, 19839, 20219, 20588, 20951, 21312, 21678, 22043, 22406, 22760, 23100, 23427, 23744, 24049, 24343, 24624, 24889, 25141, 25388, 25634, 25882, 26133, 26385, 26641, 26896, 27147, 27388, 27611, 27816, 28014, 28216, 28429, 28662, 28908, 29163, 29421, 29672, 29914, 30148, 30371, 30583, 30786, 30971, 31132, 31256, 31336, 31370, 31359, 31304, 31206, 31064, 30877, 30641, 30349, 29998, 29576, 29078, 28504, 27849, 27110, 26288, 25386, 24416, 23396, 22329, 21222, 20084, 18910, 17714, 16510, 15299, 14093, 12894, 11698, 10512, 9341, 8184, 7056, 5959, 4901, 3895, 2945, 2047, 1201, 399, -359, -1074, -1755, -2413, -3062, -3722, -4403, -5112, -5859, -6646, -7474, -8348, -9256, -10186, -11128, -12067, -12996, -13914, -14815, -15695, -16551, -17374, -18163, -18929, -19674, -20409, -21139, -21860, -22571, -23267, -23940, -24579, -25179, -25736, -26264, -26770, -27249, -27700, -28116, -28494, -28842, -29168, -29477, -29780, -30083, -30384, -30689, -30990, -31280, -31551, -31794, -32006, -32186, -32337, -32462, -32568, -32654, -32718, -32755, -32768, -32758, -32731, -32685, -32621, -32531, -32412, -32266, -32096, -31907, -31703, -31484, -31249, -30986, -30686, -30349, -29980, -29591, -29192, -28784, -28363, -27919, -27441, -26929, -26385, -25815, -25224, -24614, -23980, -23325, -22641, -21924, -21174, -20394, -19597, -18797, -17995, -17187, -16367, -15521, -14650, -13765, -12871, -11982, -11110, -10253, -9408, -8571, -7734, -6900, -6082, -5286, -4525, -3804, -3122, -2480, -1873, -1295, -743, -202};