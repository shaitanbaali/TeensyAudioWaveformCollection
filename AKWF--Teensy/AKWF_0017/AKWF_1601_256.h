/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1601 256 samples */
 
const int16_t AKWF_1601_256_DATA [256] = 
{25383, 29854, 29125, 29455, 29626, 29803, 29961, 30174, 30337, 30486, 30630, 30766, 30888, 31007, 31122, 31232, 31339, 31445, 31547, 31644, 31738, 31828, 31915, 31999, 32080, 32156, 32230, 32299, 32363, 32425, 32483, 32534, 32580, 32624, 32661, 32692, 32719, 32739, 32753, 32759, 32759, 32752, 32736, 32712, 32679, 32634, 32581, 32517, 32441, 32351, 32250, 32133, 31926, 32200, 26589, 22845, 21942, 20748, 19678, 18660, 17670, 16701, 15752, 14808, 13867, 12925, 11974, 11005, 10017, 9000, 7929, 6737, 5834, 2092, -3515, -3241, -3447, -3563, -3662, -3750, -3825, -3887, -3938, -3981, -4011, -4033, -4046, -4052, -4049, -4041, -4022, -4000, -3970, -3936, -3895, -3849, -3799, -3743, -3683, -3616, -3549, -3475, -3398, -3317, -3233, -3144, -3051, -2956, -2857, -2756, -2649, -2537, -2425, -2309, -2189, -2064, -1937, -1796, -1645, -1490, -1322, -1147, -972, -797, -620, -442, -266, -89, 88, 265, 441, 619, 796, 971, 1146, 1321, 1489, 1644, 1795, 1936, 2063, 2188, 2308, 2424, 2536, 2648, 2755, 2856, 2955, 3051, 3143, 3232, 3316, 3397, 3474, 3548, 3615, 3682, 3743, 3798, 3848, 3894, 3935, 3969, 3999, 4021, 4040, 4048, 4051, 4045, 4032, 4010, 3980, 3937, 3887, 3824, 3749, 3661, 3562, 3446, 3240, 3514, -2092, -5835, -6738, -7930, -9001, -10018, -11006, -11975, -12925, -13867, -14809, -15752, -16702, -17670, -18660, -19679, -20749, -21942, -22846, -26589, -32200, -31926, -32133, -32250, -32351, -32441, -32517, -32581, -32634, -32679, -32712, -32736, -32752, -32759, -32759, -32753, -32739, -32719, -32692, -32661, -32624, -32580, -32534, -32483, -32425, -32363, -32299, -32230, -32156, -32080, -31999, -31915, -31828, -31738, -31644, -31547, -31445, -31340, -31232, -31122, -31007, -30889, -30766, -30630, -30486, -30338, -30174, -29961, -29803, -29626, -29455, -29125, -29854, -25384};