/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1670 256 samples */
 
const int16_t AKWF_1670_256_DATA [256] = 
{13258, 17479, 19854, 21702, 23182, 24411, 25449, 26331, 27084, 27723, 28259, 28701, 29056, 29325, 29360, 30273, 26318, 16660, 14528, 12619, 11164, 9958, 8923, 8011, 7198, 6468, 5802, 5195, 4640, 4129, 3658, 3225, 2826, 2460, 2124, 1816, 1536, 1282, 1052, 847, 664, 505, 369, 254, 161, 89, 39, 2, 24, 70, 33, 5, 26, 48, 64, 78, 90, 101, 110, 118, 125, 131, 136, 139, 143, 145, 147, 149, 150, 150, 149, 147, 146, 143, 142, 139, 136, 133, 130, 125, 122, 117, 112, 108, 102, 98, 93, 87, 82, 77, 72, 67, 62, 57, 52, 48, 42, 38, 33, 28, 24, 20, 17, 14, 10, 8, 5, 4, 2, -5, 136, -540, -8009, 439, -108, 0, 0, -255, 1058, -6989, -18193, -20474, -22919, -24717, -26187, -27426, -28478, -29378, -30150, -30804, -31354, -31807, -32168, -32443, -32412, -33658, -27351, -16557, -14344, -12076, -10382, -8983, -7784, -6738, -5818, -4998, -4265, -3611, -3023, -2500, -2035, -1624, -1263, -950, -684, -464, -287, -153, -60, -11, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};