/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1689 256 samples */
 
const int16_t AKWF_1689_256_DATA [256] = 
{414, 1850, 3243, 4622, 5980, 7316, 8628, 9908, 11159, 12379, 13562, 14712, 15822, 16891, 17922, 18908, 19848, 20746, 21596, 22398, 23151, 23855, 24506, 25109, 25658, 26154, 26597, 26986, 27320, 27602, 27829, 28001, 28118, 28181, 28191, 28146, 28048, 27897, 27695, 27444, 27142, 26792, 26397, 25956, 25473, 24950, 24388, 23788, 23158, 22497, 21808, 21097, 20363, 19612, 18848, 18074, 17290, 16507, 15721, 14939, 14166, 13402, 12650, 11915, 11198, 10504, 9834, 9189, 8574, 7990, 7438, 6920, 6438, 5991, 5585, 5215, 4884, 4593, 4341, 4128, 3955, 3821, 3725, 3667, 3647, 3663, 3715, 3799, 3918, 4069, 4249, 4457, 4694, 4957, 5240, 5547, 5874, 6218, 6576, 6949, 7332, 7725, 8123, 8525, 8929, 9334, 9733, 10128, 10516, 10892, 11257, 11610, 11945, 12261, 12559, 12835, 13089, 13317, 13519, 13696, 13843, 13961, 14053, 14112, 14142, 14142, 14113, 14055, 13968, 13852, 13709, 13538, 13343, 13122, 12877, 12612, 12325, 12018, 11695, 11356, 11003, 10637, 10259, 9872, 9479, 9079, 8674, 8267, 7856, 7445, 7035, 6625, 6220, 5816, 5415, 5021, 4631, 4245, 3863, 3487, 3116, 2748, 2384, 2022, 1662, 1302, 943, 582, 216, -151, -527, -909, -1301, -1702, -2118, -2547, -2992, -3453, -3934, -4435, -4957, -5501, -6069, -6663, -7279, -7922, -8589, -9283, -10001, -10744, -11510, -12298, -13109, -13939, -14785, -15650, -16525, -17410, -18307, -19204, -20105, -21005, -21896, -22780, -23651, -24502, -25334, -26140, -26916, -27661, -28368, -29033, -29655, -30230, -30751, -31220, -31632, -31982, -32271, -32496, -32656, -32746, -32767, -32717, -32598, -32405, -32141, -31805, -31399, -30919, -30371, -29756, -29072, -28323, -27511, -26637, -25703, -24716, -23672, -22578, -21439, -20254, -19026, -17764, -16465, -15136, -13783, -12403, -11006, -9596, -8169, -6736, -5299, -3860, -2428, -971};