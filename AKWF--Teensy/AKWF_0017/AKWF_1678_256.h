/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1678 256 samples */
 
const int16_t AKWF_1678_256_DATA [256] = 
{713, 2837, 5108, 7413, 9490, 11235, 12715, 13970, 15046, 15974, 16779, 17523, 17884, 22205, 23992, 24126, 24554, 24891, 25193, 25464, 25710, 25933, 26133, 26315, 26482, 26634, 26773, 26900, 26634, 28855, 7340, -2486, -307, -609, -540, -476, -417, -364, -315, -271, -230, -193, -160, -131, -104, -82, -62, -45, 21, -261, 1075, 4906, 4652, 4697, 4696, 4691, 4684, 4674, 4662, 4648, 4630, 4609, 4585, 4558, 4529, 4536, 4268, 5225, 9122, 8950, 8910, 8855, 8793, 8724, 8649, 8568, 8479, 8383, 8279, 8166, 8043, 7907, 7793, 7458, 7995, 11900, 11732, 11472, 11221, 10934, 10613, 10254, 9852, 9397, 8882, 8295, 7620, 6842, 5935, 4866, 3599, 2139, -149, -704, 290, -2448, -4484, -6334, -7929, -9281, -10418, -11351, -12070, -12514, -12797, -4549, 7405, 11483, 12760, 13167, 13421, 13816, 14183, 14139, 17828, 18109, 16721, 15218, 13365, 11273, 9001, 6692, 4614, 2867, 1386, 130, -947, -1876, -2679, -3337, -4206, -964, -132, -847, -1172, -1510, -1812, -2083, -2329, -2551, -2752, -2935, -3102, -3253, -3392, -3519, -4017, -2010, -23722, -33727, -31714, -32167, -32236, -32301, -32360, -32413, -32462, -32506, -32547, -32584, -32617, -32646, -32673, -32695, -32715, -32732, -32694, -33001, -31681, -27862, -28123, -28079, -28077, -28073, -28067, -28056, -28044, -28030, -28012, -27991, -27967, -27940, -27910, -27835, -28031, -26992, -23005, -23080, -23012, -22951, -22887, -22818, -22743, -22661, -22574, -22478, -22373, -22260, -22136, -22001, -21822, -21836, -20947, -16655, -16399, -16188, -15920, -15632, -15311, -14952, -14549, -14094, -13579, -12992, -12316, -11537, -10629, -9558, -8290, -6693, -5146, -992, 5047, 7015, 9189, 11037, 12631, 13982, 15118, 16051, 16769, 17213, 17494, 9241, -2709, -6785, -8062, -8468, -8721, -9110, -9448, -9651, -5360, -3631, -2716, -1090};