/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1674 256 samples */
 
const int16_t AKWF_1674_256_DATA [256] = 
{14382, 16276, 17751, 17462, 17484, 17497, 17519, 17459, 18076, 18623, 18561, 18587, 18599, 18610, 18662, 18459, 20378, 21897, 21699, 21749, 21764, 21778, 21828, 21631, 23586, 25079, 24872, 24926, 24940, 24954, 24978, 24931, 25605, 26089, 26030, 26058, 26071, 26085, 26116, 26013, 27401, 28290, 28165, 28200, 28212, 28224, 28237, 28218, 28581, 28798, 28771, 28783, 28790, 28649, 29443, 26234, 6519, 6194, 6338, 6297, 6302, 6315, 6270, 7006, 7392, 7333, 7350, 7356, 7360, 7379, 7315, 7730, 8443, 8402, 8415, 8421, 8427, 8448, 8376, 8815, 9510, 9466, 9483, 9490, 9496, 9527, 9413, 10109, 11119, 11041, 11067, 11074, 11082, 11111, 11007, 11726, 12713, 12627, 12660, 12668, 12675, 12683, 12691, 12699, 12707, 12715, 12723, 12732, 12741, 12771, 12661, 13457, 14376, 14292, 14327, 14337, 14346, 14149, 15349, 11055, -8247, -19368, -20259, -20110, -20153, -20166, -20190, -20159, -20322, -22404, -22862, -22783, -22815, -22829, -22855, -22822, -23011, -25114, -25521, -25449, -25479, -25497, -25512, -25513, -25574, -26004, -26090, -26087, -26105, -26120, -26133, -26147, -26161, -26175, -26190, -26203, -26215, -26229, -26253, -26221, -26419, -27694, -27849, -27828, -27847, -27859, -27895, -27778, -28345, -31685, -32056, -31973, -31999, -32006, -31533, -34099, -21798, 293, -2308, -1838, -1838, -1844, -1840, -1846, -2637, -2911, -2860, -2874, -2876, -2878, -2878, -2884, -3293, -3417, -3394, -3404, -3406, -3408, -3407, -3427, -4240, -4479, -4434, -4446, -4449, -4456, -4446, -4490, -5302, -5522, -5483, -5493, -5498, -5502, -5512, -5478, -5783, -6059, -6028, -6038, -6042, -6048, -6050, -6058, -6060, -6066, -6071, -6076, -6081, -6089, -6124, -5958, -7539, -8814, -8637, -8678, -8685, -8693, -8744, -8509, -10825, -12501, -12260, -12316, -12326, -12336, -12391, -12146, -14856, -16698, -16417, -16484, -16493, -16504, -16523, -16487};