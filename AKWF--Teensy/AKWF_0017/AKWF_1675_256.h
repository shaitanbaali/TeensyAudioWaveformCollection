/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1675 256 samples */
 
const int16_t AKWF_1675_256_DATA [256] = 
{522, 611, 593, 601, 603, 643, 420, 2737, 4641, 4410, 4453, 4458, 4462, 4501, 4306, 5721, 7461, 7329, 7356, 7361, 7366, 7379, 7349, 7535, 7875, 7872, 7877, 7884, 7889, 7905, 7857, 8110, 8841, 8882, 8876, 8887, 8891, 8940, 8722, 10591, 12431, 12242, 12283, 12292, 12295, 12344, 12150, 13424, 15298, 15196, 15218, 15229, 15237, 15251, 15229, 15389, 15746, 15755, 15762, 15771, 15779, 15796, 15751, 16352, 16818, 16767, 16787, 16794, 16801, 16808, 16816, 16823, 16832, 16840, 16848, 16853, 16861, 16869, 16876, 16883, 16891, 16896, 16903, 16910, 16915, 16946, 16823, 17462, 19273, 19352, 19327, 19339, 19100, 20448, 14173, -4340, -4239, -4265, -4316, -4319, -4432, -3934, -6336, -14030, -14523, -14404, -14457, -14468, -14571, -14184, -15816, -25246, -26763, -26451, -26540, -26554, -26590, -26534, -26767, -30490, -31587, -31392, -31450, -31465, -31483, -31499, -31498, -32205, -32545, -32506, -32531, -32547, -32561, -32578, -32593, -32607, -32623, -32637, -32652, -32665, -32079, -34987, -17960, 15093, 20132, 19107, 19417, 19425, 19434, 19444, 19454, 19463, 19472, 19482, 19490, 19500, 19508, 19517, 19527, 19534, 19545, 19552, 19561, 19569, 19575, 19605, 19294, 19098, 19134, 19136, 19143, 19149, 19095, 19428, 16785, 14147, 14437, 14392, 14396, 14400, 14363, 14574, 13322, 11452, 11560, 11549, 11547, 11539, 11535, 11664, 7631, 5536, 5868, 5805, 5805, 5798, 5746, 6064, 2529, -239, 105, 38, 30, 84, 49, -10581, 15889, 7967, -18924, -17894, -17943, -17998, -18048, -17765, -18729, -30827, -31025, -30766, -30837, -30847, -30860, -30815, -31110, -29579, -26547, -26610, -26624, -26622, -26630, -26594, -26893, -22871, -20121, -20513, -20446, -20451, -20461, -20351, -20985, -15793, -10463, -10989, -10903, -10901, -10905, -10789, -11386, -7703, -2049, -2326, -2293, -2282, -2282, -2250, -2405, -1575};