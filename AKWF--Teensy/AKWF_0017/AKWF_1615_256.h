/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1615 256 samples */
 
const int16_t AKWF_1615_256_DATA [256] = 
{2355, 7839, 13676, 17647, 20046, 22050, 24394, 26184, 27342, 27880, 28312, 28721, 29137, 29784, 30030, 30283, 30563, 30655, 30740, 30874, 30919, 30943, 31001, 31005, 31004, 31004, 31004, 31004, 31005, 30956, 30890, 30851, 30740, 30552, 30430, 30369, 30286, 30079, 29686, 29466, 29184, 28734, 28050, 27579, 27108, 26486, 25743, 25030, 24134, 23661, 23139, 22508, 21301, 20675, 20006, 19202, 17786, 16813, 16169, 14507, 11969, 6505, 613, 2830, 9559, 13322, 15444, 16518, 17169, 18488, 19637, 20339, 20913, 21857, 22886, 23382, 23853, 24543, 25363, 26135, 26740, 27411, 27719, 28411, 28953, 29353, 29540, 29877, 30203, 30332, 30396, 30475, 30640, 30811, 30867, 30919, 30986, 31005, 31004, 31004, 31004, 31004, 31007, 30979, 30919, 30914, 30812, 30692, 30624, 30456, 30130, 29968, 29484, 28917, 28533, 28114, 27659, 26899, 25419, 23314, 21049, 19053, 16045, 11005, 5189, -132, -5773, -10051, -12461, -15252, -18294, -20254, -21104, -21935, -23008, -23864, -25401, -26295, -27112, -27848, -29154, -30243, -30883, -31278, -31590, -31916, -32232, -32551, -32714, -32767, -32763, -32764, -32764, -32765, -32762, -32710, -32590, -32509, -32446, -32334, -32215, -32149, -32098, -32025, -31853, -31465, -31269, -30749, -30209, -29823, -29406, -28991, -28596, -27894, -27246, -26703, -26205, -25300, -23460, -20865, -16842, -13239, -10544, -7900, -5508, -3756, -2586, -1977, -1433, -949, -347, -601, -1168, -1686, -2218, -3028, -4487, -6520, -9099, -11753, -14680, -18802, -22195, -24374, -25841, -26412, -26962, -27501, -28253, -28789, -29177, -29593, -30008, -30407, -31052, -31339, -31649, -31958, -32063, -32120, -32176, -32262, -32393, -32477, -32538, -32646, -32743, -32766, -32764, -32764, -32764, -32766, -32754, -32660, -32419, -32085, -31773, -31445, -31124, -30628, -29821, -28518, -27473, -26745, -25967, -24683, -23436, -22536, -21518, -20775, -19554, -16964, -13900, -11416, -8474, -3159};