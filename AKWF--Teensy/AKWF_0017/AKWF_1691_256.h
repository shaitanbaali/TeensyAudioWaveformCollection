/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1691 256 samples */
 
const int16_t AKWF_1691_256_DATA [256] = 
{596, 2195, 3714, 5211, 6700, 8156, 9587, 10993, 12376, 13733, 15042, 16342, 17629, 18884, 20132, 21357, 22521, 23609, 24671, 25748, 26764, 27692, 28498, 29152, 29726, 30276, 30819, 31280, 31654, 31990, 32268, 32503, 32656, 32739, 32764, 32683, 32507, 32252, 31944, 31623, 31300, 30961, 30562, 30093, 29539, 28910, 28236, 27548, 26849, 26147, 25450, 24729, 23929, 23023, 22024, 20982, 19937, 18918, 17932, 16946, 15898, 14735, 13454, 12096, 10677, 9230, 7793, 6356, 4892, 3372, 1804, 241, -1272, -2688, -3993, -5217, -6379, -7478, -8510, -9467, -10349, -11130, -11792, -12364, -12895, -13417, -13956, -14528, -15122, -15701, -16259, -16836, -17464, -18138, -18842, -19584, -20363, -21143, -21859, -22473, -22978, -23432, -23862, -24214, -24472, -24635, -24664, -24526, -24228, -23795, -23237, -22552, -21724, -20743, -19617, -18371, -17029, -15619, -14170, -12697, -11215, -9734, -8275, -6859, -5500, -4188, -2945, -1782, -679, 373, 1374, 2334, 3255, 4150, 5004, 5796, 6535, 7244, 7938, 8623, 9288, 9953, 10630, 11294, 11937, 12561, 13180, 13814, 14429, 15006, 15530, 15982, 16401, 16820, 17237, 17619, 17947, 18219, 18426, 18602, 18735, 18826, 18917, 18997, 19030, 19011, 18936, 18819, 18674, 18498, 18277, 18002, 17704, 17425, 17160, 16878, 16572, 16264, 15964, 15647, 15285, 14854, 14364, 13843, 13313, 12806, 12302, 11749, 11113, 10356, 9474, 8493, 7445, 6367, 5258, 4090, 2859, 1538, 131, -1295, -2693, -4027, -5288, -6518, -7742, -8950, -10135, -11286, -12380, -13388, -14308, -15169, -16005, -16816, -17607, -18387, -19138, -19820, -20433, -21019, -21629, -22281, -22951, -23632, -24312, -24947, -25508, -25980, -26355, -26672, -26946, -27146, -27252, -27245, -27086, -26762, -26282, -25682, -24965, -24145, -23214, -22159, -20975, -19645, -18196, -16677, -15177, -13674, -12144, -10594, -9020, -7430, -5817, -4183, -2566, -942};