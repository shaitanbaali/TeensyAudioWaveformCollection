/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1666 256 samples */
 
const int16_t AKWF_1666_256_DATA [256] = 
{791, 2774, 4598, 6313, 7925, 9443, 10871, 12210, 13471, 14658, 15769, 16816, 17802, 18724, 19594, 20412, 21178, 21900, 22579, 23215, 23817, 24380, 24910, 25409, 25877, 26317, 26732, 27121, 27486, 27831, 28155, 28458, 28744, 29013, 29266, 29504, 29727, 29938, 30135, 30321, 30496, 30660, 30816, 30961, 31097, 31226, 31347, 31461, 31567, 31668, 31758, 31865, 31841, 31476, 31015, 30436, 29710, 28796, 27645, 26200, 24386, 22099, 19231, 15627, 11100, 5397, -1621, -8149, -13256, -17340, -20598, -23180, -25240, -26879, -28181, -29218, -30045, -30700, -31223, -31641, -31971, -32235, -32444, -32612, -32742, -32532, -32039, -31253, -29958, -27834, -24328, -18695, -8998, 4790, 7846, 7262, 7404, 7405, 7406, 7407, 7407, 7407, 7406, 7405, 7405, 7403, 7398, 7397, 7391, 7391, 7388, 7386, 7381, 7378, 7375, 7372, 7370, 7366, 7361, 7357, 7353, 7352, 7348, 7344, 7343, 7340, 7335, 7332, 7329, 7325, 7323, 7318, 7318, 7315, 7315, 7309, 7308, 7306, 7300, 7301, 7299, 7299, 7299, 7299, 7293, 7291, 7292, 7292, 7292, 7289, 7287, 7288, 7288, 7288, 7288, 7288, 7288, 7288, 7287, 7289, 7292, 7292, 7292, 7292, 7292, 7298, 7299, 7299, 7300, 7301, 7301, 7307, 7307, 7310, 7315, 7315, 7317, 7321, 7324, 7327, 7330, 7334, 7340, 7342, 7344, 7350, 7353, 7356, 7362, 7366, 7359, 7353, 7348, 7344, 7342, 7342, 7342, 7342, 7323, 7312, 7449, 854, -8421, -14919, -19759, -23320, -25947, -27881, -29300, -30348, -31118, -31684, -32102, -32406, -32646, -32726, -32522, -32246, -31866, -31344, -30630, -29647, -28301, -26453, -23912, -20436, -15672, -9688, 2192, -4066, -27923, -25736, -25522, -25063, -24540, -23980, -23385, -22753, -22079, -21362, -20602, -19790, -18927, -18011, -17034, -15996, -14893, -13717, -12465, -11140, -9724, -8222, -6623, -4925, -3123, -1162};