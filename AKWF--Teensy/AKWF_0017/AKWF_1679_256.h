/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1679 256 samples */
 
const int16_t AKWF_1679_256_DATA [256] = 
{16173, 20903, 19606, 19929, 18658, 14913, 20319, 18980, 18511, 18074, 17767, 17926, 18080, 18159, 18138, 17984, 17823, 17665, 17509, 17356, 17204, 17055, 16909, 16764, 16621, 16481, 16343, 16208, 16073, 15939, 15809, 15680, 15553, 15427, 15303, 15182, 15061, 14943, 14824, 14703, 14562, 14339, 13886, 13334, 12915, 12424, 11136, 6142, 546, 671, 355, 108, -138, -381, -623, -860, -1068, -1165, -834, 2832, 10788, 12258, 11948, 11992, 11971, 11952, 11934, 11917, 11901, 11886, 11872, 11860, 11864, 11892, 11966, 11749, 11639, 11574, 11500, 11428, 11358, 11287, 11217, 11148, 11080, 11012, 10942, 10873, 10802, 10727, 10649, 10565, 10471, 10365, 10233, 10103, 9959, 8821, 9185, 8707, 8006, 7066, 5689, 4868, -1458, -8913, -12164, -15078, -14752, -13974, -13365, -12346, -11273, -11579, -11769, -11975, -12183, -12392, -12599, -12806, -13012, -13218, -13424, -13622, -13787, -13786, -13255, -8790, 7898, 12733, 11563, 12064, 10944, 7346, 12895, 11697, 11367, 11065, 10891, 11181, 11464, 11668, 11770, 11738, 11694, 11654, 11613, 11571, 11529, 11489, 11448, 11407, 11367, 11326, 11285, 11246, 11206, 11166, 11127, 11086, 11045, 11006, 10966, 10927, 10888, 10848, 10807, 10763, 10697, 10548, 10166, 9685, 9336, 8913, 7691, 2763, -2768, -2580, -2834, -3021, -3207, -3393, -3577, -3757, -3912, -3954, -3570, 148, 8155, 9675, 9415, 9506, 9533, 9560, 9588, 9616, 9643, 9671, 9699, 9728, 9773, 9841, 9954, 9775, 9702, 9675, 9637, 9600, 9564, 9528, 9491, 9455, 9418, 9382, 9345, 9304, 9264, 9219, 9169, 9112, 9047, 8967, 8691, 9548, 5336, -12874, -11688, -11801, -12132, -12689, -13689, -14143, -20108, -27208, -30111, -32684, -32022, -30918, -29985, -28650, -27268, -27270, -27161, -27075, -26996, -26922, -26854, -26790, -26729, -26675, -26625, -26572, -26490, -26274, -25592, -20227};