/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1654 256 samples */
 
const int16_t AKWF_1654_256_DATA [256] = 
{191, 447, 643, 856, 1149, 1582, 2217, 3105, 4290, 5803, 7636, 9788, 12184, 14754, 17436, 20127, 22761, 25264, 27543, 29518, 31128, 32338, 32792, 32748, 32767, 32684, 31964, 30874, 29584, 28131, 26584, 24998, 23439, 21943, 20565, 19307, 18122, 16998, 15932, 14916, 13943, 13003, 12086, 11185, 10277, 9358, 8415, 7439, 6449, 5465, 4482, 3507, 2531, 1554, 580, -405, -1397, -2399, -3415, -4441, -5476, -6515, -7538, -8548, -9545, -10544, -11542, -12546, -13557, -14576, -15606, -16651, -17705, -18772, -19918, -21152, -22434, -23700, -24900, -25967, -26835, -27447, -27750, -27688, -27215, -26301, -24924, -23002, -20586, -17768, -14631, -11303, -7907, -4513, -1283, 1678, 4275, 6389, 7964, 8968, 9449, 9450, 9012, 8192, 7043, 5638, 4053, 2351, 620, -1079, -2693, -4151, -5497, -6838, -8140, -9387, -10547, -11587, -12471, -13187, -13702, -13993, -14043, -13841, -13377, -12591, -11469, -10056, -8400, -6588, -4663, -2698, -775, 1040, 2682, 4077, 5197, 5990, 6485, 6714, 6696, 6454, 6017, 5420, 4698, 3892, 3045, 2182, 1345, 569, -140, -865, -1617, -2365, -3082, -3734, -4295, -4730, -5018, -5130, -5041, -4735, -4205, -3420, -2353, -1032, 497, 2166, 3944, 5756, 7528, 9213, 10735, 12044, 13098, 13841, 14294, 14518, 14513, 14280, 13820, 13139, 12249, 11161, 9886, 8436, 6825, 5076, 3205, 1160, -1114, -3555, -6112, -8712, -11287, -13775, -16114, -18232, -20066, -21557, -22654, -23337, -23643, -23607, -23231, -22533, -21528, -20226, -18663, -16857, -14835, -12651, -10297, -7830, -5239, -2352, 802, 4107, 7511, 10862, 14049, 16944, 19458, 21463, 22871, 23588, 23562, 22713, 20987, 18460, 15260, 11538, 7476, 3195, -1086, -5213, -9013, -12306, -14975, -16918, -18083, -18564, -18406, -17692, -16495, -14920, -13078, -11071, -9021, -7044, -5207, -3622, -2357, -1391, -670, -151};