/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1690 256 samples */
 
const int16_t AKWF_1690_256_DATA [256] = 
{602, 2088, 3541, 4973, 6418, 7860, 9297, 10742, 12203, 13676, 15114, 16520, 17933, 19319, 20673, 21986, 23220, 24357, 25414, 26425, 27372, 28226, 29002, 29702, 30327, 30872, 31344, 31741, 32051, 32309, 32512, 32669, 32759, 32762, 32683, 32469, 32133, 31698, 31182, 30662, 30137, 29597, 29012, 28337, 27530, 26599, 25606, 24569, 23500, 22382, 21199, 19971, 18689, 17368, 16058, 14755, 13438, 12121, 10809, 9505, 8198, 6892, 5645, 4470, 3302, 2092, 852, -407, -1620, -2744, -3782, -4751, -5645, -6482, -7251, -7928, -8510, -8977, -9352, -9730, -10210, -10772, -11339, -11850, -12301, -12726, -13181, -13721, -14349, -15046, -15779, -16511, -17216, -17898, -18567, -19245, -19900, -20483, -20933, -21227, -21365, -21345, -21172, -20862, -20428, -19905, -19308, -18626, -17867, -17103, -16378, -15669, -14944, -14201, -13434, -12643, -11833, -10994, -10136, -9283, -8415, -7482, -6481, -5450, -4427, -3409, -2394, -1382, -371, 631, 1607, 2562, 3495, 4421, 5342, 6242, 7125, 8003, 8868, 9716, 10559, 11395, 12222, 13018, 13757, 14448, 15100, 15705, 16263, 16778, 17267, 17753, 18223, 18642, 18994, 19296, 19559, 19766, 19905, 20002, 20058, 20058, 20009, 19907, 19747, 19519, 19222, 18899, 18547, 18159, 17729, 17223, 16618, 15971, 15336, 14673, 13968, 13209, 12384, 11521, 10623, 9722, 8865, 8037, 7193, 6344, 5489, 4596, 3672, 2737, 1858, 1036, 208, -660, -1580, -2574, -3564, -4490, -5369, -6206, -6983, -7730, -8446, -9106, -9723, -10275, -10772, -11311, -11979, -12743, -13532, -14295, -15021, -15719, -16419, -17167, -17960, -18771, -19571, -20331, -21026, -21687, -22334, -22966, -23548, -24015, -24323, -24480, -24496, -24356, -24048, -23597, -23026, -22356, -21592, -20739, -19810, -18889, -18013, -17172, -16341, -15518, -14697, -13843, -12942, -11998, -11069, -10188, -9284, -8296, -7213, -6048, -4825, -3538, -2202, -790};