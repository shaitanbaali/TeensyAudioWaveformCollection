/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1648 256 samples */
 
const int16_t AKWF_1648_256_DATA [256] = 
{2072, 8605, 14077, 18483, 21841, 24418, 26507, 28326, 29893, 30992, 31385, 31009, 29955, 28405, 26498, 24265, 21702, 18978, 16492, 14749, 14040, 14350, 15334, 16481, 17309, 17472, 16845, 15514, 13635, 11214, 8161, 4364, -11, -4566, -8665, -11439, -12272, -11460, -10097, -9474, -10255, -12217, -14533, -16561, -18203, -19698, -21430, -23569, -25872, -27978, -29603, -30625, -31145, -31266, -31136, -30915, -30656, -30140, -28943, -26551, -22686, -17414, -11097, -4296, 2389, 8455, 13648, 17937, 21428, 24363, 26894, 29049, 30711, 31649, 31734, 31067, 29853, 28352, 26665, 24642, 22173, 19389, 16789, 15001, 14353, 14770, 15819, 16949, 17666, 17633, 16773, 15253, 13308, 10973, 8098, 4429, -1, -4702, -8833, -11353, -11716, -10500, -9105, -8841, -10152, -12514, -14937, -16839, -18314, -19760, -21611, -23970, -26482, -28632, -30111, -30892, -31224, -31371, -31477, -31523, -31358, -30691, -29150, -26436, -22416, -17195, -11069, -4456, 2146, 8219, 13409, 17585, 20858, 23593, 26117, 28545, 30715, 32241, 32772, 32219, 30781, 28768, 26479, 24041, 21424, 18758, 16380, 14755, 14195, 14698, 15880, 17192, 18070, 18101, 17204, 15573, 13484, 11015, 8002, 4239, -153, -4700, -8669, -11164, -11635, -10513, -9053, -8574, -9677, -11998, -14586, -16744, -18385, -19815, -21486, -23624, -26010, -28187, -29785, -30689, -31068, -31170, -31203, -31211, -31107, -30634, -29391, -26963, -23100, -17835, -11511, -4668, 2085, 8207, 13419, 17640, 20974, 23731, 26133, 28310, 30213, 31573, 32108, 31713, 30486, 28691, 26596, 24265, 21685, 18950, 16419, 14610, 13868, 14209, 15304, 16617, 17591, 17814, 17134, 15693, 13742, 11360, 8412, 4664, 153, -4645, -8913, -11616, -12150, -10975, -9445, -8929, -9985, -12198, -14604, -16573, -18127, -19601, -21412, -23687, -26089, -28155, -29588, -30377, -30789, -31037, -31187, -31225, -31055, -30489, -29226, -26861, -23109, -17969, -11702, -4674};