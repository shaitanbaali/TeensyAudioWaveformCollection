/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1688 256 samples */
 
const int16_t AKWF_1688_256_DATA [256] = 
{5781, 13754, 16517, 18827, 21758, 24114, 25950, 27996, 29842, 30673, 31633, 32702, 32424, 31286, 30476, 29611, 28367, 26339, 24338, 22595, 20395, 18109, 16645, 15199, 12990, 11081, 9924, 8481, 6991, 6193, 6799, 8532, 10305, 11786, 12581, 12025, 10110, 7474, 4100, 718, -1807, -3528, -5109, -6553, -7707, -8512, -8973, -9550, -10386, -11785, -13864, -16325, -18863, -20721, -21690, -21793, -20949, -19673, -18676, -18104, -17722, -17420, -17105, -17235, -17885, -18648, -19498, -20674, -21676, -21928, -22048, -23192, -24736, -25810, -25961, -25141, -23584, -20979, -17608, -14134, -10899, -8258, -6128, -3976, -1830, -273, 588, 1118, 1496, 1272, 133, -1339, -2929, -4555, -6125, -7748, -9032, -9889, -10241, -9693, -7984, -5491, -2922, -601, 1379, 2774, 4002, 5359, 6836, 8445, 10066, 11257, 11974, 12482, 12665, 12196, 11626, 11299, 10936, 10363, 9943, 10426, 11903, 13786, 15734, 17778, 19442, 20766, 22074, 22980, 23490, 23590, 23252, 22709, 22168, 21480, 20860, 20633, 20696, 20806, 20962, 20895, 20687, 20826, 20814, 20204, 19398, 18721, 17776, 16542, 15397, 14539, 13783, 13025, 12743, 12591, 12109, 11432, 10586, 9510, 8231, 6632, 4481, 1865, -753, -3197, -5332, -7139, -8956, -10529, -11791, -12831, -13728, -14791, -15930, -16780, -17180, -17325, -17808, -18369, -18544, -18597, -19086, -19963, -20942, -21718, -22275, -22763, -22384, -21644, -20698, -19021, -17713, -16361, -14990, -14198, -13769, -13374, -13488, -13671, -13471, -13432, -13296, -13194, -13228, -12736, -11431, -10816, -10208, -9269, -8445, -6977, -5857, -4996, -4925, -6244, -6952, -6537, -6301, -5802, -3866, -2320, -1545, -355, 970, 343, -2530, -4814, -6589, -9080, -11129, -12757, -12724, -10413, -7140, -3860, 161, 3068, 4684, 6201, 6404, 6293, 6594, 5727, 2988, 582, -1357, -3052, -3392, -2475, -3012, -4481, -5394, -5398, -4544, -1877};