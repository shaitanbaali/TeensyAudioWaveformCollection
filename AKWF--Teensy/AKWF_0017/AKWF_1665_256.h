/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1665 256 samples */
 
const int16_t AKWF_1665_256_DATA [256] = 
{365, 939, 1494, 2044, 2584, 3117, 3643, 4162, 4673, 5177, 5672, 6162, 6644, 7119, 7588, 8052, 8505, 8955, 9398, 9833, 10264, 10688, 11104, 11517, 11923, 12322, 12717, 13105, 13488, 13867, 14239, 14605, 14968, 15324, 15675, 16022, 16364, 16700, 17032, 17359, 17681, 18000, 18312, 18622, 18927, 19225, 19522, 19814, 20100, 20384, 20663, 20938, 21210, 21478, 21741, 22001, 22257, 22509, 22759, 23004, 23245, 23484, 23719, 23951, 24179, 24404, 24626, 24844, 25060, 25272, 25482, 25688, 25892, 26093, 26290, 26484, 26678, 26866, 27053, 27238, 27418, 27597, 27774, 27947, 28119, 28287, 28454, 28618, 28779, 28939, 29096, 29251, 29403, 29554, 29702, 29848, 29992, 30134, 30274, 30412, 30549, 30682, 30815, 30945, 31073, 31200, 31325, 31447, 31569, 31688, 31806, 31923, 32037, 32150, 32261, 32371, 32479, 32580, 32681, 32764, 31212, 27172, 21559, 14614, 6390, -2600, -9788, -14798, -18487, -21228, -23309, -24916, -26165, -27150, -27935, -28559, -29060, -29462, -29783, -30037, -30238, -30392, -30509, -30593, -30650, -30682, -30693, -30687, -30664, -30628, -30580, -30520, -30450, -30372, -30285, -30190, -30090, -29984, -29871, -29753, -29631, -29504, -29372, -29236, -29097, -28954, -28806, -28656, -28502, -28345, -28184, -28020, -27853, -27684, -27511, -27335, -27155, -26973, -26788, -26600, -26409, -26215, -26019, -25819, -25615, -25409, -25200, -24987, -24772, -24553, -24330, -24105, -23876, -23644, -23409, -23169, -22927, -22680, -22430, -22177, -21920, -21659, -21395, -21126, -20854, -20578, -20297, -20012, -19724, -19431, -19134, -18833, -18527, -18216, -17903, -17583, -17258, -16931, -16598, -16259, -15917, -15568, -15215, -14857, -14494, -14126, -13752, -13371, -12988, -12597, -12200, -11799, -11391, -10977, -10558, -10132, -9700, -9263, -8817, -8367, -7910, -7445, -6974, -6498, -6013, -5521, -5022, -4517, -4003, -3483, -2955, -2418, -1876, -1325, -768, -190};