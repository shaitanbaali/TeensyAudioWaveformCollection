/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1684 256 samples */
 
const int16_t AKWF_1684_256_DATA [256] = 
{5451, 5765, 6073, 6382, 6690, 6999, 7308, 7646, 7786, 9363, 10507, 10652, 10991, 11299, 11621, 11838, 13629, 14421, 14632, 14892, 15463, 17288, 17612, 17909, 18218, 18523, 18830, 19149, 19380, 19998, 21728, 22012, 22317, 22623, 22950, 23137, 23986, 25528, 25373, 21368, 12910, 8412, 9015, 9651, 10498, 10355, 10376, 10372, 10387, 10272, 11193, 11714, 11603, 11616, 11612, 11611, 11570, 12507, 12756, 12691, 12696, 12694, 12669, 12734, 13571, 13635, 13609, 13607, 13601, 13594, 13588, 13594, 13513, 14055, 14409, 14332, 14338, 14331, 14324, 14317, 14310, 14304, 14290, 14304, 14856, 14921, 14894, 14890, 14883, 14883, 14837, 15195, 15369, 15298, 15563, 15678, 15645, 15641, 15633, 15625, 15617, 15609, 15602, 15588, 15604, 15797, 15798, 15787, 15779, 15773, 15756, 15783, 15884, 15870, 15857, 15876, 15909, 15895, 15888, 15880, 15872, 15863, 15855, 15846, 15836, 15818, 15915, 15557, 11091, 10408, 9798, 11666, -14277, -25147, -23187, -23906, -24208, -24509, -24818, -25125, -25432, -25737, -26042, -26347, -26653, -26948, -27201, -27503, -27805, -28108, -28408, -28719, -28980, -29178, -29488, -29787, -30087, -30384, -30705, -30894, -31049, -31370, -31666, -31966, -32236, -32630, -32360, -28169, -19740, -15205, -15941, -15776, -15794, -15401, -15258, -15279, -15266, -15257, -15254, -15225, -14669, -14588, -14598, -14586, -14578, -14570, -14559, -14566, -14507, -13808, -13735, -13745, -13734, -13725, -13718, -13710, -13702, -13685, -13737, -12975, -12673, -12730, -12712, -12704, -12697, -12671, -12762, -11955, -11519, -11430, -10301, -10271, -10273, -10265, -10257, -10250, -10245, -10238, -10208, -10332, -9641, -8694, -8822, -8792, -8787, -8768, -8839, -8503, -7176, -7297, -6912, -5514, -5563, -5550, -5545, -5541, -5537, -5533, -5529, -5493, -5660, -4636, -3637, -3803, -3768, -3765, -3735, -3879, -2528, -1837, -1977, -1949, -1945, -1939, -1973, -404};