/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1611 256 samples */
 
const int16_t AKWF_1611_256_DATA [256] = 
{8042, 17296, 20538, 22147, 23137, 23898, 24580, 25234, 25877, 26518, 27159, 27797, 28435, 29072, 29709, 30343, 30971, 31570, 32375, 32720, 32239, 31683, 31084, 30462, 29833, 29200, 28562, 27925, 27287, 26647, 26009, 25369, 24730, 24094, 23456, 22763, 22156, 21658, 4249, -12218, -16396, -17687, -17747, -17372, -16841, -16256, -15648, -15035, -14421, -13805, -13190, -12576, -11960, -11344, -10733, -10022, -9883, -6190, 2728, 5973, 6586, 6438, 5979, 5411, 4804, 4186, 3561, 2936, 2312, 1689, 1058, 457, 152, 54, 19, 6, 2, -1, 0, 0, 0, 0, 2, -7, 92, 494, 1045, 1645, 2259, 2881, 3506, 4129, 4751, 5374, 5993, 6615, 7234, 7851, 8470, 9087, 9701, 10316, 10932, 11543, 12157, 12769, 13379, 13988, 14599, 15205, 15812, 16420, 16959, 17688, 17899, 1447, -13212, -17661, -19813, -20977, -21780, -22453, -23084, -23694, -24299, -24900, -25500, -26097, -26694, -27288, -27884, -28477, -29069, -29660, -30251, -30838, -31429, -31988, -32279, -32358, -32373, -32365, -32347, -32325, -32270, -32475, -31061, -30289, -31747, -32071, -32226, -32297, -32337, -32364, -32387, -32417, -32365, -32018, -31508, -30951, -30371, -29784, -29197, -28604, -28011, -27419, -26823, -26227, -25629, -25031, -24432, -23830, -23227, -22622, -22014, -21404, -20591, -20941, -14502, 5399, 13891, 16087, 16566, 16343, 15871, 15312, 14721, 14118, 13509, 12899, 12288, 11677, 11064, 10450, 9835, 9219, 8603, 7985, 7368, 6749, 6129, 5506, 4886, 4262, 3638, 3016, 2390, 1766, 1139, 531, 179, 64, 21, 6, 2, 0, -1, 0, 0, 0, 2, -6, 52, 426, 974, 1568, 2183, 2804, 3428, 4053, 4682, 5308, 5933, 6536, 7172, 7842, 1126, -5904, -8282, -9603, -10463, -11166, -11810, -12436, -13055, -13672, -14288, -14905, -15522, -16136, -16752, -17368, -17979, -18386, -20110, -13006};