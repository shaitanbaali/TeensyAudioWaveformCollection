/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1618 256 samples */
 
const int16_t AKWF_1618_256_DATA [256] = 
{1924, 6142, 10783, 15302, 20043, 24710, 28711, 31569, 32801, 32340, 30708, 28671, 25374, 21221, 17785, 15920, 15027, 14346, 13794, 13234, 12658, 11891, 10095, 7779, 5043, 2585, 552, 2327, 4805, 7527, 9895, 11762, 12609, 13180, 13742, 14292, 14954, 15815, 17535, 20842, 24988, 28429, 30532, 32218, 32829, 31760, 29041, 25120, 20513, 15731, 11215, 6558, 2344, -1630, -5622, -9737, -13198, -16336, -19514, -22247, -23939, -24055, -22850, -20926, -18771, -16214, -13429, -11342, -10361, -10509, -11354, -12824, -14540, -16312, -17818, -19044, -20000, -20590, -20721, -20508, -20374, -20284, -19856, -18607, -16645, -14189, -11335, -7878, -3984, -125, 3221, 5793, 7411, 7954, 7535, 6521, 5262, 3749, 2082, 617, -238, -672, -1103, -1686, -2190, -2263, -2002, -1565, -863, 498, 2530, 5008, 7645, 10239, 12451, 13975, 14724, 14869, 14457, 13373, 11620, 9636, 7804, 6126, 4280, 2331, 595, -646, -1627, -2482, -3097, -3295, -3086, -2634, -1838, -826, 210, 929, 1323, 1403, 1137, 230, -1233, -2979, -4378, -5488, -6429, -7343, -7708, -7458, -6707, -5817, -4619, -2656, -707, -2362, -4458, -5702, -6616, -7392, -7709, -7421, -6537, -5596, -4516, -3157, -1424, 91, 1070, 1395, 1344, 990, 307, -699, -1737, -2558, -3052, -3283, -3149, -2559, -1734, -757, 424, 2127, 4057, 5934, 7613, 9420, 11395, 13208, 14369, 14853, 14766, 14097, 12660, 10509, 7944, 5297, 2789, 695, -748, -1509, -1958, -2249, -2219, -1757, -1158, -716, -299, 487, 1900, 3564, 5107, 6389, 7442, 7950, 7524, 6028, 3545, 283, -3543, -7460, -10979, -13890, -16395, -18417, -19760, -20266, -20367, -20486, -20707, -20632, -20084, -19167, -17969, -16498, -14738, -13010, -11493, -10571, -10329, -11171, -13152, -15892, -18519, -20693, -22660, -23975, -24033, -22502, -19848, -16697, -13546, -10171, -6104, -2027};