/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1624 256 samples */
 
const int16_t AKWF_1624_256_DATA [256] = 
{52, 234, 413, 589, 765, 937, 1108, 1277, 1444, 1612, 1775, 1937, 2099, 2257, 2416, 2571, 2725, 2878, 3030, 3179, 3327, 3475, 3619, 3762, 3904, 4045, 4185, 4321, 4457, 4593, 4725, 4857, 4990, 5118, 5246, 5372, 5498, 5623, 5745, 5867, 5987, 6106, 6224, 6340, 6457, 6570, 6682, 6795, 6906, 7015, 7122, 7230, 7337, 7441, 7545, 7648, 7751, 7851, 7950, 8049, 8146, 8242, 8338, 8432, 8527, 8619, 8709, 8800, 8891, 8979, 9067, 9153, 9239, 9324, 9399, 9405, 9745, 5404, -9958, -23387, -29278, -31500, -32259, -32471, -32477, -32211, -33375, -18695, -9893, -11132, -10555, -10266, -9981, -9698, -9417, -9141, -8866, -8594, -8326, -8061, -7796, -7536, -7277, -7024, -6771, -6519, -6273, -6027, -5784, -5545, -5307, -5071, -4840, -4607, -4380, -4155, -3931, -3708, -3491, -3273, -3060, -2848, -2636, -2428, -2224, -2020, -1817, -1617, -1420, -1223, -1032, -840, -651, -462, -276, -92, 88, 269, 447, 624, 798, 971, 1143, 1311, 1478, 1646, 1810, 1971, 2132, 2292, 2450, 2605, 2758, 2911, 3064, 3212, 3360, 3507, 3651, 3795, 3937, 4078, 4217, 4355, 4490, 4626, 4759, 4891, 5022, 5151, 5279, 5405, 5531, 5655, 5777, 5899, 6020, 6138, 6255, 6371, 6487, 6602, 6716, 6827, 6938, 7046, 7154, 7262, 7370, 7473, 7576, 7679, 7780, 7882, 7981, 8080, 8177, 8274, 8369, 8464, 8556, 8650, 8740, 8831, 8819, 9388, 7599, -12355, -11443, -10747, -10545, -10266, -9985, -9704, -9427, -9153, -8881, -8612, -8344, -8081, -7819, -7559, -7301, -7049, -6797, -6547, -6300, -6056, -5814, -5574, -5336, -5103, -4870, -4640, -4412, -4186, -3964, -3742, -3524, -3308, -3093, -2880, -2670, -2462, -2257, -2053, -1851, -1651, -1453, -1259, -1065, -872, -683, -496, -311, -124};