/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1680 256 samples */
 
const int16_t AKWF_1680_256_DATA [256] = 
{7207, 9108, 10757, 12304, 13734, 15060, 16290, 17425, 18478, 19455, 20358, 21193, 21969, 22685, 23350, 23965, 24536, 25063, 25552, 26003, 26425, 26813, 27172, 27504, 27814, 28099, 28365, 28609, 28836, 29046, 29241, 29421, 29587, 29735, 29924, 29863, 29218, 29356, 29460, 29556, 29646, 29729, 29807, 29878, 29946, 30006, 30064, 30117, 30166, 30210, 30253, 30291, 30328, 30361, 30391, 30420, 30448, 30471, 30494, 30516, 30535, 30552, 30569, 30584, 30600, 30613, 30624, 30635, 30645, 30525, 31278, 21445, 17672, 18501, 18360, 18367, 18371, 18377, 18383, 18386, 18390, 18395, 18399, 18401, 18404, 18408, 18411, 18412, 18414, 18415, 18418, 18422, 18423, 18424, 18425, 18427, 18427, 18474, 18230, 19774, 21855, 21648, 21684, 21685, 21687, 21689, 21689, 21689, 21689, 21690, 21691, 21691, 21691, 21691, 21691, 21691, 21681, 21693, 21630, 19225, 15508, 12212, 9128, 6272, 3630, 1219, -1242, -2629, 4228, 3215, 1339, -166, -1595, -2921, -4150, -5286, -6340, -7316, -8218, -9055, -9830, -10546, -11212, -11827, -12396, -12924, -13413, -13865, -14286, -14674, -15033, -15367, -15675, -15961, -16225, -16470, -16698, -16906, -17102, -17282, -17449, -17612, -17711, -18038, -18926, -19015, -19126, -19223, -19313, -19395, -19474, -19546, -19612, -19673, -19730, -19784, -19833, -19878, -19921, -19959, -19996, -20029, -20058, -20087, -20114, -20139, -20161, -20183, -20203, -20220, -20237, -20252, -20267, -20281, -20293, -20303, -20316, -20455, -19721, -29569, -33360, -32543, -32697, -32703, -32708, -32714, -32720, -32725, -32727, -32731, -32736, -32739, -32741, -32744, -32747, -32750, -32752, -32754, -32755, -32758, -32760, -32761, -32762, -32765, -32766, -32721, -32970, -31425, -29346, -29556, -29520, -29518, -29519, -29521, -29520, -29521, -29520, -29522, -29525, -29524, -29524, -29524, -29524, -29524, -29514, -29526, -29463, -27057, -23341, -20044, -16960, -14104, -11463, -9015, -6751, -4621};