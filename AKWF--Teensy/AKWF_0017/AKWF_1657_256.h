/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1657 256 samples */
 
const int16_t AKWF_1657_256_DATA [256] = 
{919, 3036, 5117, 7307, 9677, 12292, 15202, 18238, 21155, 23617, 25354, 26329, 26611, 26251, 25333, 23945, 22064, 19731, 17170, 14554, 12067, 9822, 7774, 5792, 3724, 1442, -1007, -3501, -5975, -8322, -10459, -12581, -14551, -15680, -15322, -12951, -8146, -1454, 5638, 11518, 14785, 14897, 12405, 8362, 4027, 532, -1700, -3015, -3955, -5160, -7157, -10328, -14224, -17680, -19451, -18503, -14295, -7432, 750, 8688, 14930, 18995, 21268, 21945, 21373, 19949, 17664, 14405, 10569, 6593, 2863, -331, -3023, -5551, -8248, -11454, -15317, -19593, -23822, -27500, -30087, -31394, -31544, -30722, -29134, -27037, -24492, -21451, -18118, -14718, -11384, -8306, -5488, -2784, -64, 2862, 6013, 9239, 12456, 15585, 18508, 21237, 23763, 25645, 26400, 25605, 23057, 18922, 13576, 7518, 1243, -5119, -11536, -17513, -22417, -25696, -27035, -26460, -24452, -21618, -18611, -15753, -12883, -10086, -7425, -4911, -2643, -677, 1108, 2874, 4800, 6952, 9225, 11633, 14142, 16695, 19323, 22023, 24523, 26479, 27549, 27517, 26417, 24531, 22181, 19732, 17395, 15138, 12909, 10718, 8536, 6397, 4440, 2543, 466, -1925, -4797, -8186, -11545, -14230, -15593, -15211, -13200, -9970, -6070, -2034, 1773, 5474, 8773, 11176, 12290, 11826, 9742, 6450, 2515, -1412, -4943, -8071, -10746, -12854, -14323, -15150, -15434, -14904, -13166, -9926, -4937, 1981, 9836, 17210, 22676, 25200, 24722, 21970, 17923, 13671, 10023, 6883, 3988, 1212, -1698, -4846, -8057, -11283, -14555, -17871, -21274, -24799, -28182, -30913, -32518, -32626, -31193, -28537, -25156, -21585, -18254, -15164, -12238, -9399, -6571, -3692, -920, 1762, 4535, 7542, 10879, 14578, 18347, 21721, 24279, 25635, 25838, 24928, 22855, 19617, 15227, 9679, 3263, -3419, -9688, -15132, -19683, -23270, -25688, -26784, -26455, -24535, -21295, -17372, -13441, -10019, -7251, -4972, -3007, -1066};