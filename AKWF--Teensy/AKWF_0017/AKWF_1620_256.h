/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1620 256 samples */
 
const int16_t AKWF_1620_256_DATA [256] = 
{13823, 22110, 20463, 20810, 20153, 19938, 20009, 20020, 20039, 20059, 20081, 20100, 20120, 20141, 20161, 20176, 20544, 20667, 20657, 20728, 19746, 19382, 19459, 19553, 21010, 21277, 21239, 21267, 21283, 21299, 21312, 21326, 21336, 21321, 21566, 20501, 15696, 21842, 21232, 21345, 21332, 21322, 21307, 21295, 21279, 21262, 21220, 21330, 20613, 19384, 19497, 19350, 20078, 20770, 20637, 20674, 20432, 20146, 20161, 20135, 20114, 20095, 20075, 20055, 20034, 20015, 20006, 19914, 20371, 20846, 19981, 24163, -1060, -34068, -30007, -30743, -30750, -30739, -30726, -30712, -30694, -30674, -30652, -30627, -30604, -30580, -30186, -32163, -20456, -3612, -5461, -5266, -3902, -2806, -2976, -2896, -3134, -3369, -3331, -3297, -3504, -3769, -3734, -3702, -3881, -4173, -4140, -4137, -4135, -4129, -4121, -4150, -3913, -3656, -3687, -3676, -3670, -3666, -3661, -3661, -3654, -3653, -3648, -3644, -3642, -3636, -3628, -3658, -3433, -3165, -3188, -3215, -3019, -2721, -2749, -2741, -2735, -2733, -2725, -2756, -2516, -2263, -2300, -2260, -2463, -2737, -2694, -2731, -2552, -2248, -2280, -2241, -2488, -2718, -2687, -2658, -2881, -3140, -3103, -3104, -3102, -3101, -3094, -3099, -3140, -3088, -3098, -3102, -3103, -3105, -3109, -3119, -2778, -2667, -2690, -2705, -2382, -2249, -2272, -2285, -2646, -2718, -2705, -2711, -2364, -2271, -2295, -2282, -2622, -2749, -2727, -2733, -2736, -2744, -2742, -2754, -3117, -3203, -3186, -3189, -3535, -3650, -3631, -3637, -3642, -3643, -3650, -3653, -3655, -3661, -3664, -3668, -3670, -3678, -3684, -3676, -4019, -4143, -4123, -4130, -4134, -4138, -4148, -4139, -3787, -3716, -3740, -3745, -3406, -3309, -3334, -3356, -3029, -2909, -2965, -2854, -4445, -5312, -5038, -5377, -26262, -31451, -30350, -30585, -30611, -30634, -30657, -30679, -30698, -30716, -30730, -30744, -30752, -30781, -30619, -31275};