/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1609 256 samples */
 
const int16_t AKWF_1609_256_DATA [256] = 
{26773, 31273, 30127, 30164, 30031, 29892, 29743, 29609, 29457, 29321, 29176, 29027, 28886, 28739, 28591, 28451, 28302, 28158, 28020, 27790, 27497, 27208, 26920, 26633, 26341, 26053, 25763, 25473, 25188, 24895, 24605, 24318, 24026, 23740, 23448, 23158, 22625, 23714, 16655, 1800, 3223, 2949, 2958, 2960, 2965, 2967, 2970, 2973, 2974, 2979, 2980, 2983, 2986, 2987, 2987, 2992, 2993, 2996, 2993, 2993, 2996, 2731, 4121, -2406, -15656, -14173, -14079, -13802, -13515, -13226, -12941, -12655, -12366, -12078, -11796, -11358, -11833, -7502, -2315, -3032, -2907, -2910, -2909, -2915, -2918, -2921, -2925, -2927, -2932, -2936, -2938, -2941, -2944, -2946, -2950, -2951, -2955, -2956, -2958, -2960, -2961, -2963, -2965, -2959, -2989, -2939, -2780, -2636, -2490, -2344, -2197, -2050, -1904, -1756, -1609, -1462, -1315, -1168, -1021, -873, -725, -578, -431, -286, -133, -9, 1, -1, 0, -2, 8, 132, 285, 430, 577, 724, 872, 1020, 1167, 1314, 1461, 1608, 1755, 1903, 2049, 2196, 2343, 2489, 2636, 2780, 2938, 2988, 2958, 2964, 2962, 2960, 2959, 2957, 2955, 2954, 2951, 2949, 2945, 2943, 2940, 2937, 2935, 2931, 2926, 2924, 2921, 2917, 2914, 2908, 2909, 2906, 3031, 2314, 7501, 11832, 11358, 11796, 12077, 12366, 12654, 12940, 13225, 13514, 13802, 14079, 14173, 15656, 2406, -4122, -2732, -2997, -2994, -2994, -2997, -2994, -2993, -2988, -2988, -2987, -2984, -2981, -2980, -2975, -2973, -2971, -2968, -2966, -2961, -2959, -2950, -3224, -1801, -16655, -23714, -22625, -23158, -23448, -23740, -24026, -24318, -24605, -24895, -25188, -25473, -25763, -26053, -26341, -26633, -26920, -27208, -27497, -27791, -28020, -28158, -28303, -28451, -28591, -28739, -28886, -29027, -29176, -29321, -29457, -29609, -29743, -29892, -30031, -30164, -30127, -31273, -26773};