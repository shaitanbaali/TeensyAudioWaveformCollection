/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1653 256 samples */
 
const int16_t AKWF_1653_256_DATA [256] = 
{71, 345, 665, 1035, 1460, 1939, 2481, 3082, 3734, 4435, 5176, 5949, 6743, 7545, 8358, 9164, 9955, 10728, 11469, 12186, 12893, 13582, 14247, 14887, 15489, 16057, 16586, 17068, 17500, 17880, 18203, 18470, 18677, 18824, 18910, 18940, 18918, 18848, 18734, 18584, 18402, 18192, 17961, 17714, 17457, 17194, 16920, 16626, 16320, 16007, 15691, 15385, 15092, 14818, 14573, 14359, 14186, 14057, 13978, 13951, 13972, 14043, 14162, 14324, 14528, 14766, 15037, 15334, 15656, 15994, 16347, 16709, 17075, 17452, 17849, 18257, 18675, 19095, 19515, 19931, 20333, 20722, 21092, 21435, 21750, 22037, 22286, 22497, 22669, 22804, 22910, 22988, 23045, 23085, 23115, 23137, 23157, 23180, 23208, 23244, 23287, 23334, 23380, 23419, 23446, 23455, 23440, 23392, 23305, 23174, 22990, 22750, 22447, 22083, 21674, 21220, 20716, 20152, 19529, 18838, 18076, 17244, 16325, 15325, 14239, 13065, 11807, 10457, 8996, 7456, 5844, 4173, 2481, 763, -958, -2656, -4316, -5923, -7448, -8902, -10268, -11558, -12778, -13921, -14994, -16003, -16945, -17823, -18646, -19410, -20127, -20801, -21433, -22026, -22563, -23039, -23463, -23840, -24179, -24490, -24780, -25060, -25341, -25630, -25931, -26256, -26611, -26995, -27409, -27847, -28303, -28776, -29258, -29740, -30217, -30677, -31117, -31528, -31905, -32236, -32530, -32747, -32765, -32752, -32746, -32737, -32730, -32721, -32714, -32705, -32696, -32688, -32680, -32665, -32454, -32122, -31761, -31355, -30906, -30412, -29874, -29290, -28662, -27994, -27276, -26517, -25711, -24864, -23980, -23057, -22093, -21102, -20081, -19036, -17984, -16911, -15832, -14751, -13676, -12609, -11553, -10503, -9452, -8401, -7369, -6355, -5374, -4435, -3551, -2733, -1988, -1323, -747, -264, 117, 394, 573, 661, 670, 613, 503, 354, 181, -1, -176, -335, -461, -545, -595, -623, -628, -604, -548, -456, -324, -143};