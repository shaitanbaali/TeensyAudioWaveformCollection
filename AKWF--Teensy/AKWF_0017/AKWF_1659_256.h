/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1659 256 samples */
 
const int16_t AKWF_1659_256_DATA [256] = 
{10247, 11496, 11205, 11264, 11269, 11323, 11132, 11927, 18148, 19400, 19106, 19172, 19172, 19201, 19083, 19498, 25783, 27648, 27269, 27343, 27340, 27343, 27339, 27309, 29093, 29968, 29811, 29840, 29836, 29847, 29787, 30050, 31128, 31226, 31198, 31202, 31200, 31204, 31182, 31261, 31858, 31971, 31943, 31948, 31946, 31947, 31942, 31951, 32204, 32290, 32272, 32274, 32274, 32273, 32273, 32260, 32224, 32221, 32221, 32220, 32219, 32217, 32214, 32221, 32257, 32261, 32258, 32257, 32256, 32255, 32254, 32253, 32251, 32250, 32249, 32248, 32247, 32246, 32245, 32243, 32241, 32241, 32240, 32238, 32237, 32235, 32234, 32233, 32232, 32230, 32229, 32228, 32227, 32225, 32224, 32223, 32222, 32220, 32219, 32218, 32216, 32215, 32214, 32213, 32212, 32209, 32208, 32208, 32206, 32205, 32203, 32202, 32201, 32200, 32198, 32196, 32196, 31602, 34809, 19223, -33444, -32672, -32642, -32738, -32738, -32738, -32741, -32728, -32647, -32634, -32637, -32636, -32637, -32634, -32636, -32626, -32479, -32437, -32446, -32443, -32442, -32441, -32443, -32419, -32368, -32369, -32368, -32367, -32366, -32365, -32367, -32346, -32283, -32279, -32278, -32277, -32275, -32272, -32281, -32234, -31963, -31920, -31929, -31925, -31924, -31922, -31917, -31932, -32082, -32113, -32103, -32104, -32103, -32094, -32131, -31900, -31343, -31345, -31344, -31340, -31338, -31323, -31374, -31098, -30094, -30026, -30043, -30032, -30027, -30023, -30025, -29986, -29805, -29776, -29779, -29773, -29768, -29760, -29786, -29555, -29222, -29243, -29234, -29230, -29225, -29211, -29257, -28937, -28260, -28269, -28263, -28256, -28251, -28223, -28334, -27728, -25651, -25524, -25558, -25536, -25529, -25509, -25562, -25274, -23787, -23571, -23619, -23601, -23589, -23558, -23692, -22634, -21085, -21195, -21172, -21164, -21153, -21139, -21178, -20843, -20182, -20192, -20181, -20171, -20164, -20041, -20606, -17643, -6290, -5491, -5725, -5648, -5635, -5534, -6039, -3365};