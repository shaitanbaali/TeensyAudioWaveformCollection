/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1631 256 samples */
 
const int16_t AKWF_1631_256_DATA [256] = 
{14978, 16709, 16141, 16035, 15856, 15673, 15490, 15308, 15125, 14939, 14754, 14568, 14382, 14193, 14006, 13821, 13631, 13445, 13255, 13070, 12878, 12693, 12500, 12315, 12122, 11932, 11746, 11554, 11367, 11177, 10986, 10799, 10607, 10421, 10231, 10039, 9852, 9662, 9476, 9284, 9095, 8908, 8717, 8532, 8340, 8154, 7963, 7775, 7587, 7400, 7210, 7022, 6834, 6647, 6457, 6270, 6083, 5895, 5707, 5521, 5333, 5146, 4959, 4771, 4586, 4400, 4211, 4025, 3837, 3652, 3465, 3281, 3094, 2907, 2720, 2536, 2350, 2165, 1979, 1795, 1609, 1423, 1238, 1054, 867, 681, 498, 312, 130, -118, 173, -3462, 13343, 17073, 15898, 15875, 15691, 15508, 15324, 15139, 14952, 14765, 14580, 14393, 14205, 14015, 13828, 13640, 13449, 13262, 13072, 12885, 12692, 12507, 12315, 12128, 11937, 11746, 11560, 11366, 11180, 10991, 10798, 10611, 10419, 10231, 10042, 9850, 9665, 9473, 9288, 9094, 8907, 8718, 8527, 8341, 8152, 7964, 7773, 7586, 7399, 7211, 7020, 6833, 6644, 6457, 6268, 6082, 5893, 5707, 5518, 5333, 5145, 4957, 4769, 4583, 4398, 4209, 4021, 3837, 3649, 3463, 3277, 3092, 2905, 2719, 2533, 2349, 2162, 1975, 1791, 1606, 1420, 1235, 1051, 865, 680, 494, 310, 124, -58, -243, -427, -611, -793, -980, -1163, -1347, -1530, -1716, -1898, -2082, -2265, -2496, -2588, -2746, -20823, -25737, -24821, -25208, -25381, -25559, -25732, -25907, -26083, -26257, -26429, -26600, -26773, -26946, -27114, -27285, -27457, -27628, -27798, -27969, -28139, -28309, -28474, -28646, -28816, -28983, -29148, -29319, -29488, -29653, -29822, -29989, -30156, -30323, -30488, -30658, -30824, -30990, -31157, -31323, -31476, -31524, -32428, -19937, -14685, -15338, -14796, -14443, -14085, -13734, -13380, -13025, -12673, -12324, -11970, -11616, -11267, -10931, -10503, -10456};