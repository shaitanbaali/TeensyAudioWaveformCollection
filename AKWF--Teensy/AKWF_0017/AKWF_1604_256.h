/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1604 256 samples */
 
const int16_t AKWF_1604_256_DATA [256] = 
{664, 2053, 3412, 4767, 6112, 7449, 8772, 10076, 11364, 12634, 13877, 15097, 16291, 17451, 18584, 19683, 20746, 21772, 22761, 23708, 24614, 25478, 26296, 27071, 27797, 28476, 29108, 29690, 30221, 30705, 31136, 31517, 31847, 32127, 32356, 32533, 32661, 32739, 32768, 32749, 32682, 32569, 32410, 32207, 31961, 31675, 31346, 30980, 30578, 30138, 29667, 29165, 28632, 28074, 27489, 26882, 26254, 25608, 24945, 24270, 23583, 22886, 22180, 21497, 20458, 19072, 17715, 16358, 15013, 13676, 12352, 11048, 9760, 8491, 7248, 6027, 4833, 3674, 2540, 1441, 379, -647, -1635, -2580, -3488, -4352, -5169, -5944, -6671, -7349, -7981, -8563, -9095, -9577, -10010, -10390, -10721, -10999, -11227, -11407, -11534, -11612, -11641, -11622, -11555, -11442, -11284, -11081, -10834, -10547, -10219, -9852, -9450, -9011, -8540, -8038, -7505, -6946, -6362, -5754, -5127, -4482, -3818, -3143, -2457, -1760, -1059, -353, 352, 1058, 1759, 2456, 3142, 3818, 4481, 5126, 5754, 6361, 6945, 7504, 8037, 8539, 9010, 9450, 9852, 10219, 10547, 10833, 11080, 11284, 11441, 11555, 11622, 11641, 11611, 11534, 11406, 11227, 10999, 10720, 10389, 10009, 9577, 9094, 8562, 7980, 7348, 6670, 5943, 5168, 4351, 3487, 2580, 1634, 646, -380, -1442, -2541, -3675, -4834, -6028, -7249, -8492, -9761, -11049, -12353, -13677, -15013, -16358, -17715, -19072, -20459, -21497, -22180, -22886, -23584, -24270, -24945, -25608, -26254, -26882, -27489, -28074, -28633, -29165, -29667, -30138, -30578, -30980, -31346, -31675, -31961, -32207, -32410, -32569, -32682, -32749, -32768, -32739, -32661, -32533, -32356, -32127, -31847, -31517, -31136, -30705, -30222, -29690, -29108, -28476, -27797, -27071, -26296, -25479, -24615, -23708, -22761, -21773, -20746, -19684, -18584, -17451, -16291, -15097, -13878, -12634, -11365, -10077, -8772, -7449, -6113, -4768, -3413, -2054, -665};