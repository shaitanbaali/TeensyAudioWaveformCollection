/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1616 256 samples */
 
const int16_t AKWF_1616_256_DATA [256] = 
{28866, 28360, 17878, 17382, 17502, 17020, 13113, 12785, 12843, 12797, 12774, 12754, 12734, 12714, 12692, 12672, 12651, 12631, 12610, 12586, 12564, 12542, 12513, 12462, 12411, 12359, 12329, 12310, 12290, 12269, 12249, 12230, 12212, 12192, 12173, 12155, 12136, 12118, 12099, 12076, 12026, 11974, 11922, 11902, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11903, 11911, 11943, 11978, 12007, 12033, 12059, 12086, 12120, 12155, 12190, 12219, 12308, 12046, 9709, 12424, 12210, 12221, 12183, 12148, 12114, 12081, 12054, 12029, 12003, 11972, 11936, 11907, 11903, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11904, 11903, 11931, 11984, 12037, 12082, 12102, 12122, 12139, 12158, 12176, 12196, 12213, 12234, 12252, 12272, 12293, 12315, 12333, 12368, 12420, 12471, 12519, 12546, 12567, 12591, 12614, 12635, 12655, 12674, 12695, 12717, 12736, 12758, 12779, 12803, 12868, 12673, 13674, 17431, 17465, 17148, 18683, 31978, 18059, -32074, -30678, -30801, -30867, -30866, -30866, -30867, -30866, -30867, -30867, -30866, -30867, -30843, -30969, -30389, -28680, -28764, -28754, -28772, -28677, -30170, -30774, -30332, -29956, -29543, -29054, -27459, -19544, -16655, -16855, -17365, -19328, -21880, -24898, -27558, -29823, -30543, -30717, -30271, -33065, -13218, 2341, -350, 183, 175, 175, 175, 176, 176, 174, 181, 203, 222, 245, 261, 262, 261, 262, 261, 262, 259, 241, 220, 199, 178, 175, 175, 176, 175, 175, 175, 174, -354, 2309, -18226, -33004, -30275, -30692, -30499, -29565, -27116, -24455, -21402, -18979, -17160, -16875, -16641, -20826, -28141, -29096, -29612, -30026, -30378, -30836, -29859, -28638, -28779, -28759, -28730, -28824, -30654, -30919, -30854, -30865, -30866, -30866, -30866, -30868, -30867, -30866, -30866, -30866, -30830, -31028, -30096};