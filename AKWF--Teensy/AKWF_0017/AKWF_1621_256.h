/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1621 256 samples */
 
const int16_t AKWF_1621_256_DATA [256] = 
{1763, 2646, 2486, 2702, 2765, 2801, 2821, 2682, 3780, 4403, 4212, 4264, 4220, 4162, 4112, 3857, 4946, 5974, 5682, 5757, 5712, 5662, 5614, 5405, 6074, 7067, 6815, 6859, 6812, 6758, 6696, 6560, 6754, 7279, 7121, 7088, 7016, 6942, 6873, 6703, 7475, 7902, 7731, 7754, 7714, 7667, 7622, 7529, 7707, 7866, 7762, 7729, 7675, 7618, 7572, 7448, 7768, 8256, 8121, 8144, 8122, 8096, 8083, 7969, 8356, 9255, 9131, 9198, 9213, 9222, 9235, 9108, 10241, 10908, 10769, 10884, 10916, 10933, 10954, 10843, 11552, 12196, 12050, 12126, 12126, 12119, 12102, 12039, 12187, 12412, 12320, 12300, 12254, 12206, 12153, 12081, 12344, 12402, 12324, 12296, 12250, 12203, 12154, 12102, 12051, 12000, 11946, 11895, 11845, 11796, 11748, 11703, 11659, 11617, 11576, 11538, 11504, 11469, 11461, 11304, 12042, 13114, 12948, 13088, 13137, 13184, 13216, 13224, 13555, 13674, 13654, 13674, 13674, 13664, 13623, 13744, 12279, 11381, 11477, 11251, 11129, 11016, 10920, 10840, 10775, 10721, 10683, 10653, 10630, 10500, 10786, 10071, -19596, -25672, -25856, -28401, -29885, -31092, -31988, -32674, -31776, -31494, -31557, -31286, -30955, -30536, -30035, -29550, -28393, -27437, -26867, -26159, -25495, -24841, -24182, -23700, -22140, -20672, -20275, -19607, -19058, -18541, -18074, -17632, -16895, -16468, -16140, -15816, -15532, -15281, -15053, -14884, -14063, -13674, -13567, -13383, -13253, -13142, -13040, -13049, -12126, -11577, -11627, -11497, -11442, -11406, -11349, -11542, -10096, -8764, -9006, -8806, -8752, -8711, -8704, -8702, -8043, -7948, -8005, -8018, -8066, -8121, -8183, -8366, -6186, -5451, -5631, -5493, -5473, -5469, -5485, -5554, -5321, -5222, -5331, -5385, -5463, -5539, -5687, -5554, -3533, -3455, -3463, -3407, -3399, -3402, -3454, -3447, -1429, -1070, -1135, -1032, -1009, -1012, -1030, -1085};