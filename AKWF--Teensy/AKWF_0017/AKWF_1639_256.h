/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1639 256 samples */
 
const int16_t AKWF_1639_256_DATA [256] = 
{997, 3345, 5423, 7320, 9041, 10605, 12028, 13310, 14444, 15464, 16388, 17231, 17994, 18686, 19315, 19885, 20401, 20871, 21298, 21683, 22033, 22351, 22642, 22888, 23046, 23172, 23289, 23395, 23490, 23573, 23659, 23665, 23412, 23119, 22865, 22629, 22415, 22219, 22045, 21857, 21590, 21325, 21088, 20871, 20674, 20493, 20332, 20165, 19946, 19737, 19547, 19373, 19216, 19072, 18944, 18813, 18520, 18148, 17820, 17521, 17249, 17000, 16776, 16559, 16181, 15741, 15350, 14994, 14670, 14374, 14108, 13853, 13503, 13121, 12781, 12470, 12187, 11931, 11698, 11480, 11221, 10954, 10716, 10499, 10301, 10121, 9959, 9804, 9601, 9388, 9198, 9023, 8865, 8720, 8592, 8459, 8212, 7935, 7689, 7465, 7261, 7075, 6910, 6734, 6383, 5988, 5641, 5322, 5032, 4769, 4535, 4290, 3879, 3432, 3036, 2676, 2347, 2049, 1781, 1523, 1227, 936, 674, 436, 219, 23, -154, -326, -548, -770, -969, -1149, -1314, -1463, -1597, -1733, -1920, -2110, -2278, -2432, -2573, -2700, -2811, -2944, -3192, -3453, -3686, -3897, -4090, -4265, -4420, -4578, -4788, -4993, -5178, -5346, -5498, -5635, -5758, -5888, -6069, -6249, -6410, -6557, -6690, -6811, -6918, -7042, -7253, -7464, -7652, -7823, -7979, -8120, -8249, -8368, -8532, -8718, -8884, -9034, -9170, -9295, -9406, -9517, -9795, -10151, -10463, -10748, -11006, -11241, -11453, -11651, -11890, -12139, -12360, -12562, -12745, -12914, -13061, -13217, -13601, -14074, -14487, -14866, -15210, -15522, -15803, -16076, -16506, -16987, -17414, -17801, -18153, -18475, -18759, -19050, -19560, -20133, -20641, -21103, -21524, -21905, -22245, -22586, -23148, -23763, -24308, -24805, -25255, -25664, -26031, -26391, -26905, -27450, -27931, -28370, -28770, -29132, -29455, -29780, -30263, -30774, -31226, -31638, -32013, -32321, -32726, -32356, -28166, -23037, -18562, -14463, -10745, -7362, -4299, -1470};