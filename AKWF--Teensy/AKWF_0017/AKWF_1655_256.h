/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1655 256 samples */
 
const int16_t AKWF_1655_256_DATA [256] = 
{1320, 4468, 7736, 11123, 14514, 17868, 21096, 24099, 26813, 29162, 31082, 32514, 32802, 32748, 32747, 32778, 32514, 31400, 30015, 28495, 26891, 25270, 23707, 22257, 20935, 19689, 18484, 17334, 16233, 15167, 14133, 13121, 12105, 11087, 10050, 8982, 7894, 6803, 5724, 4655, 3593, 2533, 1480, 415, -657, -1737, -2835, -3944, -5068, -6189, -7295, -8385, -9469, -10545, -11626, -12717, -13818, -14929, -16052, -17185, -18330, -19549, -20874, -22254, -23618, -24912, -26056, -26977, -27599, -27861, -27703, -27074, -25943, -24246, -21968, -19159, -15949, -12470, -8838, -5226, -1757, 1446, 4235, 6493, 8130, 9096, 9461, 9269, 8576, 7453, 5992, 4277, 2399, 452, -1463, -3267, -4871, -6265, -7562, -8794, -9919, -10916, -11764, -12443, -12929, -13206, -13256, -13073, -12649, -11977, -10974, -9640, -8044, -6245, -4306, -2322, -362, 1476, 3138, 4549, 5642, 6370, 6738, 6782, 6529, 6014, 5288, 4400, 3409, 2363, 1321, 334, -545, -1273, -1891, -2468, -2987, -3429, -3772, -4000, -4096, -4042, -3825, -3433, -2862, -2110, -1145, 70, 1511, 3117, 4813, 6563, 8283, 9903, 11360, 12584, 13516, 14120, 14367, 14319, 13996, 13406, 12556, 11459, 10138, 8612, 6900, 5046, 3044, 941, -1249, -3632, -6239, -8966, -11749, -14493, -17094, -19470, -21547, -23219, -24421, -25085, -25168, -24661, -23606, -22047, -20039, -17667, -15013, -12126, -9125, -6085, -3081, -219, 2455, 5054, 7692, 10307, 12816, 15117, 17157, 18830, 20051, 20751, 20866, 20340, 19152, 17166, 14234, 10476, 6126, 1366, -3554, -8372, -12829, -16684, -19713, -21728, -22564, -22082, -20225, -17112, -12980, -8086, -2692, 2829, 8235, 13212, 17443, 20682, 22703, 23349, 22699, 20877, 18042, 14366, 10101, 5461, 668, -4006, -8315, -12062, -15022, -17083, -18374, -19037, -19086, -18565, -17527, -16030, -14140, -11941, -9502, -6915, -4226, -1443};