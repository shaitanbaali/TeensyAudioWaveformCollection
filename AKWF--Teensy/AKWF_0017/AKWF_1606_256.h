/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1606 256 samples */
 
const int16_t AKWF_1606_256_DATA [256] = 
{1288, 3933, 6466, 8868, 11089, 13100, 14875, 16423, 17780, 18982, 20068, 21090, 22069, 23031, 23969, 24872, 25725, 26514, 27232, 27879, 28455, 28959, 29387, 29731, 29980, 30127, 30173, 30140, 30059, 29978, 29945, 30003, 30180, 30472, 30870, 31330, 31798, 32220, 32544, 32732, 32759, 32606, 32264, 31722, 30972, 29994, 28778, 27326, 25665, 23831, 21869, 19831, 17756, 15669, 13571, 11442, 9232, 6922, 4489, 1946, -670, -3314, -5859, -8214, -10369, -12290, -13939, -15322, -16408, -17215, -17776, -18143, -18389, -18598, -18834, -19156, -19586, -20140, -20804, -21554, -22364, -23213, -24082, -24968, -25863, -26751, -27616, -28426, -29162, -29788, -30291, -30673, -30952, -31157, -31328, -31487, -31645, -31776, -31843, -31788, -31552, -31085, -30357, -29374, -28150, -26711, -25115, -23394, -21592, -19774, -17948, -16169, -14487, -12924, -11513, -10278, -9161, -8177, -7368, -6627, -5933, -5247, -4540, -3798, -3016, -2190, -1329, -446, 445, 1328, 2189, 3015, 3797, 4539, 5246, 5932, 6626, 7367, 8176, 9160, 10278, 11512, 12924, 14486, 16169, 17947, 19773, 21592, 23394, 25115, 26711, 28150, 29374, 30357, 31085, 31551, 31788, 31843, 31776, 31645, 31487, 31328, 31157, 30952, 30673, 30291, 29788, 29162, 28426, 27616, 26750, 25863, 24968, 24082, 23212, 22364, 21554, 20803, 20139, 19586, 19156, 18834, 18598, 18388, 18142, 17776, 17214, 16407, 15321, 13939, 12289, 10369, 8213, 5858, 3313, 669, -1946, -4490, -6923, -9233, -11443, -13571, -15670, -17756, -19832, -21869, -23832, -25665, -27327, -28778, -29994, -30972, -31722, -32264, -32606, -32759, -32732, -32544, -32220, -31798, -31330, -30870, -30472, -30180, -30003, -29945, -29978, -30059, -30140, -30174, -30127, -29980, -29731, -29387, -28959, -28455, -27879, -27232, -26514, -25725, -24873, -23970, -23031, -22070, -21090, -20068, -18982, -17781, -16423, -14876, -13101, -11089, -8868, -6467, -3934, -1289};