/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1612 256 samples */
 
const int16_t AKWF_1612_256_DATA [256] = 
{3041, 7694, 9794, 11226, 12404, 13500, 14571, 15632, 16680, 17718, 18746, 19763, 20749, 21688, 22591, 23456, 24262, 24977, 25587, 26110, 26535, 26805, 26862, 26715, 26401, 25796, 24531, 22724, 20633, 18330, 15729, 12731, 9469, 6015, 3272, 3760, 6239, 9317, 12497, 15411, 18010, 20386, 22584, 24426, 25587, 26259, 26666, 26852, 26803, 26547, 26151, 25654, 25051, 24339, 23542, 22691, 21798, 20859, 19873, 18861, 17840, 16804, 15755, 14701, 13650, 12608, 11525, 10697, 8691, 595, -4004, -5390, -5779, -4986, -3841, -3053, -2482, -1781, -948, -341, -120, -43, -16, -6, -2, 0, -1, 0, 0, 0, 0, 0, 0, 0, 3, 75, 295, 691, 1262, 1976, 2800, 3727, 4753, 5844, 6964, 8101, 9264, 10449, 11630, 12779, 13916, 15048, 16160, 17236, 18270, 19275, 20259, 21204, 22098, 22951, 23767, 24545, 25276, 25950, 26580, 27172, 27620, 28275, 28177, 5027, -15527, -23490, -29060, -29450, -26643, -25680, -27678, -29269, -28473, -27334, -28168, -30106, -30917, -30467, -30467, -31580, -32594, -32493, -31847, -31632, -31688, -31116, -29700, -28057, -26548, -24797, -22361, -19386, -16329, -13245, -9878, -6035, -2897, -3446, -6307, -9609, -12793, -15917, -19131, -22113, -24408, -26144, -27890, -29730, -31008, -31348, -31429, -32048, -32757, -32440, -31203, -30544, -31041, -31165, -29608, -27746, -27859, -29307, -29054, -26614, -25557, -28067, -30698, -28946, -27602, -15764, 12084, 22926, 26132, 27031, 26980, 26570, 26009, 25359, 24639, 23871, 23064, 22219, 21326, 20384, 19410, 18413, 17379, 16300, 15192, 14070, 12939, 11782, 10597, 9416, 8257, 7113, 5980, 4880, 3851, 2914, 2069, 1333, 751, 347, 127, 44, 15, 6, 1, -1, 0, 0, 0, 0, 0, 0, 0, -2, -2, -4, -298, -982, -1736, -2298, -2865, -3911, -5227, -5845, -6243, -4899};