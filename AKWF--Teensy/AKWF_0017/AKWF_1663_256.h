/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1663 256 samples */
 
const int16_t AKWF_1663_256_DATA [256] = 
{4709, 3589, 8813, 13098, 16603, 19493, 21873, 23825, 25431, 26754, 27836, 28728, 29464, 30066, 30563, 30971, 31306, 31581, 31809, 31994, 32148, 32275, 32378, 32465, 32535, 32592, 32639, 32679, 32711, 32738, 32761, 32758, 32733, 32707, 32673, 32631, 32581, 32521, 32448, 32357, 32248, 32114, 31953, 31755, 31515, 31222, 30866, 30432, 29905, 29263, 28480, 27532, 26374, 24965, 23254, 21168, 18632, 15554, 11795, 7310, 1439, -2899, -2814, -2833, -2859, -2865, -2875, -2883, -2888, -2891, -2900, -2907, -2909, -2913, -2916, -2918, -2921, -2920, -2925, -2931, -2930, -2931, -2930, -2934, -2936, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2935, -2936, -2935, -2931, -2930, -2931, -2930, -2930, -2930, -2930, -2930, -2930, -2931, -2930, -2921, -2920, -2921, -2920, -2920, -2920, -2920, -2920, -2921, -2920, -2915, -2916, -2916, -2915, -2915, -2915, -2915, -2915, -2916, -2911, -2909, -2910, -2909, -2909, -2909, -2909, -2909, -2910, -2908, -2904, -2905, -2904, -2904, -2904, -2904, -2904, -2905, -2900, -2892, -2893, -2892, -2892, -2892, -2892, -2892, -2893, -2892, -2888, -2887, -2888, -2887, -2887, -2887, -2887, -2887, -2888, -2884, -2882, -2883, -2882, -2882, -2882, -2882, -2882, -2883, -2878, -2876, -2877, -2876, -2876, -2876, -2876, -2876, -2877, -2874, -2866, -2867, -2867, -2931, -2629, -5207, -10496, -14510, -17842, -20277, -24170, -17890, -6649, -12756, -15883, -18781, -21184, -23172, -24826, -26196, -27331, -28275, -29056, -29703, -30242, -30688, -31058, -31365, -31619, -31831, -32007, -32152, -32273, -32372, -32456, -32524, -32581, -32629, -32669, -32700, -32728, -32751, -32741, -32714, -32683, -32647, -32604, -32550, -32485, -32408, -32315, -32201, -32064, -31900, -31700, -31461, -30638, -33100, -18058, 7522, 9464, 17908, -3265, -17425, -4304};