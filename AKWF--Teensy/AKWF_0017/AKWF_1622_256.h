/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1622 256 samples */
 
const int16_t AKWF_1622_256_DATA [256] = 
{392, 972, 1402, 1703, 2095, 2663, 3098, 3400, 3599, 3711, 3751, 3723, 3710, 3781, 3805, 3769, 3692, 3579, 3439, 3275, 3110, 2977, 2837, 2680, 2512, 2337, 2159, 1979, 1799, 1620, 1446, 1276, 1112, 953, 801, 655, 540, 472, 406, 336, 267, 198, 133, 63, 54, 176, 295, 382, 451, 504, 543, 570, 602, 670, 736, 785, 822, 850, 872, 881, 967, 1162, 1325, 1455, 1561, 1646, 1713, 1761, 1842, 1994, 2126, 2229, 2311, 2374, 2438, 2402, 3006, 5447, 7873, 9798, 11395, 12711, 13783, 14648, 15337, 15877, 16286, 16584, 16787, 16908, 16960, 16955, 16901, 16808, 16682, 16530, 16358, 16171, 15973, 15768, 15559, 15348, 15139, 14933, 14731, 14535, 14294, 14308, 12648, 5248, -2461, -8584, -13707, -17957, -21457, -24312, -26629, -28472, -29907, -30997, -31784, -32309, -32564, -32906, -30401, -22824, -15835, -10058, -5103, -903, 2666, 5703, 8212, 10179, 11792, 13120, 14196, 15054, 15714, 16215, 16527, 16534, 16413, 16252, 16049, 15810, 15543, 15265, 14867, 14304, 13768, 13270, 12804, 12369, 11958, 11591, 11093, 10275, 9510, 8856, 8282, 7781, 7341, 6970, 6538, 5791, 5067, 4476, 3976, 3557, 3209, 2923, 2673, 2379, 2106, 1895, 1729, 1602, 1513, 1439, 1529, 1884, 2220, 2507, 2761, 2986, 3183, 3375, 3413, 3082, 2746, 2491, 2283, 2120, 1990, 1903, 1750, 1259, 748, 355, 37, -217, -419, -544, -1007, -1966, -2776, -3421, -3939, -4351, -4680, -4888, -5398, -6618, -7711, -8566, -9250, -9787, -10209, -10484, -10958, -12251, -13505, -14463, -15225, -15812, -16264, -16551, -17000, -18667, -20485, -21862, -22964, -23823, -24475, -24956, -25291, -25504, -25614, -25637, -25590, -25481, -25298, -25213, -24018, -20128, -16355, -13271, -10646, -8435, -6565, -5004, -3655, -2349, -1225, -312};