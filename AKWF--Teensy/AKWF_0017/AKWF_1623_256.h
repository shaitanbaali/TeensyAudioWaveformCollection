/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1623 256 samples */
 
const int16_t AKWF_1623_256_DATA [256] = 
{2674, 6981, 10408, 13234, 15556, 17463, 19032, 20313, 21368, 22234, 22941, 23522, 23997, 24385, 24704, 24963, 25175, 25347, 25486, 25600, 25692, 25765, 25823, 25869, 25907, 25934, 25957, 25972, 25984, 25991, 25996, 25998, 25998, 25996, 25993, 25988, 25983, 25976, 25970, 25963, 25956, 25946, 25939, 25929, 25920, 25912, 25902, 25893, 25883, 25874, 25864, 25855, 25846, 25825, 25819, 25809, 22901, 18485, 15056, 12208, 9869, 7942, 6364, 5069, 4003, 3130, 2413, 1824, 1342, 945, 621, 356, 138, -40, -183, -303, -399, -476, -541, -594, -634, -664, -677, -768, 950, 4012, 6401, 8456, 8335, 6606, 5311, 4174, 4846, 6800, 8297, 9543, 10529, 11300, 11935, 12460, 12824, 13069, 13275, 13447, 13391, 13188, 13034, 12912, 12371, 11590, 10977, 10469, 10008, 9569, 9286, 8720, 3256, -4027, -9692, -14411, -18281, -21443, -24057, -26188, -24993, -22031, -19808, -17945, -16411, -15154, -14120, -13270, -12573, -12000, -11530, -11145, -10828, -10568, -10354, -10179, -10035, -9917, -9820, -9743, -9678, -9625, -9581, -9546, -9516, -9491, -9472, -9458, -9445, -9433, -9425, -9419, -9413, -9409, -9405, -9402, -9400, -9398, -9397, -9397, -9395, -9396, -9396, -9395, -9395, -9388, -9381, -9421, -7087, -3057, 134, 2774, 4937, 6711, 8169, 9385, 7975, 4736, 2231, 146, -4465, -10269, -14850, -18623, -19570, -18617, -17948, -17383, -16912, -16525, -16205, -15941, -15782, -15693, -15614, -15547, -15492, -15445, -15404, -15372, -15431, -15541, -15624, -15692, -15745, -15785, -15804, -15908, -14469, -11817, -9746, -7955, -8293, -10201, -11637, -12914, -12971, -11997, -11265, -10653, -10187, -9843, -9555, -9321, -9255, -9290, -9310, -9324, -9529, -9860, -10100, -10380, -12340, -15010, -17093, -18822, -20282, -21518, -22529, -23350, -24946, -26923, -28477, -29766, -30822, -31652, -32423, -32647, -25730, -16072, -8604, -2308};