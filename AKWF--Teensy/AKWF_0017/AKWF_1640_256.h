/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1640 256 samples */
 
const int16_t AKWF_1640_256_DATA [256] = 
{1293, 4317, 6998, 9438, 11655, 13668, 15498, 17155, 18662, 20029, 21266, 22394, 23414, 24337, 25179, 25940, 26629, 27254, 27820, 28333, 28797, 29218, 29595, 29939, 30251, 30530, 30783, 31009, 31215, 31400, 31566, 31715, 31851, 31971, 32076, 32173, 32258, 32332, 32400, 32461, 32513, 32558, 32597, 32633, 32662, 32686, 32706, 32724, 32739, 32750, 32758, 32763, 32767, 32768, 32768, 32767, 32764, 32759, 32752, 32747, 32738, 32728, 32719, 32709, 32695, 32684, 32671, 32657, 32643, 32628, 32614, 32599, 32585, 32568, 32552, 32536, 32521, 32503, 32487, 32469, 32453, 32435, 32418, 32400, 32384, 32365, 32349, 32330, 32314, 32295, 32275, 32259, 32241, 32221, 32205, 32187, 32168, 32151, 32133, 32114, 32094, 32079, 32060, 32040, 32021, 32006, 31987, 31967, 31949, 31933, 31912, 31845, 32007, 30522, 23960, 16963, 10793, 5147, 30, -4632, -8860, -12691, -16182, -19345, -22215, -24826, -27190, -29320, -31342, -32482, -31672, -30632, -29744, -28919, -28170, -27490, -26864, -26328, -25922, -25560, -25228, -24928, -24652, -24402, -24170, -23991, -23905, -23838, -23774, -23713, -23659, -23608, -23559, -23531, -23544, -23558, -23568, -23577, -23584, -23590, -23592, -23610, -23666, -23718, -23764, -23804, -23840, -23873, -23896, -23939, -24013, -24083, -24144, -24200, -24250, -24292, -24326, -24372, -24493, -24628, -24750, -24856, -24952, -25039, -25116, -25185, -25246, -25300, -25348, -25390, -25428, -25458, -25486, -25518, -25585, -25660, -25723, -25779, -25828, -25873, -25909, -25960, -26086, -26222, -26340, -26449, -26545, -26632, -26709, -26784, -26895, -27002, -27100, -27185, -27262, -27332, -27391, -27454, -27550, -27646, -27731, -27809, -27875, -27936, -27987, -28034, -28074, -28111, -28142, -28167, -28190, -28210, -28221, -28278, -28493, -28719, -28919, -29098, -29261, -29405, -29536, -29653, -29759, -29852, -29937, -30011, -30076, -30096, -30293, -29089, -23980, -18586, -13832, -9477, -5529, -1883};