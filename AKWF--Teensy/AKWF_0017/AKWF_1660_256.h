/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1660 256 samples */
 
const int16_t AKWF_1660_256_DATA [256] = 
{20418, 20646, 20562, 20583, 20601, 20610, 20620, 20624, 20628, 20637, 20642, 20642, 20642, 20642, 20642, 20642, 20642, 20642, 20642, 20642, 20637, 20619, 20679, 20449, 17411, 16542, 16732, 16684, 16683, 16680, 16679, 16673, 16656, 16655, 16652, 16648, 16646, 16643, 16588, 16844, 17676, 17717, 17692, 17692, 17690, 17694, 17654, 17796, 18601, 18717, 18676, 18677, 18674, 18660, 18717, 18255, 17580, 17626, 17614, 17601, 17596, 17636, 17415, 18716, 21352, 21284, 21276, 21276, 21272, 21238, 21390, 20577, 17661, 17465, 17523, 17500, 17497, 17490, 17475, 17471, 17470, 17460, 17450, 17446, 17444, 17420, 17483, 16988, 16259, 16306, 16291, 16287, 16284, 16267, 16266, 16262, 16261, 16248, 16240, 16237, 16237, 16226, 16215, 16214, 16208, 16205, 16191, 16189, 16183, 16183, 16171, 16164, 16160, 16160, 16148, 16140, 16137, 16134, 16129, 16118, 16110, 16107, 16107, 16094, 16084, 16082, 16081, 16072, 16060, 16058, 16055, 16051, 16044, 16033, 16030, 16028, 16024, 16009, 16007, 16004, 16007, 16094, 15483, 22840, 28291, 27555, 27687, 27682, 27678, 27672, 27693, 27522, 27276, 27291, 27284, 27280, 27277, 27240, 27394, 26486, 24323, 24343, 24346, 24332, 24328, 24308, 24358, 24065, 23073, 23002, 23017, 23003, 22996, 22957, 23133, 21448, 19622, 19827, 19781, 19777, 19764, 19711, 19962, 18162, 15347, 15540, 15501, 15493, 15479, 15377, 15858, 13046, 6362, 6416, 6436, 6410, 6388, 6303, 6893, -3457, -10377, -9300, -9506, -9514, -9520, -9615, -9031, -15456, -20946, -20249, -20374, -20370, -20361, -20540, -19588, -28432, -33429, -32602, -32749, -32750, -32751, -32749, -32756, -32715, -32604, -32603, -32604, -32604, -32603, -32598, -32620, -32369, -32144, -32177, -32169, -32167, -32166, -32160, -32180, -31991, -31777, -31799, -31793, -31791, -31789, -31778, -31823, -31494, -30946, -30978, -30969, -30966, -30964, -30724, -31985, -24715};