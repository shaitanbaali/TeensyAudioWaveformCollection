/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1607 256 samples */
 
const int16_t AKWF_1607_256_DATA [256] = 
{1068, 3277, 5347, 7235, 8820, 10003, 10719, 10937, 10700, 10078, 9189, 8156, 7119, 6202, 5512, 5147, 5171, 5636, 6567, 7976, 9875, 12219, 14955, 17948, 20987, 23826, 26236, 28048, 29225, 29822, 29952, 29718, 29199, 28443, 27508, 26480, 25483, 24664, 24168, 24115, 24586, 25609, 27121, 28959, 30824, 32274, 32767, 31798, 29067, 24668, 19138, 13468, 8723, 6182, 5895, 7249, 9806, 13281, 17158, 20585, 23246, 25039, 25956, 25917, 24695, 21802, 16496, 7508, -5295, -16852, -24704, -29458, -31802, -32579, -32506, -32121, -31744, -31511, -31423, -31392, -31302, -31071, -30686, -30260, -29984, -30052, -30548, -31368, -32211, -32667, -32381, -31175, -29122, -26462, -23570, -20769, -18310, -16363, -14988, -14191, -13953, -14212, -14887, -15883, -17063, -18289, -19408, -20278, -20769, -20777, -20226, -19084, -17384, -15224, -12749, -10163, -7603, -5208, -3063, -1204, 324, 1493, 2244, 2563, 2485, 2051, 1347, 469, -470, -1348, -2052, -2486, -2564, -2245, -1494, -325, 1203, 3062, 5207, 7602, 10162, 12748, 15224, 17384, 19083, 20225, 20777, 20769, 20278, 19408, 18289, 17062, 15882, 14887, 14211, 13952, 14191, 14988, 16362, 18310, 20768, 23570, 26462, 29122, 31175, 32381, 32667, 32211, 31368, 30548, 30052, 29984, 30260, 30686, 31071, 31302, 31392, 31423, 31511, 31744, 32121, 32506, 32579, 31802, 29458, 24704, 16851, 5294, -7509, -16496, -21803, -24695, -25917, -25957, -25039, -23246, -20585, -17158, -13282, -9806, -7250, -5896, -6182, -8724, -13469, -19139, -24668, -29068, -31798, -32767, -32274, -30824, -28959, -27121, -25609, -24587, -24115, -24168, -24665, -25483, -26480, -27508, -28443, -29199, -29719, -29952, -29823, -29225, -28048, -26236, -23826, -20987, -17949, -14955, -12220, -9876, -7976, -6568, -5637, -5172, -5148, -5513, -6202, -7120, -8157, -9189, -10078, -10700, -10938, -10720, -10004, -8820, -7235, -5348, -3278, -1069};