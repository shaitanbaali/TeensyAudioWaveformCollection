/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1613 256 samples */
 
const int16_t AKWF_1613_256_DATA [256] = 
{374, 1262, 2168, 3111, 4091, 5110, 6175, 7281, 8439, 9655, 10930, 12279, 13716, 15252, 16925, 18783, 20864, 23702, 26769, 27615, 26759, 24752, 21715, 17622, 12507, 6126, -3491, -10733, -13061, -13901, -14167, -14212, -14166, -14071, -13948, -13799, -13627, -13437, -13222, -12986, -12729, -12450, -12149, -11826, -11479, -11112, -10722, -10310, -9877, -9415, -8982, -8641, -8307, -7941, -7522, -7046, -6473, -5776, -5007, -4194, -3347, -2465, -1549, -603, 381, 1400, 2460, 3561, 4703, 5893, 7131, 8418, 9768, 11182, 12662, 14231, 15896, 17672, 19604, 21737, 24120, 27214, 31001, 32516, 31513, 28869, 25062, 20307, 14600, 8359, 7180, 11297, 16530, 21639, 26148, 29815, 32335, 32143, 29235, 26248, 23621, 21294, 19204, 17304, 15545, 13896, 12348, 10878, 9477, 8144, 6864, 5635, 4458, 3322, 2230, 1180, 169, -807, -1747, -2657, -3532, -4374, -5191, -5953, -6596, -7140, -7609, -8014, -8355, -8677, -9087, -9534, -9977, -10402, -10809, -11193, -11555, -11896, -12215, -12512, -12785, -13038, -13269, -13479, -13667, -13835, -13979, -14102, -14206, -14287, -14319, -14404, -14162, -8324, 407, 7599, 13634, 18568, 22450, 25328, 27363, 27645, 25343, 22722, 20425, 18396, 16581, 14935, 13414, 11993, 10659, 9395, 8190, 7045, 5946, 4890, 3882, 2908, 1971, 1070, 203, -632, -1439, -2217, -2967, -3689, -4386, -5054, -5697, -6317, -6910, -7480, -8027, -8548, -9047, -9524, -9976, -10406, -10813, -11197, -11559, -11899, -12218, -12515, -12788, -13041, -13273, -13482, -13670, -13835, -13981, -14105, -14205, -14286, -14319, -14446, -14125, -8453, -8146, -12421, -13673, -14114, -14243, -14240, -14177, -14078, -13952, -13804, -13634, -13443, -13228, -12994, -12737, -12456, -12157, -11835, -11490, -11123, -10734, -10323, -9889, -9431, -8950, -8448, -7921, -7371, -6797, -6197, -5572, -4924, -4250, -3549, -2822, -2067, -1286, -460};