/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1696 256 samples */
 
const int16_t AKWF_1696_256_DATA [256] = 
{549, 1836, 3154, 4516, 5901, 7303, 8714, 10132, 11564, 13004, 14446, 15888, 17326, 18743, 20131, 21472, 22755, 24001, 25226, 26442, 27641, 28777, 29786, 30629, 31294, 31805, 32199, 32494, 32687, 32767, 32726, 32583, 32363, 32091, 31781, 31444, 31090, 30726, 30350, 29958, 29528, 29039, 28484, 27859, 27167, 26412, 25579, 24648, 23616, 22478, 21258, 19993, 18705, 17410, 16108, 14782, 13432, 12070, 10707, 9366, 8052, 6755, 5482, 4237, 3024, 1852, 707, -431, -1584, -2767, -3984, -5229, -6490, -7747, -8970, -10141, -11239, -12248, -13169, -14001, -14741, -15397, -15959, -16427, -16807, -17110, -17364, -17604, -17856, -18136, -18445, -18770, -19103, -19443, -19785, -20127, -20458, -20758, -21017, -21225, -21383, -21492, -21555, -21572, -21538, -21449, -21298, -21083, -20801, -20451, -20036, -19563, -19050, -18507, -17944, -17363, -16757, -16126, -15479, -14818, -14149, -13465, -12748, -11987, -11182, -10339, -9482, -8625, -7773, -6935, -6104, -5267, -4422, -3563, -2699, -1848, -1016, -198, 625, 1481, 2381, 3316, 4273, 5228, 6163, 7078, 7964, 8818, 9645, 10445, 11215, 11954, 12652, 13298, 13900, 14465, 15007, 15532, 16030, 16486, 16886, 17221, 17499, 17724, 17909, 18056, 18162, 18220, 18216, 18142, 17996, 17782, 17511, 17190, 16821, 16397, 15907, 15333, 14669, 13925, 13117, 12275, 11417, 10535, 9617, 8650, 7623, 6550, 5448, 4324, 3187, 2028, 835, -387, -1637, -2905, -4168, -5417, -6651, -7874, -9097, -10329, -11567, -12807, -14037, -15242, -16422, -17571, -18681, -19753, -20772, -21726, -22611, -23413, -24113, -24706, -25188, -25571, -25874, -26114, -26300, -26422, -26464, -26417, -26290, -26102, -25871, -25599, -25283, -24907, -24468, -23969, -23413, -22804, -22143, -21418, -20640, -19824, -18971, -18098, -17196, -16240, -15223, -14152, -13037, -11906, -10789, -9691, -8609, -7523, -6415, -5283, -4135, -2982, -1829, -633};