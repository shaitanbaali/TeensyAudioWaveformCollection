/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1641 256 samples */
 
const int16_t AKWF_1641_256_DATA [256] = 
{546, 1285, 1939, 2538, 3065, 3814, 4906, 5919, 6834, 7668, 8426, 9109, 9757, 10751, 11928, 12974, 13925, 14793, 15578, 16290, 16938, 17705, 18567, 19345, 20052, 20690, 21272, 21799, 22270, 22851, 23570, 24224, 24820, 25356, 25843, 26285, 26682, 27082, 27516, 27914, 28272, 28598, 28893, 29158, 29401, 29684, 29989, 30264, 30511, 30734, 30936, 31118, 31280, 31484, 31724, 31943, 32139, 32314, 32472, 32615, 32752, 32668, 32285, 31921, 31593, 31293, 31001, 30783, 30341, 26685, 21239, 16479, 12120, 8153, 4559, 1290, -1679, -4310, -6649, -8775, -10702, -12455, -14044, -15481, -16811, -17371, -17082, -16808, -16566, -16343, -16138, -15956, -15767, -15889, -16493, -17080, -17601, -18077, -18506, -18901, -19235, -19048, -18509, -18042, -17615, -17223, -16869, -16545, -16250, -16151, -16239, -16313, -16380, -16440, -16495, -16541, -16591, -16471, -16127, -15803, -15510, -15243, -14999, -14781, -14553, -13963, -13188, -12505, -11879, -11310, -10794, -10324, -9897, -9508, -9155, -8833, -8541, -8276, -8035, -7814, -7615, -7408, -7187, -6986, -6804, -6637, -6486, -6347, -6226, -6050, -5786, -5538, -5316, -5112, -4927, -4758, -4601, -4358, -4065, -3805, -3568, -3351, -3150, -2968, -2806, -1247, 1591, 4134, 6445, 8551, 10457, 12187, 13780, 14741, 14954, 15123, 15283, 15423, 15550, 15655, 15800, 15315, 13724, 12149, 10749, 9471, 8303, 7250, 6272, 4598, 2422, 480, -1291, -2897, -4358, -5688, -6885, -8268, -9866, -11313, -12628, -13823, -14905, -15888, -16786, -17511, -18031, -18495, -18916, -19297, -19642, -19956, -20228, -20272, -20172, -20091, -20014, -19944, -19879, -19818, -19763, -19535, -19155, -18816, -18506, -18222, -17965, -17727, -17522, -17086, -16363, -15699, -15098, -14548, -14049, -13595, -13188, -12702, -12044, -11424, -10867, -10358, -9892, -9475, -9079, -8304, -7269, -6345, -5505, -4742, -4047, -3415, -2847, -2082, -1117, -228};