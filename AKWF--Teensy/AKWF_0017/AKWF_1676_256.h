/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1676 256 samples */
 
const int16_t AKWF_1676_256_DATA [256] = 
{24573, 33283, 31611, 31940, 31945, 31954, 31960, 31969, 31978, 31985, 31993, 32002, 32009, 32017, 32025, 32032, 32039, 32047, 32055, 32061, 32068, 32075, 32082, 32088, 32095, 32100, 32106, 32112, 32114, 31898, 32546, 30142, -8959, -29367, -26414, -27006, -27009, -27015, -27023, -27031, -27037, -27046, -27051, -27058, -27066, -27073, -27080, -27088, -27095, -27102, -27108, -27117, -27122, -27130, -27137, -27144, -27151, -27158, -27164, -27171, -27179, -27186, -27192, -27199, -27205, -27213, -27218, -27225, -27231, -27237, -27244, -27249, -27255, -27262, -27267, -27272, -27277, -27282, -27286, -27291, -27296, -27298, -27303, -27306, -27309, -27311, -27313, -27314, -27315, -27315, -27314, -27312, -27307, -27342, -27165, -28035, -27167, -26930, -26993, -26993, -26997, -27003, -27009, -27012, -27018, -27022, -27025, -27034, -26868, -27703, -23383, -13609, -13553, -13616, -13581, -13582, -13494, -13924, -12014, -4801, -4179, -4342, -4297, -4296, -4187, -4770, -533, 4430, 3998, 4069, 4075, 4076, 4165, 3732, 6237, 10704, 10577, 10587, 10600, 10602, 10648, 10445, 11442, 14239, 14353, 14320, 14336, 14340, 14375, 14235, 14830, 17755, 18140, 18052, 18075, 18072, 18149, 17758, 20287, 23846, 23612, 23643, 23649, 23694, 23216, 25338, 22348, 12035, 13034, 12876, 12873, 12873, 12888, 12859, 12156, 11926, 11971, 11968, 11969, 11970, 11974, 12006, 11026, 10526, 10609, 10598, 10600, 10602, 10600, 10629, 10347, 10125, 10156, 10154, 10157, 10158, 10141, 10243, 9537, 8712, 8786, 8777, 8778, 8778, 8783, 8781, 8442, 8306, 8332, 8328, 8330, 8333, 8335, 8337, 8339, 8340, 8342, 8344, 8346, 8348, 8344, 8375, 8111, 7867, 7895, 7893, 7894, 7896, 7876, 7975, 7344, 6459, 6514, 6508, 6505, 6499, 6499, 6557, 4249, 3105, 3289, 3252, 3251, 3250, 3234, 3327, 2163, 1290, 1399, 1376, 1373, 1378, 1003, 3191, -12573, -23338};