/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1687 256 samples */
 
const int16_t AKWF_1687_256_DATA [256] = 
{854, 2403, 3994, 5626, 7317, 8871, 9963, 10878, 11693, 11985, 11787, 11815, 11852, 11549, 11102, 11125, 12034, 13364, 14730, 16296, 18023, 19364, 20781, 22145, 23056, 23704, 23999, 23965, 23854, 23619, 23145, 22870, 22877, 22891, 22884, 22920, 22688, 22667, 22872, 22562, 21838, 21344, 20790, 19778, 18662, 17799, 17045, 16150, 15422, 15172, 14643, 13884, 13138, 12258, 11168, 9886, 8213, 6035, 3665, 1380, -864, -2922, -4931, -6970, -8638, -10121, -11435, -12733, -14169, -15402, -16260, -16787, -17414, -18321, -18862, -19025, -19458, -20312, -21216, -22016, -22615, -23276, -23649, -23183, -22911, -22015, -20770, -19951, -18651, -17564, -16981, -16346, -15831, -15877, -15558, -15201, -15125, -14885, -14804, -14690, -13732, -12766, -12647, -11738, -10873, -9867, -8473, -7709, -6901, -7285, -8067, -7584, -6942, -7129, -6081, -4279, -3635, -2961, -1328, -558, -2134, -4220, -4809, -6485, -8757, -10379, -11518, -10847, -8872, -6969, -4507, -1265, 365, 2132, 3704, 4055, 4833, 5502, 4070, 2026, 949, -436, -1707, -1429, -1426, -3158, -4331, -4548, -4271, -3616, -113, 7770, 11017, 12091, 15981, 19686, 21933, 24208, 26873, 28719, 29863, 31726, 32794, 32438, 32159, 32226, 31643, 30395, 28692, 27365, 25809, 23518, 21748, 20499, 18520, 16078, 14687, 13342, 11431, 9928, 9442, 10099, 11036, 11800, 12557, 12736, 11770, 10158, 8045, 5279, 2785, 932, -883, -2844, -4485, -5802, -6792, -7670, -8736, -9968, -11697, -13813, -16092, -18231, -19688, -20674, -20972, -20612, -20163, -19970, -19752, -19464, -19146, -18952, -19310, -19845, -20328, -21095, -22142, -22702, -22751, -23495, -25048, -26189, -26703, -26594, -25990, -24713, -22418, -19756, -17045, -14425, -12125, -9836, -7330, -5148, -3652, -2506, -1427, -679, -823, -1568, -2353, -3405, -4598, -5950, -7326, -8345, -9141, -9448, -8854, -7394, -5616, -3879, -2082, -434};