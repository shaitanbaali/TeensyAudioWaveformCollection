/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1628 256 samples */
 
const int16_t AKWF_1628_256_DATA [256] = 
{578, 1474, 2350, 3227, 4108, 4987, 5859, 6735, 7616, 8495, 9370, 10245, 11121, 11998, 12871, 13748, 14624, 15497, 16369, 17243, 18120, 18994, 19862, 20733, 21609, 22479, 23350, 24225, 25092, 25960, 26829, 27702, 28571, 29433, 30305, 31163, 32079, 32676, 31935, 31014, 30132, 29244, 28353, 27463, 26587, 25194, 26941, 8271, -7222, -4594, -5115, -5114, -5121, -5130, -5138, -5145, -5150, -5156, -5159, -5162, -5167, -5170, -5172, -5175, -5178, -5180, -5181, -5182, -5181, -5184, -5184, -5184, -5182, -5183, -5185, -5184, -5183, -5182, -5182, -5249, -4664, -7309, -8955, -4153, -5089, -4919, -4912, -4907, -4901, -4896, -4890, -4885, -4882, -4878, -4875, -4869, -4868, -4865, -4862, -4859, -4855, -4853, -4851, -4850, -4848, -4844, -4842, -4841, -4840, -4838, -4836, -4832, -4831, -4829, -4828, -4827, -4826, -4825, -4824, -4822, -4821, -4819, -4818, -4817, -4816, -4814, -4813, -4811, -4810, -4809, -4808, -4807, -4805, -4804, -4802, -4801, -4800, -4799, -4797, -4796, -4795, -4794, -4793, -4791, -4790, -4788, -4787, -4786, -4785, -4784, -4782, -4781, -4780, -4779, -4777, -4776, -4767, -4793, -4647, -3902, -3062, -2186, -1305, -428, 451, 1327, 2211, 3090, 3965, 4839, 5718, 6463, 8067, 5927, -5225, -4798, -4801, -4813, -4810, -4805, -4801, -4795, -4791, -4789, -4784, -4781, -4778, -4774, -4773, -4770, -4767, -4765, -4763, -4760, -4757, -4757, -4756, -4751, -4750, -4749, -4747, -4747, -4744, -4740, -4740, -4738, -4737, -4736, -4735, -4734, -4733, -4731, -4730, -4728, -4727, -4726, -4726, -4724, -4723, -4721, -4720, -4718, -4717, -4716, -4715, -4713, -4713, -4711, -4710, -4709, -4707, -4706, -4705, -4703, -4702, -4701, -4700, -4699, -4697, -4696, -4695, -4693, -4693, -4691, -4690, -4689, -4688, -4686, -4677, -4708, -4523, -3765, -2923, -2041, -1165, -277};