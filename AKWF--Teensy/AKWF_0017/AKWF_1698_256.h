/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1698 256 samples */
 
const int16_t AKWF_1698_256_DATA [256] = 
{328, 754, 1089, 1361, 1579, 1751, 1887, 2009, 2059, 2375, 6791, 11116, 12578, 12714, 12068, 11031, 9855, 8683, 7585, 6617, 6988, 9015, 11006, 11883, 11677, 10892, 9841, 8716, 7625, 6635, 5823, 4682, 9451, 17083, 20242, 21274, 20692, 19084, 16741, 16111, 20404, 23523, 23780, 22630, 20690, 18604, 16033, 17093, 25185, 29074, 29498, 28030, 25539, 22395, 19738, 19724, 21771, 24030, 24045, 22707, 20978, 18959, 16530, 14100, 11528, 8292, 6110, 6422, 6600, 6128, 5438, 4662, 3879, 3200, 3005, 3291, 3529, 6889, 16529, 22754, 24612, 23969, 21906, 19396, 16785, 21671, 28352, 29384, 27944, 25151, 21809, 18520, 15547, 12938, 10646, 8565, 6692, 7884, 12748, 15304, 15382, 14280, 12568, 10644, 8729, 6949, 5369, 4003, 2844, 1882, 1094, 456, -23, 223, 5002, 11441, 13931, 14197, 13230, 11643, 9823, 8005, 6313, 4803, 3433, 5659, 9021, 9851, 9498, 8491, 7191, 5823, 4502, 3392, 3592, 5305, 6277, 6183, 5531, 4619, 3588, 974, -4676, -8570, -10114, -10474, -10118, -9397, -8523, -7623, -6773, -6011, -5414, -4428, -8935, -16723, -19684, -20144, -19231, -17164, -19650, -27212, -29567, -28818, -26584, -23670, -20664, -17838, -15326, -12993, -11961, -15911, -23683, -30500, -32288, -30714, -27706, -25939, -28878, -29533, -27699, -24869, -21708, -18181, -17075, -20377, -21124, -20002, -18054, -15707, -13978, -13664, -14174, -15098, -16212, -17049, -22386, -30329, -32782, -31776, -29021, -25468, -21785, -17877, -17171, -21189, -22231, -21100, -18978, -16430, -13841, -11302, -10382, -13802, -17066, -17516, -16458, -14649, -12538, -10403, -8668, -7454, -7009, -8384, -9031, -7736, -6111, -4700, -3590, -4981, -10420, -14115, -14827, -14097, -12634, -10926, -9203, -7593, -6145, -4887, -3843, -3003, -2355, -1764, -1673, -3862, -5734, -6140, -5792, -5047, -4131, -3184, -2287, -1476, -771, -161};