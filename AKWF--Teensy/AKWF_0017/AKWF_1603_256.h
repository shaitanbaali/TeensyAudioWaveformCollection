/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1603 256 samples */
 
const int16_t AKWF_1603_256_DATA [256] = 
{13001, 17242, 16603, 16875, 17002, 17131, 17259, 17387, 17516, 17644, 17772, 17900, 18028, 18157, 18286, 18415, 18542, 18670, 18799, 18927, 19055, 19183, 19312, 19440, 19568, 19697, 19826, 19954, 20081, 20210, 20339, 20467, 20595, 20724, 20852, 20981, 21109, 21237, 21365, 21493, 21622, 21751, 21879, 22007, 22135, 22264, 22392, 22520, 22648, 22777, 22905, 23033, 23163, 23291, 23418, 23546, 23675, 23803, 23932, 24061, 24188, 24316, 24445, 24573, 24702, 24830, 24958, 25087, 25215, 25343, 25472, 25600, 25728, 25857, 25985, 26114, 26242, 26370, 26498, 26626, 26755, 26884, 27012, 27140, 27268, 27397, 27525, 27654, 27781, 27910, 28039, 28167, 28296, 28423, 28552, 28680, 28808, 28937, 29065, 29193, 29322, 29450, 29578, 29707, 29835, 29963, 30091, 30220, 30349, 30476, 30605, 30733, 30861, 30991, 31119, 31246, 31375, 31502, 31631, 31760, 31889, 32016, 32145, 32274, 32402, 32035, 34349, 23314, -23314, -34349, -32035, -32402, -32274, -32145, -32016, -31889, -31760, -31631, -31502, -31375, -31246, -31119, -30991, -30862, -30733, -30605, -30476, -30349, -30220, -30091, -29963, -29835, -29708, -29578, -29450, -29322, -29193, -29065, -28937, -28809, -28680, -28552, -28424, -28296, -28167, -28039, -27910, -27782, -27654, -27525, -27398, -27268, -27140, -27012, -26884, -26755, -26626, -26498, -26370, -26242, -26115, -25986, -25857, -25729, -25600, -25473, -25343, -25215, -25087, -24959, -24831, -24702, -24574, -24445, -24316, -24189, -24061, -23933, -23803, -23676, -23547, -23419, -23291, -23163, -23033, -22906, -22777, -22649, -22521, -22392, -22264, -22135, -22007, -21879, -21751, -21622, -21493, -21365, -21237, -21109, -20981, -20853, -20724, -20596, -20467, -20339, -20211, -20082, -19954, -19826, -19698, -19569, -19441, -19313, -19184, -19055, -18928, -18799, -18670, -18542, -18415, -18287, -18157, -18029, -17900, -17772, -17644, -17516, -17387, -17259, -17131, -17003, -16875, -16603, -17242, -13001};