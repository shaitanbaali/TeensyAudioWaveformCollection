/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1626 256 samples */
 
const int16_t AKWF_1626_256_DATA [256] = 
{11461, 15335, 20245, 26817, 31711, 32622, 29446, 24151, 19474, 17253, 17559, 18922, 19580, 18530, 15992, 13108, 11030, 10262, 10503, 10926, 10788, 9842, 8412, 7069, 6263, 6086, 6250, 6346, 6099, 5501, 4780, 4199, 3911, 3876, 3922, 3867, 3627, 3253, 2869, 2586, 2442, 2389, 2334, 2204, 1989, 1731, 1487, 1306, 1185, 1086, 972, 812, 621, 419, 235, 80, -48, -177, -316, -481, -655, -830, -991, -1139, -1280, -1422, -1573, -1733, -1897, -2056, -2211, -2356, -2503, -2651, -2801, -2958, -3112, -3265, -3414, -3561, -3707, -3855, -4005, -4156, -4306, -4509, -4011, -7525, 6379, 16353, 19709, 26510, 31528, 32568, 29512, 24227, 19468, 17179, 17414, 18778, 19479, 18483, 15984, 13084, 10969, 10159, 10382, 10813, 10692, 9780, 8349, 6989, 6167, 5973, 6132, 6236, 6001, 5414, 4690, 4103, 3803, 3763, 3810, 3758, 3527, 3155, 2766, 2480, 2333, 2277, 2224, 2099, 1884, 1626, 1383, 1198, 1077, 977, 862, 705, 514, 313, 129, -24, -157, -285, -425, -588, -762, -936, -1098, -1246, -1388, -1531, -1681, -1839, -2003, -2163, -2316, -2463, -2609, -2756, -2908, -3064, -3218, -3372, -3521, -3667, -3814, -3962, -4112, -4263, -4413, -4561, -4707, -4853, -4998, -5145, -5293, -5438, -5584, -5732, -5874, -6018, -6163, -6306, -6451, -6595, -6738, -6881, -7022, -7163, -7307, -7448, -7589, -7730, -7868, -8008, -8151, -8288, -8428, -8567, -8706, -8843, -8979, -9116, -9253, -9389, -9528, -9665, -9801, -9934, -10069, -10205, -10338, -10474, -10607, -10740, -10876, -11010, -11143, -11277, -11407, -11539, -11672, -11805, -11934, -12064, -12196, -12324, -12456, -12587, -12716, -12844, -12973, -13102, -13231, -13357, -13485, -13615, -13740, -13867, -13994, -14118, -14245, -14372, -14497, -14623, -14747, -14872, -14995, -15120, -15242, -15497, -14921, -18200};