/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1700 256 samples */
 
const int16_t AKWF_1700_256_DATA [256] = 
{1083, 2739, 4417, 6114, 7753, 9275, 10649, 11877, 12999, 14058, 15092, 16141, 17247, 18452, 19807, 21330, 23007, 24798, 26624, 28379, 29968, 31276, 32211, 32706, 32713, 32236, 31312, 30027, 28477, 26765, 24991, 23228, 21525, 19914, 18392, 16927, 15490, 14047, 12592, 11155, 9764, 8453, 7247, 6140, 5133, 4248, 3517, 2976, 2646, 2503, 2494, 2545, 2581, 2549, 2430, 2242, 2016, 1790, 1594, 1440, 1332, 1255, 1188, 1109, 994, 822, 574, 230, -228, -820, -1544, -2372, -3244, -4080, -4800, -5357, -5741, -5974, -6107, -6176, -6209, -6219, -6204, -6163, -6083, -5955, -5763, -5497, -5154, -4746, -4292, -3813, -3321, -2817, -2296, -1762, -1227, -717, -254, 149, 492, 792, 1071, 1359, 1692, 2103, 2610, 3214, 3886, 4574, 5230, 5827, 6372, 6923, 7552, 8320, 9268, 10382, 11600, 12833, 13969, 14905, 15564, 15882, 15841, 15446, 14734, 13757, 12577, 11264, 9880, 8491, 7173, 5985, 4976, 4174, 3582, 3198, 3026, 3072, 3337, 3795, 4389, 5032, 5639, 6154, 6548, 6826, 7012, 7119, 7146, 7069, 6858, 6493, 5964, 5282, 4465, 3544, 2579, 1637, 784, 76, -476, -899, -1245, -1577, -1942, -2348, -2782, -3207, -3583, -3877, -4072, -4165, -4180, -4170, -4198, -4318, -4541, -4829, -5114, -5320, -5401, -5356, -5222, -5065, -4951, -4944, -5098, -5455, -6041, -6856, -7876, -9051, -10322, -11640, -12944, -14182, -15297, -16222, -16908, -17328, -17481, -17393, -17100, -16628, -15988, -15193, -14262, -13224, -12139, -11068, -10051, -9111, -8249, -7453, -6722, -6072, -5523, -5110, -4877, -4863, -5097, -5578, -6261, -7072, -7926, -8767, -9577, -10396, -11274, -12254, -13358, -14565, -15821, -17053, -18177, -19110, -19792, -20181, -20265, -20062, -19604, -18920, -18012, -16875, -15510, -13978, -12318, -10577, -8795, -7020, -5291, -3629, -2039, -451};