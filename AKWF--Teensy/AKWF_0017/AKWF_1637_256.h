/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1637 256 samples */
 
const int16_t AKWF_1637_256_DATA [256] = 
{502, 1330, 1944, 2778, 3775, 4498, 5174, 5903, 6666, 7429, 8193, 8954, 9720, 10443, 11119, 11926, 12718, 13441, 14398, 15243, 15773, 16099, 16435, 16902, 17354, 17938, 18744, 19242, 19571, 19931, 20334, 20733, 21175, 21674, 22044, 22374, 22763, 23168, 23574, 23980, 24372, 24674, 25305, 25939, 26356, 27361, 28092, 28518, 28854, 29137, 29643, 30047, 30644, 30507, 33993, 14093, -27257, -31247, -30794, -30346, -29568, -28997, -28137, -27207, -26681, -26260, -25854, -25440, -24959, -24494, -24123, -23776, -23415, -23017, -22612, -22207, -21802, -21396, -20991, -20587, -20175, -19460, -18664, -18072, -17503, -16936, -16368, -15806, -15207, -14465, -13841, -13350, -12755, -12056, -11347, -10667, -10074, -9508, -8941, -8370, -7775, -7166, -6557, -5939, -5094, -4294, -3409, -2329, -1744, -1386, -1065, -715, -336, -45, 109, 41, -195, -548, -919, -1235, -1567, -1992, -2940, -3935, -4707, -5605, -6280, -6895, -7504, -8108, -8686, -9254, -9821, -10390, -11036, -11741, -12454, -13104, -13608, -14162, -14898, -15545, -16115, -16683, -17250, -17819, -18377, -19101, -19910, -20403, -20809, -21215, -21622, -22026, -22431, -22837, -23243, -23621, -23968, -24313, -24746, -25236, -25670, -26077, -26486, -26920, -27710, -28681, -29268, -30036, -30673, -31422, -31897, -15424, -8694, -4663, -4816, -4964, -5033, -5182, -5174, -5110, -5132, -5338, -6022, -6228, -6393, -6764, -6763, -6775, -6822, -6866, -6914, -6960, -6949, -6921, -7037, -7145, -7193, -7245, -7267, -7226, -7263, -7649, -7980, -8085, -8220, -8235, -8205, -8230, -8291, -8543, -8610, -8649, -8769, -8755, -8740, -8779, -8825, -8873, -8918, -8968, -9001, -8974, -8926, -9133, -9367, -9270, -9312, -9455, -9498, -9420, -9202, -9055, -9064, -9212, -9418, -9391, -9223, -9238, -10001, -11289, -11567, -11003, -9216, -7451, -6493, -5914, -5296, -4439, -3527, -2750, -2111, -1623, -1039, -318};