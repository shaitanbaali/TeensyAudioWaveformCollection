/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1608 256 samples */
 
const int16_t AKWF_1608_256_DATA [256] = 
{4468, 14830, 22251, 27183, 30251, 31930, 32651, 32758, 32519, 32119, 31672, 31250, 30885, 30587, 30355, 30179, 30051, 29971, 29935, 29941, 29977, 30017, 30019, 29925, 29668, 29192, 28439, 27392, 26060, 24489, 22748, 20921, 19085, 17332, 15721, 14302, 13105, 12148, 11446, 11007, 10834, 10919, 11244, 11796, 12530, 13392, 14321, 15241, 16084, 16796, 17334, 17680, 17849, 17876, 17800, 17668, 17519, 17374, 17238, 17102, 16945, 16752, 16497, 16163, 15728, 15172, 14456, 13512, 12241, 10478, 7975, 4377, -808, -6253, -10421, -13181, -14538, -14579, -13524, -11626, -9148, -6319, -3339, -371, 2489, 5151, 7558, 9673, 11473, 12954, 14154, 15106, 15864, 16481, 17006, 17487, 17952, 18431, 18927, 19434, 19927, 20333, 20545, 20377, 19508, 17429, 13439, 8847, 5039, 1462, -2681, -8517, -17064, -23956, -26550, -26492, -24865, -22442, -19719, -16974, -14368, -11955, -9741, -7712, -5839, -4077, -2410, -796, 795, 2409, 4077, 5838, 7712, 9740, 11954, 14368, 16973, 19718, 22442, 24865, 26492, 26550, 23956, 17063, 8516, 2680, -1462, -5040, -8848, -13440, -17429, -19508, -20377, -20546, -20333, -19928, -19434, -18927, -18431, -17953, -17488, -17007, -16482, -15864, -15106, -14154, -12955, -11474, -9674, -7559, -5152, -2490, 370, 3339, 6318, 9148, 11625, 13523, 14579, 14538, 13180, 10420, 6252, 807, -4378, -7976, -10479, -12242, -13513, -14456, -15172, -15729, -16163, -16497, -16752, -16946, -17102, -17238, -17374, -17520, -17669, -17800, -17876, -17850, -17680, -17334, -16796, -16085, -15242, -14322, -13393, -12530, -11797, -11245, -10920, -10834, -11007, -11446, -12149, -13105, -14303, -15721, -17333, -19086, -20921, -22749, -24489, -26060, -27392, -28439, -29192, -29668, -29925, -30019, -30017, -29977, -29941, -29935, -29971, -30051, -30179, -30355, -30587, -30885, -31250, -31672, -32119, -32520, -32758, -32651, -31930, -30251, -27183, -22251, -14831, -4469};