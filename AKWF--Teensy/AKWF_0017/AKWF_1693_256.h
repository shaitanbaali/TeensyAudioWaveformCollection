/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1693 256 samples */
 
const int16_t AKWF_1693_256_DATA [256] = 
{1594, 4014, 6389, 8717, 11064, 13373, 15594, 17727, 19769, 21683, 23388, 24926, 26384, 27679, 28811, 29823, 30679, 31323, 31797, 32214, 32527, 32706, 32767, 32663, 32438, 32106, 31739, 31319, 30758, 30191, 29694, 29249, 28693, 27939, 27102, 26195, 25244, 24204, 23128, 22137, 21183, 20264, 19362, 18386, 17278, 16051, 14797, 13604, 12526, 11613, 10833, 10093, 9301, 8492, 7754, 7078, 6464, 5951, 5554, 5257, 5040, 4884, 4724, 4565, 4462, 4402, 4406, 4458, 4512, 4573, 4670, 4767, 4850, 4919, 4983, 5045, 5099, 5113, 5059, 4914, 4661, 4352, 4079, 3913, 3825, 3739, 3616, 3411, 3108, 2694, 2210, 1643, 937, 165, -579, -1347, -2238, -3226, -4144, -4830, -5299, -5664, -5966, -6195, -6403, -6613, -6766, -6879, -6989, -7036, -6963, -6738, -6348, -5707, -4809, -3762, -2660, -1475, -157, 1256, 2701, 4174, 5616, 6979, 8297, 9593, 10823, 11961, 13025, 14034, 14988, 15907, 16755, 17523, 18193, 18687, 18981, 19074, 19001, 18796, 18488, 18079, 17556, 16938, 16215, 15386, 14488, 13558, 12597, 11637, 10680, 9711, 8738, 7755, 6794, 5826, 4805, 3785, 2843, 1921, 888, -260, -1384, -2354, -3195, -4007, -4819, -5631, -6489, -7382, -8247, -9118, -9999, -10815, -11516, -12097, -12565, -12887, -13069, -13192, -13302, -13329, -13216, -12970, -12639, -12217, -11758, -11326, -10878, -10394, -9909, -9435, -8946, -8467, -8031, -7662, -7368, -7134, -6949, -6840, -6818, -6889, -7033, -7283, -7685, -8275, -9063, -10018, -11111, -12285, -13497, -14698, -15867, -17010, -18123, -19205, -20231, -21209, -22110, -22974, -23859, -24743, -25540, -26271, -27039, -27811, -28457, -28863, -29072, -29178, -29198, -29122, -28987, -28798, -28517, -28165, -27762, -27306, -26749, -26133, -25414, -24498, -23372, -22076, -20717, -19240, -17685, -16115, -14494, -12808, -11066, -9240, -7282, -5153, -2954, -661};