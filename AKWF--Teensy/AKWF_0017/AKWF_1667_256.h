/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1667 256 samples */
 
const int16_t AKWF_1667_256_DATA [256] = 
{8170, 10782, 12270, 13448, 14416, 15247, 15981, 16637, 17235, 17785, 18295, 18771, 19217, 19637, 20034, 20411, 20770, 21112, 21440, 21752, 22053, 22342, 22618, 22886, 23143, 23391, 23629, 23860, 24083, 24299, 24508, 24709, 24904, 25092, 25275, 25452, 25623, 25788, 25949, 26104, 26253, 26399, 26539, 26675, 26806, 26933, 27056, 27173, 27287, 27398, 27503, 27604, 27703, 27797, 27887, 27974, 28056, 28136, 28211, 28283, 28352, 28417, 28479, 28536, 28591, 28642, 28691, 28736, 28776, 28815, 28850, 28882, 28910, 28936, 28958, 28976, 28992, 29003, 28988, 29035, 29016, 18573, 13467, 11606, 9857, 8485, 7333, 6334, 5461, 4689, 4000, 3387, 2838, 2349, 1913, 1530, 1192, 901, 652, 444, 277, 151, -490, 2458, -14787, -26939, -20678, -19842, -18590, -17580, -16709, -15941, -15252, -14622, -14044, -13508, -13005, -12533, -12088, -11666, -11266, -10885, -10518, -10169, -9834, -9511, -9200, -8901, -8611, -8332, -8062, -7799, -7547, -7301, -7062, -6831, -6606, -6386, -6174, -5967, -5766, -5570, -5379, -5193, -5012, -4835, -4664, -4497, -4333, -4174, -4018, -3867, -3720, -3577, -3436, -3300, -3167, -3036, -2910, -2788, -2667, -2551, -2437, -2327, -2219, -2114, -2013, -1914, -1818, -1725, -1633, -1546, -1460, -1378, -1298, -1221, -1146, -1074, -1004, -937, -872, -810, -749, -692, -637, -584, -534, -486, -440, -396, -355, -316, -280, -245, -214, -184, -156, -131, -108, -88, -69, -53, -39, -26, -18, -10, -4, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 222, -1139, 5237, 11274, 4391, 3092, 1683, 786, 242, 16};