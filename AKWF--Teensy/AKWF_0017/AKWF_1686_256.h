/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1686 256 samples */
 
const int16_t AKWF_1686_256_DATA [256] = 
{947, 1586, 3300, 5307, 7347, 9331, 11208, 12952, 14554, 16005, 17299, 18446, 19448, 20308, 21038, 21649, 22149, 22548, 22862, 23098, 23261, 23371, 23431, 23453, 23441, 23405, 23350, 23280, 23200, 23113, 23024, 22930, 22835, 22741, 22640, 22539, 22437, 22327, 22207, 22082, 21946, 21796, 21630, 21450, 21248, 21027, 20787, 20527, 20244, 19939, 19613, 19266, 18899, 18514, 18111, 17690, 17255, 16807, 16347, 15875, 15401, 14916, 14427, 13937, 13443, 12949, 12457, 11966, 11477, 10989, 10506, 10026, 9548, 9070, 8600, 8132, 7661, 7195, 6726, 6260, 5791, 5319, 4845, 4370, 3885, 3400, 2906, 2407, 1904, 1393, 876, 349, -180, -718, -1263, -1811, -2368, -2928, -3491, -4059, -4627, -5201, -5771, -6342, -6912, -7481, -8044, -8605, -9159, -9705, -10247, -10780, -11299, -11810, -12313, -12800, -13276, -13740, -14186, -14619, -15039, -15442, -15828, -16198, -16555, -16893, -17216, -17522, -17815, -18087, -18346, -18592, -18821, -19038, -19240, -19430, -19604, -19770, -19925, -20067, -20203, -20329, -20444, -20553, -20657, -20754, -20842, -20927, -21010, -21083, -21156, -21227, -21292, -21354, -21414, -21472, -21524, -21575, -21627, -21669, -21709, -21749, -21785, -21813, -21837, -21862, -21873, -21881, -21886, -21881, -21868, -21848, -21823, -21784, -21739, -21687, -21619, -21544, -21461, -21364, -21255, -21138, -21011, -20867, -20715, -20555, -20378, -20191, -19998, -19790, -19569, -19341, -19105, -18853, -18594, -18329, -18048, -17761, -17468, -17169, -16858, -16521, -16479, -16810, -17228, -17745, -18278, -18873, -19644, -20562, -21581, -22648, -23721, -24750, -25714, -26615, -27461, -28249, -28983, -29674, -30294, -30856, -31352, -31778, -32129, -32396, -32606, -32734, -32766, -32722, -32573, -32311, -31947, -31482, -30920, -30230, -29460, -28593, -27621, -26566, -25432, -24208, -22910, -21558, -20145, -18682, -17192, -15678, -14155, -12617, -11098, -9603, -8145, -6728, -5379, -4029};