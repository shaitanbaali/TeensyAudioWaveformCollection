/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1627 256 samples */
 
const int16_t AKWF_1627_256_DATA [256] = 
{2516, 5636, 8586, 11413, 14126, 16672, 19047, 21202, 23146, 24860, 26340, 27234, 29964, 7053, 924, 5971, 8560, 11411, 14123, 16644, 19006, 21177, 23114, 24826, 26293, 27518, 28499, 29237, 29737, 30004, 30049, 29895, 29539, 29011, 28326, 27498, 26547, 25489, 24346, 23127, 21854, 20559, 19231, 17887, 16546, 15227, 13931, 12664, 11433, 10254, 9115, 8037, 7022, 6063, 5160, 4320, 3543, 2839, 2181, 1587, 1051, 568, 143, -230, -560, -844, -1087, -1289, -1458, -1593, -1701, -1783, -1846, -1891, -1922, -1946, -1961, -1973, -1991, -2013, -2044, -2090, -2153, -2234, -2340, -2473, -2635, -2831, -3067, -3340, -3654, -4016, -4423, -4882, -5388, -5946, -6564, -7233, -7962, -8750, -9585, -10471, -11421, -12416, -13462, -14548, -15666, -16823, -18009, -19204, -20418, -21616, -22804, -23973, -25105, -26180, -27184, -28100, -28926, -29637, -30212, -30644, -30910, -31003, -30907, -30611, -30109, -29397, -28467, -27312, -25939, -24356, -22582, -20618, -18457, -16158, -13710, -11141, -8511, -5817, -3064, -319, 2413, 5071, 7647, 10140, 12499, 14696, 16739, 18581, 20219, 21660, 22892, 23899, 24685, 25257, 25623, 25789, 25765, 25563, 25182, 24694, 24085, 23344, 22498, 21574, 20571, 19503, 18391, 17252, 16095, 14940, 13775, 12636, 11508, 10417, 9365, 8359, 7413, 6516, 5663, 4867, 4117, 3414, 2763, 2166, 1614, 1117, 665, 258, -103, -423, -700, -939, -1146, -1320, -1462, -1577, -1666, -1737, -1789, -1826, -1853, -1871, -1882, -1891, -1904, -1922, -1949, -1988, -2044, -2117, -2215, -2338, -2488, -2674, -2895, -3155, -3457, -3801, -4194, -4638, -5136, -5688, -6298, -6956, -7682, -8469, -9316, -10216, -11176, -12197, -13272, -14397, -15571, -16778, -18021, -19289, -20584, -21885, -23172, -24435, -25678, -26877, -28008, -29064, -30015, -30852, -31559, -32115, -32502, -32704, -32710, -32045, -34063, -14700};