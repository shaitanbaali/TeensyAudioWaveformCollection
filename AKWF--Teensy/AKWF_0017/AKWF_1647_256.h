/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1647 256 samples */
 
const int16_t AKWF_1647_256_DATA [256] = 
{662, 2514, 4375, 6182, 7887, 9492, 10983, 12308, 13430, 14369, 15239, 16201, 17366, 18763, 20350, 22041, 23772, 25508, 27195, 28743, 30057, 31052, 31714, 32105, 32320, 32457, 32577, 32688, 32762, 32745, 32625, 32410, 32086, 31616, 30959, 30092, 29050, 27878, 26621, 25315, 23981, 22644, 21318, 19993, 18670, 17351, 16032, 14692, 13321, 11970, 10724, 9637, 8685, 7789, 6878, 5942, 5050, 4293, 3693, 3182, 2659, 2070, 1464, 892, 330, -323, -1159, -2163, -3238, -4306, -5350, -6403, -7505, -8662, -9840, -11017, -12223, -13507, -14899, -16368, -17863, -19335, -20757, -22118, -23402, -24583, -25648, -26598, -27452, -28243, -29000, -29719, -30379, -30958, -31442, -31818, -32060, -32139, -32044, -31781, -31359, -30791, -30093, -29289, -28394, -27407, -26310, -25072, -23699, -22219, -20642, -18976, -17227, -15397, -13520, -11631, -9767, -7971, -6244, -4534, -2796, -1009, 804, 2576, 4279, 5923, 7499, 8991, 10374, 11624, 12761, 13803, 14738, 15550, 16208, 16712, 17097, 17379, 17546, 17587, 17527, 17404, 17243, 17034, 16761, 16430, 16054, 15632, 15122, 14494, 13759, 12955, 12101, 11204, 10254, 9272, 8300, 7378, 6511, 5674, 4854, 4076, 3361, 2708, 2090, 1484, 911, 442, 107, -134, -353, -575, -752, -833, -830, -808, -825, -883, -927, -920, -872, -837, -859, -944, -1072, -1215, -1379, -1582, -1833, -2126, -2458, -2837, -3273, -3758, -4271, -4787, -5289, -5768, -6231, -6693, -7172, -7671, -8173, -8662, -9133, -9592, -10045, -10473, -10858, -11200, -11511, -11802, -12070, -12306, -12502, -12660, -12787, -12883, -12950, -12984, -12978, -12919, -12808, -12651, -12456, -12224, -11946, -11633, -11311, -11004, -10719, -10444, -10169, -9896, -9620, -9337, -9055, -8787, -8534, -8295, -8070, -7863, -7680, -7521, -7362, -7178, -6956, -6698, -6410, -6075, -5660, -5128, -4436, -3548, -2415, -962};