/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1633 256 samples */
 
const int16_t AKWF_1633_256_DATA [256] = 
{623, 1352, 1754, 1884, 1943, 2016, 2147, 2469, 2986, 3737, 4540, 5260, 5848, 6311, 6659, 7006, 7553, 8337, 9238, 10100, 10849, 11429, 11840, 12186, 12632, 13322, 14291, 15314, 16174, 16715, 16978, 17108, 17195, 17340, 17569, 17856, 18101, 18352, 18767, 19419, 20264, 21105, 21728, 22025, 22084, 22131, 22488, 23341, 24585, 25871, 26794, 27185, 27246, 27204, 27175, 27195, 27305, 27463, 27516, 27305, 26936, 26722, 26788, 27008, 27157, 27164, 27200, 27445, 27878, 28384, 28954, 29625, 30259, 30677, 30966, 31303, 31626, 31548, 30704, 29353, 27918, 26689, 25631, 24753, 24097, 23615, 23056, 22310, 21559, 21091, 20856, 20582, 20021, 19174, 18221, 17265, 16228, 15137, 14068, 12940, 11432, 9364, 6905, 4488, 2460, 881, -267, -1125, -1863, -2763, -4080, -5704, -7148, -8097, -8666, -9156, -9719, -10511, -11755, -13521, -15621, -17580, -19183, -20545, -21897, -23385, -24941, -26512, -28105, -29659, -30974, -31888, -32409, -32709, -32763, -32557, -32268, -32159, -32234, -32362, -32364, -32207, -32057, -32022, -32124, -32280, -32387, -32303, -31917, -31320, -30807, -30553, -30429, -30212, -29642, -28738, -27752, -26894, -26364, -26136, -26131, -26134, -25741, -24709, -23206, -21632, -20311, -19293, -18383, -17371, -16108, -14537, -12818, -11195, -9888, -8940, -8198, -7405, -6462, -5455, -4542, -3810, -3249, -2558, -2545, 2193, 6599, 5576, 5620, 5454, 5181, 4652, 3833, 2701, 1477, 513, -140, -648, -1349, -2237, -3134, -3924, -4642, -5291, -5752, -5819, -5507, -5113, -4831, -4690, -4776, -5289, -6171, -7034, -7468, -7445, -7347, -7621, -8406, -9603, -10816, -11677, -11775, -11040, -9883, -8914, -8472, -8616, -9096, -9532, -9709, -9505, -9099, -8731, -8473, -8359, -8361, -8424, -8522, -8596, -8653, -8705, -8591, -8211, -7505, -6489, -5274, -4032, -2930, -2125, -1740, -1691, -1736, -1578, -1046, -242};