/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1671 256 samples */
 
const int16_t AKWF_1671_256_DATA [256] = 
{10680, 14039, 15860, 17197, 18173, 18874, 19222, 20113, 16674, 10697, 9471, 8210, 7263, 6476, 5797, 5198, 4666, 4184, 3747, 3347, 2982, 2646, 2338, 2054, 1793, 1554, 1334, 1135, 953, 788, 639, 508, 392, 292, 207, 136, 81, 40, 13, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -146, 608, -3014, -13144, -15487, -17457, -18971, -20229, -21310, -22266, -23124, -23899, -24610, -25265, -25869, -26433, -26957, -27444, -27902, -28331, -28732, -29109, -29462, -29792, -30103, -30392, -30661, -30913, -31147, -31363, -31563, -31745, -31912, -32064, -32201, -32321, -32428, -32519, -32596, -32659, -32707, -32554, -33544, -28726, -17048, -14475, -12176, -10433, -9000, -7781, -6717, -5782, -4953, -4212, -3553, -2963, -2436, -1970, -1560, -1200, -892, -632, -417, -248, -124, -42, -4, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 141, -737, 2989, 18434, 7903, 4893, 3021, 1694, 797, 241, 32, 434, 591, 639, 676, 696, 706, 708, 705, 695, 682, 665, 645, 622, 596, 568, 539, 508, 474, 440, 405, 367, 330, 291, 252, 212, 170, 130, 89, 46, 7, 3, 1};