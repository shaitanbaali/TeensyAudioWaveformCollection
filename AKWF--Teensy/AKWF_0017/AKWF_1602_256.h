/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1602 256 samples */
 
const int16_t AKWF_1602_256_DATA [256] = 
{1456, 4522, 7584, 10736, 13449, 15600, 17745, 19844, 21713, 23089, 24292, 25490, 26659, 27794, 28890, 29919, 30829, 31519, 31890, 32116, 32316, 32480, 32611, 32704, 32757, 32766, 32728, 32645, 31954, 30788, 29672, 28590, 27509, 26407, 25249, 24018, 23243, 23054, 22888, 22746, 22625, 22520, 22425, 22339, 22258, 22183, 22108, 22033, 21959, 21883, 21806, 21727, 21647, 21561, 21494, 21288, 20623, 19776, 18943, 18158, 17991, 18309, 18580, 18814, 19035, 19264, 19526, 19828, 19644, 18833, 17971, 17092, 16387, 16136, 16019, 15879, 15737, 15593, 15444, 15292, 15135, 14971, 14801, 14624, 14434, 14234, 14019, 13782, 13525, 13240, 12920, 12572, 11629, 10221, 8877, 7578, 6293, 4995, 3653, 2247, 1309, 967, 655, 379, 134, -84, -280, -458, -619, -757, -993, -1499, -2178, -2924, -3686, -4431, -5148, -5820, -6461, -6911, -6842, -6521, -6137, -5730, -4744, -3309, -1951, -645, 644, 1950, 3308, 4743, 5729, 6136, 6520, 6841, 6911, 6460, 5819, 5147, 4431, 3685, 2923, 2177, 1498, 992, 757, 618, 457, 279, 83, -135, -380, -656, -967, -1309, -2247, -3654, -4996, -6294, -7579, -8878, -10222, -11630, -12573, -12921, -13240, -13526, -13783, -14019, -14235, -14435, -14624, -14802, -14971, -15135, -15292, -15445, -15593, -15738, -15880, -16019, -16136, -16387, -17092, -17971, -18834, -19644, -19829, -19526, -19265, -19035, -18815, -18580, -18310, -17991, -18158, -18944, -19776, -20623, -21288, -21495, -21561, -21647, -21728, -21806, -21884, -21960, -22034, -22108, -22183, -22259, -22339, -22425, -22520, -22625, -22746, -22888, -23054, -23243, -24018, -25250, -26407, -27509, -28590, -29672, -30788, -31955, -32645, -32728, -32766, -32757, -32704, -32611, -32480, -32316, -32116, -31890, -31519, -30829, -29919, -28890, -27794, -26659, -25491, -24292, -23089, -21714, -19844, -17746, -15601, -13450, -10737, -7585, -4523, -1457};