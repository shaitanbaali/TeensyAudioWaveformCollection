/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1632 256 samples */
 
const int16_t AKWF_1632_256_DATA [256] = 
{430, 1392, 2384, 3356, 4232, 4995, 5683, 6311, 6962, 7655, 8394, 9056, 9574, 10018, 10444, 10789, 11067, 11205, 11252, 11239, 11201, 11275, 11448, 11679, 11888, 12037, 12113, 12083, 11919, 11610, 11253, 10946, 10699, 10477, 10318, 10250, 10367, 10650, 11007, 11355, 11593, 11723, 11896, 12231, 12786, 13384, 13885, 14332, 14854, 15459, 16106, 16769, 17305, 17640, 17828, 18123, 18659, 19285, 19851, 20319, 20765, 21150, 21426, 21629, 21720, 21454, 20730, 19720, 18633, 17414, 16021, 14566, 13141, 11675, 10100, 8492, 6922, 5215, 3219, 877, -1718, -4542, -7503, -10374, -12979, -15296, -17426, -19360, -21075, -22596, -24037, -25477, -26958, -28466, -29934, -31196, -32109, -32618, -32774, -32697, -32442, -32040, -31468, -30738, -29855, -28855, -27718, -26371, -24842, -23141, -21264, -19201, -17061, -14878, -12669, -10455, -8264, -6137, -3976, -1825, 171, 1967, 3645, 5243, 6832, 8460, 10146, 11754, 13118, 14198, 15089, 15848, 16400, 16712, 16801, 16792, 16721, 16666, 16675, 16605, 16174, 15293, 14065, 12746, 11538, 10442, 9459, 8512, 7491, 6398, 5270, 4040, 2681, 1113, -600, -2330, -3950, -5375, -6553, -7613, -8682, -9737, -10670, -11439, -12011, -12399, -12662, -12916, -13201, -13561, -13972, -14440, -14883, -15253, -15474, -15549, -15495, -15252, -14783, -14168, -13462, -12754, -12066, -11415, -10738, -10029, -9291, -8560, -7889, -7260, -6610, -5838, -4981, -4056, -3127, -2199, -1262, -316, 589, 1493, 2367, 3194, 3907, 4644, 5433, 6216, 6941, 7718, 8547, 9248, 9706, 9974, 10159, 10300, 10458, 10663, 10937, 11135, 11249, 11467, 11887, 12272, 12372, 11792, 13726, -2207, -15213, -13549, -14298, -14632, -14823, -14860, -14947, -15227, -15508, -15639, -15467, -15030, -14322, -13474, -12609, -11829, -11052, -10210, -9366, -8611, -7929, -7251, -6550, -5801, -4982, -4109, -3241, -2363, -1441, -480};