/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1673 256 samples */
 
const int16_t AKWF_1673_256_DATA [256] = 
{30402, 24248, 21584, 20213, 19054, 18099, 17275, 16548, 15892, 15293, 14742, 14229, 13748, 13298, 12872, 12467, 12083, 11716, 11365, 11029, 10705, 10394, 10094, 9804, 9524, 9254, 8992, 8737, 8491, 8251, 8018, 7792, 7572, 7357, 7148, 6944, 6746, 6553, 6363, 6179, 5999, 5823, 5652, 5483, 5320, 5160, 5003, 4849, 4700, 4553, 4410, 4270, 4134, 3999, 3868, 3740, 3615, 3492, 3372, 3255, 3140, 3028, 2918, 2811, 2706, 2604, 2504, 2405, 2311, 2217, 2126, 2037, 1951, 1866, 1784, 1704, 1626, 1550, 1475, 1403, 1332, 1265, 1198, 1133, 1071, 1010, 952, 894, 840, 786, 735, 686, 638, 592, 547, 505, 465, 426, 388, 353, 319, 287, 257, 228, 201, 176, 153, 131, 111, 92, 76, 60, 48, 36, 25, 17, 10, 4, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -118, 491, -1770, -27423, -19941, -15670, -13801, -12147, -10797, -9641, -8632, -7734, -6926, -6196, -5531, -4920, -4364, -3851, -3380, -2949, -2552, -2188, -1859, -1558, -1286, -1044, -827, -636, -472, -333, -219, -128, -62, -19, -1};