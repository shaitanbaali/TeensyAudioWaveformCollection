/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1643 256 samples */
 
const int16_t AKWF_1643_256_DATA [256] = 
{725, 2314, 3695, 4939, 6071, 7135, 8189, 9290, 10508, 11882, 13414, 15057, 16699, 18179, 19349, 20119, 20485, 20532, 20380, 20141, 19872, 19598, 19322, 19063, 18870, 18786, 18850, 19075, 19456, 19985, 20656, 21468, 22416, 23491, 24681, 25963, 27303, 28658, 29960, 31113, 32024, 32596, 32768, 32530, 31933, 31081, 30098, 29097, 28144, 27270, 26487, 25810, 25261, 24862, 24629, 24554, 24614, 24778, 24996, 25221, 25398, 25471, 25389, 25117, 24628, 23919, 22991, 21847, 20509, 18986, 17300, 15487, 13574, 11616, 9678, 7809, 6076, 4542, 3242, 2204, 1444, 949, 710, 704, 913, 1318, 1898, 2642, 3530, 4541, 5664, 6877, 8163, 9517, 10918, 12356, 13829, 15328, 16847, 18379, 19894, 21352, 22685, 23791, 24563, 24910, 24783, 24228, 23389, 22481, 21700, 21172, 20899, 20793, 20735, 20627, 20419, 20105, 19696, 19193, 18580, 17818, 16874, 15741, 14431, 12964, 11369, 9656, 7831, 5907, 3888, 1776, -422, -2708, -5085, -7529, -10019, -12507, -14926, -17212, -19294, -21107, -22618, -23802, -24651, -25183, -25408, -25338, -24993, -24386, -23550, -22506, -21297, -19976, -18592, -17216, -15910, -14731, -13728, -12937, -12366, -12021, -11896, -11977, -12255, -12704, -13297, -13989, -14727, -15439, -16043, -16464, -16634, -16508, -16084, -15395, -14512, -13514, -12489, -11507, -10607, -9817, -9153, -8637, -8296, -8150, -8204, -8448, -8866, -9450, -10189, -11077, -12112, -13278, -14566, -15952, -17396, -18844, -20209, -21382, -22253, -22732, -22781, -22444, -21856, -21210, -20700, -20443, -20441, -20612, -20848, -21079, -21303, -21545, -21832, -22159, -22487, -22788, -23054, -23295, -23546, -23830, -24163, -24550, -25000, -25512, -26094, -26743, -27453, -28212, -29004, -29802, -30580, -31302, -31914, -32376, -32639, -32664, -32423, -31909, -31122, -30067, -28764, -27232, -25482, -23541, -21435, -19183, -16825, -14408, -11962, -9544, -7203, -4975, -2900, -962};