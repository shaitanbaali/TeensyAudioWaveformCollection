/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1681 256 samples */
 
const int16_t AKWF_1681_256_DATA [256] = 
{671, 2466, 3962, 5304, 6536, 7695, 8801, 9865, 10896, 11903, 12882, 13839, 14770, 15668, 16524, 17317, 18009, 18531, 18800, 18841, 18886, 19136, 19585, 20144, 20751, 21369, 21971, 22549, 23086, 23571, 23989, 24324, 24554, 24650, 24581, 24316, 23853, 23226, 22567, 22078, 21908, 21970, 22037, 22032, 21995, 21960, 21940, 21932, 21930, 21930, 21924, 21907, 21875, 21824, 21751, 21653, 21517, 21333, 21073, 20693, 20114, 19272, 18268, 17362, 16688, 16199, 15817, 15490, 15196, 14927, 14676, 14450, 14259, 14113, 14035, 14050, 14194, 14511, 15050, 15846, 16904, 18209, 19718, 21285, 22626, 23521, 24007, 24206, 24217, 24101, 23904, 23648, 23350, 23025, 22680, 22318, 21942, 21556, 21151, 20726, 20263, 19732, 19075, 18212, 17112, 15945, 14964, 14226, 13652, 13173, 12738, 12326, 11920, 11505, 11072, 10609, 10098, 9520, 8851, 8055, 7105, 5982, 4707, 3379, 2180, 1295, 734, 276, -221, -741, -1237, -1695, -2112, -2495, -2852, -3188, -3510, -3823, -4131, -4441, -4759, -5088, -5444, -5848, -6339, -6986, -7870, -8963, -10037, -10887, -11513, -12004, -12417, -12784, -13122, -13434, -13720, -13974, -14182, -14332, -14399, -14349, -14142, -13728, -13075, -12157, -10984, -9599, -8087, -6706, -5730, -5199, -5000, -5023, -5195, -5469, -5811, -6207, -6637, -7094, -7574, -8070, -8581, -9111, -9663, -10247, -10890, -11635, -12556, -13725, -15035, -16228, -17172, -17915, -18539, -19100, -19622, -20127, -20628, -21129, -21646, -22194, -22786, -23447, -24207, -25092, -26130, -27316, -28574, -29755, -30649, -31164, -31475, -31770, -32078, -32348, -32553, -32686, -32755, -32763, -32716, -32623, -32486, -32309, -32097, -31857, -31592, -31314, -31042, -30804, -30660, -30693, -30933, -31210, -31272, -31060, -30648, -30111, -29483, -28790, -28040, -27230, -26359, -25423, -24401, -23277, -22022, -20596, -18959, -17068, -14892, -12439, -9739, -6847, -3975, -1386};