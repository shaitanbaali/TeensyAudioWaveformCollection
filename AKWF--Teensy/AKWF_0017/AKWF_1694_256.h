/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1694 256 samples */
 
const int16_t AKWF_1694_256_DATA [256] = 
{902, 3009, 5092, 7182, 9257, 11299, 13296, 15212, 17044, 18773, 20375, 21850, 23188, 24380, 25433, 26343, 27115, 27763, 28292, 28711, 29036, 29276, 29440, 29541, 29585, 29580, 29531, 29438, 29305, 29125, 28896, 28609, 28251, 27803, 27248, 26550, 25683, 24600, 23241, 21548, 19532, 17271, 14784, 12076, 9191, 6193, 3126, 67, -2914, -5770, -8434, -10855, -13007, -14857, -16384, -17592, -18475, -19046, -19324, -19329, -19088, -18623, -17969, -17143, -16187, -15031, -13788, -12531, -11194, -9809, -8392, -6964, -5532, -4108, -2708, -1331, 13, 1311, 2566, 3772, 4921, 6016, 7050, 8020, 8935, 9787, 10578, 11315, 11997, 12630, 13220, 13769, 14285, 14778, 15249, 15709, 16169, 16633, 17111, 17612, 18142, 18710, 19324, 19985, 20701, 21468, 22284, 23139, 24018, 24892, 25730, 26480, 27071, 27420, 27418, 26932, 25790, 23871, 21521, 18921, 16044, 12919, 9615, 6239, 2897, -332, -3356, -6123, -8594, -10739, -12552, -14041, -15213, -16095, -16710, -17088, -17259, -17251, -17094, -16816, -16439, -15990, -15484, -14941, -14378, -13802, -13229, -12662, -12112, -11583, -11078, -10598, -10144, -9717, -9313, -8933, -8571, -8224, -7889, -7561, -7233, -6904, -6563, -6207, -5834, -5434, -5003, -4536, -4026, -3469, -2859, -2189, -1451, -640, 250, 1228, 2301, 3476, 4754, 6134, 7618, 9193, 10839, 12537, 14248, 15923, 17510, 18934, 20113, 20959, 21370, 21246, 20470, 19066, 17289, 15204, 12794, 10096, 7178, 4133, 1034, -2049, -5041, -7912, -10625, -13146, -15477, -17609, -19540, -21285, -22849, -24242, -25486, -26586, -27558, -28418, -29174, -29836, -30417, -30922, -31359, -31733, -32047, -32306, -32506, -32652, -32741, -32770, -32735, -32631, -32453, -32197, -31857, -31424, -30900, -30274, -29548, -28722, -27797, -26772, -25658, -24453, -23168, -21813, -20386, -18896, -17355, -15755, -14103, -12401, -10646, -8842, -6986, -5078, -3127, -1086};