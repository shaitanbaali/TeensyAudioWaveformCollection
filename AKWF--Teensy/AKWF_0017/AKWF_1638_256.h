/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_1638 256 samples */
 
const int16_t AKWF_1638_256_DATA [256] = 
{1490, 3859, 5956, 7867, 9599, 11194, 12724, 14130, 15404, 16563, 17610, 18565, 19421, 20265, 21271, 22238, 23104, 23892, 24608, 25254, 25842, 26373, 26854, 27291, 27685, 28040, 28364, 28655, 28915, 29176, 29491, 29791, 30058, 30300, 30518, 30716, 30892, 31051, 31195, 31322, 31437, 31539, 31630, 31712, 31784, 31853, 31989, 32150, 32290, 32416, 32530, 32619, 32737, 32629, 30404, 27287, 24588, 22115, 19860, 17819, 15951, 14336, 13586, 13249, 12898, 12587, 12306, 12049, 11810, 11631, 11774, 12040, 12263, 12469, 12655, 12824, 12974, 13121, 13331, 13553, 13750, 13929, 14092, 14238, 14369, 14510, 14792, 15111, 15391, 15645, 15875, 16084, 16266, 16485, 16997, 17574, 18083, 18544, 18963, 19347, 19683, 20039, 20641, 21279, 21842, 22358, 22823, 23245, 23625, 23999, 24496, 24997, 25442, 25848, 26214, 26546, 26843, 27138, 27521, 27905, 28246, 28557, 28836, 29055, 29399, 28765, 24441, 19529, 15219, 11278, 7697, 4438, 1487, -1204, -3693, -5958, -8016, -9888, -11581, -13121, -14519, -15795, -16997, -18097, -19090, -19992, -20812, -21553, -22227, -22837, -23389, -23890, -24343, -24754, -25127, -25461, -25767, -26037, -26210, -26321, -26425, -26518, -26600, -26674, -26740, -26798, -26849, -26893, -26933, -26968, -26998, -27023, -27046, -27065, -27081, -27094, -27103, -27110, -27116, -27120, -27122, -27121, -27121, -27119, -27115, -27110, -27104, -27098, -27091, -27078, -27029, -26964, -26905, -26850, -26799, -26752, -26708, -26662, -26580, -26488, -26404, -26327, -26256, -26189, -26127, -26064, -25968, -25864, -25768, -25680, -25599, -25525, -25456, -25386, -25282, -25172, -25073, -24980, -24895, -24816, -24744, -24670, -24563, -24451, -24348, -24254, -24168, -24087, -24015, -23940, -23830, -23717, -23615, -23521, -23434, -23354, -23281, -23204, -23094, -22981, -22879, -22785, -22697, -22603, -22579, -22143, -19970, -17464, -15273, -13266, -11439, -9772, -8305, -6654, -3884, -984};