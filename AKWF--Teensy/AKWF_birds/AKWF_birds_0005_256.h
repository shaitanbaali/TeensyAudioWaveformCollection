/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0005 256 samples */
 
const int16_t AKWF_birds_0005_256_DATA [256] = 
{560, 2216, 4458, 7145, 10083, 13074, 15948, 18485, 20539, 22067, 23129, 23806, 24183, 24359, 24447, 24550, 24760, 25075, 25432, 25826, 26243, 26670, 27085, 27472, 27813, 28116, 28401, 28669, 28918, 29152, 29367, 29563, 29744, 29907, 30055, 30185, 30296, 30390, 30466, 30524, 30565, 30586, 30589, 30575, 30542, 30490, 30419, 30329, 30220, 30090, 29942, 29775, 29589, 29385, 29164, 28923, 28666, 28392, 28100, 27794, 27469, 27127, 26770, 26399, 26011, 25610, 25193, 24760, 24315, 23857, 23381, 22893, 22391, 21873, 21348, 20807, 20252, 19686, 19105, 18513, 17912, 17294, 16667, 16029, 15377, 14721, 14055, 13376, 12689, 11996, 11292, 10586, 9869, 9145, 8416, 7681, 6944, 6203, 5455, 4703, 3948, 3189, 2432, 1668, 901, 131, -639, -1410, -2182, -2954, -3730, -4506, -5280, -6051, -6824, -7594, -8364, -9131, -9890, -10645, -11398, -12142, -12882, -13611, -14336, -15053, -15760, -16459, -17144, -17818, -18484, -19138, -19778, -20408, -21022, -21627, -22217, -22797, -23361, -23911, -24445, -24969, -25477, -25972, -26452, -26914, -27365, -27798, -28218, -28621, -29006, -29375, -29726, -30060, -30376, -30674, -30951, -31212, -31453, -31674, -31876, -32056, -32216, -32357, -32477, -32578, -32659, -32723, -32763, -32768, -32767, -32769, -32751, -32698, -32628, -32540, -32433, -32307, -32164, -32002, -31820, -31618, -31398, -31157, -30894, -30611, -30306, -29979, -29634, -29267, -28879, -28471, -28042, -27594, -27128, -26639, -26130, -25598, -25040, -24462, -23856, -23224, -22570, -21893, -21193, -20479, -19737, -18979, -18205, -17411, -16606, -15790, -14960, -14127, -13294, -12459, -11637, -10817, -10003, -9202, -8415, -7646, -6900, -6174, -5474, -4803, -4161, -3547, -2965, -2419, -1907, -1435, -1000, -603, -247, 70, 352, 596, 808, 987, 1135, 1276, 1427, 1568, 1678, 1732, 1710, 1596, 1386, 1021, 484, -112, -639, -961, -946, -436};