/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0008 256 samples */
 
const int16_t AKWF_birds_0008_256_DATA [256] = 
{559, 3313, 6842, 10002, 12023, 13035, 13573, 14209, 15091, 16081, 17080, 18013, 18913, 19790, 20635, 21444, 22212, 22931, 23607, 24231, 24809, 25341, 25827, 26272, 26684, 27065, 27419, 27752, 28067, 28377, 28677, 28969, 29255, 29533, 29800, 30059, 30304, 30535, 30758, 30969, 31174, 31372, 31563, 31746, 31922, 32092, 32261, 32433, 32595, 32724, 32770, 32766, 32768, 32767, 32766, 32767, 32767, 32766, 32754, 32699, 32556, 32291, 31913, 31455, 30948, 30402, 29808, 29154, 28441, 27670, 26840, 25963, 25026, 24032, 22985, 21878, 20718, 19515, 18255, 16952, 15620, 14259, 12893, 11522, 10147, 8789, 7461, 6157, 4893, 3658, 2457, 1294, 171, -914, -1958, -2957, -3905, -4793, -5617, -6386, -7086, -7719, -8282, -8765, -9175, -9514, -9779, -9978, -10112, -10190, -10224, -10215, -10172, -10106, -10027, -9938, -9841, -9737, -9630, -9520, -9409, -9293, -9177, -9065, -8966, -8882, -8817, -8777, -8764, -8783, -8836, -8925, -9052, -9220, -9426, -9668, -9946, -10257, -10598, -10966, -11361, -11775, -12204, -12648, -13104, -13573, -14050, -14537, -15037, -15545, -16062, -16587, -17111, -17638, -18163, -18683, -19192, -19690, -20175, -20647, -21105, -21547, -21973, -22380, -22770, -23142, -23493, -23822, -24123, -24399, -24648, -24869, -25060, -25220, -25348, -25444, -25507, -25540, -25543, -25517, -25464, -25387, -25287, -25167, -25031, -24882, -24720, -24546, -24359, -24160, -23951, -23731, -23498, -23256, -23006, -22752, -22500, -22247, -21997, -21754, -21520, -21294, -21079, -20877, -20685, -20504, -20333, -20167, -20007, -19849, -19691, -19531, -19365, -19188, -18996, -18791, -18574, -18352, -18117, -17874, -17620, -17355, -17078, -16781, -16451, -16086, -15685, -15239, -14752, -14214, -13618, -12961, -12238, -11457, -10629, -9750, -8835, -7903, -6968, -6050, -5157, -4303, -3511, -2787, -2139, -1580, -1107, -722, -419, -174, 72, 237, 203, -182, -750, -679};