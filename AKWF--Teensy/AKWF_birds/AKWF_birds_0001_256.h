/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0001 256 samples */
 
const int16_t AKWF_birds_0001_256_DATA [256] = 
{2428, 9121, 16032, 21265, 24097, 25185, 25569, 26249, 27326, 28525, 29669, 30596, 31365, 31988, 32461, 32740, 32771, 32760, 32517, 32017, 31318, 30425, 29354, 28112, 26734, 25239, 23649, 21993, 20299, 18596, 16926, 15282, 13676, 12114, 10601, 9147, 7740, 6364, 5026, 3741, 2519, 1380, 320, -654, -1539, -2330, -3024, -3602, -4053, -4369, -4557, -4621, -4572, -4417, -4182, -3902, -3610, -3327, -3078, -2898, -2814, -2838, -2985, -3265, -3690, -4255, -4946, -5738, -6621, -7590, -8622, -9695, -10804, -11916, -13014, -14071, -15077, -16033, -16948, -17820, -18646, -19429, -20174, -20877, -21521, -22082, -22528, -22842, -23017, -23033, -22882, -22556, -22026, -21259, -20243, -18999, -17524, -15850, -13997, -12000, -9936, -7868, -5816, -3849, -2018, -371, 1047, 2221, 3100, 3651, 3885, 3826, 3519, 2989, 2274, 1437, 550, -352, -1213, -1965, -2544, -2922, -3067, -2947, -2539, -1843, -890, 269, 1618, 3123, 4741, 6432, 8148, 9853, 11507, 13037, 14425, 15658, 16716, 17603, 18306, 18841, 19237, 19510, 19660, 19691, 19600, 19390, 19069, 18663, 18184, 17639, 17020, 16297, 15453, 14511, 13460, 12307, 11063, 9756, 8443, 7186, 6023, 4986, 4122, 3467, 3045, 2887, 3058, 3600, 4492, 5720, 7242, 9008, 10978, 13050, 15099, 17078, 18901, 20463, 21675, 22477, 22827, 22666, 21949, 20673, 18869, 16624, 13968, 10950, 7656, 4169, 570, -3083, -6703, -10182, -13443, -16472, -19224, -21706, -23884, -25777, -27422, -28860, -30093, -31108, -31883, -32405, -32693, -32771, -32758, -32641, -32387, -31958, -31311, -30443, -29371, -28111, -26676, -25096, -23394, -21626, -19841, -18059, -16328, -14691, -13168, -11785, -10574, -9554, -8739, -8114, -7661, -7361, -7200, -7155, -7194, -7289, -7422, -7559, -7662, -7709, -7689, -7587, -7394, -7102, -6720, -6269, -5742, -5049, -4338, -3845, -3840, -4300, -4175, -2044};