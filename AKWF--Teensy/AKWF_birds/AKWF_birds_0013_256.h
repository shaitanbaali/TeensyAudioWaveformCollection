/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0013 256 samples */
 
const int16_t AKWF_birds_0013_256_DATA [256] = 
{1003, 3759, 6690, 9701, 12657, 15469, 18075, 20436, 22553, 24432, 26079, 27517, 28761, 29823, 30720, 31452, 32024, 32438, 32687, 32768, 32680, 32420, 31990, 31389, 30629, 29719, 28669, 27500, 26229, 24870, 23448, 21977, 20471, 18947, 17417, 15886, 14371, 12873, 11399, 9963, 8563, 7210, 5915, 4680, 3512, 2427, 1428, 520, -281, -979, -1567, -2044, -2415, -2685, -2865, -2971, -3017, -3024, -3011, -3000, -3012, -3067, -3182, -3370, -3645, -4011, -4473, -5034, -5683, -6420, -7235, -8112, -9043, -10014, -11007, -12016, -13027, -14027, -15015, -15982, -16921, -17829, -18699, -19523, -20292, -20998, -21628, -22168, -22603, -22919, -23097, -23123, -22981, -22658, -22143, -21432, -20526, -19432, -18164, -16738, -15191, -13547, -11843, -10124, -8426, -6793, -5268, -3881, -2665, -1647, -839, -251, 119, 286, 267, 90, -209, -596, -1026, -1457, -1844, -2148, -2333, -2371, -2235, -1913, -1400, -696, 190, 1240, 2431, 3742, 5134, 6578, 8044, 9493, 10901, 12241, 13489, 14632, 15659, 16558, 17330, 17975, 18492, 18887, 19164, 19329, 19386, 19341, 19196, 18953, 18611, 18173, 17632, 16994, 16261, 15434, 14533, 13569, 12562, 11541, 10534, 9571, 8692, 7928, 7317, 6892, 6683, 6712, 6993, 7533, 8322, 9337, 10556, 11931, 13406, 14932, 16440, 17856, 19121, 20164, 20926, 21359, 21422, 21089, 20343, 19187, 17636, 15710, 13455, 10913, 8134, 5187, 2125, -993, -4100, -7154, -10114, -12930, -15590, -18071, -20352, -22437, -24315, -25981, -27450, -28719, -29792, -30685, -31396, -31926, -32280, -32454, -32441, -32243, -31859, -31290, -30541, -29628, -28567, -27372, -26074, -24699, -23274, -21834, -20407, -19020, -17705, -16478, -15358, -14359, -13484, -12736, -12113, -11603, -11193, -10869, -10614, -10404, -10224, -10051, -9868, -9662, -9417, -9122, -8777, -8390, -7985, -7575, -7136, -6603, -5863, -4796, -3314, -1313};