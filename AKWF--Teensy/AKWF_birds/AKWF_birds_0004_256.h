/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0004 256 samples */
 
const int16_t AKWF_birds_0004_256_DATA [256] = 
{3674, 11163, 18003, 23898, 28484, 31369, 32572, 32747, 32077, 30223, 27192, 23482, 19280, 14510, 9161, 3293, -2924, -9093, -14835, -19724, -23454, -25796, -26654, -26099, -24324, -21508, -17878, -13700, -9287, -4707, 43, 4930, 9928, 14852, 19277, 22923, 25497, 26794, 26612, 24944, 21960, 17890, 13093, 7931, 2774, -2026, -6436, -10385, -13906, -17045, -19619, -21423, -22381, -22407, -21370, -19150, -15845, -11613, -6753, -1681, 3222, 7619, 11271, 14110, 16142, 17471, 18108, 17967, 17044, 15414, 13050, 9818, 5731, 890, -4470, -9885, -15020, -19402, -22730, -24825, -25602, -25198, -23772, -21430, -18288, -14575, -10550, -6107, -1231, 4015, 9594, 15130, 20150, 24377, 27424, 29024, 28910, 27138, 23986, 19767, 14617, 9426, 6321, 5915, 7422, 10362, 13952, 17600, 21062, 24060, 26195, 27161, 26747, 24863, 21712, 17512, 12575, 7249, 1937, -2976, -7387, -11264, -14606, -17482, -19746, -21226, -21790, -21378, -19860, -17126, -13186, -8188, -2435, 3658, 9703, 15194, 19938, 23768, 26624, 28631, 29841, 30191, 29662, 28320, 26213, 23224, 19355, 14647, 9243, 3520, -2128, -7327, -11720, -15153, -17512, -18822, -19222, -18757, -17446, -15386, -12730, -9491, -5600, -1090, 3976, 9364, 14665, 19521, 23552, 26551, 28342, 28881, 28304, 26736, 24275, 21051, 17300, 13177, 8675, 3747, -1545, -7103, -12572, -17566, -21765, -24876, -26693, -27078, -26091, -23935, -20774, -16843, -12396, -7790, -3157, 1548, 6282, 11036, 15648, 19727, 22978, 25178, 26093, 25540, 23469, 20067, 15536, 10172, 4345, -1559, -7188, -12434, -17322, -21855, -26107, -29575, -31636, -32596, -32788, -32681, -30500, -26241, -20862, -14576, -7775, -933, 5431, 11086, 15966, 20002, 23312, 25852, 27431, 27953, 27389, 25675, 22632, 18270, 12706, 6144, -880, -7931, -14489, -20063, -24568, -27861, -30001, -31136, -31227, -30237, -28223, -25305, -21413, -16421, -10480, -3471};