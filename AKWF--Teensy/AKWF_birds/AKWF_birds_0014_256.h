/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0014 256 samples */
 
const int16_t AKWF_birds_0014_256_DATA [256] = 
{1169, 2964, 4449, 5667, 6602, 7256, 7641, 7767, 7647, 7295, 6727, 5961, 5038, 3995, 2874, 1721, 587, -482, -1454, -2297, -2999, -3540, -3904, -4086, -4083, -3891, -3514, -2960, -2238, -1361, -354, 765, 1974, 3236, 4527, 5815, 7060, 8229, 9286, 10198, 10952, 11534, 11933, 12134, 12130, 11906, 11456, 10776, 9865, 8722, 7365, 5813, 4079, 2193, 193, -1896, -4028, -6162, -8266, -10287, -12190, -13958, -15554, -16961, -18170, -19160, -19930, -20473, -20771, -20814, -20595, -20120, -19406, -18470, -17344, -16052, -14630, -13121, -11550, -9954, -8371, -6826, -5353, -3980, -2723, -1599, -629, 190, 848, 1339, 1666, 1828, 1834, 1695, 1427, 1045, 570, 20, -584, -1221, -1866, -2500, -3101, -3649, -4136, -4545, -4877, -5134, -5325, -5452, -5515, -5512, -5443, -5302, -5091, -4811, -4465, -4071, -3646, -3208, -2783, -2397, -2077, -1848, -1723, -1715, -1828, -2072, -2449, -2959, -3605, -4398, -5345, -6456, -7728, -9152, -10720, -12420, -14217, -16090, -17998, -19912, -21804, -23643, -25392, -27024, -28496, -29778, -30849, -31689, -32291, -32648, -32761, -32628, -32259, -31657, -30831, -29782, -28534, -27116, -25557, -23902, -22182, -20428, -18683, -16975, -15325, -13766, -12314, -10988, -9813, -8798, -7954, -7293, -6812, -6514, -6392, -6435, -6628, -6960, -7420, -8001, -8690, -9474, -10325, -11218, -12131, -13034, -13902, -14712, -15445, -16086, -16619, -17034, -17315, -17458, -17452, -17291, -16968, -16479, -15820, -15007, -14056, -12989, -11832, -10612, -9356, -8099, -6864, -5674, -4558, -3549, -2669, -1949, -1416, -1092, -1006, -1175, -1611, -2321, -3304, -4554, -6050, -7766, -9677, -11737, -13911, -16161, -18430, -20664, -22804, -24781, -26571, -28156, -29532, -30745, -31692, -32252, -32737, -32654, -32394, -31712, -30686, -29359, -27707, -25767, -23580, -21171, -18609, -15946, -13230, -10526, -7893, -5366, -2993, -764};