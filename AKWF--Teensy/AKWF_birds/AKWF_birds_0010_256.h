/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0010 256 samples */
 
const int16_t AKWF_birds_0010_256_DATA [256] = 
{1871, 5333, 8000, 11081, 14675, 18185, 21309, 23785, 25483, 26437, 26734, 26426, 25587, 24342, 22720, 20712, 18346, 15683, 12871, 10079, 7371, 4837, 2509, 371, -1545, -3220, -4679, -5888, -6839, -7522, -7955, -8170, -8205, -8098, -7865, -7511, -7046, -6500, -5909, -5305, -4720, -4168, -3663, -3201, -2780, -2395, -2042, -1710, -1406, -1144, -947, -836, -838, -967, -1231, -1622, -2117, -2699, -3349, -4032, -4741, -5475, -6215, -6932, -7567, -8073, -8409, -8546, -8484, -8246, -7856, -7356, -6781, -6158, -5494, -4786, -4038, -3269, -2487, -1707, -928, -155, 601, 1315, 1974, 2554, 3041, 3425, 3710, 3921, 4093, 4264, 4469, 4717, 5002, 5322, 5693, 6138, 6668, 7299, 8040, 8882, 9778, 10652, 11427, 12023, 12408, 12572, 12521, 12250, 11733, 10970, 9952, 8660, 7107, 5334, 3415, 1429, -546, -2460, -4279, -6001, -7617, -9127, -10517, -11784, -12910, -13878, -14681, -15317, -15784, -16078, -16205, -16178, -15987, -15621, -15039, -14223, -13151, -11798, -10179, -8340, -6336, -4256, -2158, -104, 1870, 3753, 5534, 7179, 8665, 9971, 11065, 11933, 12565, 12972, 13165, 13155, 12956, 12594, 12065, 11350, 10413, 9211, 7719, 5928, 3819, 1465, -1067, -3687, -6268, -8734, -11079, -13257, -15256, -16976, -18305, -19190, -19553, -19352, -18620, -17436, -15924, -14191, -12365, -10498, -8614, -6684, -4748, -2835, -973, 807, 2489, 4063, 5524, 6896, 8197, 9444, 10660, 11831, 12945, 13988, 14942, 15801, 16551, 17167, 17646, 18001, 18265, 18471, 18642, 18811, 18986, 19127, 19150, 18950, 18414, 17461, 16064, 14263, 12081, 9515, 6591, 3354, -207, -4064, -8209, -12482, -16658, -20544, -23949, -26771, -28999, -30666, -31807, -32480, -32761, -32692, -32295, -31560, -30492, -29086, -27368, -25365, -23057, -20478, -17707, -14822, -12006, -9401, -7103, -5200, -3650, -2373, -1777, -919};