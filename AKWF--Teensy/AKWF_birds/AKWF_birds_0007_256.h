/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0007 256 samples */
 
const int16_t AKWF_birds_0007_256_DATA [256] = 
{996, 2953, 4864, 6309, 7277, 8010, 8803, 9773, 10854, 11985, 13103, 14211, 15321, 16399, 17445, 18450, 19397, 20298, 21142, 21929, 22667, 23359, 24007, 24616, 25183, 25711, 26204, 26671, 27114, 27536, 27934, 28303, 28650, 28973, 29267, 29533, 29772, 29986, 30184, 30368, 30542, 30708, 30868, 31027, 31185, 31343, 31506, 31670, 31833, 31993, 32148, 32295, 32428, 32545, 32642, 32715, 32758, 32767, 32744, 32687, 32599, 32475, 32318, 32129, 31906, 31651, 31353, 31011, 30625, 30192, 29708, 29171, 28581, 27936, 27237, 26485, 25676, 24821, 23918, 22971, 21996, 20983, 19942, 18881, 17804, 16722, 15641, 14544, 13446, 12347, 11244, 10150, 9055, 7962, 6885, 5831, 4803, 3814, 2858, 1947, 1088, 277, -474, -1167, -1809, -2396, -2931, -3417, -3854, -4249, -4605, -4924, -5211, -5473, -5711, -5927, -6122, -6292, -6442, -6571, -6680, -6774, -6855, -6932, -7014, -7101, -7204, -7326, -7474, -7649, -7854, -8094, -8367, -8674, -9010, -9374, -9768, -10190, -10637, -11107, -11597, -12108, -12635, -13176, -13731, -14303, -14886, -15484, -16097, -16721, -17355, -17992, -18634, -19274, -19912, -20541, -21156, -21757, -22345, -22916, -23471, -24007, -24522, -25022, -25500, -25956, -26385, -26788, -27157, -27498, -27805, -28077, -28312, -28512, -28675, -28800, -28887, -28939, -28957, -28942, -28895, -28819, -28715, -28586, -28435, -28265, -28072, -27859, -27626, -27374, -27102, -26812, -26504, -26182, -25854, -25518, -25181, -24844, -24514, -24191, -23880, -23578, -23289, -23013, -22750, -22498, -22255, -22019, -21791, -21568, -21351, -21135, -20918, -20697, -20471, -20244, -20020, -19796, -19574, -19350, -19125, -18896, -18656, -18391, -18098, -17772, -17409, -16999, -16542, -16032, -15460, -14830, -14143, -13398, -12611, -11784, -10927, -10064, -9193, -8327, -7487, -6680, -5917, -5208, -4545, -3941, -3397, -2906, -2462, -2031, -1637, -1353, -1253, -1303, -1165, -416};