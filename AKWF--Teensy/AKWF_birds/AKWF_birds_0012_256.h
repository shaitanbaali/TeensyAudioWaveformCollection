/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0012 256 samples */
 
const int16_t AKWF_birds_0012_256_DATA [256] = 
{219, 957, 2235, 3951, 5927, 7969, 9871, 11460, 12676, 13568, 14205, 14682, 15101, 15565, 16137, 16778, 17460, 18172, 18898, 19618, 20316, 20994, 21666, 22325, 22976, 23611, 24233, 24837, 25421, 25987, 26535, 27059, 27563, 28043, 28497, 28929, 29337, 29724, 30086, 30426, 30743, 31041, 31315, 31566, 31794, 31994, 32172, 32323, 32451, 32557, 32642, 32715, 32764, 32768, 32767, 32768, 32767, 32767, 32768, 32723, 32632, 32523, 32392, 32239, 32068, 31877, 31668, 31438, 31187, 30915, 30622, 30308, 29974, 29614, 29235, 28834, 28409, 27966, 27497, 27008, 26497, 25962, 25405, 24830, 24227, 23602, 22958, 22291, 21607, 20903, 20177, 19432, 18673, 17894, 17106, 16297, 15475, 14643, 13799, 12947, 12088, 11216, 10337, 9458, 8577, 7685, 6794, 5899, 5001, 4109, 3210, 2309, 1412, 512, -385, -1275, -2174, -3069, -3959, -4849, -5731, -6606, -7480, -8346, -9202, -10052, -10886, -11716, -12536, -13342, -14137, -14917, -15683, -16439, -17180, -17903, -18613, -19302, -19979, -20640, -21284, -21910, -22520, -23112, -23688, -24249, -24792, -25317, -25823, -26316, -26790, -27249, -27692, -28115, -28522, -28914, -29288, -29646, -29985, -30312, -30623, -30920, -31204, -31475, -31725, -31953, -32154, -32323, -32457, -32557, -32631, -32684, -32723, -32755, -32768, -32767, -32767, -32767, -32767, -32768, -32763, -32715, -32646, -32559, -32449, -32316, -32154, -31962, -31739, -31488, -31213, -30918, -30604, -30275, -29931, -29570, -29193, -28799, -28380, -27942, -27480, -26996, -26495, -25968, -25420, -24851, -24262, -23652, -23020, -22363, -21681, -20973, -20240, -19475, -18688, -17873, -17037, -16181, -15309, -14415, -13509, -12590, -11667, -10750, -9833, -8930, -8040, -7165, -6315, -5496, -4701, -3948, -3232, -2554, -1926, -1343, -807, -325, 101, 474, 791, 1058, 1278, 1449, 1579, 1690, 1789, 1855, 1863, 1791, 1630, 1349, 919, 444, 71, -35};