/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0011 256 samples */
 
const int16_t AKWF_birds_0011_256_DATA [256] = 
{2134, 6250, 9904, 14348, 18490, 22161, 25362, 28055, 30261, 31863, 32688, 32605, 31573, 29720, 27211, 24197, 20759, 17051, 13306, 9626, 5982, 2318, -1412, -5147, -8643, -11735, -14288, -16379, -18181, -19816, -21225, -22163, -22373, -21795, -20505, -18616, -16182, -13277, -10155, -7109, -4281, -1652, 848, 3254, 5509, 7579, 9446, 11110, 12505, 13575, 14262, 14553, 14417, 13826, 12789, 11314, 9418, 7081, 4359, 1497, -1234, -3696, -5968, -8245, -10647, -13116, -15567, -17898, -20076, -22025, -23626, -24780, -25456, -25606, -25190, -24197, -22656, -20630, -18178, -15327, -12260, -9151, -6108, -3162, -297, 2472, 5086, 7668, 10365, 13208, 16064, 18564, 20448, 21684, 22313, 22390, 21936, 20978, 19601, 17883, 15898, 13686, 11333, 8909, 6463, 4045, 1705, -511, -2608, -4598, -6477, -8202, -9661, -10782, -11545, -11972, -12096, -11944, -11513, -10795, -9800, -8574, -7181, -5730, -4262, -2834, -1591, -652, -27, 440, 989, 1712, 2538, 3394, 4204, 4940, 5485, 5666, 5411, 4731, 3639, 2157, 299, -1736, -3696, -5452, -7014, -8447, -9811, -11072, -12333, -13745, -15374, -17103, -18726, -20029, -20960, -21453, -21406, -20750, -19520, -17880, -15990, -13892, -11556, -8871, -5803, -2496, 827, 3946, 6764, 9366, 11774, 13978, 15958, 17727, 19334, 20781, 21880, 22381, 22149, 21259, 19882, 18183, 16216, 14032, 11719, 9348, 6945, 4499, 2015, -484, -2924, -5253, -7422, -9403, -11113, -12486, -13486, -14212, -14813, -15394, -15888, -16092, -15822, -15051, -13871, -12425, -10787, -8967, -7050, -5111, -3186, -1291, 605, 2480, 4304, 6120, 7968, 9841, 11571, 12896, 13648, 13846, 13577, 12925, 11903, 10540, 8924, 7118, 5125, 2896, 397, -2348, -5294, -8409, -11689, -15025, -18271, -21256, -23877, -26065, -27712, -28709, -29040, -28720, -27815, -26381, -24349, -21562, -17902, -13607, -9359, -5788, -3141, -1551};