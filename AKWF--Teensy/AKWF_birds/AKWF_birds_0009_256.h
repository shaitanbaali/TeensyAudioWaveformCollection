/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0009 256 samples */
 
const int16_t AKWF_birds_0009_256_DATA [256] = 
{2899, 7936, 12381, 15244, 16542, 16932, 17212, 17829, 18651, 19546, 20370, 21110, 21818, 22498, 23157, 23790, 24392, 24966, 25505, 26014, 26491, 26935, 27345, 27721, 28069, 28395, 28701, 28988, 29261, 29522, 29777, 30025, 30266, 30502, 30731, 30955, 31169, 31374, 31569, 31750, 31921, 32079, 32223, 32352, 32464, 32557, 32633, 32692, 32734, 32760, 32767, 32756, 32728, 32677, 32600, 32496, 32359, 32188, 31978, 31726, 31427, 31086, 30698, 30266, 29786, 29263, 28699, 28094, 27449, 26762, 26033, 25263, 24457, 23606, 22719, 21796, 20835, 19841, 18808, 17732, 16626, 15485, 14316, 13135, 11931, 10725, 9524, 8332, 7162, 6030, 4925, 3866, 2850, 1882, 959, 87, -742, -1525, -2260, -2948, -3586, -4171, -4701, -5176, -5595, -5962, -6274, -6527, -6720, -6854, -6929, -6950, -6919, -6838, -6717, -6566, -6392, -6201, -6001, -5804, -5616, -5444, -5284, -5143, -5021, -4922, -4842, -4780, -4739, -4722, -4734, -4779, -4858, -4975, -5131, -5329, -5569, -5854, -6187, -6570, -7001, -7477, -8000, -8559, -9159, -9792, -10453, -11131, -11832, -12544, -13261, -13983, -14705, -15423, -16147, -16866, -17581, -18297, -19005, -19709, -20404, -21083, -21744, -22386, -23000, -23594, -24159, -24694, -25200, -25672, -26111, -26520, -26898, -27242, -27554, -27831, -28075, -28286, -28462, -28607, -28719, -28799, -28845, -28858, -28834, -28779, -28689, -28568, -28417, -28237, -28036, -27817, -27584, -27338, -27087, -26833, -26580, -26327, -26077, -25831, -25587, -25347, -25111, -24875, -24641, -24410, -24184, -23962, -23747, -23533, -23323, -23118, -22919, -22726, -22540, -22359, -22184, -22013, -21848, -21682, -21514, -21338, -21154, -20960, -20747, -20515, -20260, -19982, -19686, -19370, -19032, -18677, -18301, -17909, -17498, -17061, -16595, -16100, -15572, -15009, -14416, -13788, -13119, -12406, -11642, -10834, -9990, -9105, -8139, -7091, -6133, -5405, -5100, -4856, -3841, -1199};