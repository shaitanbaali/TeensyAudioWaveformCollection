/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0002 256 samples */
 
const int16_t AKWF_birds_0002_256_DATA [256] = 
{3603, 9568, 15368, 20865, 25701, 29535, 31983, 32758, 31709, 28761, 24201, 18417, 11876, 5095, -1402, -7392, -13038, -18312, -22936, -26616, -29107, -30149, -29575, -27240, -23181, -17782, -11399, -4588, 2184, 8419, 13971, 19121, 23698, 27429, 30087, 31433, 31290, 29543, 26053, 20982, 14754, 7897, 906, -5754, -11589, -16653, -21120, -24754, -27419, -28922, -29110, -27885, -25183, -20917, -15339, -8870, -2004, 4773, 11114, 16633, 21551, 25909, 29363, 31720, 32750, 32263, 30109, 26187, 20547, 13579, 5901, -1842, -9117, -15341, -20319, -24323, -27310, -29158, -29846, -29359, -27679, -24817, -20697, -15393, -9300, -2796, 3700, 9847, 15307, 20091, 24368, 27918, 30387, 31557, 31201, 29123, 25221, 19463, 12196, 4112, -4081, -11651, -18141, -23056, -26559, -28852, -29848, -29553, -28062, -25417, -21632, -16731, -10610, -3655, 3562, 10510, 16706, 21793, 25588, 28249, 29828, 30206, 29383, 27400, 24230, 19846, 14248, 7550, 251, -7091, -13876, -19659, -24090, -27094, -28915, -29529, -28861, -26969, -23955, -19751, -14324, -7731, -179, 7662, 15097, 21619, 26746, 30169, 31951, 32306, 31299, 29004, 25658, 21418, 16205, 10117, 3102, -4467, -11856, -18495, -23856, -27484, -29194, -29105, -27520, -24865, -21553, -18138, -14929, -12086, -9632, -6975, -5244, -6239, -278, 18525, 31907, 31698, 29245, 27843, 25210, 21559, 17308, 12322, 6579, 200, -6616, -13252, -19226, -24021, -27238, -28706, -28455, -26729, -23723, -19672, -14945, -9845, -4350, 1550, 7759, 13986, 19718, 24547, 28042, 30007, 30317, 29072, 26485, 22793, 18238, 13198, 7881, 2176, -3824, -10012, -15961, -21190, -25302, -27905, -28854, -28110, -25839, -22287, -17715, -12478, -6932, -1195, 4899, 11212, 17422, 23099, 27777, 31001, 32446, 31949, 29571, 25604, 20414, 14433, 8152, 2084, -3786, -9582, -15120, -20167, -24367, -27401, -29034, -29072, -27418, -24198, -19723, -14319, -8336, -2120};