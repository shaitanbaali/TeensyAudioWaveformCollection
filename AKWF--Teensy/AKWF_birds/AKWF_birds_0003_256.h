/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0003 256 samples */
 
const int16_t AKWF_birds_0003_256_DATA [256] = 
{1049, 3774, 6445, 9126, 11753, 14313, 16786, 19119, 21321, 23363, 25213, 26880, 28349, 29594, 30614, 31377, 31867, 32073, 31985, 31600, 30924, 29966, 28744, 27266, 25566, 23642, 21518, 19204, 16705, 14057, 11285, 8405, 5451, 2466, -532, -3517, -6503, -9446, -12322, -15090, -17721, -20193, -22485, -24591, -26500, -28190, -29638, -30843, -31776, -32441, -32753, -32777, -32655, -32160, -31399, -30391, -29163, -27721, -26088, -24271, -22275, -20126, -17847, -15450, -12964, -10424, -7845, -5247, -2620, -4, 2580, 5097, 7517, 9824, 11999, 14033, 15919, 17640, 19178, 20539, 21700, 22659, 23409, 23938, 24253, 24363, 24278, 24012, 23582, 23009, 22297, 21454, 20481, 19387, 18193, 16912, 15540, 14109, 12623, 11095, 9520, 7923, 6316, 4724, 3165, 1649, 190, -1207, -2537, -3794, -4970, -6075, -7096, -8037, -8893, -9656, -10326, -10912, -11416, -11848, -12217, -12528, -12791, -13004, -13164, -13274, -13332, -13337, -13289, -13189, -13034, -12827, -12570, -12264, -11914, -11527, -11105, -10652, -10174, -9667, -9136, -8577, -7981, -7350, -6675, -5947, -5168, -4345, -3477, -2573, -1620, -625, 413, 1482, 2598, 3751, 4932, 6134, 7342, 8539, 9728, 10881, 11991, 13059, 14068, 15021, 15909, 16715, 17434, 18056, 18569, 18982, 19286, 19471, 19527, 19445, 19215, 18828, 18280, 17574, 16711, 15702, 14545, 13248, 11823, 10276, 8623, 6862, 4996, 3039, 1017, -1056, -3154, -5277, -7397, -9516, -11617, -13681, -15697, -17652, -19522, -21293, -22938, -24479, -25897, -27177, -28319, -29303, -30125, -30784, -31270, -31577, -31711, -31678, -31483, -31138, -30652, -30036, -29305, -28496, -27620, -26657, -25591, -24395, -23061, -21566, -19915, -17995, -15830, -13612, -11537, -9815, -8654, -8227, -8667, -10069, -12353, -15242, -18435, -21588, -24356, -26446, -27626, -27872, -27314, -26042, -24221, -21979, -19497, -16943, -14435, -11946, -9412, -6823, -4216, -1527};