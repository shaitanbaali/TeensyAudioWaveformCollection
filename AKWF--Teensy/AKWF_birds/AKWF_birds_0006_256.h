/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_birds_0006 256 samples */
 
const int16_t AKWF_birds_0006_256_DATA [256] = 
{813, 2661, 4665, 6430, 7727, 8592, 9203, 9773, 10474, 11296, 12189, 13115, 14031, 14935, 15838, 16739, 17625, 18497, 19349, 20175, 20977, 21757, 22507, 23230, 23928, 24597, 25245, 25869, 26465, 27032, 27573, 28088, 28578, 29040, 29479, 29889, 30274, 30632, 30962, 31264, 31537, 31781, 31997, 32184, 32343, 32474, 32580, 32661, 32718, 32753, 32768, 32762, 32736, 32692, 32628, 32546, 32448, 32329, 32192, 32037, 31864, 31672, 31465, 31242, 31003, 30749, 30480, 30198, 29905, 29597, 29276, 28944, 28601, 28246, 27882, 27505, 27118, 26721, 26311, 25894, 25467, 25026, 24575, 24116, 23645, 23160, 22667, 22161, 21645, 21125, 20590, 20045, 19494, 18933, 18365, 17790, 17202, 16609, 16005, 15391, 14773, 14143, 13501, 12852, 12193, 11527, 10856, 10172, 9481, 8786, 8082, 7376, 6667, 5952, 5234, 4516, 3796, 3082, 2364, 1650, 940, 234, -465, -1162, -1857, -2547, -3231, -3908, -4576, -5238, -5888, -6527, -7145, -7748, -8334, -8897, -9437, -9955, -10442, -10907, -11346, -11754, -12137, -12493, -12824, -13132, -13416, -13679, -13921, -14142, -14345, -14533, -14708, -14868, -15018, -15158, -15286, -15402, -15506, -15602, -15685, -15759, -15822, -15878, -15928, -15978, -16028, -16079, -16134, -16198, -16270, -16353, -16448, -16556, -16677, -16815, -16965, -17127, -17304, -17489, -17685, -17889, -18097, -18313, -18532, -18752, -18971, -19186, -19397, -19604, -19805, -20001, -20190, -20374, -20550, -20720, -20882, -21035, -21178, -21306, -21420, -21517, -21595, -21651, -21684, -21692, -21674, -21631, -21565, -21473, -21356, -21215, -21049, -20859, -20647, -20406, -20138, -19838, -19507, -19146, -18755, -18326, -17868, -17377, -16848, -16285, -15680, -15036, -14360, -13650, -12913, -12155, -11373, -10585, -9797, -9018, -8245, -7495, -6771, -6081, -5430, -4820, -4249, -3728, -3254, -2823, -2439, -2081, -1726, -1407, -1175, -1071, -1147, -1262, -1133, -450};