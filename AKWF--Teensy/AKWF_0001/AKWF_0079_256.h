/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0079 256 samples */
 
const int16_t AKWF_0079_256_DATA [256] = 
{79, 221, 331, 402, 436, 450, 470, 521, 620, 774, 974, 1203, 1436, 1656, 1851, 2021, 2178, 2337, 2513, 2715, 2947, 3198, 3454, 3700, 3924, 4117, 4283, 4426, 4560, 4695, 4840, 4996, 5160, 5324, 5478, 5616, 5732, 5833, 5922, 6009, 6105, 6215, 6339, 6477, 6623, 6769, 6913, 7051, 7183, 7314, 7451, 7597, 7757, 7929, 8112, 8300, 8488, 8671, 8849, 9020, 9185, 9351, 9518, 9689, 9864, 10041, 10216, 10387, 10550, 10705, 10852, 10993, 11131, 11271, 11411, 11554, 11699, 11844, 11988, 12128, 12265, 12400, 12534, 12669, 12808, 12951, 13099, 13252, 13407, 13563, 13719, 13874, 14030, 14185, 14341, 14501, 14662, 14826, 14992, 15159, 15324, 15488, 15649, 15807, 15965, 16121, 16277, 16433, 16589, 16744, 16899, 17052, 17203, 17353, 17500, 17645, 17792, 17937, 18085, 18233, 18381, 18530, 18680, 18829, 18977, 19117, 19183, 19684, 14387, -389, -16079, -25406, -25794, -19806, -12599, -8487, -8754, -11816, -15091, -17069, -18124, -19767, -23116, -27713, -31630, -32702, -29979, -24487, -18718, -15302, -15561, -18891, -23225, -26207, -26382, -23738, -19450, -15069, -11769, -9927, -9279, -9336, -9725, -10297, -10978, -11575, -11741, -11153, -9748, -7892, -6282, -5630, -6324, -8203, -10645, -12836, -14138, -14341, -13677, -12657, -11812, -11489, -11764, -12501, -13450, -14353, -15000, -15239, -14992, -14262, -13165, -11914, -10774, -9983, -9650, -9713, -9954, -10095, -9902, -9287, -8323, -7212, -6200, -5479, -5138, -5151, -5400, -5736, -6012, -6135, -6065, -5830, -5509, -5208, -5036, -5065, -5305, -5705, -6157, -6533, -6735, -6715, -6500, -6168, -5821, -5548, -5395, -5356, -5381, -5397, -5330, -5137, -4807, -4364, -3864, -3367, -2935, -2603, -2374, -2226, -2112, -1981, -1795, -1540, -1232, -909, -616, -394, -264, -220, -235, -271, -291, -265, -187, -61};