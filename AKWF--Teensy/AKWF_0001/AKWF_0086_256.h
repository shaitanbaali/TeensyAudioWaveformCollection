/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0086 256 samples */
 
const int16_t AKWF_0086_256_DATA [256] = 
{409, 1457, 2478, 3490, 4487, 5465, 6420, 7345, 8239, 9098, 9917, 10695, 11429, 12114, 12752, 13340, 13875, 14357, 14786, 15160, 15481, 15748, 15962, 16124, 16236, 16300, 16316, 16287, 16216, 16105, 15956, 15774, 15560, 15318, 15051, 14762, 14455, 14131, 13796, 13452, 13102, 12747, 12393, 12041, 11693, 11353, 11021, 10699, 10390, 10094, 9813, 9548, 9299, 9066, 8851, 8652, 8470, 8304, 8153, 8017, 7895, 7785, 7687, 7599, 7519, 7446, 7378, 7315, 7253, 7193, 7132, 7068, 6999, 6926, 6847, 6759, 6663, 6557, 6442, 6314, 6176, 6025, 5864, 5690, 5504, 5307, 5100, 4882, 4655, 4419, 4176, 3926, 3671, 3411, 3149, 2887, 2623, 2361, 2101, 1845, 1594, 1350, 1113, 884, 665, 456, 258, 71, -103, -265, -415, -553, -678, -791, -893, -983, -1063, -1133, -1195, -1249, -1297, -1339, -1377, -1413, -1446, -1480, -1514, -1552, -1593, -1639, -1691, -1750, -1817, -1894, -1980, -2076, -2184, -2303, -2433, -2574, -2727, -2891, -3066, -3250, -3443, -3645, -3854, -4068, -4287, -4509, -4733, -4957, -5180, -5399, -5613, -5820, -6019, -6207, -6384, -6547, -6696, -6828, -6943, -7040, -7117, -7174, -7211, -7226, -7220, -7192, -7144, -7076, -6988, -6881, -6756, -6615, -6461, -6292, -6112, -5923, -5728, -5528, -5327, -5125, -4927, -4734, -4550, -4377, -4218, -4075, -3951, -3848, -3768, -3713, -3686, -3688, -3720, -3784, -3880, -4009, -4172, -4368, -4598, -4861, -5156, -5481, -5836, -6219, -6627, -7059, -7511, -7980, -8466, -8961, -9464, -9973, -10481, -10985, -11482, -11967, -12435, -12885, -13310, -13706, -14072, -14401, -14690, -14938, -15139, -15292, -15394, -15441, -15433, -15368, -15243, -15060, -14815, -14511, -14146, -13720, -13238, -12695, -12098, -11448, -10745, -9994, -9199, -8359, -7482, -6571, -5627, -4658, -3669, -2661, -1644, -597};