/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0077 256 samples */
 
const int16_t AKWF_0077_256_DATA [256] = 
{366, 1003, 1615, 2219, 2814, 3400, 3980, 4550, 5117, 5678, 6231, 6780, 7326, 7865, 8402, 8934, 9460, 9983, 10501, 11013, 11520, 12024, 12520, 13014, 13501, 13981, 14457, 14926, 15389, 15847, 16299, 16743, 17181, 17613, 18038, 18459, 18871, 19277, 19677, 20072, 20460, 20842, 21216, 21586, 21951, 22309, 22662, 23009, 23350, 23687, 24018, 24342, 24662, 24978, 25288, 25593, 25894, 26190, 26482, 26768, 27050, 27328, 27600, 27870, 28134, 28393, 28649, 28901, 29149, 29392, 29631, 29866, 30098, 30325, 30547, 30767, 30982, 31195, 31403, 31606, 31806, 32003, 32197, 32385, 32555, 32686, 32759, 32762, 32687, 32524, 32272, 31927, 31492, 30965, 30356, 29666, 28904, 28075, 27187, 26247, 25267, 24252, 23207, 22145, 21068, 19985, 18904, 17825, 16756, 15703, 14663, 13644, 12650, 11677, 10729, 9808, 8911, 8041, 7199, 6379, 5584, 4814, 4063, 3334, 2626, 1934, 1260, 600, -44, -676, -1296, -1907, -2506, -3097, -3682, -4257, -4827, -5392, -5949, -6502, -7049, -7590, -8129, -8661, -9188, -9712, -10230, -10742, -11250, -11753, -12250, -12742, -13228, -13709, -14184, -14652, -15115, -15573, -16023, -16467, -16905, -17336, -17763, -18181, -18593, -19000, -19402, -19795, -20184, -20565, -20941, -21312, -21676, -22035, -22388, -22737, -23078, -23414, -23746, -24071, -24394, -24709, -25020, -25327, -25628, -25923, -26216, -26503, -26785, -27064, -27338, -27606, -27872, -28132, -28388, -28640, -28888, -29132, -29372, -29608, -29839, -30067, -30290, -30510, -30727, -30939, -31147, -31351, -31553, -31749, -31944, -32133, -32299, -32425, -32493, -32489, -32405, -32235, -31972, -31618, -31174, -30640, -30021, -29324, -28552, -27717, -26823, -25879, -24894, -23873, -22826, -21761, -20685, -19599, -18517, -17440, -16369, -15317, -14279, -13261, -12269, -11297, -10351, -9434, -8539, -7671, -6831, -6012, -5220, -4451, -3703, -2977, -2274, -1588, -920, -256};