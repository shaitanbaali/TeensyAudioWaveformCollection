/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0049 256 samples */
 
const int16_t AKWF_0049_256_DATA [256] = 
{1288, 4298, 7216, 10066, 12801, 15398, 17838, 20092, 22164, 24042, 25715, 27196, 28480, 29565, 30444, 31093, 31485, 31600, 31428, 30968, 30227, 29225, 27989, 26545, 24933, 23190, 21343, 19439, 17508, 15579, 13688, 11866, 10135, 8491, 6924, 5439, 4047, 2746, 1537, 448, -466, -1133, -1521, -1645, -1451, -910, -65, 1019, 2275, 3648, 5081, 6523, 7931, 9259, 10465, 11519, 12384, 13032, 13447, 13612, 13525, 13191, 12626, 11854, 10926, 9873, 8611, 7075, 5253, 3159, 836, -1653, -4263, -6937, -9613, -12248, -14793, -17203, -19472, -21577, -23502, -25254, -26823, -28204, -29406, -30423, -31256, -31910, -32381, -32672, -32772, -32648, -32256, -31550, -30515, -29149, -27472, -25529, -23370, -21063, -18718, -16335, -13870, -11355, -8850, -6436, -4188, -2136, -305, 1292, 2662, 3805, 4724, 5430, 5936, 6274, 6458, 6485, 6350, 6068, 5669, 5197, 4669, 4091, 3488, 2881, 2301, 1767, 1294, 899, 579, 330, 169, 118, 187, 379, 692, 1124, 1664, 2309, 3045, 3861, 4776, 5815, 6992, 8315, 9762, 11301, 12908, 14548, 16192, 17826, 19410, 20916, 22333, 23636, 24815, 25862, 26758, 27497, 28066, 28454, 28653, 28655, 28454, 28046, 27430, 26612, 25599, 24407, 23058, 21567, 19954, 18249, 16472, 14655, 12855, 11076, 9285, 7476, 5642, 3803, 1968, 138, -1670, -3450, -5203, -6913, -8573, -10184, -11731, -13212, -14619, -15918, -17068, -18034, -18790, -19336, -19677, -19821, -19783, -19582, -19238, -18772, -18205, -17564, -16865, -16130, -15381, -14631, -13894, -13186, -12511, -11881, -11298, -10765, -10280, -9847, -9467, -9166, -8980, -8935, -9044, -9302, -9693, -10199, -10801, -11485, -12229, -12998, -13759, -14492, -15214, -15941, -16679, -17418, -18140, -18817, -19431, -19961, -20384, -20685, -20844, -20842, -20646, -20211, -19488, -18447, -17104, -15535, -13814, -11863, -9635, -7151, -4468, -1570};