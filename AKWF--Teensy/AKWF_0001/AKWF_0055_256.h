/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0055 256 samples */
 
const int16_t AKWF_0055_256_DATA [256] = 
{287, 707, 1121, 1539, 1957, 2377, 2799, 3223, 3645, 4064, 4478, 4891, 5301, 5707, 6110, 6509, 6902, 7290, 7675, 8055, 8432, 8803, 9170, 9532, 9890, 10243, 10594, 10942, 11285, 11624, 11959, 12289, 12616, 12941, 13263, 13581, 13896, 14208, 14519, 14825, 15130, 15432, 15732, 16029, 16325, 16618, 16908, 17197, 17484, 17769, 18053, 18335, 18616, 18894, 19169, 19443, 19716, 19987, 20258, 20527, 20793, 21060, 21324, 21586, 21850, 22112, 22373, 22632, 22890, 23147, 23403, 23657, 23910, 24163, 24415, 24666, 24916, 25165, 25415, 25663, 25909, 26154, 26400, 26644, 26887, 27130, 27371, 27614, 27854, 28093, 28332, 28571, 28809, 29047, 29285, 29522, 29759, 29994, 30228, 30463, 30696, 30929, 31161, 31393, 31625, 31856, 32085, 32308, 32512, 32674, 32761, 32741, 32568, 32199, 31602, 30743, 29577, 28090, 26281, 24046, 21166, 17456, 13045, 8441, 4161, 415, -2853, -5790, -8481, -10949, -13232, -15352, -17296, -19068, -20667, -22079, -23307, -24351, -25212, -25902, -26429, -26805, -27049, -27175, -27198, -27137, -27007, -26826, -26608, -26364, -26110, -25856, -25614, -25394, -25202, -25045, -24929, -24857, -24831, -24850, -24910, -25008, -25138, -25292, -25461, -25637, -25812, -25982, -26136, -26270, -26379, -26459, -26510, -26529, -26517, -26472, -26395, -26287, -26149, -25986, -25797, -25586, -25352, -25101, -24834, -24554, -24265, -23968, -23664, -23355, -23045, -22734, -22425, -22119, -21815, -21514, -21219, -20929, -20644, -20366, -20094, -19825, -19559, -19298, -19042, -18788, -18536, -18285, -18035, -17783, -17530, -17276, -17019, -16759, -16496, -16228, -15955, -15679, -15400, -15114, -14823, -14527, -14226, -13921, -13609, -13294, -12974, -12648, -12320, -11988, -11649, -11305, -10957, -10603, -10244, -9879, -9507, -9128, -8741, -8344, -7936, -7511, -7070, -6606, -6090, -5489, -4798, -4071, -3386, -2791, -2276, -1811, -1372, -950, -536, -116};