/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0058 256 samples */
 
const int16_t AKWF_0058_256_DATA [256] = 
{177, 626, 1134, 1668, 2174, 2646, 3092, 3515, 3905, 4257, 4596, 4876, 5120, 5332, 5506, 5667, 5796, 5892, 5973, 6033, 6092, 6129, 6181, 6232, 6235, 6244, 6256, 6294, 6324, 6356, 6412, 6430, 6443, 6480, 6493, 6492, 6469, 6429, 6397, 6418, 6443, 6468, 6513, 6561, 6637, 6707, 6797, 6957, 7173, 7374, 7601, 7816, 8053, 8322, 8589, 8879, 9193, 9498, 9809, 10109, 10403, 10731, 11039, 11396, 11741, 12052, 12404, 12756, 13114, 13478, 13837, 14244, 14710, 15343, 17033, 17550, 18108, 18944, 19766, 20631, 21435, 22159, 22817, 23412, 23947, 24390, 24731, 24992, 25224, 25391, 25470, 25448, 25398, 25299, 25098, 24830, 24557, 24244, 23817, 23315, 22816, 22252, 21645, 20979, 20260, 19489, 18697, 17915, 17068, 16158, 15181, 14213, 13029, 10897, 9956, 8783, 7550, 6272, 5059, 3961, 2907, 1958, 1161, 514, 66, -285, -725, -1213, -1707, -2151, -2572, -2933, -3230, -3500, -3736, -3924, -4029, -4109, -4146, -4008, -3762, -2866, -2650, -2331, -1799, -1254, -811, -402, -52, 224, 586, 981, 1384, 1776, 2108, 2433, 2774, 3061, 3272, 3481, 3678, 3808, 3899, 3583, 3581, 3616, 3371, 3123, 2814, 2465, 2040, 1585, 1085, 155, -614, -1029, -1951, -3001, -4163, -5408, -6708, -7999, -9259, -10488, -11713, -12896, -14027, -15121, -16173, -17178, -18116, -18996, -19846, -20679, -21466, -22170, -22862, -23743, -25756, -26228, -26979, -27821, -28682, -29463, -30211, -30865, -31425, -31875, -32217, -32471, -32670, -32760, -32757, -32672, -32528, -32275, -31941, -31570, -31162, -30680, -30095, -29470, -28842, -28129, -27384, -26611, -25821, -24996, -24143, -23278, -22384, -21494, -20585, -19664, -18745, -17833, -16936, -16013, -15116, -14233, -13358, -12475, -11618, -10773, -9920, -9071, -8262, -7177, -5429, -4885, -3945, -3094, -2230, -1414, -707, -167};