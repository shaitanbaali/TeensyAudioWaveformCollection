/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0060 256 samples */
 
const int16_t AKWF_0060_256_DATA [256] = 
{-248, -838, -1406, -1966, -2515, -3052, -3577, -4086, -4581, -5062, -5524, -5972, -6403, -6816, -7212, -7589, -7948, -8290, -8613, -8917, -9203, -9471, -9720, -9952, -10165, -10360, -10538, -10699, -10842, -10968, -11078, -11170, -11248, -11310, -11357, -11388, -11405, -11408, -11397, -11373, -11335, -11285, -11222, -11148, -11062, -10966, -10858, -10741, -10614, -10477, -10331, -10177, -10014, -9844, -9666, -9481, -9289, -9091, -8887, -8678, -8463, -8244, -8020, -7792, -7560, -7325, -7086, -6845, -6601, -6355, -6107, -5858, -5607, -5356, -5104, -4851, -4598, -4346, -4094, -3842, -3592, -3342, -3093, -2847, -2602, -2358, -2118, -1879, -1643, -1410, -1180, -953, -729, -508, -291, -78, 132, 337, 538, 736, 929, 1118, 1302, 1481, 1657, 1827, 1992, 2153, 2308, 2457, 2602, 2739, 2870, 2994, 3109, 3216, 3315, 3403, 3480, 3547, 3602, 3645, 3677, 3695, 3701, 3695, 3675, 3641, 3595, 3533, 3457, 3366, 3261, 3140, 3005, 2855, 2690, 2512, 2321, 2119, 1907, 1686, 1457, 1223, 984, 742, 500, 258, 18, -219, -449, -674, -891, -1098, -1296, -1482, -1655, -1815, -1961, -2092, -2208, -2308, -2391, -2457, -2505, -2535, -2547, -2540, -2514, -2467, -2401, -2314, -2206, -2077, -1927, -1756, -1564, -1350, -1115, -860, -584, -289, 23, 354, 700, 1060, 1435, 1822, 2219, 2627, 3045, 3471, 3905, 4346, 4793, 5246, 5703, 6162, 6623, 7083, 7541, 7996, 8444, 8884, 9316, 9735, 10142, 10534, 10907, 11265, 11601, 11915, 12207, 12475, 12717, 12934, 13123, 13285, 13418, 13523, 13598, 13644, 13660, 13647, 13604, 13532, 13430, 13297, 13136, 12944, 12722, 12471, 12190, 11880, 11542, 11176, 10784, 10367, 9924, 9459, 8974, 8468, 7944, 7406, 6851, 6284, 5708, 5122, 4528, 3931, 3329, 2726, 2124, 1522, 926, 323};