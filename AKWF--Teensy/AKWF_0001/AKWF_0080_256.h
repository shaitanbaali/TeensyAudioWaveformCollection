/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0080 256 samples */
 
const int16_t AKWF_0080_256_DATA [256] = 
{668, 1676, 2661, 3644, 4620, 5587, 6546, 7492, 8426, 9350, 10257, 11152, 12033, 12896, 13747, 14583, 15400, 16205, 16993, 17762, 18517, 19254, 19974, 20678, 21364, 22030, 22681, 23312, 23925, 24520, 25095, 25649, 26186, 26704, 27200, 27677, 28132, 28567, 28982, 29375, 29747, 30099, 30428, 30736, 31023, 31287, 31531, 31753, 31951, 32129, 32285, 32419, 32531, 32622, 32691, 32738, 32763, 32768, 32752, 32714, 32655, 32575, 32474, 32358, 32235, 32103, 31964, 31819, 31670, 31514, 31351, 31181, 31000, 30809, 30607, 30390, 30156, 29906, 29652, 29399, 29142, 28884, 28628, 28373, 28114, 27852, 27584, 27307, 27021, 26722, 26406, 26072, 25718, 25340, 24938, 24512, 24058, 23580, 23077, 22547, 21993, 21415, 20813, 20192, 19548, 18882, 18201, 17499, 16780, 16049, 15300, 14537, 13764, 12977, 12179, 11374, 10545, 9697, 8834, 7949, 7044, 6122, 5180, 4227, 3261, 2283, 1300, 311, -682, -1673, -2660, -3645, -4621, -5588, -6546, -7493, -8427, -9351, -10257, -11152, -12033, -12897, -13748, -14583, -15401, -16205, -16993, -17762, -18517, -19255, -19974, -20678, -21364, -22030, -22681, -23313, -23925, -24521, -25095, -25650, -26187, -26704, -27200, -27677, -28132, -28567, -28982, -29375, -29747, -30099, -30428, -30737, -31023, -31287, -31531, -31753, -31951, -32129, -32285, -32419, -32531, -32622, -32691, -32738, -32763, -32768, -32752, -32714, -32655, -32575, -32474, -32358, -32235, -32103, -31964, -31819, -31670, -31514, -31351, -31181, -31000, -30809, -30607, -30390, -30156, -29906, -29652, -29400, -29142, -28885, -28628, -28373, -28114, -27852, -27584, -27307, -27021, -26722, -26406, -26072, -25718, -25341, -24939, -24512, -24058, -23580, -23077, -22547, -21993, -21416, -20814, -20192, -19548, -18882, -18201, -17499, -16781, -16049, -15300, -14538, -13764, -12977, -12180, -11374, -10546, -9698, -8835, -7950, -7045, -6122, -5180, -4228, -3262, -2285, -1305, -298};