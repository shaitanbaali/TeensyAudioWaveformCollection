/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0010 256 samples */
 
const int16_t AKWF_0010_256_DATA [256] = 
{-144, -805, -1619, -2511, -3455, -4438, -5448, -6471, -7505, -8540, -9569, -10590, -11598, -12585, -13554, -14497, -15411, -16299, -17155, -17977, -18766, -19522, -20240, -20926, -21576, -22189, -22770, -23316, -23828, -24309, -24757, -25175, -25564, -25923, -26255, -26561, -26842, -27098, -27331, -27542, -27732, -27902, -28052, -28184, -28298, -28394, -28474, -28538, -28587, -28620, -28638, -28642, -28631, -28606, -28567, -28513, -28446, -28364, -28268, -28157, -28032, -27891, -27736, -27570, -27375, -27236, -27491, -27956, -28490, -29123, -29841, -30597, -31327, -31964, -32441, -32713, -32756, -32573, -32189, -31648, -31008, -30324, -29656, -29056, -28559, -28196, -27982, -27921, -28010, -28234, -28575, -29008, -29506, -30042, -30586, -31111, -31595, -32013, -32350, -32593, -32733, -32765, -32688, -32503, -32212, -31821, -31337, -30763, -30108, -29377, -28574, -27702, -26770, -25774, -24720, -23612, -22445, -21226, -19957, -18636, -17268, -15860, -14410, -12930, -11426, -9903, -8378, -6864, -5372, -3930, -2563, -1299, -293, 493, 1599, 2905, 4320, 5814, 7353, 8923, 10503, 12072, 13625, 15147, 16622, 18049, 19418, 20718, 21953, 23113, 24195, 25204, 26135, 26989, 27770, 28477, 29113, 29683, 30189, 30634, 31025, 31362, 31652, 31898, 32104, 32274, 32412, 32521, 32606, 32670, 32714, 32744, 32761, 32767, 32766, 32758, 32747, 32733, 32718, 32703, 32689, 32677, 32667, 32660, 32656, 32655, 32657, 32662, 32669, 32678, 32690, 32701, 32712, 32723, 32729, 32733, 32735, 32736, 32735, 32732, 32729, 32724, 32718, 32712, 32707, 32704, 32703, 32706, 32713, 32724, 32737, 32750, 32762, 32767, 32762, 32742, 32700, 32630, 32526, 32383, 32195, 31955, 31661, 31309, 30895, 30419, 29879, 29275, 28609, 27882, 27096, 26256, 25362, 24419, 23434, 22406, 21341, 20245, 19120, 17970, 16803, 15617, 14421, 13221, 12014, 10811, 9617, 8432, 7267, 6129, 5018, 3950, 2933, 1977, 1106, 356};