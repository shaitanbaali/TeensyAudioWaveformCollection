/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0067 256 samples */
 
const int16_t AKWF_0067_256_DATA [256] = 
{452, 1714, 2821, 3820, 4718, 5527, 6256, 6910, 7499, 8029, 8504, 8933, 9319, 9664, 9977, 10258, 10509, 10737, 10940, 11124, 11289, 11438, 11571, 11691, 11800, 11896, 11984, 12063, 12133, 12197, 12254, 12306, 12352, 12394, 12431, 12465, 12495, 12522, 12547, 12569, 12589, 12606, 12622, 12637, 12650, 12662, 12672, 12682, 12690, 12697, 12705, 12711, 12717, 12722, 12726, 12730, 12734, 12737, 12740, 12743, 12745, 12747, 12749, 12751, 12752, 12754, 12755, 12756, 12757, 12758, 12759, 12760, 12760, 12761, 12762, 12762, 12763, 12763, 12763, 12764, 12764, 12764, 12764, 12765, 12765, 12765, 12765, 12765, 12765, 12765, 12765, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12766, 12753, 12794, 12589, 10511, 8093, 6018, 4127, 2429, 903, -473, -1708, -2820, -3821, -4719, -5528, -6257, -6911, -7499, -8030, -8505, -8934, -9319, -9665, -9977, -10258, -10510, -10737, -10941, -11124, -11290, -11438, -11572, -11692, -11800, -11897, -11985, -12063, -12134, -12197, -12255, -12306, -12352, -12394, -12432, -12465, -12496, -12523, -12548, -12569, -12590, -12607, -12623, -12638, -12650, -12662, -12673, -12683, -12691, -12698, -12705, -12712, -12717, -12722, -12727, -12731, -12734, -12738, -12741, -12744, -12746, -12748, -12750, -12751, -12753, -12754, -12755, -12757, -12758, -12759, -12759, -12760, -12761, -12762, -12762, -12762, -12763, -12764, -12763, -12764, -12765, -12764, -12764, -12765, -12766, -12765, -12765, -12765, -12766, -12765, -12766, -12767, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12766, -12753, -12794, -12589, -10511, -8094, -6019, -4130, -2435, -886};