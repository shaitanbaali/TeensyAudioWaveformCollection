/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0066 256 samples */
 
const int16_t AKWF_0066_256_DATA [256] = 
{1642, 5406, 6961, 7930, 8801, 9550, 10220, 10829, 11391, 11915, 12405, 12868, 13308, 13726, 14127, 14512, 14880, 15237, 15581, 15913, 16237, 16550, 16854, 17148, 17450, 17602, 17593, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17595, 17406, 18296, 14409, -14440, -18228, -17419, -17598, -17579, -17347, -17046, -16749, -16442, -16125, -15799, -15463, -15114, -14754, -14379, -13989, -13583, -13157, -12710, -12238, -11736, -11200, -10623, -9994, -9299, -8517, -7586, -6572, -4253, -285, 3788, 6401, 7449, 8400, 9197, 9903, 10540, 11123, 11665, 12170, 12646, 13098, 13525, 13935, 14327, 14703, 15065, 15415, 15753, 16081, 16400, 16707, 17006, 17305, 17560, 17600, 17593, 17595, 17595, 17595, 17595, 17106, 19706, 6027, -18817, -17318, -17547, -17595, -17595, -17595, -17595, -17594, -17597, -17585, -17356, -17054, -16757, -16451, -16135, -15808, -15473, -15124, -14763, -14391, -14001, -13595, -13170, -12723, -12251, -11751, -11216, -10639, -10013, -9320, -8540, -7614, -6613, -4357, -402, 3672, 6364, 7419, 8376, 9176, 9883, 10523, 11107, 11649, 12157, 12633, 13085, 13514, 13923, 14316, 14693, 15055, 15406, 15744, 16072, 16390, 16699, 16998, 17296, 17560, 17601, 16990, 20235, 2861, -20281, -16983, -17593, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17595, -17592, -17606, -17493, -17198, -16904, -16601, -16290, -15968, -15637, -15295, -14940, -14574, -14192, -13794, -13379, -12943, -12484, -11998, -11480, -10925, -10325, -9665, -8932, -8086, -7124, -5762, -2321};