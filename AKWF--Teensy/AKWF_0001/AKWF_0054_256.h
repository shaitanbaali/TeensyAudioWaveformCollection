/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0054 256 samples */
 
const int16_t AKWF_0054_256_DATA [256] = 
{284, 1164, 1888, 2493, 2980, 3349, 3597, 3722, 3722, 3607, 3397, 3115, 2787, 2435, 2080, 1734, 1408, 1119, 887, 724, 645, 666, 786, 992, 1267, 1591, 1947, 2310, 2661, 2984, 3270, 3532, 3799, 4110, 4501, 4998, 5609, 6338, 7172, 8081, 9052, 10080, 11168, 12337, 13605, 14982, 16468, 18023, 19591, 21133, 22607, 23978, 25218, 26293, 27181, 27882, 28386, 28688, 28784, 28669, 28347, 27824, 27106, 26190, 25068, 23747, 22222, 20490, 18571, 16484, 14260, 11949, 9561, 7104, 4586, 1991, -684, -3426, -6229, -9049, -11829, -14525, -17090, -19486, -21703, -23708, -25491, -27073, -28458, -29659, -30688, -31532, -32175, -32590, -32767, -32701, -32409, -31941, -31344, -30663, -29933, -29168, -28373, -27544, -26671, -25757, -24809, -23821, -22799, -21750, -20672, -19567, -18436, -17270, -16072, -14827, -13510, -12119, -10669, -9169, -7629, -6059, -4471, -2884, -1313, 225, 1692, 3066, 4331, 5463, 6453, 7300, 8001, 8546, 8918, 9098, 9079, 8862, 8464, 7904, 7218, 6449, 5615, 4730, 3810, 2863, 1904, 948, 10, -874, -1668, -2339, -2852, -3188, -3342, -3322, -3157, -2872, -2493, -2025, -1473, -850, -166, 566, 1346, 2176, 3048, 3947, 4858, 5772, 6678, 7571, 8443, 9302, 10175, 11068, 11966, 12866, 13773, 14671, 15556, 16406, 17194, 17899, 18493, 18968, 19296, 19456, 19461, 19311, 18994, 18471, 17720, 16744, 15553, 14183, 12704, 11182, 9681, 8246, 6890, 5622, 4434, 3310, 2265, 1322, 512, -122, -551, -756, -746, -569, -302, -29, 184, 290, 258, 81, -235, -686, -1282, -2047, -2987, -4111, -5417, -6869, -8419, -10007, -11569, -13059, -14422, -15617, -16634, -17465, -18106, -18553, -18806, -18860, -18714, -18360, -17799, -17045, -16127, -15098, -13995, -12856, -11701, -10535, -9359, -8150, -6889, -5587, -4281, -3007, -1805, -680};