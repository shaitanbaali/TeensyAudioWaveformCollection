/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0072 256 samples */
 
const int16_t AKWF_0072_256_DATA [256] = 
{-246, -879, -1615, -2450, -3369, -4364, -5426, -6540, -7699, -8895, -10112, -11348, -12591, -13827, -15054, -16261, -17438, -18485, -19266, -19824, -20254, -20550, -20672, -20668, -20596, -20453, -20228, -19953, -19645, -19234, -18699, -18085, -17437, -16798, -16185, -15596, -15031, -14487, -13966, -13467, -12985, -12522, -12079, -11646, -11292, -11229, -11465, -11895, -12412, -12901, -13304, -13627, -13884, -14085, -14240, -14362, -14460, -14540, -14582, -14575, -14527, -14445, -14338, -14211, -14072, -13928, -13777, -13606, -13418, -13216, -13004, -12785, -12563, -12342, -12122, -11879, -11598, -11289, -10957, -10608, -10249, -9886, -9526, -9176, -8838, -8514, -8202, -7902, -7613, -7335, -7067, -6809, -6560, -6321, -6091, -5870, -5657, -5453, -5256, -5066, -4883, -4706, -4536, -4373, -4216, -4064, -3917, -3777, -3633, -3316, -2699, -1826, -746, 501, 1872, 3318, 4805, 6284, 7682, 8973, 10160, 11249, 12255, 13177, 14023, 14801, 15513, 16166, 16766, 17316, 17822, 18290, 18722, 19124, 19501, 19856, 20195, 20502, 20756, 20961, 21123, 21245, 21332, 21387, 21412, 21410, 21386, 21340, 21276, 21197, 21106, 21004, 20895, 20781, 20664, 20546, 20429, 20299, 20150, 19986, 19809, 19620, 19421, 19213, 18998, 18778, 18552, 18324, 18093, 17862, 17632, 17402, 17175, 16954, 16736, 16523, 16295, 16033, 15744, 15432, 15098, 14746, 14381, 14000, 13610, 13212, 12806, 12397, 11986, 11574, 11166, 10761, 10361, 9970, 9589, 9219, 8864, 8522, 8193, 7877, 7572, 7279, 6998, 6727, 6466, 6215, 5974, 5741, 5517, 5301, 5094, 4894, 4700, 4514, 4334, 4162, 3996, 3837, 3683, 3537, 3396, 3260, 3131, 3005, 2885, 2769, 2658, 2551, 2448, 2349, 2254, 2162, 2073, 1988, 1906, 1827, 1751, 1678, 1608, 1541, 1477, 1416, 1357, 1300, 1245, 1193, 1143, 1094, 1047, 1002, 958, 916, 879, 816, 618, 244};