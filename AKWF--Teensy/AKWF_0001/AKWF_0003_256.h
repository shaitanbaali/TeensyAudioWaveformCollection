/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0003 256 samples */
 
const int16_t AKWF_0003_256_DATA [256] = 
{1429, 4435, 7374, 10283, 13123, 15868, 18491, 20952, 23236, 25318, 27171, 28783, 30135, 31213, 32013, 32528, 32756, 32698, 32363, 31758, 30895, 29791, 28466, 26932, 25219, 23351, 21345, 19233, 17041, 14786, 12505, 10217, 7939, 5702, 3522, 1412, -602, -2515, -4314, -5985, -7525, -8931, -10191, -11312, -12292, -13129, -13830, -14397, -14834, -15145, -15337, -15415, -15382, -15245, -15007, -14672, -14245, -13730, -13128, -12444, -11681, -10839, -9925, -8940, -7887, -6771, -5596, -4364, -3087, -1765, -404, 981, 2389, 3809, 5223, 6627, 8005, 9338, 10619, 11827, 12945, 13964, 14866, 15635, 16262, 16733, 17039, 17173, 17127, 16897, 16483, 15885, 15105, 14147, 13020, 11734, 10295, 8727, 7039, 5252, 3391, 1475, -473, -2419, -4348, -6231, -8035, -9745, -11334, -12774, -14055, -15155, -16057, -16752, -17229, -17481, -17504, -17300, -16872, -16222, -15362, -14305, -13060, -11652, -10102, -8423, -6649, -4805, -2912, -1007, 888, 2750, 4541, 6245, 7838, 9292, 10594, 11728, 12673, 13426, 13977, 14319, 14455, 14382, 14107, 13637, 12983, 12158, 11175, 10053, 8811, 7465, 6038, 4553, 3027, 1482, -59, -1583, -3066, -4493, -5854, -7129, -8311, -9393, -10362, -11217, -11956, -12575, -13076, -13462, -13734, -13898, -13959, -13923, -13795, -13584, -13295, -12934, -12506, -12018, -11472, -10874, -10227, -9531, -8791, -8010, -7184, -6319, -5415, -4471, -3493, -2479, -1432, -357, 743, 1865, 2997, 4136, 5271, 6388, 7477, 8525, 9513, 10431, 11264, 11995, 12613, 13105, 13456, 13661, 13710, 13596, 13313, 12860, 12238, 11445, 10487, 9369, 8094, 6676, 5124, 3443, 1654, -230, -2202, -4234, -6312, -8418, -10519, -12598, -14628, -16576, -18424, -20145, -21708, -23097, -24289, -25260, -25999, -26491, -26724, -26691, -26391, -25821, -24981, -23880, -22527, -20928, -19100, -17063, -14824, -12413, -9849, -7154, -4360, -1427};