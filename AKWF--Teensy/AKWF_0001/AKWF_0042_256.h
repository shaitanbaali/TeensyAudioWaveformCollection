/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0042 256 samples */
 
const int16_t AKWF_0042_256_DATA [256] = 
{64, 210, 360, 517, 683, 856, 1036, 1222, 1414, 1613, 1815, 2024, 2238, 2455, 2677, 2902, 3131, 3362, 3597, 3832, 4070, 4310, 4550, 4792, 5035, 5276, 5518, 5761, 6003, 6243, 6483, 6723, 6961, 7196, 7432, 7665, 7895, 8125, 8352, 8577, 8801, 9021, 9240, 9457, 9672, 9884, 10094, 10302, 10508, 10712, 10914, 11114, 11312, 11508, 11703, 11896, 12087, 12277, 12466, 12652, 12839, 13023, 13207, 13391, 13573, 13754, 13935, 14116, 14296, 14476, 14654, 14833, 15012, 15191, 15370, 15549, 15729, 15906, 16086, 16266, 16445, 16626, 16807, 16988, 17170, 17352, 17534, 17718, 17901, 18085, 18270, 18455, 18641, 18827, 19014, 19201, 19388, 19577, 19766, 19955, 20145, 20334, 20525, 20716, 20907, 21099, 21284, 21508, 21461, 21317, 21249, 21089, 20864, 20564, 20187, 19732, 19196, 18577, 17874, 17087, 16218, 15269, 14239, 13133, 11956, 10706, 9393, 8020, 6588, 5109, 3588, 2025, 436, -1179, -2817, -4459, -6109, -7760, -9394, -11017, -12619, -14187, -15723, -17220, -18667, -20066, -21409, -22687, -23904, -25052, -26124, -27125, -28047, -28888, -29650, -30329, -30923, -31435, -31863, -32205, -32467, -32647, -32745, -32766, -32711, -32580, -32380, -32110, -31775, -31377, -30922, -30410, -29846, -29236, -28580, -27885, -27155, -26390, -25599, -24784, -23947, -23094, -22230, -21354, -20474, -19592, -18709, -17831, -16962, -16099, -15251, -14418, -13601, -12803, -12028, -11274, -10546, -9843, -9165, -8519, -7899, -7307, -6747, -6216, -5714, -5245, -4805, -4393, -4012, -3659, -3334, -3036, -2765, -2520, -2298, -2100, -1924, -1770, -1635, -1519, -1419, -1336, -1268, -1212, -1169, -1135, -1111, -1097, -1088, -1083, -1085, -1090, -1095, -1102, -1110, -1116, -1119, -1121, -1119, -1113, -1102, -1086, -1063, -1034, -998, -955, -903, -844, -776, -701, -616, -523, -423, -313, -195, -66};