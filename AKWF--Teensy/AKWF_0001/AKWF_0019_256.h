/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0019 256 samples */
 
const int16_t AKWF_0019_256_DATA [256] = 
{1436, 3129, 4426, 5597, 6673, 7683, 8637, 9538, 10400, 11225, 12012, 12769, 13497, 14194, 14867, 15512, 16132, 16731, 17305, 17887, 18247, 18577, 19098, 19501, 19846, 20155, 20434, 20683, 20897, 21082, 21176, 21317, 22094, 21680, 21839, 22063, 22211, 22335, 22449, 22558, 22663, 22768, 22870, 22974, 23076, 23177, 23283, 23389, 23499, 23613, 23737, 23867, 24007, 24159, 24321, 24502, 24740, 24721, 24827, 25047, 25211, 25363, 25514, 25664, 25820, 25979, 26141, 26306, 26473, 26640, 26809, 26976, 27142, 27309, 27472, 27632, 27791, 27945, 28096, 28246, 28391, 28533, 28667, 28827, 28799, 28712, 28858, 28900, 28895, 28864, 28813, 28743, 28652, 28528, 28404, 27926, 27938, 27875, 27358, 27006, 26567, 26205, 23430, 23940, 24359, 23245, 22372, 21586, 20848, 20124, 19384, 18618, 17822, 16993, 16128, 15234, 14306, 13343, 12349, 11317, 10246, 9122, 7915, 7011, 5831, 4466, 3079, 1270, -1454, -3143, -4430, -5608, -6684, -7692, -8644, -9547, -10408, -11231, -12019, -12775, -13503, -14200, -14870, -15518, -16140, -16738, -17309, -17891, -18252, -18578, -19106, -19503, -19848, -20159, -20436, -20686, -20902, -21092, -21150, -21505, -22001, -21684, -21912, -22111, -22260, -22389, -22507, -22621, -22734, -22843, -22950, -23060, -23167, -23275, -23385, -23498, -23614, -23736, -23864, -24002, -24147, -24305, -24473, -24693, -24834, -24804, -25014, -25199, -25358, -25508, -25655, -25807, -25963, -26122, -26285, -26448, -26617, -26782, -26949, -27115, -27278, -27441, -27602, -27760, -27914, -28066, -28215, -28361, -28504, -28640, -28776, -28911, -28766, -28817, -28929, -28942, -28922, -28882, -28822, -28740, -28638, -28508, -28287, -27827, -28071, -27652, -27238, -26852, -26524, -25256, -23020, -24600, -23859, -22880, -22048, -21285, -20556, -19827, -19076, -18298, -17487, -16644, -15765, -14858, -13913, -12937, -11929, -10878, -9794, -8605, -7520, -6576, -5263, -3893, -2467, -119};