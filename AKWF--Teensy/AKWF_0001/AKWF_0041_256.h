/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0041 256 samples */
 
const int16_t AKWF_0041_256_DATA [256] = 
{340, 1101, 1849, 2598, 3349, 4100, 4851, 5598, 6346, 7093, 7834, 8574, 9310, 10039, 10766, 11489, 12202, 12912, 13614, 14308, 14996, 15675, 16343, 17004, 17655, 18295, 18925, 19545, 20151, 20748, 21331, 21901, 22459, 23003, 23534, 24050, 24551, 25038, 25511, 25967, 26409, 26832, 27241, 27633, 28007, 28365, 28707, 29031, 29336, 29624, 29894, 30145, 30380, 30594, 30791, 30968, 31128, 31268, 31390, 31491, 31574, 31639, 31682, 31708, 31715, 31703, 31671, 31620, 31550, 31461, 31352, 31225, 31079, 30899, 30789, 30222, 28179, 27319, 27020, 26774, 26582, 26421, 26284, 26160, 26040, 25917, 25785, 25637, 25468, 25275, 25054, 24803, 24520, 24203, 23854, 23471, 23053, 22604, 22124, 21612, 21070, 20503, 19909, 19292, 18652, 17989, 17310, 16614, 15899, 15173, 14433, 13680, 12919, 12148, 11367, 10584, 9790, 8994, 8194, 7387, 6580, 5772, 4959, 4148, 3337, 2524, 1713, 905, 95, -709, -1512, -2314, -3109, -3902, -4692, -5476, -6254, -7046, -7741, -8866, -11445, -12814, -13598, -14305, -14929, -15497, -16017, -16495, -16943, -17368, -17775, -18172, -18563, -18951, -19340, -19733, -20128, -20532, -20941, -21357, -21780, -22207, -22639, -23076, -23515, -23953, -24390, -24826, -25258, -25683, -26101, -26512, -26912, -27300, -27677, -28040, -28387, -28720, -29036, -29334, -29615, -29878, -30120, -30344, -30548, -30730, -30894, -31037, -31158, -31259, -31340, -31399, -31437, -31453, -31448, -31425, -31378, -31311, -31222, -31115, -30987, -30854, -30611, -30786, -32401, -32794, -32588, -32294, -31909, -31454, -30941, -30382, -29781, -29149, -28495, -27822, -27136, -26444, -25746, -25050, -24354, -23661, -22974, -22293, -21615, -20944, -20278, -19617, -18961, -18308, -17657, -17009, -16360, -15711, -15062, -14411, -13754, -13098, -12436, -11768, -11097, -10420, -9738, -9051, -8358, -7659, -6955, -6243, -5528, -4808, -4082, -3352, -2619, -1881, -1142, -386};