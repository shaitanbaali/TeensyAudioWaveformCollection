/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0084 256 samples */
 
const int16_t AKWF_0084_256_DATA [256] = 
{656, 2375, 4024, 5602, 7070, 8399, 9566, 10556, 11359, 11973, 12402, 12665, 12783, 12777, 12684, 12537, 12371, 12226, 12140, 12150, 12286, 12583, 13067, 13771, 14719, 15896, 17281, 18835, 20519, 22297, 24110, 25900, 27607, 29153, 30470, 31492, 32165, 32463, 32359, 31845, 30922, 29599, 27908, 25883, 23574, 21052, 18369, 15599, 12822, 10095, 7501, 5114, 3007, 1264, -77, -1016, -1549, -1692, -1470, -912, -71, 1000, 2230, 3547, 4885, 6169, 7339, 8340, 9116, 9623, 9828, 9705, 9234, 8425, 7306, 5911, 4291, 2521, 672, -1185, -2978, -4661, -6171, -7458, -8487, -9224, -9663, -9808, -9671, -9281, -8672, -7891, -6986, -5999, -4994, -4019, -3124, -2358, -1764, -1374, -1221, -1320, -1689, -2333, -3258, -4467, -5940, -7656, -9558, -11583, -13679, -15764, -17762, -19624, -21284, -22689, -23804, -24593, -25035, -25125, -24871, -24291, -23408, -22266, -20907, -19373, -17724, -16007, -14266, -12560, -10929, -9405, -8030, -6827, -5811, -5003, -4402, -4008, -3809, -3788, -3909, -4136, -4435, -4761, -5075, -5336, -5505, -5548, -5440, -5163, -4702, -4054, -3232, -2248, -1120, 118, 1432, 2792, 4150, 5466, 6707, 7826, 8794, 9580, 10158, 10508, 10616, 10475, 10077, 9429, 8543, 7427, 6111, 4627, 3014, 1321, -397, -2093, -3713, -5202, -6525, -7641, -8520, -9150, -9517, -9627, -9490, -9127, -8561, -7827, -6964, -6014, -5020, -4032, -3098, -2269, -1604, -1146, -924, -950, -1225, -1748, -2505, -3478, -4631, -5917, -7296, -8710, -10105, -11428, -12620, -13634, -14426, -14953, -15183, -15090, -14665, -13907, -12839, -11496, -9932, -8197, -6367, -4502, -2662, -919, 675, 2074, 3225, 4103, 4679, 4942, 4893, 4542, 3913, 3033, 1944, 695, -662, -2077, -3486, -4844, -6093, -7178, -8062, -8707, -9086, -9185, -8994, -8520, -7775, -6782, -5573, -4180, -2647, -985};