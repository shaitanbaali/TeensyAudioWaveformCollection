/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0087 256 samples */
 
const int16_t AKWF_0087_256_DATA [256] = 
{559, 1843, 2985, 3899, 4751, 5556, 6320, 7046, 7739, 8406, 9044, 9656, 10246, 10810, 11353, 11876, 12366, 12832, 13281, 13697, 14105, 14490, 14859, 15215, 15555, 15880, 16190, 16485, 16764, 17031, 17285, 17525, 17750, 17965, 18167, 18358, 18536, 18705, 18864, 19013, 19155, 19289, 19418, 19543, 19665, 19793, 19950, 20111, 20223, 20317, 20437, 20492, 20584, 20642, 20703, 20766, 20822, 20864, 20897, 20920, 20932, 20934, 20929, 20912, 20886, 20848, 20799, 20739, 20670, 20587, 20494, 20393, 20277, 20152, 20017, 19871, 19713, 19545, 19367, 19186, 18953, 18683, 18418, 18102, 17800, 17476, 17153, 16830, 16506, 16179, 15843, 15505, 15164, 14816, 14466, 14113, 13754, 13391, 13025, 12653, 12280, 11902, 11522, 11141, 10758, 10374, 9991, 9606, 9224, 8843, 8459, 8095, 7632, 7102, 6610, 6006, 5449, 4857, 4274, 3707, 3151, 2556, 1854, 1171, 512, -126, -743, -1344, -1931, -2501, -2976, -3387, -3781, -4152, -4506, -4839, -5153, -5451, -5730, -5996, -6245, -6476, -6698, -6866, -7226, -7701, -8080, -8650, -9090, -9567, -9993, -10360, -10684, -10982, -11260, -11516, -11749, -11963, -12156, -12334, -12499, -12652, -12796, -12929, -13052, -13164, -13262, -13350, -13425, -13481, -13524, -13553, -13564, -13560, -13553, -13437, -13798, -14462, -14916, -15857, -16504, -17260, -17914, -18438, -18878, -19269, -19623, -19937, -20212, -20445, -20644, -20817, -20968, -21101, -21219, -21320, -21406, -21474, -21520, -21544, -21540, -21509, -21446, -21352, -21227, -21067, -20882, -20600, -20619, -20819, -20863, -21225, -21375, -21588, -21722, -21751, -21711, -21627, -21508, -21351, -21162, -20934, -20678, -20395, -20094, -19779, -19448, -19106, -18752, -18382, -17998, -17598, -17180, -16740, -16281, -15799, -15293, -14765, -14212, -13634, -13040, -12423, -11783, -11127, -10441, -9736, -9008, -8255, -7476, -6673, -5840, -4975, -4070, -3122, -1973, -666};