/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0064 256 samples */
 
const int16_t AKWF_0064_256_DATA [256] = 
{2570, 3679, 4380, 4969, 5471, 5924, 6337, 6716, 7072, 7409, 7729, 8034, 8328, 8609, 8885, 9150, 9406, 9656, 9900, 10139, 10371, 10601, 10823, 11044, 11260, 11473, 11681, 11888, 12090, 12291, 12489, 12684, 12878, 13068, 13259, 13446, 13631, 13815, 13996, 14177, 14356, 14534, 14710, 14885, 15058, 15231, 15402, 15573, 15743, 15912, 16080, 16246, 16413, 16422, 17416, 12387, 8035, 9127, 9236, 9491, 9737, 9980, 10217, 10448, 10675, 10897, 11116, 11331, 11543, 11452, 13298, 5571, -9687, -7698, -7701, -7379, -7040, -6683, -6300, -5884, -5428, -4918, -4307, -3619, -2387, 1601, 3481, 4134, 4783, 5310, 5778, 6204, 6592, 6956, 7298, 7624, 7934, 8232, 8516, 8794, 9062, 9321, 9574, 9819, 10060, 10294, 10524, 10749, 10971, 11188, 11402, 11612, 11819, 12023, 12225, 12423, 12619, 12446, 14606, 2460, -8138, -5802, -5737, -5265, -4730, -4064, -3423, -1239, 2628, 3670, 4371, 4969, 5471, 5635, 7634, 334, -14448, -12628, -12732, -12536, -12339, -12140, -11937, -11731, -11524, -11312, -11097, -10877, -10655, -10427, -10196, -9958, -9715, -9468, -9212, -8950, -8677, -8396, -8107, -7804, -7488, -7155, -6805, -6431, -6028, -5585, -5096, -4530, -3822, -3083, 206, 3205, 3887, 4585, 5144, 5627, 6066, 6466, 6838, 7185, 7518, 7452, 9784, -2647, -13695, -11497, -11662, -11454, -11241, -11024, -10803, -10580, -10350, -10118, -9878, -9634, -9383, -9248, -8313, -11271, -17397, -16548, -16508, -16342, -16175, -16009, -15840, -15671, -15501, -15330, -15158, -14985, -14811, -14635, -14459, -14280, -14101, -13920, -13737, -13552, -13367, -13178, -12988, -12797, -12601, -12406, -12207, -12005, -11800, -11594, -11383, -11169, -10951, -10729, -10504, -10273, -10038, -9797, -9551, -9298, -9039, -8769, -8491, -8205, -7906, -7595, -7268, -6924, -6558, -6167, -5737, -5265, -4730, -4072, -3405, -1304};