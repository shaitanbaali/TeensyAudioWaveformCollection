/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0063 256 samples */
 
const int16_t AKWF_0063_256_DATA [256] = 
{298, 750, 1191, 1633, 2075, 2517, 2959, 3396, 3827, 4252, 4669, 5081, 5486, 5882, 6269, 6646, 7011, 7366, 7712, 8044, 8364, 8670, 8963, 9243, 9507, 9756, 9990, 10207, 10406, 10589, 10755, 10902, 11033, 11147, 11246, 11331, 11403, 11465, 11517, 11555, 11577, 11586, 11587, 11584, 11576, 11561, 11540, 11514, 11485, 11454, 11422, 11391, 11364, 11339, 11319, 11301, 11284, 11269, 11255, 11241, 11230, 11227, 11230, 11236, 11240, 11242, 11247, 11256, 11266, 11276, 11285, 11291, 11293, 11294, 11291, 11284, 11271, 11251, 11224, 11190, 11148, 11097, 11038, 10969, 10889, 10800, 10701, 10591, 10470, 10338, 10195, 10043, 9880, 9707, 9524, 9331, 9129, 8920, 8702, 8475, 8243, 8005, 7760, 7510, 7256, 6997, 6736, 6471, 6203, 5935, 5665, 5393, 5101, 4713, 4196, 3658, 3205, 2786, 2284, 1675, 1027, 387, -234, -842, -1459, -2099, -2749, -3386, -3993, -4569, -5128, -5677, -6210, -6721, -7201, -7646, -8064, -8459, -8829, -9175, -9492, -9779, -10038, -10271, -10480, -10664, -10822, -10955, -11064, -11149, -11215, -11263, -11293, -11308, -11310, -11299, -11275, -11236, -11188, -11133, -11073, -11008, -10938, -10863, -10785, -10706, -10627, -10548, -10467, -10385, -10302, -10218, -10134, -10052, -9970, -9889, -9811, -9734, -9661, -9596, -9537, -9480, -9426, -9378, -9338, -9304, -9275, -9249, -9227, -9208, -9195, -9189, -9188, -9190, -9194, -9201, -9213, -9230, -9248, -9269, -9290, -9312, -9334, -9356, -9376, -9394, -9408, -9418, -9424, -9424, -9419, -9398, -9356, -9322, -9294, -9239, -9162, -9081, -8998, -8904, -8798, -8683, -8559, -8425, -8285, -8140, -7988, -7830, -7666, -7498, -7325, -7150, -6971, -6788, -6602, -6410, -6214, -6015, -5807, -5591, -5365, -5128, -4876, -4603, -4294, -3973, -3666, -3346, -2992, -2610, -2215, -1815, -1411, -998, -576, -133};