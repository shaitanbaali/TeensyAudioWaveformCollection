/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0069 256 samples */
 
const int16_t AKWF_0069_256_DATA [256] = 
{469, 1360, 2264, 3193, 4138, 5095, 6058, 7014, 7963, 8896, 9803, 10684, 11531, 12336, 13100, 13816, 14480, 15092, 15650, 16152, 16600, 16993, 17332, 17622, 17862, 18057, 18212, 18329, 18414, 18470, 18505, 18521, 18524, 18521, 18514, 18509, 18510, 18522, 18547, 18590, 18651, 18735, 18843, 18974, 19130, 19311, 19516, 19744, 19993, 20260, 20544, 20841, 21149, 21463, 21779, 22095, 22405, 22706, 22994, 23265, 23516, 23742, 23941, 24110, 24247, 24348, 24412, 24439, 24427, 24375, 24283, 24152, 23983, 23777, 23535, 23259, 22952, 22617, 22254, 21868, 21463, 21040, 20602, 20154, 19697, 19235, 18772, 18307, 17846, 17391, 16941, 16501, 16070, 15649, 15240, 14842, 14456, 14082, 13718, 13363, 13018, 12680, 12348, 12020, 11694, 11368, 11041, 10708, 10370, 10024, 9667, 9298, 8915, 8515, 8097, 7661, 7204, 6724, 6223, 5695, 5143, 4566, 3959, 3322, 2647, 1927, 1165, 362, -481, -1357, -2263, -3193, -4139, -5096, -6058, -7015, -7963, -8896, -9804, -10685, -11532, -12337, -13100, -13816, -14480, -15093, -15651, -16152, -16600, -16994, -17333, -17622, -17862, -18057, -18212, -18329, -18414, -18471, -18504, -18521, -18525, -18521, -18514, -18509, -18510, -18522, -18547, -18590, -18652, -18736, -18843, -18974, -19131, -19312, -19517, -19744, -19993, -20261, -20545, -20841, -21149, -21463, -21780, -22095, -22406, -22706, -22995, -23266, -23516, -23743, -23941, -24110, -24247, -24348, -24413, -24439, -24427, -24375, -24283, -24153, -23983, -23777, -23536, -23260, -22952, -22617, -22254, -21868, -21464, -21040, -20602, -20155, -19697, -19235, -18772, -18308, -17847, -17391, -16941, -16501, -16070, -15649, -15240, -14843, -14456, -14082, -13718, -13364, -13019, -12681, -12348, -12021, -11695, -11368, -11041, -10709, -10371, -10025, -9668, -9298, -8915, -8516, -8098, -7662, -7205, -6725, -6223, -5696, -5144, -4567, -3960, -3322, -2648, -1930, -1170, -351};