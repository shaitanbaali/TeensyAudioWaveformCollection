/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0100 256 samples */
 
const int16_t AKWF_0100_256_DATA [256] = 
{66, 409, 831, 1285, 1762, 2252, 2750, 3251, 3752, 4252, 4746, 5236, 5717, 6189, 6653, 7106, 7547, 7977, 8395, 8799, 9191, 9568, 9933, 10284, 10620, 10943, 11253, 11548, 11829, 12097, 12350, 12590, 12817, 13029, 13229, 13416, 13589, 13750, 13899, 14034, 14158, 14270, 14370, 14458, 14535, 14601, 14655, 14699, 14732, 14755, 14768, 14770, 14763, 14746, 14720, 14684, 14639, 14586, 14524, 14454, 14375, 14288, 14193, 14091, 13981, 13864, 13740, 13608, 13470, 13326, 13175, 13018, 12855, 12687, 12513, 12333, 12148, 11959, 11765, 11566, 11363, 11156, 10944, 10730, 10511, 10289, 10065, 9838, 9607, 9375, 9140, 8903, 8664, 8423, 8182, 7939, 7695, 7452, 7207, 6961, 6716, 6471, 6226, 5983, 5739, 5497, 5256, 5016, 4778, 4542, 4307, 4075, 3846, 3619, 3395, 3175, 2957, 2743, 2533, 2327, 2125, 1928, 1735, 1548, 1366, 1189, 1018, 855, 698, 548, 409, 278, 160, 58, -13, -92, -198, -312, -435, -562, -695, -830, -967, -1106, -1246, -1388, -1529, -1671, -1812, -1952, -2092, -2231, -2369, -2505, -2640, -2773, -2903, -3032, -3159, -3282, -3404, -3523, -3639, -3753, -3863, -3971, -4075, -4176, -4274, -4369, -4460, -4548, -4633, -4713, -4791, -4864, -4934, -5001, -5064, -5122, -5177, -5229, -5276, -5320, -5359, -5396, -5428, -5456, -5480, -5500, -5517, -5530, -5539, -5545, -5546, -5544, -5537, -5528, -5514, -5497, -5477, -5452, -5424, -5393, -5358, -5443, -4837, -8238, -20692, -27853, -30817, -32140, -32660, -32767, -32634, -32344, -31939, -31444, -30875, -30244, -29559, -28826, -28053, -27243, -26398, -25526, -24627, -23704, -22764, -21807, -20835, -19856, -18869, -17876, -16885, -15893, -14905, -13927, -12956, -11997, -11054, -10126, -9218, -8332, -7468, -6629, -5819, -5037, -4287, -3573, -2893, -2253, -1658, -1111, -622, -207};