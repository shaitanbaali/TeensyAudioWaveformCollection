/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0021 256 samples */
 
const int16_t AKWF_0021_256_DATA [256] = 
{-490, -1596, -2719, -3881, -5077, -6307, -7573, -8863, -10178, -11506, -12828, -14136, -15409, -16631, -17795, -18885, -19890, -20811, -21648, -22402, -23082, -23697, -24256, -24771, -25251, -25702, -26135, -26553, -26963, -27370, -27778, -28190, -28610, -29037, -29472, -29910, -30344, -30768, -31173, -31550, -31890, -32185, -32424, -32605, -32723, -32769, -32743, -32642, -32465, -32213, -31887, -31497, -31046, -30548, -30017, -29464, -28907, -28363, -27853, -27400, -27027, -26747, -26572, -26506, -26538, -26656, -26837, -27062, -27310, -27564, -27812, -28041, -28242, -28408, -28526, -28584, -28571, -28476, -28288, -28003, -27623, -27152, -26598, -25978, -25301, -24583, -23837, -23071, -22296, -21523, -20757, -20009, -19284, -18587, -17925, -17300, -16709, -16149, -15613, -15091, -14572, -14043, -13487, -12889, -12226, -11481, -10640, -9686, -8616, -7431, -6135, -4738, -3262, -1710, -103, 1533, 3183, 4809, 6377, 7862, 9228, 10456, 11542, 12480, 13280, 13958, 14525, 14995, 15380, 15689, 15934, 16126, 16278, 16407, 16535, 16680, 16864, 17103, 17402, 17772, 18211, 18712, 19267, 19866, 20498, 21153, 21816, 22476, 23122, 23739, 24312, 24831, 25278, 25644, 25921, 26102, 26191, 26185, 26095, 25929, 25695, 25410, 25082, 24726, 24356, 23984, 23624, 23287, 22988, 22732, 22529, 22385, 22299, 22274, 22303, 22380, 22498, 22646, 22813, 22986, 23156, 23308, 23433, 23521, 23563, 23551, 23478, 23345, 23156, 22918, 22648, 22359, 22064, 21779, 21511, 21263, 21038, 20835, 20652, 20492, 20356, 20253, 20185, 20156, 20167, 20215, 20296, 20397, 20510, 20622, 20723, 20805, 20861, 20885, 20875, 20826, 20735, 20597, 20410, 20171, 19880, 19537, 19145, 18709, 18235, 17732, 17208, 16668, 16124, 15576, 15031, 14494, 13968, 13456, 12959, 12478, 12014, 11568, 11134, 10712, 10296, 9881, 9460, 9028, 8574, 8090, 7573, 7009, 6397, 5733, 5009, 4229, 3390, 2495, 1549, 530};