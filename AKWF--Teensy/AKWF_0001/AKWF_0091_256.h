/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0091 256 samples */
 
const int16_t AKWF_0091_256_DATA [256] = 
{3059, 9593, 12494, 14873, 16614, 19636, 21333, 24359, 27620, 25563, 22246, 18274, 15670, 12237, 10570, 7355, -1467, -8160, -12892, -17622, -22403, -28152, -30405, -30815, -28820, -30106, -32799, -28923, -24993, -21797, -17960, -14155, -12386, -12186, -7465, -5905, -5917, -4673, -4641, -5893, -7208, -6598, -8182, -9101, -8825, -11282, -13383, -13705, -12800, -11055, -10615, -9844, -9803, -7973, -4518, -3453, -2254, -1576, 1975, 3870, 2737, 4359, 9101, 13075, 11742, 12506, 15604, 16105, 19744, 21046, 19940, 19877, 20478, 21024, 20247, 17941, 15192, 14817, 13816, 12614, 11320, 8501, 6391, 3810, 2333, 1773, 1583, 655, 1299, 3459, 2955, 3207, 5681, 8202, 10283, 12261, 11034, 11352, 12265, 13400, 14362, 14572, 16158, 14137, 10852, 9864, 9580, 7095, 2132, 300, -2338, -3652, -4785, -6798, -8601, -10414, -8872, -9436, -12481, -15326, -13674, -9301, -8408, -8446, -7036, -6750, -4420, -1572, -550, -523, -1365, -2820, -6120, -6462, -8109, -10869, -10686, -10346, -10344, -12306, -14365, -15530, -14973, -13925, -14567, -16841, -14602, -11097, -11365, -11918, -8643, -3099, -2018, -1684, -1360, -1239, 1138, 2994, 3826, 2224, 573, 3496, 6217, 5790, 4723, 2664, 2158, 2546, 1861, 1847, 163, -933, -1215, 556, 1932, -1476, -1649, 978, 2377, 1936, 886, 1067, 1506, 3370, 5605, 5650, 6361, 8493, 9553, 10613, 12366, 12251, 10677, 10014, 11744, 11154, 9526, 8082, 7794, 6177, 5128, 4239, 1442, 457, -1085, -431, -2173, -5625, -6249, -7394, -7205, -6245, -4459, -1324, -996, -1355, 281, 2668, 3909, 5237, 3839, 5614, 7843, 8826, 7882, 6101, 7505, 6723, 4843, 2242, 929, -209, -1460, -2073, -5294, -7600, -8441, -6694, -4066, -5404, -6412, -5542, -5575, -4927, -3443, -3229, -2687, -2779, -3570, -2883, -2566, -3816, -1863, -353, -2821, -2447};