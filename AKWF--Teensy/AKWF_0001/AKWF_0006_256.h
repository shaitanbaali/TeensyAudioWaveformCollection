/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0006 256 samples */
 
const int16_t AKWF_0006_256_DATA [256] = 
{1111, 2518, 3718, 4836, 5895, 6910, 7892, 8842, 9767, 10668, 11543, 12395, 13224, 14027, 14808, 15565, 16296, 17003, 17686, 18342, 18975, 19581, 20162, 20721, 21254, 21766, 22255, 22725, 23174, 23609, 24032, 24446, 24896, 25488, 26096, 26594, 27010, 27375, 27700, 28003, 28199, 27792, 27069, 26577, 26239, 25971, 25735, 25513, 25290, 25056, 24807, 24541, 24251, 23939, 23610, 23264, 22904, 22535, 22158, 21782, 21413, 21055, 20722, 20425, 20201, 20301, 20653, 20867, 20951, 20983, 20994, 21002, 21014, 21033, 21063, 21104, 21154, 21212, 21276, 21343, 21410, 21476, 21537, 21591, 21636, 21670, 21690, 21695, 21683, 21653, 21603, 21533, 21439, 21324, 21184, 21020, 20829, 20613, 20370, 20098, 19800, 19474, 19119, 18735, 18323, 17882, 17415, 16917, 16391, 15841, 15262, 14657, 14029, 13376, 12698, 12002, 11281, 10540, 9779, 8999, 8197, 7376, 6529, 5650, 4719, 3667, 2511, 1222, -299, -1660, -2797, -3836, -4809, -5739, -6636, -7503, -8348, -9174, -9975, -10762, -11530, -12278, -13009, -13722, -14414, -15089, -15742, -16375, -16991, -17585, -18157, -18710, -19243, -19755, -20249, -20723, -21177, -21617, -22039, -22447, -22843, -23227, -23616, -23844, -23658, -23296, -22992, -22759, -22574, -22422, -22290, -22168, -22048, -21924, -21796, -21661, -21517, -21367, -21213, -21055, -20897, -20744, -20595, -20456, -20333, -20231, -20157, -20123, -20151, -20456, -21050, -21534, -21872, -22146, -22388, -22617, -22840, -23059, -23275, -23493, -23709, -23922, -24130, -24331, -24522, -24701, -24869, -25021, -25157, -25276, -25376, -25456, -25514, -25551, -25565, -25555, -25522, -25465, -25381, -25271, -25134, -24969, -24776, -24554, -24301, -24018, -23703, -23357, -22980, -22569, -22123, -21644, -21133, -20586, -20006, -19394, -18748, -18070, -17361, -16622, -15855, -15060, -14239, -13395, -12527, -11637, -10727, -9797, -8847, -7877, -6878, -5843, -4714, -3456, -2114, -507};