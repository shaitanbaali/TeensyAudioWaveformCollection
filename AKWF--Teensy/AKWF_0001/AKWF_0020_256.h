/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0020 256 samples */
 
const int16_t AKWF_0020_256_DATA [256] = 
{244, 985, 1743, 2509, 3689, 4986, 5962, 6994, 8029, 9062, 10080, 11087, 12075, 13039, 13980, 14895, 15830, 15348, 15277, 15802, 15963, 16052, 16100, 16119, 16116, 16096, 16059, 16012, 15954, 15890, 15820, 15744, 15666, 15585, 15502, 15418, 15331, 15245, 15156, 15068, 14979, 14889, 14798, 14706, 14613, 14519, 14424, 14327, 14230, 14130, 14028, 13924, 13818, 13710, 13600, 13487, 13371, 13253, 13131, 13006, 12879, 12748, 12614, 12478, 12338, 12194, 12048, 11899, 11746, 11591, 11433, 11272, 11108, 10942, 10775, 10605, 10433, 10261, 10087, 9912, 9738, 9565, 9393, 9225, 9060, 8901, 8753, 8622, 8495, 8538, 9022, 9185, 9296, 9430, 9561, 9685, 9797, 9894, 9974, 10035, 10078, 10102, 10106, 10091, 10057, 10004, 9933, 9843, 9735, 9610, 9467, 9307, 9131, 8939, 8732, 8510, 8273, 8023, 7759, 7482, 7193, 6893, 6580, 6257, 5924, 5581, 5230, 4870, 4501, 4126, 3744, 3354, 2960, 2560, 2155, 1747, 1335, 920, 502, 82, -339, -761, -1185, -1606, -2032, -2674, -3229, -3692, -4244, -4830, -5440, -6071, -6718, -7380, -8059, -8750, -9454, -10172, -10910, -11638, -12624, -13870, -14753, -15633, -16493, -17323, -18115, -18860, -19551, -20188, -20696, -20761, -20957, -21218, -21397, -21530, -21621, -21675, -21695, -21686, -21646, -21579, -21486, -21368, -21226, -21060, -20872, -20663, -20433, -20182, -19912, -19624, -19318, -18995, -18654, -18298, -17927, -17540, -17139, -16726, -16299, -15859, -15407, -14945, -14471, -13989, -13497, -12993, -12487, -12275, -11939, -11464, -11125, -10857, -10674, -11245, -11619, -11681, -11828, -11972, -12109, -12230, -12328, -12400, -12443, -12456, -12439, -12390, -12310, -12199, -12056, -11883, -11680, -11447, -11187, -10897, -10580, -10238, -9869, -9475, -9058, -8618, -8155, -7671, -7166, -6642, -6099, -5537, -4957, -4363, -3750, -3122, -2479, -1821, -1149, -446};