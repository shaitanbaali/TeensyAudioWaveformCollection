/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0082 256 samples */
 
const int16_t AKWF_0082_256_DATA [256] = 
{341, 1417, 2449, 3464, 4456, 5438, 6424, 7412, 8408, 9426, 10489, 11515, 12435, 13344, 14233, 15080, 15875, 16620, 17310, 17942, 18519, 19040, 19511, 19934, 20314, 20654, 20960, 21232, 21474, 21691, 21884, 22056, 22209, 22345, 22466, 22573, 22669, 22754, 22829, 22896, 22955, 23008, 23055, 23096, 23133, 23166, 23195, 23221, 23245, 23264, 23283, 23299, 23313, 23326, 23337, 23347, 23356, 23364, 23371, 23377, 23383, 23388, 23392, 23395, 23399, 23402, 23405, 23407, 23409, 23411, 23413, 23414, 23416, 23417, 23418, 23419, 23419, 23420, 23421, 23421, 23422, 23422, 23423, 23423, 23423, 23424, 23424, 23424, 23424, 23424, 23424, 23425, 23361, 23237, 23098, 22924, 22708, 22448, 22146, 21801, 21415, 20991, 20531, 20039, 19517, 18968, 18394, 17797, 17177, 16538, 15875, 15191, 14486, 13754, 12991, 12198, 11305, 10275, 9296, 8302, 7264, 6201, 5118, 4027, 2934, 1843, 765, -297, -1342, -2363, -3362, -4339, -5291, -6221, -7130, -8013, -8878, -9723, -10546, -11355, -12163, -12984, -13832, -14613, -15322, -16022, -16694, -17327, -17921, -18472, -18979, -19444, -19866, -20245, -20589, -20897, -21172, -21420, -21641, -21839, -22015, -22171, -22311, -22436, -22546, -22644, -22732, -22809, -22878, -22940, -22995, -23043, -23086, -23124, -23158, -23188, -23215, -23239, -23260, -23278, -23295, -23310, -23323, -23334, -23345, -23354, -23362, -23369, -23375, -23381, -23387, -23391, -23395, -23398, -23402, -23404, -23407, -23409, -23411, -23413, -23414, -23416, -23417, -23418, -23419, -23420, -23420, -23421, -23421, -23422, -23423, -23423, -23424, -23423, -23424, -23425, -23424, -23425, -23424, -23425, -23425, -23428, -23377, -23246, -23096, -22912, -22683, -22405, -22081, -21710, -21293, -20836, -20339, -19806, -19244, -18652, -18035, -17396, -16732, -16048, -15344, -14617, -13864, -13085, -12272, -11366, -10324, -9329, -8325, -7279, -6203, -5112, -4013, -2909, -1813, -705};