/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0025 256 samples */
 
const int16_t AKWF_0025_256_DATA [256] = 
{2199, 6008, 9636, 13063, 16261, 19182, 21822, 24186, 26233, 27965, 29394, 30555, 31479, 32156, 32599, 32768, 32630, 32188, 31450, 30433, 29117, 27481, 25538, 23287, 20777, 18097, 15274, 12329, 9276, 6136, 2989, -75, -3018, -5801, -8429, -10903, -13128, -15070, -16735, -18107, -19259, -20225, -21030, -21669, -22109, -22430, -22633, -22668, -22543, -22255, -21831, -21241, -20404, -19349, -18138, -16824, -15385, -13759, -12016, -10187, -8255, -6262, -4202, -2151, -212, 1646, 3440, 5106, 6668, 8053, 9104, 9905, 10560, 11168, 11743, 12022, 12069, 12063, 11959, 11784, 11485, 11095, 10773, 10403, 9812, 9028, 8232, 7487, 6719, 5999, 5382, 4719, 3850, 2701, 1430, 384, -341, -923, -1498, -2313, -3359, -4168, -4551, -4626, -4765, -5378, -6117, -6431, -6222, -5624, -4980, -4457, -4020, -3804, -3824, -3754, -3241, -2321, -1398, -826, -655, -621, -404, 168, 1115, 2210, 2983, 3164, 2886, 2367, 1852, 1553, 1464, 1489, 1424, 1156, 946, 1006, 1134, 967, 343, -529, -1261, -1577, -1316, -386, 1018, 2464, 3644, 4509, 4991, 4898, 4238, 3233, 2066, 826, -556, -2113, -3648, -4803, -5237, -4818, -3779, -2601, -1653, -890, 20, 1251, 2550, 3468, 3817, 3720, 3354, 2731, 1699, 96, -2167, -5118, -8672, -12544, -16267, -19211, -20825, -21022, -19994, -17914, -15005, -11379, -6997, -2028, 2983, 7427, 10963, 13576, 15405, 16530, 16958, 16686, 15719, 14153, 12234, 10275, 8547, 7224, 6423, 6163, 6420, 7259, 8768, 10986, 13792, 16890, 19934, 22608, 24575, 25435, 24903, 23032, 20038, 16105, 11452, 6364, 1153, -3972, -8897, -13503, -17641, -21127, -23812, -25660, -26705, -27027, -26768, -26081, -25121, -24060, -23068, -22275, -21778, -21605, -21696, -21987, -22391, -22800, -23087, -23162, -22943, -22335, -21242, -19606, -17451, -14870, -11930, -8688, -5196, -1446};