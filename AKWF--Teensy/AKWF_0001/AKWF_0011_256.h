/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0011 256 samples */
 
const int16_t AKWF_0011_256_DATA [256] = 
{123, 974, 2338, 4032, 5969, 8082, 10304, 12565, 14816, 17009, 19094, 21047, 22842, 24459, 25900, 27161, 28244, 29166, 29937, 30571, 31088, 31502, 31827, 32081, 32275, 32421, 32528, 32606, 32662, 32701, 32726, 32743, 32754, 32760, 32764, 32766, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32767, 32766, 32767, 32767, 32768, 32767, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32768, 32767, 32768, 32767, 32766, 32762, 32755, 32742, 32720, 32683, 32626, 32542, 32423, 32260, 32043, 31761, 31406, 30967, 30434, 29801, 29062, 28209, 27246, 26168, 24976, 23682, 22286, 20798, 19237, 17609, 15932, 14230, 12514, 10807, 9137, 7517, 5976, 4541, 3229, 2073, 1107, 369, -2, -378, -1104, -2038, -3134, -4360, -5681, -7075, -8520, -9989, -11468, -12941, -14385, -15794, -17155, -18455, -19693, -20862, -21953, -22973, -23917, -24784, -25580, -26306, -26964, -27560, -28096, -28577, -29008, -29393, -29735, -30039, -30307, -30545, -30754, -30938, -31100, -31241, -31365, -31473, -31566, -31647, -31717, -31776, -31826, -31868, -31903, -31930, -31950, -31965, -31974, -31977, -31974, -31967, -31953, -31934, -31909, -31878, -31840, -31796, -31744, -31685, -31617, -31541, -31453, -31358, -31420, -31627, -31848, -32079, -32305, -32498, -32639, -32722, -32758, -32767, -32767, -32767, -32758, -32726, -32654, -32535, -32373, -32186, -31998, -31838, -31727, -31680, -31699, -31779, -31906, -32060, -32224, -32378, -32511, -32614, -32686, -32732, -32755, -32765, -32767, -32767, -32768, -32766, -32758, -32736, -32692, -32613, -32487, -32303, -32045, -31703, -31262, -30711, -30039, -29232, -28282, -27184, -25924, -24506, -22931, -21199, -19326, -17332, -15233, -13070, -10885, -8712, -6618, -4661, -2904, -1429, -364};