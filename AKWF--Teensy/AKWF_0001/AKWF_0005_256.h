/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0005 256 samples */
 
const int16_t AKWF_0005_256_DATA [256] = 
{39, 287, 679, 1168, 1736, 2371, 3062, 3798, 4571, 5377, 6202, 7047, 7903, 8760, 9622, 10479, 11325, 12161, 12981, 13784, 14568, 15327, 16064, 16775, 17462, 18123, 18759, 19370, 19958, 20523, 21066, 21594, 22110, 22624, 23160, 23648, 24980, 26503, 26475, 26672, 26980, 27273, 27496, 28083, 26084, 21380, 22363, 22767, 22637, 22465, 22228, 21937, 21596, 21210, 20784, 20324, 19839, 19336, 18817, 18295, 17778, 17270, 16784, 16327, 15913, 15560, 15306, 15107, 15699, 18388, 18074, 17320, 17213, 17147, 17134, 17158, 17212, 17287, 17378, 17478, 17583, 17688, 17790, 17882, 17961, 18028, 18075, 18103, 18109, 18089, 18044, 17971, 17869, 17737, 17574, 17378, 17150, 16889, 16595, 16264, 15903, 15507, 15077, 14615, 14120, 13594, 13038, 12455, 11844, 11211, 10555, 9881, 9193, 8491, 7782, 7071, 6358, 5651, 4957, 4277, 3618, 2989, 2391, 1835, 1328, 875, 492, 189, 17, -107, -368, -725, -1154, -1645, -2190, -2779, -3407, -4069, -4756, -5468, -6196, -6934, -7683, -8436, -9188, -9939, -10685, -11421, -12147, -12857, -13555, -14235, -14898, -15540, -16164, -16767, -17349, -17914, -18457, -18982, -19490, -19986, -20470, -20945, -21411, -21920, -22416, -20425, -18392, -18467, -18496, -18452, -18387, -18298, -18182, -18040, -17875, -17689, -17490, -17279, -17062, -16845, -16633, -16430, -16240, -16071, -15930, -15820, -15753, -15743, -15821, -15988, -16634, -19575, -20026, -19424, -19586, -19790, -20028, -20292, -20570, -20857, -21144, -21427, -21702, -21963, -22207, -22432, -22634, -22813, -22965, -23089, -23184, -23250, -23283, -23286, -23256, -23192, -23093, -22960, -22791, -22585, -22342, -22061, -21740, -21380, -20979, -20537, -20056, -19531, -18965, -18360, -17712, -17025, -16302, -15542, -14747, -13923, -13071, -12197, -11304, -10396, -9480, -8563, -7648, -6745, -5861, -5000, -4172, -3388, -2650, -1972, -1363, -835, -403, -99};