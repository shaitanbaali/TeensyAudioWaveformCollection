/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0073 256 samples */
 
const int16_t AKWF_0073_256_DATA [256] = 
{-2468, -7141, -11234, -14782, -17783, -20299, -22423, -24240, -25832, -27254, -28560, -29699, -30596, -31240, -31559, -31560, -31240, -30610, -29713, -28589, -27272, -25803, -24219, -22567, -20899, -19251, -17647, -16104, -14624, -13197, -11814, -10457, -9113, -7780, -6437, -5199, -4170, -3413, -3033, -3039, -3437, -4188, -5223, -6473, -7867, -9345, -10866, -12342, -13718, -14971, -16069, -17015, -17826, -18518, -19120, -19656, -20146, -20610, -21043, -21371, -21588, -21639, -21513, -21201, -20706, -20049, -19255, -18348, -17356, -16300, -15207, -14115, -13038, -11994, -10999, -10050, -9144, -8275, -7433, -6612, -5810, -5005, -4282, -3886, -3853, -4369, -5439, -7058, -9152, -11602, -14284, -17076, -19882, -22653, -25244, -27479, -29368, -30847, -31967, -32493, -32485, -31889, -30789, -29370, -27741, -26069, -24471, -23179, -22416, -22186, -22543, -23287, -24198, -25143, -25941, -26523, -26706, -26495, -25877, -24903, -23697, -22341, -20925, -19576, -18113, -16234, -13860, -10706, -6783, -2236, 2654, 7224, 11188, 14559, 17377, 19723, 21723, 23464, 25017, 26421, 27550, 28417, 28943, 29114, 28933, 28408, 27576, 26492, 25200, 23748, 22189, 20588, 18988, 17436, 15945, 14528, 13183, 11887, 10632, 9396, 8159, 6921, 5844, 4973, 4425, 4262, 4491, 5101, 6039, 7228, 8583, 10042, 11543, 12982, 14323, 15519, 16550, 17426, 18156, 18768, 19296, 19764, 20199, 20602, 20896, 21077, 21086, 20912, 20546, 19994, 19277, 18425, 17466, 16433, 15355, 14269, 13200, 12171, 11191, 10263, 9385, 8545, 7737, 6948, 6168, 5409, 4939, 4827, 5235, 6236, 7802, 9878, 12354, 15077, 17913, 20768, 23548, 26031, 28176, 29920, 31284, 32289, 32723, 32672, 32059, 30969, 29533, 27883, 26166, 24529, 23026, 21916, 21270, 21134, 21519, 22305, 23293, 24309, 25211, 25888, 26330, 26405, 26138, 25517, 24570, 23368, 22005, 20562, 19136, 17807, 16508, 14869, 12816, 10052, 6525, 2144};