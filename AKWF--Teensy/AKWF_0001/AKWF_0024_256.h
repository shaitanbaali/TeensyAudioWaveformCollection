/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0024 256 samples */
 
const int16_t AKWF_0024_256_DATA [256] = 
{4283, 16850, 25896, 29927, 28861, 23955, 17066, 9989, 3936, -489, -3205, -4512, -4835, -4613, -4195, -3806, -3551, -3444, -3443, -3483, -3501, -3451, -3309, -3069, -2748, -2365, -1947, -1519, -1102, -711, -358, -48, 218, 439, 617, 755, 855, 921, 955, 960, 941, 901, 842, 770, 686, 596, 502, 407, 314, 224, 140, 65, -3, -61, -110, -151, -182, -204, -218, -225, -225, -219, -208, -194, -176, -155, -133, -112, -89, -68, -48, -29, -11, 4, 17, 27, 36, 43, 48, 51, 52, 51, 49, 47, 43, 39, 34, 29, 24, 19, 14, 9, 5, 1, -1, -5, -8, -9, -11, -12, -13, -12, -13, -12, -11, -10, -9, -8, -7, -6, -5, -3, -2, -1, -1, 4, 32, 128, 418, 1172, 2800, 5737, 10148, 15379, 19772, 27050, 23509, 9954, -5843, -20109, -29546, -32828, -30500, -24362, -16581, -9033, -2876, 1405, 3859, 4884, 4976, 4598, 4100, 3693, 3459, 3393, 3432, 3505, 3544, 3501, 3354, 3104, 2768, 2372, 1942, 1505, 1082, 688, 333, 24, -241, -460, -637, -773, -871, -935, -968, -971, -951, -908, -848, -774, -689, -597, -502, -406, -312, -222, -137, -61, 6, 65, 115, 154, 185, 207, 221, 227, 227, 220, 209, 194, 175, 154, 132, 111, 88, 66, 46, 27, 9, -5, -18, -30, -38, -44, -50, -53, -54, -53, -51, -48, -45, -40, -35, -30, -25, -20, -15, -10, -5, -2, 2, 4, 7, 9, 10, 11, 12, 11, 12, 11, 10, 9, 8, 7, 6, 5, 4, 2, 1, 0, -1, -5, -41, -157, -499, -1371, -3213, -6452, -11156, -16520, -20756, -21607, -17396, -7739};