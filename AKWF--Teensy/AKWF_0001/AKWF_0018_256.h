/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0018 256 samples */
 
const int16_t AKWF_0018_256_DATA [256] = 
{121, 293, 449, 575, 676, 757, 830, 902, 972, 1042, 1115, 1193, 1272, 1356, 1448, 1545, 1643, 1751, 1865, 1985, 2113, 2247, 2390, 2546, 2706, 2879, 3064, 3259, 3468, 3691, 3927, 4180, 4449, 4736, 5042, 5371, 5723, 6096, 6497, 6923, 7381, 7872, 8391, 8948, 9543, 10174, 10846, 11560, 12316, 13116, 13958, 14842, 15768, 16733, 17730, 18761, 19814, 20884, 21966, 23044, 24110, 25160, 26175, 27146, 28066, 28921, 29704, 30408, 31026, 31554, 31987, 32325, 32568, 32716, 32769, 32731, 32603, 32392, 32101, 31733, 31294, 30787, 30219, 29595, 28919, 28195, 27434, 26630, 25797, 24936, 24049, 23144, 22225, 21292, 20353, 19409, 18462, 17518, 16579, 15644, 14722, 13811, 12911, 12030, 11166, 10318, 9496, 8693, 7911, 7156, 6426, 5720, 5042, 4395, 3773, 3182, 2621, 2090, 1596, 1134, 712, 331, -2, -241, -349, -610, -917, -1247, -1564, -1818, -1984, -2075, -2117, -2129, -2124, -2114, -2101, -2090, -2079, -2073, -2074, -2078, -2088, -2102, -2122, -2148, -2180, -2217, -2261, -2310, -2369, -2435, -2508, -2588, -2676, -2773, -2880, -2998, -3124, -3262, -3413, -3576, -3753, -3943, -4151, -4373, -4614, -4875, -5155, -5456, -5782, -6133, -6509, -6914, -7352, -7820, -8322, -8861, -9438, -10052, -10711, -11409, -12152, -12939, -13773, -14643, -15560, -16514, -17502, -18522, -19563, -20623, -21692, -22756, -23810, -24841, -25840, -26793, -27693, -28526, -29288, -29968, -30560, -31064, -31474, -31787, -32005, -32128, -32157, -32096, -31947, -31713, -31399, -31014, -30556, -30034, -29450, -28813, -28124, -27393, -26619, -25809, -24970, -24106, -23214, -22309, -21389, -20458, -19524, -18583, -17643, -16707, -15776, -14852, -13940, -13042, -12155, -11289, -10440, -9610, -8805, -8019, -7259, -6524, -5815, -5133, -4478, -3852, -3258, -2695, -2162, -1663, -1202, -780, -402, -76};