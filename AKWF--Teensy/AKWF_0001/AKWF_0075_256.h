/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0075 256 samples */
 
const int16_t AKWF_0075_256_DATA [256] = 
{516, 1472, 1721, 2666, 3676, 4200, 4977, 5669, 6118, 6657, 7104, 7423, 7759, 8019, 8208, 8387, 8513, 8599, 8682, 8668, 9162, 10081, 10252, 11096, 12097, 12587, 13327, 14023, 14463, 14997, 15458, 15783, 16129, 16407, 16608, 16801, 16945, 17044, 17129, 17182, 17211, 17229, 17230, 17219, 17203, 17179, 17151, 17123, 17093, 17064, 17036, 17010, 16987, 16968, 16950, 16936, 16925, 16917, 16911, 16908, 16907, 16908, 16910, 16914, 16918, 16923, 16926, 16936, 16938, 16130, 15514, 15247, 14146, 13359, 12813, 11980, 11382, 10901, 10331, 9914, 9566, 9210, 8954, 8745, 8553, 8422, 8317, 8281, 7604, 6779, 6582, 5598, 4692, 4198, 3420, 2783, 2346, 1810, 1389, 1073, 739, 489, 293, 131, -72, -1079, -1621, -2058, -3227, -3928, -4521, -5341, -5872, -6350, -6883, -7245, -7571, -7887, -8102, -8288, -8450, -8559, -8599, -9307, -10125, -10331, -11336, -12238, -12739, -13526, -14163, -14605, -15147, -15570, -15890, -16228, -16481, -16674, -16856, -16984, -17075, -17151, -17194, -17217, -17230, -17224, -17210, -17191, -17164, -17136, -17107, -17080, -17041, -17058, -17914, -18423, -18744, -19865, -20584, -21151, -21984, -22551, -23045, -23614, -24019, -24376, -24732, -24986, -25203, -25398, -25529, -25634, -25716, -25762, -25791, -25804, -25800, -25786, -25765, -25736, -25704, -25671, -25637, -25603, -25572, -25543, -25506, -25534, -25143, -24169, -23948, -23178, -22092, -21551, -20814, -20051, -19573, -19022, -18517, -18166, -17805, -17501, -17287, -17086, -16931, -16830, -16744, -16691, -16666, -16653, -16659, -16678, -16702, -16735, -16772, -16809, -16848, -16886, -16921, -16945, -17028, -16538, -15674, -15517, -14634, -13648, -13140, -12364, -11654, -11184, -10616, -10134, -9780, -9407, -9110, -8888, -8676, -8519, -8406, -8333, -7540, -6797, -6551, -5490, -4647, -4134, -3334, -2731, -2286, -1746, -1344, -1027, -697, -458, -270, -94};