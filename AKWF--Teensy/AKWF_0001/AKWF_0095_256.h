/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0095 256 samples */
 
const int16_t AKWF_0095_256_DATA [256] = 
{-2631, -10046, -15254, -18920, -21434, -23123, -24232, -24931, -25347, -25569, -25653, -25644, -25569, -25449, -25297, -25123, -24935, -24737, -24531, -24320, -24105, -23888, -23670, -23451, -23230, -23009, -22788, -22566, -22345, -22123, -21901, -21679, -21457, -21235, -21013, -20791, -20569, -20347, -20124, -19902, -19680, -19458, -19236, -19014, -18792, -18570, -18347, -18125, -17904, -17681, -17459, -17237, -17015, -16792, -16571, -16348, -16126, -15904, -15682, -15460, -15238, -15016, -14793, -14571, -14349, -14127, -13905, -13682, -13460, -13238, -13016, -12794, -12572, -12349, -12128, -11905, -11683, -11461, -11239, -11016, -10795, -10572, -10350, -10128, -9906, -9683, -9462, -9240, -9017, -8795, -8573, -8351, -8129, -7907, -7684, -7463, -7240, -7018, -6796, -6574, -6352, -6130, -5907, -5686, -5463, -5241, -5019, -4797, -4575, -4353, -4131, -3908, -3686, -3464, -3242, -3020, -2798, -2575, -2353, -2131, -1909, -1687, -1465, -1243, -1021, -798, -576, -354, -132, 90, 313, 535, 757, 979, 1201, 1423, 1645, 1868, 2090, 2312, 2534, 2756, 2978, 3200, 3422, 3645, 3867, 4089, 4311, 4534, 4755, 4978, 5200, 5422, 5644, 5866, 6088, 6311, 6532, 6755, 6977, 7199, 7421, 7643, 7865, 8087, 8310, 8532, 8754, 8977, 9198, 9421, 9643, 9865, 10087, 10309, 10531, 10753, 10975, 11197, 11419, 11642, 11864, 12086, 12308, 12530, 12753, 12975, 13196, 13419, 13641, 13863, 14086, 14308, 14530, 14752, 14974, 15196, 15418, 15641, 15863, 16085, 16307, 16529, 16752, 16973, 17196, 17418, 17640, 17862, 18084, 18306, 18529, 18751, 18973, 19195, 19417, 19639, 19862, 20084, 20306, 20528, 20750, 20972, 21194, 21416, 21638, 21861, 22083, 22305, 22527, 22749, 22971, 23194, 23416, 23638, 23860, 24082, 24304, 24526, 24748, 24970, 25193, 25414, 25637, 25859, 26081, 26304, 26526, 26748, 26970, 27070, 27865, 24633, 15712, 6473};