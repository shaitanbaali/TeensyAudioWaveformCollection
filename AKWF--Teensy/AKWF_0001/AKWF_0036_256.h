/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0036 256 samples */
 
const int16_t AKWF_0036_256_DATA [256] = 
{1062, 3121, 5138, 7146, 9135, 11104, 13049, 14964, 16852, 18708, 20515, 22271, 23953, 25536, 27008, 28343, 29517, 30521, 31341, 31972, 32414, 32677, 32769, 32704, 32495, 32158, 31705, 31147, 30493, 29749, 28921, 28016, 27035, 25996, 24907, 23780, 22640, 21504, 20393, 19331, 18336, 17420, 16601, 15877, 15256, 14740, 14320, 13994, 13764, 13626, 13625, 13687, 13736, 13820, 13955, 14158, 14438, 14805, 15261, 15809, 16444, 17159, 17940, 18780, 19663, 20576, 21513, 22465, 23423, 24386, 25349, 26304, 27245, 28163, 29039, 29861, 30610, 31261, 31795, 32192, 32434, 32504, 32399, 32116, 31652, 31021, 30235, 29302, 28242, 27070, 25795, 24429, 22981, 21452, 19852, 18182, 16443, 14650, 12808, 10931, 9039, 7147, 5275, 3446, 1671, -32, -1650, -3188, -4640, -6004, -7294, -8512, -9663, -10759, -11795, -12771, -13795, -14864, -15881, -16853, -17767, -18604, -19347, -19972, -20463, -20817, -21031, -21119, -21100, -21001, -20846, -20665, -20478, -20303, -20152, -20033, -19948, -19903, -19895, -19925, -19998, -20113, -20271, -20472, -20714, -20994, -21302, -21628, -21960, -22286, -22585, -22848, -23063, -23220, -23316, -23353, -23333, -23262, -23154, -23016, -22861, -22692, -22512, -22325, -22123, -21900, -21649, -21359, -21025, -20641, -20207, -19725, -19200, -18644, -18069, -17488, -16915, -16357, -15824, -15326, -14863, -14437, -14069, -13802, -13450, -12972, -12419, -11803, -11141, -10445, -9736, -9027, -8334, -7673, -7052, -6476, -5949, -5468, -5030, -4636, -4275, -3948, -3659, -3408, -3203, -3056, -2974, -2969, -3054, -3233, -3510, -3884, -4351, -4904, -5530, -6223, -6970, -7759, -8587, -9446, -10335, -11253, -12196, -13166, -14158, -15163, -16168, -17164, -18127, -19035, -19870, -20606, -21227, -21718, -22064, -22263, -22315, -22222, -21989, -21626, -21143, -20546, -19842, -19034, -18120, -17097, -15965, -14714, -13344, -11858, -10255, -8546, -6743, -4862, -2924, -898};