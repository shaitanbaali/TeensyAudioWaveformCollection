/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0053 256 samples */
 
const int16_t AKWF_0053_256_DATA [256] = 
{76, 326, 570, 809, 1039, 1259, 1468, 1666, 1855, 2037, 2211, 2379, 2543, 2700, 2853, 3004, 3151, 3295, 3436, 3574, 3711, 3846, 3979, 4109, 4239, 4367, 4494, 4619, 4743, 4865, 4988, 5108, 5228, 5347, 5464, 5582, 5698, 5814, 5928, 6041, 6155, 6268, 6380, 6491, 6601, 6711, 6821, 6930, 7038, 7146, 7254, 7361, 7467, 7573, 7678, 7784, 7889, 7993, 8097, 8201, 8303, 8406, 8509, 8611, 8713, 8814, 8915, 9016, 9117, 9217, 9316, 9416, 9515, 9615, 9713, 9811, 9909, 10008, 10106, 10203, 10300, 10397, 10494, 10591, 10686, 10783, 10878, 10975, 11070, 11166, 11260, 11356, 11450, 11545, 11639, 11733, 11828, 11921, 12015, 12108, 12202, 12295, 12388, 12481, 12574, 12666, 12758, 12851, 12943, 13035, 13127, 13218, 13310, 13402, 13493, 13585, 13676, 13766, 13857, 13949, 14039, 14127, 14215, 14273, 13847, 12143, 7603, 830, -3971, -7385, -9761, -11028, -11454, -11464, -11416, -11546, -11921, -12449, -12965, -13346, -13544, -13573, -13487, -13346, -13199, -13077, -12989, -12929, -12882, -12833, -12772, -12695, -12606, -12510, -12410, -12310, -12215, -12121, -12030, -11941, -11849, -11757, -11664, -11570, -11474, -11379, -11283, -11188, -11093, -10998, -10902, -10807, -10711, -10614, -10518, -10421, -10324, -10227, -10130, -10032, -9933, -9836, -9738, -9639, -9540, -9440, -9341, -9242, -9142, -9041, -8940, -8839, -8738, -8637, -8535, -8431, -8329, -8226, -8123, -8019, -7914, -7810, -7706, -7600, -7494, -7387, -7281, -7174, -7066, -6957, -6848, -6739, -6629, -6519, -6408, -6296, -6183, -6071, -5958, -5843, -5728, -5611, -5495, -5378, -5259, -5139, -5019, -4898, -4776, -4652, -4527, -4401, -4275, -4147, -4016, -3884, -3751, -3616, -3479, -3340, -3199, -3054, -2907, -2759, -2605, -2448, -2286, -2119, -1947, -1766, -1573, -1368, -1145, -844, -450, -158};