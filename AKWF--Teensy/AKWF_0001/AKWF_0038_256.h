/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0038 256 samples */
 
const int16_t AKWF_0038_256_DATA [256] = 
{990, 2637, 4112, 5424, 6542, 7446, 8127, 8580, 8813, 8839, 8684, 8374, 7946, 7442, 6900, 6369, 5892, 5507, 5254, 5166, 5269, 5581, 6110, 6863, 7829, 8989, 10329, 11811, 13400, 15060, 16740, 18399, 19996, 21483, 22823, 23985, 24941, 25671, 26165, 26420, 26443, 26249, 25861, 25307, 24626, 23856, 23038, 22217, 21442, 20748, 20175, 19757, 19518, 19479, 19648, 20028, 20614, 21387, 22327, 23400, 24572, 25806, 27054, 28271, 29418, 30447, 31324, 32015, 32492, 32739, 32742, 32503, 32025, 31324, 30428, 29359, 28157, 26865, 25522, 24173, 22867, 21639, 20531, 19579, 18803, 18226, 17859, 17702, 17751, 17989, 18396, 18937, 19582, 20289, 21013, 21712, 22342, 22861, 23231, 23420, 23403, 23158, 22679, 21963, 21016, 19853, 18502, 16987, 15347, 13627, 11864, 10104, 8398, 6780, 5293, 3971, 2836, 1912, 1210, 729, 466, 404, 522, 790, 1172, 1629, 2116, 2592, 3013, 3335, 3522, 3542, 3369, 2985, 2377, 1547, 500, -748, -2170, -3743, -5428, -7177, -8957, -10718, -12412, -14005, -15453, -16722, -17791, -18636, -19245, -19620, -19765, -19696, -19434, -19009, -18460, -17822, -17141, -16462, -15826, -15277, -14851, -14583, -14498, -14612, -14941, -15481, -16229, -17170, -18276, -19524, -20873, -22280, -23711, -25113, -26442, -27662, -28733, -29616, -30293, -30738, -30945, -30911, -30642, -30154, -29468, -28617, -27635, -26562, -25443, -24322, -23240, -22243, -21369, -20647, -20107, -19768, -19639, -19722, -20011, -20491, -21139, -21925, -22814, -23762, -24731, -25676, -26548, -27311, -27925, -28355, -28579, -28575, -28335, -27854, -27142, -26215, -25089, -23803, -22392, -20889, -19346, -17805, -16306, -14896, -13613, -12487, -11548, -10813, -10293, -9992, -9901, -10006, -10284, -10707, -11237, -11833, -12457, -13062, -13599, -14034, -14328, -14445, -14361, -14056, -13523, -12757, -11766, -10567, -9179, -7638, -5978, -4240, -2469, -675};