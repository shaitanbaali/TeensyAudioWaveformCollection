/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0098 256 samples */
 
const int16_t AKWF_0098_256_DATA [256] = 
{652, 1708, 2679, 3624, 4543, 5442, 6325, 7187, 8042, 8876, 9692, 10499, 11290, 12062, 12821, 13564, 14286, 14999, 15695, 16372, 17034, 17678, 18303, 18915, 19510, 20087, 20650, 21196, 21724, 22239, 22737, 23216, 23682, 24132, 24570, 24989, 25392, 25785, 26165, 26526, 26875, 27213, 27536, 27844, 28142, 28430, 28705, 28968, 29217, 29456, 29688, 29905, 30115, 30314, 30500, 30681, 30852, 31015, 31168, 31311, 31447, 31576, 31698, 31809, 31915, 32014, 32105, 32189, 32266, 32339, 32404, 32463, 32518, 32566, 32605, 32644, 32676, 32702, 32724, 32744, 32754, 32760, 32764, 32763, 32756, 32746, 32733, 32715, 32694, 32668, 32641, 32608, 32574, 32536, 32491, 32448, 32398, 32345, 32292, 32233, 32174, 32111, 32046, 31978, 31907, 31834, 31758, 31683, 31600, 31519, 31433, 31346, 31259, 31169, 31076, 30980, 30882, 30786, 30668, 30186, 29493, 28456, 27029, 25230, 23083, 20638, 17954, 15074, 12028, 8866, 5615, 2214, -1517, -4797, -7665, -10298, -12707, -14903, -16889, -18685, -20303, -21746, -23040, -24190, -25211, -26119, -26920, -27627, -28254, -28806, -29291, -29723, -30104, -30437, -30733, -30993, -31225, -31428, -31610, -31771, -31912, -32038, -32150, -32249, -32335, -32410, -32475, -32533, -32582, -32622, -32658, -32687, -32707, -32722, -32730, -32733, -32731, -32721, -32708, -32685, -32659, -32629, -32594, -32549, -32499, -32443, -32378, -32311, -32240, -32155, -32067, -31973, -31871, -31760, -31642, -31518, -31385, -31243, -31092, -30933, -30765, -30587, -30401, -30206, -29998, -29782, -29557, -29317, -29069, -28806, -28533, -28251, -27956, -27643, -27321, -26986, -26637, -26274, -25897, -25505, -25099, -24678, -24239, -23787, -23319, -22834, -22333, -21815, -21282, -20730, -20161, -19577, -18975, -18359, -17723, -17069, -16400, -15714, -15011, -14290, -13556, -12803, -12033, -11253, -10453, -9641, -8814, -7968, -7111, -6239, -5349, -4444, -3517, -2569, -1593, -517};