/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0017 256 samples */
 
const int16_t AKWF_0017_256_DATA [256] = 
{-426, -1342, -2230, -3078, -3862, -4575, -5216, -5785, -6291, -6740, -7137, -7494, -7817, -8113, -8392, -8661, -8928, -9198, -9478, -9772, -10085, -10420, -10778, -11163, -11575, -12014, -12480, -12973, -13490, -14031, -14592, -15171, -15766, -16374, -16991, -17616, -18242, -18869, -19493, -20110, -20718, -21314, -21894, -22457, -23000, -23519, -24014, -24483, -24922, -25333, -25714, -26061, -26377, -26660, -26908, -27124, -27305, -27454, -27569, -27652, -27704, -27726, -27718, -27680, -27617, -27528, -27414, -27278, -27121, -26946, -26752, -26544, -26323, -26089, -25847, -25597, -25342, -25084, -24825, -24568, -24316, -24069, -23831, -23607, -23396, -23204, -23033, -22887, -22770, -22684, -22634, -22621, -22647, -22710, -22805, -22908, -23018, -23166, -23311, -23429, -23520, -23574, -23574, -23506, -23359, -23125, -22795, -22364, -21825, -21180, -20425, -19564, -18605, -17550, -16415, -15215, -13961, -12676, -11382, -10097, -8851, -7670, -6579, -5619, -4903, -4294, -3543, -2788, -2017, -1202, -346, 524, 1376, 2192, 2961, 3676, 4341, 4956, 5524, 6050, 6538, 6993, 7422, 7831, 8224, 8609, 8990, 9371, 9759, 10156, 10566, 10991, 11433, 11892, 12371, 12869, 13386, 13921, 14473, 15040, 15621, 16212, 16812, 17420, 18029, 18641, 19251, 19855, 20452, 21039, 21613, 22171, 22713, 23232, 23731, 24207, 24655, 25076, 25469, 25830, 26163, 26463, 26731, 26966, 27168, 27338, 27476, 27581, 27654, 27697, 27710, 27692, 27648, 27575, 27478, 27355, 27209, 27042, 26855, 26650, 26427, 26189, 25938, 25674, 25400, 25118, 24828, 24532, 24232, 23930, 23626, 23322, 23020, 22720, 22424, 22132, 21846, 21568, 21297, 21034, 20782, 20569, 20163, 21222, 22985, 22252, 22549, 23237, 23624, 23780, 23844, 23864, 23813, 23656, 23374, 22960, 22416, 21743, 20935, 19987, 18903, 17684, 16344, 14907, 13392, 11835, 10273, 8737, 7271, 5920, 4723, 3823, 3069, 2176, 1308, 434};