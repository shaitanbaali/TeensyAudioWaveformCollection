/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0034 256 samples */
 
const int16_t AKWF_0034_256_DATA [256] = 
{473, 1619, 2772, 3950, 5136, 6323, 7510, 8681, 9835, 10968, 12072, 13141, 14167, 15142, 16076, 16964, 17798, 18572, 19279, 19912, 20475, 20962, 21370, 21700, 21947, 22105, 22171, 22147, 22042, 21854, 21583, 21230, 20796, 20285, 19703, 19055, 18348, 17584, 16767, 15904, 14996, 14050, 13074, 12066, 11034, 9988, 8927, 7858, 6793, 5729, 4674, 3636, 2618, 1628, 672, -256, -1146, -1992, -2793, -3541, -4234, -4874, -5457, -5984, -6454, -6864, -7214, -7501, -7729, -7903, -8020, -8080, -8085, -8034, -7931, -7779, -7581, -7339, -7055, -6732, -6375, -5985, -5567, -5123, -4655, -4168, -3669, -3156, -2637, -2114, -1588, -1063, -543, -31, 469, 956, 1432, 1892, 2334, 2755, 3151, 3522, 3869, 4189, 4482, 4749, 4985, 5191, 5366, 5514, 5637, 5731, 5796, 5833, 5842, 5825, 5784, 5719, 5632, 5525, 5396, 5247, 5080, 4898, 4702, 4491, 4269, 4034, 3788, 3536, 3277, 3010, 2740, 2467, 2191, 1913, 1636, 1360, 1085, 812, 544, 280, 20, -234, -481, -722, -953, -1177, -1394, -1601, -1799, -1988, -2168, -2336, -2494, -2642, -2779, -2904, -3020, -3124, -3216, -3297, -3367, -3424, -3471, -3507, -3532, -3544, -3546, -3537, -3516, -3485, -3444, -3392, -3329, -3257, -3176, -3086, -2995, -2920, -2883, -2922, -3075, -3369, -3817, -4411, -5122, -5904, -6702, -7467, -8151, -8723, -9157, -9435, -9559, -9541, -9401, -9166, -8869, -8545, -8226, -7941, -7712, -7551, -7461, -7438, -7473, -7552, -7663, -7794, -7934, -8076, -8213, -8344, -8465, -8576, -8680, -8786, -8901, -9030, -9177, -9348, -9545, -9770, -10024, -10301, -10593, -10894, -11186, -11456, -11701, -11913, -12081, -12195, -12249, -12237, -12156, -12014, -11813, -11553, -11240, -10878, -10463, -10001, -9494, -8943, -8344, -7693, -6993, -6237, -5424, -4561, -3645, -2679, -1669, -592};