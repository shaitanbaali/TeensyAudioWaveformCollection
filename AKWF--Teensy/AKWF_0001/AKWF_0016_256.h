/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0016 256 samples */
 
const int16_t AKWF_0016_256_DATA [256] = 
{-949, -2341, -3580, -4722, -5794, -6820, -7800, -8728, -9619, -10479, -11306, -12102, -12869, -13605, -14316, -14998, -15646, -16256, -16820, -17331, -17791, -18198, -18553, -18861, -19126, -19353, -19550, -19724, -19880, -20025, -20160, -20290, -20423, -20562, -20714, -20939, -21296, -21765, -22318, -22925, -23544, -24131, -24651, -25098, -25478, -25805, -26096, -26357, -26599, -26824, -27024, -27192, -27316, -27387, -27393, -27321, -27162, -26909, -26556, -26099, -25537, -24874, -24121, -23367, -22724, -22195, -21758, -21393, -21080, -20797, -20517, -20216, -19874, -19469, -18981, -18389, -17686, -16875, -15959, -14953, -13875, -12737, -11563, -10378, -9197, -8040, -6923, -5852, -4843, -3905, -3041, -2266, -1575, -952, -404, 71, 474, 790, 1023, 1206, 1361, 1477, 1537, 1544, 1507, 1434, 1338, 1226, 1103, 972, 838, 711, 596, 493, 403, 327, 265, 225, 216, 338, 711, 1088, 1379, 1595, 1754, 1881, 2000, 2137, 2325, 2613, 3045, 3597, 4194, 4817, 5513, 6290, 7123, 7985, 8849, 9700, 10524, 11310, 12054, 12741, 13363, 13929, 14444, 14914, 15344, 15730, 16068, 16358, 16594, 16777, 16906, 16978, 16992, 16951, 16864, 16746, 16615, 16489, 16375, 16264, 16139, 15989, 15809, 15591, 15336, 15063, 14813, 14603, 14425, 14250, 14058, 13847, 13620, 13385, 13150, 12917, 12693, 12490, 12329, 12225, 12191, 12231, 12346, 12537, 12802, 13139, 13541, 13994, 14486, 14996, 15510, 16008, 16470, 16897, 17301, 17682, 18040, 18372, 18677, 18955, 19203, 19420, 19610, 19774, 19914, 20035, 20141, 20233, 20314, 20385, 20446, 20499, 20546, 20585, 20617, 20641, 20659, 20670, 20673, 20669, 20657, 20638, 20611, 20577, 20535, 20485, 20425, 20354, 20265, 20156, 20027, 19875, 19695, 19477, 19212, 18894, 18511, 18056, 17526, 16912, 16195, 15362, 14410, 13325, 12105, 10686, 8910, 7036, 5269, 3617, 2045, 488};