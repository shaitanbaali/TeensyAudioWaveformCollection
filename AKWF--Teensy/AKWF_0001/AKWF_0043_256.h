/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0043 256 samples */
 
const int16_t AKWF_0043_256_DATA [256] = 
{386, 1820, 3245, 4690, 6143, 7601, 9059, 10505, 11940, 13358, 14748, 16112, 17444, 18733, 19985, 21190, 22343, 23446, 24492, 25477, 26405, 27270, 28068, 28803, 29470, 30071, 30605, 31071, 31470, 31804, 32073, 32279, 32422, 32504, 32529, 32497, 32411, 32274, 32088, 31857, 31582, 31268, 30917, 30532, 30116, 29675, 29207, 28719, 28214, 27693, 27160, 26620, 26072, 25522, 24972, 24423, 23878, 23342, 22812, 22294, 21791, 21301, 20826, 20371, 19933, 19517, 19121, 18746, 18396, 18068, 17762, 17482, 17225, 16993, 16784, 16599, 16438, 16300, 16185, 16091, 16019, 15968, 15935, 15924, 15928, 15951, 15990, 16045, 16112, 16194, 16287, 16392, 16506, 16630, 16761, 16898, 17042, 17190, 17343, 17497, 17654, 17813, 17971, 18128, 18285, 18440, 18588, 18756, 18776, 18632, 18563, 18424, 18226, 17962, 17633, 17234, 16762, 16218, 15603, 14910, 14146, 13311, 12402, 11427, 10386, 9281, 8118, 6900, 5628, 4312, 2955, 1558, 134, -1316, -2789, -4273, -5766, -7265, -8756, -10241, -11713, -13162, -14588, -15986, -17344, -18668, -19947, -21176, -22357, -23484, -24551, -25561, -26508, -27390, -28206, -28957, -29638, -30252, -30798, -31273, -31682, -32024, -32300, -32510, -32656, -32743, -32769, -32738, -32653, -32514, -32326, -32092, -31814, -31496, -31140, -30749, -30328, -29878, -29403, -28908, -28394, -27865, -27325, -26775, -26218, -25659, -25098, -24540, -23988, -23440, -22903, -22377, -21863, -21364, -20882, -20417, -19972, -19547, -19143, -18763, -18404, -18069, -17758, -17472, -17209, -16971, -16758, -16569, -16403, -16261, -16143, -16046, -15972, -15918, -15885, -15870, -15874, -15896, -15934, -15988, -16056, -16138, -16231, -16336, -16452, -16575, -16708, -16848, -16992, -17142, -17294, -17466, -17422, -17323, -17266, -17142, -16961, -16720, -16414, -16041, -15599, -15086, -14501, -13847, -13118, -12318, -11451, -10514, -9514, -8452, -7329, -6152, -4925, -3651, -2339, -962};