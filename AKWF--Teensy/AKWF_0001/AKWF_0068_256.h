/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0068 256 samples */
 
const int16_t AKWF_0068_256_DATA [256] = 
{181, 838, 1486, 2139, 2795, 3453, 4114, 4775, 5437, 6099, 6759, 7419, 8078, 8731, 9383, 10030, 10671, 11309, 11940, 12562, 13178, 13785, 14382, 14971, 15549, 16115, 16670, 17212, 17740, 18256, 18756, 19242, 19712, 20166, 20603, 21024, 21426, 21811, 22178, 22525, 22854, 23165, 23455, 23728, 23981, 24215, 24430, 24626, 24802, 24959, 25098, 25218, 25319, 25402, 25467, 25514, 25543, 25555, 25550, 25529, 25491, 25438, 25370, 25287, 25190, 25079, 24955, 24818, 24669, 24508, 24336, 24153, 23960, 23756, 23543, 23321, 23089, 22849, 22600, 22343, 22078, 21804, 21523, 21235, 20938, 20634, 20324, 20003, 19677, 19342, 18999, 18648, 18290, 17923, 17547, 17164, 16770, 16370, 15961, 15541, 15114, 14678, 14232, 13778, 13316, 12844, 12366, 11878, 11381, 10878, 10364, 9842, 9314, 8776, 8229, 7676, 7113, 6543, 5966, 5380, 4787, 4188, 3580, 2966, 2347, 1720, 1089, 452, -190, -836, -1485, -2140, -2795, -3453, -4115, -4775, -5437, -6100, -6760, -7420, -8078, -8731, -9384, -10031, -10672, -11309, -11940, -12563, -13179, -13786, -14383, -14972, -15550, -16115, -16671, -17212, -17740, -18256, -18757, -19242, -19713, -20166, -20604, -21024, -21426, -21811, -22178, -22525, -22854, -23165, -23456, -23728, -23982, -24215, -24430, -24626, -24802, -24959, -25098, -25218, -25319, -25402, -25467, -25514, -25543, -25555, -25550, -25529, -25491, -25438, -25370, -25287, -25190, -25079, -24956, -24818, -24670, -24509, -24337, -24154, -23960, -23756, -23544, -23321, -23090, -22849, -22600, -22343, -22078, -21805, -21524, -21236, -20939, -20635, -20324, -20004, -19677, -19343, -18999, -18649, -18291, -17923, -17548, -17164, -16772, -16371, -15961, -15542, -15115, -14679, -14232, -13779, -13317, -12845, -12366, -11878, -11382, -10878, -10365, -9843, -9315, -8777, -8230, -7677, -7114, -6544, -5967, -5381, -4788, -4189, -3581, -2967, -2348, -1722, -1093, -445};