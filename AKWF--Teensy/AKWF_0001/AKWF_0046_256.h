/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0046 256 samples */
 
const int16_t AKWF_0046_256_DATA [256] = 
{-114, -291, -469, -655, -847, -1043, -1243, -1449, -1660, -1877, -2101, -2332, -2566, -2807, -3058, -3315, -3579, -3852, -4134, -4420, -4720, -5024, -5340, -5663, -5992, -6331, -6677, -7032, -7396, -7765, -8143, -8525, -8917, -9313, -9716, -10121, -10532, -10947, -11366, -11787, -12209, -12633, -13057, -13481, -13904, -14323, -14743, -15160, -15567, -15976, -16378, -16771, -17160, -17541, -17913, -18279, -18636, -18979, -19314, -19637, -19950, -20252, -20540, -20816, -21079, -21329, -21566, -21788, -21997, -22190, -22370, -22533, -22682, -22816, -22933, -23036, -23124, -23194, -23248, -23284, -23303, -23307, -23291, -23261, -23211, -23142, -23055, -22949, -22820, -22676, -22508, -22321, -22112, -21881, -21627, -21351, -21050, -20728, -20382, -20009, -19609, -19188, -18739, -18262, -17758, -17231, -16675, -16090, -15479, -14844, -14180, -13492, -12778, -12037, -11274, -10491, -9683, -8857, -8015, -7154, -6285, -5407, -4520, -3629, -2747, -1872, -1015, -217, 548, 1377, 2242, 3121, 4008, 4898, 5782, 6659, 7523, 8376, 9212, 10032, 10828, 11602, 12355, 13086, 13787, 14466, 15119, 15742, 16342, 16916, 17459, 17977, 18470, 18933, 19371, 19784, 20171, 20532, 20868, 21181, 21471, 21738, 21982, 22203, 22403, 22582, 22740, 22877, 22997, 23093, 23173, 23233, 23275, 23300, 23307, 23296, 23271, 23225, 23163, 23088, 22993, 22885, 22760, 22620, 22465, 22295, 22107, 21909, 21693, 21465, 21223, 20968, 20699, 20418, 20124, 19816, 19501, 19173, 18832, 18483, 18124, 17755, 17379, 16995, 16603, 16207, 15801, 15391, 14982, 14563, 14144, 13723, 13297, 12873, 12453, 12027, 11605, 11186, 10769, 10355, 9947, 9543, 9142, 8748, 8360, 7981, 7606, 7240, 6878, 6528, 6183, 5850, 5524, 5203, 4893, 4590, 4298, 4015, 3736, 3463, 3204, 2949, 2702, 2465, 2232, 2003, 1783, 1568, 1360, 1158, 959, 763, 574, 393, 214, 44};