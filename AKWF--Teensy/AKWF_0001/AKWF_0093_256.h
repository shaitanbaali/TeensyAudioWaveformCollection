/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0093 256 samples */
 
const int16_t AKWF_0093_256_DATA [256] = 
{497, 1359, 2197, 3030, 3855, 4671, 5479, 6274, 7061, 7836, 8597, 9348, 10085, 10807, 11516, 12211, 12888, 13551, 14198, 14827, 15440, 16036, 16612, 17171, 17711, 18232, 18735, 19216, 19678, 20121, 20543, 20943, 21324, 21684, 22020, 22338, 22633, 22906, 23159, 23388, 23597, 23784, 23949, 24091, 24213, 24312, 24391, 24446, 24490, 24629, 24931, 25357, 25859, 26397, 26946, 27491, 28020, 28527, 29010, 29465, 29891, 30292, 30661, 31001, 31314, 31595, 31848, 32070, 32262, 32424, 32555, 32654, 32724, 32760, 32766, 32740, 32682, 32593, 32472, 32320, 32137, 31924, 31680, 31406, 31102, 30769, 30409, 30018, 29603, 29160, 28689, 28194, 27676, 27131, 26565, 25976, 25364, 24734, 24083, 23411, 22723, 22016, 21292, 20553, 19800, 19031, 18251, 17458, 16651, 15838, 15012, 14178, 13337, 12487, 11632, 10773, 9908, 9039, 8170, 7296, 6422, 5550, 4675, 3803, 2933, 2065, 1203, 345, -511, -1357, -2197, -3031, -3856, -4671, -5480, -6275, -7062, -7837, -8598, -9348, -10086, -10807, -11517, -12212, -12888, -13552, -14199, -14828, -15440, -16036, -16612, -17172, -17712, -18233, -18735, -19218, -19679, -20122, -20543, -20944, -21324, -21684, -22021, -22338, -22633, -22907, -23159, -23389, -23597, -23784, -23949, -24092, -24213, -24312, -24391, -24446, -24490, -24629, -24931, -25357, -25859, -26398, -26946, -27491, -28020, -28527, -29010, -29464, -29892, -30291, -30661, -31001, -31313, -31595, -31847, -32070, -32262, -32424, -32554, -32654, -32723, -32761, -32765, -32740, -32682, -32592, -32472, -32319, -32137, -31923, -31680, -31406, -31103, -30769, -30409, -30019, -29602, -29159, -28690, -28195, -27675, -27131, -26566, -25976, -25365, -24734, -24083, -23411, -22723, -22016, -21292, -20554, -19800, -19032, -18251, -17458, -16652, -15838, -15012, -14178, -13338, -12488, -11633, -10774, -9909, -9040, -8171, -7297, -6422, -5551, -4676, -3803, -2934, -2068, -1207, -334};