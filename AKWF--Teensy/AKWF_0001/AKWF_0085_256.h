/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0085 256 samples */
 
const int16_t AKWF_0085_256_DATA [256] = 
{3615, 5040, 5878, 7225, 9376, 11813, 13764, 14861, 15328, 15667, 16198, 16888, 17494, 17846, 18010, 18199, 18593, 19214, 19951, 20679, 21364, 22044, 22770, 23558, 24346, 25072, 25696, 26223, 26680, 27087, 27437, 27677, 28039, 27359, 23634, 23387, 23445, 23380, 23300, 23192, 23063, 22920, 22773, 22618, 22452, 22275, 22087, 21891, 21688, 21479, 21260, 21033, 20797, 20554, 20307, 20054, 19800, 19543, 19288, 19034, 18787, 18559, 18234, 20083, 22462, 22338, 22127, 21970, 21822, 21690, 21575, 21477, 21400, 21338, 21292, 21262, 21246, 21243, 21253, 21272, 21301, 21335, 21372, 21411, 21451, 21490, 21523, 21553, 21575, 21587, 21587, 21572, 21542, 21495, 21435, 21335, 21439, 20578, 16723, 16373, 16349, 16216, 16081, 15923, 15732, 15507, 15245, 14939, 14586, 14183, 13727, 13216, 12650, 12027, 11348, 10616, 9829, 8988, 8099, 7158, 6175, 5155, 4098, 3014, 1909, 794, -434, 508, 1991, 947, -198, -1278, -2339, -3368, -4363, -5314, -6224, -7090, -7908, -8678, -9401, -10071, -10905, -10250, -20541, -32751, -32490, -32170, -31622, -31079, -30568, -30082, -29614, -29157, -28700, -28238, -27767, -27278, -26773, -26285, -25570, -25803, -29006, -28676, -27999, -27400, -26772, -26139, -25501, -24864, -24230, -23599, -22976, -22367, -21771, -21192, -20634, -20096, -19585, -19101, -18645, -18225, -17845, -17507, -17210, -16956, -16748, -16586, -16471, -16393, -16469, -14430, -11916, -11962, -12154, -12345, -12584, -12857, -13160, -13488, -13843, -14217, -14608, -15014, -15429, -15852, -16277, -16704, -17128, -17548, -17959, -18358, -18745, -19114, -19458, -19774, -20063, -20318, -20539, -20724, -20864, -20963, -21016, -21055, -20841, -21541, -25180, -25256, -24946, -24681, -24346, -23965, -23539, -23069, -22554, -21998, -21402, -20766, -20087, -19363, -18592, -17773, -16912, -16013, -15077, -14111, -13117, -12092, -11031, -10044, -9896, -10884, -11586, -10387, -7283, -1731};