/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0026 256 samples */
 
const int16_t AKWF_0026_256_DATA [256] = 
{535, 1398, 2170, 2875, 3511, 4078, 4580, 5015, 5387, 5698, 5950, 6147, 6293, 6388, 6438, 6444, 6412, 6343, 6242, 6110, 5952, 5770, 5569, 5349, 5115, 4869, 4613, 4350, 4083, 3812, 3540, 3270, 3001, 2737, 2478, 2226, 1982, 1745, 1518, 1301, 1095, 900, 716, 543, 382, 233, 95, -32, -146, -249, -342, -424, -496, -558, -611, -655, -691, -718, -739, -752, -759, -760, -756, -747, -733, -657, -929, 744, 6029, 7196, 9777, 12721, 14552, 15524, 16101, 16614, 17215, 17944, 18789, 19717, 20690, 21682, 22667, 23626, 24551, 25428, 26252, 27021, 27730, 28377, 28964, 29490, 29953, 30360, 30707, 31000, 31238, 31426, 31565, 31658, 31709, 31719, 31692, 31632, 31540, 31420, 31275, 31108, 30921, 30700, 30515, 30200, 25001, 22216, 20370, 16971, 14493, 13034, 12140, 11411, 10641, 9754, 8748, 7655, 6511, 5344, 4187, 3057, 1967, 932, -44, -957, -1799, -2573, -3278, -3910, -4474, -4970, -5398, -5763, -6065, -6309, -6497, -6631, -6715, -6752, -6747, -6701, -6619, -6504, -6359, -6187, -5992, -5777, -5544, -5296, -5037, -4768, -4493, -4214, -3931, -3648, -3367, -3088, -2814, -2546, -2285, -2032, -1788, -1553, -1330, -1117, -916, -727, -549, -384, -231, -89, 40, 157, 263, 357, 441, 514, 577, 631, 676, 712, 739, 759, 772, 779, 779, 774, 764, 750, 731, 681, 754, 310, -4960, -7021, -8925, -12071, -14204, -15356, -16001, -16512, -17082, -17777, -18595, -19502, -20467, -21456, -22443, -23411, -24344, -25232, -26071, -26853, -27575, -28239, -28840, -29379, -29859, -30278, -30639, -30944, -31195, -31394, -31545, -31648, -31708, -31680, -31880, -30730, -25272, -23747, -21311, -18140, -16045, -14837, -14055, -13353, -12561, -11633, -10583, -9440, -8245, -7031, -5818, -4631, -3485, -2387, -1348, -354};