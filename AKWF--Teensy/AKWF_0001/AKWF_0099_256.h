/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0099 256 samples */
 
const int16_t AKWF_0099_256_DATA [256] = 
{290, 956, 1470, 1968, 2431, 2886, 3316, 3738, 4145, 4545, 4941, 5324, 5691, 6062, 6422, 6778, 7130, 7472, 7821, 8145, 8467, 8807, 9133, 9429, 9741, 10058, 10356, 10655, 10947, 11237, 11528, 11809, 12089, 12360, 12628, 12897, 13156, 13421, 13672, 13919, 14166, 14410, 14654, 14896, 15126, 15361, 15578, 15806, 16025, 16240, 16446, 16655, 16856, 17062, 17262, 17452, 17641, 17831, 18007, 18188, 18372, 18534, 18710, 18876, 19036, 19191, 19350, 19502, 19638, 19790, 19936, 20058, 20201, 20335, 20457, 20582, 20705, 20822, 20930, 21036, 21148, 21243, 21349, 21449, 21541, 21628, 21705, 21794, 21870, 21945, 22012, 22082, 22149, 22211, 22264, 22324, 22375, 22420, 22466, 22513, 22545, 22582, 22614, 22640, 22663, 22687, 22706, 22723, 22735, 22740, 22753, 22751, 22751, 22753, 22740, 22732, 22715, 22699, 22677, 22652, 22631, 22607, 22576, 22538, 22500, 22468, 22420, 22375, 22324, 22263, 22217, 22154, 22092, 22033, 21964, 21895, 21826, 21749, 21391, 22647, 14969, -13847, -25061, -25581, -26606, -28113, -29519, -30706, -31591, -32186, -32540, -32720, -32771, -32741, -32643, -32507, -32354, -32183, -32011, -31827, -31637, -31443, -31248, -31047, -30842, -30632, -30426, -30209, -29989, -29769, -29550, -29320, -29088, -28857, -28620, -28375, -28133, -27881, -27630, -27380, -27119, -26866, -26600, -26331, -26062, -25793, -25525, -25241, -24965, -24683, -24397, -24104, -23818, -23526, -23228, -22931, -22629, -22324, -22019, -21713, -21403, -21089, -20775, -20451, -20144, -19817, -19490, -19164, -18834, -18504, -18172, -17842, -17510, -17161, -16819, -16486, -16134, -15792, -15439, -15089, -14741, -14383, -14034, -13672, -13316, -12948, -12585, -12219, -11854, -11484, -11116, -10736, -10359, -9984, -9603, -9222, -8838, -8447, -8063, -7665, -7275, -6875, -6470, -6066, -5645, -5238, -4829, -4391, -3947, -3514, -3065, -2604, -2125, -1624, -1091, -506};