/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0089 256 samples */
 
const int16_t AKWF_0089_256_DATA [256] = 
{2427, 6048, 9486, 12775, 15859, 18713, 21315, 23635, 25680, 27442, 28921, 30133, 31089, 31799, 32287, 32572, 32674, 32614, 32417, 32103, 31691, 31203, 30658, 30071, 29460, 28839, 28217, 27609, 27023, 26463, 25939, 25453, 25009, 24609, 24254, 23942, 23675, 23448, 23262, 23112, 22995, 22910, 22851, 22816, 22801, 22805, 22821, 22847, 22882, 22923, 22966, 23009, 23053, 23093, 23130, 23161, 23187, 23207, 23221, 23227, 23226, 23220, 23205, 23186, 23160, 23129, 23093, 23051, 23006, 22958, 22907, 22855, 22799, 22743, 22685, 22627, 22569, 22511, 22453, 22396, 22340, 22284, 22230, 22177, 22124, 22074, 22024, 21975, 21928, 21882, 21836, 21792, 21748, 21705, 21664, 21621, 21579, 21539, 21498, 21459, 21419, 21379, 21339, 21299, 21261, 21221, 21181, 21141, 21102, 21062, 21022, 20982, 20942, 20901, 20861, 20820, 20779, 20738, 20695, 20661, 20159, 18830, 16830, 14289, 11331, 8059, 4590, 1013, -2598, -6154, -9602, -12897, -15981, -18835, -21434, -23752, -25795, -27555, -29031, -30241, -31193, -31901, -32387, -32669, -32769, -32707, -32509, -32192, -31779, -31290, -30743, -30156, -29544, -28923, -28302, -27692, -27106, -26546, -26021, -25536, -25091, -24692, -24337, -24026, -23758, -23531, -23345, -23195, -23080, -22994, -22936, -22900, -22886, -22889, -22905, -22932, -22966, -23007, -23050, -23094, -23136, -23177, -23213, -23245, -23271, -23291, -23304, -23310, -23310, -23302, -23289, -23268, -23242, -23210, -23173, -23132, -23088, -23039, -22987, -22934, -22880, -22823, -22764, -22707, -22648, -22590, -22532, -22475, -22419, -22364, -22309, -22255, -22203, -22152, -22102, -22053, -22006, -21958, -21913, -21869, -21825, -21782, -21740, -21698, -21657, -21616, -21576, -21535, -21495, -21454, -21415, -21376, -21336, -21296, -21256, -21216, -21176, -21137, -21096, -21056, -21016, -20975, -20935, -20895, -20854, -20811, -20769, -20730, -20231, -18914, -16922, -14389, -11437, -8177, -4721, -1082};