/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0050 256 samples */
 
const int16_t AKWF_0050_256_DATA [256] = 
{-388, -1081, -1765, -2444, -3133, -3825, -4537, -5182, -5820, -6469, -7097, -7731, -8364, -9023, -9721, -10423, -11140, -11853, -12555, -13231, -13915, -14576, -15222, -15846, -16453, -17015, -17571, -18118, -18637, -19146, -19625, -20117, -20596, -21061, -21507, -21936, -22334, -22710, -23054, -23372, -23671, -23990, -24302, -24628, -24955, -25290, -25617, -25934, -26193, -26437, -26656, -26840, -26985, -27124, -27266, -27385, -27502, -27613, -27706, -27801, -27866, -27950, -27971, -28005, -28013, -27975, -27966, -27899, -27801, -27734, -27615, -27471, -27368, -27237, -27056, -26874, -26726, -26542, -26325, -26058, -25767, -25514, -25245, -24969, -24684, -24376, -24030, -23632, -23185, -22693, -22167, -21620, -21064, -20511, -19970, -19450, -18954, -18490, -18058, -17662, -17304, -16884, -16416, -15929, -15417, -14910, -14352, -13759, -13187, -12646, -12091, -11495, -10937, -10400, -9806, -9226, -8626, -7972, -7342, -6650, -5963, -5286, -4577, -3893, -3178, -2487, -1764, -1068, -348, 340, 1034, 1697, 2338, 3011, 3692, 4345, 5020, 5697, 6367, 7044, 7680, 8301, 8977, 9642, 10330, 10983, 11640, 12298, 12968, 13625, 14233, 14852, 15463, 16034, 16611, 17190, 17748, 18299, 18823, 19355, 19871, 20365, 20836, 21289, 21704, 22095, 22446, 22802, 23152, 23494, 23835, 24181, 24483, 24753, 25031, 25284, 25491, 25698, 25894, 26070, 26215, 26351, 26441, 26531, 26618, 26699, 26771, 26858, 26930, 27032, 27068, 27072, 27075, 27031, 27016, 26954, 26873, 26834, 26747, 26640, 26575, 26475, 26322, 26164, 26034, 25863, 25656, 25396, 25113, 24868, 24604, 24330, 24046, 23737, 23386, 22983, 22528, 22029, 21493, 20937, 20373, 19811, 19262, 18734, 18231, 17760, 17322, 16920, 16556, 16132, 15659, 15168, 14653, 14143, 13582, 12987, 12415, 11872, 11316, 10718, 10164, 9589, 8957, 8356, 7729, 7060, 6427, 5745, 5076, 4420, 3733, 3070, 2373, 1699, 991, 294};