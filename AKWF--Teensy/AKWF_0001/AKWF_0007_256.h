/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0007 256 samples */
 
const int16_t AKWF_0007_256_DATA [256] = 
{189, 713, 1345, 2055, 2829, 3665, 4555, 5491, 6473, 7495, 8545, 9623, 10721, 11825, 12936, 14042, 15134, 16210, 17260, 18277, 19260, 20203, 21100, 21956, 22762, 23519, 24231, 24893, 25508, 26079, 26606, 27090, 27536, 27944, 28316, 28656, 28965, 29246, 29500, 29730, 29938, 30125, 30293, 30443, 30578, 30696, 30802, 30895, 30976, 31046, 31105, 31155, 31197, 31230, 31256, 31275, 31287, 31295, 31298, 31302, 31321, 31355, 31395, 31442, 31496, 31558, 31624, 31692, 31760, 31824, 31882, 31932, 31971, 31998, 32013, 32012, 31996, 31963, 31911, 31838, 31743, 31622, 31473, 31294, 31082, 30833, 30547, 30222, 29856, 29449, 28998, 28507, 27975, 27400, 26790, 26142, 25457, 24742, 23997, 23223, 22426, 21606, 20765, 19908, 19035, 18149, 17254, 16349, 15437, 14523, 13605, 12687, 11773, 10862, 9957, 9064, 8181, 7312, 6463, 5632, 4827, 4049, 3304, 2582, 1877, 1237, 652, 168, -198, -711, -1346, -2055, -2830, -3666, -4556, -5492, -6474, -7496, -8546, -9624, -10721, -11826, -12937, -14043, -15134, -16210, -17260, -18277, -19260, -20203, -21101, -21956, -22763, -23520, -24231, -24893, -25508, -26079, -26606, -27090, -27536, -27944, -28316, -28656, -28965, -29246, -29501, -29730, -29938, -30125, -30293, -30444, -30578, -30696, -30802, -30895, -30976, -31046, -31105, -31155, -31197, -31230, -31256, -31275, -31288, -31295, -31298, -31302, -31321, -31355, -31395, -31442, -31496, -31558, -31624, -31692, -31760, -31824, -31882, -31932, -31971, -31998, -32013, -32012, -31996, -31963, -31911, -31838, -31743, -31622, -31473, -31294, -31082, -30833, -30548, -30222, -29856, -29449, -28998, -28507, -27975, -27401, -26790, -26142, -25457, -24743, -23998, -23223, -22427, -21607, -20765, -19909, -19036, -18149, -17255, -16350, -15438, -14523, -13606, -12688, -11774, -10863, -9958, -9065, -8181, -7313, -6464, -5633, -4827, -4050, -3305, -2583, -1878, -1239, -656, -160};