/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0056 256 samples */
 
const int16_t AKWF_0056_256_DATA [256] = 
{-370, -926, -1476, -2017, -2543, -3050, -3535, -4000, -4454, -4894, -5320, -5738, -6148, -6550, -6949, -7341, -7730, -8117, -8499, -8878, -9256, -9632, -10007, -10378, -10748, -11117, -11485, -11852, -12214, -12578, -12940, -13300, -13654, -14006, -14360, -14710, -15053, -15397, -15735, -16070, -16401, -16725, -17048, -17365, -17677, -17983, -18283, -18578, -18864, -19146, -19421, -19689, -19948, -20201, -20445, -20682, -20912, -21132, -21342, -21545, -21737, -21921, -22097, -22262, -22417, -22562, -22699, -22825, -22940, -23046, -23143, -23226, -23299, -23362, -23415, -23455, -23485, -23502, -23506, -23500, -23481, -23450, -23406, -23350, -23280, -23196, -23100, -22989, -22864, -22725, -22568, -22399, -22212, -22010, -21791, -21553, -21299, -21028, -20738, -20428, -20100, -19753, -19384, -18993, -18582, -18151, -17697, -17218, -16718, -16194, -15644, -15070, -14471, -13846, -13194, -12514, -11804, -11063, -10290, -9481, -8636, -7744, -6790, -5769, -4615, -2967, -1409, -315, 778, 1906, 3037, 4146, 5214, 6239, 7218, 8144, 9025, 9865, 10665, 11431, 12165, 12866, 13539, 14186, 14800, 15389, 15951, 16487, 17002, 17491, 17955, 18397, 18816, 19213, 19593, 19951, 20287, 20604, 20902, 21181, 21443, 21686, 21912, 22122, 22315, 22491, 22653, 22802, 22931, 23047, 23152, 23240, 23316, 23378, 23427, 23463, 23487, 23499, 23498, 23486, 23462, 23425, 23379, 23321, 23252, 23171, 23080, 22981, 22869, 22747, 22614, 22472, 22319, 22157, 21986, 21804, 21614, 21416, 21205, 20990, 20766, 20533, 20289, 20039, 19782, 19518, 19245, 18966, 18681, 18388, 18092, 17788, 17477, 17163, 16843, 16519, 16190, 15856, 15520, 15183, 14837, 14488, 14138, 13787, 13431, 13074, 12715, 12353, 11991, 11627, 11262, 10894, 10526, 10155, 9784, 9409, 9036, 8661, 8280, 7901, 7520, 7131, 6744, 6350, 5947, 5540, 5128, 4704, 4273, 3820, 3344, 2843, 2280, 1464, 692, 146};