/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0057 256 samples */
 
const int16_t AKWF_0057_256_DATA [256] = 
{-1288, -3141, -4992, -6825, -8472, -9936, -11285, -12528, -13642, -14617, -15469, -16219, -16862, -17392, -17819, -18154, -18399, -18557, -18636, -18617, -18470, -18208, -17856, -17402, -16826, -16125, -15312, -14316, -12700, -10785, -9253, -7758, -5957, -4335, -2773, -947, 926, 2592, 4087, 5542, 6984, 8350, 9609, 10788, 11903, 12943, 13909, 14802, 15624, 16385, 17078, 17697, 18233, 18691, 19083, 19399, 19619, 19745, 19792, 19758, 19634, 19418, 19111, 18716, 18234, 17662, 16999, 16239, 15389, 14364, 12870, 11202, 9732, 8199, 6361, 4615, 3168, 1513, -414, -2251, -3859, -5394, -6954, -8489, -9943, -11316, -12636, -13911, -15136, -16315, -17448, -18527, -19556, -20544, -21490, -22385, -23215, -23967, -24656, -25280, -25819, -26270, -26638, -26925, -27122, -27225, -27241, -27170, -27015, -26780, -26463, -26054, -25550, -24957, -24288, -23517, -22590, -21509, -20273, -18869, -16920, -14094, -11379, -9430, -8036, -6055, -3321, -726, 1322, 3128, 4987, 6824, 8471, 9935, 11284, 12528, 13642, 14617, 15469, 16218, 16861, 17392, 17818, 18153, 18398, 18557, 18636, 18617, 18470, 18208, 17855, 17401, 16826, 16124, 15312, 14315, 12700, 10784, 9252, 7758, 5956, 4334, 2772, 946, -927, -2593, -4088, -5542, -6985, -8351, -9609, -10789, -11903, -12944, -13910, -14802, -15625, -16385, -17079, -17697, -18233, -18692, -19083, -19400, -19619, -19746, -19792, -19758, -19634, -19418, -19112, -18716, -18234, -17663, -16999, -16239, -15390, -14365, -12871, -11203, -9733, -8200, -6362, -4615, -3169, -1514, 413, 2250, 3858, 5393, 6953, 8488, 9942, 11315, 12636, 13911, 15136, 16314, 17448, 18526, 19556, 20544, 21490, 22385, 23215, 23967, 24655, 25280, 25819, 26269, 26638, 26924, 27122, 27225, 27241, 27170, 27015, 26780, 26463, 26054, 25550, 24957, 24288, 23516, 22590, 21509, 20272, 18869, 16920, 14093, 11378, 9429, 8036, 6058, 3327, 704};