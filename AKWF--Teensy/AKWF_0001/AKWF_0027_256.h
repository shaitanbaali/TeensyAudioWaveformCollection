/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0027 256 samples */
 
const int16_t AKWF_0027_256_DATA [256] = 
{-16, -54, -13, -249, -615, -6359, -16630, 12134, 21085, 3815, -9433, -8075, 1025, 6275, 3675, -1819, -3704, -852, 2594, 2627, -459, -3112, -2720, -123, 1804, 1356, -523, -1670, -1069, 360, 1048, 464, -555, -895, -329, 419, 578, 106, -403, -430, -33, 315, 276, 316, 205, -276, -305, 27, 224, 117, -74, 95, -822, 7863, 11263, -14291, -14442, 785, 8368, 4678, -2465, -4974, -1806, 2208, 2694, -25, -2304, -1644, 932, 2536, 1699, -378, -1615, -95, -1784, -21096, 7331, 26105, 6367, -10585, -9931, 524, 7175, 4649, -1811, -4458, -1395, 2845, 3342, -32, -3313, -3211, -343, 2038, 1741, -388, -1863, -1329, 308, 1219, 644, -549, -1039, -457, 428, 684, 179, -435, -521, -88, 339, 339, -6, -285, -230, 43, 222, 148, -58, -164, -83, 70, 129, 53, -56, -85, -17, 71, 43, 900, 1373, 15583, 2825, -22278, -12056, 5169, 10165, 3056, -4884, -5527, -450, 3505, 2447, -1332, -3087, -1056, 2222, 3260, 1342, -1195, -1815, -329, 1356, 1507, 256, -897, -834, 138, 862, 648, -128, -597, -355, 217, 482, 227, -194, -352, -549, -211, 448, 411, -54, -319, -178, 92, -38, 892, -7455, -11834, 13805, 14790, -399, -8318, -4882, 2285, 4985, 1943, -2121, -2734, -74, 2265, 1699, -849, -2515, -1752, 590, -34, 9026, 19621, -18456, -24027, -662, 12950, 8379, -3113, -8056, -3552, 3202, 4643, 492, -3611, -3131, 874, 3827, 2915, -355, -2398, -1487, 878, 2051, 1083, -666, -1315, -437, 790, 1063, 275, -599, -678, -38, 543, 493, -24, -410, -306, 89, 324, 194, -105, -245, -116, 101, 173, 55, -101, -132, -32, 76, 82, -1, -73, -65, 1, 48, 32};