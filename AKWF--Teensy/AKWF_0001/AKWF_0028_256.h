/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0028 256 samples */
 
const int16_t AKWF_0028_256_DATA [256] = 
{872, 3122, 4866, 6419, 7979, 9548, 11090, 12560, 13940, 15217, 16381, 17442, 18398, 19257, 20029, 20719, 21335, 21884, 22375, 22811, 23199, 23545, 23853, 24127, 24370, 24586, 24779, 24950, 25101, 25236, 25355, 25462, 25557, 25641, 25715, 25781, 25840, 25892, 25938, 25979, 26016, 26049, 26078, 26103, 26126, 26146, 26164, 26180, 26194, 26206, 26216, 26226, 26235, 26244, 26250, 26256, 26263, 26267, 26272, 26276, 26279, 26282, 26283, 26287, 26289, 26291, 26292, 26294, 26295, 26296, 26297, 26298, 26300, 26300, 26301, 26301, 26301, 26301, 26301, 26302, 26303, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26304, 26294, 26337, 26119, 24890, 23931, 22760, 21703, 20611, 19401, 18109, 16789, 15481, 14218, 13025, 11905, 10865, 9909, 9030, 8226, 7494, 6823, 6214, 5660, 5155, 4695, 4270, 3914, 3464, 993, -961, -3103, -4864, -6420, -7980, -9549, -11090, -12561, -13940, -15218, -16382, -17443, -18399, -19257, -20029, -20719, -21335, -21884, -22375, -22811, -23200, -23546, -23853, -24127, -24370, -24587, -24779, -24950, -25102, -25237, -25355, -25462, -25557, -25641, -25715, -25781, -25840, -25892, -25938, -25980, -26016, -26049, -26078, -26103, -26126, -26146, -26164, -26180, -26194, -26206, -26217, -26226, -26235, -26244, -26251, -26257, -26263, -26268, -26272, -26276, -26279, -26282, -26284, -26287, -26289, -26291, -26292, -26294, -26295, -26296, -26297, -26298, -26300, -26301, -26302, -26301, -26301, -26302, -26301, -26303, -26303, -26304, -26305, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26304, -26294, -26337, -26119, -24890, -23931, -22761, -21704, -20612, -19401, -18109, -16789, -15481, -14219, -13026, -11905, -10866, -9910, -9031, -8227, -7494, -6824, -6215, -5661, -5156, -4696, -4271, -3917, -3483, -932};