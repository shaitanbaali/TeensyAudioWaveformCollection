/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0014 256 samples */
 
const int16_t AKWF_0014_256_DATA [256] = 
{837, 1608, 2161, 2643, 3075, 3468, 3833, 4174, 4484, 4768, 5051, 5403, 5785, 6135, 6519, 6939, 7397, 7890, 8409, 8940, 9474, 9990, 10489, 10973, 11457, 11950, 12464, 12997, 13538, 14080, 14598, 15084, 15528, 15918, 16254, 16528, 16739, 16913, 17082, 17277, 17522, 17831, 18202, 18616, 19045, 19464, 19848, 20187, 20475, 20720, 20928, 21106, 21264, 21406, 21535, 21652, 21755, 21843, 21915, 21967, 22006, 22024, 22025, 22010, 21977, 21928, 21860, 21777, 21679, 21565, 21437, 21295, 21138, 20967, 20785, 20591, 20382, 20166, 19935, 19695, 19446, 19190, 18922, 18647, 18363, 18074, 17778, 17475, 17166, 16850, 16532, 16207, 15880, 15546, 15209, 14870, 14525, 14179, 13830, 13476, 13124, 12767, 12407, 12046, 11684, 11318, 10951, 10584, 10214, 9841, 9468, 9092, 8713, 8333, 7950, 7563, 7174, 6780, 6384, 5980, 5569, 5152, 4726, 4288, 3833, 3358, 2860, 2317, 1718, 953, -539, -1475, -2020, -2535, -3024, -3572, -4142, -4689, -5246, -5814, -6395, -6979, -7570, -8155, -8736, -9306, -9866, -10417, -10968, -11531, -12103, -12682, -13259, -13817, -14350, -14841, -15280, -15666, -15993, -16252, -16466, -16663, -16879, -17137, -17459, -17842, -18273, -18727, -19175, -19596, -19970, -20295, -20574, -20811, -21020, -21206, -21373, -21527, -21668, -21795, -21906, -22001, -22080, -22140, -22182, -22206, -22211, -22201, -22170, -22125, -22063, -21984, -21889, -21780, -21655, -21516, -21362, -21198, -21018, -20826, -20622, -20408, -20183, -19950, -19704, -19450, -19188, -18917, -18639, -18354, -18063, -17763, -17460, -17151, -16838, -16518, -16196, -15870, -15538, -15203, -14867, -14525, -14183, -13838, -13491, -13141, -12788, -12435, -12081, -11723, -11364, -11006, -10642, -10280, -9917, -9549, -9181, -8811, -8440, -8067, -7691, -7311, -6930, -6543, -6152, -5755, -5352, -4941, -4519, -4089, -3642, -3172, -2677, -2131, -1525, -664};