/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0065 256 samples */
 
const int16_t AKWF_0065_256_DATA [256] = 
{366, 1414, 2407, 3377, 4258, 4860, 5301, 5709, 6110, 6525, 6966, 7441, 7953, 8500, 9083, 9708, 10389, 11130, 11920, 12755, 13630, 14525, 15425, 16324, 17205, 18067, 18891, 19364, 19477, 19506, 19514, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19516, 19514, 19519, 19479, 19202, 18775, 18321, 17862, 17406, 16956, 16513, 16080, 15657, 15246, 14847, 14461, 14089, 13731, 13388, 13060, 12747, 12449, 12167, 11900, 11647, 11408, 11177, 10955, 10739, 10524, 10307, 10088, 9858, 9616, 9358, 9078, 8773, 8438, 8066, 7654, 7194, 6676, 6090, 5430, 4434, 2914, 1211, -529, -2279, -3905, -5020, -5783, -6411, -6951, -7426, -7847, -8223, -8556, -8852, -9114, -9343, -9542, -9712, -9854, -9971, -10065, -10134, -10183, -10210, -10219, -10209, -10182, -10137, -10077, -10001, -9910, -9805, -9684, -9549, -9472, -9497, -9614, -9852, -10212, -10670, -11193, -11750, -12320, -12878, -13403, -13886, -14317, -14687, -14996, -15242, -15423, -15542, -15598, -15615, -15643, -15680, -15744, -15854, -16010, -16205, -16428, -16665, -16910, -17153, -17387, -17607, -17809, -17989, -18144, -18272, -18372, -18443, -18483, -18493, -18474, -18425, -18349, -18247, -18119, -17969, -17798, -17609, -17404, -17185, -16956, -16719, -16476, -16230, -15985, -15741, -15503, -15272, -15052, -14844, -14650, -14472, -14314, -14176, -14059, -13965, -13894, -13847, -13822, -13817, -13832, -13864, -13910, -13967, -14033, -14104, -14176, -14247, -14313, -14372, -14419, -14453, -14472, -14474, -14457, -14422, -14368, -14293, -14200, -14087, -13954, -13803, -13633, -13445, -13241, -13021, -12784, -12534, -12269, -11991, -11701, -11399, -11084, -10759, -10425, -10078, -9723, -9356, -8980, -8594, -8194, -7784, -7360, -6918, -6457, -5973, -5466, -4881, -3974, -2878, -1771, -662};