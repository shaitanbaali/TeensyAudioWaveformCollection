/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0076 256 samples */
 
const int16_t AKWF_0076_256_DATA [256] = 
{0, 38, -170, 1286, 2384, 1986, 3416, 4542, 4236, 4797, 6624, 6560, 6453, 8234, 8869, 8624, 10443, 11035, 10886, 10959, 12826, 13211, 12918, 14274, 15462, 15283, 15150, 16809, 17614, 17483, 17310, 18403, 19831, 19621, 19687, 19538, 21261, 21971, 21818, 21866, 21746, 22273, 24100, 24016, 24028, 24029, 24029, 24069, 23855, 25137, 26388, 26174, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26214, 26190, 26329, 24587, 23908, 24056, 24029, 24029, 24029, 23993, 24188, 22625, 21693, 21879, 21845, 21811, 21996, 20383, 19515, 19656, 19821, 18792, 17308, 17477, 17640, 16331, 15136, 15298, 15420, 13718, 12947, 13273, 12440, 10778, 10957, 10922, 9025, 8655, 8806, 8535, 6598, 6591, 6336, 4398, 4416, 4130, 2212, 2139, 2339, 722, -172, 153, -558, -2301, -2168, -2135, -3990, -4497, -4184, -5297, -6735, -6475, -6698, -8630, -8788, -8647, -9094, -10925, -10928, -10911, -10936, -12842, -13174, -13128, -12949, -14511, -15443, -15257, -15329, -15127, -16348, -17632, -17441, -17484, -17450, -17568, -19498, -19704, -19650, -19660, -19700, -19489, -20918, -22011, -21808, -21845, -21845, -21845, -21845, -21867, -21747, -22274, -24100, -24016, -24028, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -24029, -23993, -24192, -22655, -21690, -21880, -21845, -21845, -21845, -21845, -21820, -21962, -21315, -19554, -19683, -19661, -19660, -19623, -19824, -18763, -17307, -17515, -17476, -17441, -17633, -16595, -15145, -15325, -15289, -15296, -15291, -13394, -13037, -13123, -13087, -13206, -11427, -10810, -10907, -11097, -9815, -8565, -8753, -8855, -8208, -6445, -6565, -6614, -4773, -4238, -4553, -3472, -2015, -2223, -2184};