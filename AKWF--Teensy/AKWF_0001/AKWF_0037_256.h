/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0037 256 samples */
 
const int16_t AKWF_0037_256_DATA [256] = 
{1271, 3152, 4861, 6445, 7906, 9256, 10509, 11671, 12756, 13773, 14715, 15574, 16327, 16942, 17388, 17635, 17668, 17482, 17084, 16501, 15763, 14908, 13974, 12995, 12009, 11043, 10116, 9238, 8403, 7595, 6799, 5996, 5179, 4355, 3534, 2743, 2018, 1393, 899, 558, 396, 418, 635, 1069, 1687, 2447, 3309, 4230, 5180, 6143, 7108, 8082, 9085, 10128, 11228, 12406, 13671, 15027, 16478, 18000, 19566, 21143, 22679, 24136, 25484, 26697, 27768, 28703, 29507, 30200, 30797, 31305, 31742, 32113, 32416, 32638, 32757, 32742, 32560, 32185, 31602, 30807, 29811, 28641, 27327, 25909, 24427, 22905, 21384, 19886, 18422, 16996, 15598, 14201, 12787, 11329, 9813, 8246, 6634, 5000, 3386, 1822, 345, -1005, -2207, -3239, -4085, -4753, -5258, -5628, -5900, -6104, -6263, -6394, -6496, -6559, -6565, -6492, -6321, -6033, -5616, -5059, -4367, -3558, -2664, -1721, -779, 119, 939, 1658, 2266, 2765, 3166, 3488, 3748, 3963, 4151, 4325, 4487, 4628, 4731, 4767, 4702, 4510, 4170, 3675, 3032, 2262, 1387, 441, -542, -1538, -2515, -3449, -4331, -5158, -5940, -6699, -7456, -8233, -9044, -9882, -10742, -11598, -12416, -13169, -13826, -14349, -14723, -14919, -14942, -14839, -14625, -14329, -13993, -13650, -13330, -13048, -12809, -12606, -12418, -12228, -12012, -11751, -11431, -11040, -10572, -10043, -9474, -8894, -8343, -7855, -7450, -7144, -6941, -6826, -6783, -6793, -6837, -6895, -6956, -7010, -7058, -7114, -7200, -7350, -7601, -7982, -8511, -9199, -10039, -11006, -12075, -13209, -14373, -15540, -16675, -17753, -18764, -19702, -20579, -21418, -22241, -23067, -23913, -24773, -25641, -26489, -27280, -27985, -28571, -29002, -29252, -29300, -29137, -28767, -28212, -27501, -26668, -25748, -24770, -23744, -22677, -21564, -20382, -19115, -17750, -16262, -14645, -12896, -11009, -9013, -6939, -4823, -2723, -639};