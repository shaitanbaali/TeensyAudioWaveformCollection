/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0029 256 samples */
 
const int16_t AKWF_0029_256_DATA [256] = 
{226, 580, 866, 992, 1039, 969, 845, 678, 547, 413, 305, 244, 191, 167, 151, 143, 139, 130, 122, 123, 103, 92, 89, 68, 69, 53, 50, 42, 44, 35, 35, 26, 26, 16, 28, 18, 5, 20, 12, 11, 11, 8, 4, 11, -4, -23, 285, -6367, 3243, 1913, 1979, 2726, 1428, 323, -1179, -2508, -2859, -2209, -1033, 149, 1013, 1416, 1402, 1113, 673, 245, -100, -323, -412, -409, -342, -236, -136, -44, 16, 59, 65, 67, 59, 37, 28, 12, 2, 22, -90, 380, 4029, 1531, 1930, 850, 714, 856, 864, 715, 472, 199, -38, -240, -387, -495, -570, -609, -630, -615, -611, -581, -547, -520, -454, -232, -1816, 22894, -519, -1105, -3251, -4737, -2777, -1207, 512, 1813, 1966, 1133, -130, -1313, -2127, -2480, -2415, -2060, -1563, -1069, -662, -367, -219, -157, -175, -221, -277, -321, -345, -348, -331, -306, -265, -228, -192, -165, -132, -119, -98, -90, -85, -66, -70, -57, -55, -46, -34, -39, -41, -18, -26, -18, -22, -19, -18, -3, -13, -11, -6, -18, -6, -1, -21, -31, 262, -6274, 3172, 1881, 1950, 2718, 1461, 352, -1190, -2552, -2894, -2214, -1017, 164, 1004, 1414, 1386, 1116, 676, 249, -98, -320, -419, -415, -340, -235, -133, -45, 21, 49, 73, 62, 58, 39, 31, 8, 6, -21, 79, -383, -4020, -1549, -1923, -846, -719, -865, -861, -711, -473, -202, 34, 232, 396, 486, 574, 606, 625, 614, 603, 588, 541, 517, 485, 428, 367, -452, -9970, -10101, -937, -852, 413, 1231, 2555, 3756, 4048, 3352, 2170, 974, 123, -321, -359, -123};