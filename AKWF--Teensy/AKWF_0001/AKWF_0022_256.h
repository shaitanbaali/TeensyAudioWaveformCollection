/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0022 256 samples */
 
const int16_t AKWF_0022_256_DATA [256] = 
{499, 1485, 2427, 3350, 4246, 5119, 5968, 6791, 7594, 8381, 9151, 9913, 10669, 11422, 12179, 12942, 13710, 14492, 15285, 16087, 16903, 17729, 18559, 19396, 20234, 21066, 21893, 22705, 23498, 24269, 25011, 25719, 26392, 27024, 27614, 28161, 28662, 29119, 29533, 29903, 30235, 30531, 30791, 31021, 31226, 31409, 31573, 31721, 31857, 31983, 32101, 32212, 32317, 32414, 32504, 32584, 32654, 32710, 32749, 32767, 32763, 32733, 32674, 32583, 32459, 32300, 32109, 31886, 31642, 31380, 31106, 30829, 30548, 30265, 29978, 29683, 29374, 29053, 28715, 28363, 27998, 27625, 27241, 26851, 26451, 26041, 25617, 25173, 24710, 24224, 23715, 23185, 22633, 22060, 21468, 20858, 20228, 19580, 18910, 18219, 17510, 16783, 16038, 15282, 14512, 13732, 12946, 12153, 11353, 10549, 9740, 8926, 8110, 7289, 6465, 5642, 4817, 3991, 3166, 2338, 1509, 680, -153, -987, -1823, -2662, -3500, -4337, -5175, -6009, -6840, -7670, -8492, -9308, -10119, -10918, -11707, -12486, -13249, -13998, -14732, -15445, -16144, -16823, -17482, -18122, -18741, -19340, -19920, -20479, -21018, -21537, -22037, -22515, -22976, -23418, -23840, -24245, -24631, -24996, -25345, -25673, -25982, -26270, -26537, -26782, -27007, -27207, -27385, -27538, -27667, -27771, -27849, -27901, -27926, -27925, -27898, -27845, -27766, -27662, -27532, -27378, -27202, -27002, -26780, -26538, -26279, -26007, -25726, -25443, -25161, -24887, -24631, -24405, -24221, -24092, -24028, -24032, -24103, -24229, -24396, -24588, -24787, -24978, -25152, -25303, -25427, -25524, -25588, -25619, -25608, -25553, -25447, -25284, -25066, -24792, -24472, -24112, -23718, -23304, -22876, -22440, -22000, -21561, -21122, -20686, -20256, -19831, -19415, -19006, -18605, -18210, -17814, -17414, -17004, -16574, -16119, -15635, -15112, -14549, -13945, -13294, -12597, -11857, -11069, -10237, -9366, -8454, -7509, -6536, -5540, -4530, -3513, -2494, -1483, -463};