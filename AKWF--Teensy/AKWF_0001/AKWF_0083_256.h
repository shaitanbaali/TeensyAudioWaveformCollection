/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0083 256 samples */
 
const int16_t AKWF_0083_256_DATA [256] = 
{400, 1633, 2760, 3779, 4764, 5709, 6628, 7513, 8372, 9207, 10013, 10797, 11560, 12300, 13020, 13721, 14401, 15068, 15717, 16349, 16967, 17571, 18162, 18741, 19307, 19844, 20455, 20545, 19356, 18366, 17681, 17212, 16920, 16772, 16740, 16799, 16931, 17118, 17349, 17613, 17904, 18214, 18534, 18867, 19204, 19544, 19884, 20225, 20562, 20894, 21223, 21546, 21861, 22173, 22474, 22772, 23060, 23326, 23666, 23494, 22065, 20828, 19894, 19169, 18617, 18208, 17913, 17707, 17573, 17495, 17460, 17459, 17485, 17529, 17587, 17654, 17727, 17804, 17882, 17960, 18035, 18107, 18176, 18239, 18296, 18349, 18393, 18433, 18465, 18474, 18560, 18122, 16384, 14837, 13596, 12567, 11715, 11009, 10420, 9923, 9498, 9132, 8812, 8525, 8262, 8017, 7787, 7560, 7335, 7110, 6879, 6642, 6393, 6132, 5857, 5567, 5256, 4924, 4575, 4205, 3809, 3393, 2954, 2495, 1990, 1437, 880, 320, -242, -798, -1347, -1888, -2392, -2841, -3266, -3669, -4051, -4408, -4745, -5063, -5360, -5636, -5896, -6139, -6362, -6571, -6765, -6943, -7110, -7263, -7402, -7530, -7645, -7766, -7788, -8362, -10299, -11965, -13260, -14305, -15143, -15814, -16349, -16773, -17108, -17371, -17573, -17725, -17834, -17907, -17952, -17970, -17965, -17941, -17900, -17843, -17771, -17688, -17590, -17481, -17363, -17233, -17094, -16943, -16783, -16631, -16385, -16651, -18196, -19504, -20476, -21218, -21766, -22152, -22413, -22567, -22636, -22634, -22572, -22462, -22311, -22123, -21908, -21666, -21401, -21116, -20813, -20494, -20161, -19815, -19456, -19085, -18703, -18310, -17907, -17492, -17067, -16649, -16136, -16136, -17422, -18477, -19195, -19683, -19975, -20109, -20116, -20014, -19825, -19562, -19240, -18866, -18445, -17988, -17496, -16973, -16422, -15846, -15242, -14616, -13966, -13290, -12589, -11867, -11115, -10338, -9536, -8704, -7846, -6960, -6041, -5089, -4106, -3092, -2001, -774};