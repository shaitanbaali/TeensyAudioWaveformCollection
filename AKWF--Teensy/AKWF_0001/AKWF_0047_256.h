/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0047 256 samples */
 
const int16_t AKWF_0047_256_DATA [256] = 
{-250, -744, -1213, -1663, -2098, -2516, -2921, -3310, -3686, -4048, -4395, -4729, -5052, -5361, -5659, -5946, -6222, -6486, -6740, -6984, -7220, -7446, -7662, -7871, -8072, -8263, -8448, -8625, -8794, -8958, -9114, -9263, -9407, -9545, -9677, -9803, -9924, -10039, -10150, -10255, -10356, -10451, -10543, -10630, -10713, -10791, -10866, -10937, -11002, -11066, -11124, -11180, -11232, -11280, -11326, -11367, -11405, -11440, -11472, -11499, -11526, -11547, -11567, -11583, -11595, -11604, -11611, -11614, -11615, -11611, -11605, -11595, -11584, -11567, -11547, -11525, -11498, -11468, -11434, -11397, -11354, -11308, -11256, -11200, -11136, -11068, -10971, -10839, -10732, -10644, -10538, -10401, -10244, -10079, -9915, -9755, -9585, -9402, -9201, -8989, -8774, -8556, -8332, -8096, -7849, -7592, -7326, -7053, -6774, -6484, -6180, -5863, -5532, -5185, -4819, -4418, -3993, -3251, -2563, -2184, -1690, -1215, -751, -301, 138, 564, 976, 1375, 1762, 2134, 2498, 2849, 3188, 3516, 3833, 4140, 4436, 4725, 5003, 5271, 5531, 5784, 6028, 6263, 6492, 6714, 6926, 7134, 7334, 7528, 7715, 7899, 8074, 8244, 8410, 8569, 8724, 8874, 9019, 9159, 9295, 9428, 9554, 9678, 9797, 9913, 10024, 10133, 10237, 10339, 10436, 10530, 10622, 10711, 10796, 10879, 10959, 11037, 11111, 11182, 11253, 11318, 11382, 11446, 11507, 11564, 11620, 11674, 11725, 11776, 11823, 11869, 11913, 11955, 11996, 12036, 12073, 12108, 12143, 12175, 12207, 12237, 12264, 12293, 12318, 12342, 12366, 12388, 12408, 12428, 12447, 12463, 12481, 12495, 12510, 12523, 12535, 12545, 12556, 12567, 12336, 12086, 12097, 12139, 12054, 11842, 11584, 11356, 11187, 11041, 10862, 10619, 10333, 10042, 9771, 9516, 9245, 8945, 8610, 8262, 7914, 7570, 7214, 6838, 6431, 5998, 5542, 5057, 4487, 3503, 2938, 2409, 1840, 1291, 762, 238};