/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0045 256 samples */
 
const int16_t AKWF_0045_256_DATA [256] = 
{-66, -323, -591, -866, -1150, -1439, -1730, -2029, -2332, -2639, -2948, -3266, -3584, -3904, -4232, -4562, -4896, -5235, -5579, -5924, -6274, -6627, -6986, -7344, -7711, -8077, -8448, -8818, -9195, -9571, -9949, -10332, -10712, -11095, -11475, -11858, -12241, -12620, -13003, -13380, -13756, -14130, -14496, -14863, -15227, -15583, -15935, -16284, -16625, -16959, -17286, -17606, -17922, -18225, -18522, -18811, -19090, -19357, -19617, -19867, -20105, -20333, -20548, -20752, -20947, -21129, -21299, -21457, -21601, -21734, -21855, -21960, -22052, -22134, -22198, -22250, -22288, -22312, -22319, -22312, -22291, -22253, -22200, -22132, -22045, -21945, -21828, -21691, -21538, -21365, -21174, -20969, -20741, -20494, -20229, -19941, -19633, -19305, -18958, -18588, -18196, -17781, -17345, -16887, -16406, -15901, -15374, -14825, -14257, -13666, -13052, -12419, -11766, -11091, -10396, -9687, -8960, -8216, -7464, -6694, -5918, -5134, -4342, -3550, -2765, -1984, -1219, -485, 192, 900, 1657, 2431, 3218, 4007, 4798, 5585, 6365, 7136, 7896, 8645, 9380, 10093, 10798, 11481, 12141, 12786, 13408, 14007, 14586, 15145, 15679, 16193, 16683, 17152, 17597, 18021, 18423, 18803, 19159, 19495, 19812, 20108, 20382, 20637, 20874, 21089, 21285, 21466, 21627, 21771, 21897, 22003, 22096, 22173, 22231, 22274, 22304, 22316, 22313, 22297, 22267, 22220, 22163, 22089, 22000, 21900, 21787, 21659, 21519, 21366, 21203, 21025, 20837, 20636, 20425, 20200, 19967, 19724, 19469, 19201, 18930, 18646, 18353, 18051, 17740, 17423, 17098, 16765, 16426, 16083, 15734, 15378, 15018, 14651, 14282, 13915, 13540, 13164, 12783, 12402, 12022, 11636, 11257, 10875, 10493, 10112, 9731, 9355, 8978, 8605, 8234, 7867, 7501, 7138, 6780, 6424, 6072, 5725, 5382, 5041, 4703, 4373, 4042, 3719, 3400, 3082, 2769, 2461, 2157, 1859, 1561, 1272, 986, 710, 437, 173};