/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0033 256 samples */
 
const int16_t AKWF_0033_256_DATA [256] = 
{-1399, -4737, -7779, -10747, -13657, -16511, -19208, -21598, -23564, -25035, -26037, -26668, -27026, -27208, -27294, -27262, -27127, -26846, -26383, -25695, -24789, -23714, -22451, -21026, -19492, -17841, -16071, -14258, -12443, -10624, -8835, -7140, -5526, -4006, -2607, -1307, -100, 1001, 1995, 2881, 3657, 4310, 4812, 5215, 5506, 5674, 5730, 5675, 5521, 5276, 4951, 4563, 4122, 3637, 3124, 2593, 2050, 1500, 951, 411, -120, -633, -1122, -1586, -2019, -2417, -2777, -3098, -3376, -3602, -3794, -3947, -4060, -4135, -4175, -4185, -4165, -4119, -4054, -3971, -3869, -3754, -3631, -3497, -3357, -3217, -3074, -2927, -2785, -2647, -2510, -2378, -2254, -2134, -2017, -1909, -1808, -1706, -1607, -1512, -1416, -1319, -1222, -1123, -1018, -911, -800, -681, -558, -430, -295, -151, -2, 154, 318, 486, 659, 836, 1016, 1199, 1381, 1563, 1743, 1916, 2086, 2253, 2412, 2561, 2701, 2831, 2949, 3053, 3145, 3225, 3287, 3336, 3371, 3389, 3395, 3389, 3370, 3336, 3293, 3241, 3178, 3105, 3031, 2948, 2861, 2775, 2689, 2600, 2517, 2438, 2363, 2294, 2235, 2185, 2142, 2113, 2096, 2090, 2097, 2119, 2154, 2201, 2263, 2338, 2424, 2524, 2636, 2757, 2889, 3031, 3181, 3335, 3497, 3663, 3831, 4002, 4178, 4351, 4521, 4693, 4860, 5020, 5177, 5330, 5470, 5608, 5737, 5852, 5962, 6067, 6161, 6242, 6318, 6387, 6441, 6489, 6532, 6565, 6587, 6610, 6625, 6628, 6632, 6636, 6633, 6624, 6621, 6616, 6603, 6598, 6595, 6589, 6585, 6590, 6595, 6598, 6613, 6633, 6650, 6675, 6710, 6741, 6782, 6832, 6882, 6934, 6997, 7063, 7127, 7200, 7280, 7357, 7436, 7525, 7614, 7697, 7790, 7885, 7973, 8065, 8162, 8252, 8338, 8433, 8526, 8610, 8689, 8799, 8716, 7481, 5136, 1942};