/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0030 256 samples */
 
const int16_t AKWF_0030_256_DATA [256] = 
{334, 1060, 1805, 2586, 3397, 4241, 5115, 6014, 6942, 7895, 8867, 9862, 10873, 11896, 12934, 13982, 15032, 16087, 17142, 18189, 19232, 20262, 21274, 22271, 23243, 24188, 25104, 25985, 26826, 27628, 28383, 29089, 29743, 30340, 30879, 31356, 31767, 32111, 32386, 32588, 32716, 32768, 32743, 32639, 32454, 32192, 31847, 31422, 30918, 30333, 29671, 28931, 28113, 27222, 26261, 25227, 24126, 22965, 21738, 20455, 19120, 17733, 16301, 14829, 13316, 11774, 10204, 8608, 6997, 5372, 3736, 2103, 470, -1157, -2769, -4366, -5942, -7487, -9004, -10484, -11920, -13314, -14660, -15950, -17187, -18363, -19475, -20524, -21504, -22412, -23249, -24011, -24698, -25309, -25841, -26295, -26672, -26969, -27189, -27334, -27400, -27392, -27310, -27158, -26936, -26645, -26290, -25873, -25395, -24862, -24275, -23638, -22955, -22229, -21462, -20663, -19829, -18968, -18086, -17180, -16258, -15327, -14383, -13437, -12490, -11543, -10604, -9674, -8755, -7853, -6971, -6107, -5269, -4457, -3673, -2922, -2202, -1516, -867, -255, 318, 852, 1347, 1801, 2213, 2585, 2917, 3206, 3456, 3666, 3837, 3970, 4066, 4125, 4149, 4141, 4099, 4026, 3925, 3798, 3644, 3467, 3269, 3049, 2813, 2559, 2291, 2012, 1722, 1421, 1114, 803, 486, 170, -148, -466, -781, -1094, -1401, -1701, -1997, -2285, -2563, -2833, -3092, -3341, -3580, -3808, -4023, -4230, -4423, -4605, -4777, -4937, -5086, -5225, -5354, -5474, -5584, -5687, -5782, -5869, -5949, -6024, -6093, -6157, -6217, -6274, -6328, -6379, -6428, -6476, -6522, -6567, -6612, -6656, -6700, -6742, -6785, -6827, -6867, -6906, -6944, -6979, -7011, -7040, -7064, -7082, -7094, -7100, -7095, -7080, -7056, -7017, -6967, -6900, -6816, -6716, -6594, -6453, -6289, -6100, -5886, -5646, -5376, -5077, -4750, -4389, -3995, -3571, -3108, -2613, -2081, -1515, -915, -263};