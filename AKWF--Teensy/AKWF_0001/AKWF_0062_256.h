/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0062 256 samples */
 
const int16_t AKWF_0062_256_DATA [256] = 
{459, 1317, 2173, 2993, 3763, 4521, 5316, 6144, 6958, 7730, 8473, 9214, 9960, 10689, 11385, 12036, 12643, 13183, 13631, 14123, 14755, 15433, 16186, 17090, 17950, 18547, 18997, 19525, 20138, 20709, 21200, 21633, 22038, 22458, 22933, 23417, 23829, 24171, 24504, 24858, 25209, 25525, 25800, 26044, 26274, 26502, 26721, 26911, 27068, 27206, 27336, 27453, 27552, 27624, 27641, 27547, 27387, 27352, 27520, 27667, 27574, 27341, 27198, 27175, 27137, 27011, 26812, 26586, 26382, 26229, 26082, 25875, 25606, 25337, 25100, 24869, 24613, 24323, 24014, 23704, 23402, 23096, 22770, 22423, 22067, 21714, 21359, 20992, 20610, 20218, 19820, 19420, 19016, 18599, 18172, 17737, 17297, 16855, 16405, 15942, 15472, 14997, 14516, 14028, 13529, 13021, 12503, 11971, 11416, 10809, 10137, 9552, 9231, 8991, 8441, 7578, 6808, 6330, 5914, 5334, 4620, 3885, 3194, 2588, 2035, 1419, 691, -65, -752, -1380, -2024, -2720, -3440, -4152, -4836, -5498, -6163, -6849, -7538, -8210, -8858, -9493, -10127, -10756, -11366, -11936, -12411, -12789, -13185, -13707, -14413, -15189, -15834, -16367, -16971, -17677, -18351, -18898, -19337, -19748, -20206, -20719, -21224, -21658, -22037, -22424, -22845, -23266, -23650, -23986, -24292, -24594, -24900, -25190, -25447, -25671, -25878, -26081, -26273, -26443, -26586, -26708, -26816, -26914, -26996, -27057, -27098, -27122, -27135, -27135, -27120, -27087, -27038, -26977, -26905, -26820, -26721, -26593, -26392, -26118, -25888, -25812, -25785, -25615, -25301, -25010, -24814, -24641, -24415, -24130, -23812, -23500, -23223, -22967, -22681, -22344, -21991, -21659, -21339, -21005, -20646, -20266, -19879, -19489, -19095, -18688, -18258, -17811, -17358, -16898, -16422, -15923, -15396, -14837, -14202, -13430, -12695, -12390, -12430, -12092, -11052, -9932, -9347, -9076, -8594, -7807, -6913, -6067, -5371, -4830, -4251, -3454, -2526, -1689, -997, -297};