/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0081 256 samples */
 
const int16_t AKWF_0081_256_DATA [256] = 
{481, 1833, 3127, 4404, 5662, 6914, 8164, 9400, 10619, 11815, 12986, 14137, 15270, 16377, 17463, 18514, 19516, 20467, 21373, 22248, 23104, 23934, 24728, 25478, 26174, 26813, 27398, 27929, 28411, 28846, 29229, 29557, 29830, 30044, 30202, 30301, 30340, 30320, 30236, 30091, 29885, 29623, 29310, 28947, 28535, 28081, 27584, 27046, 26471, 25861, 25220, 24554, 23863, 23155, 22439, 21717, 20994, 20271, 19545, 18821, 18096, 17369, 16639, 15894, 15138, 14387, 13641, 12901, 12169, 11444, 10720, 9999, 9280, 8568, 7866, 7170, 6486, 5821, 5175, 4552, 3949, 3363, 2796, 2249, 1719, 1211, 731, 274, -156, -562, -948, -1308, -1642, -1951, -2232, -2487, -2717, -2923, -3105, -3262, -3394, -3499, -3579, -3636, -3671, -3684, -3677, -3652, -3607, -3546, -3468, -3376, -3268, -3148, -3015, -2870, -2713, -2545, -2367, -2171, -1953, -1712, -1444, -1150, -824, -443, 13, 526, 1065, 1605, 2138, 2660, 3174, 3693, 4218, 4731, 5224, 5687, 6112, 6500, 6852, 7165, 7439, 7667, 7834, 7935, 7984, 7993, 7972, 7923, 7845, 7733, 7584, 7400, 7181, 6931, 6651, 6339, 5994, 5616, 5203, 4756, 4277, 3764, 3223, 2652, 2051, 1425, 775, 102, -586, -1293, -2015, -2749, -3497, -4256, -5020, -5793, -6570, -7347, -8128, -8908, -9683, -10457, -11227, -11990, -12751, -13506, -14254, -15001, -15748, -16508, -17275, -18036, -18789, -19533, -20265, -20990, -21714, -22444, -23181, -23920, -24656, -25387, -26103, -26794, -27455, -28084, -28682, -29257, -29807, -30327, -30814, -31254, -31642, -31975, -32252, -32473, -32635, -32736, -32769, -32734, -32627, -32453, -32211, -31906, -31535, -31097, -30593, -30020, -29381, -28680, -27921, -27104, -26238, -25319, -24352, -23344, -22293, -21204, -20083, -18927, -17745, -16540, -15309, -14059, -12795, -11515, -10221, -8921, -7609, -6292, -4967, -3622, -2249, -842};