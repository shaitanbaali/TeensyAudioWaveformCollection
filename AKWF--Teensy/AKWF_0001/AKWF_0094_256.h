/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0094 256 samples */
 
const int16_t AKWF_0094_256_DATA [256] = 
{-420, -1422, -2379, -3313, -4221, -5103, -5960, -6788, -7592, -8371, -9123, -9852, -10558, -11239, -11898, -12535, -13148, -13742, -14315, -14866, -15398, -15910, -16402, -16877, -17332, -17769, -18190, -18592, -18976, -19345, -19696, -20031, -20350, -20653, -20941, -21214, -21471, -21713, -21941, -22154, -22352, -22537, -22707, -22865, -23008, -23138, -23254, -23358, -23447, -23524, -23588, -23640, -23679, -23705, -23720, -23721, -23711, -23689, -23655, -23609, -23551, -23482, -23402, -23310, -23207, -23093, -22967, -22831, -22684, -22527, -22359, -22181, -21993, -21794, -21587, -21368, -21140, -20903, -20658, -20402, -20138, -19865, -19584, -19295, -18997, -18692, -18380, -18059, -17732, -17398, -17057, -16712, -16360, -16002, -15643, -15266, -14968, -15187, -15595, -15924, -16125, -16127, -16026, -15886, -15738, -15596, -15467, -15351, -15247, -15152, -15063, -14975, -14887, -14795, -14697, -14588, -14469, -14337, -14190, -14026, -13844, -13645, -13426, -13187, -12929, -12638, -12295, -11908, -11493, -11051, -10584, -10091, -9574, -9032, -8462, -7869, -7248, -6602, -5932, -5236, -4517, -3776, -3009, -2222, -1414, -584, 266, 1133, 2023, 2931, 3859, 4813, 5791, 6891, 8145, 9336, 10466, 11569, 12651, 13727, 14792, 15371, 15539, 15825, 16233, 16738, 17313, 17935, 18583, 19235, 19870, 20478, 21051, 21587, 22087, 22553, 22986, 23391, 23769, 24122, 24456, 24770, 25067, 25349, 25619, 25878, 26127, 26370, 26606, 26843, 27083, 27329, 27668, 28181, 28637, 29002, 29316, 29598, 29863, 30116, 30361, 30600, 30833, 31060, 31279, 31489, 31689, 31876, 32049, 32207, 32349, 32471, 32575, 32657, 32717, 32754, 32767, 32755, 32718, 32654, 32563, 32444, 32296, 32123, 31899, 31466, 30784, 29767, 28486, 27380, 26431, 25565, 24725, 23880, 23012, 22103, 21151, 20160, 19125, 18053, 16952, 15820, 14667, 13500, 12318, 11132, 9948, 8771, 7607, 6556, 5640, 4674, 3661, 2629, 1600, 560};