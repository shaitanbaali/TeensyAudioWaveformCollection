/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0015 256 samples */
 
const int16_t AKWF_0015_256_DATA [256] = 
{484, 1799, 3157, 4620, 6167, 7754, 9340, 10878, 12342, 13710, 14959, 16081, 17069, 17921, 18654, 19280, 19809, 20255, 20626, 20930, 21177, 21374, 21527, 21642, 21723, 21772, 21796, 21797, 21783, 21759, 21731, 21703, 21677, 21652, 21628, 21600, 21563, 21510, 21445, 21376, 21308, 21237, 21160, 21076, 20991, 20911, 20840, 20777, 20721, 20669, 20623, 20585, 20556, 20537, 20523, 20514, 20509, 20508, 20510, 20514, 20519, 20523, 20526, 20528, 20528, 20525, 20519, 20511, 20498, 20482, 20462, 20441, 20419, 20394, 20365, 20331, 20295, 20256, 20220, 20190, 20169, 20153, 20139, 20127, 20119, 20113, 20106, 20095, 20078, 20053, 20015, 19964, 19893, 19798, 19673, 19514, 19314, 19069, 18768, 18403, 17962, 17431, 16815, 16134, 15393, 14578, 13682, 12706, 11658, 10549, 9397, 8225, 7045, 5856, 4679, 3545, 2453, 1370, 122, -1332, -2683, -3867, -4892, -5775, -6554, -7232, -7812, -8310, -8740, -9119, -9461, -9767, -10039, -10292, -10535, -10777, -11021, -11281, -11565, -11886, -12250, -12655, -13096, -13561, -14041, -14529, -15015, -15489, -15947, -16385, -16810, -17233, -17660, -18098, -18543, -18988, -19418, -19827, -20202, -20538, -20833, -21086, -21301, -21487, -21646, -21785, -21905, -22009, -22098, -22175, -22242, -22299, -22345, -22383, -22412, -22433, -22445, -22449, -22446, -22436, -22420, -22398, -22370, -22337, -22299, -22256, -22208, -22154, -22094, -22026, -21950, -21866, -21769, -21657, -21530, -21384, -21223, -21046, -20850, -20632, -20390, -20123, -19835, -19526, -19196, -18845, -18471, -18077, -17664, -17234, -16788, -16328, -15854, -15374, -14894, -14415, -13947, -13496, -13074, -12696, -12365, -12088, -11880, -11729, -11603, -11498, -11432, -11416, -11443, -11507, -11601, -11713, -11836, -11969, -12105, -12235, -12345, -12426, -12469, -12467, -12410, -12285, -12071, -11742, -11107, -10214, -9320, -8436, -7560, -6682, -5784, -4861, -3908, -2930, -1899, -729};