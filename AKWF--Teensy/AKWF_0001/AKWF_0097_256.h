/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0097 256 samples */
 
const int16_t AKWF_0097_256_DATA [256] = 
{-1476, -4498, -7121, -9544, -11770, -13817, -15693, -17401, -18960, -20377, -21661, -22821, -23869, -24811, -25661, -26425, -27107, -27720, -28269, -28761, -29199, -29591, -29941, -30253, -30532, -30778, -30999, -31195, -31370, -31526, -31664, -31789, -31897, -31993, -32082, -32157, -32226, -32287, -32341, -32388, -32431, -32469, -32502, -32531, -32557, -32582, -32603, -32619, -32638, -32651, -32665, -32676, -32687, -32696, -32703, -32712, -32717, -32722, -32728, -32733, -32736, -32740, -32742, -32746, -32746, -32750, -32751, -32752, -32756, -32756, -32756, -32760, -32760, -32761, -32760, -32761, -32759, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32764, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32766, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32765, -32762, -32773, -32699, -32313, -31786, -30932, -29763, -28274, -26487, -24426, -22125, -19616, -16921, -14090, -11155, -8146, -5100, -1935, 1508, 4486, 7114, 9543, 11770, 13816, 15693, 17401, 18960, 20377, 21660, 22821, 23869, 24811, 25661, 26425, 27106, 27721, 28269, 28761, 29200, 29591, 29940, 30253, 30531, 30778, 30999, 31195, 31371, 31526, 31664, 31788, 31897, 31993, 32082, 32158, 32226, 32287, 32341, 32388, 32431, 32468, 32502, 32531, 32557, 32582, 32602, 32620, 32638, 32651, 32665, 32676, 32687, 32696, 32703, 32711, 32716, 32723, 32727, 32733, 32736, 32740, 32742, 32746, 32746, 32750, 32751, 32752, 32756, 32756, 32755, 32759, 32761, 32760, 32760, 32760, 32760, 32764, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32765, 32762, 32773, 32698, 32313, 31786, 30932, 29762, 28274, 26487, 24425, 22124, 19616, 16921, 14089, 11155, 8152, 5109, 1900};