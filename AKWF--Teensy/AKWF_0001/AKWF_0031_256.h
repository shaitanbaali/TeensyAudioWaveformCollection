/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0031 256 samples */
 
const int16_t AKWF_0031_256_DATA [256] = 
{30, 90, 140, 184, 225, 262, 298, 333, 370, 409, 451, 498, 550, 607, 671, 741, 817, 899, 988, 1082, 1181, 1284, 1391, 1502, 1615, 1729, 1845, 1960, 2075, 2189, 2302, 2412, 2520, 2625, 2728, 2827, 2923, 3016, 3107, 3194, 3279, 3362, 3442, 3521, 3599, 3676, 3752, 3828, 3903, 3980, 4056, 4133, 4211, 4291, 4372, 4454, 4537, 4622, 4708, 4796, 4885, 4976, 5067, 5160, 5253, 5347, 5441, 5536, 5631, 5726, 5821, 5916, 6010, 6104, 6197, 6290, 6382, 6473, 6564, 6653, 6742, 6831, 6919, 7005, 7092, 7179, 7264, 7350, 7435, 7520, 7606, 7691, 7776, 7862, 7948, 8034, 8121, 8207, 8295, 8383, 8471, 8559, 8648, 8737, 8827, 8917, 9006, 9096, 9187, 9277, 9367, 9458, 9548, 9638, 9728, 9818, 9908, 9998, 10087, 10176, 10265, 10354, 10439, 10515, 10570, 10587, 10546, 10424, 10195, 9835, 9318, 8620, 7726, 6623, 5301, 3770, 2035, 116, -1951, -4139, -6402, -8684, -10946, -13128, -15172, -17039, -18677, -20042, -21110, -21854, -22258, -22323, -22051, -21461, -20574, -19428, -18060, -16511, -14836, -13082, -11296, -9533, -7836, -6245, -4802, -3532, -2459, -1603, -968, -558, -369, -389, -601, -983, -1514, -2165, -2903, -3706, -4541, -5380, -6200, -6977, -7689, -8322, -8863, -9301, -9632, -9853, -9966, -9973, -9882, -9701, -9440, -9111, -8724, -8293, -7830, -7347, -6854, -6364, -5883, -5420, -4985, -4580, -4211, -3882, -3593, -3346, -3141, -2976, -2851, -2762, -2708, -2683, -2686, -2713, -2759, -2819, -2891, -2971, -3054, -3138, -3218, -3291, -3355, -3407, -3445, -3467, -3472, -3459, -3426, -3375, -3304, -3215, -3109, -2985, -2848, -2698, -2535, -2364, -2187, -2006, -1822, -1639, -1458, -1282, -1112, -949, -796, -654, -522, -402, -294, -196, -111, -34};