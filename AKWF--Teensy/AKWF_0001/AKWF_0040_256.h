/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0040 256 samples */
 
const int16_t AKWF_0040_256_DATA [256] = 
{360, 1169, 1961, 2752, 3543, 4332, 5121, 5902, 6681, 7426, 8375, 7387, 5796, 6271, 6985, 7822, 8743, 9729, 10761, 11823, 12906, 13995, 15079, 16153, 17205, 18229, 19224, 20182, 21099, 21976, 22810, 23600, 24347, 25051, 25711, 26333, 26914, 27457, 27964, 28437, 28877, 29285, 29665, 30015, 30341, 30640, 30916, 31171, 31403, 31616, 31809, 31982, 32138, 32276, 32396, 32498, 32585, 32655, 32708, 32745, 32765, 32768, 32757, 32727, 32682, 32622, 32544, 32449, 32339, 32212, 32068, 31908, 31732, 31537, 31327, 31101, 30856, 30596, 30318, 30025, 29716, 29388, 29045, 28688, 28312, 27920, 27513, 27088, 26650, 26197, 25726, 25242, 24744, 24228, 23701, 23160, 22603, 22034, 21451, 20855, 20247, 19626, 18993, 18349, 17695, 17027, 16351, 15664, 14966, 14262, 13547, 12823, 12093, 11354, 10608, 9856, 9097, 8331, 7564, 6789, 6010, 5229, 4441, 3653, 2863, 2068, 1275, 480, -317, -1111, -1906, -2700, -3492, -4283, -5071, -5855, -6635, -7414, -8186, -8953, -9718, -10473, -11224, -11968, -12703, -13431, -14152, -14864, -15567, -16261, -16945, -17618, -18281, -18931, -19573, -20201, -20816, -21421, -22010, -22587, -23152, -23700, -24234, -24756, -25262, -25751, -26227, -26684, -27128, -27555, -27963, -28356, -28733, -29091, -29432, -29755, -30060, -30348, -30617, -30866, -31098, -31310, -31504, -31680, -31836, -31972, -32090, -32188, -32267, -32326, -32366, -32386, -32387, -32369, -32331, -32273, -32196, -32098, -31982, -31848, -31693, -31520, -31327, -31116, -30887, -30638, -30370, -30085, -29781, -29461, -29121, -28764, -28390, -27999, -27590, -27165, -26724, -26269, -25794, -25305, -24804, -24283, -23751, -23203, -22641, -22066, -21478, -20875, -20262, -19637, -18997, -18348, -17687, -17015, -16335, -15643, -14941, -14233, -13513, -12787, -12054, -11312, -10563, -9809, -9048, -8281, -7511, -6736, -5955, -5172, -4386, -3596, -2807, -2013, -1222, -413};