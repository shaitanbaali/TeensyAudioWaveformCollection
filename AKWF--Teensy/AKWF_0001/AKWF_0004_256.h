/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0004 256 samples */
 
const int16_t AKWF_0004_256_DATA [256] = 
{5297, 13274, 16686, 18599, 19904, 20706, 21340, 22136, 23298, 24818, 26527, 28194, 29653, 30811, 31653, 32229, 32580, 32746, 32752, 32644, 32468, 32270, 32059, 31807, 31473, 31024, 30437, 29706, 28838, 27823, 26694, 25351, 23629, 21777, 19968, 18207, 16324, 12943, 5978, -1117, -6394, -9422, -10954, -12601, -14481, -16446, -18708, -20881, -22754, -24301, -25525, -26446, -27118, -27604, -27969, -28272, -28553, -28806, -29029, -29191, -29272, -29270, -29164, -28955, -28642, -28223, -27653, -26865, -25995, -25101, -24197, -23176, -21908, -20416, -18926, -17707, -16876, -16300, -15616, -14606, -12257, -8099, -3720, 372, 4069, 7150, 9428, 10898, 11645, 12031, 12369, 12741, 13053, 13148, 12864, 12158, 11008, 9451, 7512, 5158, 2435, -1154, -6263, -11679, -14721, -15362, -15025, -14066, -12792, -12181, -13149, -14398, -15533, -16596, -17383, -17860, -18007, -17828, -17357, -16521, -15405, -14232, -12490, -10179, -7789, -4898, -1410, 2565, 6872, 11721, 15230, 17430, 19348, 20592, 21115, 21029, 20738, 20718, 21096, 21793, 22595, 23375, 24112, 24763, 25264, 25540, 25539, 25279, 24823, 24240, 23607, 22956, 22260, 21355, 20361, 19366, 18386, 17316, 15969, 14455, 12394, 10410, 9586, 9116, 8161, 6136, 3040, -720, -4575, -8064, -11079, -13382, -14417, -15015, -15453, -15775, -16078, -16394, -16705, -16988, -17213, -17349, -17373, -17287, -17073, -16732, -16281, -15680, -14804, -13771, -12060, -10199, -8258, -5649, -2206, 1725, 5483, 8490, 10453, 11522, 12106, 12852, 13784, 14664, 15714, 16824, 17833, 18564, 18949, 19003, 18848, 18624, 18370, 18078, 17690, 17134, 16398, 15445, 14348, 12242, 8860, 5077, 460, -5944, -12744, -16237, -17836, -18566, -18735, -18918, -19494, -20529, -21870, -23286, -24600, -25724, -26614, -27268, -27695, -27911, -27957, -27861, -27651, -27349, -26969, -26513, -25960, -25293, -24468, -23462, -22219, -20702, -18831, -16618, -13320, -5986};