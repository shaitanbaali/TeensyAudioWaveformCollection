/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0008 256 samples */
 
const int16_t AKWF_0008_256_DATA [256] = 
{-319, -1043, -1864, -2740, -3647, -4570, -5500, -6424, -7340, -8242, -9122, -9981, -10814, -11617, -12392, -13136, -13845, -14524, -15169, -15780, -16359, -16905, -17418, -17900, -18351, -18771, -19164, -19527, -19862, -20172, -20456, -20715, -20952, -21166, -21359, -21531, -21683, -21818, -21934, -22033, -22117, -22185, -22237, -22276, -22301, -22313, -22312, -22299, -22273, -22236, -22187, -22127, -22055, -21971, -21876, -21770, -21652, -21522, -21381, -21228, -21062, -20885, -20695, -20494, -20280, -20055, -19818, -19571, -19313, -19046, -18770, -18488, -18199, -17905, -17609, -17311, -17015, -16723, -16436, -16157, -15890, -15636, -15398, -15181, -14985, -14814, -14670, -14557, -14477, -14433, -14429, -14469, -14556, -14698, -14919, -15304, -15833, -16461, -17192, -18026, -18949, -19946, -20993, -22062, -23129, -24167, -25152, -26068, -26902, -27644, -28292, -28846, -29308, -29687, -29987, -30215, -30379, -30484, -30535, -30535, -30486, -30390, -30248, -30058, -29820, -29533, -29196, -28808, -28367, -27874, -27327, -26727, -26074, -25368, -24608, -23799, -22939, -22027, -21069, -20063, -19010, -17917, -16781, -15605, -14397, -13154, -11885, -10597, -9291, -7977, -6668, -5369, -4100, -2879, -1729, -696, 49, 842, 1938, 3164, 4496, 5900, 7361, 8867, 10396, 11943, 13500, 15052, 16628, 18251, 19868, 21458, 23007, 24495, 25908, 27222, 28413, 29473, 30383, 31137, 31738, 32188, 32498, 32685, 32762, 32750, 32669, 32535, 32366, 32178, 31984, 31796, 31621, 31466, 31336, 31234, 31162, 31118, 31103, 31115, 31153, 31213, 31292, 31390, 31500, 31621, 31751, 31884, 32019, 32152, 32281, 32402, 32511, 32605, 32681, 32735, 32764, 32763, 32729, 32658, 32546, 32388, 32182, 31923, 31607, 31233, 30797, 30294, 29726, 29090, 28385, 27612, 26770, 25861, 24890, 23855, 22762, 21619, 20426, 19190, 17921, 16621, 15299, 13966, 12625, 11286, 9961, 8652, 7373, 6133, 4937, 3800, 2734, 1753, 879, 176};