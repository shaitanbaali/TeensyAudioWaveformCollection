/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0001 256 samples */
 
const int16_t AKWF_0001_256_DATA [256] = 
{1161, 4759, 8715, 12926, 16418, 19441, 23692, 27131, 29993, 31865, 32696, 32627, 31802, 30407, 28577, 26421, 24027, 21267, 18027, 14256, 9966, 5288, 464, -4205, -8414, -11403, -14220, -17224, -19471, -21269, -22430, -23005, -23047, -22586, -21682, -20405, -18833, -17015, -14998, -12839, -10579, -8267, -5960, -3690, -1500, 565, 2486, 4232, 5775, 7102, 8199, 8985, 9567, 10202, 10663, 11036, 11293, 11443, 11497, 11463, 11349, 11167, 10929, 10645, 10317, 9949, 9541, 9092, 8600, 8061, 7470, 6825, 6120, 5354, 4529, 3643, 2701, 1717, 690, -365, -1434, -2513, -3588, -4643, -5675, -6674, -7629, -8541, -9400, -10201, -10946, -11624, -12230, -12759, -13199, -13543, -13779, -13898, -13892, -13755, -13486, -13087, -12564, -11929, -11193, -10376, -9500, -8587, -7665, -6761, -5896, -5092, -4362, -3699, -3088, -2403, -1901, -1566, -1287, -1057, -797, -448, 53, 767, 1745, 3037, 4653, 6926, 9442, 11187, 13575, 16636, 19722, 22730, 25276, 27144, 28234, 28530, 28122, 27166, 25831, 24254, 22507, 20606, 18519, 16150, 13414, 10247, 6614, 2593, -1655, -5928, -9941, -13434, -15767, -18142, -20568, -22384, -23818, -24713, -25120, -25074, -24605, -23763, -22620, -21232, -19644, -17902, -16034, -14075, -12064, -10022, -7977, -5955, -3969, -2039, -189, 1579, 3246, 4799, 6238, 7553, 8737, 9798, 10733, 11546, 12247, 12841, 13333, 13735, 14049, 14281, 14434, 14506, 14498, 14406, 14224, 13948, 13572, 13094, 12513, 11828, 11049, 10178, 9226, 8207, 7130, 6005, 4851, 3668, 2471, 1269, 66, -1130, -2310, -3474, -4613, -5722, -6803, -7845, -8844, -9793, -10681, -11499, -12232, -12865, -13388, -13788, -14053, -14181, -14170, -14026, -13759, -13388, -12936, -12430, -11904, -11394, -10944, -10584, -10648, -10907, -10968, -11198, -11542, -11896, -12165, -12270, -12144, -11742, -11037, -10019, -8681, -6998, -4948, -2130};