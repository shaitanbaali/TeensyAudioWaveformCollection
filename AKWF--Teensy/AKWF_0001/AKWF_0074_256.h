/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0074 256 samples */
 
const int16_t AKWF_0074_256_DATA [256] = 
{0, 0, 0, 0, 0, 52, -246, 3487, 4940, 4624, 4681, 4691, 4657, 4741, 8840, 9494, 9332, 9362, 9362, 9434, 9039, 12494, 14354, 13974, 14043, 14043, 14043, 14123, 13691, 16495, 19056, 18649, 18724, 18724, 18724, 18724, 18724, 18732, 18715, 18724, 22790, 23557, 23371, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23405, 23394, 23437, 23313, 19201, 18602, 18752, 18724, 18724, 18724, 18724, 18724, 18657, 19025, 15471, 13748, 14108, 14043, 14043, 14043, 13960, 14407, 11285, 9011, 9442, 9362, 9362, 9292, 9673, 7813, 4358, 4753, 4681, 4681, 4595, 5054, 2308, -372, 85, 0, 0, -57, 259, -1194, -4927, -4629, -4681, -4681, -4701, -4607, -4951, -9093, -9437, -9343, -9362, -9362, -9370, -9354, -9363, -13429, -14195, -14010, -14043, -14043, -14043, -14043, -14129, -13671, -16416, -19096, -18639, -18724, -18724, -18724, -18724, -18724, -18724, -18724, -18809, -18354, -21355, -23766, -23323, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23460, -23155, -24543, -28315, -28038, -28086, -28086, -28086, -28086, -28086, -28086, -28002, -28454, -25392, -23050, -23487, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23405, -23349, -23665, -22212, -18479, -18777, -18725, -18724, -18724, -18724, -18724, -18724, -18724, -18724, -18702, -18818, -18375, -14239, -13987, -14059, -14043, -14043, -14043, -14043, -14042, -14004, -14236, -10388, -9131, -9412, -9362, -9362, -9362, -9306, -9622, -8169, -4436, -4734, -4682, -4681, -4681, -4681, -4681};