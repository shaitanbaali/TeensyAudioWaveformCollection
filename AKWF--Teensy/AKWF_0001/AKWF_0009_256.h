/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0009 256 samples */
 
const int16_t AKWF_0009_256_DATA [256] = 
{27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27064, 27786, 24374, 24682, 27744, 27079, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27172, 26613, 29832, -13969, -29828, -27771, -6276, 1398, -303, -1, 0, -1, 0, -1, -1, 0, 0, -1, 0, 0, -1, -1, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 386, -1738, 13155, 28777, 26826, 27175, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 26180, 31508, -375, -31494, -26184, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -26672, -29826, -15713, 8425, -1781, -201, 2147, -13026, -29345, -25788, -31259, 8628, 27724, -8712, 740, -170, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1, -1, -59, 136, 96, -26120, -10471, 2065, -425, 0, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, -1, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, -1, -1, 0, 0, 0, -1, -1, -1, 0, -1, -1, 0, 0, -1};