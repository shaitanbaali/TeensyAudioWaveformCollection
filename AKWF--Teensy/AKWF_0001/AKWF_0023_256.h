/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0023 256 samples */
 
const int16_t AKWF_0023_256_DATA [256] = 
{-1567, -5063, -8040, -10608, -12806, -14677, -16261, -17590, -18705, -19634, -20401, -21030, -21541, -21949, -22270, -22514, -22694, -22817, -22892, -22926, -22924, -22891, -22832, -22750, -22648, -22530, -22397, -22252, -22095, -21930, -21757, -21577, -21391, -21200, -21005, -20806, -20604, -20398, -20191, -19982, -19770, -19557, -19343, -19128, -18912, -18695, -18478, -18259, -18040, -17821, -17601, -17381, -17161, -16940, -16720, -16498, -16277, -16056, -15834, -15613, -15391, -15170, -14948, -14726, -14504, -14282, -14061, -13838, -13616, -13395, -13172, -12951, -12728, -12506, -12284, -12062, -11840, -11618, -11396, -11174, -10952, -10729, -10507, -10286, -10063, -9841, -9619, -9397, -9175, -8953, -8731, -8509, -8286, -8064, -7842, -7620, -7397, -7176, -6954, -6731, -6509, -6287, -6065, -5843, -5621, -5398, -5177, -4955, -4732, -4510, -4288, -4066, -3844, -3622, -3399, -3177, -2955, -2733, -2511, -2288, -2066, -1845, -1622, -1400, -1178, -956, -734, -512, -290, -67, 155, 377, 599, 821, 1043, 1265, 1488, 1710, 1932, 2154, 2376, 2598, 2820, 3042, 3265, 3487, 3709, 3931, 4154, 4375, 4597, 4820, 5042, 5264, 5486, 5708, 5930, 6153, 6375, 6597, 6819, 7041, 7263, 7485, 7707, 7930, 8152, 8374, 8596, 8819, 9040, 9262, 9485, 9707, 9929, 10151, 10373, 10595, 10818, 11039, 11262, 11484, 11706, 11928, 12150, 12372, 12595, 12817, 13038, 13261, 13483, 13705, 13927, 14149, 14372, 14594, 14816, 15038, 15260, 15482, 15704, 15927, 16149, 16371, 16593, 16815, 17037, 17260, 17481, 17704, 17926, 18148, 18370, 18593, 18814, 19037, 19259, 19481, 19703, 19925, 20147, 20369, 20592, 20813, 21036, 21258, 21480, 21702, 21924, 22146, 22369, 22591, 22813, 23035, 23257, 23479, 23701, 23923, 24146, 24368, 24590, 24812, 25034, 25256, 25478, 25701, 25923, 26132, 26282, 26977, 19435, 13720, 10498, 7345, 5247, 2005};