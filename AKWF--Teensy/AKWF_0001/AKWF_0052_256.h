/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0052 256 samples */
 
const int16_t AKWF_0052_256_DATA [256] = 
{646, 2168, 3655, 5144, 6583, 7976, 9372, 10718, 12039, 13349, 14644, 15928, 17186, 18392, 19550, 20646, 21657, 22573, 23332, 23967, 24535, 25076, 25601, 26110, 26620, 27117, 27513, 27823, 28088, 28304, 28470, 28620, 28674, 28562, 28343, 28090, 27808, 27505, 27218, 26901, 26463, 25907, 25264, 24561, 23885, 23259, 22641, 22051, 21503, 20951, 20386, 19844, 19285, 18683, 18079, 17494, 16921, 16376, 15920, 15558, 15248, 15036, 14914, 14865, 14915, 15077, 15276, 15454, 15622, 15777, 15951, 16217, 16561, 16915, 17259, 17627, 18007, 18393, 18860, 19425, 20029, 20636, 21243, 21815, 22336, 22845, 23327, 23790, 24246, 24694, 25100, 25439, 25742, 25980, 26152, 26311, 26438, 26498, 26515, 26473, 26337, 26102, 25786, 25366, 24843, 24288, 23695, 23027, 22307, 21577, 20815, 20006, 19191, 18351, 17424, 16448, 15425, 14330, 13167, 11966, 10712, 9393, 8040, 6659, 5233, 3769, 2334, 865, -646, -2141, -3630, -5116, -6575, -8001, -9393, -10740, -12061, -13371, -14667, -15944, -17165, -18373, -19528, -20624, -21642, -22553, -23335, -23985, -24549, -25089, -25614, -26121, -26633, -27117, -27508, -27813, -28075, -28300, -28468, -28610, -28679, -28578, -28345, -28092, -27809, -27506, -27218, -26900, -26462, -25906, -25268, -24576, -23888, -23254, -22646, -22047, -21493, -20949, -20388, -19833, -19285, -18704, -18088, -17501, -16936, -16392, -15924, -15551, -15250, -15028, -14906, -14867, -14913, -15070, -15281, -15463, -15622, -15778, -15959, -16217, -16559, -16920, -17265, -17627, -18008, -18403, -18862, -19425, -20029, -20632, -21233, -21808, -22335, -22833, -23329, -23795, -24250, -24698, -25104, -25443, -25744, -25977, -26151, -26301, -26429, -26502, -26508, -26469, -26347, -26107, -25781, -25366, -24852, -24281, -23690, -23040, -22313, -21579, -20823, -20021, -19195, -18341, -17423, -16435, -15409, -14323, -13158, -11946, -10718, -9420, -8056, -6675, -5258, -3797, -2332, -822};