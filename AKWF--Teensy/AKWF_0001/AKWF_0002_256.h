/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0002 256 samples */
 
const int16_t AKWF_0002_256_DATA [256] = 
{808, 4284, 8163, 12044, 15737, 19115, 22101, 24644, 26750, 28429, 29701, 30603, 31160, 31391, 31308, 30914, 30205, 29171, 27817, 26162, 24217, 22008, 19573, 16950, 14215, 11447, 8724, 6144, 3793, 1741, 195, -1059, -2447, -3720, -4796, -5642, -6238, -6583, -6691, -6586, -6300, -5858, -5287, -4616, -3874, -3098, -2317, -1569, -888, -309, 113, 521, 924, 1252, 1491, 1633, 1678, 1631, 1496, 1283, 1006, 684, 340, 35, -267, -635, -1011, -1366, -1672, -1907, -2055, -2107, -2059, -1905, -1642, -1273, -810, -298, 198, 871, 1733, 2728, 3823, 4979, 6162, 7327, 8430, 9436, 10303, 11000, 11500, 11779, 11824, 11629, 11198, 10550, 9691, 8631, 7382, 5962, 4418, 2802, 1202, -125, -1583, -3391, -5311, -7265, -9174, -10963, -12585, -13988, -15134, -16000, -16564, -16814, -16747, -16365, -15687, -14735, -13530, -12085, -10417, -8562, -6573, -4512, -2471, -658, 864, 2731, 4792, 6864, 8854, 10694, 12327, 13706, 14804, 15600, 16082, 16249, 16104, 15662, 14945, 13985, 12811, 11437, 9894, 8220, 6457, 4664, 2916, 1283, -7, -1258, -2738, -4214, -5613, -6882, -7972, -8856, -9518, -9945, -10141, -10113, -9875, -9453, -8875, -8172, -7367, -6484, -5554, -4604, -3663, -2767, -1936, -1202, -583, -119, 212, 532, 789, 960, 1042, 1033, 938, 764, 527, 251, -10, -305, -680, -1082, -1487, -1863, -2188, -2438, -2596, -2651, -2599, -2437, -2162, -1772, -1283, -709, -138, 444, 1251, 2208, 3263, 4378, 5505, 6594, 7603, 8484, 9192, 9694, 9956, 9958, 9698, 9178, 8391, 7324, 5988, 4409, 2633, 847, -769, -2919, -5553, -8454, -11510, -14590, -17599, -20444, -23046, -25365, -27371, -29046, -30401, -31439, -32174, -32616, -32769, -32622, -32158, -31347, -30163, -28580, -26569, -24098, -21142, -17739, -13965, -9949, -5900, -2080};