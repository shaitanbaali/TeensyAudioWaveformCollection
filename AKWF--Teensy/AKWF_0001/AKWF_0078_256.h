/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0078 256 samples */
 
const int16_t AKWF_0078_256_DATA [256] = 
{350, 869, 1352, 1777, 2124, 2379, 2541, 2622, 2640, 2622, 2596, 2589, 2622, 2710, 2861, 3070, 3327, 3616, 3917, 4208, 4471, 4694, 4866, 4992, 5077, 5132, 5176, 5228, 5301, 5412, 5570, 5777, 6031, 6321, 6638, 6964, 7282, 7581, 7848, 8074, 8261, 8410, 8531, 8631, 8726, 8826, 8941, 9079, 9244, 9437, 9653, 9883, 10120, 10357, 10581, 10788, 10972, 11134, 11278, 11405, 11525, 11645, 11773, 11915, 12078, 12262, 12468, 12693, 12930, 13175, 13418, 13654, 13878, 14085, 14275, 14448, 14608, 14756, 14903, 15050, 15201, 15363, 15538, 15723, 15920, 16124, 16332, 16541, 16745, 16941, 17128, 17305, 17473, 17633, 17787, 17940, 18097, 18259, 18429, 18609, 18798, 18996, 19202, 19410, 19619, 19827, 20029, 20225, 20414, 20594, 20768, 20937, 21105, 21272, 21441, 21614, 21792, 21975, 22164, 22357, 22551, 22746, 22893, 23204, 22736, 15362, 3505, -7612, -15937, -21427, -25119, -27989, -30394, -32136, -32783, -32054, -30035, -27179, -24148, -21584, -19975, -19553, -20291, -21968, -24214, -26617, -28747, -30221, -30752, -30164, -28429, -25652, -22083, -18073, -14006, -10303, -7316, -5304, -4418, -4666, -5933, -7986, -10530, -13234, -15765, -17852, -19297, -20000, -19966, -19296, -18166, -16797, -15426, -14269, -13492, -13193, -13392, -14030, -14979, -16067, -17102, -17896, -18293, -18191, -17551, -16410, -14855, -13036, -11127, -9307, -7749, -6583, -5887, -5689, -5955, -6598, -7495, -8505, -9481, -10294, -10851, -11093, -11012, -10643, -10058, -9350, -8624, -7979, -7498, -7231, -7195, -7370, -7709, -8136, -8563, -8907, -9089, -9055, -8781, -8267, -7550, -6687, -5754, -4832, -3995, -3313, -2827, -2555, -2492, -2605, -2846, -3151, -3462, -3716, -3865, -3883, -3760, -3506, -3150, -2732, -2297, -1892, -1554, -1312, -1176, -1141, -1189, -1289, -1402, -1488, -1511, -1444, -1270, -986, -606, -138};