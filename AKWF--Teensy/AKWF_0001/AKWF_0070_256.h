/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0070 256 samples */
 
const int16_t AKWF_0070_256_DATA [256] = 
{274, 844, 1443, 2078, 2748, 3453, 4191, 4958, 5757, 6586, 7441, 8324, 9242, 10171, 11068, 11920, 12727, 13496, 14224, 14912, 15564, 16180, 16761, 17309, 17824, 18308, 18762, 19187, 19583, 19953, 20296, 20615, 20899, 21120, 21282, 21394, 21456, 21469, 21436, 21358, 21237, 21073, 20870, 20627, 20347, 20031, 19679, 19293, 18876, 18426, 17945, 17437, 16892, 16317, 15753, 15206, 14678, 14169, 13677, 13202, 12745, 12302, 11875, 11463, 11065, 10681, 10311, 9953, 9607, 9274, 8952, 8642, 8342, 8052, 7773, 7503, 7242, 6991, 6749, 6515, 6289, 6070, 5859, 5656, 5460, 5270, 5088, 4911, 4740, 4576, 4417, 4264, 4116, 3973, 3835, 3702, 3573, 3450, 3330, 3214, 3103, 2995, 2891, 2791, 2694, 2600, 2511, 2414, 2265, 2058, 1798, 1487, 1128, 721, 268, -228, -768, -1348, -1967, -2626, -3321, -4051, -4817, -5615, -6445, -7307, -8198, -9117, -10067, -11041, -12041, -13068, -14117, -15203, -16292, -17333, -18328, -19278, -20180, -21041, -21861, -22637, -23377, -24079, -24743, -25373, -25970, -26532, -27064, -27566, -28037, -28481, -28897, -29286, -29650, -29990, -30305, -30597, -30868, -31117, -31346, -31549, -31693, -31779, -31821, -31820, -31777, -31695, -31573, -31414, -31220, -30991, -30727, -30433, -30106, -29749, -29364, -28950, -28508, -28042, -27549, -27032, -26492, -25928, -25343, -24737, -24109, -23463, -22798, -22114, -21400, -20666, -19949, -19257, -18590, -17944, -17322, -16721, -16140, -15581, -15040, -14517, -14015, -13528, -13058, -12605, -12168, -11745, -11338, -10944, -10564, -10198, -9844, -9503, -9173, -8855, -8547, -8251, -7965, -7688, -7422, -7164, -6915, -6676, -6444, -6220, -6005, -5796, -5595, -5401, -5213, -5033, -4858, -4689, -4527, -4369, -4218, -4072, -3930, -3794, -3662, -3535, -3413, -3294, -3180, -3069, -2964, -2852, -2695, -2485, -2226, -1919, -1566, -1168, -728, -235};