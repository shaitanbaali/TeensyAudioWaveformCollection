/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0013 256 samples */
 
const int16_t AKWF_0013_256_DATA [256] = 
{432, 1682, 2995, 4332, 5641, 6902, 8111, 9266, 10379, 11455, 12495, 13505, 14486, 15433, 16351, 17238, 18090, 18911, 19697, 20445, 21159, 21833, 22467, 23062, 23616, 24127, 24598, 25027, 25412, 25755, 26052, 26300, 26495, 26628, 26690, 26671, 26558, 26337, 25996, 25525, 24916, 24173, 23312, 22357, 21356, 20377, 19493, 18790, 18340, 18181, 18234, 18073, 17444, 16455, 15282, 14116, 13131, 12426, 12016, 11848, 11818, 11804, 11778, 11848, 12110, 12592, 13248, 13956, 14544, 14845, 14757, 14272, 13691, 13470, 13633, 14034, 14527, 14991, 15346, 15546, 15579, 15452, 15185, 14802, 14324, 13774, 13170, 12522, 11842, 11138, 10413, 9671, 8917, 8148, 7369, 6582, 5784, 4982, 4174, 3361, 2548, 1734, 921, 112, -693, -1493, -2282, -3062, -3832, -4588, -5331, -6059, -6769, -7464, -8140, -8796, -9434, -10051, -10646, -11221, -11773, -12302, -12811, -13294, -13756, -14195, -14611, -15004, -15375, -15722, -16047, -16351, -16631, -16889, -17125, -17338, -17529, -17698, -17844, -17967, -18067, -18143, -18194, -18219, -18215, -18181, -18112, -18006, -17856, -17656, -17399, -17076, -16679, -16199, -15629, -14965, -14209, -13367, -12460, -11515, -10571, -9683, -8906, -8295, -7896, -7734, -7802, -7965, -7887, -7457, -6752, -5864, -4901, -3970, -3153, -2512, -2075, -1842, -1792, -1887, -2079, -2320, -2560, -2776, -3004, -3299, -3699, -4223, -4877, -5650, -6515, -7431, -8351, -9218, -9983, -10605, -11049, -11300, -11357, -11237, -10967, -10632, -10426, -10420, -10576, -10855, -11220, -11638, -12080, -12523, -12949, -13344, -13701, -14011, -14272, -14483, -14642, -14752, -14814, -14830, -14802, -14733, -14625, -14481, -14302, -14092, -13853, -13586, -13294, -12979, -12643, -12290, -11919, -11533, -11136, -10727, -10308, -9884, -9453, -9017, -8580, -8137, -7693, -7247, -6797, -6345, -5888, -5422, -4946, -4458, -3962, -3458, -2921, -2306, -1566, -630};