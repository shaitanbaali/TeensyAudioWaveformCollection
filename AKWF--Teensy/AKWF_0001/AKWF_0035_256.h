/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0035 256 samples */
 
const int16_t AKWF_0035_256_DATA [256] = 
{374, 1716, 3025, 4330, 5622, 6901, 8163, 9397, 10603, 11778, 12911, 14008, 15063, 16074, 17045, 17974, 18860, 19708, 20516, 21283, 22013, 22700, 23345, 23949, 24507, 25021, 25493, 25924, 26315, 26673, 27001, 27301, 27581, 27844, 28089, 28323, 28544, 28751, 28944, 29122, 29286, 29433, 29565, 29684, 29791, 29891, 29990, 30092, 30200, 30318, 30450, 30594, 30751, 30917, 31090, 31266, 31440, 31610, 31771, 31923, 32064, 32192, 32308, 32414, 32508, 32590, 32661, 32716, 32753, 32768, 32756, 32712, 32632, 32511, 32345, 32133, 31872, 31564, 31208, 30806, 30363, 29876, 29348, 28784, 28181, 27541, 26865, 26151, 25402, 24620, 23803, 22958, 22090, 21201, 20299, 19390, 18475, 17567, 16666, 15773, 14896, 14034, 13187, 12362, 11556, 10780, 10061, 9342, 8591, 7841, 7098, 6370, 5668, 4993, 4352, 3747, 3173, 2634, 2127, 1646, 1188, 750, 328, -80, -475, -857, -1227, -1583, -1927, -2253, -2568, -2870, -3161, -3447, -3729, -4015, -4309, -4614, -4934, -5271, -5629, -6006, -6405, -6824, -7262, -7719, -8194, -8687, -9200, -9732, -10284, -10859, -11457, -12076, -12718, -13379, -14056, -14747, -15445, -16146, -16847, -17541, -18228, -18905, -19569, -20222, -20865, -21494, -22116, -22726, -23324, -23910, -24557, -25244, -25923, -26597, -27254, -27888, -28481, -29016, -29483, -29870, -30176, -30404, -30561, -30660, -30715, -30742, -30752, -30759, -30770, -30791, -30822, -30867, -30925, -30992, -31069, -31151, -31239, -31328, -31416, -31502, -31583, -31656, -31719, -31767, -31800, -31814, -31807, -31779, -31728, -31657, -31565, -31452, -31325, -31180, -31024, -30855, -30670, -30473, -30257, -30019, -29755, -29461, -29133, -28768, -28360, -27911, -27423, -26894, -26327, -25725, -25092, -24430, -23744, -23034, -22304, -21560, -20815, -20093, -19274, -18348, -17346, -16279, -15148, -13965, -12742, -11480, -10193, -8889, -7568, -6243, -4915, -3586, -2262, -913};