/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0088 256 samples */
 
const int16_t AKWF_0088_256_DATA [256] = 
{-652, -2543, -4361, -6141, -7865, -9528, -11123, -12636, -14067, -15411, -16656, -17808, -18861, -19811, -20663, -21418, -22073, -22636, -23110, -23498, -23809, -24046, -24217, -24330, -24391, -24408, -24388, -24339, -24267, -24179, -24080, -23976, -23871, -23771, -23676, -23591, -23518, -23456, -23408, -23372, -23349, -23335, -23330, -23331, -23335, -23340, -23341, -23336, -23320, -23290, -23243, -23175, -23084, -22967, -22823, -22649, -22447, -22216, -21958, -21673, -21365, -21033, -20681, -20307, -19912, -19498, -19065, -18611, -18140, -17651, -17145, -16624, -16091, -15545, -14992, -14432, -13867, -13306, -12747, -12184, -11618, -11039, -10441, -9816, -9151, -8437, -7665, -6834, -5942, -4992, -3986, -2937, -1853, -738, 392, 1530, 2670, 3798, 4907, 5991, 7036, 8036, 8982, 9862, 10671, 11399, 12034, 12572, 13004, 13320, 13511, 13551, 13439, 13181, 12769, 12216, 11533, 10739, 9850, 8878, 7844, 6763, 5645, 4510, 3372, 2239, 1128, 51, -986, -1968, -2889, -3742, -4519, -5216, -5828, -6350, -6782, -7123, -7370, -7525, -7590, -7567, -7458, -7268, -7000, -6660, -6254, -5789, -5269, -4703, -4099, -3462, -2801, -2126, -1439, -750, -67, 608, 1266, 1904, 2518, 3103, 3657, 4179, 4664, 5115, 5531, 5912, 6259, 6575, 6861, 7121, 7357, 7573, 7773, 7960, 8137, 8310, 8482, 8655, 8833, 9020, 9217, 9425, 9645, 9878, 10123, 10378, 10644, 10921, 11206, 11501, 11804, 12117, 12439, 12771, 13112, 13463, 13824, 14191, 14567, 14951, 15339, 15732, 16132, 16535, 16945, 17363, 17787, 18226, 18678, 19149, 19646, 20185, 20785, 21435, 22136, 22883, 23665, 24459, 25248, 26021, 26758, 27448, 28082, 28648, 29138, 29547, 29865, 30090, 30216, 30239, 30155, 29961, 29657, 29239, 28707, 28062, 27302, 26430, 25450, 24360, 23168, 21881, 20496, 19024, 17474, 15846, 14153, 12404, 10600, 8760, 6892, 5003, 3110, 1182};