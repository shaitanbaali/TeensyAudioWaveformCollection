/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0051 256 samples */
 
const int16_t AKWF_0051_256_DATA [256] = 
{27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 26373, 30787, 9193, -30923, -26340, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27157, -26778, -29176, 15900, 29749, 26622, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 26403, 30672, -10597, -30601, -26421, -27177, -26446, -30503, -11288, 30529, 26439, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 27177, 26993, 27834, 24912, -23121, -28260, -26915, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177, -27177};