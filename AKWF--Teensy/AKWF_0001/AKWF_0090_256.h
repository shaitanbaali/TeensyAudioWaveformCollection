/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0090 256 samples */
 
const int16_t AKWF_0090_256_DATA [256] = 
{1357, 5288, 9014, 12569, 15891, 18950, 21719, 24169, 26302, 28114, 29603, 30785, 31675, 32286, 32644, 32767, 32685, 32417, 31992, 31435, 30765, 30010, 29190, 28322, 27427, 26521, 25615, 24725, 23861, 23026, 22234, 21486, 20784, 20135, 19536, 18987, 18490, 18040, 17636, 17275, 16953, 16665, 16409, 16180, 15974, 15789, 15621, 15464, 15316, 15175, 15038, 14902, 14766, 14627, 14484, 14335, 14181, 14020, 13852, 13676, 13493, 13302, 13105, 12900, 12689, 12472, 12249, 12023, 11791, 11557, 11319, 11079, 10838, 10595, 10352, 10108, 9864, 9621, 9378, 9136, 8897, 8658, 8420, 8186, 7951, 7719, 7489, 7260, 7032, 6807, 6582, 6360, 6138, 5917, 5698, 5480, 5263, 5046, 4829, 4615, 4401, 4186, 3972, 3759, 3547, 3334, 3121, 2909, 2698, 2486, 2275, 2063, 1852, 1642, 1431, 1221, 1011, 801, 592, 383, 174, -33, -242, -449, -656, -864, -1070, -1276, -1482, -1687, -1892, -2097, -2301, -2505, -2709, -2911, -3113, -3316, -3517, -3718, -3919, -4119, -4319, -4520, -4719, -4917, -5115, -5313, -5511, -5708, -5905, -6102, -6297, -6492, -6688, -6884, -7076, -7272, -7465, -7658, -7852, -8044, -8236, -8428, -8620, -8810, -9001, -9191, -9381, -9571, -9760, -9949, -10138, -10326, -10514, -10701, -10888, -11075, -11261, -11446, -11633, -11818, -12003, -12187, -12371, -12555, -12739, -12922, -13104, -13286, -13469, -13650, -13831, -14012, -14193, -14373, -14553, -14733, -14912, -15089, -15267, -15446, -15625, -15802, -15979, -16156, -16332, -16508, -16683, -16859, -17034, -17209, -17384, -17557, -17730, -17904, -18077, -18249, -18421, -18593, -18765, -18937, -19107, -19277, -19448, -19618, -19787, -19957, -20126, -20295, -20463, -20630, -20799, -20966, -21133, -21299, -21466, -21633, -21797, -21962, -22128, -22292, -22457, -22621, -22784, -22946, -23106, -23273, -22911, -21609, -19535, -16845, -13675, -10153, -6407, -2455};