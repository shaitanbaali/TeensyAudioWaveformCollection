/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0039 256 samples */
 
const int16_t AKWF_0039_256_DATA [256] = 
{713, 2234, 3875, 5642, 7483, 9351, 11189, 12924, 14505, 15885, 17020, 17898, 18516, 18877, 19004, 18925, 18670, 18278, 17786, 17236, 16666, 16117, 15626, 15222, 14938, 14795, 14816, 15013, 15392, 15962, 16715, 17646, 18746, 19994, 21374, 22866, 24421, 25989, 27517, 28931, 30179, 31214, 31995, 32509, 32749, 32725, 32458, 31971, 31302, 30483, 29556, 28565, 27542, 26532, 25572, 24691, 23923, 23290, 22811, 22502, 22371, 22423, 22653, 23057, 23622, 24332, 25170, 26116, 27122, 28138, 29111, 29967, 30658, 31132, 31352, 31304, 30982, 30396, 29566, 28520, 27294, 25918, 24436, 22895, 21324, 19768, 18270, 16853, 15553, 14396, 13397, 12574, 11938, 11488, 11226, 11145, 11234, 11477, 11854, 12349, 12915, 13501, 14050, 14498, 14788, 14873, 14718, 14304, 13627, 12702, 11543, 10180, 8650, 6985, 5226, 3421, 1599, -190, -1910, -3536, -5030, -6366, -7531, -8504, -9277, -9848, -10218, -10391, -10382, -10202, -9871, -9411, -8865, -8284, -7725, -7253, -6924, -6787, -6876, -7211, -7793, -8610, -9647, -10875, -12257, -13761, -15345, -16964, -18586, -20165, -21663, -23053, -24300, -25380, -26275, -26968, -27450, -27720, -27780, -27633, -27293, -26774, -26097, -25279, -24369, -23415, -22474, -21616, -20891, -20350, -20032, -19951, -20111, -20503, -21108, -21898, -22838, -23896, -25029, -26194, -27357, -28474, -29507, -30430, -31207, -31813, -32234, -32451, -32456, -32247, -31826, -31198, -30376, -29376, -28218, -26919, -25528, -24094, -22674, -21337, -20135, -19120, -18329, -17776, -17467, -17392, -17532, -17861, -18343, -18945, -19626, -20343, -21061, -21737, -22334, -22823, -23172, -23355, -23355, -23158, -22755, -22142, -21322, -20302, -19092, -17711, -16176, -14507, -12753, -10963, -9191, -7512, -5974, -4628, -3513, -2646, -2027, -1653, -1501, -1544, -1750, -2083, -2503, -2969, -3442, -3882, -4255, -4527, -4667, -4652, -4464, -4087, -3515, -2743, -1777, -590};