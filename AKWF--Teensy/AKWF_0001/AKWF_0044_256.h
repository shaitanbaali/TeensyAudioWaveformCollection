/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0044 256 samples */
 
const int16_t AKWF_0044_256_DATA [256] = 
{1121, 2947, 4743, 6541, 8329, 10101, 11853, 13569, 15248, 16885, 18466, 19991, 21455, 22847, 24165, 25404, 26556, 27622, 28597, 29473, 30254, 30931, 31503, 31973, 32334, 32587, 32731, 32768, 32696, 32515, 32229, 31836, 31340, 30744, 30047, 29254, 28372, 27397, 26337, 25198, 23980, 22689, 21334, 19912, 18433, 16906, 15328, 13711, 12061, 10378, 8672, 6952, 5217, 3476, 1738, 3, -1720, -3424, -5107, -6762, -8381, -9965, -11503, -12991, -14433, -15740, -16802, -17631, -18233, -18620, -18806, -18801, -18619, -18272, -17774, -17136, -16373, -15497, -14521, -13456, -12321, -11120, -9871, -8585, -7270, -5940, -4608, -3278, -1964, -677, 579, 1794, 2957, 4069, 5115, 6093, 6999, 7827, 8571, 9230, 9800, 10278, 10665, 10957, 11154, 11257, 11267, 11182, 11004, 10738, 10383, 9943, 9422, 8822, 8146, 7401, 6588, 5715, 4787, 3803, 2776, 1709, 603, -529, -1685, -2863, -4050, -5243, -6439, -7630, -8809, -9975, -11115, -12233, -13321, -14368, -15377, -16343, -17255, -18115, -18919, -19662, -20343, -20957, -21501, -21974, -22376, -22702, -22952, -23125, -23222, -23242, -23182, -23045, -22831, -22541, -22178, -21738, -21230, -20651, -20003, -19291, -18518, -17684, -16795, -15852, -14859, -13823, -12742, -11623, -10473, -9291, -8082, -6855, -5608, -4347, -3082, -1809, -537, 728, 1988, 3233, 4460, 5669, 6851, 8002, 9125, 10210, 11255, 12259, 13215, 14124, 14982, 15785, 16532, 17222, 17855, 18385, 18686, 18744, 18578, 18199, 17623, 16866, 15938, 14862, 13645, 12305, 10863, 9326, 7714, 6040, 4317, 2562, 791, -991, -2765, -4516, -6242, -7922, -9547, -11116, -12607, -14017, -15342, -16568, -17692, -18710, -19610, -20394, -21057, -21594, -22006, -22290, -22444, -22469, -22366, -22135, -21778, -21298, -20699, -19981, -19150, -18214, -17170, -16029, -14799, -13478, -12079, -10609, -9068, -7471, -5823, -4129, -2405, -612};