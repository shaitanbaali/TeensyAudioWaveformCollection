/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0092 256 samples */
 
const int16_t AKWF_0092_256_DATA [256] = 
{7904, 10107, 13646, 15641, 18088, 20158, 21509, 24010, 24789, 26604, 28281, 28661, 30502, 30787, 31857, 32226, 32601, 32374, 32197, 32049, 31213, 31400, 30520, 30386, 29877, 29000, 28509, 27310, 26574, 25202, 24608, 23417, 22242, 21413, 20007, 18878, 17785, 16344, 14548, 13478, 10381, 9667, 1653, -6379, -7858, -11045, -11447, -13626, -14258, -16102, -17275, -18217, -20049, -19933, -21796, -21558, -22899, -22998, -23381, -24175, -24449, -25506, -25447, -25935, -26052, -25718, -25639, -25480, -24679, -24944, -24182, -24297, -23853, -24004, -24200, -23864, -24939, -24394, -24813, -24385, -23716, -23322, -22312, -21802, -20754, -20061, -19362, -18804, -17264, -16799, -15372, -14566, -12739, -10908, -9551, -1753, 4745, 9409, 11337, 12904, 14786, 15290, 16646, 17682, 18282, 19299, 19896, 20162, 21092, 21024, 21569, 21927, 21778, 22517, 22053, 23028, 22508, 22456, 22764, 22158, 22530, 22086, 22008, 21851, 21408, 21481, 20919, 20585, 20451, 19974, 19645, 19488, 19035, 18647, 18014, 17466, 16978, 15828, 15538, 14036, 13851, 11813, 11974, 9131, 9087, 4973, -1220, 1285, -8969, -8101, -10528, -12213, -12919, -14800, -14904, -15577, -15928, -15869, -15918, -16083, -15979, -16198, -16919, -16093, -17179, -16017, -16940, -16196, -16110, -16378, -15728, -16486, -15620, -16224, -15254, -15360, -15149, -14689, -15070, -14082, -14072, -13695, -12667, -12397, -11765, -10903, -10929, -10415, -9989, -10325, -10071, -10100, -10589, -10929, -9977, -10937, -9989, -9506, -6933, 2640, 9300, 12437, 14371, 17228, 17773, 20171, 20342, 21351, 21759, 21422, 21802, 20682, 21337, 19953, 19647, 19087, 17492, 16924, 14550, 12727, 9992, 6652, 456, -10774, -11737, -14129, -16726, -17739, -20004, -20732, -22521, -23306, -23958, -25724, -25573, -27194, -27341, -28271, -28468, -28551, -28878, -27882, -27762, -26950, -25998, -25382, -24125, -23040, -21917, -20184, -19279, -16779, -15531, -12942, -10523, -6928};