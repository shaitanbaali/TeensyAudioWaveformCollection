/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0012 256 samples */
 
const int16_t AKWF_0012_256_DATA [256] = 
{173, 651, 1100, 1529, 1937, 2321, 2681, 3045, 3441, 3866, 4314, 4776, 5242, 5698, 6136, 6552, 6944, 7316, 7667, 7999, 8313, 8602, 8861, 9084, 9266, 9407, 9513, 9594, 9662, 9730, 9805, 9894, 9996, 10110, 10229, 10345, 10454, 10548, 10627, 10688, 10732, 10761, 10774, 10775, 10762, 10737, 10699, 10646, 10574, 10476, 10343, 10163, 9920, 9595, 9170, 8624, 7947, 7137, 6211, 5219, 4246, 3402, 2818, 2596, 2742, 2821, 2390, 1550, 563, -302, -857, -1045, -935, -677, -409, -77, 464, 1274, 2294, 3344, 4178, 4596, 4523, 4314, 4539, 5191, 6055, 6942, 7711, 8290, 8664, 8851, 8885, 8806, 8647, 8437, 8194, 7932, 7658, 7374, 7083, 6786, 6480, 6165, 5841, 5506, 5161, 4807, 4442, 4070, 3690, 3303, 2912, 2516, 2118, 1720, 1322, 925, 531, 140, -246, -626, -1002, -1369, -1729, -2081, -2424, -2758, -3083, -3398, -3703, -3998, -4283, -4557, -4820, -5072, -5314, -5545, -5764, -5974, -6172, -6359, -6535, -6701, -6856, -7001, -7135, -7258, -7371, -7475, -7567, -7651, -7724, -7788, -7843, -7888, -7924, -7951, -7969, -7979, -7980, -7972, -7956, -7929, -7891, -7840, -7773, -7683, -7566, -7410, -7206, -6939, -6596, -6161, -5621, -4969, -4208, -3352, -2439, -1528, -693, -23, 397, 518, 331, 83, 195, 707, 1482, 2357, 3169, 3791, 4153, 4243, 4101, 3797, 3415, 3038, 2665, 2212, 1611, 830, -122, -1207, -2342, -3423, -4350, -5038, -5437, -5550, -5441, -5401, -5680, -6242, -7000, -7875, -8786, -9670, -10486, -11203, -11806, -12291, -12660, -12920, -13082, -13155, -13151, -13077, -12944, -12757, -12522, -12246, -11932, -11583, -11205, -10797, -10365, -9910, -9434, -8940, -8431, -7907, -7372, -6829, -6276, -5719, -5161, -4599, -4040, -3484, -2931, -2386, -1850, -1323, -810, -300};