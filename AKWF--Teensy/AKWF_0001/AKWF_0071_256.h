/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0071 256 samples */
 
const int16_t AKWF_0071_256_DATA [256] = 
{319, 1436, 2670, 3922, 5126, 6272, 7354, 8370, 9330, 10244, 11117, 11947, 12724, 13439, 14096, 14700, 15263, 15799, 16309, 16787, 17233, 17642, 18018, 18369, 18700, 18998, 19232, 19374, 19414, 19361, 19238, 19082, 18921, 18761, 18599, 18433, 18264, 18093, 17924, 17758, 17592, 17423, 17248, 17066, 16879, 16692, 16507, 16327, 16148, 15968, 15788, 15607, 15427, 15250, 15064, 14843, 14565, 14223, 13821, 13378, 12922, 12474, 12041, 11624, 11220, 10830, 10455, 10092, 9742, 9404, 9077, 8763, 8459, 8165, 7882, 7608, 7344, 7089, 6843, 6605, 6377, 6155, 5941, 5735, 5536, 5344, 5159, 4979, 4807, 4640, 4479, 4324, 4174, 4028, 3889, 3754, 3623, 3498, 3376, 3259, 3146, 3037, 2932, 2830, 2731, 2637, 2546, 2457, 2372, 2290, 2210, 2133, 2059, 1988, 1918, 1852, 1788, 1726, 1666, 1608, 1552, 1498, 1446, 1396, 1348, 1301, 1256, 1212, 1169, 1109, 952, 609, 19, -833, -1916, -3153, -4448, -5716, -6924, -8070, -9149, -10161, -11120, -12036, -12908, -13730, -14489, -15181, -15815, -16401, -16956, -17486, -17982, -18439, -18860, -19246, -19605, -19944, -20237, -20452, -20566, -20573, -20487, -20339, -20169, -19996, -19823, -19647, -19465, -19281, -19097, -18916, -18737, -18556, -18369, -18174, -17974, -17772, -17573, -17378, -17185, -16991, -16796, -16599, -16405, -16213, -16007, -15760, -15452, -15075, -14638, -14162, -13676, -13202, -12745, -12302, -11876, -11463, -11065, -10682, -10311, -9953, -9608, -9274, -8952, -8642, -8342, -8052, -7773, -7503, -7243, -6992, -6749, -6515, -6289, -6071, -5860, -5657, -5460, -5271, -5088, -4912, -4742, -4577, -4418, -4264, -4117, -3974, -3836, -3703, -3575, -3450, -3330, -3215, -3104, -2996, -2892, -2792, -2695, -2601, -2511, -2424, -2340, -2258, -2180, -2105, -2032, -1961, -1893, -1827, -1764, -1702, -1634, -1486, -1154, -534};