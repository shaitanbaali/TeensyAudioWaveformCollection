/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0059 256 samples */
 
const int16_t AKWF_0059_256_DATA [256] = 
{460, 1690, 2955, 4271, 5630, 7037, 8483, 9944, 11428, 12960, 14535, 16147, 17776, 19399, 21003, 22567, 24068, 25495, 26828, 28046, 29146, 30112, 30935, 31610, 32133, 32499, 32711, 32768, 32676, 32439, 32063, 31558, 30934, 30201, 29373, 28462, 27484, 26452, 25381, 24291, 23187, 22083, 20995, 19922, 18872, 17847, 16843, 15855, 14879, 13898, 12906, 11892, 10842, 9745, 8600, 7394, 6134, 4821, 3463, 2084, 679, -752, -2280, -3893, -5566, -7274, -9006, -10747, -12476, -14182, -15852, -17467, -19019, -20496, -21882, -23173, -24362, -25436, -26397, -27236, -27952, -28546, -29013, -29356, -29578, -29678, -29662, -29533, -29294, -28955, -28518, -27988, -27377, -26683, -25919, -25092, -24205, -23270, -22293, -21276, -20234, -19169, -18086, -16995, -15899, -14803, -13713, -12632, -11563, -10512, -9478, -8463, -7472, -6503, -5557, -4636, -3739, -2868, -2022, -1203, -413, 335, 1084, 1834, 2576, 3312, 4037, 4751, 5454, 6142, 6817, 7481, 8127, 8760, 9383, 9994, 10600, 11206, 11815, 12438, 13081, 13749, 14449, 15181, 15941, 16713, 17497, 18317, 19187, 20092, 21019, 21950, 22866, 23748, 24585, 25352, 26036, 26624, 27104, 27463, 27693, 27790, 27747, 27563, 27238, 26775, 26174, 25445, 24594, 23630, 22568, 21415, 20187, 18903, 17573, 16214, 14847, 13480, 12130, 10815, 9536, 8311, 7141, 6030, 4982, 3999, 3072, 2200, 1380, 602, -127, -844, -1577, -2322, -3088, -3880, -4704, -5567, -6474, -7421, -8413, -9444, -10504, -11584, -12691, -13830, -15002, -16192, -17389, -18590, -19779, -20949, -22092, -23199, -24256, -25258, -26193, -27051, -27829, -28517, -29105, -29592, -29973, -30243, -30400, -30444, -30372, -30188, -29892, -29487, -28977, -28367, -27661, -26865, -25991, -25040, -24020, -22944, -21814, -20641, -19435, -18198, -16940, -15670, -14388, -13105, -11825, -10545, -9276, -8018, -6768, -5532, -4308, -3093, -1891, -677};