/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0096 256 samples */
 
const int16_t AKWF_0096_256_DATA [256] = 
{129, 355, 576, 798, 1020, 1242, 1465, 1687, 1909, 2131, 2353, 2575, 2798, 3019, 3242, 3464, 3686, 3908, 4130, 4352, 4575, 4797, 5018, 5241, 5463, 5685, 5908, 6129, 6352, 6574, 6796, 7018, 7241, 7462, 7684, 7907, 8129, 8351, 8573, 8795, 9017, 9240, 9462, 9684, 9906, 10128, 10350, 10572, 10794, 11017, 11239, 11461, 11683, 11905, 12127, 12350, 12571, 12794, 13016, 13238, 13460, 13682, 13904, 14126, 14349, 14571, 14793, 15015, 15237, 15459, 15682, 15903, 16126, 16348, 16570, 16792, 17015, 17236, 17459, 17681, 17903, 18125, 18347, 18569, 18791, 19014, 19235, 19458, 19680, 19902, 20124, 20346, 20568, 20791, 21013, 21235, 21457, 21679, 21901, 22124, 22346, 22568, 22790, 23012, 23234, 23456, 23678, 23901, 24123, 24345, 24567, 24790, 25011, 25233, 25456, 25678, 25900, 26121, 26330, 26594, 26238, 24256, 20766, 16039, 10723, 5348, 288, -4269, -8253, -11638, -14465, -16792, -18671, -20172, -21354, -22266, -22959, -23472, -23836, -24083, -24234, -24307, -24319, -24283, -24207, -24100, -23970, -23819, -23653, -23475, -23288, -23093, -22892, -22687, -22478, -22266, -22053, -21836, -21619, -21401, -21182, -20962, -20742, -20521, -20300, -20079, -19857, -19636, -19414, -19193, -18971, -18749, -18527, -18305, -18083, -17860, -17639, -17417, -17194, -16973, -16750, -16528, -16306, -16084, -15861, -15640, -15417, -15195, -14973, -14751, -14529, -14307, -14085, -13862, -13641, -13418, -13196, -12974, -12752, -12530, -12308, -12085, -11864, -11641, -11419, -11197, -10975, -10752, -10531, -10309, -10086, -9865, -9642, -9420, -9198, -8976, -8753, -8532, -8309, -8087, -7865, -7642, -7421, -7199, -6976, -6755, -6532, -6310, -6088, -5866, -5643, -5421, -5200, -4977, -4756, -4533, -4311, -4089, -3867, -3644, -3423, -3200, -2978, -2756, -2534, -2312, -2090, -1868, -1645, -1423, -1201, -979, -757, -535, -314, -87};