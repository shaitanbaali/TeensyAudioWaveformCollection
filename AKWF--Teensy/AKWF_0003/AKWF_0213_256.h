/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0213 256 samples */
 
const int16_t AKWF_0213_256_DATA [256] = 
{971, 4177, 7265, 10248, 11833, 13225, 15198, 16078, 16911, 17359, 19531, 20696, 21881, 22405, 23191, 23781, 23745, 24166, 23982, 24103, 24219, 23827, 23427, 23056, 22818, 22357, 22312, 22696, 22967, 23247, 23203, 23563, 23941, 24374, 24821, 25198, 25852, 25855, 25852, 26149, 26984, 27973, 28489, 28844, 28664, 28950, 28928, 28616, 28566, 28711, 29066, 28954, 29349, 29458, 30134, 30187, 30402, 30469, 30706, 30430, 29688, 29043, 28898, 28758, 29758, 29887, 29596, 29111, 28246, 27669, 27645, 26997, 26560, 26913, 25005, 24081, 23387, 22265, 22930, 21875, 20758, 19446, 18862, 17696, 17084, 15095, 13219, 11727, 9647, 8214, 6587, 5311, 4748, 4204, 2845, 1748, 461, -661, -903, -785, -1468, -3256, -4259, -5595, -6931, -8027, -9106, -9849, -10301, -11179, -11588, -12358, -13389, -14456, -15312, -16092, -16288, -16843, -17694, -18192, -19693, -20552, -21187, -21986, -22567, -24303, -26128, -27180, -27306, -27734, -28448, -29328, -30037, -30029, -31179, -31782, -32430, -32557, -31827, -31583, -31147, -30400, -29844, -28674, -27282, -26363, -24909, -23707, -22027, -20652, -19656, -18849, -17838, -16820, -15711, -13784, -12580, -11306, -10266, -9337, -8044, -5941, -4559, -2957, -1134, -1157, -528, 164, 455, -34, -2768, -5120, -6200, -6522, -6778, -7833, -9231, -9834, -9917, -11980, -12624, -12769, -12829, -12898, -14061, -14900, -15242, -15466, -15108, -15424, -15401, -15536, -15735, -15798, -15547, -14641, -14394, -14037, -14543, -14580, -14284, -14187, -13781, -13434, -12783, -12961, -12159, -11059, -10171, -9236, -9126, -8722, -7558, -6568, -6090, -6419, -6290, -6406, -6112, -6487, -6719, -6473, -6898, -7053, -7558, -7878, -7821, -8340, -8492, -9175, -9260, -9495, -9897, -10653, -12172, -12608, -13271, -13554, -15355, -16325, -15376, -15165, -14037, -13854, -12968, -12033, -10734, -10182, -9977, -9690, -9453, -7799, -5218, -3506, -1759, -892};