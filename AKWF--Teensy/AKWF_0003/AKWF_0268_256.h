/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0268 256 samples */
 
const int16_t AKWF_0268_256_DATA [256] = 
{831, 3053, 5352, 7742, 10179, 12622, 15027, 17328, 19490, 21467, 23218, 24720, 25934, 26818, 27342, 27478, 27209, 26529, 25439, 23959, 22098, 19893, 17379, 14580, 11537, 8286, 4868, 1360, -2197, -5808, -9441, -13050, -16541, -19827, -22862, -25599, -27975, -29919, -31376, -32315, -32741, -32660, -32082, -31017, -29495, -27565, -25275, -22691, -19880, -16888, -13783, -10636, -7493, -4424, -1489, 1276, 3810, 6070, 8032, 9663, 10939, 11837, 12333, 12427, 12132, 11473, 10468, 9142, 7532, 5676, 3628, 1447, -819, -3118, -5389, -7583, -9632, -11470, -13051, -14325, -15251, -15804, -15964, -15728, -15097, -14093, -12753, -11117, -9242, -7187, -5019, -2832, -682, 1418, 3334, 4961, 6231, 7110, 7640, 7865, 7818, 7549, 7118, 6583, 5978, 5324, 4635, 3928, 3233, 2582, 1995, 1488, 1070, 746, 527, 428, 463, 650, 1001, 1526, 2219, 3071, 4072, 5205, 6451, 7782, 9163, 10561, 11954, 13308, 14601, 15808, 16899, 17856, 18656, 19279, 19713, 19951, 19996, 19857, 19543, 19066, 18433, 17658, 16761, 15756, 14664, 13504, 12287, 11030, 9745, 8420, 7034, 5559, 4000, 2372, 633, -1298, -3465, -5842, -8334, -10871, -13429, -15985, -18479, -20819, -22924, -24731, -26223, -27377, -28159, -28539, -28501, -28056, -27228, -26050, -24555, -22761, -20707, -18438, -15989, -13417, -10774, -8092, -5425, -2819, -299, 2093, 4322, 6353, 8139, 9660, 10909, 11878, 12564, 12964, 13075, 12910, 12486, 11828, 10957, 9896, 8676, 7327, 5893, 4425, 2961, 1544, 220, -979, -2010, -2841, -3453, -3830, -3963, -3858, -3539, -3040, -2387, -1600, -718, 201, 1090, 1887, 2582, 3225, 3840, 4439, 4970, 5337, 5476, 5351, 4976, 4385, 3610, 2667, 1577, 377, -904, -2228, -3557, -4861, -6090, -7187, -8103, -8792, -9233, -9418, -9342, -9000, -8375, -7458, -6253, -4785, -3095, -1167};