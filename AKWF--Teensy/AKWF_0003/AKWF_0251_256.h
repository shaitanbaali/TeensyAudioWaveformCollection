/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0251 256 samples */
 
const int16_t AKWF_0251_256_DATA [256] = 
{523, 1980, 3421, 4872, 6327, 7783, 9240, 10691, 12136, 13540, 14878, 16159, 17380, 18538, 19639, 20681, 21662, 22585, 23450, 24255, 25002, 25692, 26322, 26896, 27413, 27872, 28277, 28625, 28920, 29160, 29348, 29483, 29567, 29602, 29588, 29528, 29422, 29272, 29080, 28847, 28575, 28265, 27922, 27546, 27138, 26702, 26240, 25752, 25244, 24714, 24168, 23606, 23008, 22356, 21659, 20948, 20243, 19544, 18837, 18119, 17389, 16652, 15912, 15176, 14440, 13705, 12973, 12244, 11528, 10823, 10131, 9457, 8799, 8157, 7538, 6941, 6367, 5821, 5302, 4811, 4352, 3924, 3529, 3170, 2846, 2557, 2308, 2097, 1924, 1791, 1698, 1645, 1633, 1660, 1728, 1835, 1982, 2168, 2391, 2652, 2950, 3281, 3649, 4048, 4478, 4939, 5428, 5944, 6485, 7048, 7633, 8234, 8825, 9396, 9951, 10475, 10370, 9287, 8067, 6962, 5932, 4994, 4152, 3416, 2780, 2232, 1767, 1374, 1050, 792, 596, 452, 355, 296, 271, 277, 310, 366, 438, 524, 618, 718, 820, 921, 1016, 1104, 1183, 1247, 1295, 1326, 1338, 1327, 1293, 1234, 1148, 1036, 895, 725, 527, 298, 38, -250, -569, -917, -1294, -1700, -2134, -2594, -3080, -3591, -4124, -4681, -5257, -5851, -6464, -7093, -7733, -8387, -9051, -9723, -10425, -11174, -11961, -12759, -13543, -14316, -15093, -15877, -16666, -17461, -18252, -19037, -19819, -20594, -21364, -22127, -22874, -23607, -24323, -25020, -25698, -26356, -26989, -27598, -28181, -28734, -29258, -29750, -30209, -30635, -31025, -31378, -31693, -31969, -32205, -32401, -32556, -32669, -32739, -32767, -32754, -32697, -32598, -32456, -32273, -32048, -31775, -31418, -30971, -30441, -29830, -29146, -28392, -27574, -26698, -25765, -24780, -23754, -22683, -21576, -20441, -19276, -18091, -16892, -15661, -14386, -13076, -11752, -10437, -9124, -7795, -6448, -5080, -3694, -2298, -862};