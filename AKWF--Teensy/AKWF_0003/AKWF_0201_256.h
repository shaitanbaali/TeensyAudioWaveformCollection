/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0201 256 samples */
 
const int16_t AKWF_0201_256_DATA [256] = 
{294, 794, 1329, 1869, 2389, 2887, 3371, 3839, 4296, 4739, 5166, 5580, 5978, 6359, 6725, 7075, 7408, 7727, 8030, 8318, 8594, 8855, 9104, 9343, 9571, 9789, 9998, 10200, 10395, 10584, 10768, 10948, 11125, 11301, 11474, 11648, 11822, 11998, 12177, 12359, 12545, 12736, 12934, 13138, 13350, 13570, 13799, 14039, 14288, 14549, 14821, 15105, 15403, 15713, 16036, 16373, 16724, 17088, 17468, 17861, 18268, 18690, 19125, 19574, 20036, 20511, 20998, 21497, 22007, 22527, 23058, 23596, 24143, 24697, 25255, 25819, 26387, 26956, 27528, 28100, 28667, 29227, 29782, 30330, 30875, 31412, 31789, 33062, 26581, 23002, 23804, 22541, 25221, 25902, 25159, 24523, 23617, 22984, 22523, 22051, 21526, 20966, 20386, 19798, 19204, 18611, 18024, 17442, 16866, 16296, 15747, 15110, 14046, 12852, 11689, 10635, 9735, 8898, 7989, 7016, 5999, 4971, 3942, 2945, 2198, 1603, 1037, 464, -148, -760, -1351, -1921, -2474, -3015, -3544, -4060, -4567, -5062, -5544, -6016, -6477, -6926, -7365, -7795, -8214, -8625, -9029, -9424, -9812, -10194, -10568, -10938, -11302, -11659, -12012, -12360, -12702, -13039, -13370, -13695, -14015, -14330, -14637, -14939, -15232, -15520, -15799, -16071, -16334, -16589, -16834, -17070, -17297, -17514, -17721, -17916, -18101, -18275, -18438, -18589, -18729, -18857, -18973, -19077, -19170, -19251, -19320, -19378, -19423, -19458, -19482, -19495, -19496, -19488, -19469, -19441, -19403, -19356, -19301, -19236, -19164, -19084, -18998, -18903, -18802, -18696, -18584, -18466, -18344, -18217, -18085, -17949, -17810, -17667, -17522, -17372, -17219, -17057, -16887, -16713, -16534, -16351, -16163, -15970, -15771, -15567, -15358, -15145, -14925, -14702, -14472, -14237, -13998, -13752, -13502, -13247, -12985, -12718, -12442, -12172, -11741, -10998, -10186, -9362, -8589, -7871, -7193, -6520, -5767, -4947, -4070, -3165, -2237, -1329, -679, -171};