/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0271 256 samples */
 
const int16_t AKWF_0271_256_DATA [256] = 
{1208, 3527, 5793, 8045, 10262, 12434, 14551, 16597, 18571, 20464, 22255, 23941, 25508, 26942, 28234, 29384, 30401, 31273, 31963, 32456, 32728, 32769, 32680, 32412, 32036, 31490, 30759, 29843, 28765, 27552, 26224, 24764, 23153, 21397, 19522, 17564, 15566, 13532, 11454, 9338, 7182, 5009, 2853, 729, -1343, -3346, -5279, -7126, -8869, -10512, -12047, -13467, -14768, -15935, -16957, -17832, -18557, -19133, -19563, -19844, -19976, -19958, -19796, -19490, -19046, -18475, -17786, -16986, -16087, -15095, -14021, -12881, -11685, -10449, -9189, -7913, -6637, -5380, -4154, -2970, -1831, -761, 198, 1022, 1682, 2235, 2622, 2864, 2912, 2780, 2489, 2059, 1502, 811, -8, -943, -1975, -3077, -4235, -5439, -6669, -7910, -9144, -10346, -11507, -12615, -13656, -14619, -15496, -16271, -16941, -17497, -17928, -18238, -18428, -18500, -18457, -18290, -18002, -17595, -17078, -16457, -15729, -14893, -13949, -12900, -11761, -10538, -9231, -7847, -6386, -4849, -3255, -1606, 92, 1822, 3584, 5368, 7154, 8931, 10678, 12374, 13999, 15551, 16998, 18316, 19590, 20670, 21592, 22286, 22770, 23057, 23157, 23050, 22742, 22251, 21606, 20829, 19945, 18960, 17880, 16722, 15498, 14223, 12921, 11607, 10299, 9021, 7782, 6590, 5456, 4380, 3371, 2440, 1592, 836, 182, -373, -838, -1215, -1513, -1729, -1865, -1920, -1900, -1809, -1651, -1431, -1154, -823, -448, -33, 420, 902, 1403, 1922, 2448, 2976, 3499, 4007, 4485, 4931, 5331, 5680, 5967, 6186, 6305, 6358, 6334, 6202, 5915, 5452, 4800, 4055, 3163, 2132, 921, -451, -1944, -3508, -5127, -6811, -8554, -10339, -12136, -13901, -15615, -17266, -18833, -20305, -21658, -22868, -23926, -24819, -25534, -26068, -26410, -26553, -26494, -26232, -25769, -25107, -24258, -23237, -22046, -20691, -19186, -17537, -15769, -13898, -11927, -9870, -7738, -5543, -3312, -1008};