/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0259 256 samples */
 
const int16_t AKWF_0259_256_DATA [256] = 
{2490, 5721, 8413, 10788, 12943, 14989, 16883, 17549, 17051, 16241, 15369, 14523, 13739, 13031, 12398, 11847, 11377, 10986, 10677, 10447, 10294, 10217, 10216, 10286, 10427, 10633, 10904, 11235, 11624, 12066, 12558, 13095, 13676, 14294, 14946, 15628, 16335, 17064, 17812, 18570, 19339, 20114, 20889, 21663, 22431, 23188, 23934, 24663, 25374, 26063, 26729, 27366, 27975, 28553, 29097, 29609, 30084, 30522, 30923, 31284, 31605, 31887, 32130, 32333, 32497, 32621, 32707, 32756, 32767, 32742, 32683, 32592, 32468, 32314, 32131, 31921, 31687, 31430, 31151, 30853, 30538, 30207, 29864, 29509, 29144, 28773, 28398, 28018, 27637, 27257, 26879, 26506, 26139, 25778, 25426, 25085, 24755, 24438, 24135, 23847, 23575, 23318, 23080, 22860, 22658, 22475, 22312, 22167, 22042, 21937, 21851, 21785, 21737, 21708, 21696, 21703, 21727, 21768, 21824, 21895, 21963, 22119, 21655, 18925, 14665, 9973, 5372, 1150, -2548, -5702, -8407, -10788, -12943, -14989, -16883, -17549, -17052, -16241, -15370, -14524, -13740, -13031, -12399, -11847, -11377, -10987, -10677, -10448, -10294, -10218, -10217, -10287, -10428, -10633, -10905, -11236, -11624, -12067, -12559, -13096, -13677, -14295, -14946, -15629, -16335, -17064, -17812, -18571, -19339, -20114, -20889, -21663, -22431, -23188, -23934, -24664, -25374, -26063, -26729, -27365, -27975, -28553, -29097, -29609, -30085, -30521, -30922, -31284, -31605, -31887, -32130, -32333, -32497, -32621, -32707, -32756, -32767, -32742, -32683, -32591, -32468, -32314, -32131, -31922, -31687, -31430, -31151, -30853, -30538, -30207, -29864, -29509, -29144, -28773, -28398, -28018, -27637, -27258, -26880, -26506, -26139, -25778, -25427, -25085, -24755, -24438, -24135, -23847, -23575, -23319, -23080, -22860, -22659, -22476, -22313, -22168, -22042, -21938, -21852, -21785, -21737, -21708, -21697, -21703, -21728, -21769, -21825, -21895, -21963, -22119, -21655, -18926, -14666, -9981, -5387, -1107};