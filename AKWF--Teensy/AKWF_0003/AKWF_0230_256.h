/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0230 256 samples */
 
const int16_t AKWF_0230_256_DATA [256] = 
{675, 2276, 3815, 5327, 6801, 8240, 9641, 10997, 12311, 13582, 14802, 15979, 17110, 18189, 19224, 20209, 21145, 22034, 22877, 23670, 24418, 25119, 25771, 26381, 26944, 27462, 27938, 28370, 28759, 29106, 29414, 29679, 29906, 30094, 30244, 30356, 30432, 30473, 30479, 30450, 30388, 30296, 30171, 30016, 29832, 29619, 29379, 29112, 28822, 28507, 28167, 27807, 27425, 27023, 26602, 26165, 25711, 25241, 24758, 24262, 23754, 23235, 22708, 22173, 21629, 21079, 20527, 19968, 19410, 18849, 18287, 17727, 17167, 16609, 16056, 15506, 14961, 14424, 13891, 13367, 12851, 12343, 11844, 11355, 10877, 10409, 9954, 9508, 9075, 8656, 8247, 7852, 7469, 7099, 6743, 6400, 6069, 5753, 5449, 5157, 4880, 4614, 4360, 4121, 3892, 3675, 3470, 3276, 3093, 2920, 2757, 2603, 2459, 2324, 2197, 2078, 1967, 1861, 1762, 1670, 1581, 1498, 1419, 1343, 1270, 1199, 1130, 1062, 995, 927, 858, 787, 716, 641, 564, 482, 395, 304, 207, 103, -8, -126, -251, -387, -530, -683, -848, -1022, -1208, -1405, -1614, -1837, -2071, -2319, -2581, -2855, -3144, -3449, -3767, -4099, -4447, -4810, -5187, -5579, -5985, -6406, -6842, -7292, -7757, -8235, -8726, -9230, -9749, -10277, -10819, -11371, -11933, -12506, -13088, -13677, -14275, -14880, -15489, -16105, -16724, -17346, -17972, -18597, -19222, -19848, -20471, -21091, -21707, -22317, -22921, -23521, -24108, -24686, -25256, -25810, -26354, -26884, -27397, -27895, -28376, -28837, -29278, -29701, -30099, -30477, -30829, -31155, -31455, -31729, -31973, -32187, -32369, -32518, -32635, -32716, -32760, -32766, -32731, -32657, -32539, -32375, -32167, -31911, -31603, -31246, -30834, -30367, -29842, -29257, -28612, -27902, -27128, -26286, -25376, -24394, -23342, -22214, -21009, -19733, -18376, -16943, -15451, -13906, -12323, -10714, -9082, -7440, -5796, -4154, -2527, -882};