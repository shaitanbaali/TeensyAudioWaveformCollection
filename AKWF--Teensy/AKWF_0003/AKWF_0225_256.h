/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0225 256 samples */
 
const int16_t AKWF_0225_256_DATA [256] = 
{370, 1217, 2051, 2888, 3727, 4567, 5410, 6248, 7088, 7925, 8758, 9589, 10416, 11236, 12052, 12861, 13661, 14455, 15241, 16015, 16781, 17536, 18277, 19009, 19726, 20429, 21120, 21795, 22454, 23098, 23725, 24334, 24926, 25500, 26055, 26590, 27106, 27601, 28076, 28529, 28962, 29373, 29760, 30127, 30470, 30789, 31086, 31358, 31607, 31833, 32034, 32211, 32364, 32492, 32596, 32675, 32731, 32761, 32767, 32749, 32707, 32640, 32550, 32436, 32298, 32136, 31952, 31744, 31515, 31261, 30987, 30691, 30374, 30035, 29677, 29298, 28899, 28482, 28045, 27590, 27119, 26629, 26123, 25601, 25062, 24509, 23943, 23360, 22765, 22159, 21539, 20908, 20267, 19614, 18953, 18283, 17603, 16917, 16224, 15522, 14817, 14106, 13388, 12670, 11946, 11219, 10491, 9760, 9027, 8296, 7563, 6830, 6100, 5370, 4643, 3918, 3195, 2476, 1763, 1051, 344, -356, -1053, -1743, -2426, -3104, -3775, -4438, -5096, -5744, -6385, -7019, -7644, -8259, -8867, -9467, -10057, -10638, -11209, -11771, -12325, -12868, -13402, -13926, -14439, -14945, -15440, -15924, -16399, -16865, -17320, -17766, -18201, -18627, -19043, -19449, -19845, -20233, -20609, -20976, -21334, -21681, -22019, -22348, -22666, -22976, -23276, -23565, -23846, -24116, -24377, -24629, -24871, -25102, -25326, -25538, -25741, -25935, -26118, -26290, -26453, -26606, -26748, -26881, -27002, -27112, -27212, -27301, -27379, -27445, -27501, -27543, -27576, -27595, -27602, -27597, -27580, -27550, -27507, -27449, -27380, -27297, -27199, -27088, -26962, -26823, -26669, -26499, -26315, -26115, -25900, -25671, -25424, -25162, -24886, -24591, -24281, -23955, -23611, -23253, -22878, -22485, -22077, -21653, -21210, -20753, -20279, -19786, -19279, -18757, -18217, -17662, -17093, -16505, -15905, -15289, -14658, -14014, -13355, -12682, -11997, -11298, -10587, -9865, -9130, -8385, -7630, -6863, -6088, -5304, -4511, -3711, -2905, -2092, -1275, -437};