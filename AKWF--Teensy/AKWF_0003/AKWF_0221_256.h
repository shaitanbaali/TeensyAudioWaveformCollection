/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0221 256 samples */
 
const int16_t AKWF_0221_256_DATA [256] = 
{360, 896, 1392, 1864, 2317, 2755, 3183, 3602, 4017, 4429, 4838, 5244, 5644, 6037, 6418, 6785, 7133, 7465, 7778, 8073, 8353, 8621, 8878, 9149, 9562, 10253, 11268, 12581, 14122, 15798, 17487, 19088, 20539, 21785, 22801, 23571, 24089, 24362, 24402, 24228, 23861, 23325, 22647, 21853, 20965, 20010, 19001, 17957, 16892, 15812, 14734, 13671, 12630, 11623, 10655, 9722, 8826, 7962, 7120, 6299, 5493, 4694, 3904, 3117, 2333, 1556, 784, 18, -736, -1479, -2208, -2917, -3607, -4274, -4914, -5529, -6116, -6675, -7209, -7716, -8198, -8659, -9100, -9526, -9997, -10611, -11437, -12508, -13812, -15334, -17038, -18796, -20499, -22084, -23490, -24679, -25630, -26322, -26753, -26930, -26864, -26575, -26084, -25420, -24609, -23685, -22679, -21615, -20519, -19414, -18309, -17214, -16138, -15075, -14030, -13002, -11980, -10964, -9953, -8938, -7923, -6856, -5623, -4201, -2645, -1042, 511, 1954, 3280, 4531, 5806, 7223, 8849, 10607, 12372, 14064, 15636, 17047, 18259, 19256, 20022, 20498, 20577, 20222, 19480, 18435, 17201, 15924, 14792, 13999, 13540, 13318, 13275, 13360, 13526, 13722, 13897, 14011, 13964, 13615, 12953, 12078, 11093, 10062, 9019, 7996, 7057, 6278, 5716, 5369, 5177, 5084, 5053, 5052, 5053, 5030, 4931, 4678, 4210, 3523, 2653, 1671, 656, -331, -1212, -1906, -2362, -2581, -2620, -2529, -2345, -2101, -1826, -1549, -1290, -1066, -889, -767, -705, -703, -760, -875, -1041, -1255, -1508, -1791, -2095, -2410, -2725, -3038, -3345, -3646, -3963, -4423, -5175, -6307, -7821, -9596, -11469, -13316, -15054, -16625, -17974, -19071, -19907, -20475, -20786, -20853, -20698, -20344, -19816, -19145, -18361, -17498, -16596, -15676, -14761, -13866, -12990, -12136, -11301, -10478, -9662, -8848, -8028, -7203, -6376, -5548, -4732, -3937, -3168, -2434, -1738, -1083, -449, 43};