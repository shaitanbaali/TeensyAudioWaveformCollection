/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0240 256 samples */
 
const int16_t AKWF_0240_256_DATA [256] = 
{159, 506, 851, 1200, 1554, 1913, 2275, 2640, 3010, 3384, 3761, 4144, 4530, 4919, 5313, 5713, 6113, 6519, 6929, 7341, 7760, 8182, 8607, 9037, 9471, 9908, 10350, 10795, 11244, 11698, 12155, 12615, 13082, 13551, 14024, 14502, 14983, 15467, 15957, 16449, 16947, 17448, 17952, 18461, 18975, 19490, 20012, 20536, 21064, 21598, 22133, 22672, 23218, 23767, 24318, 24876, 25436, 25992, 26891, 27722, 28623, 29427, 30141, 30823, 31450, 31977, 32381, 32645, 32761, 32736, 32575, 32292, 31897, 31403, 30825, 30170, 29453, 28685, 27870, 27018, 26140, 25235, 24312, 23378, 22432, 21478, 20523, 19565, 18608, 17655, 16703, 15758, 14821, 13888, 12965, 12051, 11144, 10249, 9364, 8487, 7624, 6770, 5926, 5095, 4275, 3467, 2671, 1885, 1111, 351, -400, -1138, -1862, -2577, -3279, -3967, -4646, -5311, -5964, -6607, -7236, -7853, -8459, -9052, -9632, -10202, -10759, -11303, -11836, -12357, -12865, -13362, -13846, -14319, -14780, -15228, -15664, -16088, -16499, -16900, -17288, -17663, -18028, -18380, -18719, -19047, -19363, -19666, -19957, -20237, -20504, -20760, -21003, -21234, -21454, -21662, -21857, -22041, -22211, -22371, -22518, -22653, -22778, -22535, -22290, -21886, -21481, -21062, -20570, -20020, -19446, -18873, -18322, -17807, -17332, -16899, -16510, -16162, -15849, -15571, -15322, -15100, -14900, -14718, -14552, -14401, -14259, -14127, -14001, -13881, -13765, -13651, -13539, -13428, -13317, -13206, -13093, -12979, -12863, -12745, -12624, -12500, -12374, -12244, -12111, -11975, -11835, -11691, -11544, -11393, -11238, -11080, -10917, -10751, -10582, -10408, -10230, -10048, -9862, -9672, -9478, -9281, -9079, -8873, -8663, -8449, -8231, -8009, -7784, -7555, -7320, -7082, -6841, -6594, -6345, -6090, -5832, -5572, -5306, -5035, -4761, -4483, -4200, -3915, -3625, -3331, -3033, -2731, -2425, -2115, -1801, -1483, -1161, -835, -506, -167};