/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0295 256 samples */
 
const int16_t AKWF_0295_256_DATA [256] = 
{727, 2121, 3432, 4576, 5503, 6284, 6992, 7685, 8342, 8968, 9554, 10135, 10726, 11326, 11967, 12626, 13276, 13804, 14141, 14265, 14282, 14327, 14516, 14875, 15300, 15680, 15937, 16145, 16399, 16816, 17413, 18162, 19006, 19896, 20804, 21702, 22580, 23438, 24286, 25117, 25942, 26730, 27433, 28048, 28585, 29103, 29611, 30070, 30458, 30770, 31047, 31317, 31592, 31856, 32093, 32294, 32461, 32590, 32684, 32743, 32767, 32761, 32726, 32662, 32564, 32432, 32262, 32056, 31815, 31535, 31211, 30841, 30421, 29948, 29418, 28830, 28185, 27486, 26731, 25923, 25065, 24157, 23204, 22243, 21312, 20413, 19535, 18637, 17711, 16763, 15811, 14885, 13994, 13138, 12322, 11539, 10783, 10051, 9336, 8631, 7942, 7266, 6608, 5967, 5340, 4727, 4134, 3558, 3000, 2459, 1895, 1311, 711, 133, -399, -876, -1314, -1729, -2132, -2529, -2918, -3301, -3673, -4034, -4380, -4713, -5032, -5340, -5642, -5974, -6343, -6745, -7147, -7518, -7849, -8150, -8439, -8731, -9030, -9337, -9651, -9964, -10275, -10582, -10881, -11173, -11459, -11741, -12019, -12294, -12563, -12827, -13086, -13340, -13589, -13831, -14068, -14298, -14523, -14741, -14952, -15156, -15353, -15544, -15726, -15904, -16082, -16264, -16451, -16642, -16835, -17030, -17229, -17431, -17638, -17847, -18058, -18271, -18485, -18697, -18906, -19112, -19313, -19507, -19692, -19868, -20035, -20189, -20330, -20456, -20566, -20657, -20727, -20775, -20802, -20805, -20784, -20739, -20671, -20581, -20468, -20332, -20175, -19996, -19796, -19577, -19338, -19081, -18809, -18519, -18216, -17899, -17567, -17224, -16869, -16503, -16131, -15745, -15372, -16117, -18260, -21647, -25131, -27714, -28966, -29228, -29054, -28931, -28977, -29229, -29669, -29926, -29670, -28828, -27527, -25979, -24331, -22647, -21014, -19476, -18092, -16856, -15721, -14587, -13357, -11910, -10275, -8560, -6925, -5548, -4494, -3708, -3050, -2371, -1573, -492};