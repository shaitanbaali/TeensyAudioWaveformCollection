/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0235 256 samples */
 
const int16_t AKWF_0235_256_DATA [256] = 
{866, 2576, 4227, 5847, 7455, 9035, 10561, 11993, 13362, 14677, 15940, 17157, 18303, 19375, 20421, 21264, 22075, 22731, 24097, 25709, 26180, 27289, 27850, 28369, 28875, 29292, 29651, 29954, 30193, 30356, 30426, 30438, 30515, 30399, 30401, 30449, 30514, 30582, 30635, 30670, 30693, 30719, 30754, 30794, 30818, 30800, 30725, 30589, 30413, 30220, 30031, 29853, 29670, 29460, 29205, 28902, 28568, 28171, 27788, 27424, 27042, 26634, 26194, 25731, 25272, 24852, 24495, 24210, 23985, 23797, 23625, 23457, 23300, 23163, 23055, 22965, 22880, 22721, 22416, 22097, 21736, 21352, 20965, 20588, 20170, 19713, 19247, 18708, 18122, 17514, 16898, 16280, 15651, 14991, 14303, 13538, 12857, 12208, 11554, 11004, 10512, 10079, 9282, 9038, 8805, 8363, 8007, 7705, 7429, 7148, 6836, 6491, 6129, 5772, 5441, 5139, 4851, 4549, 4218, 3848, 3448, 3013, 2482, 1932, 1340, 672, -43, -844, -1772, -2472, -3016, -3428, -3798, -4085, -4225, -4377, -4469, -4486, -4442, -4369, -4151, -4887, -5585, -5468, -6127, -6253, -6401, -6647, -6843, -7057, -7351, -7680, -8048, -8440, -8843, -9256, -9690, -10165, -10669, -11262, -11896, -12380, -12905, -13372, -13786, -14174, -14556, -14941, -15323, -15689, -16029, -16352, -16678, -17031, -17431, -17880, -18360, -18845, -19317, -19770, -20219, -20687, -21192, -21747, -22319, -22874, -23463, -24038, -24616, -25215, -25841, -26490, -27136, -27741, -28282, -28752, -29153, -29514, -29854, -30177, -30486, -30734, -30838, -30939, -31027, -31118, -31233, -31376, -31528, -31670, -31783, -31861, -31875, -31928, -32015, -32117, -32232, -32344, -32435, -32502, -32555, -32607, -32654, -32664, -32759, -32683, -32516, -32253, -31905, -31333, -30550, -30336, -29691, -28936, -28128, -27257, -26336, -25386, -24422, -23440, -22428, -21351, -20190, -18950, -17633, -16268, -14883, -13484, -12063, -10579, -9093, -7572, -5924, -4216, -2524, -702};