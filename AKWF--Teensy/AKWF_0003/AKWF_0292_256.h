/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0292 256 samples */
 
const int16_t AKWF_0292_256_DATA [256] = 
{-1, -2, -3, -5, -6, -6, -8, -9, -10, -10, -11, -13, -13, -14, -14, -16, -17, -17, -18, -20, -20, -21, -21, -21, -154, 302, -1718, -25360, -28079, -16100, -15791, -14937, -9207, -2947, 1395, 4837, 8136, 11023, 13240, 14791, 15675, 15853, 15380, 14379, 12968, 11255, 9333, 7302, 5255, 3256, 1373, -338, -1852, -3136, -4175, -4970, -5521, -5840, -5945, -5858, -5602, -5204, -4693, -4096, -3437, -2746, -2042, -1347, -680, -56, 513, 1020, 1456, 1819, 2106, 2317, 2457, 2529, 2538, 2491, 2393, 2255, 2082, 1882, 1664, 1432, 1195, 957, 723, 500, 289, 94, -83, -240, -377, -494, -589, -665, -723, -763, -788, -798, -797, -784, -763, -735, -702, -666, -627, -587, -548, -510, -473, -438, -407, -379, -354, -333, -315, -299, -287, -277, -270, -264, -260, -257, -255, -253, -253, -251, -250, -248, -246, -243, -239, -234, -229, -223, -216, -208, -199, -190, -181, -171, -160, -150, -139, -129, -118, -107, -97, -87, -77, -68, -59, -50, -42, -34, -27, -19, -13, -8, -2, 2, 7, 12, 16, 20, 24, 27, 30, 34, 37, 40, 42, 45, 47, 49, 52, 53, 55, 57, 58, 60, 61, 63, 64, 65, 66, 67, 68, 68, 69, 68, 69, 69, 69, 69, 69, 68, 69, 68, 68, 67, 65, 65, 64, 64, 63, 61, 61, 59, 58, 57, 56, 54, 53, 52, 51, 49, 48, 47, 45, 43, 42, 41, 39, 38, 36, 34, 34, 32, 30, 28, 27, 26, 24, 23, 22, 20, 19, 18, 16, 14, 13, 12, 10, 9, 8, 7, 5, 4, 3, 1, 0, -1};