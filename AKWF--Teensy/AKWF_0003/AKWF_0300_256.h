/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0300 256 samples */
 
const int16_t AKWF_0300_256_DATA [256] = 
{1219, 4136, 6724, 9019, 11017, 12749, 14256, 15564, 16699, 17664, 18452, 19056, 19468, 19684, 19714, 19569, 19268, 18830, 18273, 17618, 16873, 16053, 15171, 14229, 13244, 12225, 11179, 10121, 9062, 8006, 6969, 5955, 4968, 4019, 3111, 2244, 1427, 661, -53, -710, -1313, -1859, -2345, -2776, -3150, -3470, -3735, -3951, -4116, -4235, -4311, -4345, -4340, -4299, -4227, -4124, -3996, -3845, -3673, -3484, -3282, -3066, -2843, -2613, -2380, -2144, -1909, -1676, -1448, -1224, -1008, -801, -602, -414, -237, -71, 81, 222, 350, 466, 568, 659, 736, 802, 856, 900, 931, 953, 965, 969, 964, 952, 932, 907, 876, 839, 800, 756, 709, 661, 610, 558, 505, 453, 401, 349, 298, 249, 202, 157, 114, 73, 34, -1, -33, -64, -91, -114, -137, -156, -172, -185, -196, -204, -210, -214, -217, -216, -214, -211, -205, -199, -191, -184, -174, -164, -153, -142, -131, -119, -107, -96, -84, -73, -61, -51, -41, -31, -21, -12, -4, 3, 10, 16, 22, 27, 32, 35, 39, 42, 44, 45, 46, 47, 46, 47, 46, 45, 44, 43, 41, 39, 37, 34, 32, 29, 26, 24, 22, 19, 16, 14, 12, 10, 7, 5, 3, 1, 0, -2, -3, -4, -6, -7, -7, -8, -9, -10, -11, -10, -11, -12, -11, -12, -11, -10, -11, -10, -8, -9, -8, -8, -7, -6, -6, -6, -5, -4, -4, -4, -3, -3, -2, -1, -1, 0, -1, 0, 1, 0, 0, 1, -6, 4, -63, -1830, -5021, -9911, -15921, -22010, -27332, -31063, -32717, -32364, -30498, -27795, -24871, -22115, -19677, -17492, -15371, -13130, -10641, -7867, -4881, -1740};