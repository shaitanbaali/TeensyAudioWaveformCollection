/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0286 256 samples */
 
const int16_t AKWF_0286_256_DATA [256] = 
{1, 2, 4, 5, 8, 9, 11, -317, 1484, -9026, -31264, -31079, -28520, -15690, -7296, -5893, -6086, -4149, 223, 5569, 10493, 14344, 17116, 19037, 20258, 20832, 20762, 20064, 18797, 17047, 14924, 12526, 9944, 7279, 4606, 1997, -466, -2733, -4761, -6503, -7943, -9065, -9861, -10339, -10514, -10405, -10037, -9444, -8660, -7720, -6662, -5528, -4348, -3160, -1999, -884, 151, 1089, 1917, 2620, 3191, 3628, 3931, 4104, 4154, 4090, 3926, 3673, 3348, 2964, 2537, 2084, 1616, 1149, 696, 266, -130, -485, -796, -1055, -1261, -1415, -1515, -1564, -1566, -1525, -1445, -1333, -1194, -1034, -859, -677, -491, -306, -130, 35, 186, 319, 435, 529, 601, 653, 683, 693, 686, 661, 622, 571, 510, 442, 368, 292, 216, 142, 71, 4, -55, -108, -154, -190, -218, -237, -249, -252, -249, -239, -224, -205, -181, -156, -129, -101, -72, -46, -20, 3, 22, 40, 54, 66, 72, 77, 78, 75, 70, 63, 55, 44, 32, 19, 6, -7, -20, -33, -45, -56, -66, -74, -82, -87, -92, -95, -96, -98, -97, -95, -93, -90, -87, -83, -79, -76, -72, -69, -65, -63, -60, -57, -56, -55, -55, -54, -55, -56, -57, -58, -60, -62, -64, -65, -68, -70, -71, -73, -74, -76, -77, -78, -78, -78, -79, -78, -77, -77, -76, -75, -74, -72, -71, -69, -68, -67, -65, -63, -62, -60, -58, -57, -56, -55, -54, -52, -51, -50, -49, -48, -47, -46, -45, -43, -42, -41, -40, -39, -37, -36, -35, -33, -32, -30, -28, -26, -25, -24, -21, -19, -18, -16, -14, -12, -10, -8, -6, -4, -3, -1};