/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0263 256 samples */
 
const int16_t AKWF_0263_256_DATA [256] = 
{648, 2758, 4846, 6948, 9045, 11126, 13178, 15183, 17137, 19025, 20827, 22540, 24147, 25629, 26986, 27981, 28898, 29841, 30594, 31411, 31979, 32336, 32592, 32738, 32763, 32667, 32449, 32106, 31643, 31065, 30373, 29578, 28680, 27694, 26619, 25467, 24242, 22956, 21609, 20222, 18788, 17320, 15831, 14320, 12797, 11271, 9749, 8231, 6732, 5251, 3800, 2380, 996, -332, -1536, -2754, -3934, -5040, -6089, -7065, -7978, -8840, -9629, -10357, -11021, -11621, -12084, -12432, -12756, -12954, -13064, -13084, -13019, -12863, -12627, -12305, -11908, -11443, -10909, -10313, -9658, -8976, -8303, -7619, -6913, -6211, -5522, -4858, -4230, -3651, -3118, -2728, -2550, -2148, -1769, -1493, -1229, -905, -710, -550, -399, -270, -167, -93, -50, -35, -55, -100, -172, -265, -380, -510, -662, -782, -907, -1079, -1248, -1414, -1579, -1750, -1919, -2085, -2256, -2425, -2592, -2761, -2924, -3093, -3253, -3419, -3579, -3739, -3903, -4066, -4228, -4390, -4551, -4723, -4889, -5053, -5231, -5397, -5569, -5745, -5916, -6089, -6262, -6433, -6597, -6761, -6922, -7074, -7223, -7361, -7495, -7612, -7722, -7822, -7904, -7976, -8029, -8069, -8091, -8094, -8086, -8023, -7845, -7605, -7319, -6979, -6562, -6105, -5694, -5166, -4633, -4098, -3530, -2952, -2366, -1779, -1198, -619, -54, 495, 1028, 1539, 1979, 2306, 2683, 3030, 3324, 3664, 4015, 4332, 4640, 4954, 5271, 5597, 5928, 6262, 6599, 6945, 7290, 7576, 7660, 7560, 7359, 7053, 6593, 6214, 5745, 5046, 4261, 3392, 2446, 1422, 327, -838, -2065, -3352, -4693, -6080, -7504, -8955, -10389, -11791, -13182, -14548, -15856, -17097, -18258, -19315, -20247, -21033, -21666, -21830, -21578, -21779, -22233, -22083, -21717, -21239, -20653, -19947, -19112, -18138, -17037, -15798, -14432, -12946, -11344, -9638, -7837, -5955, -4005, -1950};