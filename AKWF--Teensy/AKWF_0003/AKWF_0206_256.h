/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0206 256 samples */
 
const int16_t AKWF_0206_256_DATA [256] = 
{458, 1452, 2030, 2603, 3168, 3714, 4335, 5035, 5409, 5831, 6213, 6605, 7075, 7546, 7993, 8403, 8789, 9173, 9610, 10028, 10498, 11026, 11541, 12127, 12729, 13266, 13758, 14222, 14682, 15213, 15712, 16179, 16628, 17083, 17379, 17495, 17588, 17663, 17738, 17786, 17779, 17833, 17872, 17926, 17995, 18063, 18125, 18218, 18319, 18396, 18471, 18497, 18517, 18512, 18493, 18483, 18480, 18485, 18497, 18483, 18438, 18382, 18319, 18247, 18222, 18231, 18221, 18196, 18169, 18122, 18081, 17970, 17757, 17489, 17250, 17050, 16787, 16470, 16132, 15705, 15277, 14839, 14395, 13973, 13543, 13049, 12559, 12085, 11862, 11737, 11275, 10832, 10405, 9960, 9509, 9031, 8506, 7921, 7369, 6819, 6325, 5847, 5313, 4797, 4215, 3610, 2992, 2330, 1624, 916, 207, -432, -1101, -1787, -2510, -3237, -3966, -4661, -5263, -5912, -6562, -7206, -7797, -8365, -8949, -9612, -10261, -10932, -11558, -12174, -12837, -13478, -13998, -14576, -15117, -15661, -16256, -16835, -17426, -18081, -18763, -19433, -20092, -20808, -21549, -22281, -22963, -23640, -24332, -25009, -25675, -26263, -26792, -27320, -27841, -28326, -28751, -29174, -29600, -30039, -30370, -30634, -30895, -31088, -31286, -31447, -31556, -31714, -31891, -32023, -32124, -32261, -32400, -32557, -32654, -32671, -32715, -32750, -32778, -32690, -32298, -32253, -32259, -32219, -32144, -32107, -32039, -31902, -31768, -31689, -31617, -31552, -31471, -31312, -31126, -31006, -30889, -30732, -30596, -30403, -30205, -30057, -29781, -29368, -28981, -28538, -28096, -27676, -27221, -26734, -26305, -25538, -24756, -24308, -23807, -23321, -22894, -22489, -22074, -21676, -21347, -20965, -20546, -20132, -19733, -19311, -18885, -18476, -18091, -17642, -17164, -16731, -16249, -15737, -15186, -14566, -13949, -13322, -12692, -12036, -11386, -10691, -9968, -9265, -8567, -7517, -6717, -6030, -5409, -4771, -4121, -3409, -2696, -2023, -1018, -288};