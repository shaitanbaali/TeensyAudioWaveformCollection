/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0238 256 samples */
 
const int16_t AKWF_0238_256_DATA [256] = 
{294, 1083, 1856, 2630, 3405, 4180, 4955, 5729, 6504, 7280, 8053, 8827, 9602, 10374, 11149, 11923, 12695, 13469, 14242, 15013, 15787, 16559, 17330, 18103, 18876, 19645, 20417, 21190, 21943, 22638, 23266, 23811, 24278, 24660, 24947, 25134, 25220, 25206, 25100, 24908, 24638, 24299, 23898, 23443, 22940, 22399, 21821, 21211, 20578, 19921, 19245, 18554, 17848, 17132, 16407, 15670, 14929, 14182, 13429, 12672, 11912, 11149, 10384, 9617, 8848, 8074, 7346, 6712, 6180, 5775, 5488, 5331, 5319, 5459, 5751, 6191, 6769, 7472, 8290, 9210, 10217, 11306, 12463, 13676, 14944, 16255, 17601, 18983, 20391, 21819, 23270, 24741, 26186, 27523, 28741, 29797, 30704, 31445, 32001, 32360, 32517, 32477, 32253, 31859, 31309, 30620, 29809, 28889, 27876, 26783, 25617, 24391, 23115, 21792, 20432, 19043, 17623, 16180, 14721, 13240, 11748, 10246, 8731, 7209, 5681, 4145, 2606, 1064, -485, -2032, -3584, -5139, -6692, -8248, -9807, -11362, -12921, -14481, -16037, -17598, -19158, -20715, -22275, -23835, -25390, -26853, -28193, -29379, -30401, -31260, -31937, -32418, -32693, -32766, -32643, -32342, -31875, -31259, -30513, -29652, -28687, -27636, -26508, -25311, -24063, -22764, -21422, -20049, -18644, -17213, -15759, -14336, -12992, -11743, -10607, -9581, -8682, -7918, -7303, -6839, -6514, -6325, -6260, -6306, -6451, -6685, -6997, -7374, -7810, -8297, -8827, -9392, -9991, -10616, -11264, -11932, -12615, -13314, -14024, -14743, -15471, -16207, -16947, -17693, -18445, -19197, -19954, -20715, -21472, -22181, -22830, -23400, -23892, -24303, -24623, -24846, -24966, -24986, -24911, -24748, -24504, -24187, -23806, -23369, -22881, -22352, -21784, -21183, -20557, -19906, -19235, -18548, -17844, -17129, -16406, -15671, -14928, -14182, -13429, -12671, -11911, -11146, -10379, -9612, -8840, -8068, -7295, -6521, -5746, -4971, -4193, -3417, -2641, -1864, -1089, -298};