/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0266 256 samples */
 
const int16_t AKWF_0266_256_DATA [256] = 
{1025, 2551, 4022, 5471, 6889, 8274, 9624, 10930, 12192, 13409, 14574, 15689, 16750, 17751, 18697, 19585, 20410, 21177, 21881, 22521, 23103, 23621, 24076, 24472, 24807, 25083, 25299, 25460, 25565, 25616, 25613, 25561, 25458, 25310, 25114, 24877, 24598, 24280, 23923, 23532, 23106, 22648, 22163, 21647, 21105, 20540, 19950, 19340, 18711, 18061, 17394, 16715, 16018, 15306, 14586, 13852, 13109, 12357, 11595, 10828, 10054, 9273, 8488, 7698, 6905, 6111, 5312, 4513, 3716, 2918, 2121, 1327, 537, -251, -1033, -1809, -2579, -3338, -4090, -4832, -5561, -6278, -6982, -7668, -8340, -8993, -9625, -10238, -10828, -11394, -11934, -12447, -12932, -13387, -13811, -14200, -14557, -14877, -15159, -15403, -15607, -15770, -15890, -15968, -16001, -15989, -15932, -15826, -15675, -15476, -15231, -14938, -14596, -14207, -13772, -13292, -12764, -12192, -11579, -10921, -10223, -9487, -8712, -7902, -7060, -6186, -5284, -4356, -3404, -2432, -1441, -434, 582, 1608, 2639, 3672, 4704, 5731, 6749, 7758, 8752, 9726, 10682, 11613, 12515, 13387, 14226, 15028, 15792, 16514, 17190, 17822, 18403, 18933, 19411, 19834, 20201, 20510, 20761, 20950, 21079, 21146, 21151, 21093, 20972, 20789, 20543, 20235, 19864, 19433, 18942, 18389, 17778, 17113, 16390, 15613, 14786, 13906, 12977, 12004, 10984, 9923, 8824, 7685, 6513, 5310, 4074, 2815, 1534, 230, -1091, -2426, -3773, -5125, -6483, -7844, -9200, -10551, -11894, -13220, -14533, -15829, -17097, -18342, -19557, -20735, -21880, -22985, -24043, -25056, -26021, -26929, -27783, -28579, -29310, -29981, -30583, -31115, -31578, -31967, -32281, -32518, -32678, -32758, -32758, -32678, -32517, -32276, -31954, -31552, -31069, -30509, -29870, -29155, -28369, -27508, -26578, -25583, -24523, -23401, -22224, -20993, -19710, -18384, -17013, -15604, -14166, -12694, -11200, -9689, -8160, -6623, -5082, -3539, -2006, -450};