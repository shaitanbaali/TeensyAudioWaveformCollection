/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0228 256 samples */
 
const int16_t AKWF_0228_256_DATA [256] = 
{984, 3149, 5093, 6891, 8549, 10082, 11503, 12814, 14033, 15164, 16212, 17190, 18101, 18947, 19738, 20478, 21168, 21816, 22421, 22988, 23521, 24021, 24490, 24933, 25348, 25739, 26109, 26456, 26784, 27095, 27387, 27663, 27924, 28172, 28406, 28628, 28837, 29036, 29224, 29402, 29572, 29733, 29885, 30029, 30166, 30296, 30420, 30537, 30649, 30756, 30856, 30951, 31042, 31129, 31211, 31289, 31364, 31435, 31502, 31566, 31627, 31686, 31741, 31792, 31843, 31890, 31936, 31979, 32020, 32058, 32095, 32131, 32164, 32197, 32227, 32257, 32285, 32310, 32335, 32359, 32382, 32404, 32424, 32445, 32464, 32480, 32498, 32514, 32529, 32544, 32557, 32571, 32583, 32595, 32607, 32618, 32629, 32639, 32648, 32657, 32665, 32674, 32681, 32689, 32696, 32702, 32709, 32715, 32721, 32726, 32731, 32737, 32742, 32747, 32750, 32754, 32759, 32675, 33116, 30687, 24090, 20383, 16352, 12796, 9533, 6539, 3802, 1292, -1019, -3139, -5090, -6892, -8550, -10083, -11503, -12814, -14033, -15165, -16212, -17191, -18101, -18947, -19738, -20479, -21168, -21816, -22421, -22988, -23521, -24021, -24490, -24933, -25349, -25739, -26109, -26456, -26784, -27095, -27387, -27663, -27924, -28173, -28406, -28628, -28837, -29036, -29224, -29402, -29572, -29733, -29885, -30029, -30166, -30296, -30420, -30537, -30649, -30756, -30856, -30951, -31043, -31129, -31211, -31290, -31364, -31435, -31502, -31566, -31627, -31686, -31741, -31792, -31843, -31890, -31936, -31979, -32020, -32058, -32095, -32131, -32164, -32197, -32227, -32257, -32285, -32310, -32335, -32359, -32382, -32404, -32424, -32445, -32464, -32480, -32498, -32514, -32529, -32544, -32557, -32571, -32583, -32595, -32607, -32618, -32629, -32639, -32648, -32657, -32665, -32674, -32681, -32689, -32696, -32702, -32709, -32715, -32721, -32726, -32731, -32737, -32742, -32747, -32750, -32754, -32759, -32675, -33116, -30687, -24090, -20384, -16353, -12797, -9533, -6544, -3812, -1263};