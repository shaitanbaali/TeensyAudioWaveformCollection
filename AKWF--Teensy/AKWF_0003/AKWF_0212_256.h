/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0212 256 samples */
 
const int16_t AKWF_0212_256_DATA [256] = 
{124, 370, 490, 625, 821, 966, 1100, 1228, 1309, 1327, 1270, 1218, 1157, 1125, 1098, 999, 917, 840, 771, 788, 818, 889, 1023, 1245, 1559, 1941, 2342, 2758, 3299, 3883, 4462, 5023, 5578, 6178, 6863, 7621, 8460, 9320, 10175, 11334, 13020, 14376, 15494, 16752, 18211, 19579, 20776, 21860, 22825, 23709, 24562, 25378, 26067, 26630, 27153, 27640, 28078, 28486, 28933, 29412, 29781, 30088, 30391, 30605, 30820, 31037, 31170, 31187, 31240, 31274, 31283, 31246, 31072, 30894, 30671, 30401, 30038, 29603, 29309, 29051, 28749, 28360, 27885, 27419, 27146, 26946, 26708, 26461, 26192, 25919, 25670, 25413, 25138, 24860, 24620, 24380, 24020, 23623, 23197, 22773, 22372, 21898, 21392, 20924, 20388, 19826, 19338, 18897, 18644, 18294, 17757, 17204, 16619, 15993, 15355, 14665, 13899, 13128, 12329, 11409, 10455, 9554, 8608, 7554, 6570, 5631, 4646, 3631, 2685, 1878, 1136, 403, -359, -1088, -1828, -2549, -3219, -3800, -4322, -4912, -5544, -6194, -6827, -7406, -7951, -8487, -9032, -9624, -10258, -10925, -11615, -12332, -13093, -13904, -14664, -15392, -16228, -17073, -17865, -18590, -19269, -19913, -20622, -21347, -22079, -22819, -23495, -24286, -25366, -26282, -27055, -27866, -28727, -29517, -30218, -30811, -31254, -31584, -31916, -32280, -32548, -32700, -32759, -32756, -32727, -32677, -32687, -32728, -32661, -32536, -32422, -32222, -31985, -31746, -31424, -31030, -30626, -30159, -29707, -29179, -28416, -27735, -27041, -26276, -25384, -24400, -23661, -22954, -22185, -21370, -20438, -19425, -18680, -18103, -17522, -16927, -16314, -15731, -15186, -14647, -14105, -13617, -13225, -12866, -12439, -12021, -11644, -11281, -10943, -10550, -10159, -9865, -9523, -9149, -8801, -8519, -8376, -8148, -7800, -7425, -7036, -6642, -6236, -5816, -5391, -4985, -4547, -4063, -3576, -3133, -2605, -1939, -1468, -1107, -699, -251};