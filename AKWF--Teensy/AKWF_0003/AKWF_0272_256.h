/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0272 256 samples */
 
const int16_t AKWF_0272_256_DATA [256] = 
{489, 1673, 2938, 4277, 5662, 7075, 8497, 9908, 11294, 12639, 13924, 15142, 16283, 17336, 18306, 19190, 19988, 20708, 21346, 21897, 22360, 22725, 22981, 23113, 23105, 22943, 22615, 22110, 21411, 20501, 19353, 17960, 16341, 14492, 12393, 10036, 7443, 4690, 1830, -1104, -4076, -7064, -9993, -12821, -15516, -18048, -20434, -22655, -24691, -26532, -28150, -29533, -30680, -31583, -32236, -32634, -32768, -32630, -32212, -31512, -30535, -29284, -27783, -26047, -24089, -21942, -19633, -17196, -14677, -12102, -9500, -6916, -4369, -1892, 482, 2748, 4888, 6885, 8741, 10441, 11978, 13362, 14595, 15677, 16618, 17415, 18068, 18579, 18946, 19166, 19237, 19155, 18914, 18507, 17927, 17168, 16249, 15191, 13993, 12668, 11234, 9686, 8106, 6537, 5003, 3546, 2134, 764, -568, -1849, -3066, -4215, -5283, -6273, -7159, -7913, -8521, -8980, -9308, -9529, -9654, -9682, -9598, -9382, -9028, -8539, -7938, -7244, -6468, -5620, -4702, -3713, -2658, -1539, -362, 857, 2117, 3410, 4727, 6068, 7425, 8779, 10126, 11446, 12722, 13942, 15086, 16133, 17074, 17892, 18570, 19099, 19464, 19656, 19669, 19501, 19148, 18603, 17862, 16915, 15772, 14440, 12905, 11163, 9217, 7114, 4887, 2555, 153, -2306, -4761, -7181, -9538, -11801, -13975, -16039, -17972, -19766, -21397, -22849, -24117, -25186, -26044, -26690, -27114, -27316, -27293, -27048, -26586, -25914, -25049, -24009, -22805, -21464, -20012, -18476, -16893, -15275, -13645, -12029, -10442, -8903, -7431, -6026, -4694, -3443, -2267, -1171, -156, 794, 1684, 2523, 3322, 4081, 4802, 5486, 6128, 6724, 7271, 7761, 8181, 8525, 8782, 8940, 8999, 8918, 8761, 8504, 8095, 7567, 6900, 6143, 5332, 4483, 3633, 2798, 2015, 1295, 636, 29, -541, -1089, -1621, -2123, -2586, -2986, -3301, -3518, -3622, -3606, -3464, -3186, -2762, -2181, -1442, -526};