/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0284 256 samples */
 
const int16_t AKWF_0284_256_DATA [256] = 
{3034, 9461, 11233, 9613, 7663, 5704, 3485, 1641, 595, 116, -67, -23, 176, 394, 550, 636, 658, 623, 548, 459, 373, 299, 241, 199, 172, 155, 145, 138, 132, 126, 118, 110, 102, 94, 87, 81, 76, 71, 68, 64, 62, 60, 58, 57, 56, 55, 54, 53, 52, 52, 51, 50, 51, 51, 50, 49, 50, 50, 50, 50, 50, 50, 49, 50, 49, 48, 49, 49, 49, 49, 48, 49, 48, 47, 48, 48, 47, 46, 47, 46, 45, 45, 45, 44, 44, 43, 42, 42, 42, 41, 40, 40, 39, 38, 38, 37, 36, 35, 34, 34, 33, 32, 31, 30, 29, 28, 27, 26, 25, 24, 23, 22, 21, 20, 19, 18, 17, 16, 15, 13, 12, 11, 10, 9, 8, 6, 5, 4, 3, 2, 1, -1, -2, -3, -4, -5, -6, -8, -9, -10, -11, -12, -13, -15, -16, -17, -18, -19, -20, -21, -22, -24, -24, -25, -27, -27, -28, -29, -30, -31, -32, -33, -34, -35, -36, -36, -37, -38, -39, -39, -40, -41, -42, -42, -43, -43, -43, -44, -45, -45, -45, -46, -46, -47, -48, -47, -47, -48, -49, -48, -48, -48, -48, -48, -48, -48, -48, -48, -48, -48, -48, -49, -48, -48, -47, -48, -47, -46, -47, -46, -45, -45, -44, -44, -44, -43, -42, -42, -41, -41, -40, -39, -39, -38, -37, -36, -35, -34, -34, -33, -32, -31, -30, -29, -28, -27, -26, -25, -24, -23, -22, -21, -20, -19, -18, -16, -15, -15, -48, -141, 743, -15613, -26285, -11316, -3798, -2308};