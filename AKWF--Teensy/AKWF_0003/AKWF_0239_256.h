/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0239 256 samples */
 
const int16_t AKWF_0239_256_DATA [256] = 
{123, 517, 902, 1289, 1676, 2062, 2450, 2836, 3222, 3609, 3995, 4381, 4767, 5153, 5539, 5925, 6310, 6695, 7081, 7466, 7852, 8237, 8622, 9007, 9392, 9776, 10162, 10546, 10930, 11315, 11699, 12083, 12467, 12851, 13234, 13618, 14002, 14385, 14769, 15152, 15535, 15918, 16301, 16684, 17067, 17448, 17832, 18216, 18597, 18979, 19360, 19743, 20125, 20507, 20888, 21270, 21652, 22032, 22414, 22795, 23177, 23558, 23938, 24318, 24685, 25139, 24551, 23834, 22785, 21672, 20623, 19402, 18043, 16641, 15292, 14051, 12962, 12044, 11300, 10727, 10318, 10058, 9935, 9933, 10039, 10240, 10524, 10879, 11296, 11767, 12283, 12840, 13428, 14045, 14687, 15348, 16028, 16721, 17426, 18144, 18869, 19601, 20341, 21084, 21833, 22587, 23341, 24099, 24859, 25620, 26383, 27148, 27912, 28680, 29446, 30213, 30976, 31726, 32596, 30392, 28121, 24660, 21180, 17722, 13716, 9277, 4686, 180, -4080, -7969, -11445, -14492, -17105, -19314, -21149, -22637, -23820, -24732, -25402, -25865, -26146, -26268, -26256, -26128, -25901, -25588, -25203, -24757, -24258, -23716, -23137, -22524, -21885, -21225, -20543, -19848, -19138, -18416, -17684, -16946, -16199, -15450, -14693, -13932, -13169, -12403, -11633, -10864, -10093, -9330, -8496, -8730, -9068, -9803, -10607, -11404, -12413, -13604, -14882, -16157, -17372, -18482, -19465, -20316, -21030, -21614, -22078, -22431, -22684, -22851, -22937, -22955, -22914, -22822, -22685, -22509, -22301, -22066, -21805, -21527, -21229, -20917, -20594, -20259, -19916, -19566, -19209, -18845, -18479, -18109, -17735, -17359, -16981, -16600, -16219, -15836, -15452, -15068, -14681, -14295, -13909, -13521, -13133, -12746, -12358, -11970, -11582, -11193, -10805, -10417, -10029, -9641, -9252, -8863, -8476, -8088, -7699, -7312, -6924, -6535, -6148, -5761, -5372, -4985, -4598, -4210, -3824, -3436, -3049, -2663, -2275, -1889, -1502, -1116, -731, -338};