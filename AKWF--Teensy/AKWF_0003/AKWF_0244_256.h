/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0244 256 samples */
 
const int16_t AKWF_0244_256_DATA [256] = 
{3729, 10478, 13153, 14955, 16395, 17827, 19252, 20704, 21976, 22702, 23411, 24120, 24856, 25438, 25932, 26670, 27372, 28084, 28791, 29500, 30210, 30917, 31617, 32362, 32787, 32752, 32751, 32745, 32738, 32731, 32724, 32717, 32709, 32701, 32694, 32686, 32678, 32670, 32662, 32654, 32646, 32638, 32629, 32621, 32613, 32604, 32596, 32588, 32579, 32570, 32562, 32553, 32545, 32536, 32528, 32519, 32511, 32501, 32493, 32485, 32418, 32622, 30436, 25923, 1290, -29509, -32630, -31900, -32135, -31726, -30981, -30250, -29684, -29705, -29374, -28621, -27911, -27195, -26479, -25760, -25041, -24334, -23572, -22218, -20940, -20265, -19177, -17704, -16876, -15915, -13955, -10819, -6853, -2750, 6726, 12109, 13831, 15486, 16889, 18321, 19749, 21181, 22107, 22785, 23503, 24217, 24925, 25637, 26348, 27055, 27767, 28475, 29184, 29887, 30617, 31223, 31224, 31479, 32234, 32476, 32431, 32432, 32425, 32418, 32411, 32061, 33435, 26593, -11766, -33626, -31780, -32150, -32169, -32170, -32169, -32169, -32160, -32196, -31859, -31112, -30384, -29756, -29735, -29483, -28741, -28025, -27306, -26590, -25868, -25148, -24432, -23707, -22417, -21069, -20360, -19356, -17894, -16465, -15000, -13710, -11362, -7217, -875, 6979, 10777, 13296, 15535, 17348, 18753, 19660, 20419, 21851, 22828, 23385, 24128, 24834, 25545, 26256, 26965, 27676, 28383, 29094, 29798, 30520, 31177, 31229, 31401, 32150, 32472, 32084, 33466, 26626, -11733, -33593, -31746, -32116, -32134, -32135, -32135, -32134, -32133, -32131, -32127, -32125, -32121, -32117, -32112, -32108, -32102, -32097, -32091, -32085, -32078, -32071, -32065, -32058, -32051, -32044, -32036, -32029, -32021, -32014, -32007, -31998, -31991, -31983, -31975, -31967, -31958, -31942, -31973, -31639, -30874, -30687, -30621, -29952, -29215, -28500, -27777, -27055, -26336, -25612, -24892, -24171, -23444, -22747, -21916, -20485, -19319, -18658, -17411, -16171, -14850, -12550, -8867, -3806};