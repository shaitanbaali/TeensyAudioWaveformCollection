/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0288 256 samples */
 
const int16_t AKWF_0288_256_DATA [256] = 
{827, 2171, 3195, 3987, 4580, 5004, 5288, 5452, 5518, 5505, 5427, 5296, 5124, 4921, 4694, 4451, 4196, 3935, 3671, 3410, 3150, 2897, 2652, 2415, 2186, 1969, 1763, 1567, 1383, 1210, 1048, 897, 756, 626, 505, 394, 292, 200, 114, 37, -32, -95, -151, -202, -246, -286, -321, -352, -378, -399, -418, -434, -446, -456, -463, -467, -470, -471, -470, -468, -464, -459, -453, -446, -438, -429, -419, -410, -399, -388, -377, -366, -354, -342, -330, -318, -307, -294, -282, -270, -259, -247, -235, -224, -212, -201, -189, -179, -169, -158, -148, -138, -129, -119, -110, -101, -92, -83, -75, -67, -59, -52, -44, -37, -30, -23, -17, -10, -4, 1, 7, 13, 18, 23, 28, 34, 38, 43, 47, 51, 56, 59, 63, 67, 70, 73, 77, 80, 83, 86, 89, 91, 94, 96, 99, 101, 103, 105, 107, 109, 111, 113, 114, 115, 117, 118, 120, 122, 123, 124, 125, 126, 127, 127, 128, 129, 130, 131, 132, 133, 133, 133, 134, 135, 134, 135, 136, 135, 136, 137, 136, 137, 136, 137, 137, 136, 137, 137, 137, 137, 137, 137, 137, 136, 137, 137, 136, 137, 136, 136, 136, 135, 136, 136, 135, 134, 135, 134, 134, 134, 133, 133, 132, 132, 132, 131, 132, 130, 129, 129, 129, 129, 128, 127, 128, 127, 126, 126, 126, 126, 125, 124, 124, 123, 124, 123, 122, 122, 122, 121, 121, 120, 119, 118, 118, 118, 117, 116, 117, 116, 116, 115, 114, 114, 113, -468, 2710, -17338, -29897, -20457, -16063, -11803, -8237, -5260, -2804, -766};