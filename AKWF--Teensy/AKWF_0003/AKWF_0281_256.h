/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0281 256 samples */
 
const int16_t AKWF_0281_256_DATA [256] = 
{426, 2040, 3731, 5510, 7348, 9229, 11133, 13033, 14921, 16776, 18573, 20301, 21937, 23455, 24840, 26070, 27125, 27997, 28673, 29151, 29431, 29518, 29420, 29148, 28708, 28112, 27361, 26468, 25442, 24291, 23035, 21692, 20281, 18835, 17381, 15945, 14563, 13254, 12035, 10925, 9926, 9037, 8253, 7562, 6947, 6390, 5869, 5367, 4868, 4356, 3824, 3267, 2682, 2086, 1526, 1019, 515, -55, -725, -1510, -2422, -3474, -4662, -5979, -7412, -8934, -10527, -12177, -13857, -15563, -17284, -19001, -20715, -22416, -24079, -25687, -27209, -28603, -29844, -30894, -31725, -32322, -32670, -32766, -32616, -32234, -31643, -30867, -29940, -28897, -27766, -26582, -25365, -24123, -22870, -21602, -20311, -19000, -17660, -16285, -14885, -13456, -12006, -10549, -9087, -7629, -6189, -4769, -3377, -2026, -716, 541, 1728, 2823, 3801, 4675, 5458, 6121, 6660, 7122, 7541, 7935, 8324, 8720, 9138, 9591, 10085, 10625, 11216, 11855, 12542, 13279, 14058, 14874, 15721, 16588, 17468, 18352, 19225, 20079, 20900, 21670, 22381, 23018, 23567, 24017, 24356, 24574, 24664, 24620, 24437, 24113, 23644, 23026, 22252, 21322, 20234, 18987, 17594, 16068, 14429, 12712, 10950, 9180, 7451, 5800, 4267, 2893, 1703, 719, -34, -521, -737, -751, -669, -564, -482, -466, -551, -765, -1125, -1635, -2283, -3053, -3923, -4871, -5879, -6921, -7974, -9025, -10053, -11047, -12001, -12897, -13730, -14496, -15188, -15814, -16377, -16883, -17340, -17750, -18105, -18398, -18608, -18713, -18693, -18524, -18195, -17693, -17021, -16187, -15204, -14099, -12902, -11645, -10371, -9119, -7927, -6844, -5906, -5143, -4583, -4238, -4109, -4185, -4442, -4846, -5354, -5921, -6503, -7057, -7549, -7955, -8259, -8456, -8546, -8541, -8453, -8299, -8097, -7866, -7644, -7476, -7355, -7261, -7180, -7056, -6836, -6494, -6003, -5348, -4521, -3520, -2356, -1002};