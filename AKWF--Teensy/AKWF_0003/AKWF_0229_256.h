/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0229 256 samples */
 
const int16_t AKWF_0229_256_DATA [256] = 
{284, 1277, 2238, 3190, 4129, 5052, 5962, 6854, 7731, 8592, 9432, 10256, 11062, 11847, 12614, 13363, 14092, 14802, 15494, 16166, 16820, 17456, 18072, 18671, 19252, 19815, 20362, 20889, 21401, 21898, 22377, 22841, 23290, 23723, 24142, 24547, 24937, 25314, 25678, 26028, 26365, 26692, 27005, 27307, 27598, 27876, 28146, 28404, 28652, 28890, 29119, 29338, 29549, 29750, 29943, 30127, 30303, 30471, 30633, 30786, 30932, 31070, 31203, 31329, 31448, 31561, 31667, 31768, 31864, 31954, 32038, 32116, 32189, 32258, 32321, 32380, 32434, 32483, 32529, 32570, 32606, 32640, 32669, 32693, 32713, 32732, 32746, 32756, 32763, 32766, 32767, 32764, 32758, 32749, 32738, 32722, 32705, 32684, 32661, 32636, 32607, 32576, 32543, 32508, 32469, 32428, 32386, 32341, 32293, 32244, 32193, 32139, 32082, 32026, 31965, 31904, 31841, 31775, 31708, 31534, 32008, 29144, 22756, 19351, 15448, 12026, 8886, 6005, 3354, 920, -1321, -3390, -5296, -7059, -8693, -10205, -11610, -12916, -14128, -15258, -16314, -17296, -18217, -19079, -19884, -20640, -21349, -22013, -22641, -23231, -23783, -24306, -24799, -25263, -25702, -26114, -26505, -26873, -27222, -27550, -27861, -28154, -28431, -28692, -28938, -29171, -29389, -29594, -29788, -29969, -30139, -30298, -30447, -30584, -30712, -30830, -30939, -31038, -31128, -31210, -31282, -31347, -31402, -31449, -31489, -31520, -31542, -31557, -31564, -31562, -31552, -31534, -31507, -31473, -31430, -31378, -31318, -31249, -31171, -31084, -30987, -30882, -30766, -30640, -30503, -30357, -30199, -30030, -29851, -29660, -29455, -29238, -29008, -28765, -28508, -28235, -27949, -27647, -27328, -26993, -26642, -26272, -25884, -25478, -25052, -24605, -24138, -23650, -23138, -22606, -22049, -21468, -20864, -20234, -19581, -18900, -18192, -17460, -16699, -15910, -15096, -14254, -13383, -12489, -11564, -10619, -9658, -8678, -7689, -6694, -5690, -4686, -3682, -2680, -1684, -674};