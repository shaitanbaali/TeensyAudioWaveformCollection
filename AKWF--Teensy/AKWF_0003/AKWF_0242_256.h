/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0242 256 samples */
 
const int16_t AKWF_0242_256_DATA [256] = 
{532, 1353, 1259, 2564, 4444, 5926, 6866, 6776, 7616, 9034, 9181, 9542, 11474, 12444, 12337, 13418, 14685, 14689, 15178, 16669, 17135, 17179, 18869, 20270, 20251, 20238, 20256, 21380, 22587, 22553, 23115, 24589, 25017, 24957, 24897, 25324, 26780, 27363, 27290, 27300, 27269, 28635, 30332, 30458, 30418, 30428, 30401, 30467, 31691, 32770, 32758, 32747, 32743, 32736, 32728, 32719, 32712, 32703, 32696, 32687, 32679, 32671, 32662, 32654, 32645, 32638, 32629, 32618, 32608, 32623, 31602, 30303, 30186, 30204, 30188, 30180, 30168, 30163, 30164, 28739, 27063, 26946, 26958, 26991, 26076, 24709, 24527, 24543, 24596, 23846, 22392, 22139, 21952, 20526, 19692, 19796, 18474, 16698, 16588, 16193, 14699, 14123, 14146, 12937, 11777, 11855, 10989, 9022, 8565, 8473, 7093, 6166, 6268, 5367, 3999, 3807, 3837, 2364, 713, 703, 178, -1315, -1756, -1795, -3097, -4130, -4037, -4819, -6261, -6456, -6756, -8662, -9709, -9592, -10622, -11928, -11964, -12399, -13879, -14429, -14369, -14303, -14730, -16653, -17598, -17507, -17482, -17679, -19050, -19923, -19869, -19850, -19949, -21213, -22238, -22223, -22217, -22218, -22217, -22179, -23151, -24462, -24586, -24549, -24552, -24547, -24560, -24478, -24864, -26766, -27757, -27654, -27668, -27662, -27656, -27649, -27642, -27635, -27628, -27622, -27615, -27608, -27601, -27594, -27587, -27580, -27573, -27566, -27559, -27552, -27544, -27537, -27530, -27522, -27515, -27508, -27501, -27493, -27486, -27479, -27470, -27448, -27519, -26376, -24516, -24227, -24280, -24258, -24251, -24244, -24237, -24214, -24281, -23744, -22262, -21773, -21841, -21817, -21797, -21859, -21092, -19657, -19371, -19405, -19461, -18855, -17380, -16957, -17000, -17073, -16474, -14504, -13740, -13835, -13810, -13818, -12768, -11498, -11403, -11413, -11454, -10562, -9169, -9062, -8630, -6673, -5777, -5864, -4729, -3500, -3518, -2968, -1486, -1024, -1150, -840};