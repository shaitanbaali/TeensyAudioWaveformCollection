/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0275 256 samples */
 
const int16_t AKWF_0275_256_DATA [256] = 
{1095, 2906, 4708, 6543, 8407, 10303, 12231, 14173, 16128, 18085, 20023, 21933, 23785, 25539, 27181, 28672, 29960, 31057, 31888, 32469, 32740, 32714, 32347, 31661, 30644, 29328, 27702, 25813, 23667, 21299, 18754, 16093, 13315, 10512, 7673, 4827, 2045, -680, -3318, -5790, -8087, -10210, -12115, -13783, -15199, -16357, -17251, -17867, -18197, -18272, -18132, -17804, -17293, -16607, -15763, -14783, -13692, -12500, -11208, -9831, -8378, -6869, -5345, -3833, -2358, -951, 383, 1643, 2817, 3902, 4887, 5751, 6489, 7103, 7599, 7987, 8280, 8468, 8558, 8527, 8361, 8027, 7527, 6846, 6034, 5084, 4052, 2911, 1696, 398, -954, -2356, -3759, -5168, -6521, -7804, -8981, -10027, -10895, -11611, -12140, -12500, -12697, -12740, -12644, -12398, -11988, -11424, -10724, -9886, -8910, -7829, -6693, -5534, -4363, -3181, -1999, -860, 208, 1204, 2141, 3038, 3901, 4716, 5472, 6162, 6784, 7343, 7847, 8289, 8665, 8967, 9192, 9347, 9448, 9508, 9541, 9560, 9571, 9566, 9538, 9476, 9377, 9239, 9056, 8814, 8511, 8144, 7693, 7182, 6588, 5944, 5224, 4457, 3611, 2709, 1747, 765, -231, -1201, -2157, -3084, -3980, -4825, -5623, -6316, -6919, -7422, -7807, -8078, -8220, -8205, -8020, -7656, -7105, -6384, -5527, -4566, -3524, -2411, -1213, 69, 1413, 2797, 4181, 5542, 6878, 8175, 9407, 10542, 11532, 12354, 13015, 13530, 13914, 14166, 14259, 14168, 13885, 13422, 12814, 12098, 11309, 10447, 9506, 8479, 7356, 6150, 4878, 3545, 2169, 745, -712, -2234, -3802, -5455, -7167, -8937, -10730, -12522, -14265, -15958, -17557, -19065, -20466, -21763, -22930, -23989, -24905, -25680, -26296, -26735, -27004, -27094, -26993, -26713, -26272, -25677, -24930, -24049, -23068, -22003, -20858, -19629, -18309, -16922, -15486, -14002, -12470, -10887, -9248, -7570, -5865, -4139, -2407, -625};