/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0236 256 samples */
 
const int16_t AKWF_0236_256_DATA [256] = 
{512, 1709, 2864, 4004, 5121, 6218, 7291, 8336, 9354, 10351, 11307, 12246, 13159, 14050, 14922, 15775, 16604, 17410, 18189, 18939, 19663, 20357, 21020, 21655, 22254, 22819, 23351, 23851, 24320, 24766, 25183, 25570, 25929, 26254, 26544, 26802, 27028, 27225, 27395, 27538, 27654, 27742, 27806, 27849, 27875, 27889, 27893, 27888, 27873, 27843, 27801, 27743, 27669, 27581, 27477, 27357, 27217, 27057, 26878, 26681, 26471, 26247, 26015, 25773, 25517, 25251, 24970, 24675, 24368, 24047, 23715, 23372, 23011, 22643, 22265, 21878, 21490, 21102, 20721, 20317, 19944, 19560, 19179, 18804, 18424, 18046, 17673, 17255, 16837, 16404, 15942, 15483, 15013, 14547, 14087, 13631, 13176, 12720, 12263, 11802, 11342, 10879, 10416, 9952, 9481, 8996, 8513, 8028, 7556, 7104, 6673, 6266, 5880, 5508, 5147, 4796, 4451, 4112, 3778, 3447, 3118, 2789, 2459, 2130, 1805, 1487, 1177, 872, 573, 273, -26, -328, -632, -939, -1246, -1556, -1872, -2196, -2518, -2848, -3171, -3491, -3803, -4108, -4408, -4707, -5007, -5307, -5610, -5918, -6229, -6545, -6901, -7255, -7639, -8041, -8456, -8909, -9347, -9815, -10292, -10779, -11269, -11766, -12262, -12765, -13274, -13787, -14312, -14850, -15395, -15946, -16499, -17046, -17589, -18123, -18649, -19173, -19693, -20209, -20722, -21232, -21738, -22244, -22749, -23255, -23763, -24270, -24770, -25263, -25747, -26220, -26687, -27148, -27600, -28044, -28477, -28897, -29304, -29698, -30076, -30449, -30801, -31138, -31450, -31732, -31976, -32169, -32358, -32492, -32611, -32694, -32746, -32767, -32756, -32708, -32629, -32520, -32378, -32200, -31984, -31723, -31416, -31063, -30665, -30230, -29730, -29188, -28607, -27962, -27285, -26561, -25796, -25000, -24171, -23310, -22416, -21494, -20515, -19503, -18459, -17367, -16255, -15109, -13916, -12731, -11517, -10302, -9087, -7875, -6668, -5464, -4263, -3061, -1864, -646};