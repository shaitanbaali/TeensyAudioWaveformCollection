/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0233 256 samples */
 
const int16_t AKWF_0233_256_DATA [256] = 
{274, 1010, 1727, 2446, 3159, 3869, 4578, 5281, 5981, 6677, 7368, 8055, 8739, 9415, 10087, 10756, 11418, 12077, 12730, 13376, 14019, 14657, 15287, 15915, 16536, 17151, 17762, 18367, 18966, 19560, 20149, 20731, 21310, 21882, 22449, 23012, 23568, 24119, 24665, 25205, 25739, 26270, 26795, 27314, 27829, 28337, 28842, 29342, 29836, 30323, 30812, 31249, 31606, 31911, 32162, 32365, 32522, 32637, 32715, 32758, 32767, 32744, 32693, 32615, 32510, 32384, 32234, 32063, 31873, 31663, 31434, 31191, 30929, 30651, 30360, 30054, 29733, 29399, 29053, 28693, 28322, 27939, 27545, 27140, 26722, 26294, 25858, 25408, 24951, 24484, 24005, 23519, 23023, 22516, 22001, 21477, 20943, 20401, 19850, 19290, 18722, 18143, 17555, 16961, 16356, 15742, 15121, 14490, 13850, 13203, 12546, 11879, 11206, 10522, 9829, 9129, 8421, 7706, 6989, 6265, 5540, 4815, 4084, 3355, 2626, 1895, 1167, 442, -285, -1007, -1727, -2447, -3160, -3870, -4579, -5282, -5982, -6678, -7369, -8056, -8739, -9415, -10088, -10757, -11419, -12077, -12730, -13377, -14020, -14657, -15288, -15915, -16537, -17151, -17762, -18367, -18966, -19560, -20149, -20731, -21311, -21882, -22449, -23012, -23568, -24119, -24666, -25205, -25739, -26270, -26796, -27314, -27830, -28338, -28842, -29342, -29836, -30323, -30812, -31249, -31606, -31911, -32162, -32365, -32522, -32637, -32715, -32758, -32767, -32744, -32693, -32615, -32510, -32384, -32234, -32063, -31873, -31663, -31435, -31191, -30929, -30651, -30360, -30054, -29733, -29399, -29053, -28693, -28322, -27939, -27545, -27140, -26722, -26294, -25858, -25409, -24951, -24484, -24006, -23519, -23024, -22516, -22001, -21478, -20943, -20401, -19850, -19290, -18722, -18143, -17555, -16961, -16357, -15743, -15122, -14491, -13851, -13204, -12546, -11880, -11207, -10522, -9830, -9130, -8422, -7707, -6990, -6266, -5541, -4816, -4085, -3356, -2627, -1898, -1171, -433};