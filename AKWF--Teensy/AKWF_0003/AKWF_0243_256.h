/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0243 256 samples */
 
const int16_t AKWF_0243_256_DATA [256] = 
{1044, 2577, 3696, 5282, 6992, 8203, 9355, 10541, 11363, 11914, 12501, 13086, 13660, 14114, 15190, 16174, 16708, 17655, 18850, 19999, 21164, 22324, 23481, 24647, 26269, 27936, 29115, 30267, 31435, 32216, 32705, 32771, 32752, 32749, 32741, 32735, 32729, 32721, 32713, 32706, 32698, 32691, 32682, 32675, 32667, 32659, 32651, 32643, 32634, 32626, 32618, 32609, 32601, 32593, 32584, 32576, 32567, 32559, 32544, 32562, 32240, 31618, 31036, 30444, 29854, 29263, 28675, 28083, 27492, 26905, 26312, 25724, 25135, 24545, 23956, 23366, 22779, 22189, 21597, 21452, 21387, 20834, 20238, 19634, 19424, 19410, 18871, 18418, 18448, 18125, 17552, 17182, 16595, 16006, 15419, 14833, 14245, 13657, 13076, 12455, 11448, 10002, 7740, 5134, 2200, -309, -2523, -4382, -5719, -6246, -7202, -8365, -9029, -9588, -10203, -10490, -10462, -10926, -11445, -11438, -11659, -12277, -12471, -12439, -12444, -12442, -12440, -12438, -12434, -12431, -12440, -12021, -11473, -11421, -11431, -11425, -11422, -11425, -11397, -11530, -12101, -12682, -13256, -14279, -15388, -15968, -16754, -17949, -18746, -19255, -19312, -19445, -20055, -20326, -20290, -20292, -20288, -20284, -20281, -20266, -20657, -21257, -21855, -22254, -22211, -22548, -23139, -23209, -23306, -23902, -24209, -24177, -24176, -24170, -24165, -24159, -24153, -24146, -24139, -24135, -24127, -23663, -23138, -23137, -22909, -22280, -22090, -22068, -21517, -21080, -21111, -20783, -20167, -19566, -19087, -19096, -18836, -18215, -18042, -18059, -18077, -17877, -17255, -17019, -17046, -17034, -17035, -16999, -17283, -17881, -18021, -17991, -17992, -17987, -17982, -17977, -17972, -17967, -17963, -17958, -17953, -17947, -17943, -17935, -17943, -17883, -17331, -16914, -16922, -16921, -16890, -16412, -15810, -15199, -14885, -14910, -14478, -13865, -13286, -12697, -12113, -11526, -10940, -10357, -9768, -9185, -8599, -8018, -7412, -6942, -6534, -5873, -4785, -3597, -2469, -947};