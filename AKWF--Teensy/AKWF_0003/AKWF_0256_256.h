/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0256 256 samples */
 
const int16_t AKWF_0256_256_DATA [256] = 
{1060, 2610, 4114, 5605, 7075, 8521, 9946, 11339, 12703, 14037, 15333, 16596, 17823, 19008, 20155, 21262, 22321, 23339, 24312, 25236, 26114, 26944, 27724, 28455, 29133, 29758, 30328, 30840, 31291, 31680, 32001, 32252, 32432, 32536, 32562, 32509, 32375, 32158, 31857, 31475, 31009, 30460, 29831, 29121, 28332, 27468, 26528, 25517, 24438, 23291, 22082, 20815, 19489, 18111, 16687, 15213, 13701, 12154, 10571, 8962, 7331, 5677, 4014, 2342, 663, -1011, -2679, -4338, -5975, -7591, -9182, -10736, -12255, -13732, -15158, -16533, -17854, -19111, -20306, -21435, -22490, -23475, -24385, -25217, -25972, -26647, -27241, -27757, -28192, -28546, -28820, -29016, -29135, -29178, -29147, -29044, -28871, -28631, -28326, -27960, -27537, -27060, -26530, -25954, -25332, -24666, -23962, -23219, -22438, -21628, -20783, -19906, -19002, -18068, -17109, -16125, -15117, -14087, -13038, -11970, -10885, -9789, -8678, -7558, -6433, -5299, -4163, -3028, -1890, -758, 370, 1494, 2608, 3714, 4810, 5893, 6965, 8024, 9065, 10092, 11106, 12098, 13075, 14034, 14970, 15888, 16785, 17657, 18510, 19341, 20146, 20928, 21681, 22404, 23094, 23746, 24354, 24918, 25432, 25890, 26292, 26631, 26906, 27115, 27253, 27320, 27314, 27235, 27080, 26850, 26547, 26168, 25715, 25190, 24591, 23921, 23185, 22377, 21504, 20568, 19566, 18504, 17386, 16208, 14976, 13695, 12362, 10984, 9564, 8099, 6602, 5071, 3507, 1922, 314, -1315, -2953, -4602, -6257, -7907, -9551, -11184, -12793, -14381, -15938, -17452, -18925, -20349, -21712, -23017, -24256, -25418, -26509, -27520, -28445, -29287, -30040, -30702, -31274, -31753, -32140, -32434, -32635, -32745, -32764, -32693, -32534, -32287, -31957, -31543, -31047, -30474, -29822, -29096, -28300, -27432, -26497, -25500, -24440, -23320, -22147, -20920, -19645, -18327, -16965, -15566, -14137, -12676, -11191, -9687, -8163, -6629, -5089, -3544, -2003, -435};