/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0299 256 samples */
 
const int16_t AKWF_0299_256_DATA [256] = 
{797, 3472, 6983, 11006, 14668, 17416, 19229, 20389, 21147, 21505, 21307, 20420, 18850, 16739, 14240, 11478, 8534, 5445, 2301, -785, -3711, -6367, -8675, -10596, -12084, -13110, -13656, -13717, -13308, -12459, -11223, -9653, -7808, -5765, -3593, -1366, 831, 2935, 4879, 6601, 8055, 9204, 10017, 10481, 10591, 10358, 9798, 8942, 7830, 6501, 5011, 3414, 1760, 108, -1482, -2974, -4313, -5463, -6395, -7085, -7519, -7692, -7607, -7278, -6721, -5966, -5042, -3983, -2834, -1631, -414, 771, 1892, 2914, 3803, 4539, 5103, 5480, 5666, 5662, 5473, 5112, 4599, 3954, 3202, 2371, 1494, 598, -287, -1130, -1908, -2597, -3176, -3634, -3956, -4138, -4179, -4083, -3857, -3513, -3067, -2537, -1941, -1305, -647, 9, 640, 1230, 1760, 2214, 2579, 2849, 3015, 3079, 3039, 2902, 2675, 2369, 1997, 1571, 1110, 630, 144, -327, -772, -1178, -1531, -1821, -2043, -2190, -2261, -2255, -2176, -2029, -1821, -1561, -1261, -928, -577, -220, 132, 467, 776, 1049, 1277, 1457, 1583, 1652, 1666, 1625, 1532, 1393, 1213, 1000, 762, 506, 245, -17, -269, -503, -712, -891, -1035, -1141, -1206, -1228, -1211, -1154, -1063, -938, -789, -618, -434, -242, -48, 138, 316, 477, 616, 731, 817, 874, 901, 898, 864, 805, 721, 617, 496, 362, 222, 80, -60, -193, -316, -423, -514, -584, -634, -661, -665, -647, -609, -552, -481, -395, -299, -197, -93, 11, 111, 204, 287, 358, 414, 456, 480, 489, 481, 458, 420, 371, 310, 242, 169, 92, 15, -59, -130, -193, -249, -295, -328, -350, -360, -358, -344, -320, -286, -244, -195, -356, 799, -4303, -28618, -20100, -24650, -11743, -7643, -12948, -16583, -18692, -15100, -9650, -4721, -1406};