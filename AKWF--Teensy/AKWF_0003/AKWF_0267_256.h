/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0267 256 samples */
 
const int16_t AKWF_0267_256_DATA [256] = 
{2175, 6276, 9998, 13420, 16633, 19712, 22677, 25418, 27676, 29260, 30271, 30760, 31050, 31246, 31301, 31073, 30421, 29319, 27939, 26505, 25207, 24082, 23010, 21753, 20095, 17946, 15384, 12662, 10066, 7802, 5957, 4459, 3160, 1928, 679, -576, -1764, -2839, -3806, -4686, -5496, -6217, -6805, -7229, -7483, -7616, -7716, -7890, -8226, -8764, -9477, -10289, -11122, -11909, -12636, -13325, -14014, -14733, -15505, -16319, -17149, -17967, -18735, -19431, -20056, -20636, -21203, -21687, -21936, -21886, -21607, -21225, -20803, -20190, -19432, -18494, -17415, -16206, -14823, -13261, -11549, -9646, -7507, -5059, -2254, 888, 4306, 7924, 11601, 15201, 18614, 21718, 24434, 26709, 28485, 29738, 30450, 30605, 30186, 29197, 27666, 25603, 23011, 19919, 16385, 12522, 8488, 4396, 371, -3467, -7047, -10281, -13083, -15403, -17183, -18393, -19021, -19063, -18530, -17447, -15866, -13848, -11469, -8853, -6106, -3300, -526, 2136, 4606, 6783, 8551, 9764, 10229, 10001, 9433, 8407, 6961, 5055, 2720, 63, -2776, -5705, -8547, -11143, -13389, -15312, -16907, -18111, -18794, -18792, -17975, -16303, -13874, -10904, -7662, -4444, -1453, 1210, 3507, 5457, 7091, 8404, 9391, 10056, 10424, 10502, 10270, 9707, 8805, 7584, 6119, 4510, 2901, 1442, 245, -617, -1130, -1312, -1178, -741, -4, 1009, 2257, 3685, 5224, 6819, 8435, 10039, 11614, 13134, 14549, 15792, 16748, 17251, 17164, 16645, 15903, 15020, 13888, 12360, 10433, 8397, 6319, 4285, 2280, 321, -1550, -3305, -4917, -6280, -7240, -7644, -7427, -6614, -5313, -3667, -1837, 31, 1843, 3512, 4982, 6196, 7091, 7629, 7788, 7555, 6910, 5843, 4358, 2444, 88, -2683, -5810, -9170, -12609, -16018, -19288, -22327, -25086, -27500, -29508, -31072, -32144, -32699, -32723, -32196, -31116, -29481, -27314, -24654, -21542, -18059, -14281, -10286, -6164, -1892};