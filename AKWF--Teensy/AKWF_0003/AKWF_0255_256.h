/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0255 256 samples */
 
const int16_t AKWF_0255_256_DATA [256] = 
{756, 3251, 5627, 7908, 10059, 12068, 13927, 15619, 17154, 18537, 19769, 20865, 21836, 22687, 23433, 24082, 24637, 25112, 25508, 25829, 26082, 26269, 26393, 26454, 26456, 26398, 26286, 26118, 25902, 25637, 25330, 24987, 24611, 24210, 23791, 23359, 22923, 22489, 22062, 21653, 21268, 20911, 20591, 20312, 20080, 19895, 19762, 19676, 19640, 19646, 19688, 19761, 19854, 19958, 20067, 20168, 20257, 20324, 20360, 20361, 20316, 20222, 20071, 19858, 19577, 19225, 18795, 18285, 17692, 17015, 16250, 15398, 14460, 13435, 12330, 11140, 9869, 8511, 7042, 5460, 3771, 1982, 132, -1745, -3629, -5486, -7295, -9051, -10734, -12336, -13858, -15294, -16640, -17901, -19072, -20152, -21142, -22035, -22833, -23532, -24123, -24608, -24979, -25232, -25362, -25363, -25231, -24960, -24546, -23987, -23277, -22416, -21409, -20251, -18950, -17511, -15932, -14222, -12378, -10371, -8189, -5840, -3354, -793, 1791, 4359, 6859, 9256, 11528, 13644, 15597, 17381, 18987, 20424, 21696, 22808, 23776, 24609, 25317, 25914, 26410, 26813, 27131, 27369, 27530, 27616, 27626, 27561, 27416, 27192, 26885, 26490, 26006, 25428, 24753, 23981, 23109, 22135, 21064, 19896, 18632, 17281, 15843, 14323, 12733, 11069, 9328, 7507, 5599, 3620, 1611, -396, -2352, -4213, -5959, -7562, -9000, -10273, -11376, -12311, -13088, -13719, -14218, -14601, -14884, -15084, -15216, -15300, -15348, -15377, -15400, -15431, -15479, -15556, -15669, -15825, -16029, -16283, -16593, -16955, -17368, -17829, -18331, -18870, -19439, -20028, -20633, -21249, -21865, -22482, -23094, -23696, -24289, -24870, -25441, -26003, -26557, -27103, -27646, -28182, -28711, -29234, -29744, -30238, -30710, -31154, -31562, -31925, -32234, -32481, -32657, -32753, -32761, -32672, -32479, -32171, -31745, -31196, -30516, -29704, -28764, -27691, -26492, -25176, -23740, -22197, -20556, -18817, -16993, -15089, -13103, -11031, -8857, -6561, -4168, -1660};