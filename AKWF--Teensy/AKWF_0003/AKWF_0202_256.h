/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0202 256 samples */
 
const int16_t AKWF_0202_256_DATA [256] = 
{1047, 2720, 4383, 6069, 7760, 9455, 11146, 12817, 14469, 16093, 17675, 19214, 20703, 22128, 23491, 24782, 25991, 27118, 28155, 29095, 29938, 30677, 31307, 31830, 32238, 32531, 32708, 32768, 32711, 32535, 32243, 31835, 31313, 30680, 29938, 29090, 28143, 27097, 25958, 24735, 23429, 22047, 20600, 19088, 17519, 15907, 14251, 12562, 10852, 9121, 7381, 5644, 3908, 2188, 494, -1175, -2805, -4387, -5877, -7532, -7609, -2942, 1805, 5492, 8488, 10836, 12627, 13939, 14825, 15344, 15538, 15448, 15106, 14543, 13786, 12854, 11769, 10553, 9218, 7781, 6260, 4663, 3005, 1301, -444, -2215, -3998, -5792, -7579, -9351, -11105, -12824, -14502, -16136, -17711, -19223, -20669, -22034, -23317, -24513, -25614, -26616, -27518, -28312, -28997, -29570, -30028, -30371, -30598, -30708, -30701, -30578, -30341, -29990, -29529, -28962, -28289, -27516, -26650, -25691, -24647, -23525, -22326, -21061, -19737, -18356, -16931, -15467, -13969, -12449, -10912, -9365, -7820, -6281, -4754, -3253, -1780, -342, 1048, 2391, 3678, 4899, 6053, 7134, 8133, 9051, 9882, 10620, 11266, 11815, 12264, 12615, 12865, 13013, 13060, 13006, 12854, 12603, 12259, 11821, 11295, 10684, 9991, 9221, 8382, 7476, 6509, 5491, 4424, 3315, 2174, 1006, -184, -1383, -2589, -3794, -4985, -6162, -7314, -8432, -9515, -10551, -11534, -12460, -13322, -14113, -14800, -15555, -15231, -11857, -8397, -5545, -3088, -1014, 727, 2173, 3352, 4291, 5016, 5542, 5890, 6074, 6108, 6003, 5771, 5423, 4968, 4415, 3775, 3054, 2262, 1409, 500, -455, -1447, -2471, -3516, -4572, -5638, -6700, -7751, -8786, -9796, -10772, -11712, -12603, -13442, -14223, -14938, -15583, -16153, -16642, -17046, -17362, -17586, -17715, -17747, -17680, -17512, -17242, -16872, -16399, -15826, -15156, -14385, -13521, -12567, -11521, -10392, -9185, -7899, -6545, -5127, -3650, -2127, -523};