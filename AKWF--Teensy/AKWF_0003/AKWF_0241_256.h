/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0241 256 samples */
 
const int16_t AKWF_0241_256_DATA [256] = 
{656, 3122, 5254, 7170, 9506, 11830, 13804, 15076, 16772, 18598, 20012, 21467, 22886, 23923, 24867, 25856, 26578, 27030, 27888, 28790, 29316, 29604, 29569, 29879, 30377, 30868, 31213, 31179, 31436, 31925, 32016, 31989, 31986, 31980, 31976, 31957, 31998, 32448, 32775, 32754, 32747, 32740, 32732, 32724, 32716, 32707, 32699, 32690, 32682, 32674, 32665, 32657, 32648, 32639, 32632, 32623, 32614, 32606, 32597, 32588, 32579, 32572, 32563, 32554, 32545, 32537, 32528, 32519, 32510, 32502, 32494, 32484, 32476, 32467, 32459, 32450, 32441, 32432, 32423, 32415, 32407, 32398, 32389, 32380, 32372, 32363, 32354, 32345, 32337, 32329, 32320, 32311, 32302, 32294, 32285, 32276, 32267, 32259, 32251, 32242, 32216, 32281, 31795, 30313, 28863, 27408, 25959, 24495, 23070, 21384, 19426, 17850, 16425, 14945, 13665, 12733, 11443, 10006, 8958, 8126, 7663, 6919, 5934, 5347, 4872, 4409, 3891, 1775, -703, -3114, -5251, -7172, -9508, -11834, -13792, -15498, -16920, -18371, -19816, -21257, -22699, -24173, -25022, -25475, -26390, -27245, -27721, -28198, -28677, -29153, -29630, -30105, -30581, -31066, -31226, -31201, -31176, -31307, -31808, -32017, -31983, -31981, -31979, -31946, -32153, -32650, -32783, -32753, -32750, -32741, -32733, -32725, -32717, -32709, -32701, -32692, -32684, -32675, -32667, -32659, -32650, -32642, -32633, -32624, -32616, -32607, -32598, -32590, -32582, -32573, -32564, -32556, -32547, -32538, -32529, -32521, -32513, -32504, -32495, -32486, -32478, -32470, -32460, -32452, -32442, -32434, -32426, -32417, -32408, -32399, -32391, -32382, -32373, -32365, -32356, -32348, -32339, -32330, -32321, -32313, -32304, -32295, -32286, -32278, -32270, -32261, -32252, -32240, -32231, -32237, -31212, -29692, -28233, -26934, -25994, -24735, -23231, -21367, -19526, -18076, -16625, -15181, -13676, -12505, -11471, -10005, -8961, -8128, -7666, -6923, -5937, -5350, -4866, -4455, -3366, -1343};