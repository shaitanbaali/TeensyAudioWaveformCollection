/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0245 256 samples */
 
const int16_t AKWF_0245_256_DATA [256] = 
{613, 2118, 3614, 4644, 5924, 7529, 8731, 9760, 10786, 12014, 13616, 14873, 15894, 16944, 17990, 19063, 19850, 20345, 21279, 22268, 22815, 23328, 23866, 24039, 24045, 24526, 24913, 24899, 24895, 24890, 24885, 24879, 24874, 24868, 24863, 24862, 24832, 25134, 25658, 25742, 25717, 25717, 25710, 25699, 26087, 26564, 26564, 26740, 27273, 27796, 28283, 28329, 28445, 28966, 29484, 29996, 30531, 30964, 30955, 31156, 31693, 32217, 32682, 32734, 32713, 32708, 32701, 32693, 32684, 32676, 32668, 32653, 32671, 32484, 31939, 31408, 30875, 30344, 29809, 29277, 28744, 28210, 27678, 27145, 26613, 26076, 25563, 24681, 23639, 23047, 22527, 21992, 21460, 20928, 20397, 19865, 19335, 18803, 18272, 17741, 17211, 16681, 16154, 15602, 15386, 15383, 14940, 14390, 13866, 13336, 12810, 12262, 11831, 11459, 10904, 10405, 9742, 8664, 7883, 7380, 6426, 5435, 4915, 4178, 3105, 2056, 1004, -45, -1100, -2150, -3196, -4263, -5754, -7247, -8275, -9561, -11163, -12359, -13388, -14412, -15641, -17263, -18185, -18684, -19659, -20719, -21786, -22568, -23057, -23601, -24039, -24054, -24081, -24559, -24945, -24932, -24927, -24923, -24917, -24912, -24906, -24900, -24895, -24890, -24889, -24856, -25019, -25569, -25777, -25747, -25725, -25835, -26372, -26640, -26603, -27003, -27474, -27471, -27653, -28190, -28704, -29222, -29738, -30252, -30795, -31032, -31008, -31413, -31947, -32483, -32779, -32752, -32748, -32740, -32732, -32724, -32716, -32708, -32699, -32690, -32685, -32302, -31743, -31217, -30682, -30151, -29617, -29084, -28553, -28019, -27486, -26954, -26421, -25889, -25356, -24823, -24287, -23773, -22885, -21847, -21259, -20740, -20206, -19674, -19142, -18612, -18086, -17529, -17220, -17291, -16943, -15824, -15395, -15421, -14972, -14422, -13898, -13369, -12839, -12310, -11780, -11252, -10721, -10193, -9671, -9108, -8106, -7174, -6680, -5871, -4796, -4176, -3574, -2542, -1486, -421};