/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0282 256 samples */
 
const int16_t AKWF_0282_256_DATA [256] = 
{1123, 2780, 4209, 5528, 6777, 8247, 9608, 11082, 12625, 14051, 15649, 17171, 18522, 19902, 21132, 22311, 23712, 24908, 26228, 27247, 28196, 29183, 29770, 30139, 30524, 30925, 31675, 32493, 32777, 32623, 31967, 31042, 30210, 29465, 28745, 28080, 27210, 26191, 25075, 23749, 22224, 20678, 19391, 18361, 17060, 15553, 14171, 12664, 10800, 9003, 7336, 5568, 3630, 1742, -82, -1910, -3714, -5505, -7295, -9081, -11019, -13042, -15042, -17291, -19698, -21952, -24297, -26540, -28371, -29743, -30631, -31268, -31580, -31591, -31327, -31147, -30670, -29940, -29013, -27886, -26702, -25431, -24138, -23275, -22562, -21601, -20324, -18816, -17352, -15875, -14201, -12429, -10468, -8263, -6127, -3841, -1167, 1819, 4740, 7309, 9417, 11075, 12501, 13775, 15121, 16305, 17522, 18704, 19548, 20311, 20978, 21502, 21923, 22261, 22222, 21975, 21483, 20931, 20352, 19440, 18193, 16990, 15922, 14505, 12832, 10924, 8641, 6208, 3776, 1537, -702, -2898, -4800, -6527, -8507, -10663, -12841, -15084, -17091, -19127, -21007, -22540, -23638, -24571, -25418, -26132, -26637, -27057, -27324, -27103, -26717, -26292, -26100, -25988, -25914, -25629, -25096, -24348, -23632, -22974, -22154, -21315, -20768, -20463, -19961, -19269, -18872, -18646, -18065, -17324, -16580, -15657, -14604, -13379, -11711, -9709, -7552, -5299, -2891, -450, 2107, 4926, 7605, 9805, 11840, 13587, 14865, 15911, 16814, 17561, 18333, 19149, 20076, 21301, 22586, 23710, 24384, 24961, 25710, 26249, 26729, 27358, 27711, 27707, 27364, 26473, 25453, 24256, 22850, 21147, 19120, 17052, 15166, 13258, 11146, 9014, 6811, 4722, 2586, 459, -1457, -3428, -5693, -7777, -9723, -11607, -13155, -14617, -16105, -17252, -18031, -18753, -19627, -20600, -21516, -22043, -22393, -22490, -22769, -22911, -22801, -22894, -22910, -22444, -21252, -19731, -17958, -16064, -14487, -13002, -11059, -8901, -6804, -4694, -2729, -775};