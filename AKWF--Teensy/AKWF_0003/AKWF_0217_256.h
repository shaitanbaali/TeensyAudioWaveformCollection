/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0217 256 samples */
 
const int16_t AKWF_0217_256_DATA [256] = 
{180, 812, 1432, 2080, 2757, -1900, -2335, -1437, -849, -220, 396, 1003, 1596, 2176, 2742, 3295, 3833, 4359, 4871, 5369, 5856, 6331, 6794, 7247, 7690, 8121, 8545, 8958, 9362, 9758, 10145, 10524, 10895, 11257, 11611, 11958, 12296, 12626, 12949, 13264, 13570, 13869, 14159, 14442, 14717, 14983, 15241, 15491, 15733, 15966, 16192, 16408, 16616, 16815, 17006, 17188, 17362, 17526, 17682, 17829, 17967, 18097, 18217, 18328, 18430, 18524, 18604, 18684, 18767, 16253, 15777, 15942, 15950, 15971, 15984, 15987, 15982, 15968, 15944, 15912, 15871, 15822, 15764, 15697, 15621, 15537, 15444, 15343, 15234, 15116, 14990, 14855, 14712, 14562, 14403, 14237, 14062, 13880, 13690, 13491, 13285, 13072, 12849, 12620, 12384, 12138, 11885, 11624, 11355, 11078, 10792, 10496, 10194, 9881, 9558, 9227, 8884, 8531, 8167, 7790, 7402, 7001, 6586, 6157, 5716, 5260, 4791, 4309, 3815, 3311, 2793, 2276, 1769, -1330, -2381, -2779, -3320, -3830, -4329, -4818, -5294, -5756, -6205, -6640, -7060, -7467, -7861, -8241, -8610, -8966, -9311, -9646, -9971, -10285, -10589, -10885, -11170, -11449, -11717, -11978, -12231, -12475, -12711, -12939, -13159, -13372, -13576, -13773, -13961, -14142, -14315, -14479, -14636, -14785, -14925, -15057, -15181, -15297, -15404, -15503, -15593, -15675, -15748, -15813, -15869, -15915, -15954, -15984, -16004, -16016, -16019, -16013, -15998, -15974, -15945, -15898, -15830, -18341, -18797, -18593, -18528, -18432, -18327, -18213, -18090, -17958, -17817, -17667, -17508, -17340, -17164, -16980, -16786, -16584, -16373, -16155, -15927, -15691, -15447, -15195, -14935, -14666, -14390, -14105, -13813, -13513, -13205, -12889, -12565, -12234, -11894, -11548, -11193, -10830, -10461, -10081, -9694, -9300, -8896, -8485, -8064, -7634, -7194, -6745, -6285, -5815, -5334, -4839, -4334, -3816, -3284, -2739, -2180, -1608, -1024, -415};