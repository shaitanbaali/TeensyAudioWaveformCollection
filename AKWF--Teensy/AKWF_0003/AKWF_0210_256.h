/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0210 256 samples */
 
const int16_t AKWF_0210_256_DATA [256] = 
{341, 1539, 3068, 4681, 6254, 7970, 9762, 11769, 13714, 15638, 17555, 19412, 21160, 22722, 23998, 25104, 26324, 27214, 27766, 28199, 28634, 29139, 29791, 30352, 30811, 31194, 31487, 32041, 32708, 32258, 31495, 31030, 30350, 29482, 28585, 27396, 26116, 25052, 24265, 23603, 22756, 21556, 20581, 19957, 19475, 19109, 18883, 18627, 18043, 17473, 17104, 16555, 16111, 15746, 15214, 14675, 14436, 14158, 13911, 13664, 13206, 12683, 12115, 11744, 11560, 11357, 11250, 11041, 10717, 10422, 10181, 10297, 10445, 10237, 9817, 9376, 8844, 8324, 7820, 7203, 6571, 5999, 5502, 4854, 3960, 3213, 2626, 2043, 1527, 895, 347, 75, -402, -807, -953, -1092, -1242, -1480, -1706, -2262, -2917, -3288, -3602, -3902, -4167, -4304, -4311, -3914, -3377, -2702, -2017, -1427, -797, -35, 668, 1419, 2415, 3523, 4417, 4761, 4497, 4533, 4307, 3612, 3118, 2588, 1889, 815, -362, -1534, -3068, -4682, -6254, -7970, -9762, -11770, -13715, -15639, -17555, -19412, -21160, -22723, -23997, -25105, -26324, -27214, -27767, -28199, -28634, -29139, -29792, -30352, -30811, -31195, -31487, -32041, -32708, -32258, -31496, -31030, -30350, -29483, -28585, -27395, -26117, -25053, -24265, -23602, -22756, -21556, -20581, -19957, -19476, -19109, -18884, -18628, -18044, -17474, -17105, -16555, -16112, -15746, -15214, -14675, -14436, -14158, -13912, -13664, -13207, -12683, -12116, -11744, -11561, -11358, -11251, -11042, -10718, -10423, -10181, -10297, -10446, -10237, -9818, -9377, -8844, -8325, -7821, -7204, -6571, -5999, -5502, -4855, -3960, -3213, -2627, -2045, -1529, -896, -348, -76, 401, 806, 951, 1092, 1241, 1479, 1704, 2261, 2916, 3287, 3601, 3902, 4166, 4303, 4310, 3913, 3377, 2701, 2016, 1426, 796, 33, -669, -1419, -2415, -3525, -4419, -4761, -4498, -4534, -4308, -3614, -3119, -2590, -1895, -804};