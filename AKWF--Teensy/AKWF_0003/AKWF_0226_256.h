/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0226 256 samples */
 
const int16_t AKWF_0226_256_DATA [256] = 
{305, 1431, 2514, 3581, 4625, 5650, 6657, 7640, 8603, 9546, 10466, 11365, 12246, 13102, 13939, 14756, 15550, 16325, 17079, 17811, 18525, 19219, 19891, 20545, 21180, 21793, 22390, 22966, 23523, 24062, 24583, 25086, 25572, 26038, 26488, 26921, 27336, 27734, 28118, 28483, 28832, 29166, 29484, 29787, 30073, 30345, 30601, 30843, 31069, 31282, 31479, 31661, 31829, 31984, 32125, 32251, 32363, 32461, 32546, 32616, 32674, 32719, 32748, 32765, 32768, 32757, 32733, 32695, 32643, 32578, 32498, 32407, 32301, 32180, 32046, 31897, 31734, 31559, 31368, 31161, 30942, 30705, 30456, 30191, 29911, 29615, 29304, 28976, 28634, 28276, 27900, 27508, 27100, 26675, 26232, 25773, 25295, 24800, 24286, 23755, 23206, 22638, 22050, 21444, 20818, 20172, 19508, 18824, 18118, 17394, 16650, 15883, 15098, 14290, 13461, 12615, 11743, 10852, 9941, 9007, 8053, 7080, 6082, 5065, 4030, 2970, 1893, 795, -321, -1428, -2513, -3582, -4626, -5651, -6658, -7641, -8603, -9546, -10466, -11366, -12247, -13102, -13940, -14757, -15550, -16326, -17080, -17811, -18526, -19219, -19891, -20545, -21180, -21793, -22391, -22966, -23524, -24062, -24583, -25086, -25572, -26038, -26489, -26921, -27337, -27735, -28118, -28483, -28832, -29166, -29484, -29787, -30073, -30345, -30601, -30843, -31069, -31282, -31479, -31661, -31829, -31985, -32125, -32251, -32363, -32461, -32546, -32616, -32674, -32719, -32748, -32765, -32768, -32757, -32733, -32695, -32643, -32578, -32499, -32407, -32301, -32180, -32046, -31897, -31734, -31559, -31368, -31161, -30942, -30705, -30456, -30191, -29911, -29615, -29304, -28977, -28634, -28276, -27900, -27508, -27100, -26675, -26232, -25773, -25295, -24800, -24286, -23756, -23206, -22639, -22050, -21444, -20819, -20172, -19509, -18824, -18118, -17395, -16650, -15883, -15098, -14291, -13462, -12615, -11743, -10853, -9942, -9008, -8054, -7080, -6082, -5066, -4031, -2973, -1898, -781};