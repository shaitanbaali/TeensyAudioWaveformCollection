/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0283 256 samples */
 
const int16_t AKWF_0283_256_DATA [256] = 
{315, 1485, 2670, 3884, 5116, 6356, 7599, 8831, 10049, 11238, 12373, 13450, 14474, 15225, 15756, 16323, 16560, 16694, 16718, 16652, 16538, 16348, 16109, 15818, 15483, 15099, 14658, 14154, 13586, 12946, 12231, 11447, 10597, 9684, 8703, 7650, 6527, 5329, 4048, 2682, 1224, -321, -1930, -3606, -5206, -6660, -8211, -9556, -10774, -11880, -12840, -13686, -14382, -14927, -15316, -15575, -15584, -15343, -15101, -14595, -13973, -13256, -12277, -11323, -10335, -9199, -8097, -6986, -5940, -4941, -4020, -3212, -2405, -1695, -1041, -406, 218, 858, 1514, 2187, 2862, 3533, 4199, 4850, 5475, 6066, 6628, 7185, 7759, 8369, 9036, 9767, 10579, 11483, 12475, 13552, 14709, 15929, 17193, 18484, 19774, 21046, 22288, 23480, 24622, 25712, 26745, 27723, 28639, 29482, 30249, 30932, 31519, 32006, 32379, 32629, 32753, 32754, 32642, 32422, 32095, 31669, 31152, 30564, 29914, 29202, 28435, 27627, 26789, 25930, 25053, 24154, 23246, 22331, 21410, 20487, 19559, 18631, 17709, 16788, 15868, 14956, 14055, 13126, 11940, 10839, 9467, 7985, 6607, 5025, 3572, 2145, 813, -431, -1622, -2736, -3793, -4799, -5773, -6724, -7639, -8640, -9719, -10503, -11184, -11991, -12559, -13018, -13414, -13762, -14129, -14485, -14844, -15200, -15558, -15926, -16074, -16055, -16111, -15857, -15500, -15025, -14453, -13815, -13066, -12315, -11690, -11147, -10747, -10554, -10553, -10733, -11048, -11235, -11607, -12093, -12485, -12993, -13512, -14057, -14697, -15477, -16268, -17144, -18147, -19250, -20425, -21621, -22815, -23998, -25151, -26257, -27297, -28245, -29085, -29810, -30409, -30864, -31149, -31243, -31135, -30583, -29817, -28924, -27611, -26138, -24638, -23103, -21432, -19869, -18307, -16992, -15686, -14451, -13443, -12489, -11652, -10870, -10143, -9503, -9113, -8692, -8309, -8066, -7795, -7540, -7220, -6835, -6384, -5854, -5233, -4510, -3695, -2796, -1825, -760};