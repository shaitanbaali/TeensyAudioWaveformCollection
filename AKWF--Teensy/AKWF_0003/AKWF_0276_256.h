/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0276 256 samples */
 
const int16_t AKWF_0276_256_DATA [256] = 
{2093, 5035, 7659, 10144, 12606, 15115, 17656, 20133, 22426, 24399, 25946, 27044, 27722, 28052, 28113, 27964, 27639, 27136, 26445, 25536, 24379, 22976, 21365, 19603, 17768, 15924, 14109, 12360, 10695, 9127, 7680, 6355, 5135, 4002, 2929, 1914, 979, 156, -522, -1037, -1385, -1568, -1585, -1424, -1070, -518, 222, 1109, 2077, 3068, 4029, 4930, 5767, 6547, 7277, 7960, 8582, 9122, 9563, 9893, 10109, 10217, 10216, 10101, 9850, 9437, 8843, 8050, 7038, 5740, 4161, 2399, 495, -1470, -3439, -5449, -7553, -9752, -12048, -14357, -16549, -18616, -20565, -22389, -24052, -25536, -26896, -28135, -29274, -30314, -31168, -31821, -32335, -32683, -32767, -32586, -32207, -31623, -30772, -29671, -28391, -26949, -25287, -23378, -21266, -19061, -16839, -14573, -12211, -9770, -7324, -4979, -2802, -762, 1211, 3177, 5147, 7049, 8797, 10343, 11692, 12926, 14148, 15399, 16655, 17864, 18960, 19911, 20717, 21409, 22034, 22628, 23181, 23657, 24005, 24177, 24140, 23877, 23394, 22714, 21865, 20863, 19708, 18400, 16947, 15353, 13649, 11866, 10028, 8181, 6375, 4647, 3042, 1587, 293, -823, -1747, -2464, -2955, -3211, -3235, -3041, -2646, -2067, -1323, -442, 538, 1568, 2599, 3577, 4455, 5200, 5778, 6156, 6308, 6208, 5840, 5197, 4289, 3139, 1767, 207, -1510, -3361, -5309, -7315, -9344, -11340, -13266, -15156, -17008, -18811, -20374, -21814, -23004, -23997, -24782, -25769, -26846, -28089, -29237, -30093, -30348, -30097, -29169, -27756, -26010, -24177, -22039, -19658, -17068, -14282, -11215, -8044, -4720, -1141, 2340, 5481, 8491, 11410, 13893, 15807, 17359, 18663, 19542, 19838, 19598, 18901, 17767, 16177, 14183, 11898, 9392, 6662, 3717, 697, -2145, -4660, -6906, -9040, -11216, -13440, -15461, -16948, -17701, -17718, -17180, -16371, -15526, -14666, -13594, -12067, -9952, -7277, -4214, -947};