/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0227 256 samples */
 
const int16_t AKWF_0227_256_DATA [256] = 
{246, 617, 980, 1343, 1704, 2066, 2427, 2786, 3144, 3501, 3857, 4212, 4565, 4917, 5269, 5618, 5966, 6313, 6658, 7002, 7346, 7686, 8027, 8365, 8701, 9037, 9370, 9703, 10033, 10363, 10690, 11016, 11340, 11663, 11985, 12305, 12623, 12939, 13256, 13569, 13880, 14192, 14500, 14808, 15114, 15417, 15720, 16022, 16321, 16619, 16915, 17211, 17504, 17796, 18086, 18376, 18662, 18948, 19232, 19516, 19797, 20077, 20355, 20632, 20907, 21180, 21454, 21725, 21994, 22262, 22529, 22794, 23058, 23320, 23581, 23841, 24099, 24356, 24611, 24865, 25117, 25369, 25619, 25868, 26115, 26361, 26605, 26848, 27090, 27330, 27570, 27808, 28044, 28280, 28513, 28746, 28978, 29208, 29438, 29665, 29891, 30116, 30340, 30562, 30785, 31006, 31224, 31442, 31660, 31874, 32089, 32261, 32652, 32137, 24697, 20628, 16375, 12614, 9172, 6034, 3181, 586, -1788, -3948, -5918, -7722, -9367, -10870, -12246, -13503, -14652, -15705, -16664, -17542, -18346, -19079, -19750, -20361, -20916, -21423, -21883, -22298, -22675, -23016, -23321, -23594, -23837, -24052, -24242, -24407, -24548, -24669, -24769, -24850, -24914, -24961, -24991, -25007, -25010, -24998, -24974, -24936, -24889, -24830, -24761, -24682, -24595, -24497, -24391, -24277, -24155, -24026, -23890, -23748, -23598, -23442, -23280, -23112, -22938, -22760, -22577, -22388, -22193, -21995, -21791, -21585, -21372, -21156, -20936, -20713, -20486, -20254, -20019, -19782, -19541, -19296, -19048, -18797, -18542, -18285, -18024, -17761, -17496, -17227, -16955, -16681, -16403, -16123, -15843, -15557, -15269, -14980, -14688, -14393, -14096, -13797, -13494, -13191, -12884, -12576, -12265, -11951, -11636, -11318, -10998, -10675, -10351, -10024, -9697, -9364, -9031, -8696, -8358, -8018, -7677, -7333, -6986, -6638, -6286, -5934, -5579, -5222, -4862, -4502, -4139, -3775, -3411, -3045, -2678, -2313, -1945, -1579, -1213, -846, -482, -109};