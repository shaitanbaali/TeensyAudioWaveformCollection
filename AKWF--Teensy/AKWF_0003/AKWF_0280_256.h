/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0280 256 samples */
 
const int16_t AKWF_0280_256_DATA [256] = 
{1382, 3924, 6742, 9572, 12493, 15383, 17927, 20115, 21709, 22782, 23235, 23045, 22479, 21523, 20471, 19374, 18313, 17350, 16519, 15854, 15378, 15087, 14806, 14652, 14349, 13819, 13146, 12151, 10955, 9650, 8416, 7200, 6169, 5278, 4586, 4120, 3782, 3500, 3303, 3027, 2533, 1670, 391, -1228, -3106, -5309, -7705, -10072, -12390, -14478, -16061, -17092, -17398, -16891, -15771, -14387, -12707, -11070, -9502, -8079, -7071, -6461, -6115, -6122, -6208, -6413, -6659, -6703, -6533, -6293, -5987, -5639, -5645, -6049, -6830, -8063, -9748, -11620, -13485, -15158, -16516, -17098, -16971, -16013, -14174, -11463, -8204, -4457, -488, 3318, 6996, 10264, 12991, 15361, 17170, 18780, 20349, 21845, 23487, 25126, 26846, 28305, 29347, 29621, 28981, 27527, 25033, 21629, 17685, 13350, 9067, 5014, 1427, -1243, -3213, -4260, -4496, -3993, -3106, -1862, -691, 217, 847, 1153, 1172, 940, 475, 4, -510, -911, -921, -757, -421, -70, 72, 56, -190, -865, -1928, -3339, -5194, -7329, -9739, -12179, -14511, -16692, -18479, -19917, -20890, -21321, -21537, -21497, -21195, -20896, -20569, -20248, -19821, -19406, -18822, -18148, -17374, -16338, -14975, -13254, -11300, -9175, -6957, -4783, -2643, -795, 736, 1916, 2722, 3194, 3520, 3603, 3667, 3833, 4435, 5342, 6710, 8655, 10947, 13745, 16689, 19722, 22666, 25232, 27261, 28917, 29807, 30179, 30148, 29728, 29180, 28564, 27769, 26929, 25998, 24731, 23020, 20947, 18223, 14998, 11266, 7128, 2894, -1134, -4815, -7913, -10287, -11883, -12579, -12654, -12141, -11154, -10019, -8827, -7755, -6917, -6294, -6066, -5939, -5898, -5811, -5606, -5315, -4951, -4627, -4390, -4524, -5228, -6571, -8669, -11372, -14759, -18510, -22364, -25885, -28838, -31145, -32404, -32759, -32097, -30545, -28273, -25438, -22206, -18784, -15552, -12520, -9752, -7342, -5128, -3014, -849};