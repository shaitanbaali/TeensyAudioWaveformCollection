/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0204 256 samples */
 
const int16_t AKWF_0204_256_DATA [256] = 
{424, 1869, 3352, 4894, 6485, 8119, 9790, 11481, 13191, 14911, 16621, 18321, 19998, 21635, 23230, 24769, 26236, 27630, 28926, 30047, 30969, 31694, 32228, 32578, 32747, 32743, 32572, 32241, 31759, 31133, 30373, 29488, 28487, 27382, 26181, 24894, 23537, 22115, 20639, 19126, 17579, 16012, 14438, 12862, 11294, 9750, 8230, 6747, 5311, 3922, 2591, 1328, 129, -996, -2041, -3009, -3894, -4693, -5409, -6039, -6583, -7046, -7426, -7727, -7953, -8106, -8189, -8209, -8171, -8078, -7938, -7756, -7537, -7289, -7017, -6729, -6429, -6125, -5823, -5528, -5247, -4983, -4744, -4533, -4355, -4212, -4110, -4050, -4035, -4066, -4145, -4271, -4446, -4668, -4935, -5247, -5601, -5993, -6420, -6880, -7365, -7872, -8397, -8930, -9469, -10008, -10537, -11053, -11547, -12013, -12444, -12834, -13175, -13463, -13689, -13849, -13937, -13949, -13880, -13723, -13477, -13141, -12707, -12179, -11554, -10829, -10009, -9093, -8081, -6980, -5790, -4514, -3163, -1738, -245, 1305, 2908, 4557, 6236, 7944, 9667, 11391, 13113, 14820, 16496, 18122, 19996, 21824, 23177, 24145, 24761, 25062, 25080, 24844, 24377, 23706, 22851, 21832, 20670, 19383, 17984, 16495, 14928, 13297, 11620, 9908, 8173, 6434, 4695, 2968, 1271, -395, -2016, -3580, -5087, -6526, -7887, -9171, -10370, -11477, -12495, -13417, -14240, -14968, -15598, -16129, -16566, -16907, -17157, -17319, -17396, -17392, -17313, -17164, -16950, -16676, -16350, -15977, -15564, -15120, -14648, -14155, -13651, -13139, -12626, -12121, -11625, -11147, -10692, -10262, -9863, -9499, -9172, -8886, -8643, -8443, -8289, -8180, -8116, -8096, -8119, -8182, -8284, -8422, -8591, -8787, -9007, -9245, -9495, -9753, -10013, -10269, -10513, -10741, -10945, -11119, -11258, -11355, -11402, -11397, -11332, -11202, -11002, -10730, -10379, -9949, -9434, -8833, -8145, -7371, -6506, -5555, -4519, -3398, -2200, -895};