/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0291 256 samples */
 
const int16_t AKWF_0291_256_DATA [256] = 
{8420, 9724, 7248, 8167, 8228, 6831, 5538, 5060, 5015, 5112, 5325, 5614, 5900, 6152, 6382, 6580, 6730, 6830, 6876, 6871, 6807, 6699, 6543, 6339, 6097, 5814, 5501, 5158, 4788, 4386, 3972, 3542, 3078, 2604, 2115, 1591, 1048, 452, -229, -1038, -4253, -5550, -5030, -5703, -6127, -6028, -5867, -5934, -6109, -6302, -6504, -6695, -6878, -7023, -7140, -7235, -7303, -7334, -7348, -7340, -7289, -7221, -7137, -7028, -6896, -6743, -6582, -6407, -6220, -6024, -5822, -5598, -5372, -5154, -4907, -4668, -4421, -4187, -3929, -3694, -3436, -3199, -2941, -2704, -2473, -2211, -1979, -1757, -1526, -1299, -1078, -859, -640, -424, -209, 2, 218, 398, 582, 808, 966, 1158, 1342, 1542, 1714, 1910, 2128, 2369, 2707, 4169, 4587, 4333, 4625, 4836, 4742, 4650, 4651, 4698, 4781, 4852, 4900, 4968, 5026, 5050, 5077, 5097, 5103, 5100, 5087, 5069, 5026, 4986, 4930, 4875, 4803, 4736, 4662, 4571, 4483, 4398, 4277, 4203, 4085, 3996, 3882, 3754, 3673, 3554, 3417, 3321, 3226, 3088, 2969, 2853, 2765, 2650, 2521, 2414, 2301, 2198, 2116, 1993, 1886, 1786, 1683, 1578, 1477, 1380, 1286, 1190, 1124, 1052, 950, 869, 791, 707, 626, 549, 475, 403, 334, 267, 202, 139, 78, 19, -35, -95, -181, -223, -268, -319, -365, -404, -443, -483, -522, -559, -595, -628, -660, -691, -718, -775, -809, -819, -847, -870, -887, -901, -918, -934, -948, -965, -1012, -1016, -1020, -1035, -1043, -1045, -1049, -1054, -1055, -1088, -1102, -1089, -1094, -1097, -1093, -1087, -1085, -1079, -1105, -1111, -1092, -1092, -1088, -1078, -1067, -1059, -1049, -1073, -1071, -1049, -1207, -540, -3394, -28107, -29939, -20177, -19662, -18193, -12548, -7047, -3906, -1098};