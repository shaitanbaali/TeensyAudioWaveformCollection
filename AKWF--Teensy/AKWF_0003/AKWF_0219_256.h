/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0219 256 samples */
 
const int16_t AKWF_0219_256_DATA [256] = 
{553, 1581, 2557, 3503, 4420, 5304, 6194, 7227, 8343, 9474, 10609, 11747, 12877, 13989, 15078, 16133, 17145, 18113, 19028, 19885, 20685, 21423, 22095, 22706, 23253, 23733, 24151, 24507, 24798, 25028, 25200, 25314, 25371, 25374, 25325, 25226, 25078, 24887, 24652, 24377, 24063, 23715, 23334, 22925, 22487, 22026, 21545, 21043, 20526, 19995, 19452, 18902, 18345, 17785, 17223, 16662, 16103, 15551, 15004, 14468, 13949, 13454, 12994, 12578, 12215, 11919, 11697, 11560, 11513, 11561, 11705, 11943, 12276, 12702, 13221, 13833, 14544, 15361, 16304, 17499, 19323, 21175, 22736, 24188, 25545, 26795, 27929, 28943, 29826, 30579, 31210, 31720, 32117, 32410, 32606, 32727, 32753, 32451, 31860, 31110, 30223, 29214, 28099, 26899, 25628, 24301, 22939, 21549, 20143, 18735, 17327, 15927, 14545, 13176, 11828, 10507, 9207, 7934, 6692, 5475, 4288, 3134, 2007, 912, -151, -1186, -2188, -3158, -4100, -5009, -6018, -7153, -8306, -9469, -10635, -11792, -12937, -14061, -15150, -16204, -17214, -18169, -19072, -19918, -20701, -21424, -22083, -22676, -23208, -23674, -24077, -24419, -24700, -24920, -25083, -25188, -25239, -25238, -25185, -25084, -24937, -24746, -24513, -24241, -23934, -23592, -23219, -22818, -22391, -21940, -21469, -20980, -20473, -19955, -19425, -18886, -18342, -17792, -17239, -16689, -16137, -15590, -15049, -14513, -13987, -13471, -12965, -12471, -11993, -11529, -11081, -10652, -10249, -9878, -9546, -9260, -9030, -8862, -8765, -8744, -8810, -8964, -9208, -9542, -9965, -10477, -11077, -11768, -12548, -13436, -14443, -15696, -17606, -19518, -21142, -22662, -24079, -25387, -26581, -27649, -28587, -29396, -30079, -30640, -31090, -31435, -31684, -31871, -31888, -31532, -30940, -30195, -29311, -28306, -27201, -26009, -24748, -23440, -22091, -20718, -19336, -17947, -16561, -15189, -13827, -12483, -11164, -9864, -8591, -7346, -6126, -4937, -3777, -2646, -1549, -460};