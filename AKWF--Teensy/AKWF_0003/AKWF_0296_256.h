/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0296 256 samples */
 
const int16_t AKWF_0296_256_DATA [256] = 
{576, 2469, 4236, 5916, 7504, 8996, 10392, 11683, 12876, 13969, 14958, 15850, 16644, 17340, 17942, 18453, 18873, 19208, 19459, 19628, 19722, 19744, 19695, 19580, 19404, 19170, 18880, 18542, 18157, 17727, 17259, 16757, 16220, 15658, 15071, 14460, 13835, 13193, 12538, 11875, 11206, 10533, 9861, 9188, 8515, 7805, 7414, 3049, -3520, -8925, -14193, -18895, -22876, -26078, -28532, -30315, -31490, -32128, -32299, -32060, -31468, -30568, -29408, -28030, -26465, -24757, -22929, -21007, -19026, -17000, -14948, -12896, -10851, -8829, -6848, -4910, -3028, -1212, 535, 2207, 3797, 5306, 6728, 8059, 9301, 10453, 11511, 12481, 13360, 14147, 14848, 15462, 15990, 16438, 16805, 17096, 17313, 17458, 17535, 17546, 17497, 17389, 17226, 17012, 16750, 16443, 16096, 15711, 15291, 14840, 14361, 13856, 13332, 12788, 12228, 11656, 11073, 10483, 9887, 9289, 8691, 8095, 7500, 6912, 6333, 5761, 5199, 4651, 4114, 3594, 3087, 2597, 2126, 1671, 1235, 818, 421, 44, -311, -647, -964, -1259, -1534, -1788, -2023, -2238, -2434, -2610, -2768, -2906, -3028, -3132, -3220, -3290, -3346, -3388, -3414, -3428, -3428, -3417, -3393, -3359, -3315, -3262, -3200, -3130, -3053, -2969, -2878, -2783, -2683, -2579, -2472, -2362, -2249, -2134, -2018, -1901, -1783, -1666, -1549, -1433, -1318, -1205, -1094, -984, -877, -772, -672, -574, -479, -387, -298, -214, -134, -58, 14, 81, 146, 207, 263, 317, 366, 410, 451, 488, 521, 551, 578, 600, 620, 636, 649, 659, 665, 671, 672, 671, 668, 663, 655, 646, 635, 623, 605, 528, 817, -2624, -8642, -13457, -18163, -22335, -25802, -28515, -30497, -31820, -32555, -32771, -32538, -31914, -30957, -29712, -28226, -26546, -24698, -22724, -20657, -18513, -16328, -14122, -11907, -9709, -7543, -5416, -3349, -1308};