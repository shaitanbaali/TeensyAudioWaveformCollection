/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0216 256 samples */
 
const int16_t AKWF_0216_256_DATA [256] = 
{144, 510, 812, 1109, 2283, 3147, 3638, 4099, 4511, 5046, 5637, 6234, 5837, 5796, 6169, 6577, 7042, 7369, 7638, 7890, 9348, 10403, 10960, 11494, 11969, 12630, 13384, 14256, 13354, 13069, 13502, 14023, 14663, 15355, 16199, 16981, 21542, 24564, 25954, 27200, 27902, 28987, 30225, 31334, 30552, 30335, 30704, 30992, 31294, 31268, 31084, 30866, 31813, 32257, 32165, 31997, 31735, 31614, 31538, 31436, 30312, 29537, 29163, 28810, 28497, 28034, 27498, 26956, 27293, 27289, 26914, 26498, 26030, 25677, 25373, 25061, 23932, 23097, 22598, 22122, 21691, 21141, 20540, 19941, 20109, 19991, 19551, 19082, 18569, 18164, 17805, 17444, 16338, 15500, 14978, 14480, 14024, 13465, 12861, 12255, 12395, 12261, 11819, 11352, 10846, 10443, 10088, 9735, 8636, 7809, 7297, 6810, 6367, 5823, 5233, 4645, 4826, 4729, 4313, 3873, 3390, 3018, 2692, 2374, 1246, 409, -84, -550, -970, -1500, -2079, -2663, -2361, -2381, -2765, -3177, -3638, -3977, -4258, -4532, -5798, -6719, -7222, -7696, -8115, -8676, -9303, -9947, -9397, -9274, -9653, -10076, -10575, -10911, -11192, -11408, -13690, -15653, -16880, -18085, -19159, -20509, -22021, -23668, -21558, -20962, -22017, -23200, -24583, -25411, -25980, -26609, -29072, -30447, -30954, -31315, -31541, -31983, -32442, -32780, -31813, -31220, -31084, -30945, -30836, -30524, -30105, -29669, -30211, -30357, -30075, -29742, -29341, -29065, -28837, -28595, -27460, -26640, -26181, -25746, -25354, -24832, -24250, -23668, -23895, -23815, -23394, -22941, -22440, -22049, -21705, -21361, -20240, -19399, -18882, -18387, -17937, -17378, -16769, -16162, -16304, -16169, -15722, -15250, -14736, -14327, -13965, -13603, -12501, -11667, -11147, -10653, -10201, -9647, -9048, -8449, -8600, -8479, -8047, -7591, -7096, -6706, -6362, -6026, -4917, -4089, -3588, -3111, -2680, -2144, -1560, -976, -1207, -1146, -746, -313};