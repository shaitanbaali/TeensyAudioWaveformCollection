/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0298 256 samples */
 
const int16_t AKWF_0298_256_DATA [256] = 
{216, 750, 1265, 1775, 2276, 2770, 3258, 3736, 4207, 4672, 5127, 5575, 6015, 6447, 6872, 7288, 7695, 8096, 8489, 8872, 9249, 9618, 9978, 10330, 10674, 11010, 11338, 11658, 11969, 12272, 12568, 12855, 13135, 13406, 13669, 13924, 14170, 14409, 14639, 14862, 15076, 15282, 15480, 15671, 15852, 16026, 16193, 16350, 16500, 16643, 16777, 16903, 17022, 17133, 17235, 17331, 17418, 17497, 17570, 17634, 17691, 17740, 17782, 17815, 17843, 17863, 17875, 17880, 17878, 17868, 17852, 17828, 17798, 17761, 17717, 17667, 17609, 17545, 17475, 17398, 17314, 17224, 17129, 17027, 16918, 16804, 16684, 16558, 16427, 16290, 16147, 15999, 15846, 15688, 15524, 15356, 15182, 15004, 14821, 14633, 14441, 14245, 14044, 13840, 13631, 13418, 13202, 12982, 12757, 12531, 12300, 12066, 11830, 11590, 11348, 11103, 10855, 10606, 10353, 10099, 9842, 9584, 9324, 9062, 8799, 8533, 8267, 8001, 7732, 7463, 7194, 6923, 6652, 6381, 6110, 5839, 5567, 5296, 5025, 4755, 4485, 4216, 3948, 3680, 3414, 3148, 2884, 2622, 2361, 2102, 1844, 1587, 1326, 1059, 775, 470, 136, -236, -654, -1125, -1656, -2254, -2922, -3666, -4484, -5376, -6344, -7379, -8478, -9635, -10836, -12079, -13353, -14642, -15943, -17243, -18527, -19795, -21033, -22229, -23383, -24485, -25527, -26508, -27423, -28265, -29039, -29738, -30361, -30912, -31387, -31789, -32120, -32379, -32570, -32696, -32760, -32762, -32706, -32596, -32433, -32222, -31965, -31665, -31326, -30950, -30538, -30095, -29624, -29125, -28602, -28060, -27494, -26911, -26314, -25700, -25075, -24440, -23794, -23139, -22480, -21812, -21141, -20467, -19789, -19110, -18429, -17749, -17069, -16390, -15712, -15038, -14365, -13694, -13029, -12367, -11709, -11056, -10407, -9762, -9125, -8492, -7865, -7245, -6629, -6021, -5420, -4824, -4235, -3653, -3078, -2510, -1949, -1395, -850, -301};