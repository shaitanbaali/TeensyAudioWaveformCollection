/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0209 256 samples */
 
const int16_t AKWF_0209_256_DATA [256] = 
{626, 1697, 2821, 3980, 5140, 6283, 7385, 8387, 9257, 9992, 10568, 10976, 11220, 11320, 11314, 11259, 11203, 11165, 11189, 11304, 11514, 11819, 12209, 12659, 13146, 13646, 14134, 14595, 15020, 15426, 15820, 16202, 16572, 16926, 17249, 17566, 17889, 18219, 18583, 19004, 19511, 20130, 20853, 21671, 22572, 23530, 24512, 25486, 26413, 27270, 28033, 28690, 29232, 29644, 29934, 30139, 30309, 30486, 30695, 30938, 31201, 31464, 31705, 31917, 32113, 32305, 32500, 32668, 32764, 32727, 32515, 32120, 31543, 30829, 30042, 29234, 28456, 27746, 27110, 26527, 26003, 25558, 25196, 24906, 24695, 24554, 24443, 24327, 24189, 24022, 23823, 23600, 23370, 23133, 22864, 22538, 22131, 21636, 21047, 20372, 19658, 18951, 18276, 17638, 17026, 16442, 15882, 15343, 14818, 14273, 13658, 12930, 12053, 10987, 9713, 8244, 6595, 4814, 2948, 1049, -816, -2585, -4198, -5600, -6771, -7716, -8443, -8951, -9251, -9370, -9352, -9247, -9108, -8988, -8937, -9010, -9222, -9540, -9918, -10326, -10743, -11152, -11538, -11879, -12165, -12410, -12600, -12730, -12837, -12939, -13044, -13162, -13284, -13420, -13597, -13852, -14233, -14764, -15436, -16230, -17116, -18063, -19060, -20082, -21122, -22195, -23286, -24362, -25391, -26339, -27185, -27921, -28529, -29017, -29408, -29732, -30024, -30315, -30625, -30940, -31241, -31510, -31725, -31851, -31879, -31812, -31673, -31483, -31256, -30997, -30709, -30396, -30057, -29693, -29303, -28906, -28525, -28178, -27876, -27631, -27459, -27358, -27309, -27296, -27298, -27291, -27269, -27256, -27254, -27237, -27181, -27067, -26832, -26437, -25897, -25224, -24444, -23584, -22664, -21712, -20739, -19765, -18830, -17958, -17151, -16410, -15723, -15063, -14400, -13682, -12878, -11991, -11018, -9980, -8911, -7836, -6783, -5787, -4861, -4019, -3271, -2630, -2120, -1773, -1607, -1616, -1767, -2009, -2272, -2484, -2570, -2478, -2198, -1742, -1115, -296};