/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0260 256 samples */
 
const int16_t AKWF_0260_256_DATA [256] = 
{781, 2036, 2980, 3722, 4303, 4758, 5118, 5399, 5619, 5793, 5936, 6046, 6129, 6199, 6251, 6288, 6321, 6342, 6373, 6367, 6369, 6437, 6440, 6434, 6429, 6425, 6421, 6416, 6412, 6406, 6401, 6397, 6393, 6388, 6382, 6377, 6373, 6367, 6363, 6356, 6468, 5821, 11224, 11774, 12083, 14868, 16549, 17737, 18559, 19131, 19532, 19812, 20006, 20140, 20230, 20290, 20327, 20351, 20363, 20367, 20366, 20360, 20352, 20341, 20329, 20317, 20304, 20287, 20272, 20257, 20240, 20227, 20215, 20199, 20182, 20166, 20150, 20134, 20119, 20102, 20085, 20070, 20055, 20038, 20022, 20006, 19990, 20051, 19591, 22219, 22980, 22613, 24774, 26211, 27255, 27991, 28509, 28868, 29119, 29290, 29404, 29480, 29528, 29555, 29568, 29572, 29566, 29555, 29541, 29526, 29506, 29487, 29464, 29443, 29423, 29399, 29376, 29353, 29329, 29304, 29305, 28708, 31833, 10461, 15362, 13526, -3623, -11720, -16743, -20299, -22776, -24527, -25764, -26642, -27264, -27701, -28008, -28224, -28371, -28471, -28537, -28579, -28602, -28615, -28617, -28614, -28603, -28591, -28576, -28560, -28542, -28522, -28502, -28480, -28464, -28400, -28655, -27328, -25201, -26299, -24343, -22812, -21678, -20852, -20258, -19829, -19518, -19291, -19124, -19001, -18910, -18839, -18783, -18742, -18705, -18675, -18649, -18628, -18606, -18588, -18569, -18551, -18536, -18521, -18506, -18486, -18470, -18455, -18440, -18425, -18409, -18395, -18379, -18365, -18349, -18335, -18320, -18305, -18290, -18276, -18261, -18246, -18207, -18356, -17611, -14819, -16127, -14332, -12624, -11361, -10434, -9764, -9279, -8929, -8674, -8492, -8359, -8259, -8188, -8136, -8096, -8064, -8042, -8023, -8008, -7994, -7982, -7972, -7962, -7951, -7946, -7939, -7932, -7925, -7918, -7911, -7904, -7898, -7891, -7884, -7878, -7871, -7865, -7858, -7852, -7845, -7838, -7832, -7826, -7746, -8184, -5899, -4231, -5219, -2690, -726};