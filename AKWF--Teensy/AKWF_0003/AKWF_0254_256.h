/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0254 256 samples */
 
const int16_t AKWF_0254_256_DATA [256] = 
{679, 2344, 3909, 5416, 6859, 8244, 9573, 10844, 12062, 13228, 14341, 15410, 16433, 17404, 18325, 19188, 19983, 20707, 21352, 21915, 22397, 22798, 23119, 23361, 23524, 23609, 23615, 23547, 23411, 23213, 22966, 22677, 22357, 22013, 21653, 21281, 20909, 20542, 20189, 19859, 19555, 19284, 19051, 18861, 18720, 18630, 18593, 18601, 18650, 18727, 18822, 18923, 19017, 19096, 19150, 19175, 19165, 19120, 19036, 18911, 18740, 18514, 18231, 17883, 17464, 16973, 16408, 15765, 15049, 14256, 13390, 12455, 11452, 10389, 9282, 8135, 6962, 5774, 4573, 3364, 2156, 940, -278, -1496, -2718, -3942, -5164, -6392, -7620, -8848, -10079, -11303, -12514, -13709, -14869, -15981, -17035, -18013, -18906, -19701, -20385, -20952, -21391, -21692, -21853, -21867, -21727, -21426, -20959, -20325, -19522, -18559, -17446, -16194, -14819, -13344, -11778, -10143, -8457, -6726, -4968, -3196, -1412, 364, 2121, 3849, 5529, 7151, 8710, 10195, 11607, 12945, 14207, 15398, 16520, 17570, 18551, 19464, 20309, 21090, 21809, 22459, 23039, 23544, 23962, 24285, 24503, 24610, 24601, 24479, 24242, 23887, 23412, 22815, 22093, 21251, 20295, 19227, 18063, 16810, 15478, 14082, 12633, 11142, 9632, 8113, 6596, 5104, 3644, 2228, 877, -402, -1598, -2694, -3695, -4596, -5398, -6114, -6748, -7311, -7814, -8268, -8677, -9051, -9394, -9710, -10002, -10277, -10542, -10804, -11072, -11354, -11659, -11991, -12354, -12752, -13187, -13662, -14178, -14731, -15321, -15944, -16588, -17247, -17914, -18575, -19232, -19881, -20518, -21148, -21771, -22386, -22999, -23606, -24211, -24821, -25437, -26067, -26713, -27370, -28033, -28696, -29346, -29973, -30567, -31113, -31599, -32017, -32352, -32595, -32736, -32767, -32682, -32473, -32133, -31653, -31025, -30248, -29317, -28238, -27022, -25672, -24209, -22650, -21003, -19288, -17523, -15710, -13868, -12007, -10129, -8252, -6391, -4552, -2756, -974};