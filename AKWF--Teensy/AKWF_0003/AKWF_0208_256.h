/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0208 256 samples */
 
const int16_t AKWF_0208_256_DATA [256] = 
{1594, -1447, -5950, -701, 4643, 4017, 4847, 4511, 3352, 5976, 3573, 738, 1144, -267, 3708, 4754, 4817, 9300, 7301, 10450, 12331, 10087, 11710, 12116, 10403, 16191, 15024, 17728, 17584, 15524, 20023, 17507, 14890, 17173, 18868, 24305, 30844, 27155, 22767, 19460, 15491, 18570, 22036, 23899, 27039, 26789, 25602, 25854, 25372, 22491, 23202, 25151, 31806, 29858, 26256, 27506, 28747, 22981, 22399, 24715, 24381, 20776, 20549, 20945, 20203, 19617, 18678, 17537, 16657, 13619, 10206, 8783, 5329, -1702, -1072, -5017, -7802, -6531, -3709, -169, 164, 1094, 1352, 3778, -495, -859, 1318, 1008, 2294, 1738, 748, 1428, -4135, -9861, -7913, -4389, -1241, -1053, -2649, 40, 1472, 3353, 7477, 8072, 8511, 14461, 20419, 23102, 20246, 16675, 11728, 10150, 9306, 12059, 12902, 13331, 17307, 13992, 14118, 15200, 15053, 14953, 16287, 13763, 11057, 10371, 8605, 11227, 8391, 4131, 3173, 7421, 4283, -121, -2050, -7547, -11134, -12106, -11421, -10504, -13689, -10659, -9529, -12061, -18869, -19593, -24054, -23104, -24706, -26726, -24975, -21353, -20165, -21846, -22165, -22065, -21311, -23796, -18059, -16743, -16246, -20339, -22915, -24797, -23737, -21108, -18282, -18218, -20310, -19063, -17548, -20939, -25650, -25462, -21086, -24223, -29483, -26149, -23170, -24045, -23285, -21212, -21253, -15893, -11559, -8506, -8018, -5214, -4041, -2397, 1861, 4782, -768, -2214, -2066, -6842, -8894, -8269, -9067, -7269, -4846, -2315, 2992, 7307, 7490, 4476, 1507, 7200, 7009, 6053, 10832, 10810, 7093, 5726, -149, -2069, -1282, -3487, -5047, -9066, -10439, -7644, -5681, -9065, -9518, -10668, -10515, -10187, -12389, -10758, -9889, -16444, -16880, -15057, -17063, -14580, -13358, -16581, -15362, -11113, -10775, -14364, -17520, -20052, -16762, -15340, -13607, -15431, -18814, -13947, -18209, -19895, -17264, -7751, -3297, -882};