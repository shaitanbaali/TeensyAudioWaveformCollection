/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0261 256 samples */
 
const int16_t AKWF_0261_256_DATA [256] = 
{13748, 13750, 13752, 13753, 13754, 13754, 13754, 13754, 13754, 13753, 13753, 13752, 13750, 13663, 14147, 11975, 5329, 5727, 5660, 5656, 5654, 5652, 5650, 5648, 5646, 5644, 5642, 5639, 5637, 5731, 5214, 7866, 13902, 13675, 13694, 13705, 13702, 13700, 13698, 13695, 13692, 13690, 13687, 13685, 13683, 13593, 14076, 11903, 5256, 5653, 5585, 5580, 5577, 5575, 5573, 5570, 5567, 5565, 5563, 5560, 5557, 5652, 5134, 7785, 13822, 13594, 13613, 13624, 13621, 13618, 13617, 13613, 13611, 13608, 13605, 13603, 13601, 13511, 13995, 11821, 5174, 5571, 5503, 5498, 5495, 5493, 5491, 5488, 5485, 5483, 5481, 5478, 5475, 5570, 5052, 7703, 13740, 13512, 13531, 13542, 13539, 13536, 13535, 13531, 13529, 13527, 13524, 13812, 12223, 19984, 34319, 30491, 24147, 24542, 24471, 24464, 24459, 24454, 24449, 24443, 24438, 24431, 24425, 24419, 24413, 24269, 24891, 23333, -21209, -25645, -24483, -24706, -24708, -24710, -24709, -24710, -24708, -24705, -24703, -24701, -24698, -24780, -24290, -26456, -32884, -33672, -28351, -12835, -13869, -13687, -13679, -13675, -13671, -13667, -13663, -13659, -13657, -13555, -14067, -11409, -5367, -5590, -5565, -5549, -5546, -5543, -5540, -5537, -5534, -5531, -5528, -5525, -5522, -5606, -5117, -7285, -13927, -13524, -13588, -13587, -13584, -13582, -13580, -13577, -13574, -13571, -13569, -13567, -13563, -13464, -13977, -11319, -5278, -5502, -5477, -5461, -5459, -5456, -5454, -5451, -5449, -5446, -5443, -5441, -5439, -5522, -5034, -7203, -13844, -13441, -13505, -13505, -13502, -13500, -13497, -13494, -13492, -13489, -13487, -13485, -13481, -13382, -13896, -11237, -5196, -5420, -5396, -5380, -5378, -5375, -5372, -5370, -5367, -5365, -5362, -5360, -5357, -5441, -4953, -7121, -13763, -13360, -13424, -13424, -13421, -13419, -13416, -13413, -13411, -13408, -13405, -13404, -13401, -13315, -13763, -11345};