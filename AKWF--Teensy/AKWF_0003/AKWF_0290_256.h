/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0290 256 samples */
 
const int16_t AKWF_0290_256_DATA [256] = 
{1209, 6880, 15688, 15691, 12525, 11254, 10698, 9705, 8616, 7697, 6762, 5776, 4894, 4177, 3561, 3008, 2523, 2100, 1735, 1427, 1167, 946, 752, 588, 439, 309, 188, 75, -27, -126, -227, -332, -431, -539, -661, -787, -930, -1096, -1293, -1555, -1844, -3073, -5702, -5806, -4735, -4303, -4184, -3947, -3674, -3473, -3274, -3066, -2878, -2735, -2624, -2522, -2429, -2351, -2280, -2218, -2172, -2128, -2076, -2031, -1988, -1945, -1894, -1840, -1790, -1741, -1689, -1637, -1580, -1507, -1445, -1381, -1306, -1230, -1159, -1083, -1003, -925, -841, -761, -670, -596, -514, -414, -335, -260, -177, -92, -9, 77, 164, 251, 339, 430, 520, 577, 666, 759, 830, 907, 1000, 1090, 1174, 1277, 1415, 1553, 2187, 3389, 3381, 2926, 2814, 2837, 2744, 2637, 2545, 2479, 2420, 2355, 2284, 2247, 2202, 2153, 2115, 2084, 2055, 2027, 2001, 1975, 1937, 1908, 1877, 1847, 1817, 1784, 1755, 1707, 1677, 1630, 1585, 1555, 1510, 1477, 1417, 1367, 1340, 1282, 1220, 1192, 1148, 1082, 1021, 979, 954, 899, 835, 782, 731, 702, 669, 608, 552, 505, 458, 411, 367, 323, 279, 240, 228, 193, 141, 100, 65, 29, -6, -40, -72, -104, -134, -163, -191, -217, -242, -267, -288, -327, -369, -379, -389, -406, -422, -435, -449, -462, -473, -484, -495, -505, -514, -521, -536, -571, -576, -569, -571, -575, -577, -578, -579, -581, -579, -594, -617, -606, -595, -591, -589, -585, -580, -574, -576, -599, -595, -576, -566, -561, -553, -545, -537, -536, -557, -549, -527, -516, -508, -499, -489, -478, -477, -498, -487, -484, -626, 295, -11042, -31270, -27888, -15160, -9093, -6797, -3998, -1026};