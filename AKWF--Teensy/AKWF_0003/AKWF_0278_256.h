/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0278 256 samples */
 
const int16_t AKWF_0278_256_DATA [256] = 
{144, 581, 1079, 1612, 2167, 2740, 3328, 3933, 4578, 5287, 6063, 6897, 7759, 8631, 9505, 10368, 11212, 12048, 12885, 13729, 14566, 15362, 16096, 16760, 17341, 17833, 18239, 18565, 18819, 19009, 19129, 19169, 19127, 19009, 18817, 18555, 18229, 17853, 17442, 17010, 16568, 16124, 15676, 15235, 14812, 14423, 14065, 13743, 13455, 13201, 12990, 12834, 12739, 12697, 12698, 12736, 12809, 12915, 13048, 13199, 13352, 13495, 13617, 13722, 13815, 13892, 13944, 13957, 13923, 13838, 13705, 13525, 13292, 13004, 12657, 12247, 11781, 11278, 10748, 10204, 9651, 9089, 8529, 7985, 7468, 6991, 6559, 6172, 5830, 5530, 5273, 5070, 4930, 4859, 4857, 4917, 5032, 5194, 5403, 5656, 5950, 6278, 6631, 6992, 7345, 7675, 7967, 8216, 8421, 8577, 8682, 8728, 8711, 8624, 8465, 8239, 7949, 7603, 7210, 6773, 6296, 5780, 5221, 4625, 3998, 3351, 2697, 2045, 1400, 770, 159, -431, -989, -1509, -1989, -2420, -2798, -3119, -3382, -3594, -3763, -3894, -3992, -4072, -4047, -4914, -6340, -7880, -9392, -11139, -12960, -14966, -17166, -19502, -21764, -23894, -25792, -27458, -28895, -30149, -31176, -31914, -32402, -32695, -32777, -32587, -32163, -31491, -30629, -29564, -28396, -27167, -25866, -24541, -23145, -21726, -20299, -18903, -17618, -16381, -15257, -14243, -13348, -12571, -11870, -11316, -10910, -10580, -10366, -10288, -10286, -10354, -10535, -10762, -10990, -11252, -11584, -11885, -12144, -12400, -12669, -12845, -12906, -12901, -12877, -12764, -12538, -12205, -11823, -11379, -10857, -10260, -9607, -8940, -8249, -7509, -6729, -5960, -5261, -4625, -4011, -3400, -2815, -2299, -1887, -1571, -1324, -1111, -925, -792, -744, -770, -849, -941, -1009, -1066, -1160, -1310, -1489, -1664, -1796, -1854, -1850, -1835, -1848, -1881, -1910, -1902, -1815, -1642, -1415, -1181, -952, -720, -481, -196};