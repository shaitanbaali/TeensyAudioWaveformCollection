/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0205 256 samples */
 
const int16_t AKWF_0205_256_DATA [256] = 
{123, 550, 957, 1359, 1770, 2186, 2592, 2967, 3272, 3476, 3599, 3658, 3683, 3728, 3848, 4061, 4357, 4729, 5160, 5641, 6180, 6793, 7479, 8234, 9044, 9888, 10740, 11568, 12358, 13111, 13844, 14587, 15360, 16163, 16988, 17810, 18606, 19367, 20081, 20749, 21373, 21957, 22499, 23006, 23480, 23920, 24331, 24714, 25069, 25400, 25705, 25987, 26246, 26486, 26704, 26903, 27086, 27246, 27384, 27494, 27574, 27626, 27648, 27650, 27632, 27602, 27561, 27514, 27461, 27402, 27352, 27292, 25356, 25102, 23442, 22786, 22929, 22903, 22893, 22863, 22812, 22733, 22625, 22490, 22325, 22134, 21918, 21652, 21532, 20520, 18953, 19399, 20597, 19914, 19340, 18677, 17962, 17214, 16449, 15686, 14943, 14228, 13591, 12756, 13347, 14139, 13456, 13075, 12705, 12387, 12115, 11876, 11740, 11124, 9446, 7693, 6127, 4521, 2854, 1236, -421, -221, -1378, -3136, -4735, -6293, -7724, -8620, -9809, -11754, -13581, -15300, -17082, -18874, -20555, -22131, -23675, -25192, -26634, -27992, -29244, -30332, -31210, -31871, -32331, -32615, -32750, -32729, -32809, -31011, -29845, -29625, -29165, -28506, -28962, -29257, -28600, -28186, -27790, -28868, -28993, -28788, -28708, -28620, -28512, -28370, -28171, -27934, -29020, -28948, -28520, -28141, -27729, -27308, -26879, -26449, -26023, -25602, -25188, -24784, -24386, -23997, -23616, -23239, -22870, -22507, -22154, -21816, -21495, -21188, -20895, -20611, -20329, -20047, -19759, -19501, -18990, -19812, -20831, -20276, -19947, -19546, -19118, -18663, -18192, -17711, -17227, -16749, -16284, -15835, -15404, -14992, -14600, -14225, -13867, -13523, -13195, -12898, -12660, -12497, -12414, -12406, -12459, -12572, -12730, -12914, -13082, -13382, -12951, -11862, -12055, -12049, -12014, -11926, -11785, -11595, -11357, -11076, -10730, -10505, -9439, -7885, -7580, -7087, -6594, -6158, -4328, -3430, -2998, -2465, -1954, -1456, -985, -488, -247, -297};