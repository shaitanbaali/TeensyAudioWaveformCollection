/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0265 256 samples */
 
const int16_t AKWF_0265_256_DATA [256] = 
{361, 1446, 2535, 3635, 4615, 5532, 6483, 7478, 8528, 9562, 10464, 11380, 12290, 13116, 13881, 14607, 15285, 15959, 16637, 17334, 18056, 18716, 19285, 19880, 20547, 21143, 21451, 21778, 22213, 22820, 23311, 23620, 24058, 24415, 24542, 24759, 25108, 25321, 25332, 25404, 25729, 26003, 26119, 26082, 25929, 25704, 25466, 25560, 25929, 26254, 26450, 26511, 26468, 26357, 26206, 26054, 25852, 25287, 24554, 23940, 23507, 23246, 23124, 23095, 23122, 23188, 22997, 22479, 21981, 21622, 21428, 21299, 20887, 20354, 19951, 19716, 19647, 19457, 18983, 18544, 18266, 18128, 17782, 17269, 16870, 16662, 16367, 15844, 15409, 15157, 14787, 14248, 13831, 13624, 13387, 12911, 12492, 12267, 12104, 11684, 11234, 10955, 10816, 10462, 9987, 9648, 9508, 9399, 9007, 8582, 8307, 8213, 8020, 7568, 7171, 6945, 6860, 6560, 6092, 5736, 5566, 5453, 5061, 4610, 4306, 4181, 4144, 3838, 3396, 3071, 2923, 2770, 2338, 1894, 1605, 1493, 1258, 790, 392, 170, 73, -253, -721, -1065, -1234, -1528, -2027, -2424, -2663, -3074, -3609, -3974, -4339, -4907, -5371, -5683, -6176, -6702, -7022, -7383, -7913, -8311, -8770, -9360, -9856, -10506, -11107, -11530, -12094, -12609, -13119, -13741, -14368, -15112, -15697, -16321, -16943, -17605, -18291, -18813, -19428, -19993, -20639, -21266, -21966, -22619, -23126, -23711, -24259, -24930, -25473, -25977, -26544, -26971, -27519, -28008, -28314, -28763, -29179, -29597, -30160, -30551, -30922, -31436, -31805, -31927, -31979, -32281, -32595, -32754, -32748, -32615, -32401, -32149, -31890, -31645, -31424, -31233, -31070, -30936, -30822, -30739, -30610, -30115, -29453, -28919, -28444, -27737, -27064, -26479, -25729, -24978, -24096, -23251, -22347, -21499, -20651, -19765, -18815, -17851, -16868, -15895, -14808, -13705, -12656, -11543, -10455, -9446, -8397, -7292, -6139, -4972, -3771, -2671, -1688, -684};