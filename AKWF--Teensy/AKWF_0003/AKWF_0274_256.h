/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0274 256 samples */
 
const int16_t AKWF_0274_256_DATA [256] = 
{1987, 6954, 11804, 16431, 20632, 24299, 27378, 29824, 31589, 32584, 32727, 31997, 30457, 28253, 25542, 22476, 19171, 15672, 12036, 8349, 4690, 1132, -2307, -5620, -8751, -11566, -14082, -16265, -18134, -19646, -20726, -21340, -21505, -21245, -20619, -19644, -18417, -16987, -15470, -13913, -12390, -10932, -9607, -8452, -7491, -6727, -6142, -5750, -5582, -5645, -5896, -6272, -6742, -7308, -7953, -8587, -9064, -9271, -9178, -8808, -8178, -7281, -6111, -4709, -3164, -1590, -80, 1300, 2504, 3503, 4277, 4818, 5141, 5274, 5244, 5074, 4794, 4452, 4096, 3768, 3503, 3342, 3338, 3533, 3920, 4492, 5356, 6378, 7538, 8778, 10129, 11594, 13168, 14813, 16513, 18221, 19902, 21392, 22622, 23475, 23957, 24000, 23607, 22718, 21308, 19378, 16953, 14056, 10735, 7054, 3077, -1046, -5161, -9171, -12970, -16417, -19369, -21697, -23373, -24437, -24892, -24705, -23855, -22389, -20429, -18113, -15565, -12861, -10061, -7248, -4490, -1860, 558, 2709, 4543, 6023, 7155, 7948, 8414, 8565, 8415, 7996, 7363, 6590, 5744, 4864, 3956, 3094, 2303, 1549, 741, -168, -1127, -1967, -2699, -3328, -3925, -4470, -4921, -5239, -5446, -5512, -5426, -5098, -4524, -3676, -2613, -1348, 41, 1484, 2833, 3954, 4754, 5201, 5306, 5060, 4452, 3528, 2416, 1254, 90, -1103, -2347, -3576, -4676, -5590, -6374, -7103, -7784, -8330, -8621, -8598, -8274, -7698, -6900, -5878, -4635, -3194, -1616, 10, 1608, 3119, 4497, 5731, 6821, 7788, 8674, 9511, 10311, 11084, 11826, 12562, 13318, 14056, 14720, 15272, 15685, 15953, 16162, 16253, 16240, 16033, 15576, 14827, 13795, 12532, 11131, 9641, 8133, 6559, 4897, 3056, 998, -1347, -3955, -6849, -9983, -13263, -16585, -19805, -22778, -25405, -27568, -29149, -30074, -30319, -29925, -28946, -27401, -25272, -22542, -19269, -15560, -11526, -7251, -2637};