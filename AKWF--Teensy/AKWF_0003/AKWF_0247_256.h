/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0247 256 samples */
 
const int16_t AKWF_0247_256_DATA [256] = 
{209, 589, 661, 630, 778, 1115, 1415, 1724, 2044, 2342, 2663, 2970, 3275, 3596, 3896, 4206, 4618, 4965, 5288, 5425, 5404, 5431, 5709, 6033, 6328, 6649, 6955, 7250, 7625, 8018, 8327, 8625, 8938, 9263, 9381, 9356, 9394, 9684, 10003, 10298, 10619, 10922, 11217, 11600, 11984, 12290, 12587, 12901, 13220, 13319, 13292, 13342, 13643, 13958, 14249, 14586, 14998, 15317, 15618, 15923, 16240, 16533, 16849, 17159, 17241, 17211, 17276, 17586, 17895, 18185, 18530, 18938, 19252, 19551, 19856, 20171, 20463, 20780, 21081, 21147, 21115, 21197, 21506, 21913, 22258, 22559, 22854, 23173, 23468, 23774, 24086, 24377, 24696, 24986, 25036, 25005, 25101, 25419, 25827, 26164, 26464, 26759, 27077, 27369, 27676, 27985, 28275, 28597, 28874, 28906, 28893, 29126, 29451, 29739, 30051, 30354, 30648, 30964, 31255, 31563, 31870, 32133, 32543, 32352, 28594, 22865, 14044, 5044, -2886, -10542, -17999, -22151, -25282, -27824, -28793, -29747, -30265, -30600, -30866, -30843, -30845, -30838, -30850, -30728, -30391, -30083, -29772, -29445, -29142, -28817, -28501, -28202, -27823, -27578, -27602, -27561, -27271, -26941, -26638, -26308, -25997, -25682, -25355, -25051, -24727, -24303, -23957, -23632, -23512, -23529, -23478, -23174, -22848, -22545, -22214, -21904, -21599, -21205, -20814, -20501, -20195, -19871, -19547, -19445, -19464, -19399, -19086, -18764, -18461, -18131, -17823, -17517, -17116, -16735, -16422, -16118, -15793, -15477, -15392, -15414, -15334, -15012, -14695, -14396, -14040, -13624, -13303, -12996, -12681, -12358, -12058, -11731, -11424, -11356, -11378, -11283, -10956, -10643, -10344, -9981, -9571, -9254, -8948, -8632, -8312, -8013, -7684, -7390, -7336, -7358, -7247, -6917, -6498, -6156, -5849, -5544, -5218, -4917, -4600, -4282, -3985, -3654, -3373, -3333, -3355, -3227, -2889, -2472, -2136, -1830, -1525, -1201, -902, -584, -272, 35};