/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0270 256 samples */
 
const int16_t AKWF_0270_256_DATA [256] = 
{1141, 3564, 6401, 9944, 14089, 18292, 21534, 23514, 24229, 24229, 24547, 25591, 27470, 29655, 31535, 32588, 32739, 32154, 31143, 29916, 28492, 26794, 24767, 22495, 20238, 18259, 16672, 15361, 14007, 12254, 9917, 7064, 4016, 1275, -760, -1977, -2562, -2898, -3355, -4149, -5263, -6496, -7568, -8258, -8473, -8284, -7863, -7383, -6953, -6593, -6266, -5925, -5540, -5108, -4638, -4146, -3642, -3135, -2631, -2155, -1755, -1511, -1543, -1965, -2755, -3574, -4057, -4147, -4029, -4126, -4473, -5065, -6067, -7337, -8937, -10623, -12245, -13662, -14879, -15831, -16483, -16833, -16933, -16893, -16794, -16663, -16467, -16132, -15585, -14767, -13658, -12297, -10777, -9223, -7779, -6546, -5562, -4758, -4030, -3339, -2734, -2282, -2028, -1984, -2153, -2537, -3134, -3927, -4862, -5844, -6780, -7587, -8219, -8681, -9003, -9219, -9353, -9395, -9303, -9015, -8495, -7746, -6723, -5390, -3741, -1825, 232, 2262, 3971, 5165, 5585, 6118, 7166, 8654, 10589, 12411, 13768, 14329, 13947, 12630, 10831, 9003, 7470, 6354, 5620, 5206, 5059, 5110, 5271, 5408, 5402, 5185, 4780, 4321, 4017, 4086, 4638, 5624, 6815, 7894, 8599, 8875, 8839, 8679, 8556, 8542, 8604, 8630, 8499, 8135, 7553, 6830, 6074, 5359, 4706, 4116, 3598, 3177, 2882, 2721, 2676, 2720, 2834, 3029, 3337, 3805, 4472, 5332, 6344, 7361, 8178, 8502, 8428, 8547, 9266, 10570, 11960, 12805, 13037, 12776, 11962, 10833, 9355, 7767, 6157, 4587, 3002, 1494, 152, -988, -1999, -3038, -4236, -5598, -7019, -8333, -9377, -10057, -10374, -10422, -10350, -10312, -10411, -10684, -11093, -11512, -11829, -12037, -12210, -12449, -12812, -13308, -13928, -14669, -15514, -16451, -17421, -18345, -19145, -19757, -20151, -20345, -20368, -20250, -19999, -19597, -18997, -18135, -16960, -15446, -13586, -11420, -8985, -6358, -3682, -1110};