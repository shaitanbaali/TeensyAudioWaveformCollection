/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0294 256 samples */
 
const int16_t AKWF_0294_256_DATA [256] = 
{6, 20, 33, 79, 202, -883, 18443, 33287, 19837, 1445, -13624, -21602, -21031, -13215, -1693, 9083, 15398, 15553, 10220, 1986, -5835, -10437, -10519, -6580, -549, 5094, 8285, 8066, 4846, 79, -4356, -6909, -6880, -4584, -1126, 2091, 3899, 3783, 1984, -658, -3093, -4454, -4355, -2990, -991, 845, 1873, 1809, 803, -670, -2012, -2740, -2646, -1844, -698, 346, 925, 885, 316, -509, -1252, -1644, -1572, -1105, -449, 140, 464, 437, 115, -348, -761, -972, -922, -652, -279, 54, 234, 215, 32, -228, -457, -571, -538, -382, -169, 18, 117, 105, 2, -145, -273, -334, -313, -223, -102, 3, 58, 50, -9, -91, -162, -196, -181, -130, -61, -2, 28, 23, -10, -56, -96, -114, -105, -76, -37, -3, 13, 10, -9, -34, -56, -67, -61, -44, -22, -4, 5, 3, -7, -21, -34, -80, -203, 882, -18443, -33287, -19837, -1446, 13623, 21602, 21030, 13214, 1693, -9084, -15398, -15554, -10221, -1987, 5835, 10437, 10518, 6580, 548, -5094, -8286, -8067, -4846, -80, 4355, 6908, 6880, 4583, 1125, -2092, -3900, -3784, -1985, 657, 3093, 4453, 4354, 2989, 990, -846, -1874, -1810, -804, 669, 2012, 2739, 2645, 1843, 697, -347, -926, -886, -317, 508, 1251, 1643, 1571, 1104, 448, -141, -465, -438, -116, 347, 760, 971, 921, 651, 278, -55, -235, -216, -33, 227, 456, 570, 537, 381, 168, -19, -118, -106, -3, 144, 272, 333, 312, 222, 101, -4, -59, -51, 8, 90, 161, 195, 180, 129, 60, 1, -29, -24, 9, 55, 95, 113, 104, 75, 36, 2, -14, -11, 8, 33, 55, 66, 60, 43, 21, 3, -6, -4};