/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0252 256 samples */
 
const int16_t AKWF_0252_256_DATA [256] = 
{915, 2305, 3678, 5063, 6450, 7826, 9156, 10420, 11629, 12782, 13879, 14928, 15929, 16881, 17791, 18658, 19484, 20274, 21027, 21743, 22428, 23082, 23703, 24297, 24864, 25404, 25920, 26410, 26879, 27327, 27752, 28158, 28547, 28916, 29269, 29606, 29926, 30232, 30525, 30802, 31068, 31321, 31563, 31793, 32013, 32221, 32422, 32599, 32716, 32764, 32743, 32653, 32493, 32265, 31971, 31609, 31182, 30692, 30137, 29522, 28849, 28118, 27334, 26499, 25613, 24683, 23710, 22695, 21646, 20563, 19449, 18312, 17151, 15971, 14779, 13573, 12360, 11147, 9930, 8716, 7511, 6311, 5125, 3956, 2802, 1668, 560, -525, -1582, -2608, -3605, -4568, -5495, -6388, -7241, -8055, -8830, -9562, -10252, -10899, -11501, -12059, -12571, -13035, -13455, -13828, -14154, -14436, -14683, -14896, -15077, -15226, -15345, -15439, -15511, -15562, -15596, -15614, -15620, -15611, -15593, -15566, -15531, -15490, -15442, -15390, -15333, -15274, -15212, -15147, -15082, -15014, -14947, -14878, -14808, -14738, -14667, -14595, -14523, -14449, -14375, -14299, -14223, -14144, -14066, -13985, -13904, -13821, -13738, -13653, -13567, -13482, -13396, -13310, -13225, -13141, -13059, -12979, -12903, -12829, -12759, -12695, -12636, -12582, -12536, -12497, -12466, -12446, -12434, -12432, -12440, -12460, -12492, -12537, -12596, -12668, -12753, -12852, -12967, -13095, -13240, -13398, -13571, -13760, -13961, -14178, -14407, -14650, -14906, -15174, -15453, -15743, -16043, -16351, -16667, -16992, -17320, -17654, -17992, -18331, -18672, -19013, -19351, -19688, -20020, -20345, -20665, -20977, -21277, -21568, -21845, -22108, -22357, -22589, -22802, -22996, -23169, -23319, -23446, -23548, -23622, -23667, -23683, -23666, -23616, -23531, -23410, -23249, -23048, -22806, -22520, -22190, -21815, -21392, -20923, -20404, -19835, -19218, -18550, -17833, -17067, -16251, -15386, -14475, -13514, -12508, -11461, -10369, -9238, -8071, -6866, -5630, -4367, -3075, -1765, -405};