/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0287 256 samples */
 
const int16_t AKWF_0287_256_DATA [256] = 
{5199, 16517, 29101, 29383, 21201, 12332, 7618, -4956, -27495, -28280, -19135, -14205, -11558, -6995, 7759, 21858, 18118, 12659, 10806, 8471, 4862, -1426, -11756, -12675, -8512, -5862, -2167, 6647, 9308, 6705, 5256, 4691, 3703, 2278, 1044, -1454, -6073, -5827, -1367, 3489, 3800, 2881, 2640, 2452, 2125, 1790, 1469, 1025, 626, 417, 432, 534, 728, 954, 859, 761, 750, 712, 656, 818, -12815, -31419, -26826, -7366, 5227, 16101, 28513, 28870, 20870, 12122, 7491, -4991, -27553, -28387, -19241, -14291, -11621, -7063, 7711, 21740, 17912, 12435, 10577, 8239, 4592, -1520, -11805, -13117, -8976, -6261, -2477, 6404, 8831, 6146, 4690, 4186, 3197, 1821, 449, -1537, -5751, -6284, -479, 3155, 2496, 1846, 1975, 1913, 1464, 1110, 818, 414, 52, -119, -224, 26, 378, 336, 443, 573, 406, 63, 32, 532, -13151, -32005, -27344, -7794, 4869, 15689, 28080, 28483, 20503, 11758, 7143, -5322, -27871, -28696, -19535, -14565, -11893, -7328, 7459, 21499, 17680, 12213, 10364, 8036, 4398, -1705, -11981, -13284, -9135, -6413, -2619, 6271, 8704, 6026, 4578, 4083, 3096, 1742, 441, -1623, -5815, -6118, -543, 2997, 2418, 1805, 1925, 1866, 1430, 1082, 792, 396, 32, -17, -149, 101, 364, 286, 438, 574, 482, 206, 96, 205, -8, -151, -27, 41, 35, 33, 45, 55, 43, -283, -423, -260, -186, -193, -192, -177, -173, -173, -172, -162, -193, -674, -840, -606, -508, -514, -503, -475, -461, -451, -435, -420, -412, -407, -403, -400, -397, -395, -393, -391, -390, -387, -385, -383, -380, -377, -392, -300, -785, -2679, -2621, -1757, -1510, -1508, -1397, -1262, -1181, -1102, -1004, -918, -860, -845, -865, -406, -11442, -28882, -25525, -6860};