/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0262 256 samples */
 
const int16_t AKWF_0262_256_DATA [256] = 
{13750, 13753, 13754, 13754, 13755, 13755, 13755, 13755, 13755, 13755, 13754, 13754, 13752, 13665, 14147, 11984, 5367, 5764, 5697, 5692, 5690, 5689, 5687, 5685, 5683, 5680, 5678, 5676, 5674, 5769, 5249, 7914, 13911, 13674, 13696, 13707, 13703, 13702, 13699, 13696, 13694, 13691, 13689, 13687, 13683, 13595, 14077, 11912, 5294, 5690, 5621, 5617, 5614, 5611, 5610, 5606, 5604, 5602, 5599, 5596, 5594, 5689, 5169, 7833, 13830, 13594, 13641, 13618, 13509, 29907, 33245, 32441, 32583, 32577, 32573, 32569, 32563, 32472, 32950, 30782, 24161, 24553, 24481, 24473, 24466, 24459, 24453, 24446, 24440, 24432, 24426, 24419, 24411, 24502, 23977, 26637, 32629, 32388, 32404, 32410, 32403, 32395, 32388, 32380, 32373, 32365, 32358, 32351, 32342, 32250, 32726, 30557, 23934, 24324, 24252, 24241, 24233, 24227, 24219, 24211, 24204, 24196, 24189, 24181, 24173, 24030, 24645, 23116, -21246, -25673, -24514, -24739, -24740, -24741, -24743, -24742, -24741, -24740, -24738, -24735, -24732, -24814, -24327, -26484, -33095, -32692, -32752, -32750, -32744, -32737, -32732, -32727, -32720, -32713, -32707, -32701, -32694, -32590, -33100, -30426, -24419, -24647, -24616, -24596, -24589, -24581, -24574, -24567, -24560, -24552, -24545, -24538, -24529, -24609, -24118, -26271, -32880, -32474, -32531, -32527, -32519, -32511, -32504, -32496, -32488, -32211, -33693, -19281, -12292, -13647, -13894, -11220, -5215, -5445, -5416, -5398, -5394, -5389, -5384, -5380, -5376, -5373, -5369, -5365, -5361, -5445, -4957, -7116, -13728, -13327, -13389, -13389, -13385, -13383, -13380, -13377, -13374, -13372, -13368, -13366, -13363, -13263, -13778, -11107, -5106, -5337, -5311, -5295, -5293, -5290, -5287, -5285, -5283, -5280, -5277, -5275, -5273, -5356, -4870, -7029, -13641, -13241, -13304, -13304, -13301, -13299, -13296, -13294, -13291, -13288, -13286, -13284, -13281, -13194, -13645, -11210};