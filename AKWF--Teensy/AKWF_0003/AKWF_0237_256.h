/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0237 256 samples */
 
const int16_t AKWF_0237_256_DATA [256] = 
{470, 1262, 2042, 2825, 3608, 4393, 5179, 5962, 6745, 7528, 8307, 9084, 9858, 10625, 11389, 12149, 12900, 13645, 14382, 15109, 15830, 16539, 17238, 17927, 18603, 19266, 19917, 20553, 21173, 21781, 22372, 22946, 23507, 24049, 24574, 25085, 25577, 26052, 26511, 26951, 27374, 27781, 28170, 28542, 28897, 29234, 29556, 29860, 30148, 30420, 30675, 30914, 31135, 31339, 31525, 31693, 31844, 31975, 32087, 32179, 32251, 32302, 32331, 32338, 32324, 32287, 32225, 32141, 32033, 31901, 31745, 31564, 31361, 31135, 30889, 30622, 30334, 30030, 29706, 29366, 29011, 28639, 28253, 27853, 27439, 27012, 26573, 26119, 25653, 25176, 24686, 24184, 23670, 23143, 22606, 22056, 21492, 20918, 20332, 19733, 19123, 18501, 17867, 17224, 16569, 15903, 15229, 14545, 13852, 13153, 12444, 11729, 11010, 10285, 9555, 8823, 8085, 7347, 6607, 5864, 5122, 4382, 3640, 2900, 2163, 1426, 693, -36, -764, -1487, -2205, -2921, -3631, -4338, -5042, -5740, -6436, -7129, -7816, -8500, -9182, -9859, -10535, -11207, -11874, -12540, -13203, -13862, -14518, -15172, -15820, -16466, -17107, -17741, -18373, -18999, -19619, -20233, -20840, -21439, -22032, -22615, -23189, -23755, -24308, -24851, -25383, -25901, -26407, -26898, -27372, -27832, -28277, -28701, -29109, -29499, -29867, -30217, -30546, -30852, -31139, -31402, -31644, -31862, -32057, -32229, -32377, -32501, -32602, -32679, -32732, -32762, -32767, -32748, -32706, -32641, -32552, -32441, -32306, -32151, -31973, -31774, -31554, -31314, -31052, -30772, -30473, -30154, -29817, -29460, -29087, -28697, -28288, -27863, -27423, -26964, -26491, -26004, -25501, -24983, -24453, -23908, -23350, -22780, -22196, -21602, -20996, -20378, -19751, -19113, -18464, -17809, -17143, -16469, -15789, -15100, -14404, -13703, -12994, -12280, -11562, -10838, -10111, -9379, -8642, -7901, -7157, -6408, -5656, -4902, -4141, -3379, -2614, -1845, -1076, -287};