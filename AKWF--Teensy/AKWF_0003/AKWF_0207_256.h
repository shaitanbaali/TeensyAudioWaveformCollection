/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0207 256 samples */
 
const int16_t AKWF_0207_256_DATA [256] = 
{159, 562, 1070, 1688, 2405, 3208, 4083, 5010, 5973, 6945, 7903, 8834, 9725, 10563, 11335, 12021, 12602, 13062, 13390, 13579, 13637, 13572, 13400, 13136, 12796, 12392, 11932, 11430, 10896, 10344, 9794, 9258, 8750, 8280, 7852, 7469, 7132, 6848, 6617, 6445, 6334, 6290, 6307, 6376, 6490, 6639, 6817, 7016, 7229, 7454, 7690, 7930, 8169, 8394, 8589, 8739, 8829, 8856, 8829, 8762, 8666, 8551, 8432, 8326, 8247, 8206, 8209, 8254, 8335, 8440, 8557, 8669, 8766, 8836, 8873, 8874, 8834, 8754, 8629, 8456, 8230, 7948, 7617, 7245, 6841, 6420, 5997, 5584, 5194, 4835, 4510, 4221, 3967, 3746, 3567, 3435, 3353, 3320, 3335, 3391, 3482, 3602, 3746, 3914, 4104, 4302, 4496, 4671, 4810, 4900, 4936, 4910, 4824, 4674, 4456, 4172, 3815, 3383, 2875, 2292, 1647, 956, 241, -467, -1132, -1725, -2211, -2559, -2740, -2732, -2525, -2119, -1520, -739, 207, 1297, 2508, 3811, 5174, 6578, 8002, 9421, 10816, 12154, 13401, 14532, 15523, 16358, 17036, 17555, 17922, 18148, 18242, 18212, 18065, 17809, 17455, 17015, 16507, 15948, 15347, 14717, 14064, 13387, 12697, 11996, 11289, 10583, 9883, 9191, 8511, 7831, 7145, 6451, 5738, 4999, 4231, 3429, 2593, 1718, 795, -188, -1242, -2391, -3642, -4997, -6447, -7971, -9552, -11172, -12804, -14421, -16004, -17526, -18970, -20334, -21607, -22792, -23895, -24919, -25871, -26755, -27569, -28316, -28996, -29608, -30157, -30652, -31095, -31496, -31852, -32159, -32412, -32603, -32725, -32768, -32729, -32603, -32389, -32090, -31706, -31230, -30659, -29985, -29200, -28310, -27319, -26230, -25056, -23805, -22481, -21096, -19652, -18166, -16663, -15155, -13667, -12222, -10825, -9490, -8227, -7039, -5935, -4926, -4016, -3219, -2540, -1981, -1540, -1208, -964, -786, -645, -511, -355, -132};