/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0264 256 samples */
 
const int16_t AKWF_0264_256_DATA [256] = 
{-399, -1471, -2490, -3486, -4453, -5395, -6311, -7197, -8055, -8884, -9681, -10450, -11187, -11893, -12568, -13214, -13825, -14408, -14957, -15475, -15962, -16418, -16834, -17239, -17581, -15695, -14905, -15111, -14099, -13547, -13747, -14236, -14691, -15013, -15231, -15400, -15551, -15694, -15822, -15928, -16009, -16067, -16100, -16114, -16106, -16077, -16029, -15962, -15875, -15769, -15645, -15505, -15346, -15172, -14982, -14777, -14559, -14325, -14122, -13701, -14139, -20981, -22583, -23100, -26540, -28038, -27410, -26040, -24766, -23799, -23024, -22292, -21516, -20689, -19835, -18971, -18106, -17244, -16379, -15510, -14644, -13775, -12906, -12043, -11182, -10326, -9476, -8632, -7796, -6969, -6149, -5342, -4585, -3721, -3161, -12168, -15803, -15485, -20212, -22709, -21885, -19753, -17686, -16095, -14849, -13712, -12551, -11337, -10100, -8873, -7667, -6485, -5328, -4186, -3063, -1963, -881, 176, 1208, 2218, 3202, 4157, 5090, 5994, 6869, 7718, 8535, 9323, 10084, 10814, 11514, 12183, 12821, 13406, 14043, 14380, 10063, 8671, 8820, 6598, 5524, 5998, 7045, 8023, 8750, 9295, 9769, 10238, 10713, 11180, 11624, 12041, 12429, 12790, 13128, 13441, 13730, 13995, 14237, 14454, 14649, 14819, 14967, 15093, 15196, 15278, 15337, 15376, 15393, 15394, 15256, 15143, 15083, 14936, 14794, 14679, 14567, 14438, 14288, 14119, 13934, 13735, 13524, 13300, 13064, 12818, 12559, 12289, 12011, 11722, 11425, 11120, 10808, 10488, 10163, 9830, 9493, 9153, 8805, 8455, 8103, 7763, 7502, 6484, 15254, 23356, 22483, 27928, 32352, 32523, 30603, 28489, 26879, 25720, 24732, 23713, 22615, 21463, 20293, 19132, 17982, 16836, 15696, 14562, 13430, 12306, 11193, 10087, 8995, 7916, 6848, 5799, 4764, 3744, 2745, 1763, 800, -141, -1062, -1961, -2836, -3690, -4507, -5265, -6405, -964, 3396, 2431, 5592, 7913, 7544, 5918, 4225, 2889, 1863, 946};