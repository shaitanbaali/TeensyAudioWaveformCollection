/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0215 256 samples */
 
const int16_t AKWF_0215_256_DATA [256] = 
{12717, 13074, 13422, 13771, 14122, 14471, 14821, 15170, 15520, 15871, 16219, 16569, 16920, 17269, 17619, 17969, 18319, 18668, 19018, 19368, 19717, 20067, 20417, 20767, 21117, 21465, 21816, 22166, 22514, 22866, 23215, 23564, 23915, 24263, 24614, 24964, 25313, 25663, 26013, 26363, 26712, 27063, 27412, 27761, 28112, 28461, 28811, 29161, 29510, 29861, 30210, 30559, 30910, 31259, 31609, 31957, 32303, 32678, 32350, 31634, 30982, 30316, 29652, 28986, 28321, 27656, 26992, 26326, 25661, 24997, 24330, 23666, 23002, 22335, 21671, 21006, 20340, 19677, 19011, 18346, 17681, 17016, 16351, 15686, 15021, 14263, 14108, 11340, -21, -18, 21, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -79, 360, -1566, -8409, -8365, -8661, -8918, -9172, -9425, -9677, -9929, -10182, -10434, -10687, -10940, -11192, -11445, -11699, -11952, -12204, -12457, -12709, -12962, -13215, -13467, -13720, -13972, -14226, -14479, -14732, -14984, -15237, -15489, -15742, -15995, -16247, -16500, -16754, -17006, -17259, -17512, -17764, -18017, -18269, -18521, -18774, -19027, -19281, -19534, -19787, -20039, -20291, -20542, -20804, -20737, -20492, -20276, -20055, -19833, -19612, -19391, -19169, -18949, -18727, -18506, -18286, -18063, -17844, -17622, -17400, -17181, -16959, -16737, -16516, -16294, -16074, -15853, -15631, -15411, -15189, -14968, -14747, -14526, -14305, -14083, -13863, -13641, -13419, -13199, -12978, -12756, -12536, -12314, -12093, -11873, -11650, -11430, -11209, -10987, -10768, -10545, -10323, -10103, -9881, -9661, -9440, -9218, -8998, -8776, -8424, -8918, -5022, 616, -141, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};