/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0269 256 samples */
 
const int16_t AKWF_0269_256_DATA [256] = 
{942, 2810, 4895, 7121, 9375, 11579, 13687, 15680, 17571, 19380, 21124, 22832, 24511, 26141, 27694, 29116, 30351, 31351, 32065, 32448, 32441, 31960, 30956, 29505, 27687, 25523, 23007, 20243, 17432, 14754, 12187, 9698, 7294, 5049, 2956, 859, -1397, -3896, -6590, -9385, -12234, -15085, -17840, -20389, -22615, -24462, -25949, -27121, -28035, -28757, -29351, -29883, -30411, -30960, -31525, -32058, -32486, -32736, -32739, -32430, -31747, -30652, -29157, -27299, -25119, -22678, -20028, -17232, -14373, -11489, -8607, -5741, -2874, -2, 2865, 5738, 8601, 11426, 14187, 16827, 19276, 21483, 23394, 24971, 26188, 26991, 27342, 27279, 26876, 26194, 25309, 24296, 23193, 22050, 20937, 19765, 18513, 17097, 15457, 13560, 11389, 8948, 6289, 3547, 874, -1564, -3656, -5405, -6881, -8187, -9431, -10680, -11967, -13304, -14660, -15967, -17149, -18124, -18833, -19230, -19281, -18979, -18334, -17370, -16123, -14647, -13025, -11331, -9616, -7909, -6212, -4519, -2836, -1149, 552, 2273, 4025, 5802, 7584, 9365, 11116, 12802, 14400, 15874, 17206, 18395, 19433, 20316, 21030, 21537, 21798, 21820, 21639, 21240, 20588, 19695, 18652, 17586, 16468, 15293, 14070, 12854, 11661, 10403, 8979, 7317, 5434, 3370, 1151, -1184, -3552, -5858, -7993, -9889, -11542, -12968, -14201, -15296, -16311, -17310, -18357, -19485, -20702, -21984, -23270, -24499, -25615, -26540, -27199, -27533, -27520, -27167, -26494, -25528, -24307, -22882, -21320, -19660, -17926, -16126, -14247, -12282, -10235, -8100, -5885, -3620, -1336, 893, 2991, 4908, 6590, 7993, 9102, 9921, 10458, 10684, 10552, 10137, 9578, 8764, 7742, 6592, 5461, 4442, 3540, 2754, 2129, 1715, 1461, 1224, 869, 336, -375, -1223, -2138, -3017, -3731, -4159, -4232, -3956, -3401, -2672, -1889, -1172, -623, -324, -310, -562, -1005, -1549, -2085, -2482, -2607, -2358, -1682, -532};