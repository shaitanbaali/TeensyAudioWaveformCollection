/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0222 256 samples */
 
const int16_t AKWF_0222_256_DATA [256] = 
{300, 745, 1134, 1478, 1777, 2034, 2251, 2429, 2571, 2683, 2765, 2822, 2858, 2877, 2885, 2882, 2874, 2864, 2857, 2853, 2859, 2874, 2902, 2946, 3007, 3085, 3182, 3300, 3439, 3598, 3779, 3980, 4202, 4444, 4707, 4988, 5288, 5605, 5940, 6291, 6657, 7038, 7434, 7843, 8267, 8702, 9152, 9613, 10086, 10572, 11071, 11581, 12103, 12638, 13185, 13744, 14314, 14896, 15490, 16095, 16710, 17337, 17972, 18614, 19266, 19923, 20586, 21252, 21921, 22590, 23258, 23921, 24580, 25232, 25872, 26501, 27115, 27710, 28286, 28840, 29367, 29867, 30336, 30771, 31171, 31532, 31850, 32126, 32356, 32536, 32667, 32745, 32767, 32735, 32643, 32491, 32280, 32006, 31669, 31269, 30805, 30275, 29680, 29023, 28299, 27512, 26665, 25755, 24785, 23760, 22678, 21544, 20366, 19139, 17872, 16574, 15242, 13885, 12512, 11123, 9727, 8334, 6943, 5565, 4208, 2872, 1568, 300, -930, -2111, -3245, -4329, -5354, -6324, -7236, -8086, -8878, -9611, -10284, -10902, -11465, -11974, -12435, -12850, -13219, -13551, -13845, -14106, -14339, -14545, -14729, -14895, -15043, -15179, -15304, -15421, -15531, -15635, -15737, -15836, -15934, -16031, -16128, -16226, -16323, -16420, -16518, -16615, -16712, -16807, -16903, -16997, -17089, -17180, -17268, -17355, -17439, -17523, -17604, -17683, -17762, -17841, -17919, -17998, -18077, -18159, -18243, -18329, -18418, -18512, -18609, -18712, -18819, -18931, -19049, -19171, -19299, -19430, -19566, -19705, -19848, -19992, -20135, -20280, -20422, -20561, -20695, -20824, -20944, -21055, -21155, -21240, -21311, -21365, -21399, -21413, -21402, -21369, -21308, -21218, -21099, -20948, -20764, -20545, -20290, -19999, -19669, -19300, -18893, -18446, -17959, -17434, -16870, -16267, -15630, -14959, -14256, -13525, -12767, -11986, -11190, -10377, -9555, -8730, -7904, -7083, -6274, -5478, -4703, -3954, -3231, -2543, -1892, -1279, -710, -175};