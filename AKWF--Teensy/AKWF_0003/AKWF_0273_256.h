/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0273 256 samples */
 
const int16_t AKWF_0273_256_DATA [256] = 
{1558, 4264, 6849, 9359, 11765, 14047, 16184, 18154, 19962, 21604, 23081, 24398, 25554, 26539, 27353, 27984, 28418, 28650, 28672, 28472, 28037, 27366, 26451, 25293, 23928, 22360, 20616, 18716, 16670, 14492, 12216, 9870, 7483, 5098, 2731, 422, -1806, -3917, -5912, -7777, -9507, -11112, -12558, -13827, -14904, -15765, -16414, -16849, -17056, -17021, -16735, -16200, -15424, -14417, -13186, -11723, -10045, -8175, -6132, -3955, -1662, 735, 3192, 5662, 8086, 10395, 12555, 14547, 16349, 17950, 19322, 20419, 21220, 21721, 21937, 21904, 21653, 21207, 20575, 19754, 18748, 17558, 16202, 14692, 13031, 11231, 9306, 7276, 5142, 2918, 602, -1775, -4178, -6583, -8956, -11287, -13567, -15785, -17919, -19971, -21905, -23722, -25416, -26956, -28349, -29570, -30602, -31444, -32080, -32511, -32735, -32748, -32544, -32124, -31501, -30684, -29674, -28469, -27070, -25476, -23714, -21808, -19767, -17609, -15348, -12994, -10584, -8140, -5684, -3245, -832, 1551, 3880, 6157, 8371, 10504, 12557, 14516, 16366, 18103, 19715, 21181, 22497, 23650, 24623, 25414, 25990, 26348, 26512, 26442, 26150, 25636, 24905, 23983, 22884, 21628, 20237, 18735, 17127, 15445, 13660, 11812, 9884, 7882, 5844, 3768, 1686, -368, -2380, -4313, -6126, -7795, -9279, -10537, -11551, -12296, -12760, -12932, -12805, -12388, -11703, -10775, -9623, -8260, -6714, -5018, -3210, -1333, 587, 2534, 4480, 6404, 8279, 10067, 11747, 13300, 14707, 15967, 17074, 18015, 18785, 19369, 19753, 19935, 19911, 19687, 19266, 18647, 17823, 16802, 15580, 14146, 12482, 10592, 8506, 6265, 3899, 1438, -1106, -3695, -6283, -8850, -11356, -13790, -16142, -18382, -20485, -22444, -24222, -25830, -27275, -28548, -29661, -30600, -31351, -31909, -32268, -32423, -32365, -32076, -31546, -30767, -29752, -28520, -27073, -25415, -23549, -21490, -19279, -16945, -14495, -11946, -9309, -6600, -3867, -1081};