/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0249 256 samples */
 
const int16_t AKWF_0249_256_DATA [256] = 
{272, 882, 1481, 2073, 2654, 3216, 3771, 4345, 4966, 5642, 6366, 7131, 7924, 8730, 9548, 10372, 11202, 12049, 12916, 13810, 14742, 15712, 16723, 17776, 18863, 19974, 21102, 22228, 23339, 24425, 25466, 26453, 27374, 28213, 28965, 29623, 30182, 30646, 31016, 31297, 31496, 31620, 31676, 31673, 31619, 31525, 31399, 31255, 31101, 30932, 30737, 30509, 30252, 29975, 29690, 29401, 29119, 28846, 28582, 28323, 28066, 27802, 27525, 27228, 26899, 26535, 26128, 25673, 25168, 24611, 24002, 23345, 22643, 21898, 21122, 20317, 19491, 18657, 17816, 16979, 16155, 15347, 14566, 13816, 13098, 12419, 11777, 11170, 10600, 10061, 9546, 9054, 8578, 8107, 7639, 7168, 6703, 6262, 5852, 5470, 5111, 4764, 4421, 4078, 3732, 3383, 3035, 2691, 2354, 2026, 1711, 1410, 1124, 855, 605, 376, 167, -19, -186, -334, -468, -591, -710, -827, -949, -1079, -1223, -1381, -1557, -1754, -1974, -2219, -2488, -2783, -3104, -3448, -3813, -4197, -4595, -5003, -5417, -5831, -6247, -6675, -7136, -7637, -8177, -8746, -9335, -9933, -10526, -11111, -11680, -12233, -12775, -13302, -13820, -14336, -14850, -15368, -15894, -16429, -16977, -17540, -18117, -18711, -19319, -19941, -20586, -21256, -21950, -22666, -23401, -24147, -24902, -25662, -26417, -27169, -27908, -28625, -29318, -29975, -30589, -31155, -31663, -32108, -32461, -32684, -32764, -32701, -32510, -32210, -31823, -31372, -30874, -30342, -29788, -29220, -28641, -28057, -27470, -26883, -26299, -25716, -25137, -24561, -23982, -23401, -22813, -22212, -21597, -20962, -20299, -19610, -18891, -18135, -17345, -16520, -15656, -14759, -13830, -12871, -11893, -10900, -9917, -8993, -8158, -7427, -6806, -6290, -5869, -5536, -5279, -5088, -4952, -4861, -4805, -4773, -4759, -4749, -4738, -4717, -4677, -4612, -4513, -4373, -4188, -3951, -3660, -3314, -2915, -2468, -1976, -1448, -893, -303};