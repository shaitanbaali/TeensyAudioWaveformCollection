/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0203 256 samples */
 
const int16_t AKWF_0203_256_DATA [256] = 
{935, 2506, 4080, 5683, 7303, 8934, 10569, 12196, 13811, 15407, 16970, 18499, 19985, 21417, 22794, 24105, 25342, 26505, 27583, 28569, 29464, 30259, 30949, 31535, 32010, 32371, 32618, 32748, 32760, 32655, 32430, 32090, 31632, 31060, 30376, 29582, 28682, 27680, 26579, 25388, 24106, 22741, 21304, 19795, 18221, 16596, 14919, 13199, 11451, 9673, 7877, 6076, 4269, 2469, 687, -1077, -2809, -4501, -6153, -7722, -9327, -10413, -6811, -1664, 2263, 5463, 7992, 9943, 11382, 12383, 13000, 13278, 13261, 12982, 12476, 11765, 10875, 9831, 8646, 7339, 5932, 4431, 2855, 1219, -473, -2202, -3956, -5731, -7512, -9286, -11053, -12795, -14504, -16178, -17802, -19368, -20875, -22309, -23665, -24941, -26126, -27215, -28208, -29095, -29875, -30545, -31100, -31541, -31864, -32069, -32155, -32122, -31971, -31703, -31319, -30824, -30218, -29506, -28693, -27779, -26773, -25680, -24503, -23250, -21929, -20542, -19101, -17612, -16077, -14513, -12921, -11308, -9690, -8067, -6448, -4845, -3262, -1705, -188, 1288, 2715, 4082, 5390, 6628, 7790, 8874, 9875, 10785, 11605, 12328, 12953, 13479, 13903, 14222, 14439, 14551, 14560, 14468, 14275, 13983, 13596, 13117, 12549, 11895, 11163, 10355, 9477, 8536, 7536, 6484, 5390, 4257, 3091, 1906, 701, -513, -1725, -2934, -4129, -5299, -6445, -7555, -8620, -9638, -10601, -11500, -12333, -13094, -13775, -14375, -14888, -15303, -15620, -15904, -13601, -9333, -5875, -2972, -560, 1407, 2995, 4246, 5197, 5886, 6342, 6590, 6651, 6547, 6296, 5912, 5412, 4810, 4115, 3342, 2504, 1606, 663, -315, -1323, -2346, -3377, -4411, -5433, -6439, -7422, -8370, -9279, -10143, -10950, -11699, -12383, -12994, -13529, -13983, -14352, -14632, -14820, -14913, -14909, -14806, -14604, -14302, -13899, -13398, -12797, -12100, -11309, -10426, -9454, -8400, -7262, -6050, -4769, -3421, -2019, -533};