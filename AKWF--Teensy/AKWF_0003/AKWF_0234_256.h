/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0234 256 samples */
 
const int16_t AKWF_0234_256_DATA [256] = 
{915, 2557, 4269, 6046, 7788, 9499, 11177, 12802, 14365, 15829, 17171, 18402, 19514, 20504, 21418, 22297, 23168, 24047, 24936, 25814, 26622, 27417, 28167, 28864, 29517, 30136, 30717, 31228, 31638, 31926, 32063, 32211, 32281, 32282, 32407, 32544, 32666, 32748, 32766, 32715, 32610, 32466, 32265, 32263, 32079, 31660, 31291, 30823, 30271, 29683, 29083, 28473, 27830, 27137, 26386, 25589, 24750, 23873, 23027, 22177, 21301, 20391, 19453, 18501, 17568, 16689, 15886, 15159, 14499, 13884, 13301, 12752, 12247, 11802, 11427, 11105, 10808, 10511, 10196, 9863, 9522, 9181, 8938, 8354, 6739, 6771, 6370, 5683, 5215, 4847, 4492, 4119, 3726, 3303, 2843, 2322, 1886, 1369, 887, 453, 67, -424, -1029, -1060, -1383, -1683, -1904, -2069, -2206, -2341, -2491, -2653, -2807, -2934, -3056, -2933, -2857, -3013, -3061, -3161, -3321, -3514, -3692, -3859, -4112, -4424, -4794, -5328, -5879, -6251, -6560, -6798, -6985, -7142, -7284, -7427, -7580, -7772, -8019, -8314, -8670, -9079, -9506, -9905, -10246, -10520, -10725, -10879, -10975, -11103, -11239, -11369, -11494, -11607, -11704, -11794, -11908, -12085, -12356, -12573, -12834, -13292, -13643, -13961, -14254, -14502, -14696, -14832, -14904, -14908, -14844, -14728, -14589, -14454, -14337, -14238, -14143, -14032, -13899, -13748, -13597, -13470, -13379, -13328, -13263, -13209, -13170, -13122, -13091, -13091, -13123, -13175, -13213, -13205, -13130, -12986, -12788, -12556, -12303, -12031, -11729, -11382, -10982, -10543, -10098, -9675, -9271, -9062, -9027, -8915, -8910, -9468, -10016, -10647, -11592, -12653, -13779, -14956, -16181, -17450, -18762, -20115, -21437, -22779, -24090, -25206, -26202, -27029, -27719, -27935, -28339, -28753, -28720, -28553, -28231, -27762, -27170, -26475, -25692, -24821, -23851, -22761, -21551, -20234, -18829, -17370, -15879, -14354, -12793, -11181, -9566, -7902, -6203, -4518, -2826, -973};