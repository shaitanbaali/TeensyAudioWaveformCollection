/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0248 256 samples */
 
const int16_t AKWF_0248_256_DATA [256] = 
{613, 1577, 2788, 3856, 4574, 5295, 6055, 6799, 7517, 8291, 9005, 9754, 10507, 11218, 11990, 12714, 13425, 14347, 15070, 15538, 16017, 16523, 17012, 17494, 17996, 18512, 19252, 20022, 20454, 20685, 21125, 21644, 22121, 22604, 23121, 23508, 23751, 23992, 24232, 24472, 24761, 25260, 25759, 26072, 26334, 26657, 26907, 27126, 27152, 27127, 27218, 27477, 27712, 27949, 28197, 28425, 28677, 28955, 28982, 28956, 29088, 29356, 29560, 29573, 29561, 29555, 29547, 29540, 29535, 29515, 29590, 29853, 30119, 30130, 30117, 30111, 30103, 30095, 30087, 30080, 30072, 30064, 30056, 30048, 30040, 30032, 30023, 30015, 30008, 30001, 29990, 29991, 29936, 29684, 29414, 29310, 29314, 29304, 29297, 29289, 29281, 29273, 29264, 29256, 29250, 29060, 28776, 28593, 28585, 28578, 28567, 28572, 28438, 28157, 27930, 27889, 27914, 27703, 27168, 26666, 25566, 24306, 22826, 20508, 18296, 15843, 12651, 9232, 6769, 4252, 846, -2745, -5715, -8517, -11159, -13433, -15752, -17620, -19132, -21071, -22436, -23654, -24698, -25723, -26635, -27393, -28151, -28730, -29233, -29694, -29952, -30253, -30552, -30791, -31024, -31272, -31512, -31745, -32004, -32185, -32182, -32173, -32169, -32155, -32177, -32395, -32697, -32774, -32750, -32746, -32737, -32729, -32722, -32713, -32704, -32696, -32688, -32679, -32671, -32663, -32654, -32646, -32634, -32639, -32529, -32252, -32009, -31956, -31955, -31945, -31935, -31930, -31756, -31437, -31252, -31270, -31228, -30988, -30724, -30481, -30212, -29975, -29931, -29942, -29842, -29570, -29231, -28954, -28703, -28453, -28188, -27943, -27681, -27436, -27058, -26519, -26056, -25774, -25531, -25185, -24634, -24039, -23764, -23520, -23094, -22563, -22085, -21570, -21078, -20446, -19648, -18958, -18456, -17818, -17218, -16736, -16163, -15382, -14648, -13912, -13140, -12425, -11657, -10915, -10188, -9412, -8692, -7959, -6988, -6115, -5392, -4568, -3528, -2561, -1584, -537};