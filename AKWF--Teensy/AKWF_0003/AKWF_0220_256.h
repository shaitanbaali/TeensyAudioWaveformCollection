/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0220 256 samples */
 
const int16_t AKWF_0220_256_DATA [256] = 
{899, 2644, 4292, 5879, 7405, 8885, 10333, 11742, 13109, 14410, 15627, 16758, 17812, 18801, 19745, 20646, 21492, 22273, 22976, 23598, 24156, 24669, 25152, 25614, 26045, 26429, 26753, 27012, 27217, 27386, 27535, 27667, 27776, 27843, 27860, 27823, 27747, 27651, 27550, 27450, 27342, 27210, 27039, 26826, 26580, 26322, 26062, 25809, 25552, 25275, 24966, 24623, 24256, 23882, 23515, 23155, 22792, 22404, 21972, 21490, 20965, 20410, 19841, 19261, 18662, 18033, 17362, 16650, 15916, 15182, 14468, 13790, 13143, 12513, 11893, 11278, 10684, 10134, 9647, 9228, 8873, 8565, 8290, 8050, 7855, 7723, 7668, 7691, 7780, 7913, 8071, 8246, 8442, 8672, 8943, 9255, 9592, 9935, 10266, 10579, 10879, 11182, 11498, 11825, 12150, 12452, 12713, 12926, 13101, 13250, 13385, 13510, 13611, 13665, 13612, 13466, 13266, 13045, 12833, 12616, 12376, 12102, 11790, 11447, 11088, 10732, 10398, 10089, 9793, 9498, 9184, 8845, 8489, 8132, 7786, 7455, 7124, 6769, 6371, 5921, 5426, 4904, 4364, 3812, 3238, 2625, 1961, 1249, 498, -268, -1029, -1783, -2533, -3292, -4078, -4887, -5709, -6526, -7319, -8083, -8828, -9565, -10307, -11055, -11794, -12506, -13175, -13795, -14378, -14940, -15493, -16045, -16587, -17100, -17574, -18008, -18412, -18808, -19210, -19631, -20062, -20484, -20878, -21241, -21582, -21919, -22273, -22647, -23032, -23415, -23784, -24136, -24483, -24843, -25232, -25653, -26090, -26531, -26955, -27358, -27750, -28146, -28557, -28985, -29419, -29838, -30225, -30575, -30894, -31197, -31494, -31785, -32057, -32293, -32472, -32594, -32668, -32712, -32742, -32762, -32766, -32738, -32666, -32547, -32393, -32220, -32040, -31852, -31639, -31375, -31042, -30636, -30163, -29638, -29072, -28462, -27795, -27058, -26229, -25306, -24299, -23191, -21972, -20685, -19327, -17904, -16401, -14797, -13110, -11375, -9617, -7862, -6113, -4359, -2602, -805};