/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0277 256 samples */
 
const int16_t AKWF_0277_256_DATA [256] = 
{226, 720, 1060, 1265, 1352, 1347, 1280, 1190, 1108, 1033, 966, 930, 943, 1000, 1122, 1357, 1732, 2230, 2833, 3551, 4398, 5358, 6413, 7570, 8834, 10198, 11645, 13139, 14663, 16209, 17747, 19235, 20634, 21921, 23096, 24159, 25093, 25887, 26522, 26997, 27319, 27496, 27535, 27446, 27234, 26907, 26483, 25994, 25472, 24924, 24345, 23746, 23139, 22538, 21929, 21263, 20531, 19755, 18934, 18055, 17123, 16161, 15191, 14220, 13256, 12315, 11406, 10535, 9721, 8979, 8333, 7813, 7421, 7152, 7002, 6966, 7041, 7219, 7508, 7915, 8432, 9045, 9730, 10466, 11244, 12039, 12721, 13050, 12935, 12460, 11645, 10445, 8865, 6943, 4693, 2129, -654, -3522, -6383, -9155, -11743, -14093, -16150, -17850, -19169, -20107, -20650, -20775, -20473, -19760, -18649, -17164, -15357, -13285, -11003, -8553, -5959, -3279, -600, 1968, 4342, 6513, 8467, 10149, 11540, 12647, 13455, 13943, 14123, 14029, 13690, 13122, 12365, 11450, 10401, 9264, 8074, 6854, 5627, 4435, 3314, 2281, 1350, 568, -41, -495, -804, -955, -927, -741, -574, -712, -1229, -2033, -3124, -4566, -6335, -8383, -10699, -13273, -16014, -18784, -21484, -24026, -26323, -28334, -30017, -31315, -32206, -32685, -32739, -32354, -31538, -30326, -28729, -26769, -24500, -21985, -19301, -16512, -13644, -10752, -7908, -5211, -2746, -541, 1366, 2910, 4075, 4886, 5346, 5451, 5218, 4686, 3879, 2826, 1580, 189, -1302, -2817, -4307, -5745, -7100, -8325, -9379, -10249, -10904, -11271, -11314, -11049, -10495, -9647, -8501, -7100, -5601, -4247, -3144, -2243, -1558, -1179, -1125, -1374, -1952, -2885, -4126, -5576, -7156, -8799, -10442, -12057, -13611, -15054, -16354, -17495, -18452, -19201, -19725, -20017, -20059, -19820, -19304, -18544, -17578, -16431, -15107, -13625, -12028, -10396, -8787, -7219, -5723, -4362, -3155, -2088, -1162, -379};