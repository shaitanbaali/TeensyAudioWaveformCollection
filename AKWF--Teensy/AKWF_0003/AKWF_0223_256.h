/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0223 256 samples */
 
const int16_t AKWF_0223_256_DATA [256] = 
{1314, 5158, 8306, 10962, 13183, 15030, 16556, 17799, 18803, 19602, 20220, 20686, 21020, 21240, 21362, 21399, 21363, 21265, 21114, 20915, 20676, 20403, 20101, 19772, 19422, 19053, 18666, 18267, 17855, 17432, 17001, 16563, 16116, 15665, 15209, 14747, 14284, 13816, 13345, 12873, 12399, 11922, 11445, 10965, 10484, 10004, 9521, 9038, 8555, 8071, 7586, 7102, 6616, 6131, 5646, 5160, 4674, 4189, 3701, 3225, 2844, 2586, 2431, 2365, 2376, 2452, 2586, 2769, 2993, 3254, 3548, 3867, 4210, 4573, 4953, 5348, 5756, 6174, 6603, 7039, 7482, 7932, 8387, 8846, 9310, 9776, 10245, 10717, 11191, 11666, 12144, 12623, 13102, 13584, 14066, 14548, 15032, 15515, 15999, 16484, 16969, 17454, 17940, 18425, 18911, 19398, 19884, 20370, 20857, 21343, 21830, 22317, 22803, 23291, 23778, 24264, 24752, 25239, 25723, 26201, 26699, 26321, 23770, 19448, 14369, 9204, 4354, -14, -3856, -7163, -9981, -12364, -14353, -16006, -17366, -18467, -19351, -20045, -20575, -20964, -21231, -21394, -21467, -21462, -21390, -21261, -21081, -20860, -20601, -20310, -19993, -19651, -19290, -18912, -18517, -18111, -17693, -17265, -16829, -16387, -15937, -15483, -15024, -14561, -14095, -13626, -13154, -12681, -12205, -11727, -11249, -10769, -10288, -9807, -9324, -8841, -8358, -7873, -7388, -6904, -6418, -5932, -5447, -4961, -4475, -3990, -3501, -3037, -2684, -2449, -2314, -2265, -2291, -2381, -2525, -2718, -2950, -3219, -3518, -3842, -4190, -4557, -4940, -5338, -5749, -6169, -6599, -7038, -7482, -7933, -8389, -8849, -9313, -9780, -10249, -10722, -11197, -11672, -12150, -12629, -13109, -13591, -14072, -14555, -15039, -15522, -16006, -16492, -16976, -17461, -17948, -18433, -18919, -19406, -19891, -20378, -20865, -21350, -21837, -22323, -22807, -23290, -23768, -24238, -24691, -25111, -25465, -25696, -25696, -25276, -24112, -21723, -17518, -11704, -5952, -1027};