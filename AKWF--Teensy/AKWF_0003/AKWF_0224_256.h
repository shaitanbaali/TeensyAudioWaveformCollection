/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0224 256 samples */
 
const int16_t AKWF_0224_256_DATA [256] = 
{353, 1495, 2617, 3742, 4865, 5987, 7102, 8207, 9303, 10388, 11455, 12507, 13542, 14553, 15544, 16513, 17453, 18370, 19259, 20118, 20951, 21752, 22520, 23260, 23968, 24643, 25289, 25902, 26482, 27032, 27552, 28041, 28500, 28930, 29331, 29705, 30051, 30372, 30668, 30938, 31187, 31413, 31617, 31802, 31967, 32113, 32243, 32356, 32454, 32536, 32604, 32661, 32704, 32736, 32755, 32765, 32766, 32757, 32738, 32711, 32676, 32632, 32581, 32523, 32456, 32382, 32301, 32212, 32116, 32012, 31900, 31781, 31654, 31518, 31374, 31221, 31058, 30887, 30706, 30514, 30313, 30100, 29876, 29641, 29393, 29134, 28862, 28576, 28276, 27963, 27634, 27291, 26933, 26557, 26165, 25757, 25330, 24887, 24425, 23943, 23441, 22918, 22374, 21808, 21219, 20606, 19968, 19304, 18613, 17897, 17152, 16380, 15581, 14752, 13896, 13016, 12107, 11174, 10220, 9240, 8239, 7219, 6177, 5119, 4046, 2957, 1858, 750, -368, -1489, -2614, -3742, -4865, -5986, -7102, -8207, -9303, -10388, -11454, -12507, -13541, -14553, -15544, -16512, -17453, -18370, -19259, -20117, -20949, -21751, -22520, -23260, -23967, -24643, -25287, -25900, -26481, -27032, -27551, -28039, -28499, -28929, -29330, -29703, -30050, -30370, -30666, -30938, -31186, -31412, -31617, -31801, -31966, -32113, -32243, -32355, -32452, -32535, -32604, -32659, -32703, -32734, -32755, -32765, -32765, -32755, -32737, -32710, -32675, -32632, -32580, -32521, -32455, -32381, -32300, -32211, -32114, -32011, -31900, -31780, -31652, -31516, -31373, -31220, -31057, -30886, -30705, -30513, -30312, -30100, -29876, -29640, -29393, -29133, -28861, -28575, -28276, -27962, -27633, -27290, -26931, -26557, -26165, -25757, -25330, -24887, -24424, -23942, -23440, -22918, -22373, -21808, -21219, -20605, -19968, -19304, -18613, -17897, -17152, -16380, -15581, -14751, -13895, -13015, -12107, -11174, -10220, -9240, -8239, -7218, -6177, -5119, -4047, -2960, -1864, -735};