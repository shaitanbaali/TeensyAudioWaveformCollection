/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0231 256 samples */
 
const int16_t AKWF_0231_256_DATA [256] = 
{248, 897, 1513, 2109, 2685, 3241, 3777, 4293, 4788, 5265, 5721, 6159, 6579, 6980, 7363, 7730, 8078, 8411, 8727, 9028, 9314, 9584, 9840, 10084, 10313, 10530, 10735, 10927, 11109, 11281, 11443, 11594, 11735, 11869, 11996, 12115, 12226, 12332, 12432, 12527, 12617, 12704, 12787, 12867, 12945, 13021, 13097, 13171, 13246, 13322, 13399, 13477, 13559, 13641, 13729, 13820, 13916, 14017, 14124, 14235, 14355, 14481, 14614, 14755, 14903, 15059, 15226, 15400, 15585, 15779, 15982, 16195, 16418, 16650, 16893, 17145, 17408, 17678, 17959, 18249, 18549, 18856, 19173, 19497, 19827, 20166, 20509, 20860, 21214, 21574, 21937, 22303, 22672, 23043, 23413, 23784, 24154, 24522, 24886, 25249, 25607, 25961, 26307, 26648, 26982, 27309, 27626, 27934, 28233, 28522, 28801, 29068, 29324, 29570, 29804, 30026, 30237, 30438, 30625, 30804, 30970, 31127, 31274, 31411, 31541, 31662, 31774, 31880, 31979, 32072, 32159, 32241, 32318, 32389, 32457, 32520, 32577, 32628, 32673, 32710, 32740, 32760, 32768, 32762, 32743, 32706, 32648, 32568, 32461, 32325, 32155, 31948, 31701, 31408, 31064, 30666, 30209, 29685, 29093, 28427, 27680, 26849, 25927, 24910, 23798, 22583, 21259, 19832, 18295, 16666, 14973, 13223, 11437, 9632, 7813, 5996, 4196, 2412, 658, -1057, -2735, -4366, -5944, -7474, -8946, -10359, -11717, -13014, -14248, -15426, -16542, -17597, -18595, -19533, -20413, -21236, -22002, -22712, -23369, -23970, -24520, -25018, -25462, -25858, -26203, -26499, -26747, -26947, -27099, -27205, -27265, -27280, -27250, -27177, -27060, -26900, -26698, -26455, -26171, -25848, -25487, -25087, -24651, -24181, -23674, -23137, -22568, -21966, -21338, -20683, -20001, -19297, -18570, -17823, -17058, -16276, -15479, -14670, -13849, -13018, -12183, -11339, -10493, -9650, -8809, -7974, -7151, -6337, -5537, -4752, -3981, -3228, -2493, -1777, -1081, -393};