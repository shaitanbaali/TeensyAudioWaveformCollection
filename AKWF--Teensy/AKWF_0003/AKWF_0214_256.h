/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0214 256 samples */
 
const int16_t AKWF_0214_256_DATA [256] = 
{567, 1966, 3137, 3493, 4775, 6341, 8316, 9667, 10347, 11155, 12146, 13517, 13857, 14727, 15673, 15640, 15178, 14732, 14161, 14669, 14165, 14078, 14565, 14947, 15201, 15342, 14052, 12623, 13136, 13740, 15157, 15366, 15576, 15625, 15312, 15413, 15189, 15524, 15795, 16289, 15942, 16072, 16410, 16513, 16941, 17049, 17885, 17528, 14061, 13407, 12489, 13201, 12168, 11319, 10086, 9328, 8606, 7479, 6471, 5775, 5982, 6290, 5941, 5169, 4184, 3787, 2731, 1343, 917, 443, 323, -288, -1110, -1635, -1554, -898, -1344, -865, -342, -1021, -1577, -1235, -817, 536, 196, 536, 1235, 1889, 2752, 4164, 3845, 3541, 4011, 4584, 5881, 6166, 6351, 6268, 6309, 6142, 5705, 5747, 5932, 6242, 6668, 7199, 8170, 8542, 8678, 8786, 9950, 8063, 5788, 4923, 3591, 3315, -449, -2841, -5795, -7661, -9044, -10690, -12913, -14748, -15668, -16770, -17799, -18615, -19300, -19840, -22286, -24305, -25292, -26173, -26239, -26884, -28113, -29213, -29432, -30013, -30828, -31272, -32119, -32394, -32739, -32585, -32061, -30719, -28617, -26984, -24963, -23370, -22121, -19712, -17939, -16093, -14368, -12659, -10821, -9541, -7867, -6363, -4895, -3855, -2329, -764, 680, 2550, 4224, 5812, 8172, 9483, 10989, 13281, 15485, 14358, 13681, 14274, 15316, 15922, 13291, 12506, 11290, 11888, 12027, 11347, 10247, 10002, 10562, 10834, 10889, 10727, 10545, 10137, 10129, 9992, 10248, 10117, 10989, 11267, 11153, 10624, 10107, 9914, 9143, 8677, 8414, 7739, 5811, 4702, 2993, 2344, 1246, -259, -460, -1543, -2152, -2628, -4210, -6931, -8329, -9380, -9577, -10279, -11011, -12086, -13584, -14868, -15956, -16700, -17446, -17877, -19104, -19645, -19565, -19892, -19402, -19272, -19323, -18102, -16590, -14896, -13490, -12398, -12475, -10864, -9800, -8470, -7613, -7286, -6718, -5509, -3853, -2615, -1573, -451};