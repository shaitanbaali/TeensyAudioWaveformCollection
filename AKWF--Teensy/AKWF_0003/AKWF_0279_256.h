/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0279 256 samples */
 
const int16_t AKWF_0279_256_DATA [256] = 
{2050, 5653, 8975, 12165, 15166, 18031, 20738, 23190, 25343, 27176, 28693, 29948, 30968, 31756, 32319, 32655, 32768, 32660, 32330, 31784, 31045, 30148, 29128, 28004, 26797, 25510, 24141, 22702, 21194, 19621, 17966, 16216, 14399, 12566, 10714, 8791, 6453, 3415, 112, -3049, -5949, -8630, -11256, -13864, -16427, -18894, -21162, -23139, -24809, -26211, -27371, -28309, -29032, -29530, -29809, -29890, -29784, -29501, -29048, -28449, -27726, -26898, -25985, -24995, -23933, -22789, -21558, -20255, -18912, -17533, -16109, -14626, -13083, -11525, -10021, -8600, -7253, -5934, -4563, -2921, -946, 1184, 3373, 5591, 7781, 9878, 11837, 13629, 15239, 16664, 17887, 18865, 19565, 19965, 20051, 19827, 19297, 18467, 17325, 15847, 13901, 11385, 8537, 5873, 3487, 1301, -663, -2421, -4146, -5917, -7544, -8952, -10159, -11169, -12002, -12683, -13208, -13546, -13659, -13535, -13181, -12511, -11531, -10300, -8767, -6902, -4741, -2287, 432, 3087, 5636, 8145, 10490, 12587, 14407, 15955, 17274, 18396, 19326, 20069, 20637, 21046, 21311, 21440, 21429, 21268, 20952, 20488, 19882, 19158, 18340, 17425, 16407, 15315, 14172, 12997, 11776, 10487, 9129, 7646, 6174, 4878, 3672, 2399, 949, -729, -2604, -4575, -6563, -8530, -10379, -12030, -13547, -14933, -16151, -17183, -18016, -18647, -19078, -19328, -19413, -19349, -19154, -18829, -18377, -17799, -17082, -16215, -15191, -13948, -12559, -11027, -9245, -7179, -4877, -2449, -40, 2246, 4369, 6342, 8239, 10028, 11657, 13133, 14434, 15528, 16409, 17074, 17528, 17788, 17876, 17795, 17544, 17116, 16507, 15716, 14757, 13629, 12171, 10352, 8247, 5722, 2615, -748, -3817, -6639, -9292, -11743, -14025, -16182, -18176, -19940, -21450, -22700, -23711, -24522, -25147, -25585, -25827, -25866, -25699, -25333, -24777, -24049, -23168, -22153, -21024, -19783, -18436, -16977, -15386, -13650, -11754, -9448, -6141, -1876};