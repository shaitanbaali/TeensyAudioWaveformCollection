/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0253 256 samples */
 
const int16_t AKWF_0253_256_DATA [256] = 
{897, 2599, 4240, 5836, 7376, 8854, 10215, 11548, 12817, 14015, 15144, 16218, 17208, 18147, 19055, 19910, 20709, 21465, 22181, 22826, 23421, 24020, 24586, 25122, 25650, 26161, 26636, 27145, 27645, 28128, 28609, 29073, 29499, 29865, 30218, 30514, 30744, 30936, 31066, 31121, 31123, 31118, 31054, 30962, 30863, 30738, 30595, 30472, 30333, 30185, 30055, 29933, 29795, 29664, 29587, 29501, 29441, 29430, 29438, 29462, 29520, 29614, 29688, 29767, 29859, 29901, 29898, 29862, 29779, 29608, 29380, 29111, 28747, 28326, 27876, 27365, 26775, 26194, 25563, 24885, 24198, 23499, 22744, 21982, 21229, 20446, 19662, 18922, 18185, 17443, 16742, 16095, 15449, 14842, 14291, 13738, 13180, 12644, 12114, 11538, 10971, 10410, 9789, 9152, 8520, 7883, 7229, 6619, 6023, 5426, 4862, 4344, 3852, 3380, 2981, 2617, 2260, 1960, 1717, 1509, 1363, 1298, 1261, 1267, 1334, 1439, 1563, 1718, 1874, 2004, 2112, 2181, 2198, 2150, 2067, 1911, 1673, 1378, 1025, 622, 172, -316, -847, -1415, -2019, -2660, -3327, -4005, -4707, -5444, -6179, -6929, -7674, -8397, -9106, -9784, -10454, -11105, -11751, -12392, -13024, -13653, -14316, -15002, -15728, -16488, -17264, -18071, -18880, -19720, -20555, -21401, -22236, -23035, -23823, -24568, -25295, -25977, -26635, -27266, -27831, -28347, -28814, -29240, -29594, -29898, -30152, -30316, -30419, -30499, -30516, -30493, -30465, -30433, -30381, -30347, -30344, -30358, -30410, -30518, -30623, -30754, -30927, -31108, -31279, -31465, -31671, -31842, -32011, -32189, -32341, -32468, -32591, -32697, -32744, -32761, -32759, -32672, -32523, -32334, -32085, -31757, -31382, -30985, -30520, -30024, -29530, -29008, -28456, -27943, -27414, -26838, -26264, -25704, -25084, -24420, -23773, -23060, -22264, -21446, -20584, -19649, -18680, -17675, -16580, -15426, -14229, -12966, -11622, -10240, -8813, -7282, -5698, -4080, -2426, -713};