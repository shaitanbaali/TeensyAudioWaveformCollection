/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0285 256 samples */
 
const int16_t AKWF_0285_256_DATA [256] = 
{-14187, -32970, -28725, -19708, -7658, 6285, 18770, 26724, 28883, 25873, 19542, 12000, 5003, -343, -3651, -5034, -4945, -3983, -2720, -1596, -872, -628, -804, -1250, -1793, -2277, -2594, -2695, -2584, -2304, -1916, -1487, -1071, -706, -410, -184, -20, 99, 188, 261, 324, 383, 436, 480, 512, 529, 529, 513, 484, 443, 395, 342, 289, 236, 188, 142, 102, 65, 33, 6, -17, -36, -52, -63, -72, -76, -77, -76, -72, -66, -59, -51, -41, -32, -23, -14, -5, 2, 8, 15, 20, 25, 28, 31, 34, 34, 35, 35, 34, 34, 32, 30, 28, 25, 23, 21, 19, 17, 15, 13, 11, 9, 8, 7, 5, 4, 3, 2, 2, 1, 1, 1, 0, 1, 0, -1, 0, -1, 0, -1, -1, -2, -1, -2, -3, -2, -3, -3, -4, -4, -5, -5, -6, -8, -8, -9, -9, -9, -10, -11, -11, -11, -12, -13, -13, -14, -14, -15, -16, -15, -16, -16, -16, -17, -18, -17, -18, -19, -18, -19, -21, -20, -21, -20, -21, -22, -21, -22, -22, -23, -22, -22, -22, -22, -23, -22, -23, -24, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -24, -23, -22, -23, -22, -22, -22, -22, -23, -22, -21, -22, -21, -22, -21, -20, -20, -21, -19, -18, -19, -18, -17, -18, -17, -16, -17, -16, -15, -16, -15, -14, -15, -13, -12, -12, -11, -11, -10, -10, -10, -9, -8, -9, -8, -8, -7, -6, -5, -4, -4, -3, -4, -3, -3, -2, -1, -1, 0, 0, 1, 1, 2, 2, 3, 3};