/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0289 256 samples */
 
const int16_t AKWF_0289_256_DATA [256] = 
{-15484, -33329, -29374, -23141, -17400, -12432, -8253, -4793, -1941, 384, 2250, 3732, 4884, 5754, 6389, 6825, 7094, 7225, 7244, 7170, 7022, 6814, 6562, 6274, 5960, 5631, 5291, 4945, 4601, 4258, 3922, 3597, 3280, 2977, 2687, 2410, 2148, 1900, 1668, 1450, 1246, 1057, 881, 718, 568, 430, 304, 188, 83, -12, -97, -175, -243, -305, -359, -407, -450, -486, -517, -542, -564, -582, -595, -606, -613, -618, -619, -618, -616, -612, -606, -599, -589, -579, -568, -557, -544, -530, -516, -501, -486, -471, -455, -439, -424, -408, -392, -377, -361, -345, -329, -314, -299, -284, -269, -255, -241, -227, -213, -199, -186, -173, -161, -149, -137, -124, -113, -102, -91, -82, -71, -60, -51, -42, -33, -24, -16, -8, 0, 7, 15, 22, 28, 35, 41, 48, 54, 60, 66, 72, 77, 81, 86, 91, 96, 100, 104, 108, 112, 116, 120, 123, 126, 130, 132, 134, 138, 140, 143, 146, 147, 150, 152, 154, 156, 158, 159, 161, 163, 164, 165, 166, 168, 169, 171, 171, 172, 173, 174, 175, 175, 176, 177, 177, 178, 179, 178, 179, 179, 180, 180, 179, 180, 181, 182, 181, 182, 182, 182, 181, 182, 181, 180, 179, 180, 180, 180, 179, 180, 179, 178, 178, 179, 178, 177, 177, 178, 176, 175, 176, 175, 174, 175, 173, 172, 173, 172, 171, 172, 171, 171, 170, 168, 169, 168, 168, 167, 165, 166, 165, 165, 164, 164, 163, 161, 161, 161, 160, 159, 159, 158, 157, 157, 157, 156, 155, 154, 154, 154, 153, 153, 151, 150, 150, 149, 150};