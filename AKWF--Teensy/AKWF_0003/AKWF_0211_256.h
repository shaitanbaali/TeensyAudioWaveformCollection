/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0211 256 samples */
 
const int16_t AKWF_0211_256_DATA [256] = 
{1157, 3363, 5868, 8026, 9978, 12052, 13736, 15558, 17635, 19012, 20678, 22450, 23479, 25012, 26722, 27493, 28718, 30151, 30937, 31588, 32311, 32740, 31943, 31500, 31063, 29351, 28432, 27202, 24846, 23224, 21246, 18796, 16410, 13781, 11195, 8597, 5491, 2987, 98, -2968, -6021, -8999, -11688, -14337, -16839, -19000, -20946, -22503, -24366, -25946, -27306, -28584, -29429, -30364, -31010, -31819, -32561, -32321, -31120, -30855, -30010, -28574, -27300, -25706, -23719, -22016, -20273, -18290, -15967, -13736, -11308, -9620, -7800, -5445, -3405, -1702, -61, 1779, 3421, 5082, 6971, 8361, 9918, 11726, 13543, 14480, 15893, 17718, 18577, 19813, 21304, 21962, 22362, 23247, 23744, 24251, 24880, 24903, 25604, 25657, 25493, 25958, 26263, 26208, 26109, 26471, 26847, 26675, 26649, 27028, 27210, 26868, 26621, 26083, 25575, 24315, 22798, 21978, 20349, 18354, 16643, 14668, 12732, 9972, 7475, 5846, 3090, 515, -1212, -3400, -5340, -7136, -8834, -10567, -12338, -13623, -15180, -17361, -18882, -20168, -22414, -23998, -25234, -27180, -28867, -29701, -29698, -30477, -30520, -29803, -29587, -28294, -26500, -25409, -23998, -21829, -19464, -17599, -15457, -13476, -11266, -8992, -6498, -4048, -1759, 1213, 3619, 5807, 8618, 10863, 13151, 15429, 17851, 19752, 21349, 23063, 24312, 25602, 26629, 27302, 27883, 28596, 29010, 28960, 29001, 28994, 28504, 27678, 27236, 26441, 24186, 22769, 21365, 19106, 17266, 15677, 13784, 11752, 9941, 8068, 6341, 4571, 2128, 511, -1274, -3460, -5236, -7180, -9033, -10917, -12846, -14681, -16404, -17679, -19203, -20313, -21068, -21877, -22486, -23390, -23541, -24031, -24924, -25183, -25663, -26413, -26790, -27119, -27755, -28110, -28645, -28899, -29060, -29489, -29719, -29600, -29019, -28662, -28416, -26899, -25808, -25134, -23915, -22370, -21105, -20285, -18961, -16970, -15372, -14157, -12073, -9887, -7887, -5673, -3593, -1142};