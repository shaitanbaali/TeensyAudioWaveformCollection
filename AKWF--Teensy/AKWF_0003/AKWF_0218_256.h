/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0218 256 samples */
 
const int16_t AKWF_0218_256_DATA [256] = 
{690, 1779, 2718, 4610, 1905, -4842, -2927, -1981, -898, 171, 1220, 2251, 3261, 4245, 5208, 6148, 7063, 7956, 8827, 9675, 10506, 11316, 12105, 12879, 13635, 14374, 15098, 15805, 16497, 17177, 17841, 18490, 19128, 19751, 20358, 20954, 21537, 22105, 22661, 23202, 23730, 24246, 24747, 25234, 25710, 26169, 26616, 27050, 27467, 27873, 28263, 28638, 29001, 29348, 29680, 29999, 30302, 30589, 30863, 31122, 31366, 31595, 31808, 32007, 32189, 32357, 32440, 32963, 31240, 27538, 28024, 28030, 28092, 28138, 28170, 28186, 28187, 28175, 28145, 28102, 28044, 27971, 27883, 27782, 27665, 27533, 27389, 27229, 27056, 26868, 26666, 26451, 26223, 25979, 25723, 25453, 25169, 24872, 24564, 24241, 23905, 23556, 23193, 22819, 22429, 22026, 21613, 21183, 20739, 20283, 19812, 19326, 18825, 18308, 17773, 17224, 16655, 16068, 15463, 14835, 14188, 13519, 12827, 12112, 11375, 10613, 9830, 9025, 8199, 7360, 6374, 6234, 1885, -6163, -6291, -7286, -8138, -8975, -9791, -10589, -11365, -12115, -12845, -13551, -14232, -14892, -15529, -16143, -16738, -17315, -17871, -18410, -18932, -19435, -19925, -20399, -20858, -21302, -21732, -22148, -22550, -22938, -23312, -23674, -24021, -24356, -24678, -24985, -25280, -25562, -25829, -26083, -26324, -26550, -26763, -26964, -27148, -27319, -27476, -27619, -27748, -27862, -27961, -28046, -28116, -28171, -28213, -28239, -28249, -28244, -28225, -28191, -28142, -28078, -28068, -27587, -29323, -33006, -32471, -32386, -32215, -32028, -31827, -31611, -31379, -31133, -30869, -30593, -30302, -29995, -29674, -29340, -28989, -28624, -28247, -27853, -27446, -27026, -26591, -26142, -25680, -25203, -24715, -24212, -23695, -23165, -22624, -22067, -21498, -20917, -20321, -19714, -19092, -18457, -17810, -17148, -16472, -15784, -15080, -14360, -13628, -12879, -12112, -11331, -10530, -9711, -8875, -8014, -7136, -6236, -5312, -4365, -3398, -2405, -1394, -339};