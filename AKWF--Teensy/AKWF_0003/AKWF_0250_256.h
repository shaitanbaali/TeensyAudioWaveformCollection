/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0250 256 samples */
 
const int16_t AKWF_0250_256_DATA [256] = 
{1285, 3217, 5055, 6822, 8484, 10016, 11394, 12605, 13654, 14551, 15313, 15973, 16556, 17094, 17605, 18098, 18562, 18982, 19336, 19621, 19843, 20016, 20164, 20331, 20556, 20884, 21354, 21986, 22789, 23746, 24823, 25978, 27168, 28342, 29447, 30446, 31288, 31951, 32417, 32687, 32770, 32691, 32477, 32155, 31766, 31424, 31353, 31506, 31430, 30790, 29585, 27946, 26010, 23884, 21649, 19347, 17025, 14709, 12411, 10141, 7889, 5616, 3312, 952, -1470, -3914, -6333, -8644, -10761, -12620, -14179, -15419, -16360, -17040, -17503, -17815, -18031, -18214, -18417, -18694, -19090, -19630, -20325, -21153, -22068, -23000, -23879, -24649, -25267, -25714, -26002, -26150, -26189, -26152, -26071, -25958, -25829, -25686, -25528, -25357, -25173, -24973, -24764, -24561, -24397, -24404, -24583, -24739, -24818, -24975, -25164, -25134, -24788, -24159, -23303, -22266, -21074, -19750, -18307, -16757, -15112, -13392, -11597, -9751, -7864, -5951, -4033, -2121, -225, 1638, 3459, 5224, 6909, 8499, 9988, 11365, 12622, 13752, 14741, 15592, 16313, 16910, 17387, 17742, 17967, 18041, 17952, 17682, 17246, 16656, 15956, 15198, 14453, 13799, 13296, 13008, 12975, 13229, 13776, 14611, 15704, 17001, 18528, 20395, 22471, 24271, 25372, 25705, 25423, 24700, 23665, 22394, 20941, 19372, 17754, 16164, 14660, 13252, 11953, 10754, 9632, 8580, 7589, 6634, 5711, 4812, 3930, 3057, 2177, 1254, 268, -797, -1945, -3129, -4297, -5370, -6264, -6922, -7304, -7405, -7252, -6892, -6377, -5775, -5157, -4589, -4136, -3848, -3777, -3962, -4442, -5241, -6365, -7800, -9498, -11406, -13431, -15466, -17424, -19195, -20708, -21910, -22781, -23337, -23612, -23675, -23598, -23448, -23291, -23185, -23163, -23250, -23455, -23788, -24368, -25283, -26279, -27200, -27905, -28135, -27808, -27007, -25835, -24392, -22735, -20917, -18993, -16985, -14928, -12849, -10754, -8673, -6615, -4588, -2598, -599};