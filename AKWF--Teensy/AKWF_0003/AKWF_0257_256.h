/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0257 256 samples */
 
const int16_t AKWF_0257_256_DATA [256] = 
{431, 1859, 3344, 4902, 6513, 8166, 9847, 11534, 13219, 14886, 16515, 18097, 19616, 21055, 22407, 23655, 24785, 25793, 26665, 27391, 27966, 28383, 28636, 28720, 28635, 28379, 27952, 27356, 26595, 25670, 24592, 23367, 21999, 20504, 18891, 17166, 15352, 13454, 11487, 9473, 7416, 5335, 3250, 1168, -895, -2916, -4895, -6812, -8651, -10409, -12072, -13627, -15073, -16398, -17595, -18664, -19598, -20397, -21060, -21586, -21977, -22240, -22375, -22389, -22289, -22083, -21775, -21374, -20891, -20334, -19709, -19029, -18300, -17530, -16731, -15907, -15066, -14221, -13373, -12530, -11702, -10891, -10103, -9347, -8621, -7934, -7288, -6684, -6127, -5618, -5155, -4741, -4375, -4055, -3779, -3545, -3349, -3187, -3055, -2947, -2857, -2781, -2711, -2640, -2562, -2470, -2357, -2214, -2036, -1816, -1545, -1218, -832, -380, 142, 732, 1395, 2127, 2926, 3791, 4715, 5692, 6719, 7785, 8880, 10001, 11133, 12268, 13399, 14510, 15596, 16646, 17645, 18590, 19469, 20272, 20993, 21623, 22151, 22575, 22887, 23081, 23152, 23096, 22910, 22590, 22135, 21545, 20816, 19952, 18956, 17825, 16567, 15187, 13683, 12069, 10350, 8528, 6620, 4632, 2570, 454, -1709, -3908, -6121, -8341, -10553, -12734, -14876, -16965, -18974, -20900, -22726, -24429, -26007, -27443, -28722, -29842, -30789, -31556, -32140, -32535, -32740, -32753, -32575, -32209, -31659, -30931, -30032, -28967, -27750, -26392, -24898, -23288, -21573, -19762, -17878, -15930, -13931, -11906, -9861, -7811, -5781, -3775, -1811, 92, 1930, 3684, 5338, 6891, 8327, 9633, 10808, 11840, 12723, 13456, 14032, 14450, 14712, 14815, 14765, 14563, 14217, 13731, 13115, 12379, 11531, 10584, 9553, 8448, 7283, 6079, 4845, 3596, 2356, 1134, -54, -1186, -2254, -3240, -4126, -4907, -5567, -6093, -6482, -6722, -6812, -6746, -6525, -6148, -5617, -4938, -4116, -3158, -2076, -847};