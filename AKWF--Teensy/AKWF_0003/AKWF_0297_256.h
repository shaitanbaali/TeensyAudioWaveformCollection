/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0297 256 samples */
 
const int16_t AKWF_0297_256_DATA [256] = 
{272, 862, 1378, 1855, 2294, 2697, 3067, 3402, 3707, 3987, 4248, 4463, 4767, 6383, 7844, 8456, 8993, 9618, 10289, 10961, 11563, 12067, 12483, 12817, 13118, 13357, 13538, 13691, 13796, 13878, 13928, 13923, 13902, 13864, 13896, 13967, 13945, 13900, 13843, 13818, 15109, 16955, 17864, 18535, 19236, 19997, 20761, 21462, 22053, 22548, 22961, 23306, 23597, 23840, 24025, 24156, 24257, 24320, 24350, 24359, 24350, 24317, 24269, 24202, 24128, 24052, 23980, 23776, 24665, 26789, 27706, 28839, 30013, 30907, 31730, 32055, 32273, 32486, 32637, 32726, 32756, 32738, 32680, 32590, 32465, 32308, 32129, 31908, 31757, 32340, 32767, 32742, 32684, 32674, 32689, 32703, 32678, 32602, 32479, 32314, 32136, 31923, 31684, 31434, 31161, 30881, 30584, 30262, 29933, 29604, 29267, 28941, 28179, 27164, 26213, 25232, 24858, 24746, 24154, 23481, 22870, 22341, 21829, 21317, 20761, 20197, 19613, 19012, 18397, 17790, 17170, 16554, 15925, 15292, 14661, 14051, 13429, 12805, 12201, 11593, 11004, 10415, 9814, 9279, 8736, -2360, -9593, -10739, -11848, -13322, -15059, -16829, -18410, -19717, -20772, -21637, -22362, -22966, -23443, -23797, -24035, -24175, -24233, -24224, -24152, -24028, -23858, -23648, -23405, -23134, -22842, -22529, -22202, -21864, -21516, -21163, -20806, -20448, -20090, -19734, -19378, -19028, -18685, -18344, -18012, -17690, -17373, -17062, -17013, -17094, -17152, -17218, -17277, -17334, -17391, -17452, -17511, -17559, -17619, -17672, -17736, -17785, -17836, -17889, -17945, -17993, -18043, -18085, -18134, -18183, -18226, -18262, -18303, -18357, -18264, -18056, -17979, -17939, -17931, -17683, -17030, -22243, -24869, -24681, -24524, -24504, -24672, -24906, -25099, -25172, -25130, -25002, -24814, -24566, -24274, -23936, -23532, -23089, -22615, -22111, -21573, -21024, -20455, -19885, -19294, -18685, -18049, -17632, -15450, -10812, -8313, -6769, -5112, -3183, -1273, -323};