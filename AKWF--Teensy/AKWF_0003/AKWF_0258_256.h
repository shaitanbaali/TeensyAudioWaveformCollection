/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0258 256 samples */
 
const int16_t AKWF_0258_256_DATA [256] = 
{4700, 11517, 17098, 19797, 19812, 19019, 17986, 16915, 15879, 14906, 14009, 13188, 12449, 11794, 11220, 10731, 10326, 10002, 9761, 9600, 9518, 9513, 9582, 9723, 9933, 10209, 10548, 10946, 11399, 11904, 12457, 13052, 13689, 14360, 15060, 15790, 16540, 17309, 18092, 18884, 19683, 20483, 21280, 22072, 22855, 23623, 24377, 25111, 25822, 26509, 27168, 27796, 28395, 28959, 29487, 29979, 30433, 30846, 31221, 31554, 31848, 32100, 32311, 32482, 32612, 32702, 32754, 32768, 32744, 32685, 32592, 32466, 32308, 32121, 31906, 31666, 31401, 31115, 30808, 30484, 30145, 29790, 29425, 29051, 28667, 28280, 27889, 27496, 27105, 26716, 26330, 25950, 25578, 25215, 24862, 24522, 24194, 23881, 23583, 23301, 23037, 22790, 22562, 22354, 22163, 21994, 21844, 21715, 21605, 21515, 21446, 21395, 21365, 21353, 21359, 21382, 21424, 21481, 21534, 21653, 21489, 17659, 10333, 2391, -5088, -11677, -17324, -20703, -21141, -20453, -19450, -18370, -17312, -16308, -15367, -14503, -13715, -13003, -12373, -11821, -11349, -10957, -10645, -10411, -10254, -10172, -10165, -10229, -10361, -10561, -10823, -11146, -11525, -11957, -12440, -12968, -13537, -14145, -14786, -15457, -16155, -16873, -17609, -18360, -19118, -19883, -20650, -21413, -22171, -22923, -23660, -24382, -25087, -25768, -26427, -27060, -27663, -28237, -28779, -29286, -29758, -30195, -30593, -30953, -31275, -31557, -31800, -32004, -32168, -32294, -32382, -32433, -32447, -32426, -32371, -32283, -32163, -32013, -31835, -31631, -31400, -31148, -30874, -30581, -30271, -29946, -29607, -29256, -28899, -28532, -28161, -27787, -27410, -27034, -26662, -26292, -25928, -25571, -25223, -24885, -24558, -24244, -23943, -23657, -23387, -23133, -22896, -22677, -22476, -22294, -22130, -21987, -21861, -21755, -21669, -21602, -21553, -21522, -21510, -21516, -21538, -21576, -21631, -21700, -21784, -21880, -21990, -22110, -22241, -22382, -22510, -22708, -22530, -18394, -10840, -2655};