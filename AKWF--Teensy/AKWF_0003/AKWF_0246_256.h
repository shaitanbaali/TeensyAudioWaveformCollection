/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0246 256 samples */
 
const int16_t AKWF_0246_256_DATA [256] = 
{12691, 12946, 13197, 13448, 13699, 13949, 14201, 14452, 14703, 14955, 15205, 15457, 15708, 15959, 16210, 16461, 16713, 16964, 17215, 17465, 17718, 17969, 18219, 18471, 18722, 18973, 19225, 19475, 19726, 19978, 20229, 20480, 20731, 20982, 21233, 21485, 21736, 21987, 22238, 22489, 22741, 22992, 23242, 23494, 23745, 23996, 24247, 24499, 24749, 25001, 25252, 25503, 25754, 26005, 26257, 26508, 26759, 27010, 27261, 27512, 27763, 28015, 28265, 28517, 28768, 29019, 29270, 29522, 29772, 30024, 30275, 30526, 30777, 31029, 31280, 31531, 31782, 32032, 32272, 32569, 32593, 31413, 30113, 28847, 27570, 26293, 25018, 23740, 22465, 21191, 19913, 18636, 17361, 16032, 15024, 12757, 710, -196, 53, -1, 0, 1, -52, 214, -813, -9767, -10692, -11030, -11531, -12002, -12474, -12947, -13417, -13889, -14361, -14833, -15305, -15777, -16247, -16720, -17191, -17663, -18135, -18606, -19077, -19550, -20022, -20492, -20965, -21436, -21908, -22380, -22851, -23323, -23795, -24266, -24738, -25204, -25702, -25751, -25490, -25273, -25048, -24824, -24600, -24375, -24150, -23927, -23702, -23477, -23252, -23029, -22804, -22579, -22354, -22131, -21906, -21681, -21457, -21233, -21008, -20783, -20559, -20335, -20110, -19885, -19661, -19437, -19212, -18987, -18764, -18539, -18314, -18089, -17866, -17641, -17416, -17192, -16968, -16743, -16518, -16294, -16070, -15845, -15620, -15397, -15172, -14947, -14722, -14499, -14274, -14049, -13824, -13601, -13376, -13151, -12927, -12703, -12478, -12253, -12029, -11805, -11580, -11355, -11131, -10907, -10682, -10275, -11027, -4961, 798, -185, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};