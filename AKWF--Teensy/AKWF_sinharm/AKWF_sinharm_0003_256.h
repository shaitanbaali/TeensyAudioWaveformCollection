/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0003 256 samples */
 
const int16_t AKWF_sinharm_0003_256_DATA [256] = 
{1687, 4118, 6448, 8702, 10846, 12857, 14710, 16376, 17842, 19092, 20107, 20884, 21413, 21692, 21723, 21510, 21065, 20395, 19518, 18455, 17221, 15844, 14352, 12765, 11117, 9440, 7755, 6101, 4506, 2992, 1593, 333, -768, -1686, -2405, -2911, -3189, -3235, -3043, -2614, -1948, -1054, 55, 1370, 2875, 4542, 6359, 8295, 10319, 12414, 14544, 16674, 18785, 20839, 22805, 24664, 26382, 27934, 29302, 30462, 31399, 32101, 32556, 32757, 32702, 32393, 31832, 31027, 29994, 28743, 27292, 25668, 23887, 21977, 19972, 17890, 15765, 13634, 11515, 9444, 7457, 5568, 3811, 2212, 785, -445, -1462, -2260, -2826, -3154, -3245, -3098, -2723, -2123, -1317, -320, 853, 2174, 3625, 5178, 6802, 8472, 10159, 11826, 13450, 15003, 16447, 17766, 18931, 19916, 20707, 21283, 21630, 21740, 21603, 21218, 20583, 19702, 18588, 17242, 15688, 13942, 12017, 9945, 7752, 5454, 3092, 693, -1721, -4108, -6445, -8703, -10847, -12858, -14711, -16376, -17843, -19093, -20107, -20884, -21414, -21692, -21723, -21510, -21065, -20395, -19519, -18456, -17221, -15845, -14353, -12765, -11118, -9441, -7756, -6102, -4507, -2993, -1594, -334, 767, 1685, 2404, 2910, 3188, 3234, 3042, 2613, 1947, 1053, -56, -1371, -2876, -4543, -6360, -8296, -10319, -12414, -14545, -16674, -18785, -20840, -22806, -24664, -26382, -27934, -29302, -30462, -31399, -32101, -32556, -32757, -32702, -32393, -31832, -31027, -29994, -28744, -27292, -25668, -23888, -21978, -19972, -17891, -15765, -13634, -11515, -9445, -7458, -5569, -3812, -2213, -786, 444, 1461, 2260, 2826, 3153, 3244, 3098, 2722, 2122, 1316, 319, -854, -2175, -3626, -5179, -6802, -8472, -10159, -11826, -13451, -15003, -16448, -17766, -18932, -19917, -20707, -21283, -21630, -21740, -21604, -21219, -20583, -19702, -18588, -17243, -15688, -13942, -12018, -9946, -7753, -5459, -3104, -660};