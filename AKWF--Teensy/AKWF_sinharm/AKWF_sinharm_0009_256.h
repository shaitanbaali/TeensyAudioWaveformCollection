/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0009 256 samples */
 
const int16_t AKWF_sinharm_0009_256_DATA [256] = 
{1928, 4717, 7413, 10057, 12623, 15094, 17454, 19677, 21756, 23679, 25426, 26998, 28383, 29575, 30577, 31386, 32002, 32435, 32688, 32769, 32690, 32463, 32103, 31622, 31037, 30366, 29623, 28828, 28000, 27153, 26306, 25474, 24672, 23917, 23219, 22588, 22038, 21574, 21201, 20928, 20751, 20676, 20699, 20817, 21025, 21316, 21684, 22117, 22603, 23137, 23701, 24284, 24874, 25458, 26019, 26553, 27040, 27472, 27841, 28135, 28350, 28477, 28513, 28455, 28303, 28056, 27717, 27290, 26783, 26200, 25548, 24843, 24092, 23307, 22503, 21689, 20881, 20095, 19339, 18629, 17980, 17397, 16895, 16485, 16170, 15957, 15855, 15861, 15980, 16209, 16547, 16988, 17524, 18150, 18850, 19616, 20436, 21291, 22169, 23052, 23922, 24764, 25559, 26286, 26933, 27481, 27913, 28216, 28378, 28384, 28225, 27895, 27387, 26694, 25816, 24756, 23512, 22091, 20506, 18755, 16856, 14826, 12668, 10412, 8070, 5655, 3198, 715, -1778, -4252, -6692, -9081, -11387, -13602, -15710, -17684, -19521, -21203, -22719, -24064, -25232, -26213, -27012, -27626, -28057, -28314, -28401, -28327, -28103, -27743, -27260, -26668, -25984, -25227, -24410, -23553, -22677, -21792, -20922, -20082, -19282, -18543, -17873, -17284, -16788, -16391, -16099, -15916, -15846, -15886, -16035, -16292, -16649, -17099, -17637, -18250, -18926, -19657, -20428, -21224, -22036, -22848, -23645, -24418, -25150, -25833, -26457, -27009, -27483, -27873, -28173, -28380, -28491, -28509, -28434, -28268, -28019, -27693, -27294, -26839, -26330, -25783, -25210, -24623, -24034, -23458, -22905, -22389, -21925, -21518, -21182, -20926, -20756, -20678, -20696, -20815, -21033, -21348, -21761, -22263, -22848, -23510, -24233, -25010, -25826, -26667, -27515, -28357, -29172, -29947, -30662, -31299, -31840, -32273, -32577, -32743, -32755, -32602, -32273, -31762, -31065, -30174, -29089, -27816, -26350, -24701, -22880, -20889, -18745, -16464, -14054, -11538, -8938, -6265, -3551, -754};