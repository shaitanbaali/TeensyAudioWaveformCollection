/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0014 256 samples */
 
const int16_t AKWF_sinharm_0014_256_DATA [256] = 
{1659, 4063, 6394, 8691, 10934, 13114, 15220, 17229, 19144, 20951, 22635, 24200, 25636, 26934, 28100, 29131, 30023, 30782, 31410, 31909, 32288, 32552, 32708, 32767, 32735, 32623, 32443, 32201, 31913, 31585, 31231, 30858, 30476, 30097, 29725, 29368, 29036, 28731, 28459, 28223, 28027, 27868, 27751, 27673, 27632, 27627, 27651, 27704, 27775, 27863, 27962, 28063, 28161, 28250, 28323, 28371, 28392, 28379, 28328, 28232, 28090, 27897, 27655, 27360, 27011, 26613, 26164, 25669, 25134, 24559, 23951, 23318, 22664, 21997, 21329, 20661, 20004, 19367, 18757, 18180, 17645, 17158, 16723, 16349, 16037, 15791, 15615, 15508, 15470, 15501, 15600, 15760, 15979, 16251, 16568, 16925, 17310, 17716, 18134, 18553, 18960, 19347, 19702, 20014, 20273, 20468, 20590, 20631, 20580, 20434, 20183, 19824, 19355, 18771, 18071, 17258, 16332, 15295, 14155, 12914, 11581, 10166, 8673, 7119, 5512, 3860, 2182, 488, -1213, -2901, -4569, -6205, -7790, -9318, -10781, -12161, -13456, -14654, -15751, -16741, -17620, -18384, -19035, -19569, -19991, -20304, -20509, -20614, -20625, -20547, -20394, -20170, -19887, -19556, -19186, -18788, -18376, -17955, -17541, -17144, -16769, -16428, -16130, -15879, -15685, -15550, -15480, -15478, -15545, -15682, -15888, -16162, -16502, -16902, -17360, -17868, -18421, -19013, -19637, -20283, -20945, -21615, -22282, -22945, -23592, -24214, -24809, -25367, -25886, -26361, -26789, -27166, -27493, -27765, -27986, -28157, -28279, -28355, -28389, -28387, -28354, -28294, -28214, -28120, -28020, -27919, -27823, -27742, -27678, -27637, -27625, -27645, -27702, -27797, -27931, -28106, -28319, -28571, -28858, -29175, -29517, -29882, -30258, -30640, -31019, -31385, -31729, -32041, -32311, -32528, -32679, -32759, -32753, -32654, -32453, -32141, -31711, -31158, -30475, -29659, -28708, -27620, -26396, -25040, -23548, -21930, -20195, -18340, -16383, -14334, -12193, -9984, -7717, -5402, -3058, -649};