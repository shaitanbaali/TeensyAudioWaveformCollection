/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0004 256 samples */
 
const int16_t AKWF_sinharm_0004_256_DATA [256] = 
{2187, 5346, 8390, 11360, 14218, 16946, 19517, 21897, 24077, 26041, 27762, 29240, 30464, 31425, 32128, 32571, 32760, 32705, 32416, 31909, 31199, 30308, 29260, 28072, 26774, 25390, 23945, 22471, 20992, 19530, 18116, 16774, 15520, 14381, 13372, 12509, 11807, 11273, 10917, 10741, 10747, 10934, 11296, 11826, 12513, 13343, 14303, 15375, 16536, 17773, 19060, 20371, 21691, 22993, 24252, 25454, 26574, 27591, 28495, 29264, 29886, 30355, 30658, 30793, 30756, 30549, 30175, 29639, 28953, 28125, 27170, 26108, 24950, 23720, 22441, 21129, 19809, 18506, 17238, 16030, 14906, 13879, 12972, 12201, 11580, 11120, 10833, 10722, 10793, 11047, 11480, 12087, 12858, 13786, 14852, 16042, 17337, 18713, 20149, 21623, 23102, 24566, 25990, 27340, 28593, 29726, 30708, 31526, 32151, 32567, 32757, 32710, 32413, 31860, 31046, 29974, 28640, 27056, 25232, 23173, 20904, 18443, 15800, 13012, 10104, 7089, 4012, 898, -2231, -5333, -8385, -11360, -14219, -16947, -19518, -21897, -24078, -26041, -27762, -29240, -30464, -31425, -32128, -32571, -32760, -32705, -32416, -31909, -31199, -30308, -29261, -28072, -26774, -25391, -23945, -22471, -20992, -19531, -18117, -16774, -15520, -14382, -13373, -12510, -11808, -11274, -10917, -10741, -10748, -10935, -11297, -11826, -12514, -13343, -14304, -15376, -16537, -17773, -19060, -20371, -21691, -22993, -24252, -25454, -26574, -27592, -28495, -29264, -29886, -30355, -30658, -30794, -30756, -30549, -30175, -29639, -28953, -28125, -27170, -26108, -24951, -23720, -22441, -21129, -19809, -18507, -17239, -16031, -14906, -13879, -12973, -12202, -11581, -11121, -10833, -10723, -10794, -11048, -11480, -12088, -12858, -13787, -14853, -16042, -17337, -18713, -20149, -21623, -23103, -24566, -25991, -27340, -28593, -29726, -30708, -31526, -32151, -32567, -32757, -32710, -32413, -31860, -31046, -29974, -28640, -27056, -25232, -23173, -20905, -18443, -15801, -13012, -10105, -7095, -4026, -856};