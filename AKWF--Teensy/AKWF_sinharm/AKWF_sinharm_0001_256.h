/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0001 256 samples */
 
const int16_t AKWF_sinharm_0001_256_DATA [256] = 
{958, 2351, 3712, 5070, 6417, 7754, 9079, 10384, 11673, 12941, 14183, 15403, 16595, 17754, 18885, 19982, 21040, 22064, 23049, 23992, 24894, 25753, 26565, 27333, 28052, 28721, 29345, 29916, 30436, 30905, 31322, 31687, 31999, 32258, 32463, 32617, 32718, 32764, 32760, 32706, 32598, 32442, 32235, 31980, 31678, 31330, 30936, 30497, 30018, 29497, 28935, 28337, 27701, 27032, 26332, 25599, 24838, 24051, 23238, 22403, 21548, 20672, 19783, 18879, 17961, 17037, 16103, 15164, 14224, 13281, 12338, 11402, 10470, 9545, 8632, 7728, 6838, 5965, 5108, 4271, 3455, 2661, 1890, 1147, 429, -259, -917, -1547, -2143, -2705, -3237, -3733, -4193, -4618, -5007, -5358, -5674, -5952, -6192, -6397, -6564, -6695, -6789, -6847, -6870, -6858, -6812, -6733, -6621, -6478, -6305, -6102, -5873, -5617, -5335, -5031, -4703, -4355, -3989, -3605, -3206, -2794, -2368, -1933, -1491, -1041, -587, -132, 325, 780, 1233, 1680, 2119, 2550, 2970, 3377, 3770, 4147, 4505, 4844, 5163, 5457, 5729, 5974, 6192, 6382, 6542, 6672, 6770, 6834, 6867, 6863, 6826, 6752, 6643, 6496, 6314, 6093, 5837, 5543, 5212, 4844, 4441, 4000, 3524, 3014, 2468, 1892, 1281, 639, -31, -733, -1463, -2217, -2997, -3802, -4626, -5472, -6337, -7216, -8113, -9021, -9939, -10868, -11802, -12740, -13684, -14626, -15565, -16503, -17433, -18354, -19267, -20165, -21047, -21916, -22762, -23587, -24391, -25166, -25915, -26636, -27322, -27977, -28597, -29179, -29724, -30228, -30690, -31109, -31484, -31813, -32095, -32330, -32514, -32650, -32735, -32768, -32751, -32681, -32557, -32382, -32153, -31872, -31538, -31151, -30712, -30220, -29679, -29085, -28441, -27751, -27011, -26224, -25392, -24515, -23595, -22634, -21633, -20592, -19519, -18407, -17263, -16091, -14886, -13656, -12404, -11126, -9830, -8517, -7185, -5844, -4493, -3131, -1768, -375};