/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0015 256 samples */
 
const int16_t AKWF_sinharm_0015_256_DATA [256] = 
{1413, 3461, 5452, 7425, 9361, 11258, 13107, 14893, 16618, 18272, 19845, 21340, 22749, 24063, 25288, 26417, 27447, 28383, 29222, 29963, 30612, 31168, 31634, 32015, 32313, 32533, 32678, 32754, 32766, 32718, 32615, 32463, 32265, 32025, 31749, 31440, 31103, 30738, 30350, 29942, 29514, 29068, 28606, 28128, 27633, 27122, 26594, 26047, 25484, 24898, 24291, 23661, 23005, 22323, 21615, 20875, 20104, 19304, 18470, 17605, 16709, 15779, 14821, 13835, 12820, 11782, 10725, 9647, 8559, 7459, 6353, 5252, 4153, 3065, 1996, 947, -74, -1058, -2007, -2911, -3763, -4565, -5307, -5986, -6602, -7149, -7624, -8030, -8362, -8620, -8808, -8924, -8971, -8950, -8866, -8723, -8521, -8269, -7971, -7631, -7256, -6851, -6422, -5976, -5518, -5052, -4588, -4128, -3678, -3243, -2827, -2433, -2067, -1728, -1420, -1144, -900, -689, -510, -362, -243, -153, -87, -41, -14, -1, 2, 0, -2, -3, 4, 22, 57, 111, 187, 289, 420, 581, 774, 999, 1257, 1546, 1868, 2219, 2597, 3001, 3427, 3868, 4323, 4785, 5250, 5713, 6167, 6607, 7026, 7419, 7780, 8103, 8382, 8613, 8790, 8909, 8966, 8959, 8883, 8736, 8518, 8229, 7865, 7429, 6923, 6347, 5703, 4997, 4229, 3404, 2531, 1607, 641, -358, -1392, -2452, -3528, -4622, -5723, -6825, -7930, -9026, -10109, -11179, -12229, -13256, -14260, -15234, -16180, -17096, -17978, -18830, -19650, -20437, -21194, -21921, -22618, -23288, -23934, -24552, -25150, -25727, -26282, -26821, -27342, -27846, -28333, -28806, -29260, -29699, -30119, -30518, -30897, -31250, -31576, -31871, -32132, -32355, -32534, -32666, -32746, -32768, -32730, -32625, -32448, -32196, -31863, -31445, -30942, -30347, -29658, -28877, -27996, -27019, -25948, -24777, -23512, -22160, -20713, -19183, -17577, -15891, -14138, -12326, -10454, -8539, -6587, -4603, -2605, -553};