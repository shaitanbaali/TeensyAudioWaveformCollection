/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0005 256 samples */
 
const int16_t AKWF_sinharm_0005_256_DATA [256] = 
{2004, 4901, 7699, 10440, 13094, 15643, 18068, 20342, 22457, 24398, 26146, 27701, 29052, 30189, 31119, 31837, 32346, 32654, 32767, 32698, 32454, 32054, 31513, 30845, 30069, 29207, 28274, 27294, 26285, 25263, 24253, 23268, 22325, 21441, 20630, 19901, 19268, 18736, 18310, 17997, 17795, 17705, 17722, 17844, 18061, 18364, 18743, 19188, 19681, 20212, 20763, 21318, 21865, 22384, 22860, 23281, 23630, 23895, 24064, 24128, 24077, 23905, 23608, 23183, 22629, 21948, 21145, 20225, 19196, 18069, 16852, 15564, 14214, 12819, 11402, 9971, 8549, 7156, 5804, 4514, 3306, 2188, 1179, 295, -458, -1067, -1524, -1827, -1971, -1954, -1778, -1446, -966, -343, 406, 1276, 2251, 3311, 4442, 5627, 6842, 8071, 9293, 10485, 11629, 12707, 13695, 14581, 15346, 15974, 16455, 16777, 16931, 16912, 16713, 16336, 15780, 15049, 14151, 13090, 11882, 10537, 9067, 7493, 5833, 4101, 2323, 520, -1293, -3088, -4847, -6553, -8177, -9708, -11128, -12415, -13562, -14555, -15382, -16039, -16520, -16821, -16942, -16887, -16660, -16269, -15723, -15036, -14217, -13285, -12257, -11149, -9981, -8775, -7546, -6321, -5118, -3953, -2849, -1825, -892, -73, 624, 1188, 1605, 1871, 1979, 1928, 1716, 1347, 824, 153, -658, -1596, -2653, -3813, -5056, -6375, -7748, -9154, -10582, -12010, -13419, -14797, -16123, -17381, -18562, -19649, -20632, -21503, -22254, -22881, -23381, -23750, -23994, -24113, -24114, -24004, -23793, -23491, -23110, -22663, -22167, -21634, -21082, -20527, -19982, -19465, -18992, -18573, -18225, -17957, -17780, -17702, -17731, -17868, -18118, -18478, -18951, -19527, -20201, -20967, -21811, -22721, -23684, -24682, -25699, -26719, -27717, -28679, -29585, -30412, -31144, -31760, -32243, -32578, -32749, -32742, -32548, -32153, -31557, -30748, -29729, -28502, -27063, -25423, -23593, -21576, -19390, -17052, -14570, -11973, -9280, -6509, -3690, -784};