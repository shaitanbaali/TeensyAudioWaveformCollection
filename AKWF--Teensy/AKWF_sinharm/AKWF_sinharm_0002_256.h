/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0002 256 samples */
 
const int16_t AKWF_sinharm_0002_256_DATA [256] = 
{1462, 3581, 5642, 7685, 9695, 11665, 13591, 15452, 17253, 18984, 20633, 22198, 23673, 25048, 26324, 27494, 28551, 29496, 30325, 31033, 31621, 32089, 32433, 32657, 32761, 32745, 32611, 32364, 32006, 31540, 30973, 30308, 29550, 28705, 27782, 26783, 25720, 24597, 23421, 22205, 20951, 19669, 18372, 17061, 15746, 14442, 13147, 11876, 10638, 9433, 8276, 7172, 6124, 5142, 4234, 3401, 2649, 1987, 1412, 932, 550, 266, 84, 3, 25, 149, 375, 701, 1126, 1646, 2259, 2959, 3746, 4613, 5553, 6563, 7637, 8763, 9942, 11163, 12415, 13697, 14998, 16306, 17621, 18928, 20218, 21490, 22730, 23928, 25083, 26182, 27217, 28185, 29076, 29884, 30603, 31228, 31751, 32172, 32483, 32682, 32766, 32732, 32576, 32301, 31904, 31386, 30745, 29986, 29108, 28113, 27009, 25793, 24473, 23056, 21542, 19938, 18256, 16493, 14665, 12777, 10830, 8841, 6816, 4758, 2684, 600, -1492, -3572, -5639, -7686, -9696, -11666, -13591, -15453, -17253, -18985, -20633, -22199, -23674, -25049, -26325, -27494, -28551, -29496, -30325, -31033, -31621, -32089, -32433, -32657, -32761, -32745, -32611, -32364, -32006, -31540, -30973, -30308, -29550, -28706, -27782, -26783, -25720, -24597, -23422, -22206, -20951, -19669, -18372, -17061, -15747, -14442, -13148, -11877, -10638, -9434, -8276, -7173, -6125, -5143, -4235, -3401, -2650, -1987, -1413, -933, -551, -267, -85, -4, -26, -150, -376, -702, -1126, -1647, -2260, -2960, -3747, -4614, -5553, -6564, -7638, -8764, -9942, -11164, -12415, -13697, -14999, -16307, -17621, -18928, -20218, -21490, -22730, -23928, -25083, -26182, -27217, -28185, -29076, -29884, -30603, -31228, -31751, -32172, -32483, -32682, -32766, -32732, -32576, -32301, -31904, -31386, -30745, -29986, -29108, -28113, -27009, -25793, -24473, -23056, -21542, -19939, -18256, -16493, -14665, -12777, -10831, -8842, -6817, -4763, -2694, -572};