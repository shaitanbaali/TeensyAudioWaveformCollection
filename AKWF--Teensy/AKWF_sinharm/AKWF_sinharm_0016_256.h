/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0016 256 samples */
 
const int16_t AKWF_sinharm_0016_256_DATA [256] = 
{2152, 5261, 8257, 11185, 14003, 16697, 19241, 21602, 23771, 25731, 27459, 28954, 30207, 31207, 31960, 32464, 32727, 32755, 32561, 32159, 31563, 30796, 29879, 28827, 27672, 26436, 25143, 23821, 22493, 21183, 19917, 18716, 17596, 16584, 15692, 14931, 14318, 13858, 13556, 13416, 13437, 13614, 13942, 14412, 15013, 15726, 16541, 17435, 18387, 19382, 20393, 21397, 22372, 23297, 24145, 24901, 25541, 26046, 26402, 26592, 26606, 26434, 26069, 25509, 24750, 23800, 22658, 21334, 19844, 18197, 16408, 14502, 12494, 10406, 8271, 6100, 3925, 1779, -325, -2357, -4285, -6100, -7771, -9276, -10607, -11741, -12666, -13376, -13864, -14122, -14152, -13959, -13547, -12924, -12104, -11101, -9927, -8610, -7169, -5623, -4001, -2326, -622, 1076, 2750, 4374, 5917, 7363, 8687, 9866, 10887, 11733, 12389, 12851, 13107, 13158, 13002, 12639, 12081, 11331, 10405, 9317, 8082, 6723, 5260, 3711, 2108, 472, -1174, -2799, -4380, -5898, -7318, -8626, -9802, -10822, -11674, -12344, -12818, -13095, -13162, -13024, -12680, -12133, -11395, -10473, -9382, -8140, -6761, -5270, -3691, -2042, -353, 1348, 3044, 4701, 6292, 7797, 9188, 10446, 11550, 12476, 13214, 13749, 14068, 14166, 14039, 13683, 13100, 12296, 11282, 10062, 8653, 7077, 5342, 3473, 1500, -566, -2693, -4852, -7029, -9190, -11304, -13362, -15331, -17187, -18919, -20501, -21920, -23168, -24230, -25098, -25772, -26249, -26530, -26622, -26532, -26270, -25847, -25284, -24591, -23793, -22911, -21962, -20970, -19961, -18955, -17974, -17046, -16183, -15409, -14742, -14196, -13784, -13521, -13409, -13457, -13666, -14036, -14562, -15239, -16058, -17003, -18062, -19220, -20451, -21738, -23060, -24388, -25699, -26973, -28176, -29290, -30288, -31143, -31840, -32355, -32670, -32771, -32644, -32279, -31670, -30810, -29703, -28346, -26749, -24923, -22871, -20616, -18178, -15565, -12814, -9947, -6983, -3962, -842};