/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0012 256 samples */
 
const int16_t AKWF_sinharm_0012_256_DATA [256] = 
{1177, 2884, 4548, 6205, 7842, 9460, 11052, 12609, 14134, 15620, 17060, 18456, 19802, 21089, 22324, 23497, 24605, 25652, 26630, 27538, 28376, 29143, 29836, 30457, 31002, 31473, 31871, 32195, 32445, 32625, 32732, 32769, 32741, 32647, 32490, 32271, 31994, 31662, 31276, 30842, 30362, 29838, 29276, 28677, 28046, 27387, 26703, 25998, 25275, 24539, 23793, 23041, 22283, 21529, 20778, 20032, 19295, 18574, 17865, 17177, 16509, 15861, 15239, 14644, 14075, 13537, 13028, 12549, 12105, 11692, 11310, 10963, 10645, 10361, 10109, 9886, 9693, 9529, 9391, 9279, 9192, 9126, 9081, 9054, 9044, 9047, 9062, 9089, 9121, 9160, 9201, 9243, 9283, 9320, 9349, 9372, 9385, 9385, 9371, 9343, 9297, 9233, 9149, 9044, 8916, 8766, 8594, 8398, 8176, 7931, 7663, 7369, 7052, 6712, 6348, 5965, 5560, 5136, 4693, 4234, 3759, 3272, 2769, 2259, 1740, 1214, 685, 152, -381, -913, -1440, -1964, -2479, -2986, -3483, -3964, -4432, -4886, -5320, -5736, -6132, -6507, -6860, -7191, -7498, -7781, -8039, -8275, -8485, -8671, -8834, -8974, -9092, -9188, -9263, -9319, -9357, -9379, -9387, -9382, -9364, -9338, -9305, -9267, -9225, -9184, -9143, -9107, -9077, -9055, -9045, -9047, -9064, -9099, -9152, -9227, -9324, -9447, -9596, -9772, -9978, -10214, -10478, -10778, -11108, -11469, -11866, -12291, -12750, -13242, -13763, -14315, -14895, -15502, -16135, -16792, -17468, -18166, -18880, -19608, -20349, -21098, -21851, -22606, -23364, -24112, -24854, -25586, -26302, -26997, -27673, -28319, -28936, -29521, -30067, -30572, -31033, -31447, -31810, -32120, -32371, -32565, -32696, -32761, -32761, -32695, -32557, -32347, -32065, -31710, -31281, -30779, -30201, -29549, -28825, -28028, -27158, -26222, -25214, -24139, -23005, -21805, -20547, -19235, -17867, -16451, -14993, -13489, -11949, -10378, -8773, -7146, -5501, -3838, -2170, -460};