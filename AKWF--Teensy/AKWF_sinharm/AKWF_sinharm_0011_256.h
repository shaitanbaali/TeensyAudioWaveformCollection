/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0011 256 samples */
 
const int16_t AKWF_sinharm_0011_256_DATA [256] = 
{964, 4536, 7981, 11344, 14569, 17626, 20481, 23090, 25434, 27487, 29218, 30621, 31680, 32383, 32732, 32725, 32372, 31679, 30664, 29349, 27752, 25902, 23835, 21571, 19153, 16621, 13999, 11337, 8672, 6031, 3463, 996, -1341, -3511, -5492, -7262, -8795, -10083, -11112, -11871, -12363, -12587, -12548, -12257, -11728, -10980, -10031, -8907, -7637, -6244, -4763, -3227, -1662, -106, 1408, 2854, 4199, 5415, 6479, 7365, 8055, 8533, 8787, 8808, 8591, 8136, 7449, 6534, 5409, 4083, 2577, 919, -870, -2765, -4726, -6731, -8745, -10728, -12656, -14491, -16197, -17752, -19123, -20282, -21209, -21884, -22288, -22411, -22244, -21784, -21030, -19988, -18668, -17078, -15244, -13185, -10919, -8485, -5908, -3218, -463, 2329, 5124, 7870, 10544, 13102, 15500, 17720, 19723, 21473, 22955, 24143, 25016, 25565, 25779, 25652, 25187, 24386, 23261, 21824, 20095, 18099, 15853, 13396, 10763, 7977, 5088, 2132, -859, -3833, -6755, -9592, -12292, -14829, -17170, -19274, -21121, -22686, -23944, -24887, -25496, -25766, -25698, -25291, -24555, -23499, -22140, -20503, -18602, -16472, -14148, -11652, -9023, -6305, -3523, -727, 2047, 4772, 7399, 9898, 12242, 14391, 16324, 18022, 19457, 20620, 21498, 22083, 22375, 22375, 22090, 21528, 20707, 19645, 18360, 16880, 15236, 13451, 11558, 9597, 7590, 5577, 3595, 1666, -171, -1887, -3463, -4867, -6079, -7087, -7872, -8426, -8745, -8826, -8670, -8287, -7686, -6881, -5890, -4737, -3443, -2036, -548, 995, 2560, 4110, 5621, 7055, 8380, 9571, 10598, 11434, 12059, 12454, 12601, 12490, 12113, 11469, 10553, 9375, 7945, 6273, 4381, 2288, 17, -2396, -4926, -7542, -10199, -12867, -15512, -18084, -20556, -22892, -25044, -26993, -28702, -30138, -31285, -32117, -32616, -32772, -32576, -32024, -31115, -29858, -28266, -26347, -24124, -21627, -18870, -15897, -12741, -9431, -6021, -2467};