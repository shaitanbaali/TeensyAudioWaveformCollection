/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0010 256 samples */
 
const int16_t AKWF_sinharm_0010_256_DATA [256] = 
{1467, 3594, 5661, 7706, 9712, 11676, 13587, 15428, 17201, 18898, 20505, 22026, 23451, 24775, 25998, 27119, 28132, 29040, 29843, 30541, 31137, 31634, 32035, 32342, 32563, 32702, 32764, 32757, 32685, 32554, 32371, 32145, 31877, 31578, 31252, 30903, 30541, 30169, 29789, 29410, 29032, 28661, 28298, 27947, 27607, 27283, 26972, 26679, 26402, 26140, 25892, 25661, 25443, 25238, 25044, 24861, 24685, 24519, 24357, 24202, 24053, 23907, 23765, 23628, 23494, 23364, 23239, 23121, 23010, 22906, 22812, 22730, 22661, 22606, 22570, 22550, 22552, 22576, 22621, 22693, 22789, 22910, 23058, 23230, 23428, 23649, 23890, 24153, 24432, 24723, 25025, 25331, 25636, 25941, 26232, 26507, 26762, 26987, 27178, 27326, 27428, 27475, 27461, 27381, 27228, 26999, 26687, 26290, 25802, 25224, 24550, 23778, 22913, 21950, 20891, 19743, 18502, 17175, 15768, 14282, 12728, 11112, 9437, 7715, 5956, 4162, 2349, 525, -1305, -3126, -4930, -6712, -8455, -10158, -11810, -13400, -14925, -16379, -17752, -19042, -20245, -21354, -22372, -23295, -24119, -24849, -25482, -26022, -26470, -26830, -27107, -27303, -27424, -27475, -27462, -27391, -27268, -27101, -26895, -26657, -26392, -26110, -25812, -25506, -25201, -24896, -24598, -24311, -24039, -23785, -23553, -23341, -23154, -22992, -22856, -22745, -22660, -22600, -22563, -22549, -22556, -22584, -22628, -22689, -22764, -22851, -22949, -23057, -23171, -23292, -23420, -23551, -23686, -23825, -23969, -24116, -24268, -24426, -24589, -24759, -24938, -25126, -25324, -25534, -25758, -25996, -26250, -26518, -26802, -27103, -27420, -27751, -28095, -28453, -28819, -29193, -29572, -29952, -30328, -30697, -31054, -31394, -31709, -31996, -32247, -32454, -32617, -32723, -32768, -32747, -32653, -32479, -32222, -31875, -31434, -30895, -30256, -29513, -28667, -27712, -26654, -25489, -24222, -22856, -21389, -19829, -18186, -16454, -14651, -12781, -10845, -8861, -6838, -4780, -2704, -574};