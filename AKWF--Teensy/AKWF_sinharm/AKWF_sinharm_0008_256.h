/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0008 256 samples */
 
const int16_t AKWF_sinharm_0008_256_DATA [256] = 
{1548, 3784, 5946, 8065, 10117, 12090, 13970, 15735, 17381, 18895, 20265, 21489, 22562, 23474, 24233, 24836, 25285, 25589, 25750, 25780, 25686, 25484, 25184, 24799, 24345, 23838, 23291, 22721, 22146, 21578, 21032, 20524, 20065, 19668, 19341, 19097, 18939, 18876, 18909, 19041, 19272, 19602, 20025, 20538, 21133, 21799, 22533, 23319, 24143, 25000, 25871, 26740, 27601, 28436, 29227, 29968, 30644, 31241, 31753, 32169, 32479, 32680, 32767, 32736, 32585, 32318, 31935, 31439, 30841, 30143, 29355, 28491, 27557, 26568, 25539, 24479, 23407, 22338, 21280, 20252, 19270, 18339, 17477, 16694, 15997, 15396, 14897, 14505, 14223, 14052, 13991, 14038, 14187, 14434, 14769, 15185, 15670, 16209, 16793, 17406, 18031, 18655, 19262, 19835, 20359, 20819, 21198, 21487, 21668, 21734, 21673, 21477, 21141, 20659, 20027, 19247, 18318, 17245, 16034, 14688, 13220, 11642, 9958, 8191, 6353, 4454, 2519, 563, -1401, -3350, -5270, -7147, -8955, -10687, -12330, -13861, -15278, -16569, -17721, -18732, -19599, -20315, -20883, -21303, -21578, -21716, -21720, -21605, -21376, -21047, -20633, -20142, -19596, -19007, -18391, -17764, -17143, -16540, -15973, -15456, -14999, -14617, -14318, -14112, -14005, -14004, -14112, -14331, -14659, -15098, -15641, -16283, -17019, -17836, -18729, -19685, -20686, -21729, -22794, -23865, -24934, -25983, -26996, -27963, -28870, -29701, -30453, -31109, -31664, -32113, -32446, -32664, -32764, -32744, -32608, -32360, -32004, -31546, -30996, -30364, -29660, -28895, -28084, -27237, -26369, -25499, -24632, -23787, -22979, -22213, -21506, -20870, -20309, -19833, -19450, -19162, -18973, -18883, -18891, -18996, -19191, -19472, -19830, -20254, -20736, -21261, -21819, -22392, -22966, -23528, -24061, -24546, -24972, -25324, -25583, -25740, -25783, -25698, -25477, -25112, -24598, -23929, -23104, -22124, -20986, -19698, -18267, -16695, -14995, -13182, -11259, -9250, -7168, -5027, -2850, -606};