/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0006 256 samples */
 
const int16_t AKWF_sinharm_0006_256_DATA [256] = 
{1714, 4197, 6603, 8975, 11288, 13534, 15700, 17765, 19726, 21572, 23289, 24874, 26322, 27620, 28775, 29780, 30633, 31339, 31899, 32315, 32594, 32741, 32764, 32671, 32469, 32170, 31782, 31317, 30786, 30196, 29561, 28891, 28192, 27479, 26758, 26037, 25324, 24624, 23943, 23288, 22660, 22060, 21495, 20960, 20457, 19984, 19539, 19121, 18724, 18345, 17978, 17623, 17270, 16915, 16555, 16184, 15796, 15390, 14960, 14503, 14018, 13502, 12954, 12375, 11765, 11128, 10462, 9773, 9067, 8345, 7613, 6880, 6151, 5432, 4732, 4057, 3415, 2814, 2260, 1761, 1323, 952, 652, 430, 287, 226, 249, 357, 547, 819, 1170, 1595, 2090, 2649, 3261, 3921, 4622, 5350, 6098, 6854, 7606, 8344, 9058, 9735, 10364, 10937, 11441, 11869, 12213, 12465, 12618, 12669, 12613, 12446, 12169, 11783, 11286, 10684, 9982, 9181, 8293, 7323, 6279, 5174, 4020, 2822, 1597, 357, -888, -2123, -3338, -4519, -5654, -6733, -7748, -8683, -9534, -10295, -10954, -11512, -11962, -12302, -12531, -12651, -12661, -12566, -12369, -12078, -11697, -11235, -10701, -10103, -9452, -8759, -8033, -7287, -6533, -5778, -5037, -4320, -3635, -2994, -2404, -1871, -1406, -1012, -694, -457, -301, -230, -242, -339, -516, -772, -1102, -1503, -1967, -2491, -3066, -3685, -4342, -5029, -5737, -6462, -7194, -7926, -8655, -9372, -10070, -10750, -11404, -12029, -12627, -13192, -13726, -14229, -14702, -15147, -15567, -15964, -16345, -16710, -17068, -17421, -17775, -18133, -18505, -18892, -19297, -19725, -20183, -20667, -21184, -21732, -22312, -22925, -23565, -24231, -24921, -25628, -26343, -27066, -27785, -28493, -29181, -29837, -30454, -31020, -31524, -31958, -32309, -32568, -32724, -32769, -32694, -32492, -32155, -31678, -31056, -30287, -29370, -28301, -27083, -25723, -24215, -22571, -20800, -18904, -16895, -14789, -12585, -10309, -7969, -5578, -3159, -671};