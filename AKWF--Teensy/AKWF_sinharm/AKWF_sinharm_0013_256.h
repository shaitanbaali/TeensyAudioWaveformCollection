/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0013 256 samples */
 
const int16_t AKWF_sinharm_0013_256_DATA [256] = 
{1230, 3013, 4750, 6473, 8168, 9835, 11466, 13050, 14587, 16071, 17495, 18859, 20161, 21389, 22554, 23646, 24662, 25610, 26487, 27290, 28024, 28692, 29292, 29829, 30308, 30727, 31095, 31412, 31684, 31915, 32109, 32268, 32398, 32502, 32582, 32645, 32690, 32723, 32746, 32760, 32765, 32766, 32765, 32758, 32749, 32736, 32720, 32703, 32679, 32651, 32617, 32576, 32525, 32464, 32393, 32308, 32209, 32094, 31964, 31816, 31650, 31465, 31264, 31044, 30804, 30549, 30276, 29988, 29687, 29373, 29048, 28717, 28377, 28033, 27690, 27345, 27004, 26668, 26339, 26020, 25713, 25418, 25137, 24873, 24623, 24392, 24176, 23975, 23791, 23622, 23463, 23316, 23177, 23043, 22911, 22778, 22641, 22497, 22339, 22164, 21969, 21750, 21501, 21221, 20902, 20542, 20140, 19691, 19191, 18642, 18037, 17377, 16664, 15892, 15065, 14186, 13252, 12265, 11232, 10152, 9028, 7869, 6673, 5450, 4202, 2934, 1655, 369, -920, -2204, -3477, -4739, -5976, -7187, -8370, -9513, -10619, -11680, -12693, -13657, -14569, -15425, -16229, -16976, -17665, -18303, -18883, -19411, -19889, -20318, -20701, -21043, -21346, -21611, -21847, -22056, -22241, -22409, -22560, -22701, -22835, -22968, -23100, -23235, -23378, -23530, -23693, -23868, -24059, -24267, -24489, -24728, -24984, -25256, -25542, -25843, -26155, -26478, -26810, -27149, -27492, -27837, -28180, -28523, -28859, -29187, -29509, -29817, -30113, -30394, -30660, -30908, -31141, -31352, -31546, -31723, -31882, -32021, -32145, -32253, -32345, -32425, -32491, -32548, -32595, -32633, -32664, -32690, -32711, -32727, -32742, -32753, -32762, -32766, -32766, -32764, -32755, -32737, -32710, -32672, -32620, -32551, -32460, -32346, -32204, -32030, -31822, -31574, -31283, -30944, -30554, -30111, -29608, -29044, -28415, -27720, -26956, -26122, -25215, -24237, -23190, -22066, -20872, -19615, -18286, -16894, -15446, -13938, -12379, -10776, -9129, -7448, -5741, -4009, -2268, -482};