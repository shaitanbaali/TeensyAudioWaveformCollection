/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_sinharm_0007 256 samples */
 
const int16_t AKWF_sinharm_0007_256_DATA [256] = 
{1709, 4181, 6570, 8918, 11196, 13395, 15499, 17485, 19350, 21081, 22662, 24095, 25371, 26484, 27436, 28227, 28858, 29336, 29663, 29851, 29909, 29846, 29676, 29411, 29068, 28658, 28197, 27701, 27188, 26665, 26154, 25666, 25212, 24807, 24457, 24173, 23964, 23832, 23783, 23820, 23941, 24146, 24431, 24792, 25224, 25714, 26259, 26846, 27464, 28102, 28744, 29380, 29998, 30581, 31120, 31601, 32012, 32343, 32586, 32729, 32768, 32696, 32511, 32211, 31792, 31259, 30613, 29860, 29008, 28060, 27027, 25925, 24760, 23544, 22297, 21027, 19749, 18484, 17239, 16031, 14876, 13783, 12767, 11840, 11007, 10280, 9666, 9168, 8790, 8534, 8396, 8380, 8477, 8683, 8989, 9386, 9864, 10410, 11012, 11656, 12326, 13008, 13684, 14340, 14961, 15531, 16032, 16456, 16789, 17018, 17131, 17124, 16987, 16716, 16307, 15761, 15077, 14256, 13308, 12233, 11043, 9750, 8357, 6886, 5349, 3754, 2125, 475, -1182, -2825, -4440, -6014, -7524, -8962, -10316, -11565, -12706, -13729, -14623, -15386, -16012, -16499, -16848, -17062, -17143, -17098, -16934, -16660, -16286, -15827, -15296, -14702, -14063, -13398, -12717, -12037, -11378, -10750, -10169, -9652, -9206, -8847, -8583, -8423, -8373, -8441, -8629, -8937, -9367, -9915, -10577, -11350, -12226, -13191, -14241, -15363, -16541, -17766, -19023, -20294, -21571, -22833, -24067, -25264, -26404, -27477, -28476, -29384, -30193, -30902, -31501, -31984, -32354, -32604, -32741, -32764, -32681, -32494, -32211, -31846, -31403, -30896, -30337, -29738, -29109, -28470, -27829, -27197, -26592, -26021, -25498, -25032, -24629, -24299, -24049, -23879, -23794, -23794, -23879, -24044, -24286, -24599, -24974, -25400, -25871, -26370, -26888, -27409, -27916, -28399, -28841, -29224, -29535, -29761, -29886, -29900, -29787, -29541, -29151, -28607, -27909, -27050, -26028, -24847, -23503, -22005, -20361, -18571, -16652, -14616, -12467, -10233, -7924, -5553, -3148, -669};