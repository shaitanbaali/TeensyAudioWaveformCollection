/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0144 256 samples */
 
const int16_t AKWF_oscchip_0144_256_DATA [256] = 
{10554, 11599, 11350, 11394, 11396, 11458, 11177, 12434, 21188, 22504, 22182, 22251, 22252, 22270, 22205, 22451, 26316, 27314, 27099, 27141, 27140, 27153, 27136, 27132, 31212, 32824, 32509, 32569, 32567, 32568, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32521, 32687, 32061, 22183, 19635, 20189, 20080, 20080, 19987, 20111, 20137, -8835, -20280, -18030, -18465, -18459, -18533, -18164, -19972, -27314, -27789, -27647, -27687, -27689, -27702, -27646, -27896, -29645, -29907, -29844, -29859, -29858, -29863, -29848, -29903, -30762, -30984, -30937, -30945, -30946, -30943, -30946, -30947, -30129, -29805, -29870, -29858, -29858, -29872, -29806, -30126, -31422, -31505, -31482, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31397, -31853, -29619, -20548, -19961, -20133, -20087, -20087, -19978, -20470, -18269, -2952, -648, -1210, -1090, -1090, -999, -1324, -99, 19228, 24214, 23130, 23342, 23341, 23302, 23354, 23365, 11120, 6283, 7235, 7051, 7054, 7006, 7244, 6075, 1324, 1018, 1110, 1084, 1084, 1074, 1117, 927, -386, -585, -537, -546, -546, -551, -536, -591, -1450, -1671, -1623, -1634, -1633, -1635, -1633, -1633, -2040, -2201, -2168, -2174, -2174, -2178, -2156, -2263, -2696, -2724, -2715, -2717, -2717, -2721, -2706, -2770, -3208, -3273, -3257, -3261, -3260, -3265, -3250, -3305, -4162, -4384, -4337, -4345, -4346, -4348, -4345, -4344, -5160, -5482, -5419, -5430, -5429, -5438, -5395, -5607, -6472, -6527, -6512, -6517, -6516, -6523, -6495, -6620, -7496, -7626, -7595, -7604, -7603, -7607, -7593, -7647, -8504, -8727, -8680, -8691, -8690, -8701, -8687, -8683, -11945, -13234, -12982, -13030, -13029, -12888, -13648, -9573};