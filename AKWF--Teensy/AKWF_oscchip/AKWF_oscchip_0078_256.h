/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0078 256 samples */
 
const int16_t AKWF_oscchip_0078_256_DATA [256] = 
{12447, 14298, 13918, 13989, 13996, 14042, 13894, 14390, 23971, 26109, 25635, 25727, 25726, 25745, 25630, 26179, 28262, 28338, 28311, 28314, 28310, 28304, 28299, 28294, 28288, 28282, 28276, 28270, 28264, 28258, 28252, 28245, 28239, 28232, 28225, 28218, 28211, 28199, 28217, 28087, 27553, 27519, 27520, 27511, 27504, 27493, 27501, 27428, 26884, 26802, 26814, 26803, 26795, 26783, 26794, 26726, 25137, 24725, 24810, 24784, 24778, 24765, 24785, 24661, 24116, 24087, 24089, 24080, 24073, 24062, 24071, 24005, 23452, 23374, 23387, 23376, 23369, 23349, 23417, 23033, 22021, 22036, 22027, 22018, 22013, 22001, 22022, 21893, 21359, 21328, 21328, 21319, 21314, 21294, 21349, 21101, 18934, 18624, 18687, 18668, 18662, 18631, 18760, 18053, 16023, 16023, 16025, 16013, 16008, 15980, 16092, 15528, 12887, 12692, 12738, 12724, 12720, 12696, 12773, 12422, 9229, 8695, 8809, 8780, 8776, 8705, 9060, 7272, 1571, 1579, 1608, 1587, 1585, 1557, 1685, 1091, -2141, -2381, -2312, -2330, -2331, -2334, -2324, -2370, -2912, -3008, -2984, -2989, -2988, -3015, -2876, -3543, -5613, -5592, -5588, -5592, -5590, -5591, -5589, -5588, -5588, -5587, -5586, -5585, -5584, -5687, -5253, -6863, -26954, -30323, -29515, -29675, -29672, -29673, -29636, -29797, -30309, -30308, -30301, -30297, -30291, -30294, -30243, -30437, -31495, -31577, -31548, -31546, -31538, -31534, -31515, -31552, -32078, -32170, -32139, -32135, -32128, -32125, -32088, -32228, -32739, -32743, -32727, -32721, -32713, -32700, -32710, -32615, -32076, -32009, -32014, -32004, -31995, -31986, -31978, -31969, -31960, -31951, -31944, -31936, -31927, -31918, -31909, -31900, -31892, -31883, -31876, -31867, -31858, -31850, -31841, -31832, -31823, -31816, -31808, -31799, -31790, -31766, -31840, -31408, -30416, -30455, -30440, -30430, -30422, -30330, -30756, -28724, -21354, -21224, -21271, -21243, -21234, -21098, -21781, -18523};