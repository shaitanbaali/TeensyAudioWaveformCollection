/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0129 256 samples */
 
const int16_t AKWF_oscchip_0129_256_DATA [256] = 
{28628, 31106, 30516, 30620, 30623, 30600, 30706, 30233, 26938, 26441, 26564, 26539, 26539, 26519, 26591, 26319, 22013, 20901, 21144, 21095, 21094, 21039, 21328, 19766, 15631, 15644, 15661, 15650, 15650, 15623, 15759, 15092, 12386, 12209, 12262, 12248, 12248, 12197, 12427, 11402, 4267, 3193, 3458, 3402, 3402, 3381, 3454, 3180, -1128, -2241, -2000, -2047, -2046, -2081, -1900, -2877, -5459, -5451, -5441, -5448, -5448, -5470, -5362, -5894, -8056, -8198, -8157, -8168, -8168, -8176, -8141, -8298, -9396, -9559, -9519, -9529, -9528, -9528, -9528, -9528, -9528, -9528, -9528, -9528, -9528, -9487, -9704, -8533, -5432, -5441, -5456, -5449, -5448, -5405, -5622, -4555, -221, 61, -23, -1, -1, 15, -55, 259, 2453, 2783, 2701, 2720, 2720, 2732, 2687, 2858, 5549, 6242, 6092, 6122, 6122, 6135, 6063, 6454, 7487, 7482, 7478, 7482, 7482, 7482, 7482, 7482, 7482, 7482, 7482, 7482, 7482, 7470, 7523, 7286, 5640, 5393, 5453, 5440, 5440, 5425, 5479, 5274, 2047, 1214, 1395, 1359, 1360, 1339, 1447, 861, -693, -688, -681, -685, -685, -702, -620, -1020, -2644, -2750, -2718, -2728, -2729, -2744, -2674, -2989, -5180, -5511, -5431, -5448, -5448, -5451, -5442, -5475, -6013, -6152, -6121, -6126, -6127, -6133, -6097, -6293, -6810, -6808, -6807, -6808, -6808, -6803, -6830, -6696, -6154, -6120, -6129, -6127, -6126, -6092, -6250, -5541, -601, 142, -39, -1, -1, 12, -33, 138, 2829, 3521, 3370, 3402, 3402, 3402, 3402, 3402, 3402, 3402, 3402, 3402, 3402, 3385, 3467, 3067, 1442, 1337, 1369, 1360, 1360, 1344, 1415, 1099, -1099, -1429, -1349, -1365, -1364, -1382, -1319, -1558, -5326, -6297, -6087, -6127, -6126, -6340, -5220, -11274, -27297, -27246, -27178, -27224, -27226, -26891, -28691, -19039};