/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0024 256 samples */
 
const int16_t AKWF_oscchip_0024_256_DATA [256] = 
{21736, 29871, 28162, 28486, 28483, 28495, 28449, 28611, 30962, 31445, 31328, 31343, 31333, 31330, 31296, 31383, 32546, 32762, 32696, 32693, 32679, 32364, 33625, 28031, -19348, -27697, -25729, -26142, -26147, -26107, -26299, -25498, -19600, -18769, -18963, -18917, -18911, -18884, -18979, -18528, -15344, -14951, -15044, -15014, -15007, -14980, -15074, -14600, -11858, -11538, -11613, -11587, -11580, -11554, -11634, -11233, -9279, -9103, -9139, -9121, -9115, -9094, -9162, -8812, -7240, -7139, -7161, -7151, -7144, -7133, -7164, -6977, -6194, -6148, -6157, -6149, -6143, -6132, -6171, -5956, -5187, -5151, -5160, -5152, -5149, -5125, -5218, -4755, -3224, -3196, -3205, -3196, -3195, -3184, -3226, -2979, -2222, -2218, -2218, -2215, -2213, -2188, -2310, -1647, 205, 205, 197, 204, 206, 212, 196, 238, 2158, 2710, 2594, 2617, 2617, 2628, 2596, 2703, 5377, 6112, 5950, 5980, 5978, 5978, 5977, 5974, 5970, 5969, 5968, 5966, 5960, 5959, 5958, 5954, 5950, 5949, 5946, 5941, 5940, 5940, 5926, 5957, 6346, 6420, 6399, 6400, 6395, 6393, 6391, 6385, 6383, 6379, 6375, 6374, 6367, 6365, 6364, 6358, 6355, 6353, 6345, 6345, 6341, 6338, 6325, 6374, 6770, 6813, 6796, 6796, 6793, 6785, 6798, 6727, 6332, 6284, 6291, 6287, 6281, 6267, 6318, 6077, 4905, 4800, 4824, 4814, 4808, 4800, 4833, 4658, 3873, 3823, 3832, 3828, 3826, 3809, 3864, 3587, 2414, 2349, 2367, 2360, 2359, 2344, 2386, 2176, 1412, 1378, 1384, 1380, 1380, 1365, 1436, 1088, -53, -74, -67, -70, -70, -74, -69, -73, -1179, -1584, -1503, -1520, -1520, -1539, -1492, -1597, -6850, -8540, -8187, -8254, -8253, -8286, -8189, -8427, -19559, -22746, -22065, -22187, -22181, -22172, -22174, -22137, -21359, -21143, -21182, -21161, -21153, -21050, -21536, -19261};