/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0050 256 samples */
 
const int16_t AKWF_oscchip_0050_256_DATA [256] = 
{1048, 1976, 1820, 1853, 1853, 1867, 1799, 2128, 3769, 3976, 3922, 3931, 3930, 3944, 3888, 4113, 6537, 7164, 7022, 7049, 7049, 7050, 7044, 7052, 7805, 8128, 8064, 8074, 8072, 8067, 8067, 8047, 8382, 8603, 8565, 8568, 8566, 8579, 8495, 8857, 11318, 11750, 11637, 11659, 11651, 11658, 11623, 11723, 13695, 14341, 14199, 14223, 14216, 14225, 14213, 14135, 18124, 20206, 19826, 19895, 19885, 19905, 19766, 20394, 23248, 23556, 23460, 23472, 23462, 23474, 23380, 23706, 26960, 27713, 27526, 27551, 27539, 27531, 27512, 27521, 28672, 29119, 29014, 29019, 29005, 28991, 28976, 28994, 28289, 27837, 27896, 27867, 27855, 27828, 27875, 27585, 25932, 25655, 25708, 25677, 25664, 25635, 25679, 25470, 22249, 21271, 21467, 21411, 21400, 21383, 21375, 21394, 19150, 18051, 18243, 18192, 18182, 18134, 18301, 17425, 13751, 13371, 13464, 13427, 13419, 13410, 13401, 13391, 13382, 13374, 13367, 13359, 13348, 13206, 13535, 12699, -20837, -33516, -30919, -31453, -31437, -31432, -31425, -31481, -30063, -29219, -29356, -29322, -29315, -29299, -29322, -29167, -28339, -28203, -28224, -28204, -28195, -28175, -28195, -28062, -26446, -25977, -26065, -26032, -26020, -26006, -25995, -25985, -25598, -25408, -25429, -25409, -25397, -25384, -25365, -25397, -24719, -24234, -24295, -24268, -24258, -24236, -24258, -24088, -22853, -22582, -22630, -22604, -22594, -22570, -22589, -22486, -20130, -19275, -19437, -19391, -19381, -19367, -19355, -19370, -18644, -18231, -18291, -18263, -18255, -18219, -18327, -17774, -14886, -14477, -14573, -14542, -14532, -14522, -14522, -14478, -14068, -13950, -13965, -13951, -13943, -13927, -13933, -13913, -11647, -10631, -10816, -10771, -10764, -10751, -10730, -10835, -8817, -7431, -7641, -7594, -7587, -7555, -7665, -7153, -3457, -2748, -2913, -2872, -2868, -2859, -2876, -2801, -1224, -678, -788, -761, -762, -755, -760, -723};