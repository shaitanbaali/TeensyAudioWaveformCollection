/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0074 256 samples */
 
const int16_t AKWF_oscchip_0074_256_DATA [256] = 
{96, 141, 134, 135, 135, 136, 136, 136, 136, 136, 136, 136, 136, 136, 136, 136, 136, 136, 136, 136, 136, 140, 122, 193, 997, 1146, 1112, 1118, 1119, 1119, 1119, 1118, 1117, 1117, 1117, 1117, 1117, 1120, 1104, 1172, 1579, 1614, 1603, 1606, 1605, 1617, 1553, 1896, 2625, 2581, 2588, 2588, 2589, 2598, 2547, 2776, 3568, 3569, 3564, 3567, 3566, 3574, 3527, 3729, 4958, 5058, 5031, 5036, 5036, 5046, 4984, 5318, 6045, 6012, 6014, 6014, 6013, 6033, 5916, 6491, 8438, 8474, 8458, 8462, 8461, 8478, 8385, 8780, 11207, 11449, 11386, 11396, 11395, 11435, 11203, 12445, 15412, 15308, 15313, 15317, 15314, 15363, 15086, 16439, 21565, 21738, 21671, 21689, 21684, 21687, 21643, 21818, 23022, 23163, 23120, 23123, 23120, 22481, 25838, 8523, -33571, -31767, -31951, -32019, -32020, -31880, -32600, -29262, -15551, -15173, -15332, -15274, -15271, -15241, -15365, -14829, -10711, -10241, -10364, -10333, -10332, -10302, -10448, -9676, -7797, -7864, -7851, -7846, -7843, -7827, -7891, -7581, -6385, -6348, -6358, -6352, -6350, -6342, -6367, -6256, -5434, -5337, -5358, -5349, -5348, -5341, -5366, -5221, -4845, -4849, -4847, -4845, -4843, -4834, -4871, -4679, -3887, -3845, -3856, -3851, -3850, -3844, -3867, -3759, -2951, -2839, -2864, -2859, -2858, -2853, -2877, -2741, -2355, -2360, -2358, -2357, -2356, -2351, -2369, -2281, -1876, -1852, -1859, -1855, -1856, -1855, -1853, -1854, -1853, -1851, -1852, -1851, -1850, -1849, -1850, -1848, -1847, -1848, -1847, -1845, -1845, -1842, -1860, -1776, -1369, -1347, -1354, -1353, -1352, -1350, -1351, -1351, -1350, -1349, -1348, -1348, -1349, -1343, -1368, -1235, -850, -855, -856, -853, -854, -850, -869, -782, -379, -354, -358, -357, -357, -355, -361, -334};