/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0097 256 samples */
 
const int16_t AKWF_oscchip_0097_256_DATA [256] = 
{534, 737, 698, 704, 704, 708, 712, 672, 1874, 2412, 2310, 2328, 2329, 2330, 2350, 2225, 3659, 4615, 4455, 4485, 4484, 4496, 4470, 4514, 8834, 10107, 9823, 9876, 9874, 9877, 9897, 9735, 12926, 14419, 14122, 14178, 14174, 14175, 14271, 13710, 19391, 23350, 22663, 22786, 22782, 22800, 22750, 22795, 30607, 32874, 32375, 32462, 32456, 32448, 32436, 32473, 31661, 31282, 31349, 31328, 31321, 31312, 31288, 31388, 30316, 29563, 29680, 29646, 29640, 29630, 29627, 29607, 28750, 28481, 28526, 28509, 28500, 28490, 28472, 28544, 26962, 26192, 26322, 26289, 26281, 26272, 26220, 26483, 23680, 21668, 21979, 21913, 21907, 21890, 21896, 21887, 18523, 17366, 17595, 17546, 17540, 17529, 17489, 17702, 13839, 11811, 12177, 12104, 12099, 12079, 12131, 11926, 8355, 7620, 7787, 7749, 7746, 7734, 7735, 7782, 4381, 3213, 3463, 3412, 3411, 3404, 3369, 3585, 489, -1173, -858, -921, -921, -941, -876, -1107, -4657, -5371, -5207, -5238, -5239, -5252, -5236, -5200, -10285, -12001, -11648, -11713, -11712, -11713, -11735, -11571, -13899, -15126, -14896, -14937, -14934, -14946, -14893, -15073, -18119, -18815, -18661, -18686, -18683, -18688, -18678, -18641, -22355, -23743, -23467, -23511, -23507, -23507, -23539, -23295, -27055, -29177, -28802, -28862, -28857, -28862, -28818, -28937, -31990, -32744, -32565, -32591, -32584, -32576, -32568, -32561, -32553, -32546, -32537, -32530, -32522, -32514, -32506, -32497, -32488, -32481, -32473, -32464, -32456, -32442, -32450, -32391, -31057, -30737, -30800, -30778, -30769, -30742, -30707, -31024, -21878, -18248, -18988, -18839, -18834, -18819, -18701, -19382, -11497, -6760, -7629, -7457, -7454, -7441, -7464, -7374, -5187, -4637, -4750, -4722, -4719, -4712, -4706, -4757, -2709, -1882, -2038, -2005, -2003, -2001, -1985, -2075, -967, -284, -400, -378, -377, -375, -379, -355};