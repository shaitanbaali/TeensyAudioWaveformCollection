/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0045 256 samples */
 
const int16_t AKWF_oscchip_0045_256_DATA [256] = 
{284, 338, 321, 323, 323, 331, 296, 454, 1348, 1487, 1450, 1455, 1456, 1456, 1456, 1456, 1456, 1456, 1456, 1455, 1454, 1457, 1451, 1460, 2294, 2645, 2574, 2584, 2585, 2583, 2583, 2583, 2582, 2581, 2581, 2581, 2580, 2578, 2579, 2579, 2577, 2577, 2577, 2575, 2574, 2634, 2412, 3261, 13794, 16661, 16044, 16165, 16160, 16012, 16760, 12317, 2395, 2532, 2561, 2526, 2524, 2524, 2516, 2507, 2506, 2505, 2503, 2502, 2501, 2500, 2498, 2497, 2496, 2484, 2482, 2481, 2481, 2479, 2479, 2478, 2477, 2476, 2475, 2475, 2474, 2472, 2472, 2472, 2463, 2458, 2457, 2457, 2456, 2444, 2493, 2237, 1363, 1307, 1324, 1319, 1317, 1316, 1317, 1317, 1315, 1314, 1314, 1316, 1307, 1300, 1301, 1301, 1300, 1298, 1299, 1298, 1302, 947, 2779, -7942, -31929, -31599, -31512, -31579, -31581, -31291, -32665, -25514, -1010, 569, 76, 227, 233, 233, 268, 113, -778, -915, -876, -879, -879, -903, -762, -1733, -3229, -3126, -3136, -3136, -3137, -3129, -3122, -3121, -3121, -3119, -3119, -3117, -3117, -3115, -3114, -3114, -3113, -3112, -3112, -3102, -3096, -3089, -3121, -2967, -2079, -1934, -1967, -1958, -1959, -1957, -1956, -1956, -1954, -1955, -1954, -1942, -1940, -1941, -1939, -1938, -1939, -1938, -1936, -1937, -1939, -1773, -2566, 1514, 15514, 16412, 16133, 16210, 16205, 16021, 17082, 7289, -2919, -1749, -1951, -1958, -1961, -1961, -1963, -1962, -1963, -1965, -1964, -1964, -1964, -1964, -1964, -1964, -1964, -1964, -1964, -1964, -1964, -1964, -1965, -1964, -1963, -1962, -1963, -1962, -1962, -1951, -2016, -1401, -763, -837, -827, -826, -825, -826, -825, -825, -826, -824, -823, -824, -823, -824, -817, -811, -812, -811, -811, -812, -812, -802, -844, -613};