/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0051 256 samples */
 
const int16_t AKWF_oscchip_0051_256_DATA [256] = 
{1490, 2610, 2450, 2480, 2478, 2477, 2500, 2372, 3434, 4659, 4527, 4549, 4546, 4559, 4525, 4615, 7995, 9305, 9042, 9094, 9091, 9091, 9096, 9013, 10962, 12136, 11936, 11970, 11965, 11965, 11987, 11805, 13711, 15441, 15211, 15248, 15241, 15233, 15243, 15157, 15722, 16511, 16438, 16440, 16435, 16426, 16421, 16418, 15817, 15525, 15570, 15553, 15545, 15535, 15519, 15581, 14529, 13759, 13865, 13835, 13829, 13821, 13780, 13969, 12217, 10308, 10509, 10464, 10460, 10445, 10460, 10396, 8523, 7826, 7963, 7929, 7923, 7913, 7901, 7984, 5442, 3961, 4215, 4161, 4156, 4153, 4150, 4145, 4144, 4138, 4135, 4133, 4128, 4123, 3728, 5901, -10981, -33122, -31189, -31502, -31510, -31504, -31504, -31498, -30280, -29738, -29834, -29805, -29797, -29787, -29772, -29794, -29251, -28866, -28914, -28891, -28880, -28856, -28502, -30513, -11662, 8253, 6007, 6419, 6425, 6431, 6433, 6463, 6293, 6022, 6041, 6043, 6047, 6046, 6047, 6056, 5770, 5613, 5640, 5633, 5634, 5634, 5630, 5650, 5401, 5192, 5220, 5214, 5211, 5208, 5200, 5249, 4843, 4334, 4380, 4371, 4369, 4293, 4422, 4256, -14601, -22573, -21025, -21333, -21323, -21291, -21177, -22054, -5724, 4971, 3230, 3562, 3558, 3561, 3557, 3606, 3152, 2694, 2749, 2742, 2742, 2742, 2742, 2742, 2742, 2742, 2742, 2742, 2741, 2708, 2714, 2947, -8106, -13827, -12803, -13005, -12997, -12993, -12964, -13136, -10847, -9045, -9303, -9250, -9248, -9243, -9221, -9319, -8485, -7484, -7581, -7562, -7555, -7545, -7557, -7520, -5991, -5371, -5485, -5458, -5457, -5450, -5441, -5493, -4385, -3692, -3802, -3776, -3776, -3771, -3743, -3880, -2467, -1136, -1303, -1271, -1269, -1264, -1253, -1304, -931, -396, -438, -429, -428, -426, -425, -429, -133, 12, -11, -5, -6, -5, -3, -7};