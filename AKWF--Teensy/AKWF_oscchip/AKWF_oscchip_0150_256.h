/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0150 256 samples */
 
const int16_t AKWF_oscchip_0150_256_DATA [256] = 
{27376, 29494, 28989, 29080, 29083, 29089, 29063, 29180, 30002, 30127, 30096, 30102, 30102, 30056, 30311, 28741, 25882, 26045, 26022, 26021, 26020, 25969, 26240, 24775, 20897, 20910, 20925, 20913, 20913, 20835, 21222, 19325, 11613, 11115, 11262, 11222, 11221, 11189, 11334, 10683, 6159, 5477, 5643, 5610, 5610, 5546, 5897, 3739, -190, 35, 4, 0, 0, -32, 131, -747, -3074, -3067, -3055, -3062, -3062, -3095, -2932, -3732, -6978, -7189, -7127, -7144, -7144, -7179, -7021, -7729, -12666, -13409, -13228, -13264, -13264, -13323, -13003, -14965, -18542, -18337, -18366, -18372, -18371, -18413, -18196, -19368, -22468, -22457, -22444, -22453, -22453, -22511, -22225, -23625, -29308, -29675, -29567, -29597, -29597, -29615, -29536, -29890, -32356, -32727, -32637, -32655, -32655, -32562, -33073, -29936, -24218, -24544, -24501, -24492, -24491, -24471, -24579, -23995, -22447, -22454, -22458, -22454, -22454, -22421, -22584, -21783, -18535, -18325, -18387, -18372, -18371, -18287, -18670, -16955, -5024, -3229, -3669, -3574, -3572, -3549, -3677, -2892, -1465, -1548, -1537, -1534, -1535, -1514, -1622, -1035, 515, 512, 504, 508, 509, 521, 460, 760, 1978, 2056, 2031, 2037, 2038, 2046, 2007, 2184, 3418, 3605, 3559, 3565, 3566, 3595, 3435, 4417, 6204, 6102, 6117, 6120, 6120, 6166, 5923, 7239, 10728, 10719, 10702, 10710, 10711, 10748, 10564, 11465, 15119, 15356, 15286, 15307, 15308, 15331, 15226, 15697, 18986, 19480, 19358, 19385, 19385, 19432, 19176, 20746, 23608, 23443, 23466, 23468, 23467, 23385, 23818, 21477, 15277, 15297, 15325, 15308, 15308, 15226, 15634, 13633, 5510, 4984, 5141, 5101, 5101, 5002, 5451, 3441, -10547, -12651, -12137, -12245, -12245, -12316, -11932, -14287, -18577, -18330, -18366, -18372, -18371, -18392, -18284, -18870, -20416, -20413, -20405, -20409, -20409, -20123, -21663, -13406};