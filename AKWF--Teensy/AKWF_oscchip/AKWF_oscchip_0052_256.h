/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0052 256 samples */
 
const int16_t AKWF_oscchip_0052_256_DATA [256] = 
{14328, 25362, 23626, 23954, 23942, 23940, 23925, 23975, 23434, 22917, 22975, 22957, 22950, 22942, 22860, 23250, 20218, 15989, 16316, 16258, 16246, 16236, 16186, 16394, 15047, 12348, 12407, 12402, 12388, 12375, 12354, 12455, 10588, 9340, 9535, 9489, 9483, 9477, 9448, 9576, 8234, 6951, 7110, 7073, 7070, 7063, 7033, 7170, 6083, 4570, 4686, 4663, 4659, 4654, 4651, 4648, 4300, 4142, 4169, 4159, 4155, 4154, 4147, 4161, 3848, 3641, 3671, 3662, 3662, 3658, 3635, 3742, 2671, 1645, 1777, 1750, 1747, 1748, 1733, 1787, 1356, 752, 800, 792, 786, 783, 787, 785, 98, -209, -151, -163, -163, -168, -171, -153, -461, -668, -636, -642, -642, -642, -646, -620, -887, -1144, -1110, -1116, -1115, -1115, -1115, -1115, -1115, -1115, -1115, -1116, -1115, -1116, -1112, -1114, -1801, -2109, -2051, -2066, -2063, -2059, -2060, -2058, -2057, -2057, -2058, -2057, -2055, -2056, -2056, -2055, -2054, -2054, -2053, -2048, -2047, -2048, -2046, -2045, -2046, -2045, -2044, -2043, -2044, -2043, -2039, -2037, -2036, -2035, -2036, -2034, -2033, -2034, -2034, -2032, -2032, -2030, -2026, -2026, -2025, -2026, -2075, -1779, -4714, -7529, -7168, -7229, -7226, -7207, -7276, -7002, -3355, -2295, -2523, -2474, -2473, -2549, -2426, -2468, -23794, -33288, -31498, -31849, -31833, -31826, -31817, -31809, -31802, -31791, -31780, -31769, -31759, -31614, -32192, -29467, -12681, -9823, -10514, -10345, -10335, -10284, -10422, -9843, -2179, 49, -423, -319, -315, -309, -303, -298, -638, -787, -755, -759, -756, -751, -753, -735, -1042, -1244, -1210, -1213, -1213, -1216, -1185, -1306, -2054, -2181, -2149, -2155, -2152, -2150, -2143, -2169, -2531, -2637, -2613, -2618, -2615, -2611, -2611, -2609, -2610, -2609, -2607, -2608, -2602, -2597, -2612, -2570};