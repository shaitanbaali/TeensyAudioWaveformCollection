/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0146 256 samples */
 
const int16_t AKWF_oscchip_0146_256_DATA [256] = 
{11679, 13409, 12996, 13069, 13071, 13081, 13036, 13234, 14610, 14817, 14767, 14778, 14778, 14786, 14756, 14870, 16670, 17134, 17034, 17055, 17055, 17078, 16957, 17609, 19335, 19328, 19321, 19326, 19326, 19358, 19199, 19979, 23145, 23348, 23288, 23304, 23304, 23194, 23695, 21455, 5871, 3528, 4102, 3977, 3975, 4029, 3833, 4575, 16270, 19286, 18629, 18760, 18760, 18779, 18754, 18748, 24732, 27096, 26631, 26721, 26720, 26743, 26630, 27186, 29445, 29592, 29550, 29560, 29560, 29564, 29549, 29615, 30074, 30142, 30126, 30129, 30129, 30127, 30135, 30106, 29656, 29541, 29565, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29560, 29556, 29571, 29514, 28616, 28382, 28434, 28424, 28424, 28424, 28424, 28424, 28424, 28424, 28424, 28424, 28424, 28420, 28443, 28331, 27878, 27850, 27858, 27855, 27855, 27800, 28050, 26932, 19138, 17965, 18251, 18190, 18190, 18118, 18375, 17407, 2113, -1832, -974, -1142, -1141, -1194, -1124, -1110, -17348, -23763, -22502, -22745, -22742, -22819, -22433, -24327, -32019, -32517, -32371, -32409, -32409, -32377, -32524, -31866, -27280, -26592, -26761, -26724, -26724, -26726, -26718, -26746, -27197, -27312, -27288, -27292, -27293, -27292, -27292, -27292, -27292, -27292, -27292, -27292, -27292, -27288, -27311, -27199, -26747, -26718, -26726, -26724, -26723, -26720, -26735, -26670, -26213, -26143, -26158, -26153, -26154, -26153, -26153, -26153, -26153, -26153, -26153, -26153, -26153, -26155, -26153, -26153, -26583, -26751, -26717, -26724, -26724, -26728, -26705, -26817, -27269, -27299, -27290, -27292, -27292, -27289, -27304, -27238, -26780, -26711, -26727, -26724, -26723, -26723, -26723, -26723, -26723, -26723, -26723, -26723, -26723, -26725, -26723, -26723, -27151, -27319, -27287, -27293, -27293, -27059, -28315, -21581};