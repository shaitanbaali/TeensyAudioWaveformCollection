/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0149 256 samples */
 
const int16_t AKWF_oscchip_0149_256_DATA [256] = 
{3645, 5923, 5537, 5612, 5611, 5675, 5384, 6683, 15732, 17094, 16762, 16835, 16836, 16864, 16763, 17146, 23200, 24763, 24424, 24490, 24490, 24501, 24487, 24483, 27936, 29299, 29030, 29083, 29080, 29082, 29086, 29049, 29754, 30159, 30088, 30103, 30102, 30079, 30185, 29711, 26419, 25925, 26045, 26020, 26020, 26001, 26069, 25813, 21774, 20733, 20959, 20915, 20915, 20892, 20923, 20930, 13643, 10763, 11330, 11221, 11222, 11214, 11189, 11393, 7518, 5295, 5681, 5609, 5611, 5579, 5724, 5074, 549, -130, 36, 0, 0, -12, 29, -125, -2548, -3174, -3037, -3065, -3066, -3075, -3062, -3059, -6126, -7338, -7099, -7146, -7147, -7155, -7183, -6959, -11184, -13612, -13187, -13267, -13265, -13295, -13162, -13753, -17869, -18487, -18336, -18368, -18368, -18384, -18329, -18534, -21767, -22599, -22416, -22453, -22452, -22470, -22447, -22442, -27813, -29932, -29517, -29598, -29596, -29601, -29615, -29503, -31614, -32828, -32616, -32657, -32656, -32610, -32821, -31875, -25292, -24303, -24547, -24494, -24493, -24486, -24513, -24411, -22797, -22382, -22472, -22452, -22453, -22443, -22456, -22458, -19388, -18176, -18414, -18368, -18369, -18353, -18302, -18712, -10962, -6513, -7292, -7143, -7146, -7112, -7270, -6560, -1624, -881, -1063, -1025, -1025, -1021, -1034, -983, -173, 37, -9, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -4, 15, -339, -543, -507, -514, -514, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513, -513};