/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0121 256 samples */
 
const int16_t AKWF_oscchip_0121_256_DATA [256] = 
{571, 503, 520, 519, 519, 581, 236, 2740, 5973, 5648, 5703, 5704, 5704, 5727, 5597, 6396, 7852, 7768, 7780, 7781, 7781, 7833, 7558, 9047, 12985, 12972, 12957, 12968, 12969, 12991, 12862, 14061, 15169, 15018, 15045, 15045, 15045, 14995, 15271, 13267, 10677, 10939, 10895, 10894, 10894, 10941, 10681, 12277, 15184, 15019, 15042, 15045, 15045, 15055, 15000, 15298, 16086, 16084, 16080, 16081, 16081, 16092, 16028, 16628, 17181, 17106, 17119, 17118, 17118, 17130, 17061, 17563, 18210, 18145, 18156, 18158, 18158, 18170, 18105, 18503, 19228, 19187, 19194, 19195, 19195, 19200, 19173, 19321, 19715, 19713, 19711, 19712, 19713, 19735, 19606, 20805, 21911, 21759, 21787, 21786, 21786, 21836, 21560, 23565, 26154, 25895, 25939, 25939, 25939, 25791, 26603, 21617, 12530, 13049, 12978, 12968, 12968, 12521, 14863, 2207, -31285, -31180, -31038, -31132, -31133, -31116, -31213, -30315, -29485, -29598, -29578, -29579, -29580, -29567, -29636, -29132, -28482, -28549, -28537, -28536, -28537, -28513, -28642, -27846, -26392, -26475, -26465, -26462, -26463, -26473, -26418, -26716, -27504, -27500, -27497, -27500, -27498, -27465, -27658, -25861, -24203, -24428, -24388, -24389, -24388, -24364, -24502, -23500, -22207, -22337, -22315, -22316, -22315, -22304, -22369, -21968, -21237, -21280, -21274, -21272, -21273, -21262, -21317, -21019, -20231, -20235, -20238, -20235, -20235, -20224, -20289, -19689, -19136, -19212, -19198, -19198, -19198, -19186, -19255, -18754, -18107, -18173, -18162, -18161, -18161, -18156, -18188, -17988, -17626, -17647, -17642, -17641, -17642, -17626, -17708, -17263, -16082, -16086, -16091, -16088, -16086, -16053, -16247, -14446, -12787, -13014, -12972, -12971, -12971, -12965, -13000, -12750, -12427, -12460, -12455, -12454, -12454, -12425, -12587, -11590, -9774, -9876, -9863, -9860, -9861, -9803, -10106, -8468, -4133, -4146, -4165, -4154, -4152, -4105, -4378, -1748};