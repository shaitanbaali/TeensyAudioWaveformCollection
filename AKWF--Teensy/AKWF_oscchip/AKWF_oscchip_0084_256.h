/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0084 256 samples */
 
const int16_t AKWF_oscchip_0084_256_DATA [256] = 
{4204, 7851, 7314, 7414, 7414, 7421, 7424, 7347, 10584, 11916, 11659, 11704, 11703, 11704, 11737, 11517, 14442, 16246, 15939, 15993, 15991, 15989, 16007, 15880, 16957, 17927, 17787, 17808, 17804, 17805, 17807, 17739, 19598, 20370, 20207, 20232, 20228, 20224, 20240, 20122, 21361, 22164, 22015, 22035, 22029, 22024, 22061, 21826, 23602, 25285, 25028, 25070, 25064, 25061, 25060, 25000, 26391, 26971, 26845, 26861, 26854, 26849, 26861, 26741, 27995, 28778, 28630, 28652, 28644, 28638, 28656, 28506, 29569, 30573, 30412, 30433, 30426, 30419, 30414, 30388, 30842, 31039, 30994, 30994, 30986, 30978, 30976, 30934, 31333, 31594, 31544, 31544, 31535, 31527, 31534, 31439, 32130, 32794, 32695, 32704, 32695, 32621, 32341, 34249, -6487, -26292, -22571, -23264, -23268, -23271, -23260, -23335, -22542, -21972, -22065, -22047, -22046, -22047, -22040, -22040, -23015, -23314, -23242, -23252, -23248, -23242, -23227, -23299, -21932, -21273, -21397, -21366, -21362, -21357, -21375, -21241, -22430, -23308, -23151, -23174, -23168, -23157, -23162, -23153, -21192, -20575, -20697, -20667, -20661, -20655, -20646, -20666, -20209, -19986, -20022, -20008, -20003, -19999, -20020, -19850, -21446, -22592, -22395, -22427, -22420, -22408, -22411, -22405, -20009, -19184, -19342, -19306, -19300, -19291, -19265, -19406, -16772, -15389, -15628, -15579, -15574, -15572, -15632, -15239, -19092, -22060, -21606, -21686, -21680, -21660, -21664, -21709, -15971, -13938, -14354, -14267, -14264, -14265, -14314, -13969, -19212, -22046, -21511, -21607, -21602, -21595, -21453, -22206, -15423, -9790, -10666, -10503, -10499, -10493, -10489, -10504, -9540, -9191, -9263, -9245, -9242, -9235, -9202, -9394, -6763, -5316, -5589, -5533, -5533, -5531, -5513, -5599, -4832, -4210, -4308, -4286, -4286, -4282, -4280, -4296, -3342, -2985, -3056, -3043, -3041, -3038, -3014, -3169, -1009, 210, -4, 36, 37, 36, 44, 2};