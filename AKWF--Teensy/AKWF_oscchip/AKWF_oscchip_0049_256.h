/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0049 256 samples */
 
const int16_t AKWF_oscchip_0049_256_DATA [256] = 
{189, 101, 123, 123, 123, 151, 12, 949, 2520, 2433, 2446, 2450, 2449, 2478, 2328, 3179, 5323, 5346, 5331, 5334, 5335, 5352, 5260, 5721, 7517, 7673, 7628, 7636, 7636, 7639, 7603, 7737, 8642, 8808, 8766, 8769, 8764, 8782, 8674, 9372, 10543, 10473, 10477, 10477, 10469, 10472, 10438, 10605, 11032, 11031, 11023, 11021, 11014, 11020, 10971, 11195, 12090, 12159, 12133, 12136, 12129, 12135, 12084, 12277, 13633, 13882, 13816, 13824, 13816, 13837, 13687, 14617, 16182, 16084, 16084, 16082, 16075, 16085, 15985, 16499, 17780, 17774, 17757, 17755, 17746, 17744, 17712, 17820, 18261, 18292, 18272, 18267, 18258, 18257, 18213, 18502, 18835, 18789, 18786, 18778, 18769, 18760, 18751, 18743, 18734, 18724, 18715, 18706, 18697, 18688, 18679, 18669, 18660, 18651, 18641, 18633, 18623, 18634, 18530, 18984, 20772, 20918, 20866, 20867, 20855, 20852, 20809, 21095, 21422, 21376, 21371, 21362, 21354, 21309, 21476, 20298, 18327, 18428, 18406, 18392, 18383, 18373, 18363, 18355, 18342, 18334, 18325, 18314, 18262, 17901, 20191, -10005, -34222, -30786, -31444, -31430, -31434, -31409, -31542, -30350, -28988, -29125, -29095, -29086, -29080, -29059, -29119, -28645, -27850, -27885, -27868, -27857, -27846, -27811, -27924, -27218, -25487, -25471, -25471, -25456, -25441, -25425, -25438, -25075, -24785, -24811, -24791, -24776, -24766, -24742, -24798, -24194, -23503, -23562, -23535, -23523, -23513, -23480, -23573, -22848, -21670, -21726, -21704, -21688, -21679, -21633, -21803, -20751, -18167, -18147, -18155, -18135, -18125, -18104, -18148, -17438, -16862, -16932, -16906, -16897, -16888, -16835, -17071, -14983, -12600, -12837, -12785, -12778, -12769, -12754, -12781, -12534, -12139, -12153, -12144, -12135, -12122, -12114, -12171, -9781, -8451, -8675, -8622, -8618, -8607, -8578, -8734, -6618, -4919, -5161, -5110, -5103, -5100, -5045, -5325, -2761};