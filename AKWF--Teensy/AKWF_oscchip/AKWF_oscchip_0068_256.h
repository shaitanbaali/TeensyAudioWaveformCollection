/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0068 256 samples */
 
const int16_t AKWF_oscchip_0068_256_DATA [256] = 
{3858, 4065, 4019, 4030, 4032, 4037, 4029, 4065, 4468, 4531, 4516, 4520, 4519, 4557, 4356, 5354, 8373, 8369, 8362, 8367, 8367, 8408, 8200, 9132, 13843, 14197, 14104, 14123, 14122, 14136, 14067, 14330, 17084, 17558, 17450, 17468, 17465, 17470, 17422, 17646, 18401, 18412, 18400, 18399, 18396, 18438, 18196, 19299, 25589, 26185, 26028, 26056, 26051, 26033, 26090, 25759, 25032, 25063, 25053, 25046, 25040, 25007, 25140, 24466, 22141, 22115, 22128, 22116, 22109, 22080, 22186, 21691, 18476, 18166, 18245, 18220, 18214, 18163, 18405, 17110, 14225, 14367, 14343, 14336, 14330, 14289, 14473, 13584, 10482, 10447, 10463, 10450, 10447, 10411, 10561, 9907, 5914, 5551, 5643, 5619, 5615, 5544, 5916, 3896, -779, -618, -640, -651, -652, -695, -479, -1535, -5370, -5487, -5451, -5465, -5464, -5482, -5399, -5768, -8124, -8394, -8331, -8343, -8343, -8394, -8112, -9610, -13250, -13128, -13133, -13141, -13138, -13151, -13070, -13448, -15002, -15063, -15038, -15043, -15040, -15087, -14848, -15891, -23819, -24842, -24578, -24630, -24624, -24705, -24246, -26552, -32482, -32264, -32272, -32277, -32271, -32143, -32755, -29907, -18091, -17712, -17860, -17805, -17798, -17767, -17877, -17398, -13366, -12859, -12984, -12952, -12947, -12890, -13169, -11733, -8032, -8132, -8118, -8108, -8105, -8036, -8364, -6859, -596, -348, -420, -396, -394, -350, -535, 236, 6205, 6969, 6786, 6826, 6827, 6847, 6740, 7298, 8771, 8744, 8744, 8746, 8745, 8793, 8537, 9755, 15196, 15538, 15444, 15465, 15463, 15514, 15225, 16869, 19960, 19741, 19768, 19769, 19762, 19236, 22000, 7971, -32705, -32184, -32048, -32169, -32166, -32165, -32163, -32161, -32158, -32154, -32149, -32146, -32141, -32135, -32131, -32125, -32118, -32112, -32106, -32099, -32094, -31791, -33334, -25823, -3416, -3717, -3744, -3689, -3683, -3641, -3835, -2874};