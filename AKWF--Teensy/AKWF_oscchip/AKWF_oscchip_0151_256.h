/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0151 256 samples */
 
const int16_t AKWF_oscchip_0151_256_DATA [256] = 
{18572, 20846, 20306, 20402, 20404, 20404, 20404, 20404, 20404, 20404, 20404, 20404, 20404, 20422, 20326, 20915, 21990, 21929, 21938, 21939, 21939, 21944, 21917, 22064, 22451, 22449, 22446, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22447, 22366, 22812, 20068, 15065, 15349, 15311, 15306, 15306, 15347, 15131, 16300, 19398, 19388, 19376, 19385, 19385, 19418, 19255, 20055, 23304, 23515, 23452, 23469, 23469, 23371, 23914, 19972, 14881, 15393, 15308, 15306, 15306, 15189, 15828, 11905, 4756, 5163, 5109, 5100, 5100, 4924, 5845, 868, -12307, -12264, -12209, -12245, -12247, -12296, -12051, -13251, -18122, -18437, -18343, -18368, -18369, -18393, -18257, -19243, -20514, -20387, -20409, -20410, -20409, -19844, -22941, -3920, 30747, 28772, 29040, 29081, 29082, 29091, 29037, 29329, 30105, 30103, 30100, 30102, 30102, 30070, 30233, 29432, 26184, 25974, 26036, 26021, 26020, 25959, 26299, 23833, 20650, 20970, 20916, 20915, 20915, 20804, 21411, 17686, 10896, 11282, 11231, 11222, 11222, 11165, 11463, 9851, 5591, 5603, 5621, 5611, 5611, 5565, 5790, 4690, 226, -63, 23, 0, -1, -37, 167, -1313, -3223, -3031, -3063, -3066, -3065, -3112, -2857, -4424, -7282, -7119, -7141, -7146, -7146, -7208, -6884, -8638, -13287, -13274, -13254, -13265, -13266, -13307, -13103, -14102, -18162, -18425, -18348, -18368, -18369, -18417, -18146, -20119, -22666, -22408, -22451, -22453, -22452, -22534, -22087, -24833, -29835, -29550, -29591, -29596, -29597, -29627, -29465, -30342, -32666, -32660, -32650, -32656, -32656, -32350, -34000, -25149};