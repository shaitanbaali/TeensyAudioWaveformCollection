/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0046 256 samples */
 
const int16_t AKWF_oscchip_0046_256_DATA [256] = 
{3129, 4400, 4078, 4146, 4147, 4148, 4153, 4164, 4165, 4164, 4165, 4167, 4167, 4167, 4167, 4167, 4167, 4167, 4167, 4165, 4163, 4306, 3589, 7474, 18348, 18640, 18502, 18541, 18540, 18432, 18919, 16623, 5235, 3829, 4210, 4111, 4110, 4109, 4103, 4091, 4089, 4087, 4085, 4083, 4082, 4081, 4077, 4064, 4063, 4062, 4060, 4058, 4057, 4056, 4055, 4053, 4053, 4044, 4036, 4035, 4034, 4033, 4032, 4031, 4029, 4028, 4027, 4026, 4027, 4004, 4066, 3598, 2779, 2814, 2808, 2806, 2805, 2804, 2803, 2801, 2802, 2798, 2787, 2786, 2786, 2785, 2784, 2783, 2782, 2782, 2780, 2779, 2778, 2387, 4530, -11505, -33550, -31732, -32006, -32019, -32018, -31653, -33547, -22005, 2102, 1594, 1559, 1628, 1636, 1627, 1684, 1406, 483, 429, 453, 450, 451, 426, 573, -699, -2073, -1916, -1940, -1939, -1937, -1938, -1937, -1935, -1935, -1936, -1930, -1921, -1922, -1921, -1919, -1920, -1919, -1918, -1917, -1918, -1917, -1906, -1951, -1727, -787, -690, -719, -713, -712, -712, -713, -712, -710, -710, -710, -710, -711, -703, -696, -697, -697, -696, -696, -696, -700, -521, -1398, 3213, 17975, 18691, 18420, 18493, 18493, 18361, 18944, 16254, 1144, -1181, -601, -737, -742, -743, -745, -745, -747, -747, -749, -750, -749, -751, -752, -751, -751, -752, -751, -753, -754, -753, -753, -763, -766, -765, -765, -765, -765, -753, -825, -230, 495, 423, 443, 444, 443, 444, 444, 444, 444, 444, 444, 444, 444, 397, 631, -614, -4269, -4389, -4342, -4363, -4361, -4360, -4361, -4360, -4360, -4353, -4344, -4345, -4343, -4407, -4046, -6685, -10570, -10292, -10328, -10329, -10326, -10416, -9948, -12644, -18773, -18723, -18693, -18702, -18703, -18547, -19333, -15017};