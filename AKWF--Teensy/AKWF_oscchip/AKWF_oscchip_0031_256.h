/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0031 256 samples */
 
const int16_t AKWF_oscchip_0031_256_DATA [256] = 
{14505, 22141, 20588, 20887, 20887, 20891, 20890, 20887, 20887, 20883, 20878, 20873, 20869, 20862, 20855, 20849, 20842, 20834, 20824, 20817, 20809, 20798, 20788, 20781, 20771, 20760, 20750, 20740, 20730, 20719, 20708, 20697, 20685, 20674, 20664, 20653, 20642, 20631, 20618, 20607, 20597, 20584, 20572, 20561, 20551, 20541, 20527, 20516, 20505, 20494, 20482, 20470, 20459, 20446, 20435, 20424, 20413, 20401, 20389, 20378, 20367, 20354, 20343, 20332, 20319, 20307, 20296, 20286, 20274, 20262, 20250, 20239, 20227, 20216, 20204, 20191, 20180, 20170, 20159, 20147, 20134, 20125, 20113, 20100, 20088, 20077, 20067, 20054, 20042, 20032, 20021, 20008, 19998, 19987, 19975, 19961, 19951, 19939, 19929, 19917, 19905, 19894, 19883, 19872, 19859, 19849, 19837, 19825, 19813, 19803, 19792, 19780, 19768, 19757, 19746, 19736, 19723, 19568, 19871, 19099, -21320, -33630, -30970, -31498, -31493, -31492, -31488, -31484, -31479, -31473, -31465, -31457, -31446, -31368, -31602, -30731, -15878, -12327, -13078, -12916, -12904, -12897, -12877, -12912, -13555, -13684, -13642, -13642, -13633, -13627, -13605, -13652, -14292, -14417, -14377, -14376, -14367, -14361, -14344, -14371, -14690, -14738, -14716, -14710, -14702, -14695, -14677, -14711, -15033, -15072, -15051, -15045, -15037, -15030, -15011, -15051, -15370, -15403, -15385, -15379, -15370, -15362, -15358, -15313, -15858, -16173, -16111, -16111, -16102, -16094, -16085, -16077, -16068, -16058, -16050, -16041, -16033, -16023, -16017, -15995, -16269, -16412, -16373, -16369, -16361, -16352, -16345, -16317, -16895, -17160, -17103, -17101, -17092, -17084, -17075, -17057, -17349, -17463, -17431, -17428, -17418, -17409, -17399, -17383, -17678, -17791, -17755, -17751, -17741, -17730, -17720, -17710, -17700, -17692, -17681, -17671, -17660, -17654, -17635, -17641, -18890, -19281, -19189, -19193, -19182, -19172, -19162, -19152, -19141, -19130, -19121, -19111, -19100, -19030, -19330, -17952};