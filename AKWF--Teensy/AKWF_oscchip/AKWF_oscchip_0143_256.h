/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0143 256 samples */
 
const int16_t AKWF_oscchip_0143_256_DATA [256] = 
{822, 414, 511, 494, 494, 499, 466, 706, 1014, 981, 985, 986, 986, 1333, -568, 11107, 32388, 31175, 31340, 31365, 31362, 31334, 31527, 28745, 26920, 27222, 27165, 27165, 27163, 27078, 27569, 23003, 18791, 19367, 19260, 19259, 19259, 19093, 20013, 13337, 4715, 5582, 5435, 5432, 5432, 5392, 5609, 4279, 1857, 1996, 1976, 1974, 1973, 1959, 2050, 742, -116, 27, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -4, 19, -311, -527, -491, -498, -498, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -508, -842, 1092, -16885, -33467, -31205, -31617, -31618, -31616, -31474, -32263, -26537, -19144, -19888, -19762, -19759, -19759, -19692, -20063, -17784, -13633, -13871, -13837, -13830, -13825, -13795, -13999, -11056, -9126, -9447, -9388, -9390, -9388, -9340, -9616, -7047, -4678, -5001, -4942, -4940, -4940, -4881, -5210, -2824, 255, -54, -2, 0, -1, 90, -405, 2632, 8166, 7852, 7896, 7901, 7905, 7925, 7788, 9751, 11038, 10825, 10866, 10865, 10867, 10947, 10486, 14767, 18714, 18176, 18274, 18273, 18273, 18273, 18273, 18273, 18273, 18273, 18273, 18273, 18273, 18267, 18298, 18109, 17763, 17783, 17782, 17781, 17770, 17700, 18178, 11305, 6801, 7548, 7406, 7408, 7404, 7288, 7963, 1684, -4107, -3316, -3460, -3460, -3460, -3578, -2921, -7691, -13850, -13232, -13335, -13339, -13339, -13474, -12732, -17288, -25593, -25120, -25186, -25196, -25201, -25221, -25084, -27047, -28333, -28120, -28160, -28159, -28150, -27860, -29534, -13406};