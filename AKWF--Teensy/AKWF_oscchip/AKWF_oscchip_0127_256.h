/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0127 256 samples */
 
const int16_t AKWF_oscchip_0127_256_DATA [256] = 
{21067, 22978, 22528, 22610, 22615, 22597, 22697, 21972, 21035, 21128, 21110, 21108, 21105, 21092, 21151, 20763, 20060, 20097, 20088, 20083, 20079, 20050, 20179, 19458, 17556, 17557, 17561, 17552, 17547, 17531, 17586, 17288, 16091, 16011, 16029, 16018, 16013, 15966, 16194, 14500, 12314, 12530, 12488, 12483, 12479, 12418, 12727, 10805, 7303, 7497, 7468, 7461, 7458, 7449, 7472, 7326, 6940, 6939, 6938, 6934, 6931, 6925, 6943, 6842, 6443, 6415, 6421, 6416, 6414, 6610, 5511, 13473, 23752, 22716, 22887, 22888, 22885, 22863, 22954, 22373, 21320, 21376, 21363, 21357, 21352, 21336, 21385, 21093, 20325, 20323, 20321, 20314, 20309, 20271, 20425, 19638, 16453, 16243, 16299, 16277, 16273, 16256, 16317, 15830, 15202, 15261, 15245, 15240, 15236, 15175, 15483, 13557, 10053, 10249, 10217, 10209, 10205, 10135, 10477, 8609, 3673, 3685, 3703, 3687, 3684, 3669, 3726, 3431, 2237, 2158, 2179, 2171, 2169, 2131, 2330, 881, -991, -804, -836, -839, -840, -879, -661, -2005, -4453, -4314, -4334, -4336, -4335, -4351, -4271, -4702, -5839, -5835, -5828, -5831, -5831, -5849, -5749, -6239, -8225, -8354, -8315, -8323, -8323, -8327, -8292, -8530, -8841, -8808, -8811, -8809, -8808, -8824, -8727, -9301, -10348, -10286, -10291, -10291, -10289, -10327, -10112, -11258, -14288, -14276, -14261, -14266, -14263, -14291, -14129, -14909, -18088, -18291, -18226, -18239, -18236, -18253, -18146, -18604, -21825, -22307, -22183, -22205, -22200, -22269, -21857, -24348, -28892, -28629, -28659, -28658, -28651, -28687, -28468, -29608, -32634, -32618, -32599, -32600, -32594, -32466, -33056, -30113, -18180, -17400, -17623, -17556, -17547, -17552, -17493, -17718, -19323, -19559, -19494, -19502, -19496, -19495, -19459, -19646, -19989, -19963, -19961, -19955, -19951, -19964, -19854, -20423, -21937, -21927, -21914, -21912, -21909, -21644, -23023, -15598};