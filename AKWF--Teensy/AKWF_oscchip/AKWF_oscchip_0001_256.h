/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0001 256 samples */
 
const int16_t AKWF_oscchip_0001_256_DATA [256] = 
{29450, 31113, 30737, 30808, 30817, 30803, 30879, 30490, 29028, 28964, 28980, 28967, 28959, 28931, 29029, 28494, 26684, 26615, 26625, 26606, 26592, 26567, 26625, 26268, 25180, 25158, 25151, 25135, 25121, 25090, 25170, 24660, 23234, 23228, 23221, 23204, 23190, 23167, 23204, 22920, 22216, 22211, 22200, 22184, 22173, 22131, 22282, 21390, 19320, 19381, 19360, 19344, 19331, 19289, 19440, 18515, 16477, 16553, 16531, 16516, 16506, 16485, 16530, 16188, 15523, 15547, 15534, 15522, 15513, 15456, 15696, 14271, 11685, 11845, 11811, 11799, 11791, 11759, 11874, 11129, 9851, 9945, 9920, 9914, 9906, 9895, 9901, 9849, 9471, 9406, 9413, 9404, 9398, 9382, 9426, 9201, 7704, 7508, 7547, 7534, 7528, 7508, 7569, 7263, 5384, 5182, 5231, 5215, 5210, 5189, 5263, 4901, 3047, 2875, 2920, 2905, 2901, 2891, 2923, 2764, 2024, 1966, 1978, 1971, 1970, 1952, 2024, 1677, 196, 118, 139, 132, 132, 112, 207, -273, -2097, -2170, -2143, -2151, -2152, -2204, -1936, -3235, -7551, -7651, -7606, -7620, -7617, -7625, -7576, -7802, -8517, -8518, -8511, -8511, -8508, -8530, -8387, -9127, -11239, -11226, -11213, -11214, -11209, -11214, -11157, -11425, -12113, -12097, -12090, -12086, -12080, -12105, -11933, -12804, -14853, -14772, -14773, -14771, -14763, -14781, -14640, -15393, -17075, -16994, -16996, -16991, -16981, -17004, -16823, -17815, -19769, -19662, -19664, -19657, -19648, -19641, -19622, -19644, -20005, -20064, -20040, -20032, -20022, -20021, -19973, -20118, -21599, -21840, -21768, -21769, -21758, -21751, -21716, -21799, -22526, -22633, -22593, -22587, -22575, -22568, -22528, -22627, -23360, -23442, -23407, -23400, -23386, -23378, -23339, -23450, -24184, -24250, -24216, -24208, -24196, -24188, -24144, -24274, -25002, -25054, -25021, -25013, -24998, -24999, -24914, -25225, -26688, -26772, -26730, -26723, -26708, -26379, -28050, -19206};