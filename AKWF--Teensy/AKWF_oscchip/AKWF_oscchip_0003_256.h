/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0003 256 samples */
 
const int16_t AKWF_oscchip_0003_256_DATA [256] = 
{9508, 13994, 13064, 13246, 13252, 13259, 13264, 13266, 13270, 13271, 13271, 13271, 13268, 13267, 13266, 13261, 13259, 13255, 13251, 13248, 13242, 13237, 13233, 13226, 13221, 13217, 13210, 13202, 13197, 13192, 13185, 13178, 13171, 13166, 13160, 13153, 13146, 13139, 13132, 13125, 13118, 13111, 13103, 13096, 13090, 13082, 13075, 13067, 13060, 13052, 13044, 13038, 13031, 13053, 13092, 12581, 26765, 33031, 31823, 32041, 32028, 32015, 32004, 31992, 31978, 31964, 31950, 31936, 31920, 31904, 31889, 31875, 31676, 31589, 31586, 31567, 31550, 31535, 31517, 31501, 31483, 31468, 31448, 31432, 31414, 31347, 31434, 31194, 16351, 11696, 12681, 12473, 12461, 12445, 12438, 12413, 12019, 11901, 11914, 11899, 11888, 11877, 11868, 11860, 11851, 11842, 11834, 11825, 11817, 11808, 11800, 11793, 11786, 11778, 11770, 11764, 11755, 11748, 11741, 11735, 11727, 11719, 11713, 11706, 11698, 11696, 11669, 11742, 12523, 12654, 12615, 12614, 12607, 12597, 12610, 12515, 11716, 11585, 11607, 11594, 11586, 11581, 11573, 11565, 11559, 11552, 11545, 11537, 11531, 11443, 11819, 10141, 351, -792, -506, -576, -580, -608, -796, 416, -17490, -27667, -25827, -26178, -26170, -26165, -26160, -26155, -26147, -26139, -26130, -26121, -26110, -26101, -26092, -26066, -26405, -26565, -26522, -26516, -26503, -26490, -26477, -26475, -26101, -25928, -25946, -25926, -25912, -25898, -25884, -25870, -25856, -25843, -25829, -25814, -25800, -25787, -25771, -25754, -26111, -26235, -26191, -26182, -26168, -26154, -26139, -26125, -26484, -26597, -26557, -26549, -26532, -26517, -26503, -26487, -26473, -26459, -26443, -26428, -26414, -26398, -26383, -26369, -26352, -26337, -26324, -26308, -26293, -26278, -26263, -26249, -26233, -26218, -26204, -26187, -26174, -26158, -26144, -26129, -26115, -26099, -26084, -26069, -26054, -26042, -26019, -26038, -26413, -26480, -26446, -26435, -26419, -26300, -26833, -24306};