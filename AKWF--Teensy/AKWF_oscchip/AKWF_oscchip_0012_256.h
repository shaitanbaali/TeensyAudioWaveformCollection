/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0012 256 samples */
 
const int16_t AKWF_oscchip_0012_256_DATA [256] = 
{632, 1386, 1285, 1305, 1304, 1304, 1292, 1359, 767, 278, 355, 340, 340, 341, 341, 341, 341, 341, 340, 341, 338, 334, 351, 263, 735, 1809, 1774, 1774, 1777, 1777, 1777, 1777, 1777, 1776, 1774, 1775, 1775, 1774, 1787, 1717, 2094, 2767, 2718, 2723, 2725, 2724, 2735, 2667, 3081, 3723, 3667, 3674, 3674, 3673, 3690, 3590, 4243, 5182, 5085, 5099, 5099, 5097, 5104, 5037, 5509, 6098, 6031, 6040, 6038, 6036, 6037, 6001, 6251, 6531, 6494, 6498, 6493, 6490, 6513, 6373, 7439, 8522, 8368, 8392, 8389, 8383, 8396, 8300, 9139, 9894, 9782, 9798, 9792, 9791, 9837, 9526, 12536, 14854, 14495, 14556, 14549, 14545, 14588, 14291, 17389, 19617, 19233, 19299, 19289, 19284, 19293, 19145, 21069, 22296, 22076, 22105, 22096, 22085, 22092, 21960, 23977, 25074, 24870, 24894, 24882, 24875, 24874, 24762, 26849, 27859, 27646, 27673, 27658, 27644, 27642, 27561, 27969, 28591, 28521, 28516, 28499, 28495, 27667, 32009, 3887, -33879, -29875, -30594, -30613, -30613, -30566, -30831, -28914, -26544, -26809, -26754, -26749, -26740, -26699, -26889, -25322, -23664, -23854, -23808, -23795, -23785, -23729, -23962, -22022, -20173, -20419, -20360, -20348, -20335, -20313, -20363, -19778, -19264, -19328, -19303, -19291, -19280, -19250, -19352, -18135, -17204, -17330, -17295, -17284, -17272, -17225, -17436, -14868, -13168, -13440, -13376, -13367, -13358, -13334, -13414, -12085, -11285, -11421, -11383, -11376, -11367, -11353, -11397, -10374, -9821, -9911, -9884, -9878, -9869, -9859, -9894, -8826, -8333, -8416, -8395, -8388, -8374, -8368, -8431, -5171, -3819, -4091, -4032, -4027, -4015, -4027, -4015, -1420, -499, -686, -646, -642, -639, -641, -634, -254, -134, -157, -151, -150, -151, -150, -146, -144, -143, -142, -143, -142, -143, -140, -153};