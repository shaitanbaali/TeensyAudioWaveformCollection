/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0033 256 samples */
 
const int16_t AKWF_oscchip_0033_256_DATA [256] = 
{846, 1354, 1259, 1281, 1280, 1284, 1292, 1212, 3014, 4110, 3923, 3959, 3959, 3960, 3989, 3806, 5890, 7732, 7486, 7530, 7529, 7525, 7560, 7345, 9077, 11256, 11055, 11082, 11079, 11089, 11061, 11093, 13730, 14811, 14589, 14630, 14623, 14620, 14619, 14574, 15467, 16011, 15913, 15923, 15916, 15910, 15911, 15860, 16374, 16828, 16757, 16760, 16754, 16753, 16721, 16807, 17852, 18106, 18039, 18045, 18035, 18026, 18018, 18013, 18335, 18463, 18426, 18422, 18413, 18406, 18398, 18377, 18668, 18842, 18802, 18799, 18789, 18780, 18780, 18723, 19232, 19687, 19615, 19616, 19608, 19599, 19583, 19605, 19944, 20022, 19992, 19987, 19977, 19972, 19954, 19958, 20938, 21336, 21241, 21246, 21238, 21233, 21230, 21140, 22935, 24023, 23823, 23850, 23838, 23800, 23338, 26121, -5675, -33804, -30078, -30771, -30766, -30729, -30869, -30324, -24391, -22895, -23226, -23151, -23149, -23140, -23136, -23124, -22786, -22647, -22665, -22651, -22643, -22631, -22621, -22638, -22030, -21653, -21705, -21684, -21673, -21644, -21724, -21307, -19185, -18881, -18946, -18920, -18911, -18889, -18927, -18725, -16623, -16088, -16196, -16160, -16153, -16136, -16144, -16099, -14096, -13294, -13447, -13407, -13399, -13388, -13379, -13397, -12788, -12416, -12469, -12450, -12443, -12431, -12451, -12308, -11599, -11496, -11513, -11502, -11494, -11470, -11530, -11269, -8468, -7759, -7911, -7874, -7867, -7859, -7858, -7847, -7510, -7373, -7395, -7383, -7380, -7375, -7368, -7378, -7074, -6886, -6912, -6904, -6898, -6878, -6948, -6605, -4846, -4596, -4653, -4637, -4635, -4630, -4632, -4599, -4246, -4156, -4175, -4168, -4162, -4159, -4161, -4150, -3819, -3682, -3706, -3698, -3695, -3694, -3693, -3690, -3685, -3684, -3683, -3681, -3676, -3671, -3685, -3616, -3262, -3210, -3222, -3218, -3217, -3199, -3246, -3054, -957, -429, -545, -517, -517, -515, -527, -470};