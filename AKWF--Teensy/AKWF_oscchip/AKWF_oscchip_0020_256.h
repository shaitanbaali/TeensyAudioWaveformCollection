/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0020 256 samples */
 
const int16_t AKWF_oscchip_0020_256_DATA [256] = 
{2206, 4708, 4406, 4460, 4460, 4460, 4498, 4286, 5974, 7598, 7374, 7415, 7413, 7409, 7450, 7216, 9241, 11080, 10803, 10853, 10847, 10846, 10893, 10576, 13531, 16063, 15689, 15749, 15742, 15736, 15802, 15417, 17320, 22684, 22607, 22593, 22594, 22586, 22631, 22329, 23903, 28046, 27960, 27945, 27943, 27930, 27951, 27763, 28708, 30894, 30822, 30807, 30801, 30784, 30792, 30652, 31315, 32753, 32670, 32660, 32647, 32630, 32556, 32850, 31061, 27444, 27642, 27592, 27573, 27557, 27463, 27862, 25373, 20841, 21102, 21049, 21027, 21013, 20923, 21320, 18834, 14783, 15069, 15009, 14992, 14983, 14927, 15155, 13667, 11309, 11511, 11465, 11454, 11445, 11400, 11592, 10253, 8295, 8474, 8435, 8426, 8419, 8367, 8610, 6941, 4759, 4967, 4926, 4919, 4913, 4870, 5080, 3583, 1762, 1967, 1926, 1925, 1921, 1880, 2084, 529, -1234, -1014, -1057, -1057, -1059, -1117, -809, -3215, -5762, -5448, -5501, -5501, -5501, -5546, -5298, -7269, -9168, -8906, -8950, -8946, -8946, -8978, -8794, -9709, -12824, -12899, -12859, -12868, -12862, -12897, -12686, -13722, -16775, -16800, -16769, -16772, -16765, -16803, -16554, -17776, -21219, -21166, -21154, -21152, -21145, -21175, -20950, -22100, -25114, -25036, -25024, -25018, -25008, -25033, -24817, -25924, -28476, -28396, -28385, -28375, -28361, -28372, -28233, -28909, -30335, -30253, -30247, -30232, -30218, -30151, -30414, -28804, -25548, -25729, -25684, -25665, -25648, -25573, -25879, -23959, -20464, -20674, -20631, -20609, -20597, -20545, -20738, -19489, -17454, -17592, -17557, -17543, -17531, -17461, -17759, -15808, -12815, -13080, -13022, -13012, -13001, -12941, -13203, -11418, -8807, -9047, -8998, -8988, -8981, -8921, -9199, -7292, -4797, -5038, -4990, -4984, -4978, -4940, -5114, -3863, -2349, -2518, -2482, -2481, -2477, -2441, -2611, -1315, 154, -28, 5, 9, 9, 16, -16};