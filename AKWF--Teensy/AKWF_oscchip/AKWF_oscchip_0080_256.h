/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0080 256 samples */
 
const int16_t AKWF_oscchip_0080_256_DATA [256] = 
{16855, 28690, 26691, 27073, 27067, 27065, 27048, 27120, 26546, 25988, 26065, 26048, 26043, 26035, 26022, 26081, 24594, 23921, 24039, 24008, 24003, 23997, 23960, 24135, 22148, 20812, 21024, 20978, 20973, 20967, 20935, 21073, 19961, 18831, 18969, 18936, 18929, 18922, 18908, 18971, 17519, 16804, 16933, 16904, 16898, 16893, 16878, 16932, 16281, 15806, 15880, 15862, 15857, 15851, 15611, 16913, 7124, -3223, -1867, -2111, -2114, -2147, -2348, -998, -22723, -33749, -31616, -32022, -32016, -32005, -31587, -33926, -12197, 4114, 1383, 1897, 1895, 1893, 2306, 80, 15677, 32723, 30385, 30807, 30803, 30770, 30594, 31875, 11466, 1321, 3240, 2869, 2870, 2868, 2866, 2864, 2863, 2859, 2858, 2856, 2855, 2854, 3224, 1158, 15520, 31401, 29367, 29743, 29737, 29730, 29714, 29790, 28371, 27615, 27743, 27714, 27708, 27691, 27395, 29085, 12888, 202, 2122, 1764, 1760, 1755, 1753, 1749, 1746, 1743, 1740, 1738, 1736, 1733, 1723, 1770, 1066, 663, 738, 722, 720, 719, 694, 829, -387, -1404, -1251, -1281, -1282, -1281, -1609, 180, -11915, -26680, -24880, -25188, -25183, -25179, -25140, -25364, -22546, -20939, -21242, -21184, -21178, -21174, -21158, -21228, -20614, -20091, -20166, -20144, -20139, -20134, -20129, -20124, -20119, -20115, -20109, -20104, -20099, -20094, -20089, -20085, -20078, -20072, -20067, -20062, -20057, -20053, -20060, -19982, -20584, -21093, -21012, -21023, -21016, -21012, -21006, -21001, -20996, -20989, -20984, -20980, -20974, -20967, -20962, -20957, -20951, -20945, -20940, -20935, -20929, -20922, -20918, -20913, -20906, -20901, -20896, -20891, -20884, -20878, -20874, -20869, -20861, -20856, -20852, -20845, -20839, -20825, -20610, -21811, -8432, 382, -1161, -873, -871, -868, -864, -861, -859, -856, -854, -852, -850, -848, -846, -844, -843, -842, -841, -840, -839, -849, -787, -1087};