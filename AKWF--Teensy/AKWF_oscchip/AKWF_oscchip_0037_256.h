/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0037 256 samples */
 
const int16_t AKWF_oscchip_0037_256_DATA [256] = 
{1573, 1631, 1612, 1614, 1618, 1655, 1487, 2327, 5705, 6018, 5927, 5948, 5947, 5976, 5852, 6385, 10455, 11294, 11098, 11136, 11133, 11166, 10961, 12231, 14663, 14567, 14566, 14567, 14562, 14590, 14420, 15293, 17937, 18030, 17982, 17989, 17981, 17993, 17902, 18286, 20319, 20600, 20516, 20526, 20519, 20549, 20325, 21844, 24085, 23911, 23925, 23918, 23911, 23845, 24120, 22467, 18639, 18654, 18662, 18641, 18632, 18487, 19120, 15901, 3720, 2783, 3062, 2979, 2972, 2902, 3176, 1937, -6908, -8634, -8225, -8320, -8322, -8572, -7224, -15959, -31443, -30746, -30814, -30833, -30832, -30434, -32404, -21642, 8082, 8839, 8476, 8609, 8615, 8619, 8622, 8623, 8623, 8625, 8625, 8625, 8623, 8623, 8623, 8621, 8621, 8620, 8614, 8612, 8611, 8605, 8624, 8475, 8161, 8164, 8161, 8158, 8153, 8139, 8194, 7897, 6891, 6822, 6840, 6833, 6827, 6930, 6458, 8508, 22047, 24368, 23778, 23904, 23896, 23889, 23882, 23874, 23867, 23857, 23850, 23841, 23832, 23658, 24501, 19760, 7278, 7033, 7152, 7093, 7086, 7076, 7084, 7002, 6653, 6611, 6615, 6607, 6601, 6597, 6590, 6586, 6581, 6577, 6572, 6567, 6562, 6560, 6553, 6550, 6544, 6541, 6536, 6532, 6531, 6525, 6522, 6518, 6514, 6512, 6506, 6503, 6502, 6239, 7383, 2242, -27750, -32542, -31351, -31616, -31611, -31609, -31602, -31596, -31589, -31582, -31574, -31564, -31554, -31544, -31532, -31522, -31511, -31500, -31487, -31475, -31463, -31450, -31435, -31422, -31408, -31394, -31381, -31367, -31352, -31337, -31323, -31307, -31291, -31277, -31261, -31246, -31232, -31216, -31201, -31185, -31170, -31154, -31140, -31124, -31110, -31093, -31079, -31062, -31047, -31031, -31016, -31000, -30990, -30597, -32287, -24410, 19023, 25578, 23942, 24318, 24321, 23999, 25757, 13746, -4672, -3398, -3572, -3590, -3591, -3541, -3777, -2342};