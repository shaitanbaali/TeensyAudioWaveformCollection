/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0089 256 samples */
 
const int16_t AKWF_oscchip_0089_256_DATA [256] = 
{356, 452, 432, 435, 436, 436, 438, 423, 764, 924, 894, 900, 900, 900, 904, 878, 1179, 1391, 1356, 1361, 1362, 1363, 1361, 1363, 1737, 1847, 1823, 1828, 1828, 1829, 1834, 1791, 2474, 2806, 2740, 2753, 2753, 2751, 2762, 2699, 3302, 3740, 3663, 3676, 3674, 3677, 3671, 3676, 4418, 4640, 4592, 4602, 4600, 4600, 4603, 4566, 5254, 5577, 5514, 5524, 5523, 5522, 5526, 5493, 5794, 6011, 5973, 5978, 5976, 5978, 5971, 5976, 7064, 7423, 7349, 7362, 7360, 7358, 7359, 7341, 7672, 7840, 7809, 7812, 7811, 7809, 7816, 7758, 8346, 8786, 8716, 8728, 8726, 8725, 8722, 8717, 9072, 9201, 9173, 9176, 9173, 9171, 9172, 9149, 9474, 9651, 9616, 9620, 9618, 9616, 9620, 9586, 9869, 10099, 10061, 10065, 10062, 10061, 10057, 10044, 10772, 11024, 10966, 10972, 10969, 10968, 10978, 10898, 11891, 12440, 12332, 12349, 12345, 12336, 11745, 15023, -12420, -34826, -31147, -31847, -31836, -31823, -31828, -31897, -27197, -25501, -25839, -25770, -25765, -25748, -25653, -26282, -17051, -11983, -12890, -12713, -12711, -12686, -12751, -12502, -7980, -6927, -7149, -7103, -7099, -7093, -7089, -7106, -6047, -5624, -5702, -5687, -5683, -5680, -5671, -5713, -5072, -4689, -4751, -4737, -4735, -4730, -4737, -4708, -3954, -3763, -3805, -3795, -3793, -3792, -3790, -3799, -3442, -3297, -3327, -3320, -3319, -3318, -3312, -3339, -3019, -2818, -2854, -2848, -2846, -2843, -2849, -2826, -2066, -1873, -1915, -1906, -1904, -1904, -1901, -1914, -1559, -1414, -1443, -1437, -1436, -1435, -1436, -1435, -1433, -1434, -1434, -1432, -1431, -1430, -1434, -1422, -1049, -947, -970, -965, -964, -963, -962, -973, -624, -474, -501, -494, -495, -494, -490, -516, -202, -3, -35, -28, -28, -28, -30, -21};