/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0041 256 samples */
 
const int16_t AKWF_oscchip_0041_256_DATA [256] = 
{15979, 30856, 28806, 29198, 29184, 29175, 29190, 29110, 28357, 28168, 28201, 28184, 28178, 28164, 28162, 28141, 27426, 27126, 27171, 27147, 27137, 27122, 27101, 27177, 25266, 24047, 24232, 24180, 24169, 24152, 24168, 24036, 23266, 23130, 23150, 23129, 23117, 23102, 23104, 23048, 22297, 22065, 22102, 22078, 22067, 22052, 22043, 22047, 21021, 20499, 20583, 20552, 20541, 20530, 20515, 20526, 20220, 19981, 20004, 19986, 19974, 19950, 20004, 19738, 17464, 16958, 17065, 17030, 17021, 17008, 17008, 16977, 16250, 15973, 16019, 15998, 15989, 15978, 15963, 16010, 14717, 13924, 14049, 14015, 14008, 13988, 14039, 13758, 12242, 12006, 12055, 12036, 12028, 12009, 12046, 11883, 9655, 9014, 9148, 9111, 9106, 9092, 9096, 9109, 6341, 5049, 5290, 5236, 5232, 5225, 5192, 5373, 2660, 658, 962, 900, 896, 706, 1488, -1820, -27324, -32619, -31378, -31641, -31636, -31608, -31656, -31504, -27170, -25601, -25916, -25842, -25834, -25814, -25790, -25943, -21338, -18718, -19166, -19064, -19055, -19044, -19011, -19151, -17464, -15972, -16165, -16119, -16111, -16081, -16139, -15878, -12907, -12093, -12261, -12218, -12211, -12196, -12200, -12191, -10101, -9164, -9332, -9289, -9284, -9272, -9245, -9391, -6910, -5207, -5469, -5410, -5408, -5381, -5472, -5054, -2046, -1451, -1586, -1553, -1550, -1650, -1349, -2308, -22885, -29968, -28511, -28802, -28787, -28778, -28770, -28777, -28107, -27737, -27791, -27770, -27759, -27746, -27714, -27845, -26103, -24667, -24857, -24807, -24796, -24762, -24834, -24477, -20755, -19781, -19981, -19926, -19915, -19890, -19906, -19850, -16350, -14847, -15124, -15057, -15047, -15031, -15006, -15139, -12317, -10454, -10742, -10674, -10668, -10658, -10663, -10598, -10214, -10139, -10150, -10140, -10132, -10110, -10157, -9971, -6667, -5617, -5834, -5783, -5780, -5768, -5765, -5797, -3786, -2735, -2920, -2877, -2875, -2877, -2849, -2962};