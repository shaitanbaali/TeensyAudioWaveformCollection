/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0096 256 samples */
 
const int16_t AKWF_oscchip_0096_256_DATA [256] = 
{624, 588, 598, 597, 598, 613, 528, 972, 2230, 2221, 2217, 2221, 2221, 2244, 2124, 2689, 5322, 5494, 5445, 5457, 5457, 5514, 5198, 6961, 10496, 10277, 10305, 10308, 10307, 10352, 10104, 11341, 15172, 15160, 15139, 15148, 15146, 15154, 15095, 15344, 16678, 16771, 16738, 16741, 16737, 16781, 16521, 17885, 20662, 20465, 20492, 20489, 20484, 20555, 20156, 22038, 28053, 28025, 27999, 28009, 28004, 28020, 27893, 28654, 29686, 29570, 29583, 29577, 29570, 29550, 29613, 29221, 28426, 28464, 28449, 28440, 28434, 28406, 28508, 27961, 26249, 26236, 26234, 26223, 26215, 26152, 26449, 24499, 21653, 21908, 21857, 21850, 21842, 21787, 22043, 20568, 17382, 17512, 17492, 17480, 17475, 17421, 17665, 16390, 12111, 12026, 12062, 12042, 12036, 11974, 12283, 10397, 7459, 7745, 7691, 7687, 7684, 7631, 7893, 6497, 3231, 3373, 3356, 3348, 3346, 3306, 3501, 2561, -933, -1003, -970, -985, -985, -1045, -725, -2645, -5543, -5252, -5303, -5303, -5303, -5379, -4968, -7074, -11984, -11738, -11774, -11777, -11776, -11805, -11649, -12358, -14982, -15016, -14995, -15000, -14998, -15042, -14776, -16397, -18938, -18720, -18752, -18751, -18747, -18796, -18505, -20060, -23691, -23569, -23576, -23577, -23574, -23614, -23373, -24511, -28834, -28972, -28922, -28929, -28924, -28964, -28701, -30232, -32850, -32634, -32661, -32656, -32649, -32641, -32634, -32627, -32618, -32611, -32603, -32595, -32586, -32520, -32814, -31331, -25212, -24924, -25010, -24975, -24967, -24854, -25421, -22189, -16433, -16915, -16827, -16819, -16813, -16760, -17002, -15753, -12378, -12478, -12466, -12456, -12451, -12401, -12644, -10970, -8995, -9235, -9187, -9182, -9178, -9133, -9359, -8042, -5774, -5955, -5920, -5917, -5914, -5895, -5984, -5516, -4259, -4290, -4283, -4279, -4277, -4254, -4369, -3566, -2563, -2670, -2650, -2648, -2647, -2611, -2797, -1650};