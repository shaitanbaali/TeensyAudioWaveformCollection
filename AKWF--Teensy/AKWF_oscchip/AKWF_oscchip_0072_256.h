/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0072 256 samples */
 
const int16_t AKWF_oscchip_0072_256_DATA [256] = 
{28242, 31805, 31088, 31215, 31219, 31217, 31218, 31204, 30890, 30805, 30819, 30811, 30806, 30801, 30795, 30798, 30500, 30374, 30390, 30378, 30372, 30362, 30370, 30297, 29662, 29548, 29566, 29553, 29546, 29535, 29535, 29507, 28584, 28307, 28355, 28336, 28329, 28318, 28303, 28361, 26651, 25858, 25998, 25963, 25955, 25929, 26007, 25650, 21814, 21170, 21323, 21283, 21277, 21252, 21284, 21206, 15641, 14014, 14367, 14293, 14288, 14273, 14224, 14533, 8829, 6117, 6655, 6546, 6543, 6515, 6614, 6226, 1738, 987, 1165, 1125, 1122, 1113, 1128, 1102, -1369, -2097, -1939, -1970, -1972, -1977, -1992, -1863, -4443, -5627, -5398, -5441, -5441, -5447, -5420, -5525, -6787, -7024, -6971, -6981, -6980, -6984, -6974, -6986, -8496, -8979, -8880, -8897, -8896, -8895, -8897, -8868, -9422, -9697, -9645, -9652, -9650, -9650, -9637, -9682, -10310, -10433, -10402, -10405, -10403, -10402, -10398, -10394, -10690, -10793, -10769, -10770, -10768, -10765, -10763, -10760, -10757, -10755, -10751, -10749, -10747, -10744, -10736, -10753, -11067, -11130, -11111, -11110, -11108, -11105, -11102, -11099, -11096, -11094, -11091, -11088, -11084, -11082, -11079, -11076, -11073, -11070, -11067, -11065, -11061, -11060, -11051, -11067, -11381, -11444, -11425, -11426, -11422, -11419, -11416, -11413, -11409, -11407, -11405, -11401, -11398, -11395, -11392, -11389, -11385, -11383, -11380, -11377, -11374, -11371, -11368, -11364, -11361, -11359, -11356, -11353, -11350, -11347, -11343, -11340, -11337, -11334, -11332, -11329, -11325, -11322, -11319, -11316, -11313, -11310, -11308, -11304, -11301, -11295, -11300, -11271, -10643, -10488, -10521, -10511, -10508, -10505, -10502, -10500, -10497, -10493, -10490, -10488, -10485, -10484, -10472, -10506, -10824, -10863, -10850, -10849, -10846, -10844, -10838, -10845, -11157, -11231, -11210, -11210, -11208, -11205, -11202, -11199, -11196, -11193, -11190, -11187, -11185, -11066, -11676, -8827};