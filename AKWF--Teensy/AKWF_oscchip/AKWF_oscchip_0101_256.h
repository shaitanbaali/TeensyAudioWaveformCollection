/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0101 256 samples */
 
const int16_t AKWF_oscchip_0101_256_DATA [256] = 
{1138, 785, 880, 872, 875, 917, 727, 1739, 4677, 4682, 4673, 4684, 4685, 4717, 4553, 5608, 7091, 6934, 6959, 6957, 6958, 6958, 6958, 6958, 6958, 6957, 6956, 6956, 6954, 6953, 6952, 6951, 6950, 6948, 6947, 6946, 6943, 6953, 6893, 7251, 7742, 7685, 7696, 7693, 7690, 7859, 6938, 11861, 21865, 21201, 21302, 21303, 21302, 21141, 21959, 18076, 5316, 5377, 5411, 5377, 5374, 5330, 5550, 4147, 2175, 2369, 2331, 2328, 2325, 2501, 1536, 6859, 17929, 17363, 17438, 17452, 17449, 17453, 17413, 17596, 18190, 18192, 18183, 18182, 18178, 18184, 18127, 18456, 18957, 18909, 18914, 18910, 18905, 18909, 18858, 19104, 19667, 19640, 19636, 19633, 19628, 19624, 19619, 19613, 19609, 19603, 19598, 19594, 19588, 19582, 19579, 19573, 19567, 19563, 19558, 19552, 19547, 19543, 19537, 19531, 19527, 19522, 19516, 19510, 19507, 19491, 19544, 19123, 18674, 18730, 18713, 18709, 18704, 18698, 18693, 18689, 18683, 18678, 18674, 18668, 18662, 18650, 18692, 18441, 17862, 17884, 17874, 17868, 17862, 17817, 18035, 16435, 14640, 14852, 14811, 14806, 14802, 14623, 15565, 9865, 553, 1287, 1159, 1146, 1144, 1021, 1667, -1841, -10405, -10190, -10207, -10225, -10225, -10305, -9863, -12997, -16648, -16205, -16280, -16276, -16275, -16301, -16146, -17042, -18640, -18517, -18529, -18528, -18525, -18552, -18383, -19246, -21581, -21529, -21523, -21525, -21520, -21527, -21463, -21844, -22306, -22241, -22246, -22242, -22236, -22260, -22092, -22997, -24604, -24462, -24480, -24475, -24469, -24495, -24318, -25157, -27528, -27459, -27453, -27450, -27442, -27468, -27287, -28427, -29823, -29649, -29674, -29667, -29660, -29692, -29472, -30658, -32789, -32622, -32642, -32635, -32628, -32619, -32611, -32603, -32595, -32587, -32579, -32570, -32563, -32544, -32590, -32207, -31729, -31773, -31756, -31748, -31738, -31393, -33212, -22113};