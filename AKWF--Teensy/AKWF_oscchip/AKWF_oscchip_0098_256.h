/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0098 256 samples */
 
const int16_t AKWF_oscchip_0098_256_DATA [256] = 
{5832, 9340, 8656, 8782, 8786, 8798, 8812, 8679, 13302, 15284, 14905, 14973, 14973, 14972, 14981, 14923, 15617, 16063, 15986, 15997, 15995, 16004, 15971, 16049, 19368, 20267, 20059, 20095, 20093, 20096, 20107, 19964, 23457, 24959, 24648, 24699, 24694, 24690, 24695, 24625, 25310, 25767, 25679, 25689, 25683, 25677, 25670, 25664, 25658, 25652, 25645, 25639, 25632, 25625, 25619, 25612, 25606, 25599, 25593, 25586, 25579, 25573, 25560, 25586, 25231, 24997, 25032, 25019, 25013, 25004, 25001, 24986, 24569, 24441, 24458, 24447, 24439, 24431, 24421, 24447, 23680, 23324, 23382, 23364, 23358, 23350, 23329, 23413, 22388, 21685, 21790, 21762, 21756, 21747, 21747, 21730, 20910, 20652, 20700, 20684, 20678, 20669, 20646, 20757, 18518, 17385, 17590, 17547, 17543, 17536, 17519, 17579, 16914, 16419, 16491, 16471, 16467, 16448, 16462, 16468, 11555, 9977, 10319, 10248, 10244, 10233, 10187, 10480, 5572, 3132, 3612, 3515, 3513, 3509, 3415, 3926, -688, -4199, -3604, -3717, -3716, -3719, -3717, -3715, -4530, -4794, -4741, -4752, -4752, -4762, -4816, -4402, -11154, -14546, -13908, -14026, -14022, -14038, -13972, -14210, -17580, -18261, -18108, -18134, -18131, -18135, -18125, -18108, -20490, -21343, -21169, -21195, -21193, -21192, -21214, -21032, -23939, -25522, -25239, -25285, -25281, -25279, -25260, -25304, -26134, -26314, -26265, -26268, -26262, -26262, -26254, -26212, -28600, -29475, -29286, -29315, -29308, -29302, -29303, -29245, -29962, -30363, -30281, -30287, -30280, -30278, -30248, -30315, -31995, -32373, -32277, -32287, -32279, -32272, -32264, -32246, -32637, -32777, -32738, -32736, -32727, -32716, -32685, -32823, -30643, -29406, -29629, -29576, -29569, -29546, -29587, -29424, -26034, -25268, -25427, -25386, -25378, -25363, -25353, -25421, -22253, -21018, -21252, -21198, -21191, -21175, -21088, -21626, -14458, -10258, -10981, -10838, -10831, -10810, -10892, -10424};