/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0073 256 samples */
 
const int16_t AKWF_oscchip_0073_256_DATA [256] = 
{29102, 31720, 31167, 31265, 31269, 31257, 31290, 31175, 28656, 28080, 28203, 28171, 28166, 28138, 28257, 27649, 25170, 25039, 25068, 25053, 25047, 24926, 25443, 23147, 5907, 3497, 4043, 3924, 3918, 3879, 3986, 3591, -4852, -7007, -6555, -6643, -6645, -6652, -6621, -6776, -7496, -7538, -7527, -7530, -7528, -7522, -7550, -7431, -6340, -6176, -6215, -6205, -6204, -6128, -6321, -5769, 15392, 21196, 19915, 20160, 20157, 20229, 19862, 21495, 29100, 29457, 29331, 29362, 29357, 29309, 29503, 28702, 21370, 20348, 20597, 20538, 20532, 20504, 20558, 20422, 13276, 11378, 11794, 11707, 11704, 11614, 12038, 10117, 1141, 595, 735, 696, 692, 678, 725, 525, -1283, -1563, -1501, -1516, -1516, -1527, -1482, -1716, -2403, -2401, -2397, -2400, -2399, -2408, -2364, -2573, -3647, -3735, -3712, -3718, -3718, -3719, -3709, -3743, -4101, -4165, -4149, -4151, -4150, -4158, -4113, -4329, -5028, -5028, -5023, -5025, -5024, -5028, -4999, -5128, -5855, -5911, -5892, -5895, -5894, -5896, -5881, -5934, -6660, -6793, -6758, -6761, -6761, -6758, -6756, -6755, -6753, -6752, -6750, -6749, -6747, -6752, -6720, -6848, -7574, -7629, -7613, -7614, -7613, -7613, -7603, -7630, -7993, -8054, -8037, -8038, -8036, -8038, -8015, -8116, -8463, -8466, -8461, -8460, -8458, -8459, -8443, -8503, -8861, -8893, -8882, -8881, -8879, -8878, -8869, -8895, -9251, -9321, -9304, -9305, -9302, -9304, -9282, -9377, -9725, -9731, -9725, -9724, -9721, -9719, -9717, -9714, -9711, -9709, -9706, -9704, -9702, -9701, -9692, -9711, -10065, -10142, -10121, -10122, -10119, -10117, -10114, -10112, -10109, -10106, -10103, -10100, -10098, -10098, -10084, -10133, -10496, -10533, -10518, -10518, -10515, -10514, -10507, -10519, -10878, -10956, -10933, -10934, -10931, -10928, -10926, -10923, -10920, -10918, -10914, -10911, -10909, -10764, -11519, -8014};