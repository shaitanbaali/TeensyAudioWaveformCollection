/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0148 256 samples */
 
const int16_t AKWF_oscchip_0148_256_DATA [256] = 
{28385, 31010, 30384, 30498, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30464, 30655, 29620, 26883, 26892, 26904, 26895, 26895, 26857, 27049, 26108, 22288, 22042, 22115, 22093, 22092, 22076, 22150, 21817, 19493, 19143, 19228, 19209, 19209, 19143, 19504, 17290, 13252, 13481, 13450, 13447, 13447, 13408, 13612, 12509, 9593, 9601, 9612, 9604, 9604, 9577, 9711, 9053, 6376, 6202, 6255, 6241, 6241, 6224, 6299, 5966, 3643, 3293, 3378, 3359, 3357, 3336, 3456, 2719, 1374, 1453, 1440, 1439, 1439, 1414, 1542, 852, -973, -966, -959, -964, -964, -1204, -14, -5847, -29542, -31078, -30620, -30743, -30743, -30744, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30743, -30390, -32294, -22079};