/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0077 256 samples */
 
const int16_t AKWF_oscchip_0077_256_DATA [256] = 
{2335, 2849, 2751, 2768, 2770, 2775, 2772, 2755, 4647, 5331, 5196, 5222, 5221, 5222, 5231, 5173, 6023, 6513, 6428, 6442, 6441, 6448, 6421, 6515, 8494, 8969, 8863, 8882, 8881, 8881, 8881, 8856, 9792, 10156, 10078, 10089, 10086, 10086, 10106, 9972, 11678, 12680, 12495, 12527, 12524, 12420, 12742, 11762, -16209, -23034, -21493, -21796, -21793, -21732, -21679, -22531, 4775, 15526, 13324, 13746, 13739, 13704, 13287, 15922, -15636, -34405, -30934, -31598, -31587, -31433, -31911, -30467, 8413, 17846, 15813, 16208, 16215, 16219, 16222, 16167, 18017, 18778, 18634, 18660, 18658, 18655, 18653, 18650, 18647, 18644, 18640, 18636, 18634, 18630, 18625, 18621, 18618, 18614, 18610, 18605, 18601, 18597, 18592, 18588, 18583, 18579, 18574, 18569, 18565, 18560, 18555, 18550, 18545, 18541, 18536, 18531, 18526, 18522, 18516, 18512, 18507, 18502, 18497, 18492, 18487, 18481, 18471, 18507, 17587, 17167, 17245, 17225, 17220, 17198, 17266, 16988, 13915, 13430, 13544, 13513, 13508, 13498, 13507, 13480, 11499, 10943, 11057, 11030, 11026, 11013, 10978, 11250, 5769, 3265, 3747, 3651, 3650, 3624, 3721, 3320, -699, -1379, -1227, -1259, -1260, -1286, -1234, -1339, -9130, -11458, -10982, -11070, -11072, -11071, -11064, -11106, -10202, -9778, -9853, -9836, -9834, -9838, -9816, -9897, -10894, -11087, -11040, -11048, -11047, -11050, -11039, -11050, -12960, -13588, -13453, -13475, -13472, -13486, -13590, -12895, -25282, -31571, -30384, -30597, -30592, -30586, -30581, -30575, -30570, -30564, -30558, -30551, -30545, -30535, -30531, -30532, -29563, -29230, -29292, -29271, -29264, -29252, -29209, -29436, -25889, -24037, -24384, -24309, -24302, -24252, -24407, -23834, -14709, -12921, -13322, -13235, -13228, -13206, -13217, -13278, -6495, -4243, -4705, -4614, -4610, -4603, -4575, -4746, -2113, -714, -964, -913, -912, -904, -931, -785};