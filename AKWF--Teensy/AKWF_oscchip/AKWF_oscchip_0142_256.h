/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0142 256 samples */
 
const int16_t AKWF_oscchip_0142_256_DATA [256] = 
{28336, 30990, 30359, 30469, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30473, 30412, 30750, 28671, 24885, 25100, 25072, 25069, 25068, 24894, 25808, 20870, 7806, 7844, 7900, 7864, 7863, 7823, 8020, 7057, 3146, 2892, 2968, 2947, 2946, 2911, 3107, 1684, -153, 33, 0, -1, 0, -135, 603, -3931, -12196, -11725, -11788, -11798, -11799, -11963, -11101, -15757, -28076, -28037, -27985, -28019, -28021, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -28020, -27998, -28121, -27365, -25988, -26065, -26056, -26055, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -26054, -25736, -27501, -14683, 1866, 201, 483, 492, 492, 492, 492, 492, 492, 492, 492, 492, 492, 477, 555, 131, -992, -988, -984, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -981, -1013, -775, -470, -501, -495, -494, -495, -500, -469, -659, -1003, -983, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -986, -987, -992, -960, -1197, -1503, -1473, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1478, -1720, -521, -6394, -30250, -31796, -31336, -31459, -31460, -31461, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31460, -31103, -33029, -22698};