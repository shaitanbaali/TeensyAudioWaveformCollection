/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0058 256 samples */
 
const int16_t AKWF_oscchip_0058_256_DATA [256] = 
{194, 252, 236, 238, 239, 239, 239, 239, 239, 239, 239, 239, 238, 244, 215, 380, 777, 778, 777, 781, 780, 776, 774, 775, 775, 775, 775, 774, 775, 773, 772, 773, 773, 773, 773, 773, 773, 773, 773, 773, 772, 771, 771, 771, 771, 771, 771, 771, 771, 771, 771, 769, 768, 992, -30, 4660, 29158, 32580, 31703, 31898, 31891, 31875, 31904, 31755, 30083, 29629, 29718, 29684, 29678, 29531, 30217, 26164, 16687, 16703, 16753, 16709, 16698, 16634, 16884, 15560, 10526, 10109, 10225, 10186, 10176, 10139, 10255, 9715, 5913, 5167, 5336, 5292, 5286, 5270, 5296, 5194, 3159, 2461, 2601, 2568, 2564, 2547, 2619, 2193, 969, 926, 941, 932, 932, 923, 956, 782, -63, -173, -144, -150, -152, -302, 242, -1880, -24393, -30174, -28884, -29151, -29142, -29121, -29142, -29096, -25952, -24607, -24857, -24796, -24791, -24708, -25058, -23218, -16519, -16035, -16178, -16127, -16120, -16084, -16189, -15677, -12278, -11663, -11802, -11762, -11756, -11713, -11812, -11453, -4916, -2772, -3211, -3113, -3111, -3089, -3166, -2711, -1498, -1472, -1477, -1469, -1467, -1467, -1462, -1458, -1457, -1456, -1455, -1451, -1446, -1449, -1437, -1478, -1895, -1994, -1969, -1973, -1972, -1969, -1972, -1964, -1566, -1404, -1435, -1424, -1424, -1425, -1423, -1422, -1422, -1423, -1422, -1420, -1421, -1420, -1401, -1473, -1898, -1964, -1946, -1948, -1949, -1945, -1952, -1925, -1508, -1385, -1411, -1402, -1403, -1403, -1401, -1400, -1401, -1401, -1400, -1398, -1398, -1407, -1366, -1562, -2402, -2482, -2459, -2462, -2461, -2453, -2487, -2336, -1068, -792, -858, -844, -843, -841, -845, -833, -430, -278, -305, -298, -299, -298, -298, -298, -298, -299, -297, -296, -297, -294, -308, -238};