/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0126 256 samples */
 
const int16_t AKWF_oscchip_0126_256_DATA [256] = 
{2740, 3018, 2953, 2965, 2966, 2976, 2930, 3136, 4570, 4785, 4734, 4743, 4744, 4879, 4137, 8698, 17011, 16539, 16602, 16611, 16610, 16652, 16431, 17624, 20782, 20773, 20759, 20769, 20770, 20804, 20638, 21450, 24752, 24967, 24904, 24919, 24919, 24933, 24871, 25147, 27064, 27353, 27283, 27298, 27298, 27292, 27329, 27100, 26684, 26709, 26704, 26703, 26703, 26715, 26652, 26993, 27895, 27893, 27888, 27889, 27889, 27899, 27851, 28084, 29029, 29091, 29072, 29075, 29075, 29096, 29003, 29416, 32288, 32719, 32612, 32637, 32638, 32298, 34155, 22752, 1967, 3151, 2990, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2966, 2929, 3119, 2096, -610, -601, -591, -598, -598, -618, -523, -987, -2875, -2997, -2960, -2970, -2970, -2987, -2911, -3255, -5646, -6005, -5917, -5936, -5936, -5943, -5906, -6133, -6549, -6525, -6528, -6528, -6528, -6535, -6503, -6674, -7125, -7124, -7121, -7122, -7122, -7127, -7104, -7219, -7691, -7722, -7712, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7714, -7708, -7745, -7518, -7102, -7126, -7123, -7123, -7122, -7116, -7148, -6977, -6526, -6530, -6530, -6528, -6529, -6528, -6528, -6528, -6528, -6528, -6528, -6528, -6528, -6525, -6540, -6472, -5994, -5922, -5940, -5937, -5936, -5930, -5967, -5738, -5323, -5347, -5343, -5343, -5342, -5324, -5419, -4909, -3557, -3560, -3567, -3565, -3564, -3527, -3730, -2641};