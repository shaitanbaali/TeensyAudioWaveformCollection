/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0066 256 samples */
 
const int16_t AKWF_oscchip_0066_256_DATA [256] = 
{613, 702, 685, 689, 691, 694, 686, 715, 1224, 1334, 1309, 1313, 1314, 1314, 1315, 1316, 1316, 1316, 1316, 1316, 1316, 1319, 1302, 1376, 1887, 1945, 1932, 1936, 1935, 1945, 1906, 2047, 4563, 5138, 5015, 5038, 5037, 5037, 5036, 5035, 5034, 5033, 5033, 5032, 5031, 5031, 5059, 4879, 7439, 8956, 8695, 8739, 8738, 8748, 8711, 8828, 11845, 12592, 12419, 12449, 12447, 12457, 12467, 12307, 17990, 20256, 19785, 19869, 19865, 19866, 19949, 19440, 25365, 29080, 28403, 28523, 28516, 28431, 28664, 27987, 6271, 828, 2044, 1801, 1799, 1798, 1796, 1761, 2712, 3093, 3010, 3021, 3020, 3024, 2993, 3111, 4141, 4276, 4243, 4248, 4247, 4243, 4246, 4230, 3730, 3596, 3622, 3616, 3615, 3612, 3610, 3624, 3155, 2958, 2994, 2986, 2985, 2983, 2983, 2981, 2980, 2979, 2977, 2978, 2976, 2977, 2972, 2984, 3479, 3617, 3586, 3592, 3589, 3594, 3608, 3488, 6720, 8149, 7874, 7924, 7923, 7945, 7841, 8259, 12867, 13650, 13459, 13496, 13494, 13536, 13442, 13612, 27490, 31592, 30673, 30844, 30837, 30768, 30509, 32418, -5398, -22924, -19402, -20071, -20064, -20053, -20111, -19892, -17305, -16885, -16986, -16964, -16963, -16939, -16980, -16928, -9984, -7909, -8349, -8262, -8261, -8256, -8242, -8337, -6492, -5630, -5794, -5762, -5759, -5754, -5764, -5717, -5205, -5113, -5130, -5123, -5121, -5118, -5119, -5113, -4622, -4470, -4498, -4491, -4490, -4517, -4653, -3640, -23338, -33226, -31449, -31769, -31766, -31745, -31808, -31529, -27995, -27274, -27429, -27392, -27386, -27366, -27376, -27376, -22519, -20871, -21208, -21138, -21132, -21119, -21063, -21374, -16017, -13231, -13746, -13646, -13640, -13608, -13702, -13341, -7213, -5932, -6228, -6164, -6161, -6147, -6150, -6196, -2304, -952, -1234, -1178, -1177, -1169, -1202, -1037};