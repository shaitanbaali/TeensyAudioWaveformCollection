/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0057 256 samples */
 
const int16_t AKWF_oscchip_0057_256_DATA [256] = 
{12189, 24021, 22413, 22715, 22704, 22700, 22696, 22692, 22686, 22681, 22674, 22667, 22660, 22649, 22647, 22629, 21332, 20764, 20863, 20830, 20824, 20816, 20813, 20751, 21604, 22178, 22073, 22084, 22070, 22061, 22046, 22061, 21810, 21554, 21576, 21557, 21547, 21536, 21525, 21515, 21504, 21493, 21484, 21473, 21463, 21453, 21442, 21430, 21418, 21407, 21397, 21386, 21375, 21366, 21362, 21306, 21831, 22256, 22183, 22183, 22172, 22154, 21552, 24857, -1508, -33607, -30415, -30961, -30966, -30971, -30971, -30970, -30969, -30964, -30958, -30953, -30947, -30940, -30931, -30922, -30914, -30903, -30892, -30882, -30871, -30859, -30849, -30837, -30823, -30811, -30797, -30785, -30770, -30650, -30969, -29840, -9866, -3515, -4873, -4578, -4573, -4561, -4553, -4570, -3009, -2201, -2338, -2304, -2299, -2294, -2293, -2267, -2540, -2750, -2711, -2714, -2712, -2707, -2709, -2682, -2902, -3160, -3129, -3133, -3130, -3128, -3124, -3128, -3455, -3583, -3555, -3557, -3556, -3552, -3549, -3550, -3548, -3548, -3543, -3539, -3540, -3538, -3533, -3551, -3301, -3064, -3091, -3086, -3081, -3079, -3078, -3077, -3077, -3074, -3071, -3070, -3069, -3068, -3068, -3067, -3060, -3059, -3059, -3058, -3057, -3056, -3051, -3049, -3049, -3048, -3047, -3046, -3043, -3040, -3035, -3060, -2829, -2571, -2597, -2589, -2588, -2585, -2589, -2577, -2239, -2117, -2140, -2131, -2130, -2131, -2130, -2128, -2129, -2125, -2122, -2121, -2120, -2120, -2115, -2138, -1878, -1650, -1678, -1670, -1671, -1670, -1673, -1647, -1849, -2126, -2102, -2105, -2102, -2102, -2103, -2102, -1780, -1635, -1663, -1657, -1652, -1653, -1654, -1636, -1919, -2119, -2085, -2091, -2089, -2089, -2092, -2062, -2300, -2554, -2523, -2529, -2527, -2528, -2526, -2521, -2521, -2520, -2519, -2519, -2518, -2516, -2515, -2527, -1916, -1576, -1632, -1620, -1620, -1626, -1591, -1758};