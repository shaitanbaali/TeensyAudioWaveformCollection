/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0132 256 samples */
 
const int16_t AKWF_oscchip_0132_256_DATA [256] = 
{28521, 31069, 30469, 30578, 30584, 30517, 30899, 28124, 24540, 24898, 24835, 24831, 24828, 24295, 27200, 9329, -23237, -21385, -21639, -21679, -21679, -21646, -21821, -20878, -18381, -18388, -18395, -18386, -18383, -18112, -19443, -12904, 13641, 15364, 14854, 14991, 14993, 14679, 16425, 3750, -12617, -10971, -11249, -11255, -11254, -11041, -12204, -5056, 7968, 7227, 7329, 7345, 7346, 7246, 7769, 4944, -2532, -2507, -2477, -2499, -2500, -2464, -2639, -1783, 1697, 1923, 1855, 1874, 1875, 1835, 2053, 468, -1576, -1370, -1405, -1407, -1406, -1294, -1910, 1873, 8767, 8376, 8429, 8435, 8435, 8444, 8386, 8699, 9527, 9523, 9518, 9520, 9519, 9530, 9462, 9781, 11084, 11166, 11139, 11144, 11142, 11146, 11106, 11370, 11712, 11675, 11677, 11675, 11672, 11676, 11640, 11846, 12226, 12202, 12202, 12199, 12197, 12379, 11402, 16657, 30568, 30519, 30457, 30492, 30487, 30343, 31026, 27647, 13934, 13039, 13297, 13223, 13217, 13205, 13236, 12968, 12622, 12653, 12643, 12638, 12633, 12605, 12738, 11893, 10353, 10437, 10420, 10415, 10412, 10371, 10570, 9469, 6559, 6565, 6575, 6564, 6561, 6518, 6712, 5745, 1825, 1570, 1643, 1621, 1617, 1545, 1942, -961, -4711, -4335, -4399, -4401, -4400, -4434, -4264, -5316, -7233, -7122, -7136, -7137, -7137, -7143, -7113, -7268, -7683, -7681, -7678, -7676, -7676, -7682, -7639, -7850, -8719, -8774, -8755, -8757, -8755, -8760, -8722, -8983, -9322, -9287, -9289, -9288, -9286, -9308, -9169, -10007, -11537, -11447, -11456, -11455, -11453, -11467, -11378, -11847, -13093, -13086, -13079, -13079, -13075, -13086, -13017, -13335, -14637, -14718, -14688, -14693, -14690, -14699, -14623, -15147, -15825, -15754, -15762, -15759, -15755, -15918, -14990, -20663, -31003, -30409, -30484, -30491, -30485, -30463, -30544, -30067, -28816, -28813, -28813, -28802, -28794, -28445, -30286, -20379};