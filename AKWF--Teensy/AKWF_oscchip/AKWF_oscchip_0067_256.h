/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0067 256 samples */
 
const int16_t AKWF_oscchip_0067_256_DATA [256] = 
{15808, 17183, 16892, 16943, 16946, 16946, 16946, 16944, 16942, 16941, 16940, 16937, 16935, 16932, 16930, 16927, 16923, 16921, 16918, 16914, 16910, 16654, 17773, 12957, -26370, -32238, -30891, -31165, -31165, -30689, -33204, -20314, 17268, 16929, 16791, 16905, 16903, 16903, 16902, 16901, 16900, 16898, 16896, 16893, 16891, 16889, 16886, 16883, 16880, 16877, 16873, 16870, 16866, 16862, 16858, 16855, 16851, 16847, 16843, 16840, 16836, 16831, 16827, 16823, 16819, 16814, 16811, 16806, 16802, 16798, 16793, 16789, 16785, 16780, 16776, 16771, 16767, 16762, 16758, 16754, 16749, 16745, 16740, 16736, 16731, 16727, 16722, 16719, 16713, 16709, 16704, 16701, 16696, 16692, 16687, 16683, 16678, 16674, 16669, 16665, 16661, 16656, 16652, 16647, 16643, 16638, 16634, 16629, 16624, 16508, 16975, 15109, -7522, -11514, -10531, -10733, -10732, -10733, -10735, -10736, -10735, -10735, -10735, -10736, -10735, -10734, -10733, -10731, -10730, -10728, -10728, -10725, -10723, -10720, -10724, -10703, -10392, -10323, -10337, -10332, -10330, -10331, -10312, -10386, -10686, -10696, -10690, -10689, -10687, -10683, -10681, -10679, -10675, -10673, -10670, -10668, -10665, -10661, -10661, -10650, -10347, -10259, -10275, -10269, -10266, -10266, -10251, -10307, -10613, -10634, -10624, -10623, -10620, -10616, -10620, -10591, -10276, -10219, -10230, -10225, -10222, -10220, -10216, -10213, -10509, -10600, -10578, -10579, -10576, -10573, -10570, -10567, -10565, -10562, -10559, -10556, -10553, -10551, -10548, -10545, -10542, -10539, -10537, -10534, -10531, -10527, -10525, -10526, -10232, -10122, -10141, -10135, -10132, -10131, -10119, -10157, -10463, -10502, -10490, -10489, -10486, -10482, -10482, -10471, -10168, -10080, -10097, -10090, -10088, -10086, -10084, -10070, -10345, -10470, -10443, -10445, -10442, -10439, -10437, -10434, -10431, -10428, -10426, -10423, -10420, -10417, -10415, -10412, -10409, -10406, -10403, -10400, -10398, -10292, -10842, -8246};