/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0079 256 samples */
 
const int16_t AKWF_oscchip_0079_256_DATA [256] = 
{823, 757, 753, 759, 762, 765, 769, 771, 772, 775, 777, 779, 781, 782, 783, 785, 786, 787, 787, 788, 788, 1111, -588, 7606, 32416, 32000, 31977, 32026, 32025, 32014, 32051, 31868, 30941, 30876, 30890, 30880, 30874, 30841, 30984, 30141, 28534, 28628, 28602, 28594, 28587, 28547, 28717, 27840, 25204, 25210, 25210, 25197, 25190, 25167, 25241, 24873, 23033, 22900, 22922, 22907, 22901, 22868, 23000, 22210, 20580, 20653, 20638, 20629, 20622, 20606, 20654, 20372, 19483, 19465, 19468, 19458, 19453, 19321, 19955, 16992, 534, -956, -573, -664, -668, -645, -788, -42, 1629, 1536, 1543, 1541, 1540, 1559, 1452, 1958, 3761, 3786, 3767, 3773, 3771, 3776, 3742, 3889, 4811, 4898, 4870, 4875, 4874, 4873, 4871, 4871, 4870, 4868, 4867, 4866, 4864, 4863, 4862, 4860, 4859, 4858, 4856, 4855, 4854, 4838, 4917, 4422, 3681, 3746, 3734, 3732, 3731, 3730, 3729, 3727, 3726, 3725, 3724, 3724, 3722, 3722, 3721, 3720, 3718, 3717, 3716, 3715, 3714, 3713, 3712, 3711, 3710, 3708, 3708, 3706, 3705, 3693, 3756, 3410, 2556, 2580, 2580, 2577, 2577, 2559, 2650, 2189, 394, 322, 345, 336, 338, -18, 1912, -9294, -27839, -26144, -26425, -26425, -26424, -26371, -26630, -25302, -21841, -21963, -21954, -21944, -21939, -21925, -21969, -21747, -20823, -20790, -20791, -20784, -20779, -20773, -20768, -20764, -20758, -20753, -20747, -20743, -20737, -20731, -20726, -20721, -20715, -20710, -20705, -20699, -20693, -20698, -20644, -20856, -21765, -21791, -21779, -21776, -21770, -21765, -21760, -21754, -21748, -21743, -21737, -21731, -21726, -21720, -21714, -21708, -21703, -21696, -21690, -21686, -21679, -21673, -21668, -21662, -21656, -21651, -21645, -21639, -21633, -21627, -21622, -21616, -21610, -21604, -21598, -21593, -21586, -21410, -22319, -17302};