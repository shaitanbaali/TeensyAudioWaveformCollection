/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0107 256 samples */
 
const int16_t AKWF_oscchip_0107_256_DATA [256] = 
{2121, 3177, 2980, 3018, 3018, 3019, 3007, 3046, 3741, 3884, 3850, 3856, 3856, 3883, 3865, 3682, 15482, 19743, 18888, 19044, 19041, 19039, 19039, 19016, 19313, 19474, 19442, 19445, 19441, 19443, 19590, 18693, 26659, 33095, 32100, 32282, 32276, 32219, 32217, 32544, 11017, 2877, 4467, 4165, 4158, 4151, 4127, 4248, 2508, 1463, 1638, 1602, 1599, 1596, 1544, 1825, -691, -2890, -2576, -2635, -2636, -2644, -2653, -2557, -5775, -7079, -6810, -6860, -6859, -6859, -6842, -6937, -5772, -5061, -5189, -5164, -5164, -5163, -5162, -5160, -5159, -5159, -5157, -5156, -5155, -5177, -5207, -4811, -15767, -20235, -19329, -19500, -19495, -19493, -19498, -19444, -20022, -20375, -20306, -20315, -20310, -20259, -20391, -20002, -7696, -4554, -5218, -5086, -5082, -5096, -5122, -4791, -14281, -18356, -17582, -17722, -17719, -17710, -17638, -18066, -12945, -9659, -10201, -10094, -10090, -10087, -10085, -10080, -10078, -10074, -10071, -10068, -10065, -10061, -10055, -10077, -9449, -9164, -9215, -9202, -9200, -9197, -9203, -9151, -9699, -10083, -10016, -10023, -10020, -10003, -10029, -9978, -5267, -3848, -4156, -4095, -4095, -4089, -4074, -4168, -2290, -1409, -1584, -1549, -1548, -1548, -1507, -1728, 501, 2059, 1786, 1836, 1837, 1810, 1866, 1807, -7697, -10466, -9864, -9976, -9974, -9946, -9839, -10716, 5503, 13170, 11704, 11984, 11981, 11986, 12096, 11420, 18074, 22745, 21953, 22103, 22099, 22020, 22157, 21956, -3371, -11297, -9692, -9996, -9999, -9963, -9780, -11127, 15350, 28210, 25863, 26290, 26289, 26267, 25881, 28170, 4840, -12643, -9959, -10456, -10457, -10408, -10470, -10458, 6282, 12021, 10839, 11061, 11059, 11050, 10990, 11359, 5314, 2126, 2719, 2611, 2609, 2607, 2551, 2857, -69, -2340, -1977, -2044, -2044, -2041, -2044, -2068, -414, 165, 43, 65, 63, 62, 69, 39};