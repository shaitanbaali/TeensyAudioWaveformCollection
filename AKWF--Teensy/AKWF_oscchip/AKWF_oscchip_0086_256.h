/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0086 256 samples */
 
const int16_t AKWF_oscchip_0086_256_DATA [256] = 
{1824, 2412, 2296, 2317, 2317, 2319, 2341, 2205, 4169, 5281, 5077, 5112, 5111, 5112, 5127, 5031, 5886, 6601, 6490, 6508, 6507, 6507, 6505, 6491, 7219, 7478, 7422, 7432, 7430, 7429, 7431, 7403, 7730, 7915, 7879, 7884, 7882, 7880, 7891, 7819, 8390, 8866, 8786, 8800, 8798, 8797, 8794, 8778, 9497, 9763, 9707, 9716, 9714, 9713, 9718, 9668, 10317, 10686, 10619, 10629, 10626, 10623, 10644, 10507, 11638, 12597, 12450, 12475, 12472, 12470, 12468, 12449, 13147, 13433, 13374, 13381, 13378, 13377, 13397, 13251, 15148, 16320, 16119, 16149, 16146, 16143, 16149, 16083, 16627, 17116, 17044, 17053, 17048, 17047, 17046, 17017, 17719, 18007, 17943, 17950, 17945, 17941, 17946, 17884, 18512, 18919, 18843, 18852, 18848, 18868, 18788, 18969, 26719, 28745, 28284, 28366, 28360, 28263, 28097, 29869, -15312, -34225, -30390, -31130, -31120, -31112, -30997, -31711, -23743, -18735, -19627, -19451, -19451, -19441, -19455, -19408, -17543, -17016, -17121, -17096, -17093, -17087, -17079, -17115, -16070, -15605, -15686, -15665, -15661, -15657, -15639, -15715, -14778, -14158, -14254, -14234, -14229, -14223, -14223, -14212, -13838, -13724, -13740, -13734, -13729, -13725, -13717, -13744, -13064, -12728, -12786, -12772, -12767, -12763, -12735, -12873, -11363, -10277, -10449, -10414, -10410, -10404, -10405, -10399, -9654, -9422, -9470, -9457, -9454, -9449, -9436, -9511, -8129, -7465, -7594, -7566, -7564, -7562, -7553, -7583, -7280, -7055, -7092, -7082, -7080, -7076, -7078, -7075, -6331, -6097, -6143, -6132, -6129, -6126, -6120, -6156, -5472, -5137, -5200, -5186, -5185, -5182, -5176, -5206, -4901, -4680, -4716, -4708, -4707, -4705, -4704, -4702, -4701, -4699, -4698, -4697, -4695, -4692, -4679, -4753, -3423, -2724, -2846, -2822, -2821, -2818, -2787, -2964, -1206, 150, -53, -15, -16, -14, -13, -6};