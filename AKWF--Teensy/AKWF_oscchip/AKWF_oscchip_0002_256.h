/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0002 256 samples */
 
const int16_t AKWF_oscchip_0002_256_DATA [256] = 
{1944, 2119, 2084, 2089, 2094, 2121, 1997, 2599, 5409, 5612, 5553, 5566, 5566, 5688, 5059, 8083, 19937, 20599, 20391, 20441, 20435, 20537, 19987, 22557, 32102, 32382, 32274, 32295, 32286, 32246, 32371, 31669, 29278, 29228, 29235, 29211, 29197, 29070, 29648, 26547, 17295, 17170, 17233, 17185, 17173, 17065, 17551, 14976, 8130, 8177, 8179, 8154, 8145, 8134, 8130, 8112, 7712, 7588, 7608, 7595, 7588, 7607, 7519, 7771, 13301, 14770, 14438, 14495, 14486, 14504, 14415, 14698, 19877, 21123, 20841, 20887, 20880, 20880, 20834, 20968, 22974, 23395, 23288, 23295, 23283, 23293, 23202, 23510, 26707, 27315, 27153, 27170, 27157, 27148, 27111, 27188, 27987, 28105, 28060, 28051, 28037, 27974, 28178, 27208, 19452, 18321, 18577, 18507, 18493, 18431, 18649, 17583, 10711, 9816, 10029, 9970, 9961, 9901, 10126, 9080, 3441, 2852, 2994, 2953, 2946, 2711, 3825, -1221, -27705, -29750, -29201, -29333, -29334, -29304, -29425, -28811, -25979, -25783, -25831, -25809, -25798, -25784, -25792, -25682, -25275, -25240, -25236, -25221, -25209, -25193, -25203, -25079, -24672, -24647, -24638, -24623, -24610, -24570, -24695, -23992, -21607, -21556, -21562, -21539, -21527, -21510, -21501, -21487, -20708, -20427, -20468, -20446, -20434, -20420, -20413, -20391, -19599, -19334, -19374, -19352, -19341, -19322, -19331, -19253, -16893, -16188, -16324, -16285, -16274, -16258, -16270, -16187, -14594, -14164, -14247, -14219, -14209, -14205, -14181, -14218, -15015, -15190, -15140, -15137, -15128, -15113, -15126, -15032, -13818, -13552, -13600, -13580, -13572, -13559, -13569, -13482, -12669, -12504, -12532, -12519, -12510, -12497, -12511, -12414, -11593, -11455, -11480, -11465, -11457, -11440, -11479, -11267, -9623, -9395, -9444, -9424, -9419, -9394, -9470, -9094, -6665, -6349, -6421, -6400, -6394, -6357, -6503, -5831, -2208, -1829, -1920, -1896, -1889, -1869, -1964, -1477};