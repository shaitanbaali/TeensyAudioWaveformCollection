/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0095 256 samples */
 
const int16_t AKWF_oscchip_0095_256_DATA [256] = 
{2285, 3732, 3447, 3500, 3502, 3513, 3547, 3297, 9274, 12024, 11501, 11602, 11600, 11601, 11670, 11269, 15712, 18754, 18249, 18339, 18335, 18338, 18327, 18334, 19939, 20430, 20317, 20333, 20329, 20326, 20330, 20272, 21264, 21738, 21642, 21654, 21649, 21646, 21697, 21375, 24460, 26656, 26268, 26333, 26326, 26326, 26310, 26308, 27925, 28404, 28294, 28308, 28301, 28295, 28296, 28232, 29216, 29688, 29589, 29599, 29591, 29585, 29586, 29533, 29965, 30273, 30210, 30213, 30206, 30197, 30190, 30182, 30174, 30166, 30158, 30151, 30143, 30135, 30127, 30119, 30111, 30103, 30095, 30087, 30079, 30070, 30048, 30125, 29270, 28612, 28703, 28677, 28669, 28653, 28653, 28657, 25512, 24398, 24619, 24570, 24562, 24550, 24497, 24769, 20435, 18096, 18525, 18437, 18431, 18424, 18344, 18747, 14949, 11937, 12412, 12320, 12316, 12297, 12295, 12387, 7119, 5219, 5616, 5534, 5532, 5522, 5465, 5814, 1006, -1634, -1140, -1235, -1236, -1239, -1327, -838, -5040, -8439, -7882, -7990, -7989, -7999, -7993, -7912, -12654, -14335, -13992, -14057, -14056, -14061, -14124, -13677, -19844, -23316, -22696, -22808, -22804, -22814, -22761, -22939, -26192, -26963, -26791, -26817, -26813, -26813, -26806, -26766, -29334, -30320, -30121, -30148, -30141, -30135, -30140, -30066, -30993, -31533, -31432, -31443, -31435, -31432, -31413, -31444, -32524, -32795, -32724, -32729, -32720, -32712, -32703, -32695, -32687, -32679, -32671, -32662, -32654, -32644, -32616, -32721, -31330, -30461, -30609, -30574, -30566, -30553, -30556, -30519, -29408, -29124, -29176, -29156, -29148, -29134, -29118, -29209, -26615, -25556, -25763, -25715, -25708, -25698, -25657, -25855, -23544, -22090, -22340, -22282, -22276, -22257, -22288, -22168, -18907, -18055, -18227, -18187, -18180, -18164, -18138, -18334, -12726, -10363, -10806, -10718, -10713, -10705, -10639, -11026, -6440, -3545, -4030, -3937, -3934, -3927, -3948, -3804};