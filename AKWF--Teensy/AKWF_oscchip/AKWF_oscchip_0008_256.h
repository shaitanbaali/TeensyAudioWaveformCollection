/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0008 256 samples */
 
const int16_t AKWF_oscchip_0008_256_DATA [256] = 
{22332, 24692, 24188, 24287, 24297, 24301, 24302, 24303, 24303, 24303, 24300, 24295, 24291, 24285, 24278, 24271, 24263, 24256, 24246, 24238, 24228, 24217, 24207, 24196, 24185, 24174, 24162, 24151, 24140, 24126, 24114, 24102, 24090, 24076, 24065, 24052, 24039, 24026, 24012, 24000, 23986, 23974, 23961, 23948, 23934, 23921, 23907, 23894, 23880, 23867, 23853, 23840, 23826, 23815, 23801, 23788, 23773, 23760, 23747, 23734, 23720, 23707, 23693, 23680, 23666, 23653, 23639, 23627, 23612, 23600, 23586, 23572, 23559, 23545, 23531, 23518, 23505, 23490, 23478, 23465, 23451, 23439, 23424, 23411, 23397, 23384, 23371, 23357, 23345, 23331, 23317, 23304, 23291, 23278, 23265, 23252, 23238, 23226, 23212, 23198, 23184, 23172, 23158, 23146, 23132, 23119, 23105, 23093, 23079, 23067, 23052, 23039, 23026, 23014, 23000, 22987, 22975, 22840, 23403, 20868, 7132, 5711, 6058, 5965, 5955, 5947, 5937, 5931, 5923, 5915, 5908, 5902, 5896, 5871, 5962, 5486, 3401, 3271, 3305, 3292, 3287, 3277, 3308, 3130, 2446, 2404, 2414, 2407, 2404, 2396, 2431, 2236, 1549, 1528, 1534, 1526, 1525, 1220, 2796, -5317, -31697, -32010, -31793, -31879, -31875, -31869, -31860, -31851, -31841, -31830, -31819, -31808, -31795, -31782, -31769, -31755, -31739, -31724, -31709, -31695, -31679, -31663, -31648, -31631, -31614, -31599, -31582, -31565, -31549, -31531, -31514, -31496, -31480, -31463, -31444, -31427, -31411, -31393, -31376, -31359, -31342, -31323, -31306, -31287, -31270, -31254, -31235, -31218, -31199, -31183, -31165, -31147, -31130, -31111, -31095, -31075, -31058, -31042, -31024, -31007, -30988, -30971, -30952, -30935, -30917, -30900, -30882, -30865, -30846, -30830, -30813, -30794, -30778, -30759, -30742, -30723, -30706, -30689, -30670, -30653, -30634, -30618, -30600, -30583, -30564, -30547, -30531, -30511, -30495, -30477, -30460, -30443, -30423, -30142, -31542, -24327};