/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0025 256 samples */
 
const int16_t AKWF_oscchip_0025_256_DATA [256] = 
{6859, 7469, 7344, 7367, 7370, 7425, 7155, 8411, 15518, 16164, 15981, 16019, 16019, 16024, 15982, 16160, 17029, 17092, 17069, 17061, 17057, 17108, 16822, 18081, 23301, 23583, 23491, 23503, 23495, 23494, 23435, 23655, 24516, 24528, 24508, 24503, 24490, 24486, 24425, 24666, 25506, 25516, 25493, 25483, 25469, 25491, 25309, 26123, 28640, 28662, 28630, 28622, 28609, 28624, 28438, 29310, 31814, 31777, 31756, 31748, 31730, 31719, 31695, 31700, 32536, 32784, 32712, 32707, 32688, 32670, 32651, 32633, 32618, 32601, 32582, 32563, 32545, 32527, 32509, 32490, 32472, 32452, 32437, 32419, 32401, 32382, 32363, 32344, 32326, 32308, 32290, 32271, 32252, 32233, 32215, 32200, 32181, 32162, 32144, 32125, 32106, 32089, 32069, 32050, 32032, 32013, 31995, 31977, 31958, 31937, 31943, 31818, 30909, 30749, 30763, 30738, 30725, 30325, 32056, 24634, -24656, -31290, -29660, -30023, -30024, -30026, -30027, -30026, -30027, -30025, -30024, -30014, -30005, -29995, -30018, -29844, -28948, -28859, -28870, -28856, -28842, -28829, -28815, -28801, -28787, -28774, -28759, -28746, -28732, -28708, -28740, -28513, -27628, -27567, -27565, -27547, -27532, -27514, -27499, -27484, -27471, -27453, -27439, -27423, -27409, -27390, -27376, -27361, -27347, -27329, -27314, -27299, -27285, -27268, -27252, -27237, -27222, -27208, -27190, -27176, -27160, -27143, -27133, -27112, -26251, -25954, -25995, -25970, -25955, -25941, -25927, -25910, -25893, -25880, -25864, -25850, -25836, -25825, -25798, -25819, -26664, -26883, -26818, -26812, -26798, -26780, -26777, -26721, -25832, -25600, -25635, -25612, -25594, -25576, -25578, -25501, -24611, -24403, -24432, -24409, -24395, -24359, -24432, -24088, -20571, -19871, -20014, -19966, -19956, -19904, -20051, -19376, -13135, -12119, -12345, -12282, -12274, -12242, -12315, -11961, -9294, -8901, -8989, -8962, -8949, -8905, -9083, -8279, -2997, -2282, -2455, -2412, -2401, -2355, -2572, -1504};