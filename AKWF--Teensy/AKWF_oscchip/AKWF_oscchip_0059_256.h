/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0059 256 samples */
 
const int16_t AKWF_oscchip_0059_256_DATA [256] = 
{1049, 504, 624, 605, 611, 618, 620, 623, 629, 631, 632, 633, 637, 949, -655, 8410, 31885, 32231, 32006, 32091, 32088, 32066, 32141, 31733, 30116, 29960, 29991, 29972, 29960, 29813, 30569, 24359, 16909, 17659, 17521, 17507, 17499, 17416, 17786, 15318, 11074, 11289, 11258, 11242, 11233, 11179, 11408, 10062, 6588, 6530, 6556, 6538, 6529, 6503, 6626, 5065, 3786, 3959, 3919, 3917, 3913, 3891, 3986, 3207, 2275, 2365, 2346, 2342, 2340, 2327, 2387, 1973, 1266, 1302, 1297, 1290, 1292, 1016, 2448, -5584, -26369, -26677, -26476, -26551, -26545, -26512, -26711, -24221, -22172, -22452, -22390, -22383, -22375, -22278, -22771, -18584, -13673, -14162, -14073, -14063, -14055, -13999, -14243, -12600, -9770, -9910, -9889, -9879, -9871, -9783, -10202, -7814, -1651, -1555, -1608, -1580, -1576, -1558, -1631, -697, 70, -32, -9, -5, -4, -2, -1, 0, 5, 8, 7, 7, 9, 10, 9, 10, 9, 11, 15, 16, 16, 18, 17, 17, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 17, 18, 20, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 19, 17, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 17, -9, -239, 1260, -17658, -33202, -31026, -31433, -31419, -31409, -31090, -32856, -17323};