/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0029 256 samples */
 
const int16_t AKWF_oscchip_0029_256_DATA [256] = 
{28775, 31166, 30654, 30743, 30748, 30742, 30776, 30608, 29821, 29766, 29780, 29773, 29770, 29741, 29860, 29267, 26950, 26818, 26850, 26834, 26828, 26814, 26853, 26629, 25855, 25828, 25830, 25821, 25815, 25737, 26099, 24230, 18105, 18029, 18066, 18042, 18035, 18011, 18102, 17595, 16089, 16068, 16077, 16067, 16061, 16047, 16096, 15812, 15065, 15066, 15064, 15058, 15054, 15033, 15112, 14666, 13556, 13585, 13577, 13569, 13565, 13553, 13573, 13489, 11953, 11545, 11630, 11607, 11605, 11596, 11606, 11558, 10772, 10589, 10625, 10615, 10610, 10549, 10773, 9872, -2737, -5340, -4742, -4864, -4865, -4812, -5035, -4135, 4831, 6560, 6153, 6237, 6236, 6223, 6268, 6077, 4501, 4251, 4305, 4291, 4290, 4271, 4350, 4001, 1209, 830, 923, 902, 900, 892, 930, 749, -432, -581, -541, -549, -550, -558, -526, -669, -1450, -1534, -1513, -1517, -1518, -1532, -1462, -1779, -3356, -3471, -3438, -3445, -3444, -3458, -3388, -3723, -5294, -5398, -5368, -5376, -5375, -5390, -5306, -5698, -7240, -7322, -7296, -7302, -7301, -7308, -7261, -7476, -8243, -8263, -8253, -8255, -8253, -8260, -8212, -8441, -9205, -9212, -9203, -9204, -9202, -9210, -9159, -9406, -10155, -10161, -10151, -10151, -10148, -10146, -10144, -10141, -10139, -10137, -10134, -10131, -10129, -10129, -10118, -10138, -10898, -11120, -11068, -11075, -11073, -11072, -11063, -11081, -11463, -11560, -11533, -11535, -11532, -11533, -11516, -11560, -12344, -12520, -12476, -12481, -12478, -12476, -12466, -12492, -12884, -12961, -12939, -12939, -12936, -12939, -12907, -13020, -14188, -14411, -14357, -14364, -14361, -14373, -14300, -14582, -16935, -17303, -17214, -17229, -17226, -17240, -17150, -17520, -20300, -20658, -20564, -20578, -20572, -20587, -20490, -20906, -23660, -24000, -23906, -23921, -23915, -23916, -23878, -24016, -24792, -24868, -24841, -24840, -24832, -24556, -26000, -18706};