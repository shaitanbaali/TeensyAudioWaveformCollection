/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0038 256 samples */
 
const int16_t AKWF_oscchip_0038_256_DATA [256] = 
{969, 1188, 1137, 1150, 1150, 1158, 1130, 1244, 2818, 3268, 3166, 3188, 3187, 3228, 3016, 4252, 7253, 7267, 7243, 7255, 7253, 7278, 7156, 7748, 10122, 10340, 10274, 10285, 10284, 10310, 10181, 10698, 14689, 15506, 15305, 15345, 15336, 15333, 15322, 15338, 16103, 16372, 16307, 16313, 16305, 16336, 16139, 17157, 20251, 20369, 20315, 20320, 20311, 20326, 20217, 20667, 23061, 23391, 23295, 23304, 23294, 23290, 23261, 23317, 24095, 24298, 24240, 24240, 24228, 24222, 24201, 24190, 26028, 26839, 26670, 26688, 26675, 26689, 26553, 27163, 29532, 29711, 29642, 29642, 29630, 29612, 29611, 29542, 29128, 29037, 29043, 29024, 29010, 28979, 29012, 28853, 25761, 24696, 24898, 24839, 24829, 24727, 25158, 22745, 15776, 15543, 15629, 15585, 15575, 15526, 15686, 14867, 10846, 10328, 10455, 10415, 10408, 10374, 10459, 10080, 6121, 5102, 5322, 5265, 5260, 5240, 5263, 5213, 1491, -93, 209, 142, 143, 94, 302, -781, -4740, -5025, -4935, -4959, -4958, -5045, -4667, -6338, -17585, -19590, -19094, -19195, -19190, -19210, -19137, -19360, -23608, -24993, -24698, -24752, -24741, -24811, -24412, -26540, -32265, -32362, -32291, -32303, -32291, -32285, -32256, -32331, -32717, -32746, -32721, -32710, -32698, -32668, -32713, -32455, -30048, -29466, -29582, -29540, -29527, -29503, -29509, -29450, -27190, -26263, -26425, -26372, -26360, -26319, -26439, -25723, -23358, -23211, -23239, -23214, -23202, -23147, -23312, -22492, -17664, -16881, -17064, -17011, -17000, -16980, -16996, -16887, -15311, -14825, -14918, -14888, -14877, -14866, -14859, -14863, -13768, -13229, -13319, -13290, -13285, -13260, -13327, -12943, -11344, -11177, -11210, -11195, -11189, -11166, -11225, -10934, -8528, -8004, -8120, -8089, -8082, -8067, -8088, -8013, -5344, -4334, -4534, -4488, -4483, -4448, -4607, -3732, -1009, -870, -914, -899, -894, -880, -931, -667};