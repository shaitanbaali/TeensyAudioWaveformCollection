/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0087 256 samples */
 
const int16_t AKWF_oscchip_0087_256_DATA [256] = 
{4917, 4742, 4778, 4774, 4775, 4781, 4744, 5009, 5298, 5260, 5267, 5267, 5266, 5290, 5149, 5975, 7341, 7217, 7237, 7236, 7235, 7251, 7162, 7603, 8744, 8704, 8706, 8706, 8705, 8717, 8638, 9140, 9743, 9667, 9678, 9676, 9674, 9691, 9586, 10150, 11202, 11127, 11139, 11137, 11135, 11162, 10992, 12421, 13735, 13551, 13581, 13576, 13573, 13583, 13511, 13969, 14604, 14538, 14545, 14542, 14539, 14541, 14507, 14672, 15031, 15011, 15009, 15006, 15003, 15039, 14812, 16406, 18140, 17899, 17936, 17931, 17928, 17937, 17861, 18270, 18947, 18883, 18889, 18885, 18880, 18898, 18777, 19359, 20883, 20826, 20824, 20822, 20817, 20827, 20744, 21243, 21843, 21761, 21770, 21764, 21759, 21843, 21351, 24052, 28952, 28569, 28627, 28625, 28623, 28025, 31187, 15463, -30824, -30583, -30494, -30593, -30596, -30502, -31023, -27576, -22816, -23279, -23197, -23191, -23188, -23179, -23206, -23034, -22667, -22679, -22672, -22667, -22662, -22624, -22798, -21904, -18748, -18671, -18697, -18679, -18676, -18658, -18722, -18306, -17619, -17675, -17661, -17654, -17649, -17612, -17781, -16895, -14607, -14679, -14669, -14661, -14656, -14631, -14728, -14264, -12229, -12146, -12171, -12158, -12155, -12137, -12204, -11813, -11108, -11157, -11144, -11141, -11137, -11119, -11195, -10799, -9640, -9642, -9642, -9636, -9634, -9624, -9656, -9495, -8686, -8621, -8634, -8628, -8626, -8476, -9266, -4887, 4580, 4141, 4192, 4212, 4213, 4126, 4595, 2262, -6003, -6189, -6104, -6133, -6132, -6124, -6158, -5952, -5611, -5640, -5633, -5632, -5631, -5613, -5699, -5256, -4114, -4149, -4147, -4145, -4143, -4133, -4173, -3987, -3176, -3142, -3151, -3146, -3146, -3126, -3230, -2649, -1597, -1679, -1664, -1662, -1662, -1660, -1661, -1659, -1658, -1659, -1657, -1656, -1656, -1730, -1360, -3003, -11473, -12130, -11964, -12003, -12001, -11840, -12707, -7510};