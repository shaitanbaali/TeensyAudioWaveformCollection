/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0092 256 samples */
 
const int16_t AKWF_oscchip_0092_256_DATA [256] = 
{17052, 33593, 31063, 31542, 31533, 31523, 31525, 31535, 29115, 28233, 28403, 28367, 28362, 28355, 28340, 28400, 27286, 26674, 26772, 26745, 26739, 26733, 26727, 26720, 26714, 26707, 26700, 26693, 26687, 26677, 26669, 26688, 25483, 25006, 25095, 25070, 25063, 25056, 25035, 25109, 24013, 23362, 23473, 23447, 23440, 23433, 23337, 23825, 19560, 15862, 16424, 16318, 16312, 16305, 16298, 16312, 15699, 15458, 15504, 15492, 15486, 15479, 15445, 15625, 13417, 12123, 12360, 12308, 12305, 12301, 12233, 12584, 9745, 7255, 7633, 7556, 7551, 7543, 7539, 7591, 5188, 4247, 4428, 4393, 4391, 4387, 4357, 4531, 2356, 1057, 1279, 1234, 1233, 1202, 1284, 1018, -6500, -8552, -8122, -8202, -8202, -8195, -8185, -8286, -4774, -3254, -3541, -3488, -3486, -3491, -3582, -3040, -9891, -14301, -13568, -13699, -13697, -13695, -13693, -13690, -13689, -13686, -13684, -13681, -13678, -13676, -13677, -13647, -14230, -14492, -14436, -14442, -14438, -14437, -14476, -14225, -16831, -18600, -18287, -18342, -18337, -18306, -18374, -18177, -9956, -7694, -8192, -8088, -8084, -8088, -8106, -7924, -11465, -13038, -12722, -12781, -12778, -12771, -12716, -13026, -9858, -7748, -8114, -8036, -8035, -8048, -8005, -8093, -13082, -14561, -14254, -14306, -14304, -14304, -14313, -14214, -16522, -17590, -17391, -17423, -17420, -17414, -17378, -17568, -15508, -14071, -14296, -14248, -14245, -14243, -14236, -14236, -14847, -15045, -14997, -15002, -14998, -14993, -14980, -15036, -13901, -13322, -13424, -13400, -13396, -13393, -13382, -13426, -12918, -12536, -12596, -12580, -12577, -12580, -12569, -12560, -14427, -15027, -14890, -14911, -14908, -14896, -14828, -15245, -8968, -5731, -6358, -6234, -6233, -6229, -6197, -6361, -4865, -3709, -3896, -3859, -3859, -3856, -3856, -3856, -3234, -3026, -3066, -3058, -3057, -3054, -3053, -3051, -3051, -3050, -3048, -3047, -3046, -3055, -2999, -3281};