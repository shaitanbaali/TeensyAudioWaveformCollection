/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0157 256 samples */
 
const int16_t AKWF_oscchip_0157_256_DATA [256] = 
{28267, 30963, 30322, 30434, 30437, 30411, 30530, 30001, 26319, 25765, 25901, 25873, 25873, 25815, 26133, 24181, 20626, 20829, 20800, 20796, 20796, 20765, 20927, 20053, 17742, 17752, 17761, 17754, 17754, 17742, 17803, 17504, 16292, 16215, 16239, 16233, 16233, 16227, 16254, 16136, 15318, 15194, 15225, 15219, 15219, 15213, 15245, 15050, 14694, 14714, 14711, 14712, 14712, 14722, 14668, 14960, 15729, 15725, 15723, 15725, 15725, 15741, 15660, 16057, 17671, 17776, 17745, 17754, 17754, 17771, 17693, 18045, 20497, 20868, 20778, 20796, 20796, 20808, 20744, 21135, 21849, 21808, 21814, 21815, 21815, 21846, 21685, 22557, 24868, 24862, 24852, 24858, 24857, 24870, 24809, 25107, 26317, 26396, 26372, 26378, 26378, 26393, 26327, 26621, 28669, 28976, 28901, 28917, 28916, 28940, 28813, 29593, 31014, 30933, 30943, 30945, 30945, 30606, 32384, 22775, -2655, -2575, -2467, -2537, -2540, -2548, -2507, -2705, -3513, -3566, -3548, -3552, -3552, -3576, -3470, -3941, -7216, -7708, -7588, -7613, -7614, -7648, -7458, -8628, -10759, -10636, -10654, -10657, -10656, -10698, -10482, -11647, -14730, -14719, -14706, -14714, -14715, -14755, -14553, -15546, -19581, -19843, -19766, -19786, -19786, -19807, -19715, -20127, -22992, -23423, -23318, -23339, -23339, -23403, -23054, -25199, -29110, -28887, -28917, -28921, -28922, -28927, -28900, -29044, -29430, -29430, -29428, -29429, -29429, -29429, -29429, -29429, -29429, -29429, -29429, -29429, -29429, -29447, -29368, -29720, -32173, -32542, -32453, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32471, -32108, -34065, -23570};