/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0009 256 samples */
 
const int16_t AKWF_oscchip_0009_256_DATA [256] = 
{4395, 4050, 4122, 4120, 4130, 4150, 4091, 4464, 5140, 5099, 5109, 5115, 5115, 5128, 5064, 5448, 6110, 6056, 6068, 6068, 6067, 6098, 5907, 7115, 9034, 8875, 8899, 8896, 8894, 8962, 8586, 10965, 14342, 14033, 14079, 14079, 14072, 14085, 13977, 14642, 15550, 15446, 15456, 15449, 15443, 15453, 15346, 16036, 16912, 16807, 16817, 16808, 16800, 16834, 16588, 18304, 20266, 20030, 20061, 20053, 20044, 20059, 19919, 20529, 23204, 23337, 23284, 23284, 23273, 23273, 23200, 23491, 24611, 24646, 24615, 24608, 24596, 24596, 24515, 24836, 25943, 25957, 25931, 25923, 25911, 25896, 25881, 25868, 25854, 25839, 25826, 25812, 25799, 25770, 25826, 25432, 24317, 24304, 24295, 24278, 24263, 24124, 24777, 21198, 12243, 12356, 12371, 12334, 12324, 12189, 12836, 9357, 1152, 1426, 1389, 1369, 1362, 1456, 910, 3911, 10601, 10282, 10315, 10319, 10314, 10309, 10303, 10298, 10293, 10286, 10281, 10277, 10271, 10229, 10415, 9294, 7301, 7423, 7401, 7390, 7387, 7369, 7430, 7043, 6377, 6424, 6411, 6406, 6402, 6385, 6446, 6036, 5389, 5439, 5426, 5422, 5420, 4931, 7557, -9339, -33305, -31147, -31497, -31519, -31511, -31506, -31498, -31492, -31481, -31471, -31461, -31450, -31436, -31425, -31413, -31399, -31384, -31372, -31357, -31340, -31326, -31311, -31295, -31278, -31262, -31246, -31231, -31212, -31197, -31181, -31164, -31147, -31131, -31113, -31095, -31078, -31062, -30909, -31589, -28053, -14850, -14267, -14452, -14378, -14362, -14503, -13687, -17574, -30645, -30958, -30810, -30841, -30827, -30380, -32608, -21487, 13274, 13326, 13196, 13289, 13299, 13301, 13331, 13204, 12837, 12839, 12837, 12836, 12841, 12377, 14832, 1698, -31156, -30722, -30630, -30721, -30717, -30710, -30705, -30696, -30685, -30677, -30665, -30655, -30644, -30630, -30616, -30603, -30591, -30575, -30562, -30546, -30533, -30172, -32039, -20608};