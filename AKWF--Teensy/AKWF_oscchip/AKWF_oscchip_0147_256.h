/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0147 256 samples */
 
const int16_t AKWF_oscchip_0147_256_DATA [256] = 
{23398, 25890, 25296, 25401, 25404, 25375, 25507, 24918, 20819, 20203, 20355, 20323, 20323, 20284, 20496, 19193, 16820, 16956, 16939, 16937, 16937, 16897, 17107, 15972, 12970, 12979, 12990, 12980, 12980, 12966, 13034, 12703, 11359, 11270, 11296, 11290, 11290, 11283, 11313, 11182, 10271, 10133, 10168, 10160, 10160, 10153, 10189, 9971, 9576, 9600, 9597, 9597, 9597, 9614, 9524, 10009, 11295, 11291, 11285, 11290, 11290, 11290, 11290, 11290, 11290, 11290, 11290, 11290, 11290, 11293, 11278, 11344, 11799, 11868, 11849, 11853, 11853, 11866, 11795, 12230, 13020, 12974, 12979, 12980, 12980, 12997, 12907, 13393, 14681, 14677, 14672, 14676, 14676, 14694, 14604, 15047, 16844, 16960, 16927, 16937, 16937, 16950, 16892, 17152, 18972, 19245, 19177, 19192, 19192, 19237, 18990, 20510, 23276, 23118, 23141, 23143, 23143, 22949, 23968, 18461, 3884, 3930, 3992, 3950, 3948, 4066, 3479, 6356, 18036, 18792, 18567, 18629, 18630, 18675, 18470, 19386, 25760, 26719, 26483, 26535, 26535, 26568, 26391, 27475, 29450, 29338, 29354, 29355, 29355, 29361, 29331, 29494, 29923, 29922, 29920, 29921, 29921, 29917, 29940, 29828, 29379, 29349, 29358, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29355, 29346, 29391, 29170, 28273, 28214, 28233, 28228, 28228, 28228, 28228, 28228, 28228, 28228, 28228, 28228, 28228, 28222, 28257, 28039, 27644, 27667, 27663, 27662, 27662, 27565, 28075, 25322, 18031, 18053, 18085, 18066, 18065, 17910, 18678, 14918, -359, -1348, -1054, -1132, -1133, -1256, -700, -3186, -20482, -23083, -22448, -22584, -22584, -22694, -22093, -25783, -32509, -32125, -32178, -32185, -32186, -32191, -32161, -32322, -32750, -32751, -32749, -32750, -32750, -32414, -34223, -24523};