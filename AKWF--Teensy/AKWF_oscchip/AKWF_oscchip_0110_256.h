/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0110 256 samples */
 
const int16_t AKWF_oscchip_0110_256_DATA [256] = 
{9170, 8826, 8916, 8903, 8905, 8971, 8632, 10391, 15409, 15376, 15364, 15378, 15377, 15256, 15905, 11685, 5961, 6588, 6478, 6475, 6472, 6461, 6512, 6220, 5630, 5664, 5657, 5655, 5654, 5652, 5651, 5650, 5648, 5646, 5645, 5643, 5641, 5639, 5638, 5637, 5635, 5634, 5632, 5631, 5629, 5638, 5582, 5872, 6465, 6422, 6426, 6424, 6423, 6422, 6419, 6418, 6416, 6415, 6413, 6411, 6410, 6408, 6406, 6405, 6404, 6402, 6400, 6399, 6395, 6646, 5269, 12748, 28123, 27243, 27379, 27394, 27390, 27325, 27648, 26032, 20918, 20898, 20908, 20893, 20886, 20798, 21247, 18339, 14080, 14467, 14396, 14391, 14386, 14344, 14536, 13436, 11049, 11148, 11132, 11123, 11119, 10967, 11745, 7763, -5683, -5948, -5824, -5877, -5877, -5998, -5355, -9218, -15257, -14664, -14762, -14763, -14764, -14818, -14518, -16084, -19760, -19579, -19595, -19598, -19594, -19299, -20809, -13623, 13179, 13720, 13448, 13550, 13552, 13464, 13946, 11075, 6728, 7164, 7085, 7083, 7081, 7101, 6997, 7523, 8749, 8688, 8693, 8692, 8691, 8696, 8657, 8834, 9487, 9494, 9487, 9487, 9486, 9504, 9389, 10081, 11168, 11074, 11088, 11087, 11084, 11109, 10963, 11735, 13546, 13485, 13487, 13488, 13485, 13501, 13392, 13901, 15843, 15906, 15881, 15883, 15881, 15958, 15516, 18135, 22627, 22268, 22320, 22321, 22312, 21744, 24751, 8737, -32689, -31754, -31740, -31851, -31849, -31829, -31925, -31451, -29486, -29392, -29418, -29406, -29403, -29366, -29533, -28564, -26836, -26978, -26949, -26942, -26936, -26930, -26924, -26918, -26911, -26904, -26898, -26892, -26885, -26821, -27128, -25037, -22563, -22865, -22800, -22794, -22788, -22772, -22822, -22487, -21916, -21955, -21938, -21931, -21925, -21919, -21914, -21908, -21902, -21895, -21890, -21884, -21878, -21872, -21866, -21860, -21854, -21848, -21842, -21836, -21829, -21498, -23262, -12418};