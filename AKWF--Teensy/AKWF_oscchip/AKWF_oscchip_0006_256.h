/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0006 256 samples */
 
const int16_t AKWF_oscchip_0006_256_DATA [256] = 
{18262, 33411, 30970, 31429, 31421, 31414, 31402, 31420, 31079, 30862, 30889, 30871, 30858, 30845, 30826, 30867, 29818, 29242, 29329, 29294, 29281, 29265, 29176, 29564, 27132, 23067, 23375, 23305, 23288, 23273, 23193, 23539, 21123, 17561, 17872, 17805, 17791, 17779, 17456, 19136, 7935, -6522, -5023, -5282, -5300, -5308, -5312, -5317, -5320, -5321, -5327, -5329, -5330, -5331, -5330, -5330, -5330, -5330, -5330, -5331, -5330, -5326, -5324, -5324, -5323, -5323, -5318, -5316, -5316, -5315, -5310, -5307, -5307, -5305, -5299, -5298, -5297, -5294, -5290, -5290, -5286, -5281, -5280, -5279, -5273, -5271, -5266, -5286, -4957, -4744, -4775, -4766, -4766, -4761, -4761, -4737, -5074, -5266, -5229, -5233, -5227, -5225, -5223, -5233, -4880, -4699, -4729, -4721, -4720, -4716, -4713, -4701, -5056, -5217, -5184, -5188, -5183, -5180, -5179, -5182, -4805, -4657, -4683, -4675, -4674, -4672, -4666, -4667, -5040, -5170, -5139, -5143, -5139, -5135, -5128, -5160, -4893, -4608, -4639, -4629, -4628, -4627, -4628, -4592, -4860, -5133, -5093, -5098, -5096, -5090, -5084, -5113, -4822, -4561, -4597, -4584, -4583, -4582, -4584, -4549, -4855, -5087, -5047, -5053, -5052, -5046, -5039, -5067, -4745, -4516, -4553, -4543, -4538, -4538, -4539, -4511, -4837, -5046, -5004, -5010, -5008, -5005, -4997, -5017, -4671, -4480, -4509, -4500, -4495, -4494, -4495, -4474, -4828, -5000, -4964, -4965, -4964, -4962, -4956, -4954, -4954, -4950, -4945, -4945, -4943, -4938, -4937, -4934, -4929, -4928, -4926, -4921, -4919, -4917, -4912, -4910, -4909, -4904, -4900, -4900, -4897, -4893, -4892, -4889, -4884, -4883, -4882, -4876, -4874, -4871, -4872, -4847, -4450, -4355, -4371, -4367, -4363, -4360, -4353, -4381, -4774, -4854, -4833, -4834, -4829, -4828, -4826, -4821, -4819, -4818, -4812, -4810, -4809, -4823, -4729, -5096};