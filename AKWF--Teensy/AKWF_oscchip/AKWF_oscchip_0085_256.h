/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0085 256 samples */
 
const int16_t AKWF_oscchip_0085_256_DATA [256] = 
{1991, 3742, 3461, 3515, 3513, 3528, 3510, 3505, 8541, 10291, 9943, 10007, 10006, 10009, 10034, 9860, 12936, 14567, 14278, 14329, 14327, 14369, 14207, 14803, 24510, 26612, 26128, 26217, 26213, 26095, 26096, 26823, -17784, -34561, -31103, -31757, -31755, -31732, -31479, -33000, -11434, 950, -1294, -877, -878, -876, -875, -873, -872, -871, -871, -869, -869, -867, -866, -867, -865, -864, -865, -864, -862, -862, -863, -862, -860, -861, -860, -861, -860, -858, -859, -858, -858, -859, -858, -856, -857, -856, -856, -856, -857, -855, -854, -855, -854, -854, -854, -854, -855, -854, -852, -853, -852, -852, -852, -852, -853, -852, -850, -851, -850, -850, -850, -850, -850, -851, -849, -848, -849, -848, -848, -848, -848, -849, -848, -846, -847, -847, -846, -846, -846, -846, -847, -845, -844, -845, -844, -844, -844, -844, -844, -845, -843, -842, -843, -842, -842, -842, -842, -843, -842, -840, -841, -841, -840, -840, -840, -840, -841, -840, -838, -839, -839, -838, -838, -838, -838, -839, -838, -836, -837, -836, -836, -836, -836, -836, -837, -835, -834, -835, -834, -834, -834, -834, -834, -835, -833, -832, -833, -832, -832, -832, -832, -832, -833, -831, -830, -831, -830, -830, -830, -830, -830, -831, -829, -828, -829, -828, -828, -828, -828, -829, -828, -827, -826, -827, -826, -826, -826, -826, -827, -826, -824, -825, -824, -824, -824, -824, -824, -825, -824, -822, -823, -822, -822, -822, -822, -822, -823, -822, -821, -820, -821, -820, -820, -820, -820, -819, -821, -820, -390, -255, -285, -279, -277, -278, -277, -277, -277, -277, -277, -277, -277, -279, -272, -305};