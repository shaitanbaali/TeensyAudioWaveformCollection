/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0130 256 samples */
 
const int16_t AKWF_oscchip_0130_256_DATA [256] = 
{27985, 30408, 29830, 29932, 29935, 29913, 30016, 29554, 26333, 25847, 25967, 25944, 25943, 25883, 26215, 24171, 20443, 20655, 20627, 20621, 20621, 20567, 20850, 19323, 15280, 15293, 15310, 15299, 15299, 15272, 15405, 14753, 12107, 11935, 11987, 11973, 11973, 11924, 12148, 11145, 4171, 3122, 3380, 3325, 3325, 3264, 3597, 1551, -2178, -1968, -1996, -2000, -2001, -2034, -1858, -2812, -5337, -5328, -5318, -5325, -5325, -5229, -5708, -3362, 6164, 6782, 6599, 6646, 6647, 6700, 6458, 7538, 15050, 16178, 15902, 15962, 15962, 16099, 15350, 19952, 28338, 27862, 27927, 27935, 27935, 27983, 27735, 29072, 32611, 32600, 32586, 32594, 32595, 32541, 32807, 31505, 26212, 25868, 25970, 25944, 25943, 25867, 26212, 24670, 13941, 12328, 12723, 12639, 12640, 12526, 13150, 9313, 2322, 2721, 2668, 2659, 2659, 2706, 2458, 3795, 7330, 7317, 7303, 7314, 7314, 7314, 7314, 7314, 7314, 7314, 7314, 7314, 7314, 7302, 7354, 7122, 5514, 5272, 5331, 5318, 5318, 5272, 5522, 3988, 1195, 1354, 1332, 1329, 1329, 1308, 1414, 841, -677, -672, -666, -671, -670, -687, -607, -997, -2584, -2688, -2656, -2666, -2667, -2682, -2613, -2921, -5064, -5387, -5308, -5325, -5325, -5333, -5292, -5546, -6012, -5985, -5988, -5989, -5988, -5995, -5960, -6152, -6657, -6655, -6654, -6655, -6655, -6650, -6677, -6545, -6016, -5982, -5991, -5989, -5988, -5954, -6109, -5416, -587, 139, -38, -1, -1, 37, -171, 1108, 3436, 3302, 3321, 3325, 3325, 3325, 3325, 3325, 3325, 3325, 3325, 3325, 3325, 3309, 3388, 2997, 1410, 1306, 1337, 1329, 1329, 1313, 1382, 1074, -1074, -1397, -1319, -1335, -1333, -1387, -1095, -2885, -6146, -5960, -5986, -5988, -5989, -6198, -5102, -11020, -26683, -26634, -26567, -26612, -26614, -26287, -28046, -18612};