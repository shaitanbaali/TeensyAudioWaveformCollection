/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0042 256 samples */
 
const int16_t AKWF_oscchip_0042_256_DATA [256] = 
{12316, 25864, 23904, 24276, 24262, 24260, 24247, 24299, 23848, 23317, 23364, 23350, 23342, 23335, 23317, 23363, 23011, 22397, 22417, 22404, 22394, 22382, 22366, 22429, 20637, 19549, 19722, 19677, 19667, 19658, 19640, 19680, 19164, 18685, 18739, 18718, 18708, 18699, 18677, 18724, 18309, 17738, 17777, 17759, 17751, 17740, 17716, 17781, 17331, 16365, 16369, 16364, 16354, 16344, 16333, 16344, 16056, 15843, 15866, 15852, 15842, 15834, 15797, 15949, 14555, 13011, 13175, 13136, 13128, 13121, 13101, 13149, 12785, 12177, 12206, 12196, 12187, 12177, 12167, 12202, 10999, 10293, 10404, 10377, 10370, 10362, 10341, 10427, 9388, 8473, 8589, 8561, 8555, 8552, 8515, 8676, 7424, 5762, 5904, 5875, 5871, 5865, 5822, 6024, 4772, 2253, 2322, 2320, 2310, 2304, 2279, 2427, -103, -1895, -1621, -1675, -1674, -1687, -1977, -267, -16301, -33249, -31330, -31665, -31656, -31653, -31587, -31908, -29689, -26147, -26355, -26317, -26304, -26283, -26266, -26390, -22122, -19734, -20148, -20057, -20048, -20035, -20003, -20124, -18548, -17203, -17375, -17332, -17322, -17312, -17264, -17464, -15751, -13583, -13768, -13728, -13717, -13709, -13672, -13818, -12845, -10975, -11030, -11021, -11009, -10996, -10973, -11098, -8794, -7238, -7484, -7431, -7426, -7418, -7380, -7573, -5651, -3685, -3907, -3864, -3861, -3855, -4126, -2619, -13420, -29894, -28799, -28947, -28956, -28951, -28935, -28975, -28689, -28034, -28022, -28017, -28003, -27957, -27614, -29778, -2683, 19199, 16022, 16619, 16615, 16620, 16605, 16714, 15844, 14779, 14877, 14861, 14859, 14859, 14517, 16327, 4521, -17206, -16359, -16421, -16465, -16458, -16445, -16569, -13925, -12261, -12536, -12477, -12476, -12471, -12463, -12484, -12234, -11990, -12014, -12005, -11998, -11994, -11944, -12187, -10403, -7834, -8031, -7996, -7989, -7983, -7952, -8090, -7229, -5300, -5313, -5318, -5307, -5305, -5282, -5396};