/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0156 256 samples */
 
const int16_t AKWF_oscchip_0156_256_DATA [256] = 
{4782, 6444, 6046, 6117, 6121, 6130, 6091, 6267, 7500, 7687, 7642, 7651, 7651, 7668, 7572, 8161, 9233, 9172, 9180, 9181, 9181, 9191, 9137, 9430, 10206, 10203, 10200, 10203, 10203, 10227, 10105, 10704, 13139, 13297, 13249, 13262, 13263, 13266, 13253, 13312, 13721, 13783, 13769, 13773, 13773, 13785, 13721, 14112, 14829, 14787, 14794, 14795, 14795, 14805, 14751, 15044, 15819, 15814, 15813, 15814, 15814, 15830, 15749, 16148, 17772, 17877, 17846, 17855, 17855, 17872, 17793, 18148, 20614, 20986, 20896, 20915, 20915, 20927, 20863, 21255, 21973, 21932, 21938, 21939, 21939, 21970, 21808, 22685, 25009, 25003, 24994, 25000, 24999, 25012, 24950, 25250, 26466, 26546, 26522, 26528, 26528, 26543, 26477, 26773, 28832, 29141, 29065, 29082, 29080, 29104, 28976, 29760, 31190, 31109, 31119, 31121, 31121, 30780, 32569, 22905, -2670, -2590, -2481, -2552, -2555, -2563, -2522, -2721, -3533, -3586, -3569, -3573, -3573, -3597, -3491, -3964, -7257, -7752, -7630, -7657, -7658, -7692, -7501, -8677, -10820, -10696, -10714, -10717, -10716, -10758, -10541, -11713, -14814, -14802, -14790, -14798, -14798, -14840, -14636, -15635, -19692, -19956, -19878, -19898, -19898, -19919, -19826, -20241, -23123, -23556, -23451, -23471, -23471, -23536, -23184, -25342, -29275, -29051, -29081, -29085, -29086, -29091, -29064, -29209, -29597, -29597, -29595, -29596, -29596, -29596, -29596, -29596, -29596, -29596, -29596, -29596, -29596, -29614, -29535, -29889, -32355, -32727, -32637, -32657, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32656, -32432, -33638, -27170};