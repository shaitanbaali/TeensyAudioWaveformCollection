/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0152 256 samples */
 
const int16_t AKWF_oscchip_0152_256_DATA [256] = 
{863, 1010, 974, 980, 981, 995, 931, 1216, 3196, 3493, 3422, 3435, 3435, 3468, 3284, 4419, 6483, 6364, 6380, 6383, 6383, 6423, 6214, 7342, 10327, 10317, 10306, 10312, 10313, 10337, 10219, 10796, 13141, 13293, 13248, 13261, 13261, 13311, 13082, 14107, 21237, 22308, 22049, 22104, 22104, 22160, 21853, 23740, 27179, 26985, 27011, 27014, 27014, 27034, 26930, 27495, 28988, 28983, 28977, 28981, 28981, 28989, 28950, 29143, 29924, 29975, 29959, 29963, 29963, 29947, 30023, 29682, 27305, 26947, 27034, 27014, 27014, 26969, 27215, 25707, 22955, 23111, 23090, 23087, 23087, 23047, 23256, 22128, 19141, 19150, 19163, 19153, 19153, 19129, 19247, 18670, 16327, 16174, 16221, 16209, 16209, 16187, 16288, 15833, 12662, 12185, 12303, 12277, 12277, 12187, 12679, 9658, 4153, 4468, 4427, 4421, 4421, 4057, 5962, -4329, -31564, -31479, -31363, -31440, -31441, -31208, -32367, -26690, -3630, -2134, -2581, -2462, -2460, -2465, -2440, -2553, -3344, -3464, -3434, -3440, -3441, -3485, -3239, -4750, -7504, -7348, -7368, -7372, -7373, -7412, -7204, -8331, -11314, -11304, -11291, -11299, -11300, -11339, -11143, -12105, -16014, -16268, -16191, -16213, -16212, -16229, -16153, -16495, -18871, -19227, -19139, -19159, -19158, -19237, -18807, -21450, -26268, -25993, -26032, -26039, -26038, -26058, -25954, -26518, -28011, -28006, -27999, -28003, -28003, -28011, -27972, -28165, -28946, -28997, -28982, -28987, -28988, -28971, -29047, -28705, -26326, -25969, -26057, -26039, -26039, -25982, -26290, -24402, -20963, -21158, -21131, -21127, -21128, -21089, -21298, -20168, -17182, -17191, -17203, -17197, -17196, -17173, -17291, -16713, -14366, -14216, -14260, -14248, -14248, -14231, -14307, -13966, -11590, -11232, -11319, -11299, -11300, -11283, -11342, -11121, -7622, -6720, -6917, -6880, -6881, -6836, -7070, -5802, -2445, -2455, -2469, -2460, -2460, -2440, -2547, -1972};