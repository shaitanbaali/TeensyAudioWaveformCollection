/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0133 256 samples */
 
const int16_t AKWF_oscchip_0133_256_DATA [256] = 
{13256, 14352, 14094, 14142, 14145, 14145, 14145, 14145, 14145, 14145, 14143, 14143, 14140, 14113, 14250, 13396, 11840, 11926, 11912, 11907, 11905, 11880, 11995, 11357, 9672, 9674, 9679, 9671, 9668, 9650, 9721, 9357, 7886, 7788, 7813, 7804, 7801, 7772, 7917, 6843, 5458, 5594, 5569, 5566, 5564, 5545, 5636, 5067, 4030, 4087, 4077, 4075, 4073, 4052, 4149, 3617, 2211, 2214, 2219, 2214, 2213, 2206, 2233, 2089, 1499, 1460, 1471, 1468, 1467, 1457, 1506, 1149, 687, 732, 725, 724, 722, 710, 779, 353, -423, -379, -386, -387, -388, -391, -372, -477, -757, -756, -757, -758, -757, -763, -734, -878, -1465, -1503, -1492, -1493, -1494, -1507, -1433, -1969, -2659, -2590, -2601, -2600, -2600, -2626, -2486, -3338, -4892, -4803, -4814, -4815, -4814, -4727, -5178, -2737, 3716, 3697, 3670, 3688, 3689, 3683, 3712, 3567, 2980, 2942, 2954, 2951, 2950, 2948, 2949, 2949, 2949, 2947, 2946, 2947, 2947, 2937, 2982, 2697, 2176, 2205, 2200, 2200, 2200, 2195, 2213, 2106, 1826, 1826, 1827, 1825, 1825, 1819, 1848, 1701, 1114, 1075, 1086, 1082, 1081, 1079, 1089, 1046, 747, 703, 712, 709, 710, 705, 729, 586, 327, 341, 340, 339, 340, 331, 369, 158, -403, -401, -399, -401, -400, -406, -377, -522, -1110, -1148, -1135, -1138, -1138, -1145, -1116, -1244, -2138, -2272, -2239, -2245, -2246, -2254, -2208, -2492, -3010, -2980, -2983, -2983, -2984, -3002, -2902, -3432, -4833, -4829, -4821, -4824, -4825, -4826, -4811, -4883, -5175, -5193, -5187, -5186, -5185, -5335, -4646, -7726, -29176, -32399, -31607, -31774, -31770, -31603, -32501, -26956, -16857, -17427, -17345, -17328, -17322, -17258, -17566, -15865, -11372, -11381, -11396, -11378, -11375, -11223, -12012, -7755};