/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0114 256 samples */
 
const int16_t AKWF_oscchip_0114_256_DATA [256] = 
{17447, 31764, 29479, 29917, 29911, 29910, 29909, 29908, 29906, 29902, 29899, 29894, 29890, 29885, 29881, 29877, 29871, 29865, 29860, 29853, 29847, 29841, 29834, 29827, 29821, 29814, 29807, 29800, 29792, 29786, 29778, 29771, 29764, 29756, 29749, 29741, 29734, 29726, 29718, 29710, 29703, 29695, 29687, 29679, 29672, 29664, 29656, 29648, 29641, 29632, 29624, 29617, 29609, 29601, 29593, 29586, 29577, 29569, 29561, 29554, 29546, 29538, 29530, 29523, 29514, 29506, 29499, 29491, 29483, 29475, 29467, 29459, 29451, 29443, 29436, 29427, 29420, 29412, 29404, 29396, 29388, 29380, 29372, 29364, 29357, 29349, 29341, 29333, 29326, 29317, 29309, 29301, 29294, 29286, 29278, 29270, 29262, 29254, 29246, 29239, 29231, 29223, 29215, 29207, 29199, 29192, 29184, 29176, 29168, 29125, 28625, 31598, -8414, -32437, -28327, -29077, -29081, -29075, -29099, -29029, -26706, -26095, -26231, -26201, -26199, -26186, -26167, -26312, -21973, -20131, -20497, -20424, -20419, -20413, -20380, -20542, -18587, -17343, -17558, -17514, -17510, -17496, -17518, -17444, -14317, -13507, -13681, -13641, -13638, -13631, -13616, -13703, -11509, -10596, -10777, -10737, -10734, -10728, -10685, -10920, -8313, -6644, -6935, -6875, -6872, -6862, -6880, -6817, -4897, -4381, -4486, -4461, -4458, -4496, -4548, -3891, -24384, -33092, -31443, -31746, -31743, -31738, -31733, -31728, -31723, -31716, -31711, -31704, -31697, -31692, -31685, -31678, -31670, -31664, -31656, -31649, -31642, -31634, -31626, -31618, -31611, -31603, -31594, -31586, -31579, -31571, -31562, -31555, -31546, -31538, -31529, -31522, -31513, -31504, -31497, -31488, -31480, -31472, -31463, -31456, -31446, -31439, -31431, -31421, -31413, -31406, -31396, -31389, -31380, -31371, -31363, -31354, -31347, -31339, -31329, -31322, -31314, -31304, -31296, -31288, -31279, -31271, -31263, -31254, -31246, -31203, -31027, -32309, -10370, 131, -1884, -1489, -1490, -1496, -1433, -1725};