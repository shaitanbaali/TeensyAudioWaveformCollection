/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0117 256 samples */
 
const int16_t AKWF_oscchip_0117_256_DATA [256] = 
{24918, 31577, 30269, 30504, 30515, 30516, 30517, 30517, 30515, 30514, 30512, 30510, 30506, 30503, 30499, 30494, 30489, 30485, 30479, 30473, 30467, 30461, 30455, 30449, 30442, 30435, 30428, 30422, 30414, 30407, 30400, 30393, 30385, 30378, 30370, 30363, 30354, 30158, 31080, 26945, 1624, -717, -65, -226, -230, -235, -239, -242, -246, -249, -252, -254, -257, -259, -261, -262, -264, -265, -266, -268, -268, -266, -283, -219, 177, 214, 203, 205, 206, 204, 203, 204, 203, 204, 203, 201, 202, 202, 202, 202, 202, 202, 201, 202, 200, 199, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 200, 199, 200, 198, 197, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 198, 197, 198, 197, 195, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 196, 197, 198, 178, 911, 1202, 1146, 1157, 1157, 1151, 1174, 1078, 288, 173, 199, 194, 194, 192, 197, 182, -204, -305, -282, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -286, -287, -371, -169, -662, -25412, -32317, -30765, -31061, -31054, -31051, -31047, -31044, -31039, -31034, -31028, -31023, -31017, -31011, -31005, -30999, -30992, -30986, -30979, -30972, -30965, -30957, -30949, -30943, -30935, -30927, -30920, -30912, -30905, -30897, -30889, -30881, -30873, -30865, -30857, -30849, -30842, -30704, -31382, -28130};