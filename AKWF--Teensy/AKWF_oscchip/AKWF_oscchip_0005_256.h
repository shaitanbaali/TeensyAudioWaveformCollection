/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0005 256 samples */
 
const int16_t AKWF_oscchip_0005_256_DATA [256] = 
{24566, 26502, 26080, 26157, 26160, 26201, 25989, 26999, 31480, 31741, 31652, 31664, 31656, 31644, 31632, 31621, 31611, 31596, 31582, 31570, 31554, 31551, 31478, 31741, 32703, 32715, 32690, 32678, 32662, 32611, 32770, 31863, 28918, 28868, 28875, 28847, 28830, 28801, 28849, 28503, 27533, 27514, 27503, 27482, 27467, 27398, 27659, 26233, 22452, 22468, 22461, 22438, 22422, 22328, 22731, 20464, 14840, 14986, 14963, 14939, 14928, 14888, 15023, 14200, 12363, 12417, 12404, 12390, 12383, 12313, 12624, 10847, 7268, 7439, 7411, 7397, 7389, 7352, 7506, 6582, 4811, 4914, 4893, 4886, 4881, 4808, 5162, 2966, -903, -635, -681, -686, -687, -912, 294, -7013, -18700, -17776, -17914, -17927, -17923, -17932, -17844, -18387, -19198, -19115, -19121, -19115, -19109, -19101, -19094, -19085, -19075, -19068, -19060, -19051, -19042, -18955, -19321, -17661, -8669, -7738, -7962, -7901, -7894, -7926, -7719, -8628, -13135, -13461, -13365, -13380, -13372, -13380, -13303, -13634, -15126, -15207, -15173, -15172, -15164, -15178, -15064, -15554, -17507, -17607, -17567, -17569, -17558, -17495, -17772, -16381, -11474, -11329, -11369, -11341, -11333, -11203, -11832, -8538, 2157, 2288, 2207, 2248, 2255, 2206, 2471, 1152, -2658, -2664, -2634, -2645, -2643, -2736, -2239, -4761, -11354, -11235, -11228, -11240, -11239, -11247, -11172, -11545, -12475, -12442, -12442, -12436, -12432, -12520, -12008, -14875, -21222, -20989, -20993, -21003, -20994, -21009, -20878, -21530, -22860, -22783, -22782, -22773, -22763, -22751, -22738, -22728, -22717, -22705, -22692, -22681, -22667, -22352, -23998, -13764, 4280, 3028, 3230, 3251, 3259, 3312, 3062, 4650, 7132, 6941, 6973, 6976, 6977, 6900, 7258, 5695, -5959, -7473, -7094, -7174, -7175, -7202, -7070, -7637, -11151, -11553, -11443, -11464, -11460, -11505, -11254, -12348, -18333, -18942, -18777, -18810, -18802, -18576, -19734, -13809};