/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0054 256 samples */
 
const int16_t AKWF_oscchip_0054_256_DATA [256] = 
{719, 840, 811, 818, 818, 819, 813, 837, 1146, 1230, 1212, 1216, 1215, 1228, 1164, 1534, 2411, 2413, 2406, 2408, 2408, 2413, 2380, 2542, 3161, 3214, 3197, 3201, 3199, 3294, 2892, 4574, 17632, 20221, 19593, 19727, 19725, 19722, 19719, 19716, 19713, 19709, 19705, 19701, 19697, 19694, 19690, 19686, 19682, 19677, 19672, 19669, 19663, 19659, 19654, 19649, 19645, 19640, 19635, 19630, 19624, 19379, 20264, 16897, -22718, -33042, -30707, -31202, -31194, -31193, -31191, -31189, -31188, -31184, -31180, -31176, -31177, -30765, -32759, -22666, 14399, 17286, 16431, 16656, 16659, 16652, 16685, 16547, 15609, 15433, 15475, 15465, 15463, 15457, 15473, 15414, 14198, 13793, 13876, 13857, 13855, 13836, 13912, 13480, 12270, 12236, 12246, 12238, 12235, 12208, 12315, 11787, 9283, 8968, 9048, 9025, 9023, 9003, 9064, 8812, 6331, 5714, 5851, 5819, 5819, 5815, 5817, 5808, 5215, 4969, 5015, 5004, 5002, 5022, 4918, 5441, 7295, 7414, 7372, 7382, 7380, 7358, 7444, 7050, 4541, 4097, 4205, 4177, 4174, 4161, 4201, 4053, 1625, 855, 1016, 981, 982, 922, 1213, -394, -4568, -4623, -4582, -4600, -4601, -4656, -4397, -5644, -11288, -11902, -11729, -11770, -11769, -11808, -11644, -12319, -18525, -19986, -19655, -19720, -19718, -19751, -19662, -19868, -28408, -31784, -31115, -31245, -31235, -31230, -31224, -31218, -31211, -31205, -31198, -31191, -31187, -31022, -31718, -28511, -9278, -6249, -7014, -6837, -6833, -6822, -6840, -6752, -5516, -5153, -5227, -5208, -5206, -5173, -5318, -4480, -2413, -2397, -2409, -2399, -2396, -2384, -2429, -2199, -1266, -1176, -1200, -1190, -1189, -1187, -1194, -1157, -844, -775, -790, -785, -785, -783, -784, -783, -782, -782, -783, -781, -780, -777, -795, -695, -393, -378, -382, -381, -380, -374, -405, -245};