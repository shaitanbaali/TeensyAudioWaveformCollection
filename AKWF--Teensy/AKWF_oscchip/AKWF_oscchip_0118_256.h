/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0118 256 samples */
 
const int16_t AKWF_oscchip_0118_256_DATA [256] = 
{21941, 29329, 27892, 28153, 28160, 28144, 28237, 27779, 25969, 25900, 25922, 25912, 25909, 25942, 25766, 26536, 32080, 32763, 32583, 32616, 32609, 32590, 32628, 32459, 29271, 28510, 28671, 28631, 28624, 28603, 28669, 28322, 26943, 26898, 26907, 26895, 26887, 26734, 27410, 24569, 1549, -1201, -479, -645, -649, -652, -656, -659, -662, -666, -668, -670, -673, -674, -676, -677, -679, -679, -681, -682, -682, -680, -695, -634, -171, -115, -129, -127, -129, -128, -128, -128, -128, -128, -129, -128, -129, -131, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -130, -131, -129, -128, -129, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -128, -121, -157, 12, 928, 1011, 990, 995, 995, 990, 1009, 930, 16, -159, -121, -128, -129, -134, -106, -240, -689, -690, -686, -688, -687, -687, -687, -687, -687, -687, -687, -687, -687, -687, -687, -687, -687, -688, -686, -685, -684, -950, 430, -6044, -28094, -28233, -28111, -28169, -28168, -28168, -28146, -28221, -28682, -28716, -28700, -28698, -28693, -28673, -28723, -28513, -25728, -25205, -25318, -25287, -25281, -25294, -25184, -25686, -27462, -27501, -27481, -27480, -27472, -27458, -27486, -27329, -26403, -26298, -26312, -26301, -26294, -26205, -26636, -24404};