/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0039 256 samples */
 
const int16_t AKWF_oscchip_0039_256_DATA [256] = 
{826, 1560, 1453, 1476, 1476, 1476, 1493, 1395, 2206, 3162, 3065, 3081, 3080, 3079, 3089, 3040, 3350, 3901, 3873, 3877, 3876, 3871, 3938, 3600, 5455, 10586, 10726, 10660, 10679, 10679, 10704, 10521, 12358, 14053, 13825, 13862, 13857, 13853, 13876, 13719, 14823, 16348, 16215, 16226, 16222, 16216, 16261, 15985, 17587, 21060, 20996, 20978, 20981, 20977, 20985, 20842, 22859, 24330, 24094, 24128, 24116, 24108, 24131, 23923, 25595, 27445, 27226, 27252, 27240, 27229, 27254, 27042, 28334, 30495, 30357, 30358, 30347, 30335, 30345, 30208, 30874, 32668, 32685, 32651, 32644, 32589, 32248, 34223, 6420, -18231, -14974, -15596, -15586, -15593, -15594, -15622, -15437, -15188, -15214, -15210, -15210, -15208, -15185, -15302, -14589, -13155, -13193, -13191, -13183, -13178, -13173, -13183, -12924, -12738, -12760, -12750, -12745, -12740, -12731, -12749, -12528, -12295, -12317, -12306, -12301, -12296, -12284, -12303, -12129, -11856, -11867, -11859, -11853, -11846, -11836, -11852, -11725, -11423, -11415, -11412, -11406, -11399, -11388, -11420, -10938, -10530, -10579, -10561, -10558, -10552, -10538, -10580, -10187, -9691, -9728, -9715, -9711, -9705, -9696, -9714, -9564, -9275, -9281, -9274, -9268, -9264, -9254, -9269, -9163, -8853, -8834, -8833, -8828, -8823, -8815, -8832, -8610, -8380, -8399, -8392, -8386, -8382, -8369, -8413, -8063, -7533, -7562, -7553, -7548, -7545, -7553, -7484, -7860, -8737, -8732, -8723, -8723, -8717, -8709, -8741, -8247, -7849, -7900, -7885, -7883, -7878, -7844, -8007, -6618, -4921, -5079, -5049, -5047, -5042, -5046, -4997, -5296, -5848, -5821, -5820, -5821, -5816, -5805, -5842, -5628, -5017, -4994, -4999, -4993, -4990, -4978, -5022, -4567, -4129, -4184, -4171, -4167, -4166, -4119, -4365, -2566, 25, -175, -142, -141, -136, -134, -135, -133, -132, -133, -132, -127, -127, -126, -132};