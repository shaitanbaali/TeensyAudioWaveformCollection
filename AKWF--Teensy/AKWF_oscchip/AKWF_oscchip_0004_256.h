/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0004 256 samples */
 
const int16_t AKWF_oscchip_0004_256_DATA [256] = 
{20073, 21183, 20940, 20985, 20989, 20989, 20989, 20989, 20984, 20980, 20977, 20973, 20964, 21065, 20500, 23215, 32247, 32447, 32345, 32368, 32355, 32334, 32367, 32122, 31384, 31372, 31360, 31343, 31326, 31286, 31411, 30649, 28503, 28496, 28489, 28467, 28452, 28348, 28800, 26280, 20050, 20127, 20126, 20094, 20080, 19889, 20822, 15809, 4082, 4489, 4432, 4407, 4395, 4356, 4513, 3580, 1531, 1624, 1605, 1598, 1593, 1557, 1724, 717, -1256, -1161, -1173, -1181, -1183, -1219, -1032, -2122, -4044, -3918, -3936, -3938, -3938, -3973, -3787, -4897, -6813, -6657, -6682, -6679, -6678, -6694, -6599, -7185, -8111, -8029, -8040, -8038, -8035, -8037, -8000, -8206, -8498, -8468, -8468, -8465, -8461, -8457, -8453, -8449, -8443, -8439, -8435, -8431, -8424, -8401, -8492, -8040, -5815, -5608, -5660, -5644, -5639, -5607, -5746, -5090, -2115, -1914, -1966, -1948, -1946, -1811, -2465, 658, 14021, 14718, 14506, 14563, 14565, 14601, 14402, 15382, 19024, 19171, 19110, 19122, 19116, 19144, 18956, 19843, 22708, 22765, 22728, 22728, 22719, 22719, 22661, 22884, 23597, 23585, 23571, 23561, 23550, 23151, 25176, 14400, -16194, -15955, -15847, -15939, -15944, -15945, -15950, -15952, -15949, -15947, -15947, -15944, -15940, -15942, -15909, -16056, -16392, -16375, -16371, -16366, -16359, -16346, -16368, -16204, -15855, -15864, -15854, -15846, -15838, -15831, -15823, -15813, -15806, -15796, -15788, -15781, -15770, -15770, -15729, -15903, -16214, -16184, -16177, -16169, -16161, -16159, -16118, -16298, -16603, -16568, -16563, -16556, -16545, -16536, -16526, -16518, -16509, -16501, -16491, -16481, -16470, -16461, -16452, -16442, -16434, -16424, -16416, -16406, -16396, -16386, -16377, -16369, -16359, -16350, -16339, -16330, -16320, -16310, -16303, -16294, -16285, -16274, -16265, -16255, -16244, -16239, -16212, -16285, -16648, -16665, -16648, -16639, -16627, -16413, -17511, -11723};