/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0109 256 samples */
 
const int16_t AKWF_oscchip_0109_256_DATA [256] = 
{3857, 6295, 5817, 5906, 5908, 5908, 5903, 5939, 5059, 4653, 4730, 4715, 4714, 4715, 4739, 4597, 6166, 7239, 7060, 7093, 7091, 7090, 7089, 7088, 7087, 7085, 7084, 7082, 7081, 7080, 7082, 7056, 7493, 7702, 7658, 7664, 7662, 7660, 7665, 7624, 8013, 8289, 8237, 8244, 8243, 8251, 8228, 8238, 12062, 13200, 12952, 12998, 12995, 12993, 12994, 12966, 13402, 13609, 13566, 13570, 13567, 13565, 13588, 13425, 14974, 16083, 15896, 15929, 15925, 15923, 15916, 15915, 16378, 16526, 16490, 16493, 16488, 16485, 16485, 16457, 16885, 17096, 17051, 17053, 17050, 17053, 17023, 17119, 18570, 18877, 18802, 18811, 18806, 18804, 18797, 18789, 19709, 20028, 19956, 19965, 19959, 19954, 19953, 19922, 20342, 20565, 20519, 20523, 20517, 20520, 20486, 20581, 22539, 22952, 22846, 22858, 22853, 22851, 22844, 22813, 24203, 24699, 24586, 24601, 24595, 24590, 24588, 24551, 24969, 25195, 25144, 25146, 25139, 24921, 25706, 22944, -22538, -31997, -29882, -30306, -30310, -30308, -30309, -30317, -29850, -29684, -29714, -29705, -29701, -29701, -29719, -29562, -31653, -32826, -32613, -32644, -32639, -32633, -32625, -32618, -32611, -32604, -32597, -32590, -32582, -32573, -32566, -32564, -32103, -31920, -31946, -31933, -31924, -31916, -31908, -31899, -31892, -31883, -31874, -31866, -31858, -31764, -32001, -31211, -9053, -3378, -4646, -4393, -4389, -4385, -4380, -4362, -4809, -4991, -4949, -4952, -4949, -4946, -4955, -4885, -5695, -6202, -6106, -6119, -6116, -6115, -6108, -6119, -6604, -6724, -6697, -6700, -6698, -6698, -6698, -6661, -7573, -7943, -7865, -7877, -7875, -7873, -7871, -7869, -7867, -7864, -7862, -7860, -7858, -7856, -7854, -7852, -7850, -7848, -7846, -7843, -7842, -7839, -7835, -7849, -7396, -7202, -7237, -7229, -7226, -7222, -7232, -7179, -6690, -6605, -6624, -6618, -6616, -6607, -6645, -6405};