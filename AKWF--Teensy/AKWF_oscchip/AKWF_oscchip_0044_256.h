/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0044 256 samples */
 
const int16_t AKWF_oscchip_0044_256_DATA [256] = 
{5465, 5532, 5491, 5501, 5509, 5513, 5518, 5520, 5522, 5526, 5528, 5528, 5528, 5528, 5528, 5528, 5528, 5528, 5528, 5528, 5526, 5518, 5546, 5434, 4226, 3908, 3977, 3960, 3960, 3958, 3958, 3956, 3950, 3950, 3949, 3948, 3947, 3946, 3927, 4016, 4313, 4329, 4319, 4320, 4318, 4320, 4305, 4358, 4665, 4710, 4694, 4695, 4694, 4688, 4710, 4532, 4278, 4295, 4291, 4286, 4284, 4300, 4212, 4726, 5852, 5832, 5826, 5825, 5824, 5808, 5877, 5508, 4304, 4237, 4258, 4249, 4248, 4245, 4240, 4239, 4238, 4235, 4231, 4230, 4229, 4220, 4242, 4067, 3814, 3831, 3826, 3824, 3823, 3818, 3818, 3816, 3815, 3811, 3808, 3808, 3807, 3804, 3800, 3800, 3798, 3797, 3792, 3791, 3790, 3790, 3785, 3783, 3782, 3782, 3778, 3775, 3774, 3773, 3772, 3768, 3765, 3764, 3764, 3760, 3757, 3756, 3755, 3753, 3748, 3748, 3747, 3746, 3743, 3739, 3738, 3738, 3736, 3732, 3731, 3730, 3731, 3791, 3414, 7043, 10690, 10253, 10330, 10324, 10320, 10313, 10335, 10155, 9902, 9918, 9912, 9906, 9903, 9871, 10003, 9202, 7513, 7548, 7546, 7537, 7534, 7522, 7553, 7367, 6766, 6727, 6736, 6728, 6724, 6704, 6788, 5933, 5069, 5170, 5147, 5146, 5140, 5120, 5214, 4517, 3506, 3580, 3566, 3563, 3559, 3530, 3663, 2865, 1184, 1217, 1218, 1212, 1208, 1191, 1306, -682, -2082, -1867, -1909, -1910, -1912, -1945, -1748, -3667, -5597, -5366, -5408, -5406, -5404, -5713, -4042, -15824, -32943, -31623, -31814, -31819, -31817, -31757, -32019, -30419, -27047, -27112, -27107, -27087, -27072, -27033, -27231, -23743, -21281, -21649, -21565, -21556, -21543, -21509, -21631, -20341, -19044, -19186, -19145, -19135, -19126, -19080, -19261, -17856, -15845, -15987, -15952, -15944, -15938, -15722, -16783, -10059};