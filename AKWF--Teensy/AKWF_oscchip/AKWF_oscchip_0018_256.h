/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0018 256 samples */
 
const int16_t AKWF_oscchip_0018_256_DATA [256] = 
{596, 552, 560, 559, 564, 577, 511, 921, 1541, 1486, 1494, 1495, 1495, 1565, 1177, 3744, 7383, 7009, 7072, 7072, 7071, 7082, 7015, 7464, 8041, 7979, 7986, 7981, 7979, 8010, 7842, 8572, 12384, 12670, 12591, 12603, 12599, 12614, 12509, 12991, 15250, 15394, 15343, 15348, 15341, 15365, 15200, 15952, 18908, 19063, 19007, 19011, 19000, 19026, 18844, 19671, 22621, 22691, 22652, 22653, 22642, 22656, 22517, 23154, 25367, 25390, 25360, 25353, 25341, 25341, 25259, 25609, 26680, 26677, 26656, 26644, 26631, 26618, 26591, 26646, 26807, 26791, 26778, 26765, 26749, 26707, 26838, 26044, 24083, 24127, 24109, 24091, 24076, 24003, 24310, 22508, 18321, 18441, 18420, 18398, 18387, 18264, 18843, 15564, 8790, 9064, 9026, 9004, 8993, 8941, 9174, 7777, 5101, 5263, 5231, 5221, 5215, 5119, 5601, 2662, -2561, -2186, -2248, -2256, -2257, -2347, -1892, -4660, -9068, -8718, -8773, -8778, -8775, -8874, -8341, -11621, -16573, -16126, -16198, -16197, -16194, -16280, -15767, -19191, -24018, -23519, -23596, -23590, -23581, -23630, -23337, -24586, -31348, -32033, -31845, -31874, -31862, -31856, -31807, -31946, -32691, -32730, -32699, -32688, -32672, -32624, -32761, -32011, -28593, -28351, -28403, -28369, -28353, -28299, -28481, -27515, -23792, -23578, -23626, -23593, -23576, -23502, -23793, -22311, -17117, -16962, -16999, -16967, -16954, -16873, -17217, -15407, -9507, -9432, -9467, -9438, -9427, -9391, -9524, -8787, -6610, -6583, -6594, -6579, -6571, -6545, -6643, -6103, -4675, -4685, -4682, -4674, -4669, -4659, -4680, -4534, -4179, -4185, -4182, -4176, -4173, -4165, -4188, -4031, -3685, -3694, -3691, -3688, -3683, -3676, -3704, -3538, -3196, -3209, -3206, -3201, -3199, -3192, -3221, -3043, -2709, -2727, -2723, -2717, -2715, -2715, -2714, -2713, -2708, -2706, -2706, -2705, -2703, -2660, -2865, -1567};