/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0010 256 samples */
 
const int16_t AKWF_oscchip_0010_256_DATA [256] = 
{24609, 30790, 29494, 29735, 29738, 29741, 29741, 29741, 29741, 29740, 29738, 29735, 29732, 29729, 29724, 29720, 29715, 29710, 29706, 29701, 29695, 29689, 29683, 29677, 29670, 29664, 29657, 29650, 29643, 29636, 29629, 29622, 29615, 29608, 29600, 29593, 29586, 29578, 29571, 29563, 29555, 29548, 29540, 29533, 29525, 29517, 29509, 29501, 29494, 29486, 29479, 29471, 29463, 29455, 29447, 29439, 29432, 29424, 29416, 29408, 29400, 29393, 29384, 29376, 29368, 29361, 29353, 29345, 29337, 29329, 29322, 29314, 29306, 29298, 29290, 29283, 29275, 29267, 29259, 29251, 29243, 29236, 29228, 29219, 29212, 29204, 29196, 29188, 29180, 29173, 29165, 29157, 29149, 29141, 29133, 29126, 29118, 29110, 29102, 29094, 29087, 29079, 29071, 29063, 29055, 29048, 29040, 29033, 29025, 29017, 29009, 29001, 28993, 28986, 28978, 28970, 28963, 28656, 29872, 24879, -24219, -33638, -31438, -31892, -31890, -31891, -31892, -31891, -31890, -31888, -31886, -31882, -31879, -31875, -31870, -31865, -31861, -31856, -31849, -31844, -31837, -31831, -31824, -31818, -31810, -31803, -31797, -31789, -31781, -31774, -31766, -31758, -31750, -31743, -31735, -31727, -31719, -31711, -31703, -31694, -31687, -31678, -31670, -31662, -31653, -31646, -31637, -31629, -31620, -31612, -31604, -31596, -31587, -31579, -31571, -31562, -31554, -31545, -31536, -31529, -31520, -31512, -31503, -31495, -31486, -31478, -31469, -31462, -31452, -31338, -31414, -31675, 4152, 18140, 15248, 15820, 15816, 15704, 15908, 15763, -20746, -33513, -30884, -31382, -31372, -31255, -31493, -31033, 6703, 18295, 15886, 16343, 16346, 16204, 16571, 15474, -22177, -33268, -30877, -31339, -31332, -31328, -31324, -31321, -31316, -31311, -31305, -31300, -31293, -31288, -31282, -31275, -31268, -31262, -31255, -31248, -31241, -31233, -31225, -31219, -31211, -31203, -31195, -31188, -31180, -31172, -31164, -31156, -31148, -31140, -31132, -31124, -31115, -30917, -31924, -27154};