/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0034 256 samples */
 
const int16_t AKWF_oscchip_0034_256_DATA [256] = 
{2347, 2787, 2675, 2701, 2704, 2736, 2602, 3192, 7451, 8250, 8056, 8097, 8096, 8119, 8044, 8290, 13712, 15583, 15197, 15273, 15268, 15333, 14968, 16905, 22329, 22473, 22399, 22418, 22408, 22430, 22299, 22863, 25689, 26032, 25930, 25941, 25931, 25939, 25863, 26115, 28917, 29600, 29429, 29451, 29438, 29427, 29410, 29408, 30271, 30632, 30544, 30546, 30531, 30529, 30463, 30713, 31622, 31673, 31638, 31628, 31613, 31606, 31560, 31683, 32615, 32767, 32709, 32703, 32689, 32651, 32701, 32465, 28320, 26999, 27264, 27191, 27182, 26604, 29488, 13493, -29138, -30054, -29606, -29779, -29786, -29781, -29825, -29616, -28678, -28569, -28596, -28583, -28577, -28496, -28791, -27582, -15822, -13069, -13700, -13557, -13552, -13567, -13507, -13609, -19836, -22292, -21787, -21880, -21871, -21781, -22173, -20083, -13173, -12750, -12875, -12829, -12820, -12838, -12722, -13190, -16013, -16464, -16343, -16358, -16353, -16327, -16376, -16168, -12930, -11951, -12152, -12099, -12098, -12022, -12358, -10434, -5510, -5447, -5489, -5465, -5457, -5452, -5447, -5441, -5438, -5431, -5428, -5426, -5420, -5411, -5424, -5365, -4891, -4782, -4805, -4794, -4791, -4784, -4796, -4747, -3408, -2898, -2998, -2974, -2974, -2955, -3037, -2600, -1220, -1151, -1172, -1166, -1166, -963, -1855, 2251, 25326, 28874, 27983, 28178, 28174, 28111, 28297, 27585, 18358, 15709, 16276, 16147, 16143, 16086, 16145, 16152, 2397, -4011, -2822, -3065, -3061, -3191, -2609, -5497, -17227, -18284, -17972, -18046, -18047, -18084, -17926, -18581, -23767, -24813, -24561, -24605, -24601, -24585, -24602, -24523, -22715, -22058, -22180, -22144, -22136, -22092, -22257, -21318, -18580, -18475, -18501, -18479, -18471, -18436, -18541, -17997, -15146, -14749, -14844, -14812, -14802, -14767, -14858, -14457, -9791, -8560, -8827, -8759, -8751, -8736, -8744, -8725, -6115, -4946, -5165, -5113, -5108, -5054, -5317, -3845};