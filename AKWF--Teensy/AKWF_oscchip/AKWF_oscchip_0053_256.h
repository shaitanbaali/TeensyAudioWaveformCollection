/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0053 256 samples */
 
const int16_t AKWF_oscchip_0053_256_DATA [256] = 
{14315, 26519, 24781, 25114, 25099, 25095, 25082, 25132, 24611, 24052, 24108, 24087, 24080, 24072, 23986, 24397, 21525, 16995, 17284, 17238, 17222, 17214, 17164, 17369, 16127, 13273, 13288, 13294, 13277, 13264, 13239, 13356, 11536, 10163, 10356, 10307, 10303, 10296, 10266, 10402, 9113, 7723, 7868, 7836, 7832, 7825, 7793, 7935, 6893, 5289, 5389, 5370, 5364, 5357, 5355, 5360, 5015, 4833, 4863, 4852, 4850, 4846, 4838, 4857, 4552, 4321, 4353, 4343, 4338, 4336, 4315, 4427, 3395, 2287, 2407, 2382, 2380, 2379, 2367, 2422, 2006, 1365, 1405, 1402, 1397, 1391, 1391, 1403, 725, 370, 432, 415, 416, 415, 410, 432, 128, -100, -65, -70, -71, -71, -76, -47, -305, -581, -553, -560, -559, -560, -477, -925, 2187, 6982, 6663, 6703, 6708, 6676, 6686, 6886, -4308, -10141, -9094, -9306, -9296, -9296, -9305, -9241, -10146, -10828, -10723, -10741, -10736, -10732, -10735, -10705, -10957, -11229, -11191, -11192, -11192, -11155, -11250, -10917, -3536, -1057, -1575, -1467, -1465, -1463, -1458, -1456, -1454, -1453, -1448, -1445, -1445, -1444, -1444, -1440, -1436, -1435, -1435, -1434, -1434, -1435, -1489, -1170, -3993, -7035, -6691, -6752, -6752, -6730, -6780, -6614, -2925, -1688, -1944, -1890, -1888, -1950, -1921, -1523, -22565, -33515, -31548, -31937, -31915, -31910, -31902, -31893, -31884, -31872, -31864, -31853, -31842, -31707, -32220, -29929, -12754, -9321, -10135, -9943, -9935, -9891, -9990, -9636, -1877, 727, 187, 303, 306, 310, 318, 326, -8, -180, -140, -145, -144, -143, -143, -118, -421, -647, -610, -616, -612, -615, -591, -693, -1459, -1608, -1571, -1580, -1575, -1576, -1571, -1586, -1957, -2078, -2050, -2056, -2054, -2054, -2050, -2047, -2048, -2048, -2046, -2045, -2045, -2047, -2036, -2088};