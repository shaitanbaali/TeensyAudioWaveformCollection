/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0062 256 samples */
 
const int16_t AKWF_oscchip_0062_256_DATA [256] = 
{3099, 2774, 2863, 2853, 2884, 2809, 3083, 8624, 10468, 10093, 10172, 10170, 10181, 10186, 10103, 13737, 15652, 15311, 15375, 15371, 15369, 15388, 15255, 16826, 18111, 17920, 17949, 17943, 17936, 17954, 17817, 18841, 20093, 19962, 19975, 19968, 19965, 19947, 19958, 21095, 21563, 21461, 21470, 21462, 21453, 21449, 21403, 22081, 22512, 22431, 22434, 22423, 22415, 22403, 22393, 22383, 22372, 22361, 22352, 22340, 22328, 22316, 22307, 22296, 22284, 22273, 22263, 22253, 22240, 22230, 22217, 22207, 22198, 22186, 22174, 22163, 22151, 22139, 22150, 21817, 21557, 21580, 21564, 21555, 21544, 21510, 21624, 20547, 19312, 19429, 19399, 19387, 19367, 19377, 19314, 16985, 16057, 16234, 16188, 16177, 16156, 16123, 16353, 10770, 7331, 7903, 7780, 7778, 7767, 7710, 8010, 4735, 1699, 2080, 2004, 2001, 1994, 1886, 2457, -1843, -7792, -7310, -7385, -7393, -7405, -7396, -7362, -10699, -12324, -12017, -12076, -12073, -12076, -12109, -11862, -15453, -18122, -17707, -17782, -17773, -17767, -17810, -17528, -19962, -22671, -22375, -22417, -22410, -22415, -22370, -22460, -25586, -26715, -26471, -26510, -26498, -26492, -26490, -26395, -28501, -29746, -29515, -29547, -29534, -29521, -29517, -29451, -30043, -30570, -30481, -30481, -30467, -30451, -30027, -32305, -14526, 9270, 7281, 7614, 7635, 7642, 7650, 7655, 7661, 7663, 7669, 7673, 7673, 7674, 7671, 7697, 7365, 7128, 7165, 7160, 7158, 7154, 7146, 7176, 6897, 6599, 6632, 6627, 6623, 6619, 6612, 6642, 6422, 6075, 6092, 6085, 6082, 6011, 5970, 6744, -19183, -33429, -30929, -31422, -31405, -31401, -31395, -31412, -31097, -30827, -30853, -30838, -30830, -30818, -30792, -30877, -30109, -29136, -29216, -29189, -29176, -29151, -29164, -29109, -25681, -24201, -24466, -24396, -24386, -24362, -24311, -24601, -19149, -15525, -16088, -15968, -15959, -15939, -15764, -16735, -6714};