/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0036 256 samples */
 
const int16_t AKWF_oscchip_0036_256_DATA [256] = 
{14742, 17250, 16639, 16767, 16768, 16772, 16774, 16774, 16774, 16774, 16772, 16769, 16765, 16766, 16757, 16767, 17347, 17569, 17518, 17521, 17514, 17509, 17502, 17497, 17489, 17483, 17476, 17467, 17460, 17454, 17447, 17438, 17430, 17424, 17415, 17408, 17399, 17391, 17382, 17374, 17367, 17357, 17349, 17342, 17334, 17324, 17315, 17308, 17019, 16880, 16896, 16881, 16873, 16854, 16891, 16659, 15725, 15634, 15648, 15636, 15629, 15707, 15331, 16842, 29075, 31569, 30958, 31080, 31066, 31056, 31043, 31031, 31019, 31007, 30994, 30980, 30968, 30813, 31522, 27658, 16145, 15663, 15822, 15756, 15744, 15729, 15732, 15661, 15342, 15290, 15289, 15276, 15268, 15257, 15248, 15239, 15228, 15220, 15213, 15203, 15195, 15186, 15177, 15168, 15159, 15150, 15142, 15135, 15127, 15120, 15110, 15101, 15094, 15085, 15076, 15069, 15062, 14842, 15729, 11868, -15294, -20514, -19264, -19539, -19539, -19540, -19539, -19537, -19537, -19536, -19532, -19527, -19525, -19519, -19515, -19509, -19504, -19498, -19491, -19484, -19476, -19469, -19463, -19455, -19447, -19438, -19431, -19423, -19414, -19405, -19394, -19387, -19380, -19370, -19361, -19353, -19342, -19333, -19324, -19315, -19305, -19296, -19287, -19277, -19267, -19258, -19249, -19240, -19231, -19221, -19211, -19200, -19194, -18879, -20197, -14233, 25088, 32269, 30552, 30929, 30925, 30724, 31350, 29197, -8855, -21210, -18639, -19162, -19151, -19150, -19145, -19144, -19141, -19135, -19132, -19126, -19121, -19115, -19109, -19103, -19097, -19089, -19082, -19075, -19066, -19060, -19050, -19043, -19037, -19028, -19019, -19010, -19001, -18993, -18986, -18975, -18965, -18956, -18947, -18939, -18929, -18921, -18911, -18901, -18892, -18884, -18874, -18866, -18856, -18847, -18838, -18828, -18819, -18809, -18800, -18789, -18779, -18771, -18761, -18751, -18742, -18733, -18724, -18714, -18705, -18696, -18688, -18676, -18665, -18657, -18647, -18639, -18632, -18408, -19513, -13581};