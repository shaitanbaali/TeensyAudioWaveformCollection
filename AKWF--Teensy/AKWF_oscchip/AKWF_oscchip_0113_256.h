/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0113 256 samples */
 
const int16_t AKWF_oscchip_0113_256_DATA [256] = 
{512, 529, 524, 525, 525, 593, 275, 1591, 12281, 13598, 13253, 13328, 13327, 13325, 13325, 13322, 13320, 13318, 13316, 13314, 13311, 13309, 13306, 13304, 13301, 13297, 13295, 13292, 13289, 13285, 13282, 13280, 13277, 13274, 13270, 13267, 13264, 13260, 13257, 13254, 13250, 13246, 13243, 13240, 13236, 13233, 13230, 13225, 13222, 13218, 13215, 13212, 13208, 13205, 13202, 13198, 13195, 13190, 13187, 13183, 13180, 13177, 13173, 13170, 13167, 13163, 13159, 13155, 13152, 13148, 13145, 13141, 13138, 13135, 13131, 13127, 13123, 13120, 13117, 13113, 13110, 13107, 13103, 13100, 13095, 13092, 13089, 13085, 13082, 13079, 13075, 13072, 13068, 13064, 13060, 13057, 13054, 13050, 13047, 13044, 13040, 13037, 13033, 13028, 13025, 13022, 13018, 13015, 13012, 13008, 13005, 13002, 12998, 12994, 12990, 12987, 12984, 12980, 12977, 12973, 12970, 12967, 12963, 12960, 12956, 12952, 12949, 12945, 12942, 12939, 12935, 12932, 12928, 12523, 14654, 3877, -31253, -31664, -31402, -31522, -31521, -31501, -31589, -31169, -28695, -28441, -28503, -28485, -28480, -28440, -28624, -27614, -25351, -25457, -25437, -25428, -25421, -25385, -25538, -24763, -22030, -21990, -22009, -21991, -21985, -21973, -22000, -21847, -20902, -20807, -20828, -20816, -20811, -20760, -20998, -19729, -16890, -17041, -17012, -17004, -16999, -16972, -17077, -16564, -14737, -14705, -14713, -14704, -14699, -14679, -14746, -14447, -12565, -12382, -12423, -12407, -12403, -12374, -12508, -11768, -10076, -10138, -10126, -10120, -10117, -10107, -10138, -9965, -9361, -9342, -9344, -9340, -9337, -9320, -9381, -9100, -7247, -7023, -7074, -7060, -7057, -7031, -7158, -6458, -4746, -4793, -4789, -4784, -4782, -4768, -4829, -4521, -3299, -3250, -3268, -3262, -3260, -3253, -3280, -3150, -2217, -2100, -2128, -2121, -2120, -2102, -2189, -1744, -579, -615, -611, -609, -607, -600, -634, -464};