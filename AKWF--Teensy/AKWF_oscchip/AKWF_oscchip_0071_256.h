/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0071 256 samples */
 
const int16_t AKWF_oscchip_0071_256_DATA [256] = 
{491, 249, 281, 282, 284, 297, 247, 595, 1012, 961, 972, 974, 975, 985, 938, 1206, 1680, 1641, 1647, 1649, 1650, 1642, 1681, 1489, 970, 984, 984, 983, 983, 983, 983, 983, 983, 983, 983, 983, 979, 1305, -467, 9477, 26938, 25507, 25755, 25759, 25757, 25754, 25751, 25747, 25742, 25738, 25735, 25730, 25724, 25702, 25793, 25119, 24291, 24376, 24356, 24349, 24343, 24338, 24331, 24325, 24319, 24314, 24307, 24301, 24294, 24275, 24340, 23963, 22919, 22923, 22922, 22914, 22907, 22892, 22934, 22608, 22173, 22212, 22195, 22190, 22184, 22169, 22207, 21957, 21466, 21491, 21480, 21474, 21466, 21200, 22566, 15628, -5512, -5398, -5295, -5366, -5368, -5448, -5036, -7593, -11071, -10667, -10742, -10743, -10744, -10811, -10446, -12398, -16328, -16050, -16091, -16091, -16089, -16189, -15655, -18190, -26180, -26129, -26101, -26117, -26114, -26063, -26308, -24702, -22562, -22784, -22736, -22731, -22727, -22720, -22714, -22709, -22705, -22697, -22692, -22687, -22681, -22676, -22669, -22664, -22658, -22652, -22646, -22640, -22635, -22628, -22623, -22617, -22610, -22604, -22599, -22593, -22586, -22436, -23207, -18823, -9484, -9897, -9843, -9819, -9816, -9727, -10175, -6866, -3370, -3850, -3758, -3755, -3751, -3740, -3786, -3492, -3037, -3079, -3069, -3067, -3065, -3024, -3230, -2138, 387, 273, 286, 292, 292, 294, 295, 295, 296, 297, 297, 296, 298, 299, 298, 299, 299, 299, 299, 298, 301, 286, 371, -70, -1082, -1031, -1040, -1040, -1040, -1030, -1079, -715, -328, -379, -371, -369, -369, 2, -2025, 10473, 29801, 28135, 28419, 28434, 28430, 28426, 28423, 28419, 28414, 28411, 28407, 28400, 28386, 27612, 31891, 909, -34811, -30482, -31250, -31256, -31255, -31247, -31293, -31015, -30550, -30584, -30573, -30567, -30563, -30298, -31702, -23640};