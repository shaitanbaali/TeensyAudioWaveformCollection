/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0075 256 samples */
 
const int16_t AKWF_oscchip_0075_256_DATA [256] = 
{18286, 30831, 28736, 29134, 29126, 29123, 29119, 29116, 29112, 29107, 29102, 29097, 29092, 29087, 29080, 29074, 29069, 29062, 29055, 29049, 29043, 29036, 29029, 29022, 29015, 29008, 29001, 28993, 28987, 28979, 28972, 28964, 28957, 28950, 28942, 28935, 28927, 28919, 28912, 28905, 28897, 28889, 28881, 28874, 28867, 28859, 28852, 28844, 28836, 28828, 28821, 28813, 28805, 28797, 28790, 28782, 28774, 28767, 28759, 28751, 28744, 28677, 28279, 30891, -10191, -31144, -27040, -27828, -27820, -27820, -27830, -27800, -27402, -27327, -27343, -27336, -27334, -27331, -27329, -27325, -26939, -26813, -26833, -26823, -26817, -26818, -26851, -26571, -30761, -32890, -32483, -32552, -32545, -32513, -32597, -32246, -27166, -26066, -26295, -26240, -26233, -26224, -26219, -26214, -25465, -25194, -25239, -25223, -25216, -25209, -25195, -25227, -24541, -24166, -24224, -24203, -24196, -24187, -24191, -24146, -23361, -23169, -23205, -23190, -23183, -23171, -23164, -23201, -20976, -20120, -20290, -20251, -20245, -20237, -20207, -20348, -18336, -17158, -17364, -17320, -17315, -17288, -17358, -17105, -11570, -10318, -10606, -10544, -10540, -10530, -10520, -10606, -7620, -6479, -6712, -6662, -6660, -6654, -6615, -6838, -4133, -2561, -2854, -2795, -2794, -2779, -2822, -2680, 453, 1191, 1033, 1066, 1067, 1077, 1077, 1001, 4690, 6109, 5830, 5882, 5882, 5885, 5912, 5715, 8392, 9944, 9673, 9725, 9723, 9726, 9712, 9753, 10901, 11210, 11142, 11151, 11150, 11144, 11137, 11185, 9384, 8617, 8760, 8730, 8728, 8723, 8682, 8906, 5991, 4134, 4439, 4381, 4379, 4366, 4390, 4318, 1603, 873, 1036, 1003, 1002, 999, 992, 1039, -42, -523, -428, -448, -447, -452, -442, -481, -881, -941, -928, -930, -931, -932, -928, -937, -1325, -1429, -1406, -1411, -1410, -1408, -1404, -1450, -359, 105, 15, 34, 34, 22, 85, -223};