/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0105 256 samples */
 
const int16_t AKWF_oscchip_0105_256_DATA [256] = 
{1264, 1821, 1712, 1731, 1733, 1747, 1736, 1698, 6635, 8437, 8083, 8151, 8152, 8156, 8198, 7916, 12421, 14919, 14482, 14559, 14558, 14561, 14700, 13874, 21750, 28144, 27198, 27369, 27366, 27371, 27367, 27288, 31408, 32947, 32622, 32677, 32670, 32664, 32657, 32650, 32643, 32636, 32628, 32621, 32613, 32604, 32404, 33455, 24448, 16611, 17810, 17585, 17580, 17566, 17556, 17638, 14317, 13055, 13313, 13255, 13250, 13236, 13137, 13732, 6210, 1876, 2685, 2528, 2527, 2523, 2440, 2886, -673, -3770, -3279, -3376, -3377, -3374, -3373, -3426, -1381, -576, -734, -706, -708, -704, -675, -872, 1713, 3249, 2982, 3033, 3033, 3036, 3024, 3057, 3914, 4137, 4089, 4096, 4096, 4083, 4060, 4261, -2113, -4893, -4364, -4463, -4463, -4458, -4370, -4893, 1546, 5733, 5034, 5160, 5158, 5158, 5158, 5157, 5155, 5156, 5155, 5154, 5153, 5151, 5148, 5164, 4764, 4586, 4619, 4612, 4611, 4608, 4571, 4776, 2643, 1191, 1447, 1398, 1397, 1383, 1417, 1345, -2966, -4165, -3905, -3955, -3955, -3962, -3981, -3798, -7821, -9588, -9235, -9302, -9300, -9302, -9367, -8960, -13274, -16110, -15609, -15702, -15698, -15710, -15672, -15752, -20026, -21237, -20981, -21024, -21020, -21022, -21034, -20892, -24031, -25499, -25225, -25271, -25267, -25261, -25266, -25197, -25889, -26368, -26284, -26292, -26286, -26210, -26327, -26110, -4190, 2723, 1278, 1557, 1561, 1538, 1409, 2313, -15614, -24366, -22708, -23010, -23006, -23001, -22936, -23271, -19872, -17301, -17708, -17630, -17625, -17574, -17628, -17676, -1192, 4188, 3034, 3260, 3260, 3246, 3146, 3855, -7455, -13148, -12024, -12234, -12229, -12226, -12184, -12405, -10339, -8800, -9058, -9006, -9004, -8995, -9002, -9013, -6481, -5640, -5812, -5778, -5775, -5770, -5748, -5891, -3565, -2380, -2598, -2554, -2555, -2548, -2579, -2419};