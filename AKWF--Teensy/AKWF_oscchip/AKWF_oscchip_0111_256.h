/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0111 256 samples */
 
const int16_t AKWF_oscchip_0111_256_DATA [256] = 
{24751, 32468, 30973, 31245, 31249, 31248, 31246, 31244, 31242, 31238, 31234, 31230, 31225, 31220, 31215, 31208, 31202, 31196, 31190, 31184, 31178, 31170, 31168, 31143, 30474, 30289, 30324, 30308, 30300, 29967, 31601, 24238, -9700, -11280, -10746, -10902, -10908, -10908, -10929, -10855, -10171, -10077, -10103, -10097, -10097, -10080, -10126, -10022, -4669, -3260, -3575, -3514, -3513, -3584, -3229, -4819, -12210, -12644, -12527, -12556, -12555, -12578, -12465, -12912, -16978, -17597, -17450, -17478, -17475, -17373, -17646, -16862, 10136, 17533, 15994, 16289, 16293, 16249, 16473, 15420, 10054, 9616, 9730, 9701, 9699, 9705, 9672, 9801, 11149, 11387, 11329, 11337, 11335, 11334, 11327, 11337, 11983, 12181, 12137, 12142, 12139, 12147, 12090, 12337, 13694, 13795, 13762, 13767, 13764, 13770, 13727, 13875, 15917, 16290, 16193, 16207, 16203, 16224, 16091, 16694, 18661, 18657, 18643, 18644, 18639, 18681, 18451, 19421, 24882, 25292, 25171, 25196, 25189, 24946, 25928, 22246, -23482, -31514, -29601, -29996, -29998, -29975, -30094, -29509, -27550, -27515, -27523, -27516, -27514, -27493, -27568, -27211, -25184, -24985, -25027, -25012, -25006, -25000, -24994, -24990, -24984, -24978, -24972, -24966, -24960, -24919, -25099, -24164, -20866, -20787, -20815, -20796, -20790, -20780, -20796, -20688, -20004, -19921, -19933, -19923, -19916, -19912, -19907, -19901, -19895, -19889, -19883, -19879, -19873, -19867, -19861, -19857, -19852, -19845, -19839, -19836, -19829, -19641, -20509, -16775, 9322, 12068, 11306, 11479, 11482, 11507, 11424, 11715, 17138, 18289, 18020, 18074, 18071, 17989, 18403, 16497, 9157, 8958, 9024, 8998, 8995, 8987, 9009, 8911, 8225, 8147, 8163, 8158, 8156, 8058, 8397, 7238, -14292, -19042, -17984, -18191, -18195, -18194, -18193, -18192, -18189, -18188, -18186, -18184, -18181, -18164, -18224, -17950, -15925, -15644, -15704, -15686, -15682, -15630, -15887, -14531};