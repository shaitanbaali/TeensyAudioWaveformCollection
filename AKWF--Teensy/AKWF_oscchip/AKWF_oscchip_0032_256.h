/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0032 256 samples */
 
const int16_t AKWF_oscchip_0032_256_DATA [256] = 
{7263, 7450, 7372, 7386, 7389, 7403, 7343, 7652, 8830, 8929, 8900, 8908, 8908, 8937, 8773, 10103, 11678, 11518, 11544, 11543, 11542, 11553, 11483, 11919, 12696, 12657, 12659, 12659, 12656, 12657, 12636, 12732, 13017, 13022, 13016, 13016, 13012, 13009, 13006, 13002, 13000, 12997, 12993, 12990, 12987, 12987, 12960, 13127, 13365, 13343, 13343, 13339, 13336, 13344, 13277, 13653, 14468, 14451, 14446, 14445, 14442, 14442, 14422, 14500, 14788, 14805, 14796, 14794, 14791, 14799, 14729, 15305, 15963, 15892, 15899, 15895, 15892, 15897, 15847, 16142, 16651, 16622, 16620, 16617, 16612, 16766, 15958, 20383, 32130, 32340, 32209, 32251, 32246, 32241, 32235, 32228, 32221, 32214, 32208, 32200, 32193, 32185, 32178, 32171, 32162, 32154, 32147, 32139, 32130, 32123, 32115, 32106, 32098, 32090, 32082, 32074, 32068, 31619, 33789, 22536, -14501, -16603, -15930, -16128, -16134, -16138, -16140, -16142, -16144, -16145, -16144, -16144, -16145, -16144, -16142, -16140, -16139, -16137, -16135, -16132, -16130, -16127, -16124, -16121, -16119, -16115, -16111, -16109, -16105, -16101, -16098, -16094, -16090, -16087, -16083, -16079, -16075, -16070, -16066, -16063, -16059, -16055, -16050, -16046, -16043, -16038, -16033, -16030, -16026, -16021, -16017, -16014, -16008, -16004, -16001, -15996, -15991, -15988, -15983, -15979, -15975, -15970, -15966, -15963, -15958, -15953, -15950, -15945, -15941, -15937, -15932, -15928, -15924, -15920, -15915, -15912, -15906, -15903, -15899, -15894, -15890, -15886, -15881, -15877, -15873, -15868, -15865, -15861, -15855, -15852, -15847, -15843, -15839, -15834, -15830, -15827, -15821, -15817, -15814, -15809, -15805, -15801, -15796, -15792, -15788, -15783, -15779, -15775, -15771, -15766, -15763, -15759, -15753, -15750, -15746, -15741, -15737, -15733, -15728, -15724, -15721, -15716, -15712, -15708, -15703, -15699, -15695, -15690, -15686, -15683, -15678, -15673, -15674, -15456, -16564, -9749};