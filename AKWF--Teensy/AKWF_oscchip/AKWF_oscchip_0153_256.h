/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0153 256 samples */
 
const int16_t AKWF_oscchip_0153_256_DATA [256] = 
{942, 1103, 1064, 1070, 1071, 1086, 1016, 1328, 3491, 3815, 3737, 3752, 3752, 3788, 3587, 4827, 7082, 6951, 6969, 6972, 6972, 7015, 6787, 8020, 11280, 11269, 11256, 11263, 11264, 11290, 11161, 11791, 14354, 14520, 14471, 14485, 14485, 14540, 14290, 15409, 23198, 24368, 24084, 24144, 24144, 24206, 23870, 25931, 29688, 29476, 29505, 29508, 29508, 29530, 29416, 30033, 31664, 31659, 31653, 31657, 31657, 31666, 31623, 31834, 32686, 32742, 32724, 32728, 32728, 32710, 32793, 32421, 29826, 29434, 29530, 29508, 29508, 29459, 29728, 28080, 25074, 25245, 25221, 25218, 25218, 25175, 25403, 24170, 20908, 20917, 20932, 20921, 20921, 20895, 21024, 20394, 17834, 17667, 17718, 17706, 17706, 17682, 17793, 17295, 13831, 13310, 13439, 13411, 13411, 13313, 13850, 10550, 4536, 4880, 4835, 4829, 4829, 4649, 5590, 507, -12938, -12897, -12841, -12878, -12880, -12862, -12948, -12527, -10820, -10710, -10743, -10734, -10734, -10730, -10744, -10682, -10249, -10184, -10202, -10199, -10198, -10192, -10226, -10019, -9642, -9664, -9662, -9661, -9661, -9689, -9546, -10316, -12352, -12345, -12336, -12342, -12342, -12386, -12171, -13222, -17492, -17769, -17686, -17709, -17708, -17727, -17643, -18017, -20613, -21001, -20905, -20927, -20926, -21012, -20542, -23430, -28693, -28393, -28436, -28443, -28442, -28464, -28350, -28966, -30596, -30591, -30583, -30588, -30588, -30597, -30554, -30765, -31618, -31673, -31656, -31662, -31663, -31644, -31728, -31354, -28756, -28366, -28462, -28443, -28443, -28381, -28717, -26655, -22897, -23110, -23082, -23077, -23078, -23035, -23263, -22030, -18767, -18778, -18791, -18784, -18783, -18758, -18886, -18255, -15692, -15528, -15577, -15563, -15563, -15544, -15627, -15255, -12660, -12268, -12364, -12342, -12343, -12325, -12389, -12147, -8326, -7340, -7555, -7515, -7516, -7467, -7723, -6338, -2671, -2681, -2697, -2687, -2687, -2665, -2782, -2154};