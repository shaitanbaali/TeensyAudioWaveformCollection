/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0091 256 samples */
 
const int16_t AKWF_oscchip_0091_256_DATA [256] = 
{26487, 31825, 30776, 30963, 30968, 30961, 30969, 30951, 29343, 28846, 28943, 28919, 28914, 28908, 28898, 28930, 28182, 27821, 27880, 27863, 27859, 27840, 27881, 27684, 25206, 24696, 24801, 24772, 24766, 24752, 24755, 24743, 22369, 21559, 21718, 21679, 21674, 21665, 21638, 21763, 19575, 18432, 18640, 18594, 18588, 18572, 18607, 18456, 15940, 15424, 15542, 15513, 15509, 15502, 15497, 15504, 14702, 14420, 14473, 14457, 14452, 14445, 14410, 14607, 11697, 10142, 10434, 10375, 10372, 10356, 10399, 10230, 7721, 7223, 7331, 7304, 7300, 7289, 7292, 7332, 4147, 3057, 3279, 3236, 3233, 3227, 3198, 3395, 475, -1057, -777, -833, -833, -837, -824, -876, -1693, -1879, -1840, -1847, -1847, -1854, -1851, -1832, -4162, -5024, -4853, -4883, -4883, -4886, -4908, -4763, -6891, -8095, -7884, -7920, -7921, -7926, -7909, -7960, -9185, -9487, -9415, -9427, -9426, -9426, -9425, -9404, -10174, -10481, -10414, -10422, -10420, -10434, -10355, -10671, -13205, -13510, -13427, -13443, -13440, -13441, -13429, -13451, -14277, -14477, -14427, -14432, -14429, -14427, -14426, -14396, -15174, -15478, -15410, -15416, -15412, -15408, -15404, -15402, -15397, -15392, -15389, -15385, -15380, -15377, -15374, -15369, -15366, -15362, -15357, -15352, -15349, -15345, -15340, -15348, -14961, -14801, -14825, -14815, -14812, -14803, -14821, -14723, -13891, -13757, -13783, -13772, -13769, -13762, -13769, -13727, -12513, -12171, -12236, -12220, -12215, -12209, -12198, -12254, -10372, -9538, -9693, -9661, -9658, -9641, -9693, -9464, -6946, -6522, -6623, -6600, -6597, -6591, -6596, -6578, -5358, -4998, -5074, -5057, -5055, -5053, -5049, -5065, -4688, -4513, -4545, -4536, -4535, -4526, -4555, -4435, -3171, -2971, -3019, -3009, -3007, -3018, -2988, -3044, -6713, -7741, -7516, -7558, -7557, -7570, -7619, -7197, -15150, -18758, -18045, -18180, -18176, -18070, -18616, -16013};