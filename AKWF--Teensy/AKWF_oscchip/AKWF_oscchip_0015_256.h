/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0015 256 samples */
 
const int16_t AKWF_oscchip_0015_256_DATA [256] = 
{11062, 24400, 22546, 22882, 22878, 22876, 22987, 22331, 28226, 33056, 32291, 32426, 32413, 32395, 32233, 33113, 23459, 15947, 17114, 16881, 16872, 16866, 16920, 16482, 21560, 25073, 24505, 24595, 24581, 24559, 24401, 25272, 14960, 8315, 9442, 9214, 9206, 9184, 9066, 9749, -20, -6016, -4943, -5157, -5158, -5159, -5160, -5199, -4521, -4142, -4210, -4201, -4200, -4200, -4199, -4211, -3974, -3858, -3877, -3872, -3871, -3872, -3870, -3867, -3867, -3866, -3864, -3861, -3859, -3860, -3857, -3855, -3854, -3853, -3849, -3848, -3847, -3843, -3841, -3841, -3837, -3835, -3835, -3831, -3829, -3828, -3825, -3823, -3822, -3819, -3815, -3816, -3813, -3809, -3810, -3807, -3803, -3804, -3800, -3797, -3796, -3794, -3791, -3790, -3787, -3783, -3784, -3781, -3777, -3777, -3774, -3771, -3770, -3768, -3765, -3764, -3762, -3759, -3761, -3739, -3921, -4096, -4069, -4070, -4069, -4067, -4060, -4080, -3884, -3713, -3736, -3729, -3725, -3725, -3758, -3556, -5355, -6828, -6593, -6634, -6632, -6628, -6596, -6765, -4927, -3507, -3732, -3686, -3685, -3680, -3680, -3676, -3673, -3673, -3668, -3668, -3664, -3661, -3663, -3642, -3863, -3999, -3970, -3974, -3972, -3968, -3965, -3979, -3754, -3615, -3637, -3630, -3629, -3627, -3626, -3612, -3836, -3962, -3937, -3939, -3934, -3934, -3929, -3947, -3817, -3588, -3600, -3597, -3592, -3590, -3589, -3586, -3584, -3583, -3580, -3578, -3577, -3574, -3571, -3571, -3568, -3565, -3565, -3561, -3558, -3558, -3555, -3553, -3552, -3550, -3546, -3544, -3544, -3540, -3539, -3538, -3535, -3533, -3532, -3527, -3527, -3525, -3525, -3502, -3665, -3859, -3835, -3837, -3836, -3832, -3832, -3829, -3825, -3825, -3822, -3819, -3819, -3816, -3808, -3830, -3650, -3461, -3485, -3477, -3475, -3475, -3471, -3468, -3468, -3464, -3462, -3462, -3458, -3467, -3408, -3662};