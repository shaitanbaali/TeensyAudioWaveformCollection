/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0136 256 samples */
 
const int16_t AKWF_oscchip_0136_256_DATA [256] = 
{28947, 31236, 30692, 30789, 30792, 30787, 30810, 30702, 29956, 29843, 29866, 29856, 29852, 29836, 29868, 29725, 27532, 26962, 27079, 27050, 27044, 27010, 27150, 26352, 24250, 24249, 24253, 24242, 24233, 24196, 24337, 23610, 20674, 20478, 20528, 20507, 20501, 20485, 20526, 20307, 18817, 18587, 18637, 18620, 18615, 18592, 18646, 18411, 14765, 13819, 14019, 13974, 13970, 13951, 14020, 13619, 12567, 12565, 12566, 12559, 12554, 12536, 12604, 12242, 10775, 10675, 10699, 10689, 10685, 10676, 10697, 10587, 9841, 9726, 9750, 9741, 9738, 9730, 9746, 9674, 8576, 8291, 8350, 8334, 8332, 8325, 8346, 8213, 7861, 7859, 7858, 7855, 7852, 7832, 7920, 7468, 5636, 5515, 5548, 5537, 5535, 5525, 5559, 5397, 4282, 4114, 4153, 4142, 4140, 4136, 4147, 4099, 3370, 3181, 3219, 3210, 3210, 2948, 4316, -3080, -22649, -22587, -22505, -22559, -22558, -22515, -22716, -21722, -17695, -17431, -17505, -17481, -17477, -17464, -17507, -17290, -15800, -15573, -15624, -15609, -15605, -15587, -15631, -15443, -12529, -11774, -11934, -11898, -11894, -11862, -12005, -11209, -9108, -9111, -9116, -9107, -9104, -9105, -9083, -9170, -9533, -9554, -9544, -9543, -9540, -9542, -9516, -9620, -10358, -10466, -10437, -10440, -10438, -10449, -10397, -10579, -13489, -14238, -14072, -14100, -14097, -14047, -14288, -12966, -9466, -9473, -9486, -9472, -9469, -9541, -9170, -10970, -18291, -18763, -18618, -18652, -18649, -18666, -18567, -18989, -21951, -22393, -22281, -22300, -22294, -22295, -22271, -22336, -23425, -23702, -23635, -23641, -23636, -23478, -24278, -19915, -8376, -8405, -8450, -8413, -8408, -8326, -8708, -6811, 878, 1379, 1234, 1276, 1280, 1261, 1358, 934, -2031, -2475, -2365, -2387, -2385, -2414, -2307, -2700, -8886, -10480, -10132, -10198, -10197, -10321, -9659, -13222, -22656, -22622, -22580, -22604, -22601, -22289, -23945, -15037};