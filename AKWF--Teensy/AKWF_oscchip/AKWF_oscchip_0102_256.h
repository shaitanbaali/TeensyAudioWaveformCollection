/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0102 256 samples */
 
const int16_t AKWF_oscchip_0102_256_DATA [256] = 
{10910, 18399, 17133, 17374, 17370, 17368, 17387, 17268, 18134, 18970, 18846, 18867, 18865, 18861, 18899, 18667, 20068, 22047, 21831, 21865, 21861, 21857, 21857, 21822, 22151, 22371, 22329, 22330, 22326, 22320, 22321, 22280, 22554, 22831, 22789, 22791, 22785, 22780, 22787, 22709, 23154, 23814, 23749, 23754, 23749, 23743, 23743, 23707, 24024, 24252, 24209, 24209, 24203, 24197, 24205, 24125, 24667, 25242, 25159, 25166, 25159, 25154, 25147, 25141, 25134, 25127, 25120, 25114, 25108, 25101, 25095, 25087, 25081, 25074, 25068, 25061, 25054, 25047, 25054, 24970, 25509, 26097, 26009, 26017, 26010, 26003, 26010, 25929, 26354, 27039, 26965, 26969, 26962, 26957, 26973, 26825, 28123, 29077, 28911, 28935, 28927, 28921, 28899, 28969, 28422, 27819, 27887, 27865, 27857, 27851, 27849, 27803, 28513, 28884, 28811, 28816, 28808, 28777, 28101, 31993, -5221, -34363, -29947, -30764, -30764, -30765, -30765, -30765, -30765, -30763, -30761, -30758, -30754, -30750, -30738, -30782, -30072, -29663, -29733, -29715, -29709, -29703, -29697, -29689, -29684, -29678, -29670, -29663, -29656, -29649, -29629, -29697, -29177, -28543, -28613, -28591, -28584, -28576, -28568, -28561, -28555, -28547, -28539, -28531, -28524, -28517, -28503, -28532, -28218, -27949, -27983, -27967, -27960, -27954, -27946, -27938, -27930, -27923, -27915, -27907, -27900, -27892, -27876, -27923, -27209, -26796, -26858, -26837, -26830, -26822, -26822, -26778, -27078, -27330, -27284, -27286, -27279, -27272, -27250, -27318, -26815, -26177, -26238, -26217, -26210, -26201, -26182, -26252, -25217, -24574, -24674, -24650, -24642, -24635, -24622, -24650, -24347, -24072, -24104, -24088, -24081, -24072, -23760, -25434, -14292, 443, -1117, -842, -831, -826, -818, -845, -501, -275, -311, -301, -299, -297, -296, -294, -292, -291, -289, -288, -287, -286, -284, -285, -283, -282, -283, -281, -280, -288, -248, -438};