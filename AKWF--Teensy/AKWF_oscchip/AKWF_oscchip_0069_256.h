/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0069 256 samples */
 
const int16_t AKWF_oscchip_0069_256_DATA [256] = 
{18089, 33564, 31167, 31619, 31612, 31608, 31597, 31634, 31343, 31019, 31053, 31041, 31035, 30984, 30585, 33117, -7177, -29043, -25200, -25904, -25907, -25909, -25910, -25910, -25908, -25907, -25905, -25903, -25900, -25891, -25537, -27495, -13639, 3046, 1161, 1499, 1506, 1507, 1510, 1512, 1514, 1515, 1517, 1518, 1519, 1520, 1521, 1522, 1521, 1523, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1524, 1523, 1518, 1549, 1174, 955, 995, 987, 988, 987, 959, 1119, -181, -1305, -1130, -1164, -1163, -1163, -1163, -1163, -1163, -1163, -1163, -1163, -1163, -1163, -1159, -1188, -814, -594, -633, -625, -625, -625, -625, -625, -625, -625, -626, -625, -623, -624, -624, -623, -623, -623, -623, -623, -623, -623, -624, -622, -621, -622, -621, -621, -621, -621, -621, -621, -621, -622, -621, -619, -619, -617, -611, -662, 542, 1082, 975, 996, 995, 995, 978, 1076, -1, -721, -596, -620, -619, -619, -619, -619, -619, -619, -619, -619, -619, -619, -620, -619, -617, -617, -618, -617, -617, -617, -617, -617, -617, -617, -617, -617, -618, -617, -616, -615, -616, -615, -615, -615, -615, -616, -618, -602, -997, -1177, -1143, -1149, -1150, -1149, -1149, -1149, -1149, -1150, -1149, -1147, -1147, -1148, -1147, -1147, -1148, -1147, -1145, -1146, -1145, -1145, -1145, -1146, -1145, -1143, -1144, -1143, -1143, -1143, -1144, -1142, -1141, -1142, -1141, -1141, -1142, -1141, -1118, -1237, -366, 571, 448, 471, 471, 469, 458, 535, -639, -1233, -1116, -1138, -1137, -1137, -1131, -1168, -826, -565, -609, -601, -600, -602, -600, -599, -1022, -1158, -1131, -1137, -1136, -1135, -1134, -1135, -1134, -1134, -1134, -1135, -1134, -1142, -1088, -1367};