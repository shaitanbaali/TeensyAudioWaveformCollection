/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0063 256 samples */
 
const int16_t AKWF_oscchip_0063_256_DATA [256] = 
{4074, 6942, 6299, 6434, 6436, 6533, 6063, 9124, 14753, 14531, 14546, 14558, 14554, 14608, 14327, 15852, 20230, 20378, 20312, 20328, 20320, 20339, 20234, 20691, 22960, 23244, 23164, 23174, 23164, 22826, 24607, 11833, -6445, -5001, -5223, -5243, -5259, -4919, -6701, 3816, 27410, 27163, 27055, 27123, 27117, 27119, 27064, 27303, 28188, 28246, 28217, 28212, 28204, 27938, 29013, 24276, -7129, -12862, -11488, -11800, -11803, -11805, -11813, -11814, -11816, -11817, -11816, -11816, -11824, -11426, -13411, -2517, 27639, 28357, 27981, 28107, 28109, 28097, 28114, 28013, 27549, 27490, 27495, 27482, 27474, 27437, 27574, 26494, 25015, 25130, 25097, 25086, 25077, 25025, 25216, 24013, 21500, 21549, 21539, 21523, 21512, 21417, 21808, 19731, 12546, 12087, 12225, 12176, 12168, 12116, 12286, 11476, 6436, 5591, 5792, 5739, 5736, 5606, 6247, 1986, -5052, -4646, -4702, -4712, -4717, -4776, -4503, -6021, -9911, -9949, -9917, -9931, -9931, -9979, -9747, -10870, -15877, -16403, -16249, -16279, -16277, -16302, -16185, -16637, -20724, -21633, -21411, -21451, -21442, -21488, -21209, -22844, -26123, -26020, -26012, -26010, -26001, -26025, -25854, -26684, -29337, -29454, -29397, -29400, -29390, -29384, -29336, -29477, -30379, -30507, -30458, -30454, -30440, -29965, -32475, -14700, 13310, 11599, 11841, 11884, 11894, 11900, 11903, 11910, 11911, 11913, 11913, 11913, 11913, 11908, 11930, 11819, 11368, 11324, 11333, 11329, 11326, 11317, 11327, 11269, 10808, 10709, 10729, 10722, 10714, 10705, 10735, 10518, 10107, 10117, 10111, 10106, 10104, 9706, 11661, 1054, -30596, -31906, -31434, -31583, -31585, -31574, -31588, -31497, -31036, -30964, -30972, -30959, -30951, -30933, -30953, -30825, -29467, -29097, -29166, -29136, -29127, -29061, -29327, -27670, -23847, -23844, -23850, -23826, -23814, -23723, -24090, -22170, -14956, -14367, -14527, -14472, -14463, -14366, -14801, -12627};