/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0043 256 samples */
 
const int16_t AKWF_oscchip_0043_256_DATA [256] = 
{1299, 1417, 1356, 1369, 1375, 1394, 1320, 1723, 3164, 3273, 3242, 3251, 3253, 3274, 3188, 3580, 6132, 6590, 6482, 6506, 6508, 6522, 6437, 6982, 7936, 7887, 7893, 7894, 7893, 7896, 7872, 7997, 8345, 8352, 8347, 8347, 8345, 8343, 8342, 8339, 8338, 8335, 8333, 8332, 8329, 8330, 8319, 8356, 8713, 8797, 8777, 8779, 8777, 8789, 8708, 9178, 10183, 10159, 10156, 10157, 10155, 10156, 10132, 10237, 10591, 10611, 10601, 10601, 10598, 10604, 10562, 10736, 11830, 12014, 11963, 11970, 11968, 11968, 11953, 11998, 12703, 12919, 12869, 12874, 12869, 13066, 12046, 17742, 32069, 32195, 32068, 32113, 32111, 32105, 32100, 32094, 32087, 32081, 32074, 32067, 32061, 32054, 32046, 32039, 32031, 32024, 32016, 32008, 32001, 31992, 31985, 31977, 31969, 31960, 31952, 31944, 31940, 31373, 34140, 19564, -25749, -27837, -27076, -27307, -27311, -27314, -27315, -27314, -27315, -27313, -27312, -27309, -27307, -27304, -27300, -27297, -27293, -27288, -27283, -27279, -27273, -27268, -27263, -27257, -27251, -27245, -27239, -27233, -27227, -27220, -27214, -27207, -27200, -27194, -27188, -27181, -27174, -27167, -27160, -27153, -27146, -27139, -27132, -27125, -27119, -27111, -27104, -27097, -27090, -27082, -27076, -27069, -27061, -27053, -27047, -27040, -27032, -27026, -27017, -27011, -27006, -26629, -28312, -20513, 19295, 24708, 23324, 23649, 23647, 23623, 23718, 23364, 19027, 17874, 18129, 18075, 18076, 18035, 18234, 17052, 14327, 14340, 14353, 14340, 14336, 14301, 14452, 13678, 10793, 10557, 10624, 10603, 10600, 10557, 10724, 9986, 4876, 3902, 4132, 4077, 4076, 4042, 4131, 3851, -2506, -4652, -4203, -4297, -4297, -4388, -3934, -6403, -13441, -13646, -13550, -13580, -13580, -13678, -13215, -15395, -25961, -27308, -26952, -27029, -27023, -27020, -27016, -27012, -27007, -27001, -26996, -26991, -26990, -26725, -28072, -19587};