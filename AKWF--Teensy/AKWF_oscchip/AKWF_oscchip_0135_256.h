/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0135 256 samples */
 
const int16_t AKWF_oscchip_0135_256_DATA [256] = 
{28608, 31101, 30511, 30617, 30620, 30615, 30641, 30522, 29712, 29588, 29614, 29605, 29602, 29563, 29746, 28584, 26473, 26588, 26566, 26557, 26551, 26514, 26669, 25800, 23513, 23514, 23517, 23505, 23498, 23459, 23612, 22821, 19625, 19411, 19468, 19446, 19439, 19421, 19469, 19230, 17609, 17361, 17416, 17398, 17391, 17330, 17637, 15706, 12192, 12387, 12354, 12346, 12341, 12322, 12397, 11963, 10816, 10817, 10818, 10811, 10807, 10786, 10863, 10467, 8871, 8764, 8792, 8780, 8778, 8769, 8791, 8673, 7863, 7738, 7765, 7756, 7754, 7733, 7826, 7245, 6187, 6245, 6234, 6232, 6229, 6222, 6246, 6101, 5718, 5717, 5717, 5714, 5711, 5689, 5788, 5296, 3304, 3171, 3208, 3197, 3194, 3185, 3223, 3047, 1836, 1651, 1695, 1685, 1684, 1671, 1734, 1349, 646, 684, 680, 677, 675, 391, 1881, -6169, -27475, -27406, -27316, -27373, -27372, -27326, -27543, -26460, -22074, -21787, -21867, -21839, -21834, -21818, -21866, -21629, -20004, -19759, -19812, -19793, -19789, -19739, -19984, -18439, -15629, -15784, -15758, -15749, -15744, -15708, -15863, -14997, -12707, -12711, -12714, -12704, -12700, -12691, -12708, -12606, -12204, -12174, -12178, -12172, -12168, -12150, -12212, -11917, -9895, -9589, -9660, -9640, -9637, -9628, -9645, -9568, -8377, -8067, -8130, -8114, -8111, -8098, -8148, -7859, -7092, -7091, -7092, -7089, -7086, -7079, -7096, -6998, -6597, -6569, -6573, -6569, -6567, -6560, -6584, -6466, -5656, -5532, -5562, -5553, -5551, -5546, -5558, -5505, -4711, -4504, -4548, -4538, -4536, -4535, -4532, -4532, -4530, -4529, -4527, -4526, -4525, -4500, -4618, -4028, -1637, -1482, -1525, -1512, -1512, -1532, -1428, -1891, -5120, -5605, -5485, -5511, -5509, -5539, -5426, -5850, -12586, -14323, -13943, -14015, -14013, -14148, -13427, -17306, -27575, -27541, -27493, -27518, -27514, -27173, -28976, -19279};