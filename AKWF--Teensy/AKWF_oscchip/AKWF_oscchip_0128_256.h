/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0128 256 samples */
 
const int16_t AKWF_oscchip_0128_256_DATA [256] = 
{2242, 3799, 3538, 3587, 3586, 3587, 3610, 3472, 4934, 6121, 5945, 5977, 5977, 5977, 5998, 5880, 6811, 7871, 7749, 7770, 7771, 7777, 7769, 7767, 9569, 10281, 10141, 10168, 10166, 10167, 10173, 10130, 10956, 11429, 11348, 11365, 11365, 11366, 11395, 11223, 13047, 14532, 14312, 14352, 14351, 14351, 14394, 14156, 16023, 18144, 17900, 17943, 17944, 17953, 17941, 17939, 20635, 21700, 21492, 21532, 21531, 21535, 21549, 21440, 23505, 24688, 24481, 24522, 24521, 24522, 24540, 24436, 25534, 26426, 26294, 26319, 26319, 26319, 26341, 26222, 27153, 28213, 28091, 28112, 28111, 28116, 28110, 28109, 29457, 29991, 29885, 29906, 29905, 29905, 29905, 29905, 29905, 29905, 29905, 29905, 29905, 29906, 29912, 29877, 30242, 30539, 30495, 30502, 30501, 30502, 30509, 30469, 30781, 31135, 31095, 31101, 31101, 31101, 31101, 31101, 31101, 31101, 31101, 31101, 31101, 31102, 31105, 31083, 31496, 31732, 31691, 31701, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31700, 31694, 31729, 31362, 31065, 31109, 31102, 31101, 31101, 31094, 31134, 30824, 30471, 30511, 30503, 30501, 30501, 29784, 33739, 8030, -33057, -30003, -30475, -30509, -30503, -30484, -30636, -27746, -26088, -26379, -26323, -26323, -26322, -26287, -26494, -24300, -22516, -22781, -22732, -22733, -22733, -22698, -22895, -21342, -19577, -19778, -19743, -19744, -19743, -19708, -19902, -18641, -16624, -16773, -16751, -16750, -16746, -16735, -16823, -15171, -14223, -14389, -14358, -14359, -14357, -14322, -14529, -12336, -10555, -10820, -10770, -10769, -10769, -10713, -11029, -8544, -5716, -6041, -5984, -5983, -5983, -5920, -6269, -4001, -377, -648, -605, -603, -602, -602, -602};