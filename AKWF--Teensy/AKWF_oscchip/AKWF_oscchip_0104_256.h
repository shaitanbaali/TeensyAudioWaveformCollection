/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0104 256 samples */
 
const int16_t AKWF_oscchip_0104_256_DATA [256] = 
{6084, 5609, 5751, 5730, 5734, 5738, 5741, 5744, 5747, 5749, 5751, 5752, 5754, 5755, 5756, 5756, 5756, 5758, 5758, 5758, 5756, 5746, 5799, 5459, 4967, 5012, 5004, 5002, 5001, 5001, 5000, 4998, 4998, 4997, 4995, 4995, 4993, 4992, 4991, 4991, 4989, 4988, 4987, 4985, 4984, 4983, 4982, 4980, 4979, 4978, 4976, 4975, 4974, 4972, 4972, 4970, 4969, 4967, 4966, 4965, 4963, 4957, 4984, 4774, 4558, 4587, 4581, 4579, 4578, 4577, 4575, 4575, 4574, 4572, 4571, 4570, 4568, 4567, 4565, 4565, 4563, 4562, 4560, 4559, 4559, 4557, 4555, 4555, 4553, 4552, 4551, 4549, 4549, 4547, 4546, 4545, 4543, 4542, 4541, 4540, 4540, 4564, 4416, 5812, 6930, 6756, 6786, 6785, 6783, 6787, 6759, 6951, 7175, 7146, 7148, 7147, 7145, 7148, 7121, 7273, 7530, 7508, 7509, 7508, 7506, 7514, 7458, 7927, 8300, 8238, 8248, 8245, 8243, 8246, 8215, 8405, 8634, 8603, 8606, 8604, 8602, 8606, 8564, 9096, 9386, 9330, 9338, 9335, 9334, 9331, 9329, 9327, 9324, 9321, 9319, 9317, 9314, 9312, 9310, 9307, 9304, 9302, 9300, 9297, 9296, 9298, 9259, 9777, 10078, 10024, 10032, 10030, 10027, 10033, 9980, 10427, 10812, 10754, 10761, 10758, 10756, 10773, 10661, 11407, 12332, 12229, 12244, 12241, 12239, 12228, 12265, 11746, 11429, 11481, 11467, 11465, 11462, 11468, 11412, 11857, 12250, 12188, 12196, 12192, 12188, 11597, 14825, -6332, -34740, -31601, -32143, -32147, -32146, -32143, -32141, -32138, -32135, -32130, -32126, -32121, -32116, -32100, -32151, -31700, -31290, -31346, -31330, -31323, -31316, -31309, -31301, -31294, -31287, -31279, -31272, -31264, -31256, -31242, -31278, -30757, -30425, -30472, -30454, -30446, -30438, -30430, -30422, -30414, -30406, -30398, -30390, -30382, -30374, -29913, -32388, -15960};