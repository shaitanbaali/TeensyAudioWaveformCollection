/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0154 256 samples */
 
const int16_t AKWF_oscchip_0154_256_DATA [256] = 
{1835, 2003, 1963, 1970, 1971, 2005, 1852, 2537, 7308, 8026, 7850, 7889, 7889, 7934, 7687, 9202, 11965, 11807, 11828, 11831, 11831, 11871, 11661, 12794, 15791, 15781, 15769, 15778, 15778, 15802, 15684, 16263, 18615, 18767, 18722, 18735, 18735, 18752, 18675, 19019, 21406, 21766, 21679, 21695, 21695, 21763, 21393, 23667, 27811, 27576, 27607, 27612, 27612, 27622, 27570, 27853, 28604, 28602, 28597, 28599, 28599, 28572, 28709, 28034, 25287, 25109, 25162, 25148, 25148, 25131, 25208, 24865, 22480, 22121, 22209, 22189, 22189, 22110, 22542, 19889, 15052, 15327, 15291, 15284, 15284, 15254, 15411, 14562, 12315, 12321, 12331, 12324, 12324, 12300, 12418, 11838, 9485, 9335, 9380, 9367, 9367, 9339, 9466, 8895, 4918, 4322, 4467, 4438, 4438, 4409, 4564, 3615, 1888, 1986, 1972, 1971, 1972, 1962, 2014, 1731, 981, 983, 986, 983, 984, 721, 2023, -4352, -30247, -31926, -31427, -31560, -31561, -31427, -32040, -29297, -10212, -7344, -8046, -7894, -7895, -7940, -7693, -9207, -11968, -11811, -11834, -11836, -11837, -11876, -11667, -12799, -15795, -15786, -15773, -15783, -15784, -15791, -15752, -15945, -16729, -16778, -16764, -16769, -16768, -16813, -16609, -17523, -23885, -24842, -24608, -24659, -24660, -24728, -24358, -26630, -30774, -30540, -30571, -30574, -30575, -30584, -30532, -30815, -31565, -31562, -31559, -31561, -31561, -31561, -31561, -31561, -31561, -31561, -31561, -31561, -31561, -31533, -31661, -31090, -27115, -26516, -26662, -26630, -26629, -26584, -26831, -25316, -22555, -22711, -22689, -22685, -22686, -22616, -22982, -21001, -15758, -15775, -15797, -15783, -15784, -15760, -15878, -15298, -12942, -12789, -12834, -12822, -12822, -12805, -12881, -12539, -10155, -9797, -9884, -9864, -9865, -9819, -10066, -8550, -5786, -5943, -5922, -5920, -5919, -5880, -6089, -4958, -1963, -1971, -1984, -1975, -1975, -1952, -2074, -1416};