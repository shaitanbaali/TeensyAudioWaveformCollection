/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0023 256 samples */
 
const int16_t AKWF_oscchip_0023_256_DATA [256] = 
{321, 293, 303, 306, 310, 404, -69, 2476, 8481, 8346, 8343, 8359, 8359, 8487, 7798, 11560, 19703, 19337, 19381, 19386, 19383, 19471, 18962, 21841, 27672, 27328, 27364, 27361, 27352, 27390, 27118, 28625, 31461, 31284, 31291, 31280, 31266, 31260, 31216, 31321, 32548, 32739, 32674, 32670, 32653, 32627, 32655, 32440, 30783, 30507, 30554, 30524, 30507, 30464, 30563, 30049, 26781, 26325, 26415, 26376, 26359, 26316, 26428, 25851, 22546, 22197, 22267, 22232, 22217, 22173, 22301, 21629, 17910, 17561, 17640, 17605, 17592, 17556, 17674, 17053, 14211, 13970, 14022, 13996, 13986, 13946, 14085, 13386, 10557, 10393, 10429, 10407, 10398, 10362, 10507, 9756, 6923, 6823, 6849, 6833, 6827, 6802, 6888, 6425, 4830, 4778, 4794, 4782, 4779, 4773, 4771, 4764, 4762, 4758, 4751, 4751, 4746, 4710, 4871, 4042, 1696, 1715, 1719, 1709, 1709, 1691, 1768, 1321, 172, 195, 194, 187, 187, 170, 258, -220, -1344, -1319, -1321, -1324, -1323, -1393, -1018, -3070, -7510, -7315, -7339, -7343, -7342, -7356, -7301, -7500, -10318, -10958, -10810, -10836, -10830, -10846, -10770, -11039, -13875, -14424, -14296, -14315, -14310, -14308, -14283, -14358, -15176, -15305, -15268, -15267, -15260, -15275, -15166, -15603, -19293, -19851, -19704, -19724, -19716, -19712, -19675, -19786, -20592, -20693, -20655, -20649, -20640, -20656, -20519, -21066, -24341, -24663, -24566, -24576, -24564, -24564, -24489, -24769, -26407, -26544, -26490, -26488, -26473, -26458, -26444, -26431, -26416, -26403, -26389, -26373, -26361, -26343, -26350, -26235, -25817, -25781, -25774, -25758, -25743, -25719, -25749, -25522, -24697, -24657, -24651, -24634, -24621, -24582, -24681, -24098, -22099, -22023, -22036, -22013, -21998, -21906, -22307, -20241, -13972, -13875, -13910, -13878, -13868, -13785, -14151, -12207, -6746, -6794, -6794, -6773, -6764, -6698, -7010, -5172};