/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0055 256 samples */
 
const int16_t AKWF_oscchip_0055_256_DATA [256] = 
{2147, 1634, 1768, 1750, 1763, 1772, 1779, 1784, 1791, 1797, 1803, 1805, 1813, 1816, 1816, 1822, 1825, 1826, 1826, 1828, 1833, 1833, 1835, 1835, 1835, 1835, 1835, 1835, 1835, 1840, 1809, 2049, 2365, 2337, 2343, 2343, 2340, 2344, 2314, 2495, 2859, 2849, 2846, 2847, 2845, 2844, 2845, 2844, 2842, 2843, 2839, 2837, 2837, 2841, 2811, 3081, 3367, 3332, 3338, 3337, 3336, 3323, 3353, 3146, 2808, 2825, 2822, 2821, 2819, 2819, 2790, 2942, 3316, 3316, 3312, 3312, 3313, 3305, 3327, 3026, 2770, 2805, 2797, 2796, 2794, 2783, 2813, 2569, 2254, 2281, 2275, 2275, 2273, 2273, 2271, 2267, 2265, 2264, 2265, 2263, 2257, 2530, 1187, 8339, 30333, 31342, 30971, 31077, 31071, 31065, 31056, 31048, 31038, 31028, 31019, 31009, 30997, 30985, 30973, 30961, 30949, 30936, 30924, 30911, 30899, 30862, 30958, 30319, 28814, 28802, 28796, 28779, 28764, 28761, 28673, 29579, 30310, 30188, 30194, 30179, 30163, 30145, 30161, 29893, 29574, 29590, 29571, 29555, 29541, 29526, 29510, 29496, 29481, 29465, 29452, 29437, 29420, 29406, 29392, 29377, 29362, 29347, 29331, 29318, 29302, 29297, 29225, 29777, 30309, 30226, 30224, 30209, 30193, 29493, 33246, 6103, -33023, -30096, -30548, -30584, -30592, -30594, -30595, -30594, -30593, -30591, -30584, -30581, -30576, -30569, -30562, -30553, -30544, -30535, -30523, -30514, -30504, -30492, -30479, -30470, -30456, -30443, -30431, -30418, -30406, -30392, -30379, -30366, -30351, -30339, -30322, -30310, -30296, -30280, -30267, -30253, -30238, -30222, -30208, -30194, -30178, -30164, -30149, -30134, -30119, -30106, -30089, -30074, -30060, -30044, -30029, -30015, -29999, -29984, -29970, -29954, -29938, -29924, -29908, -29895, -29879, -29863, -29848, -29833, -29818, -29804, -29789, -29773, -29758, -29742, -29726, -29713, -29690, -29386, -31030, -15314};