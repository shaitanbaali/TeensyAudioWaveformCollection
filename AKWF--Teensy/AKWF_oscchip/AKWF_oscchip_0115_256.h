/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0115 256 samples */
 
const int16_t AKWF_oscchip_0115_256_DATA [256] = 
{5231, 6383, 6136, 6184, 6190, 6298, 5880, 7401, 28806, 32681, 31774, 31956, 31956, 31954, 31951, 31948, 31944, 31939, 31935, 31930, 31926, 31919, 31914, 31908, 31901, 31895, 31888, 31881, 31874, 31869, 31854, 31879, 32272, 32346, 32321, 32316, 32308, 32300, 32292, 32284, 32276, 32267, 32259, 32251, 32243, 32148, 32558, 30654, 18018, 16557, 16921, 16833, 16827, 16820, 16814, 16807, 16800, 16795, 16789, 16783, 16777, 16772, 16767, 16760, 16756, 16751, 16745, 16740, 16735, 16730, 16726, 16721, 16716, 16711, 16705, 16700, 16695, 16691, 16686, 16681, 16677, 16672, 16667, 16663, 16660, 16649, 16643, 16702, 14008, 12998, 13203, 13157, 13152, 13136, 13189, 12951, 11307, 11117, 11162, 11148, 11144, 11135, 11149, 11091, 9870, 9593, 9650, 9635, 9631, 9627, 9623, 9637, 8867, 8580, 8635, 8621, 8619, 8446, 9218, 5861, -19266, -22732, -21937, -22103, -22104, -22093, -22124, -22009, -19624, -19020, -19143, -19115, -19112, -19099, -19091, -19177, -14684, -12864, -13212, -13143, -13140, -13122, -13182, -12910, -10448, -10077, -10167, -10146, -10143, -10128, -10155, -10066, -6868, -6008, -6196, -6156, -6154, -6128, -6244, -5713, -3262, -3145, -3183, -3169, -3168, -3146, -3234, -2870, 438, 894, 781, 808, 809, 815, 800, 839, 2849, 3380, 3263, 3287, 3288, 3067, 4173, -785, -23841, -25211, -24846, -24937, -24938, -24935, -24933, -24930, -24925, -24922, -24918, -24913, -24908, -24904, -24899, -24894, -24888, -24883, -24878, -24872, -24866, -24860, -24855, -24849, -24843, -24836, -24830, -24824, -24818, -24811, -24805, -24799, -24793, -24786, -24780, -24773, -24767, -24761, -24754, -24748, -24741, -24735, -24728, -24722, -24715, -24709, -24702, -24696, -24689, -24683, -24676, -24669, -24663, -24656, -24650, -24643, -24637, -24630, -24624, -24616, -24610, -24603, -24596, -24590, -24583, -24578, -24571, -24565, -24558, -24420, -25119, -21783};