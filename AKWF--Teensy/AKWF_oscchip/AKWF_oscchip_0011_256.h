/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0011 256 samples */
 
const int16_t AKWF_oscchip_0011_256_DATA [256] = 
{16232, 30510, 28407, 28795, 28788, 28781, 28769, 28793, 28458, 28207, 28237, 28221, 28209, 28196, 28168, 28264, 26919, 25981, 26122, 26080, 26067, 26054, 26031, 26068, 25363, 24920, 24977, 24950, 24936, 24920, 24884, 25015, 22856, 21623, 21829, 21774, 21760, 21742, 21714, 21820, 19657, 18454, 18662, 18606, 18596, 18582, 18567, 18588, 17837, 17460, 17517, 17494, 17482, 17467, 17449, 17518, 15228, 14210, 14391, 14344, 14335, 14322, 14313, 14327, 13165, 12678, 12767, 12740, 12730, 12722, 12713, 12706, 12698, 12690, 12681, 12674, 12667, 12655, 12651, 12641, 11445, 11031, 11104, 11082, 11074, 11063, 11065, 11040, 9827, 9443, 9519, 9495, 9489, 9479, 9482, 9448, 8632, 8397, 8444, 8426, 8420, 8412, 8419, 8373, 7552, 7335, 7375, 7359, 7355, 7349, 7333, 7396, 6805, 6244, 6322, 6300, 6297, 6276, 5872, 8289, -14576, -34325, -31493, -32012, -32001, -31994, -31944, -32198, -29627, -27638, -27928, -27861, -27851, -27840, -27811, -27895, -26904, -26164, -26272, -26234, -26221, -26208, -26195, -26181, -26166, -26153, -26139, -26125, -26112, -26095, -26079, -26089, -25728, -25499, -25521, -25502, -25486, -25468, -25437, -25544, -23743, -22715, -22883, -22835, -22820, -22804, -22777, -22858, -21031, -20051, -20218, -20171, -20158, -20140, -20116, -20215, -17624, -16333, -16556, -16501, -16489, -16473, -16451, -16546, -13496, -12144, -12391, -12331, -12324, -12305, -12295, -12343, -9645, -8523, -8742, -8690, -8683, -8670, -8671, -8671, -6711, -5979, -6120, -6086, -6080, -6075, -6070, -6064, -6060, -6055, -6049, -6047, -6041, -6036, -6034, -6024, -5617, -5487, -5510, -5501, -5497, -5493, -5478, -5543, -4988, -4400, -4468, -4452, -4447, -4445, -4430, -4499, -3915, -3351, -3423, -3405, -3405, -3402, -3391, -3426, -3128, -2848, -2887, -2876, -2875, -2872, -2859, -2923, -2311, -1781, -1857, -1841, -1838, -1850, -1774, -2098};