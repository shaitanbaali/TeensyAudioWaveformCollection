/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0155 256 samples */
 
const int16_t AKWF_oscchip_0155_256_DATA [256] = 
{22713, 25121, 24548, 24651, 24655, 24638, 24715, 24373, 21988, 21628, 21715, 21695, 21695, 21684, 21723, 21576, 19234, 18629, 18761, 18735, 18735, 18723, 18739, 18743, 15034, 13570, 13859, 13803, 13806, 13750, 14026, 12674, 7180, 6822, 6929, 6901, 6901, 6875, 6990, 6476, 2899, 2362, 2492, 2463, 2463, 2463, 2463, 2463, 2463, 2463, 2463, 2463, 2463, 2447, 2468, 2472, -2346, -4250, -3876, -3949, -3947, -3979, -3822, -4594, -7733, -7937, -7878, -7894, -7894, -7920, -7805, -8319, -11895, -12433, -12301, -12327, -12327, -12333, -12313, -12388, -13559, -13862, -13795, -13806, -13807, -13817, -13803, -13800, -17138, -18457, -18198, -18248, -18248, -18180, -18515, -16873, -10203, -9771, -9900, -9865, -9865, -9842, -9944, -9487, -6305, -5827, -5944, -5920, -5920, -5905, -5957, -5760, -2640, -1835, -2010, -1974, -1975, -1965, -1978, -1980, 987, 2157, 1926, 1971, 1971, 2019, 1783, 2941, 7649, 7955, 7863, 7889, 7889, 7911, 7809, 8266, 11446, 11923, 11806, 11831, 11831, 11845, 11793, 11991, 15113, 15918, 15743, 15778, 15778, 15785, 15776, 15774, 17996, 18874, 18701, 18736, 18735, 18759, 18640, 19221, 21576, 21731, 21685, 21695, 21695, 21729, 21576, 22262, 27032, 27750, 27574, 27612, 27612, 27616, 27603, 27652, 28434, 28636, 28591, 28599, 28599, 28591, 28602, 28605, 26010, 24984, 25186, 25148, 25148, 25124, 25243, 24663, 22309, 22157, 22202, 22189, 22189, 22150, 22329, 21529, 15961, 15123, 15329, 15285, 15284, 15273, 15312, 15164, 12823, 12219, 12350, 12324, 12324, 12317, 12326, 12328, 10104, 9227, 9401, 9366, 9367, 9327, 9524, 8558, 4635, 4381, 4456, 4438, 4438, 4424, 4488, 4201, 2212, 1913, 1986, 1970, 1972, 1968, 1981, 1932, 1151, 949, 993, 983, 984, 905, 1009, 1032, -23436, -33102, -31201, -31568, -31562, -31237, -32985, -23608};