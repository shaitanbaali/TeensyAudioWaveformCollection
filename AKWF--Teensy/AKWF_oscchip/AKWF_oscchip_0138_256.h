/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0138 256 samples */
 
const int16_t AKWF_oscchip_0138_256_DATA [256] = 
{430, 493, 477, 479, 480, 482, 470, 526, 915, 973, 957, 959, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 960, 962, 950, 1006, 1395, 1452, 1437, 1439, 1440, 1441, 1435, 1459, 1841, 1939, 1916, 1920, 1920, 1934, 1858, 2271, 3368, 3366, 3359, 3360, 3361, 3364, 3345, 3440, 3823, 3848, 3843, 3846, 3846, 3876, 3739, 4350, 8615, 9255, 9101, 9133, 9133, 9184, 8999, 9698, 20730, 23576, 22956, 23078, 23078, 22532, 25392, 9939, -30957, -30829, -30656, -30770, -30771, -30772, -30771, -30771, -30771, -30771, -30771, -30771, -30771, -30739, -30888, -30221, -25569, -24869, -25039, -25005, -25005, -24960, -25120, -24517, -15006, -12554, -13087, -12980, -12979, -12921, -13227, -11573, -7195, -7210, -7228, -7218, -7217, -7190, -7325, -6663, -3984, -3812, -3861, -3847, -3847, -3841, -3866, -3755, -2981, -2864, -2892, -2887, -2886, -2879, -2905, -2808, -1288, -896, -981, -966, -965, -961, -986, -847, -481, -484, -487, -486, -485, -482, -501, -406, -19, 5, -3, -1, 0, 2, -10, 46, 435, 490, 476, 480, 480, 480, 480, 480, 480, 480, 480, 480, 480, 465, 541, 128, -970, -967, -963, -965, -965, -965, -965, -965, -965, -965, -965, -965, -965, -968, -956, -1012, -1399, -1457, -1442, -1445, -1445, -1442, -1455, -1407, -647, -450, -494, -486, -485, -481, -506, -367, 2, 0, -2, -1, 0, -12, 45, -237, -1387, -1461, -1440, -1445, -1445, -1437, -1475, -1308, -142, 33, -9, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -10, 41, -237, -969, -968, -963, -965, -965, -957, -1002, -762};