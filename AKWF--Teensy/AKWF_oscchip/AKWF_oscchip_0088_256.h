/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0088 256 samples */
 
const int16_t AKWF_oscchip_0088_256_DATA [256] = 
{49, 23, 26, 26, 25, 40, -32, 314, 1774, 1839, 1817, 1824, 1823, 1841, 1746, 2282, 3235, 3154, 3167, 3168, 3168, 3177, 3126, 3380, 4077, 4059, 4058, 4060, 4058, 4068, 4014, 4260, 5362, 5410, 5393, 5398, 5397, 5425, 5264, 6154, 7736, 7607, 7627, 7625, 7624, 7633, 7578, 7837, 8534, 8515, 8515, 8514, 8512, 8514, 8494, 8574, 8936, 8954, 8947, 8946, 8943, 8974, 8796, 9831, 11725, 11600, 11615, 11615, 11612, 11619, 11569, 11812, 12505, 12496, 12492, 12492, 12489, 12499, 12429, 12739, 14195, 14289, 14261, 14264, 14261, 14268, 14207, 14527, 15175, 15132, 15134, 15132, 15128, 15184, 14861, 16464, 21412, 21395, 21365, 21378, 21383, 20621, 24700, -381, -34805, -30836, -31556, -31554, -31556, -31470, -31925, -29489, -24537, -24878, -24820, -24814, -24811, -24738, -25085, -23401, -18040, -18057, -18069, -18053, -18047, -17970, -18364, -15806, -12352, -12711, -12639, -12635, -12633, -12575, -12864, -11227, -7974, -8160, -8126, -8117, -8115, -8077, -8256, -7357, -4519, -4510, -4517, -4509, -4506, -4485, -4573, -4175, -1970, -1770, -1818, -1806, -1804, -1787, -1867, -1407, -416, -459, -453, -450, -450, -445, -464, -358, -4, 3, -1, 1, 2, 3, 2, 3, 2, 4, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 6, 5, 5, 6, 6, 6, 6, -1, 32, -166, -466, -436, -440, -441, -440, -440, -440, -440, -440, -440, -440, -440, -440, -449, -406, -603, -1329, -1338, -1332, -1333, -1334, -1333, -1333, -1334, -1333, -1331, -1332, -1332, -1331, -1336, -1310, -1454, -1789, -1779, -1781, -1782, -1780, -1783, -1764, -1857, -2216, -2227, -2224, -2226, -2225, -2240, -2148, -2696, -3627, -3553, -3563, -3563, -3562, -3531, -3692, -2768};