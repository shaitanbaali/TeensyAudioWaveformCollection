/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0060 256 samples */
 
const int16_t AKWF_oscchip_0060_256_DATA [256] = 
{867, 2226, 2065, 2096, 2095, 2096, 2121, 1986, 2962, 4361, 4253, 4268, 4270, 4268, 4283, 4208, 4631, 5580, 5567, 5559, 5562, 5561, 5566, 5527, 6058, 6469, 6409, 6418, 6417, 6412, 6418, 6365, 6806, 7314, 7258, 7265, 7263, 7257, 7260, 7233, 7401, 7694, 7676, 7674, 7670, 7668, 7673, 7625, 7860, 8511, 8524, 8513, 8511, 8519, 8721, 7448, 20871, 33296, 31656, 31955, 31940, 31929, 31760, 32628, 26059, 16945, 17661, 17537, 17521, 17514, 17421, 17828, 15303, 9994, 10080, 10084, 10062, 10053, 9997, 10220, 9038, 4997, 4741, 4817, 4787, 4781, 4736, 4964, 2914, 642, 892, 841, 839, 837, 788, 1018, -559, -3204, -3064, -3081, -3088, -3089, -3111, -3000, -3628, -5250, -5274, -5258, -5265, -5265, -5268, -5245, -5497, -5720, -5687, -5691, -5688, -5687, -5686, -5685, -5684, -5679, -5677, -5676, -5675, -5674, -5672, -5646, -5798, -6102, -6094, -6089, -6089, -6088, -6083, -6081, -6080, -6075, -6071, -6070, -6068, -6064, -6066, -6039, -6266, -6510, -6478, -6481, -6476, -6474, -6478, -6446, -6625, -6913, -6891, -6888, -6888, -6884, -6880, -6879, -6876, -6870, -6868, -6864, -6860, -6859, -6858, -6833, -7090, -7301, -7270, -7272, -7267, -7263, -7262, -7256, -7254, -7251, -7245, -7243, -7240, -7235, -7228, -7250, -7083, -6777, -6785, -6781, -6777, -6772, -6771, -6767, -6762, -6761, -6755, -6751, -6750, -6744, -6734, -6781, -6296, -5816, -5872, -5857, -5854, -5850, -5841, -5867, -5673, -5386, -5402, -5396, -5393, -5391, -5387, -5383, -5382, -5377, -5373, -5373, -5369, -5365, -5357, -5390, -5211, -4531, -4471, -4485, -4478, -4477, -4459, -4533, -3880, -3094, -3168, -3153, -3151, -3150, -3144, -3164, -2997, -2695, -2706, -2703, -2700, -2700, -2677, -2784, -2207, -553, -504, -523, -519, -515, -508, -530};