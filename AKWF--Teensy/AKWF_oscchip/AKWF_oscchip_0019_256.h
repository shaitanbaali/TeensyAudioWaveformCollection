/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0019 256 samples */
 
const int16_t AKWF_oscchip_0019_256_DATA [256] = 
{1314, 1871, 1758, 1783, 1784, 1794, 1760, 1913, 3127, 3299, 3257, 3267, 3267, 3284, 3203, 3574, 5980, 6286, 6205, 6221, 6219, 6221, 6203, 6273, 6669, 6709, 6696, 6696, 6695, 6712, 6605, 7067, 9489, 9668, 9615, 9623, 9620, 9627, 9569, 9822, 11013, 11095, 11065, 11066, 11060, 11230, 10329, 14640, 31508, 32424, 32119, 32190, 32179, 32156, 32210, 31876, 30681, 30634, 30630, 30613, 30599, 30543, 30734, 29691, 26146, 26075, 26089, 26063, 26048, 25990, 26197, 25030, 21578, 21522, 21536, 21511, 21497, 21463, 21561, 20979, 19461, 19461, 19453, 19437, 19425, 19394, 19424, 19293, 14600, 13211, 13501, 13431, 13421, 13398, 13429, 13289, 10533, 9795, 9949, 9907, 9899, 9880, 9912, 9770, 7386, 6809, 6924, 6895, 6889, 6882, 6883, 6848, 6444, 6354, 6368, 6359, 6354, 6337, 6381, 6186, 4185, 3798, 3883, 3861, 3858, 3852, 3860, 3811, 3402, 3334, 3346, 3341, 3335, 3305, 3432, 2877, -1570, -2209, -2057, -2091, -2091, -2117, -1997, -2555, -6157, -6619, -6501, -6526, -6524, -6558, -6394, -7100, -11109, -11523, -11413, -11435, -11431, -11456, -11313, -11928, -15155, -15397, -15326, -15336, -15331, -15346, -15232, -15741, -18129, -18291, -18233, -18238, -18231, -18239, -18147, -18540, -20100, -20174, -20140, -20138, -20127, -20123, -20090, -20190, -20571, -20572, -20557, -20548, -20537, -20536, -20479, -20696, -21469, -21471, -21453, -21444, -21432, -21417, -21431, -21290, -20896, -20881, -20872, -20859, -20848, -20834, -20826, -20809, -20413, -20276, -20289, -20274, -20262, -20247, -20243, -20209, -19417, -19178, -19217, -19195, -19185, -19156, -19198, -19020, -15476, -14526, -14726, -14673, -14663, -14641, -14678, -14503, -11700, -11057, -11189, -11151, -11142, -11119, -11169, -10931, -7726, -7038, -7187, -7149, -7143, -7118, -7190, -6862, -3675, -3060, -3202, -3167, -3163, -3144, -3217, -2864};