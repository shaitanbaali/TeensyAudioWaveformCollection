/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0028 256 samples */
 
const int16_t AKWF_oscchip_0028_256_DATA [256] = 
{18470, 24023, 22860, 23074, 23078, 23081, 23083, 23083, 23083, 23083, 23082, 23080, 23078, 23074, 23083, 23024, 22656, 22603, 22611, 22605, 22600, 22596, 22592, 22587, 22583, 22577, 22573, 22568, 22562, 22551, 22577, 22430, 21684, 21623, 21632, 21623, 21617, 21586, 21711, 21072, 18133, 17933, 17987, 17967, 17962, 17945, 17998, 17716, 16632, 16566, 16582, 16573, 16567, 16555, 16592, 16383, 15659, 15636, 15636, 15628, 15624, 15614, 15613, 15633, 13568, 12757, 12920, 12882, 12878, 12869, 12877, 12863, 10767, 10031, 10179, 10146, 10143, 10134, 10140, 10121, 8701, 8245, 8335, 8316, 8313, 8307, 8312, 8288, 7569, 7356, 7400, 7389, 7386, 7381, 7389, 7352, 6629, 6437, 6476, 6463, 6461, 6453, 6475, 6388, 4922, 4591, 4661, 4644, 4642, 4630, 4668, 4509, 2312, 1842, 1948, 1926, 1925, 1910, 1964, 1740, -450, -870, -772, -790, -791, -798, -776, -866, -1603, -1719, -1693, -1699, -1700, -1704, -1683, -1777, -2521, -2619, -2597, -2602, -2603, -2607, -2581, -2694, -3425, -3520, -3496, -3500, -3498, -3511, -3449, -3722, -5183, -5330, -5294, -5302, -5301, -5306, -5274, -5421, -6156, -6209, -6191, -6194, -6194, -6199, -6165, -6321, -7053, -7101, -7084, -7085, -7084, -7094, -7033, -7308, -8388, -8442, -8422, -8425, -8422, -8423, -8422, -8402, -9080, -9361, -9303, -9310, -9308, -9312, -9305, -9288, -11345, -12145, -11976, -12007, -12004, -12003, -11997, -11997, -12692, -12933, -12880, -12886, -12884, -12889, -12868, -12899, -15751, -16624, -16438, -16468, -16465, -16469, -16444, -16505, -18641, -19268, -19128, -19153, -19149, -19157, -19107, -19257, -22115, -22865, -22694, -22723, -22718, -22726, -22672, -22839, -25765, -26423, -26269, -26291, -26286, -26290, -26244, -26397, -28601, -29047, -28936, -28952, -28945, -28951, -28890, -29104, -31286, -31696, -31592, -31605, -31597, -31419, -32323, -28036};