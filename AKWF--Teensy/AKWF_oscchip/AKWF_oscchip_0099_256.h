/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0099 256 samples */
 
const int16_t AKWF_oscchip_0099_256_DATA [256] = 
{6558, 11520, 10539, 10724, 10724, 10722, 10678, 10949, 7172, 5004, 5403, 5329, 5330, 5372, 5219, 5732, 16359, 18725, 18175, 18282, 18279, 18252, 18250, 18464, 8360, 4673, 5455, 5300, 5300, 5317, 5499, 4307, 20027, 28776, 27108, 27420, 27412, 27412, 27393, 27430, 28306, 28505, 28456, 28458, 28453, 28409, 28407, 28743, 12108, 5818, 7053, 6818, 6814, 6828, 6987, 5865, 20981, 29624, 28095, 28379, 28372, 28364, 28364, 28338, 27897, 27784, 27802, 27793, 27786, 27778, 27771, 27775, 27362, 27184, 27209, 27196, 27188, 27181, 27165, 27213, 26477, 26013, 26084, 26063, 26055, 26044, 26050, 26002, 24687, 24335, 24405, 24383, 24376, 24368, 24358, 24381, 23558, 23206, 23271, 23251, 23245, 23236, 23197, 23383, 21170, 19770, 20016, 19964, 19958, 19949, 19950, 19925, 19045, 18805, 18851, 18834, 18829, 18814, 18788, 18987, 14068, 11983, 12398, 12313, 12310, 12271, 12422, 11797, 5981, 5114, 5309, 5263, 5259, 5234, 5290, 5135, -948, -2589, -2245, -2312, -2314, -2316, -2321, -2290, -3093, -3453, -3388, -3402, -3402, -3447, -3256, -4062, -11987, -13366, -13053, -13112, -13112, -13122, -13096, -13151, -16574, -17602, -17382, -17420, -17416, -17417, -17429, -17319, -19697, -20811, -20595, -20630, -20625, -20639, -20563, -20839, -24401, -25049, -24888, -24914, -24908, -24906, -24897, -24893, -25744, -26006, -25941, -25946, -25940, -25938, -25951, -25806, -28185, -29337, -29101, -29141, -29134, -29131, -29106, -29167, -30054, -30204, -30161, -30161, -30154, -30150, -30134, -30127, -31830, -32365, -32244, -32258, -32250, -32243, -32238, -32206, -32592, -32777, -32733, -32732, -32723, -32702, -32746, -32535, -29877, -29353, -29459, -29428, -29420, -29402, -29408, -29393, -25998, -24878, -25092, -25042, -25035, -25023, -24989, -25158, -22082, -20442, -20723, -20661, -20653, -20606, -20748, -20169, -11403, -9483, -9907, -9817, -9811, -9804, -9811, -9680};