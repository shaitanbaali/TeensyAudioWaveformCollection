/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0106 256 samples */
 
const int16_t AKWF_oscchip_0106_256_DATA [256] = 
{8743, 10972, 10536, 10613, 10615, 10710, 10206, 12774, 21465, 21640, 21559, 21590, 21588, 21612, 21470, 22111, 25852, 26222, 26122, 26139, 26133, 26129, 26124, 26118, 26113, 26107, 26102, 26096, 26090, 25971, 26552, 23754, 13352, 13184, 13277, 13234, 13228, 13201, 13301, 12844, 9795, 9475, 9558, 9532, 9528, 9492, 9609, 9174, 1635, 56, 431, 357, 355, 306, 543, -558, -4646, -4705, -4679, -4693, -4693, -4680, -4750, -4464, -2551, -2366, -2415, -2405, -2404, -2393, -2435, -2288, 335, 899, 775, 800, 801, 808, 768, 967, 1695, 1719, 1711, 1714, 1713, 1810, 1356, 3330, 16874, 18485, 18108, 18183, 18182, 18182, 18174, 18192, 18561, 18643, 18623, 18624, 18620, 18724, 18165, 20865, 32155, 32680, 32499, 32545, 32538, 32378, 33099, 29871, 4805, 1408, 2245, 2064, 2062, 2027, 2181, 1391, -754, -692, -699, -704, -706, -746, -560, -1407, -5183, -5329, -5277, -5293, -5295, -5318, -5211, -5644, -9458, -9974, -9842, -9868, -9868, -9847, -9952, -9411, -7998, -8034, -8028, -8025, -8022, -8021, -8020, -8018, -8016, -8014, -8012, -8011, -8009, -8090, -7712, -9219, -22142, -23880, -23469, -23551, -23551, -23556, -23504, -23752, -24452, -24444, -24436, -24433, -24428, -24305, -24908, -21972, -8646, -7751, -7981, -7917, -7912, -7977, -7675, -8950, -20164, -21950, -21533, -21612, -21608, -21560, -21788, -20617, -16991, -17004, -17018, -17002, -16996, -16931, -17237, -15799, -8258, -7695, -7857, -7811, -7808, -7825, -7737, -8075, -11850, -12494, -12334, -12362, -12358, -12326, -12472, -11751, -9575, -9601, -9600, -9592, -9589, -9566, -9661, -9236, -6946, -6794, -6836, -6823, -6820, -6806, -6854, -6658, -4365, -3991, -4080, -4059, -4057, -4023, -4208, -3269, -390, -382, -392, -384, -382, -433, -174, -1338, -7318, -7787, -7670, -7696, -7696, -7661, -7837, -6986};