/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0061 256 samples */
 
const int16_t AKWF_oscchip_0061_256_DATA [256] = 
{9546, 10590, 10334, 10391, 10394, 10448, 10222, 11298, 17864, 18976, 18704, 18763, 18759, 18780, 18699, 18982, 23552, 24949, 24650, 24704, 24695, 24720, 24555, 25411, 27642, 27655, 27627, 27625, 27615, 27622, 27525, 27942, 29797, 29990, 29922, 29922, 29911, 29909, 29857, 30004, 31391, 31693, 31606, 31609, 31594, 31594, 31511, 31917, 32752, 32713, 32699, 32687, 32669, 32654, 32640, 32625, 32609, 32592, 32578, 32562, 32544, 32529, 32514, 32497, 32480, 32465, 32450, 32433, 32417, 32400, 32383, 32368, 32352, 32336, 32318, 32304, 32288, 32264, 32282, 32085, 31625, 31610, 31595, 31577, 31558, 31524, 31603, 31126, 29237, 29055, 29087, 29061, 29044, 29008, 29076, 28717, 25883, 25269, 25397, 25351, 25339, 25216, 25764, 22212, 15519, 15739, 15716, 15689, 15676, 15603, 15903, 14247, 9203, 8996, 9065, 9033, 9023, 8938, 9280, 7678, -834, -1999, -1702, -1777, -1783, -1809, -1725, -2057, -6219, -7375, -7120, -7174, -7172, -7242, -6883, -8971, -13772, -13754, -13727, -13741, -13738, -13779, -13555, -14641, -18839, -19171, -19064, -19085, -19079, -19101, -18973, -19484, -23249, -23958, -23775, -23808, -23798, -23801, -23757, -23854, -26556, -27498, -27287, -27316, -27305, -27307, -27236, -27541, -28433, -28450, -28427, -28418, -28404, -28400, -28348, -28528, -29452, -29559, -29514, -29508, -29493, -29481, -29466, -29452, -29439, -29424, -29410, -29394, -29379, -29364, -29352, -29337, -29323, -29308, -29294, -29281, -29266, -29250, -29235, -29220, -29207, -29192, -29177, -29163, -29147, -29133, -29118, -29104, -29090, -29075, -29060, -29045, -29029, -29015, -29001, -28987, -28972, -28957, -28942, -28927, -28912, -28892, -28908, -28728, -28263, -28240, -28230, -28212, -28199, -28170, -28217, -27898, -26480, -26301, -26333, -26306, -26292, -26252, -26345, -25884, -21684, -20665, -20878, -20819, -20806, -20764, -20817, -20672, -13591, -10748, -11288, -11167, -11163, -11001, -11775, -7411};