/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0016 256 samples */
 
const int16_t AKWF_oscchip_0016_256_DATA [256] = 
{608, 829, 785, 795, 797, 948, 228, 3478, 24879, 27235, 26619, 26753, 26748, 26742, 26736, 26728, 26719, 26710, 26701, 26690, 26681, 26669, 26658, 26646, 26634, 26622, 26610, 26595, 26582, 26571, 26556, 26541, 26527, 26514, 26501, 26485, 26473, 26457, 26443, 26430, 26415, 26400, 26387, 26372, 26357, 26340, 26326, 26312, 26297, 26284, 26267, 26253, 26239, 26225, 26209, 26193, 26181, 26163, 26150, 26135, 26119, 26106, 26090, 26074, 26060, 26046, 26032, 26017, 26002, 25986, 25970, 25955, 25942, 25926, 25912, 25897, 25881, 25869, 25853, 25839, 25824, 25809, 25793, 25778, 25763, 25749, 25734, 25721, 25705, 25690, 25676, 25661, 25646, 25381, 26301, 22849, -22683, -33008, -30723, -31187, -31189, -31189, -31209, -31116, -29987, -29765, -29807, -29791, -29782, -29762, -29802, -29573, -27305, -26895, -26978, -26947, -26935, -26901, -26977, -26585, -23597, -23103, -23207, -23169, -23155, -23106, -23251, -22575, -18055, -17469, -17594, -17551, -17540, -17528, -17515, -17501, -17492, -17482, -17470, -17459, -17448, -17426, -17475, -17189, -15682, -15523, -15556, -15535, -15524, -15512, -15520, -15430, -15050, -15012, -15009, -15000, -14991, -14980, -14970, -14975, -14633, -14461, -14483, -14467, -14459, -14451, -14443, -14435, -14424, -14416, -14409, -14400, -14392, -14382, -14374, -14379, -13673, -13388, -13433, -13415, -13407, -13398, -13391, -13388, -13025, -12887, -12906, -12892, -12884, -12873, -12873, -12851, -11782, -11406, -11475, -11454, -11447, -11435, -11439, -11402, -10312, -9978, -10040, -10021, -10013, -10006, -10007, -9977, -9231, -9027, -9063, -9049, -9042, -9034, -9033, -9008, -8637, -8538, -8551, -8543, -8538, -8527, -8538, -8478, -7736, -7563, -7596, -7583, -7578, -7564, -7594, -7457, -5952, -5667, -5724, -5710, -5704, -5693, -5722, -5572, -4067, -3796, -3855, -3840, -3838, -3823, -3866, -3674, -2176, -1934, -1991, -1974, -1972, -1961, -2014, -1752};