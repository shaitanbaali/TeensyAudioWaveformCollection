/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0123 256 samples */
 
const int16_t AKWF_oscchip_0123_256_DATA [256] = 
{522, 571, 560, 563, 564, 592, 461, 1048, 5134, 5748, 5598, 5630, 5630, 5636, 5613, 5699, 7035, 7381, 7305, 7321, 7321, 7332, 7272, 7596, 8455, 8453, 8448, 8450, 8450, 8459, 8414, 8635, 9531, 9590, 9573, 9577, 9576, 9579, 9564, 9630, 10086, 10154, 10137, 10141, 10141, 10143, 10135, 10164, 10609, 10723, 10700, 10706, 10706, 10712, 10682, 10842, 11269, 11268, 11266, 11267, 11267, 11271, 11249, 11359, 11807, 11835, 11829, 11832, 11832, 11835, 11821, 11885, 12339, 12407, 12389, 12393, 12393, 12395, 12387, 12416, 12863, 12976, 12952, 12958, 12958, 12969, 12910, 13232, 14088, 14084, 14081, 14084, 14084, 14088, 14066, 14175, 14623, 14653, 14643, 14645, 14645, 14648, 14633, 14700, 15155, 15224, 15206, 15210, 15210, 15197, 15242, 15073, 12399, 11708, 11859, 11832, 11832, 11878, 11638, 12931, 16355, 16345, 16330, 16339, 16339, 16344, 16321, 16432, 16881, 16911, 16902, 16904, 16904, 16631, 17871, 12323, -26300, -32105, -30686, -30991, -30992, -30988, -31003, -30947, -30055, -29826, -29876, -29866, -29866, -29821, -30060, -28767, -25346, -25357, -25371, -25362, -25361, -25316, -25541, -24437, -19952, -19661, -19747, -19725, -19725, -19705, -19793, -19401, -16677, -16267, -16367, -16347, -16347, -16342, -16357, -16300, -15405, -15175, -15224, -15213, -15214, -15202, -15262, -14940, -14084, -14087, -14090, -14087, -14088, -14060, -14195, -13534, -10846, -10672, -10724, -10710, -10710, -10684, -10801, -10278, -6641, -6095, -6228, -6199, -6199, -6186, -6231, -6062, -3389, -2701, -2851, -2820, -2821, -2843, -2724, -3370, -5082, -5076, -5068, -5072, -5073, -5059, -5126, -4796, -3451, -3364, -3390, -3385, -3384, -3378, -3407, -3277, -2368, -2231, -2264, -2259, -2258, -2254, -2269, -2213, -1322, -1091, -1141, -1130, -1129, -1124, -1154, -993, -566, -566, -569, -568, -567, -561, -596, -407};