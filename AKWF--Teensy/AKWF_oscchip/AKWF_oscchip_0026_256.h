/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0026 256 samples */
 
const int16_t AKWF_oscchip_0026_256_DATA [256] = 
{13551, 29634, 32943, 31071, 29804, 30821, 30810, 30554, 30675, 30676, 30647, 30658, 30655, 30648, 30644, 30639, 30634, 30629, 30623, 30617, 30611, 30606, 30599, 30592, 30585, 30578, 30577, 30478, 30671, 30889, 28689, 23434, 16477, 12513, 11958, 12614, 12728, 12562, 12921, 11139, 6265, -426, -4577, -5307, -4759, -4306, -4761, -6159, -8828, -11705, -12831, -12802, -12510, -12550, -12636, -12586, -12587, -12597, -12591, -12588, -12587, -12585, -12583, -12581, -12578, -12576, -12574, -12571, -12565, -12570, -12569, -12501, -12352, -12168, -12091, -11995, -11917, -12992, -11069, -1941, 13657, 27623, 32032, 31320, 29916, 30431, 30703, 30443, 30493, 30527, 30494, 30491, 30491, 30486, 30480, 30476, 30469, 30463, 30457, 30451, 30445, 30438, 30431, 30424, 30417, 30410, 30402, 30396, 30388, 30380, 30372, 30365, 30357, 30353, 30347, 30011, 30966, 31050, 22364, 3487, -19024, -30094, -30973, -28716, -28469, -29364, -29059, -28982, -29090, -29053, -29041, -29053, -29045, -29039, -29036, -29031, -29027, -29021, -29033, -28847, -29145, -29813, -25826, -15277, -620, 8512, 10135, 8907, 7989, 8911, 11341, 16027, 21117, 23111, 23063, 22548, 22608, 22780, 22687, 22530, 22235, 21878, 21752, 21590, 21667, 22933, 19550, 7457, -11858, -26973, -30918, -29461, -28603, -29580, -24571, -12726, 1416, 8725, 9500, 8084, 7650, 8666, 8947, 4304, -6643, -21062, -29238, -30278, -28776, -29251, -28706, -21294, -8017, 4525, 8996, 8498, 7406, 8491, 5177, -4965, -19214, -28544, -30330, -28934, -29004, -29149, -22787, -10169, 3160, 8803, 8887, 7464, 7378, 8492, 8126, 2349, -9522, -23324, -29717, -30054, -28644, -28594, -29105, -28898, -28862, -28921, -28892, -28884, -28886, -28876, -28869, -28864, -28857, -28851, -28845, -28838, -28832, -28825, -28818, -28811, -28804, -28796, -28789, -28782, -28775, -28768, -28760, -28753, -28745, -28735, -28760, -28504, -28799, -30120, -24832, -8711};