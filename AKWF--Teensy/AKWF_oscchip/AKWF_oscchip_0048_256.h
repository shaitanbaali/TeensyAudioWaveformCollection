/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0048 256 samples */
 
const int16_t AKWF_oscchip_0048_256_DATA [256] = 
{367, 463, 441, 448, 447, 451, 436, 503, 957, 1039, 1018, 1022, 1023, 1029, 993, 1220, 1616, 1594, 1594, 1594, 1594, 1606, 1548, 1862, 2725, 2749, 2736, 2739, 2740, 2748, 2707, 2898, 3798, 3908, 3877, 3882, 3883, 3884, 3872, 3913, 4360, 4468, 4441, 4444, 4443, 4455, 4389, 4774, 5600, 5580, 5576, 5577, 5576, 5580, 5551, 5675, 6120, 6144, 6133, 6135, 6130, 6133, 6100, 6241, 7143, 7293, 7250, 7257, 7256, 7258, 7235, 7286, 8168, 8437, 8375, 8384, 8382, 8382, 8347, 8512, 8935, 8938, 8931, 8930, 8922, 8928, 8884, 9083, 9975, 10072, 10040, 10041, 10038, 10038, 10019, 10065, 10509, 10609, 10582, 10580, 10573, 10582, 10507, 10906, 11725, 11695, 11691, 11688, 11680, 11683, 11649, 11780, 12217, 12233, 12221, 12216, 12211, 12211, 12174, 12319, 13220, 13356, 13316, 13319, 13311, 13309, 13291, 13317, 13754, 13878, 13840, 13842, 13832, 13840, 13771, 14108, 14953, 14952, 14938, 14935, 14927, 14931, 14878, 15092, 15988, 16063, 16034, 16031, 16021, 15750, 16808, 12404, -24600, -32598, -30710, -31110, -31107, -31066, -31266, -29999, -27579, -27654, -27646, -27630, -27625, -27573, -27780, -26610, -23102, -22944, -22991, -22964, -22955, -22912, -23047, -22365, -18727, -18208, -18328, -18289, -18279, -18244, -18326, -17978, -13519, -12269, -12536, -12468, -12460, -12433, -12520, -11972, -10702, -10693, -10698, -10682, -10678, -10646, -10756, -10160, -7923, -7728, -7774, -7757, -7752, -7734, -7775, -7583, -6223, -5953, -6013, -5996, -5988, -5983, -5986, -5959, -5520, -5370, -5396, -5387, -5385, -5368, -5420, -5116, -4244, -4210, -4219, -4215, -4209, -4201, -4220, -4125, -3670, -3612, -3622, -3617, -3617, -3605, -3621, -3540, -2646, -2416, -2462, -2448, -2448, -2435, -2497, -2120, -1282, -1294, -1291, -1289, -1289, -1276, -1334, -1002};