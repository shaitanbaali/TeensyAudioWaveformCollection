/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0141 256 samples */
 
const int16_t AKWF_oscchip_0141_256_DATA [256] = 
{2630, 2927, 2856, 2866, 2867, 2899, 2751, 3416, 8046, 8742, 8572, 8609, 8609, 8642, 8462, 9564, 11575, 11461, 11476, 11480, 11480, 11538, 11233, 12880, 17240, 17226, 17207, 17222, 17222, 17254, 17094, 17879, 21075, 21282, 21219, 21236, 21236, 21259, 21155, 21621, 24864, 25352, 25233, 25257, 25257, 25303, 25052, 26597, 29412, 29252, 29274, 29277, 29277, 29248, 29401, 28576, 26397, 26404, 26413, 26407, 26406, 26332, 26699, 24901, 17592, 17116, 17259, 17223, 17222, 17189, 17338, 16672, 12042, 11345, 11516, 11479, 11480, 11355, 12037, 7847, 206, 641, 582, 574, 573, 504, 870, -1107, -6341, -6323, -6301, -6319, -6320, -6398, -6008, -7919, -15680, -16184, -16034, -16073, -16072, -16099, -15980, -16512, -20217, -20775, -20639, -20667, -20667, -20667, -20667, -20667, -20667, -20667, -20667, -20667, -20667, -20621, -20865, -19548, -16060, -16070, -16084, -16073, -16072, -16031, -16237, -15226, -11117, -10851, -10931, -10912, -10911, -10879, -11027, -10363, -5732, -5035, -5207, -5167, -5166, -5134, -5313, -4212, -2203, -2318, -2302, -2299, -2300, -2288, -2349, -2021, -1149, -1150, -1155, -1153, -1152, -1185, -1024, -1810, -5005, -5213, -5151, -5166, -5167, -5216, -4992, -5992, -12936, -13980, -13724, -13779, -13779, -13819, -13603, -14928, -17341, -17205, -17222, -17225, -17226, -17266, -17053, -18205, -21257, -21247, -21233, -21242, -21242, -21266, -21151, -21712, -23995, -24143, -24098, -24110, -24110, -24153, -23960, -24824, -30845, -31750, -31528, -31577, -31576, -31590, -31518, -31960, -32765, -32720, -32726, -32726, -32726, -32715, -32776, -32445, -31572, -31574, -31579, -31577, -31576, -31539, -31723, -30823, -27171, -26934, -27004, -26985, -26985, -26939, -27147, -26216, -19735, -18759, -18998, -18947, -18946, -18894, -19181, -17417, -14199, -14382, -14357, -14351, -14352, -14247, -14795, -11832, -3986, -4012, -4044, -4021, -4020, -3981, -4195, -3046};