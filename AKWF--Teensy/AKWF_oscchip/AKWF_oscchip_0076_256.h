/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0076 256 samples */
 
const int16_t AKWF_oscchip_0076_256_DATA [256] = 
{26043, 31746, 30624, 30824, 30831, 30831, 30830, 30828, 30826, 30823, 30820, 30817, 30812, 30808, 30804, 30799, 30793, 30787, 30781, 30775, 30768, 30762, 30755, 30748, 30741, 30734, 30727, 30720, 30713, 30706, 30698, 30690, 30683, 30675, 30667, 30659, 30651, 30643, 30636, 30628, 30620, 30613, 30604, 30596, 30589, 30580, 30572, 30564, 30556, 30547, 30540, 30532, 30523, 30392, 30521, 30779, -13824, -28472, -25277, -25896, -25890, -25889, -25905, -25843, -25444, -25406, -25415, -25411, -25409, -25405, -25409, -25379, -24980, -24898, -24910, -24902, -24897, -24904, -24885, -24849, -29376, -30883, -30565, -30617, -30611, -30369, -31487, -26553, 4215, 7424, 6671, 6839, 6847, 6850, 6853, 6855, 6857, 6858, 6860, 6861, 6862, 6861, 6862, 6866, 6498, 6361, 6390, 6383, 6381, 6379, 6391, 6333, 5938, 5888, 5899, 5895, 5894, 5889, 5899, 5859, 5078, 4896, 4936, 4927, 4925, 4923, 4922, 4928, 4558, 4416, 4445, 4439, 4437, 4417, 4501, 4148, 1349, 1004, 1091, 1070, 1070, 1059, 1090, 995, -1359, -1914, -1787, -1813, -1814, -1815, -1816, -1795, -2537, -2819, -2761, -2773, -2772, -2786, -2722, -2979, -4975, -5213, -5154, -5165, -5166, -5170, -5154, -5199, -6362, -6649, -6587, -6597, -6596, -6598, -6597, -6567, -7663, -8099, -8013, -8027, -8026, -8032, -7997, -8138, -9317, -9488, -9444, -9451, -9449, -9448, -9441, -9454, -9837, -9936, -9910, -9912, -9910, -9911, -9891, -9970, -10361, -10384, -10374, -10374, -10371, -10372, -10350, -10430, -11218, -11340, -11308, -11312, -11309, -11308, -11303, -11307, -11689, -11794, -11766, -11768, -11765, -11773, -11716, -11951, -13142, -13203, -13179, -13181, -13179, -13181, -13158, -13229, -14025, -14148, -14114, -14117, -14113, -14124, -14085, -14151, -18779, -20079, -19791, -19842, -19839, -19848, -19771, -20096, -21661, -21758, -21725, -21728, -21724, -21609, -22191, -19406};