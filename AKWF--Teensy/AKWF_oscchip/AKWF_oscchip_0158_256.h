/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0158 256 samples */
 
const int16_t AKWF_oscchip_0158_256_DATA [256] = 
{459, 501, 491, 494, 493, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 494, 499, 472, 615, 990, 988, 984, 986, 986, 1230, 16, 5966, 30139, 31705, 31239, 31363, 31366, 31316, 31595, 29567, 26948, 27211, 27167, 27165, 27165, 27075, 27570, 24532, 18995, 19312, 19268, 19259, 19259, 19119, 19853, 15886, 5385, 5417, 5461, 5432, 5432, 5404, 5542, 4864, 2113, 1935, 1988, 1974, 1975, 1951, 2082, 1129, -103, 22, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -6, 27, -213, -523, -492, -497, -498, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -497, -853, 1094, -10865, -32661, -31421, -31590, -31617, -31616, -31496, -32126, -28724, -19718, -19746, -19785, -19760, -19760, -19712, -19949, -18788, -14071, -13767, -13857, -13830, -13829, -13776, -14072, -11927, -9156, -9435, -9390, -9390, -9389, -9339, -9617, -7907, -4793, -4970, -4946, -4941, -4940, -4895, -5131, -3857, -482, -493, -508, -498, -497, -502, -482, -579, -972, -997, -989, -991, -991, -991, -991, -991, -991, -991, -991, -991, -991, -986, -1017, -827, -481, -501, -498, -497, -498, -497, -497, -497, -497, -497, -497, -497, -497, -492, -523, -357};