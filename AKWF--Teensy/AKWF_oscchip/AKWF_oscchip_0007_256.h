/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0007 256 samples */
 
const int16_t AKWF_oscchip_0007_256_DATA [256] = 
{4148, 4317, 4267, 4279, 4282, 4282, 4284, 4290, 4255, 4549, 4936, 4903, 4910, 4910, 4909, 4903, 4883, 5130, 4118, 2737, 28790, 31866, 31000, 31171, 31167, 31162, 31158, 31127, 31237, 30493, 29194, 29255, 29235, 29225, 29212, 29200, 29187, 29145, 29312, 27558, 25838, 26044, 25991, 25978, 25966, 25953, 25931, 25916, 25973, 23333, 21943, 22181, 22120, 22108, 22095, 22083, 22038, 22143, 21688, 16318, 14919, 15214, 15140, 15131, 15120, 15108, 15043, 15301, 13979, 8578, 8102, 8228, 8185, 8177, 8169, 8162, 8077, 8473, 6058, 1147, 1289, 1279, 1263, 1258, 1253, 1248, 1190, 1495, -1102, -4017, -3700, -3759, -3760, -3763, -3766, -3770, -3784, -3668, -6160, -7717, -7456, -7506, -7506, -7505, -7503, -7511, -7486, -7558, -8983, -9446, -9346, -9361, -9359, -9357, -9355, -9358, -9332, -9425, -9915, -9974, -9955, -9955, -9950, -9949, -9944, -9940, -9936, -9933, -9929, -9923, -9918, -9915, -9912, -9906, -9901, -9899, -9894, -9890, -9885, -9882, -9877, -9872, -9868, -9865, -9860, -9854, -9851, -9846, -9843, -9837, -9834, -9830, -9825, -9820, -9816, -9811, -9807, -9802, -9797, -9794, -9788, -9784, -9779, -9774, -9764, -9560, -10736, 920, 11993, 10568, 10822, 10822, 10823, 10822, 10782, 10770, 11171, -3730, -11515, -10105, -10383, -10378, -10379, -10374, -10370, -10369, -10368, -10366, -10365, -10363, -10362, -10356, -10351, -10349, -10348, -10346, -10339, -10332, -10331, -10329, -10325, -10317, -10315, -10313, -10308, -10301, -10299, -10296, -10289, -10284, -10282, -10277, -10270, -10268, -10266, -10258, -10253, -10251, -10246, -10239, -10237, -10233, -10224, -10222, -10219, -10211, -10206, -10204, -10198, -10191, -10190, -10185, -10177, -10174, -10172, -10164, -10160, -10157, -10152, -10146, -10143, -10138, -10132, -10129, -10124, -10117, -10114, -10111, -10105, -10098, -10095, -10091, -10087, -9957, -10611, -6622};