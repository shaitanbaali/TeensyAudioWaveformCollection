/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0093 256 samples */
 
const int16_t AKWF_oscchip_0093_256_DATA [256] = 
{21656, 30871, 29091, 29416, 29424, 29424, 29426, 29439, 28620, 28307, 28366, 28354, 28352, 28333, 28403, 28070, 25419, 25054, 25138, 25115, 25107, 25089, 25125, 24985, 21532, 20647, 20838, 20796, 20790, 20723, 21030, 19599, 13451, 13222, 13302, 13271, 13266, 13288, 13160, 13653, 18125, 18707, 18551, 18579, 18574, 18540, 18625, 18374, 9632, 7469, 7956, 7857, 7852, 8047, 7039, 11568, 31166, 32065, 31802, 31868, 31866, 31851, 31885, 31717, 30387, 30200, 30235, 30219, 30212, 30195, 30216, 30132, 27531, 26854, 26989, 26955, 26947, 26918, 27027, 26463, 23858, 23672, 23713, 23695, 23688, 23659, 23742, 23354, 19854, 19274, 19395, 19362, 19356, 19337, 19363, 19260, 15869, 14890, 15089, 15045, 15040, 15013, 15122, 14591, 11944, 11766, 11815, 11799, 11794, 11745, 11930, 11163, 2305, 788, 1157, 1082, 1079, 994, 1148, 903, -25482, -33474, -31732, -32066, -32061, -32027, -32180, -31496, -27950, -27717, -27778, -27756, -27751, -27732, -27789, -27543, -24875, -24439, -24537, -24510, -24503, -24487, -24501, -24478, -21034, -20020, -20232, -20183, -20177, -20149, -20254, -19753, -17126, -16904, -16951, -16934, -16928, -16888, -17022, -16465, -10345, -9226, -9468, -9414, -9409, -9393, -9419, -9352, -4722, -3276, -3564, -3505, -3502, -3486, -3547, -3252, -1499, -1318, -1364, -1354, -1352, -1355, -1338, -1399, -2266, -2446, -2404, -2410, -2410, -2438, -2285, -3004, -5591, -5622, -5597, -5606, -5604, -5630, -5500, -6056, -9616, -9949, -9853, -9874, -9872, -9888, -9819, -10058, -14464, -15376, -15156, -15198, -15195, -15232, -15024, -15972, -19417, -19471, -19440, -19447, -19443, -19463, -19344, -19824, -22928, -23225, -23144, -23157, -23152, -23167, -23084, -23356, -27741, -28627, -28418, -28454, -28449, -28469, -28323, -28996, -31555, -31644, -31608, -31610, -31603, -31599, -31576, -31635, -32063, -32109, -32088, -32083, -32076, -31989, -32401, -30282};