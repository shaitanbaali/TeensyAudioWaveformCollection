/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0119 256 samples */
 
const int16_t AKWF_oscchip_0119_256_DATA [256] = 
{19344, 31958, 29465, 29928, 29928, 29931, 29945, 29855, 31378, 32166, 32016, 32042, 32038, 32033, 32028, 32024, 32020, 32014, 32008, 32002, 31995, 31991, 31983, 31970, 32515, 32699, 32651, 32652, 32644, 32636, 32629, 32621, 32614, 32604, 32597, 32589, 32581, 32573, 32564, 32555, 32548, 32540, 32531, 32522, 32513, 32475, 32490, 32641, 20526, 16228, 17085, 16917, 16911, 16899, 16858, 17093, 13559, 11646, 11985, 11914, 11909, 11904, 11873, 12017, 10690, 9635, 9794, 9761, 9757, 9749, 9747, 9771, 7593, 6785, 6940, 6907, 6905, 6901, 6893, 6924, 6432, 6143, 6191, 6180, 6178, 6176, 6174, 6172, 6169, 6167, 6164, 6163, 6162, 6158, 6156, 6168, 5624, 5408, 5449, 5438, 5436, 5434, 5419, 5495, 4518, 3930, 4036, 4014, 4014, 4012, 4011, 4009, 4009, 4007, 4006, 4004, 4003, 4000, 3996, 4031, 2944, 2507, 2594, 2574, 2573, 2572, 2557, 2640, 1664, 1070, 1179, 1157, 1156, 1148, 1173, 1095, -1197, -1769, -1649, -1672, -1672, -1678, -1685, -1601, -4290, -5372, -5164, -5204, -5203, -5204, -5223, -5102, -6537, -7445, -7291, -7318, -7317, -7319, -7306, -7343, -8464, -8776, -8711, -8722, -8720, -8722, -8730, -8651, -10753, -11681, -11498, -11527, -11525, -11523, -11535, -11452, -12394, -13011, -12906, -12923, -12919, -12924, -12907, -12933, -15186, -15848, -15699, -15724, -15720, -15731, -15777, -15394, -23257, -26888, -26165, -26298, -26292, -26286, -26281, -26276, -26270, -26265, -26259, -26253, -26247, -26241, -26235, -26229, -26223, -26216, -26209, -26203, -26196, -26188, -26179, -26200, -25663, -25412, -25451, -25434, -25428, -25421, -25414, -25407, -25400, -25394, -25387, -25380, -25374, -25367, -25360, -25353, -25347, -25340, -25333, -25326, -25319, -25313, -25310, -25279, -25794, -26037, -25986, -25987, -25981, -25973, -25967, -25960, -25953, -25946, -25939, -25933, -25925, -25905, -25975, -25400};