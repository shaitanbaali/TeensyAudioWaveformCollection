/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0090 256 samples */
 
const int16_t AKWF_oscchip_0090_256_DATA [256] = 
{22, 19, 21, 20, 22, 23, 22, 23, 23, 23, 23, 23, 28, -2, 184, 503, 480, 484, 485, 485, 485, 485, 485, 485, 484, 485, 484, 483, 484, 484, 484, 484, 484, 484, 484, 483, 490, 456, 641, 966, 941, 945, 946, 944, 992, 734, 2031, 5652, 5561, 5560, 5568, 5567, 5567, 5565, 5565, 5564, 5563, 5561, 5560, 5558, 5582, 5449, 6186, 7493, 7385, 7401, 7401, 7398, 7412, 7330, 7731, 8804, 8772, 8772, 8772, 8772, 8876, 8282, 12258, 17085, 16523, 16623, 16622, 16618, 16727, 16122, 19581, 25962, 25547, 25606, 25610, 25606, 25350, 26695, 19721, 250, 383, 416, 366, 363, 360, 357, 355, 352, 350, 349, 347, 345, 349, 317, 488, 818, 797, 800, 799, 798, 775, 890, 303, -1520, -1521, -1509, -1516, -1518, -1518, -1517, -1517, -1517, -1517, -1517, -1517, -1517, -1517, -1517, -1518, -1517, -1515, -1516, -1515, -1516, -1522, -1486, -1757, -2008, -1969, -1975, -1976, -1976, -1968, -2003, -1785, -1486, -1517, -1511, -1510, -1509, -1622, -1005, -4327, -11090, -10688, -10752, -10756, -10761, -11028, -9495, -21603, -33309, -31728, -32015, -32012, -32005, -31743, -33147, -24169, -11548, -12783, -12561, -12548, -12544, -12419, -13063, -9446, -1608, -1935, -1895, -1877, -1874, -1871, -1869, -1867, -1865, -1862, -1860, -1859, -1857, -1837, -1936, -1321, -390, -479, -465, -464, -462, -479, -392, -850, -1888, -1838, -1842, -1842, -1841, -1835, -1870, -1617, -1347, -1384, -1375, -1376, -1376, -1356, -1459, -853, 87, -4, 13, 13, 15, 16, 15, 16, 16, 16, 16, 16, 15, 9, 46, -208, -475, -440, -448, -447, -447, -466, -365, -958, -1898, -1817, -1830, -1831, -1831, -1810, -1922, -1332, 57};