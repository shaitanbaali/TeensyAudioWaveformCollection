/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0139 256 samples */
 
const int16_t AKWF_oscchip_0139_256_DATA [256] = 
{28175, 30781, 30161, 30272, 30276, 30276, 30276, 30276, 30276, 30276, 30276, 30276, 30276, 29582, 33386, 10020, -32562, -30137, -30466, -30516, -30518, -30518, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30517, -30166, -32057, -21916};