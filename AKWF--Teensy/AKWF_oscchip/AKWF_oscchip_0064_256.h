/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0064 256 samples */
 
const int16_t AKWF_oscchip_0064_256_DATA [256] = 
{26567, 31504, 30339, 30568, 30570, 30412, 31043, 28412, 4544, -937, 313, 37, 39, 38, 36, 32, 29, 29, 27, 27, 26, 26, 24, 20, 19, 18, 17, 18, 18, 14, 29, -38, -422, -483, -468, -472, -472, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -471, -472, -470, -469, -470, -469, -469, -469, -469, -469, -469, -469, -469, -469, -469, -470, -468, -467, -468, -467, -465, -466, -465, -465, -465, -465, -465, -465, -465, -465, -465, -465, -465, -465, -465, -466, -464, -463, -464, -463, -463, -464, -462, -462, -460, -459, -460, -459, -459, -459, -460, -455, -475, -377, 3, 34, 25, 28, 28, 28, 28, 28, 28, 28, 28, 27, 28, 30, 29, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 29, 33, 16, 92, 479, 527, 513, 517, 517, 517, 517, 517, 517, 517, 517, 517, 517, 517, 517, 516, 515, 514, 515, 513, 512, 513, 512, 513, 512, 510, 511, 511, 511, 511, 511, 511, 510, 511, 510, 508, 509, 509, 509, 508, 507, 507, 507, 507, 507, 507, 507, 507, 507, 507, 507, 507, 506, 507, 506, 504, 505, 505, 505, 505, 504, 505, 503, 500, 501, 501, 501, 501, 501, 501, 501, 501, 501, 501, 501, 501, 500, 498, 496, 497, 497, 497, 497, 497, 497, 494, 506, 446, 63, -4, 11, 7, 8, 8, 8, 8, 8, 8, 8, 7, 10, -312, 1329, -7763, -31555, -31833, -31624, -31708, -31708, -31351, -33185, -23249};