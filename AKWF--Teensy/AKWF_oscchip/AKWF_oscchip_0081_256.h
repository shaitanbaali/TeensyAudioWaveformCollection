/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0081 256 samples */
 
const int16_t AKWF_oscchip_0081_256_DATA [256] = 
{766, 936, 894, 901, 903, 938, 804, 1297, 7891, 9109, 8825, 8882, 8881, 8883, 8880, 8872, 9922, 10259, 10192, 10204, 10202, 10337, 9684, 12551, 29944, 31767, 31331, 31418, 31414, 31415, 31390, 31462, 32536, 32759, 32702, 32706, 32699, 32655, 32694, 32695, 19335, 14658, 15575, 15398, 15390, 15399, 15319, 15645, 17823, 18060, 17996, 18004, 17999, 17993, 17987, 17983, 17978, 17972, 17967, 17962, 17957, 17952, 17947, 17942, 17937, 17932, 17928, 17922, 17918, 17934, 17824, 18268, 21584, 21951, 21842, 21858, 21853, 21847, 21842, 21837, 21831, 21826, 21820, 21815, 21809, 21776, 21752, 22100, 9724, 5059, 6035, 5844, 5842, 5831, 5865, 5710, 4604, 4468, 4499, 4489, 4486, 4478, 4492, 4437, 3356, 3105, 3153, 3140, 3137, 3132, 3132, 3168, 1130, 358, 505, 475, 475, 466, 497, 362, -724, -882, -844, -852, -854, -862, -836, -923, -3046, -3606, -3485, -3507, -3508, -3510, -3510, -3486, -4483, -4899, -4820, -4834, -4834, -4826, -4855, -4731, -3629, -3468, -3506, -3497, -3496, -3496, -3495, -3494, -3493, -3492, -3491, -3490, -3489, -3549, -3240, -4611, -11186, -11535, -11427, -11456, -11454, -11479, -11362, -11816, -16237, -16878, -16713, -16745, -16742, -16746, -16723, -16768, -18916, -19482, -19349, -19370, -19367, -19373, -19319, -19538, -20616, -20685, -20667, -20666, -20661, -20656, -20653, -20647, -20642, -20637, -20632, -20626, -20622, -20616, -20611, -20606, -20601, -20595, -20590, -20585, -20579, -20574, -20568, -20563, -20558, -20552, -20546, -20541, -20536, -20530, -20525, -20519, -20514, -20509, -20503, -20497, -20493, -20484, -20484, -20467, -19417, -19077, -19142, -19124, -19119, -19079, -19244, -18469, -14069, -13703, -13808, -13776, -13771, -13752, -13813, -13555, -10248, -9641, -9784, -9750, -9746, -9727, -9748, -9736, -4454, -2803, -3159, -3086, -3085, -3066, -3151, -2741};