/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0131 256 samples */
 
const int16_t AKWF_oscchip_0131_256_DATA [256] = 
{1938, 2110, 2071, 2078, 2079, 2118, 1918, 3364, 5231, 5044, 5074, 5075, 5075, 5109, 4921, 6073, 8171, 8051, 8067, 8069, 8068, 8106, 7894, 9037, 12067, 12056, 12043, 12049, 12047, 12052, 12010, 12203, 12995, 13045, 13026, 13028, 13025, 13039, 12938, 13657, 14588, 14491, 14504, 14501, 14497, 14500, 14465, 14655, 15004, 14980, 14978, 14975, 14972, 14973, 14943, 15082, 15459, 15453, 15446, 15444, 15441, 15571, 14899, 18171, 31473, 32332, 32072, 32134, 32128, 31935, 32976, 25374, 15563, 16542, 16370, 16359, 16355, 16343, 16370, 16172, 15818, 15832, 15824, 15819, 15814, 15789, 15891, 15311, 13787, 13789, 13790, 13782, 13777, 13744, 13880, 13192, 10407, 10224, 10274, 10256, 10252, 10193, 10489, 8315, 5510, 5789, 5738, 5734, 5731, 5666, 6007, 3896, 47, 264, 234, 227, 225, 198, 329, -387, -2286, -2281, -2274, -2279, -2281, -2286, -2266, -2363, -2760, -2786, -2779, -2779, -2780, -2791, -2725, -3207, -3829, -3765, -3777, -3778, -3776, -3780, -3749, -3940, -4288, -4269, -4269, -4268, -4269, -4289, -4180, -4752, -6267, -6261, -6255, -6258, -6256, -6268, -6205, -6499, -7692, -7768, -7743, -7748, -7746, -7763, -7661, -8383, -9314, -9218, -9232, -9231, -9229, -9238, -9173, -9555, -10252, -10211, -10214, -10212, -10209, -10343, -9625, -13491, -23726, -23691, -23645, -23670, -23667, -23650, -23706, -23409, -22212, -22132, -22149, -22137, -22132, -22115, -22177, -21689, -21062, -21119, -21103, -21098, -21093, -21063, -21184, -20410, -19003, -19079, -19062, -19054, -19049, -19008, -19188, -18180, -15524, -15527, -15533, -15520, -15515, -15486, -15601, -15010, -12620, -12461, -12502, -12485, -12480, -12465, -12526, -12041, -11415, -11474, -11460, -11455, -11452, -11385, -11725, -9611, -5760, -5977, -5944, -5935, -5933, -5889, -6099, -4951, -1916, -1924, -1936, -1925, -1923, -1898, -2022, -1353};