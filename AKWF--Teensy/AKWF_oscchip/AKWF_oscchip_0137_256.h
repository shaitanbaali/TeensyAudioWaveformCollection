/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0137 256 samples */
 
const int16_t AKWF_oscchip_0137_256_DATA [256] = 
{28802, 31179, 30616, 30718, 30721, 30634, 31028, 29256, 16932, 15076, 15526, 15427, 15424, 15420, 15416, 15414, 15411, 15407, 15404, 15401, 15397, 15382, 15430, 15153, 14421, 14419, 14419, 14412, 14408, 14401, 14416, 14319, 13935, 13907, 13910, 13905, 13901, 13921, 13807, 14301, 17764, 18281, 18150, 18173, 18169, 18110, 18404, 16564, 13215, 13401, 13371, 13364, 13359, 13341, 13413, 12998, 11906, 11906, 11907, 11900, 11897, 11877, 11949, 11573, 10050, 9949, 9974, 9962, 9959, 9995, 9818, 10591, 15978, 16785, 16584, 16622, 16620, 16775, 15904, 21222, 30920, 30362, 30432, 30438, 30433, 30433, 30401, 30532, 30889, 30882, 30873, 30868, 30861, 30852, 30845, 30839, 30832, 30823, 30817, 30809, 30801, 30636, 31345, 28129, 5786, 2422, 3237, 3054, 3049, 3041, 3049, 2996, 2237, 2038, 2077, 2066, 2064, 1789, 3208, -4467, -24778, -24716, -24629, -24687, -24687, -24643, -24851, -23821, -19641, -19367, -19444, -19419, -19416, -19401, -19447, -19222, -17675, -17438, -17492, -17475, -17471, -17452, -17499, -17303, -14278, -13495, -13661, -13623, -13619, -13586, -13734, -12907, -10725, -10728, -10734, -10724, -10720, -10721, -10699, -10789, -11164, -11186, -11175, -11174, -11170, -11173, -11145, -11252, -12019, -12132, -12101, -12103, -12100, -12111, -12057, -12245, -15266, -16041, -15868, -15899, -15896, -15842, -16093, -14719, -11088, -11096, -11108, -11094, -11090, -11163, -10779, -12646, -20242, -20733, -20582, -20617, -20613, -20631, -20528, -20966, -24041, -24498, -24380, -24399, -24394, -24395, -24368, -24437, -25566, -25853, -25785, -25791, -25785, -25618, -26449, -21920, -9944, -9976, -10021, -9984, -9977, -9892, -10288, -8319, -338, 182, 32, 76, 79, 60, 161, -278, -3355, -3816, -3700, -3724, -3722, -3750, -3640, -4047, -10467, -12121, -11760, -11829, -11826, -11954, -11267, -14964, -24754, -24720, -24676, -24699, -24697, -24372, -26091, -16847};