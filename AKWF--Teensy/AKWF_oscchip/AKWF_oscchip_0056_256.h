/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0056 256 samples */
 
const int16_t AKWF_oscchip_0056_256_DATA [256] = 
{11790, 23292, 21626, 21936, 21925, 21925, 21919, 21916, 21910, 21906, 21901, 21892, 21884, 21878, 21872, 21863, 21855, 21846, 21838, 21831, 21819, 21809, 21783, 21868, 21310, 20009, 19999, 19998, 19983, 19973, 19971, 19900, 20710, 21330, 21225, 21233, 21223, 21213, 21199, 21215, 20973, 20707, 20724, 20711, 20700, 20691, 20681, 20669, 20659, 20648, 20639, 20628, 20618, 20608, 20597, 20586, 20576, 20566, 20556, 20546, 20532, 20522, 20519, 20468, 21003, 21414, 21340, 21342, 21328, 21305, 20734, 23943, -3838, -34407, -30965, -31578, -31583, -31585, -31585, -31584, -31582, -31578, -31572, -31566, -31558, -31551, -31543, -31533, -31523, -31513, -31502, -31492, -31479, -31468, -31456, -31444, -31432, -31418, -31405, -31390, -31377, -31356, -31066, -32635, -18965, -3926, -5609, -5297, -5286, -5269, -5281, -5201, -3527, -2943, -3052, -3020, -3015, -3012, -3005, -2993, -3302, -3459, -3423, -3426, -3421, -3418, -3420, -3394, -3663, -3870, -3835, -3837, -3837, -3831, -3834, -3806, -4033, -4285, -4256, -4258, -4258, -4253, -4249, -4248, -4247, -4243, -4240, -4240, -4239, -4235, -4230, -4236, -3924, -3763, -3789, -3781, -3781, -3779, -3774, -3770, -3771, -3769, -3766, -3762, -3763, -3761, -3760, -3755, -3752, -3752, -3750, -3751, -3746, -3742, -3742, -3741, -3740, -3736, -3734, -3733, -3732, -3730, -3726, -3729, -3420, -3258, -3285, -3275, -3275, -3273, -3270, -3290, -3008, -2797, -2828, -2819, -2818, -2819, -2815, -2809, -2810, -2808, -2807, -2807, -2805, -2800, -2804, -2787, -2453, -2337, -2359, -2352, -2350, -2352, -2351, -2342, -2648, -2808, -2778, -2781, -2780, -2779, -2776, -2795, -2518, -2310, -2339, -2331, -2330, -2333, -2323, -2363, -2705, -2778, -2758, -2762, -2760, -2761, -2756, -2769, -3103, -3217, -3190, -3194, -3194, -3191, -3187, -3188, -3186, -3185, -3185, -3182, -3177, -3181, -3162, -3264};