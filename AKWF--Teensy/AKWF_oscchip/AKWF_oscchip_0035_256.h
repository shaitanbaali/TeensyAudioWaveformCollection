/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0035 256 samples */
 
const int16_t AKWF_oscchip_0035_256_DATA [256] = 
{31, 29, 34, 46, 78, -135, 3557, 6124, 5725, 5804, 5806, 5808, 5865, 5536, 8635, 11856, 11483, 11549, 11546, 11555, 11524, 11617, 13795, 14533, 14370, 14400, 14395, 14398, 14397, 14296, 17634, 19419, 19092, 19150, 19142, 19135, 19131, 19100, 19379, 19613, 19570, 19567, 19559, 19550, 19543, 19532, 19526, 19515, 19507, 19498, 19488, 19480, 19470, 19462, 19452, 19442, 19433, 19423, 19415, 19360, 19192, 20517, -4123, -20118, -17493, -18012, -17997, -17986, -17632, -19753, 791, 21416, 18897, 19355, 19339, 19328, 19357, 19247, 17415, 16829, 16945, 16915, 16910, 16903, 16896, 16891, 16884, 16876, 16870, 16862, 16853, 16848, 16840, 16833, 16823, 16816, 16808, 16801, 16794, 16787, 16767, 16818, 16329, 15748, 15797, 15779, 15771, 15762, 15757, 15742, 15379, 15231, 15250, 15237, 15229, 15217, 15199, 15284, 13357, 12153, 12344, 12296, 12292, 12283, 12244, 12424, 10511, 8718, 8941, 8891, 8887, 8876, 8884, 8831, 8092, 7860, 7904, 7890, 7884, 7878, 7873, 7872, 7525, 7350, 7378, 7366, 7362, 7355, 7332, 7450, 5652, 4306, 4503, 4463, 4458, 4454, 4412, 4637, 2646, 410, 646, 603, 602, 588, 609, 548, -1590, -2411, -2248, -2283, -2283, -2297, -2316, -2097, -7903, -11378, -10790, -10905, -10901, -10904, -10983, -10486, -16021, -20998, -20346, -20461, -20452, -20447, -20512, -20121, -23017, -26919, -26587, -26630, -26622, -26626, -26601, -26579, -29674, -31100, -30816, -30860, -30847, -30837, -30836, -30748, -31945, -32807, -32660, -32672, -32657, -32644, -32629, -32614, -32599, -32584, -32568, -32553, -32538, -32519, -32513, -32472, -31733, -31461, -31499, -31472, -31456, -31432, -31411, -31504, -28194, -26330, -26639, -26559, -26545, -26522, -26412, -26996, -19942, -13824, -14641, -14472, -14462, -14448, -14326, -14920, -10105, -3884, -4427, -4330, -4320, -4301, -4310, -4296, -1149, 232};