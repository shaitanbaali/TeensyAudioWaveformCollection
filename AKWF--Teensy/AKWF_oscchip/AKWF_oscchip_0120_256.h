/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0120 256 samples */
 
const int16_t AKWF_oscchip_0120_256_DATA [256] = 
{2758, 2987, 2934, 2943, 2944, 2951, 2928, 3031, 3746, 3854, 3827, 3833, 3833, 3834, 3828, 3851, 4203, 4293, 4273, 4277, 4276, 4279, 4256, 4382, 4717, 4715, 4713, 4714, 4712, 4721, 4668, 4927, 5985, 6052, 6030, 6035, 6034, 6037, 6013, 6114, 6827, 6934, 6906, 6911, 6909, 6909, 6902, 6923, 7271, 7360, 7338, 7341, 7339, 7341, 7316, 7442, 7777, 7774, 7770, 7770, 7767, 7772, 7735, 7907, 8611, 8654, 8638, 8641, 8639, 8638, 8625, 8674, 9030, 9081, 9066, 9066, 9065, 9063, 9055, 9076, 9423, 9511, 9490, 9492, 9489, 9451, 9636, 8617, 5921, 5926, 5936, 5927, 5924, 5958, 5779, 6645, 10174, 10400, 10330, 10346, 10344, 10345, 10330, 10380, 10734, 10785, 10770, 10771, 10768, 10765, 10763, 10760, 10757, 10754, 10753, 10749, 10747, 10745, 10740, 10737, 11401, 11662, 11607, 11613, 11610, 11605, 11620, 11529, 11174, 11148, 11152, 11147, 11144, 11146, 11120, 11220, 11932, 12036, 12007, 12009, 12007, 12007, 11991, 12033, 12730, 12909, 12867, 12871, 12867, 12864, 12861, 12859, 12855, 12851, 12848, 12845, 12842, 12845, 12806, 12977, 13678, 13721, 13704, 13705, 13701, 13442, 14599, 9405, -26720, -32151, -30824, -31110, -31110, -31104, -31125, -31033, -29629, -29262, -29338, -29318, -29313, -29302, -29307, -29302, -26961, -26033, -26210, -26168, -26162, -26138, -26221, -25781, -24010, -23890, -23918, -23903, -23896, -23802, -24198, -22393, -9867, -7979, -8433, -8329, -8324, -8326, -8298, -8381, -9784, -10142, -10060, -10071, -10067, -10071, -10059, -10053, -12049, -12836, -12678, -12704, -12700, -12726, -12581, -13271, -16093, -16273, -16215, -16225, -16222, -16236, -16151, -16507, -19006, -19378, -19282, -19296, -19292, -19228, -19441, -18615, -5628, -2275, -3000, -2854, -2852, -2848, -2846, -2844, -2505, -2371, -2394, -2386, -2385, -2353, -2516, -1627};