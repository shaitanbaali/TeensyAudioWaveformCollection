/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0083 256 samples */
 
const int16_t AKWF_oscchip_0083_256_DATA [256] = 
{1345, 1353, 1347, 1349, 1350, 1359, 1312, 1522, 2914, 3056, 3017, 3028, 3026, 3038, 2968, 3339, 4176, 4131, 4135, 4136, 4135, 4154, 4048, 4536, 6341, 6364, 6353, 6356, 6355, 6368, 6300, 6578, 8435, 8612, 8565, 8574, 8573, 8577, 8542, 8718, 9133, 9118, 9117, 9116, 9113, 9117, 9090, 9209, 9650, 9663, 9656, 9655, 9652, 9656, 9622, 9761, 10670, 10774, 10748, 10750, 10748, 10757, 10692, 11022, 11874, 11849, 11846, 11846, 11842, 11849, 11801, 12016, 12913, 12953, 12937, 12938, 12935, 12937, 12908, 13022, 13933, 14055, 14020, 14023, 14020, 14035, 13933, 14427, 15714, 15667, 15668, 15667, 15663, 15682, 15564, 16075, 18364, 18447, 18410, 18414, 18410, 18434, 18298, 18831, 23495, 24082, 23922, 23952, 23948, 23984, 23752, 24898, 27894, 27808, 27809, 27808, 27802, 27828, 27655, 28405, 31566, 31691, 31646, 31650, 31643, 31642, 31607, 31709, 32627, 32741, 32706, 32704, 32697, 32090, 35295, 18461, -28377, -28040, -27921, -28052, -28053, -28051, -28072, -27972, -27524, -27492, -27498, -27494, -27492, -27471, -27541, -27223, -24491, -24054, -24149, -24125, -24120, -24121, -24088, -24223, -24658, -24650, -24643, -24639, -24632, -24604, -24713, -24178, -21415, -21217, -21271, -21251, -21245, -21230, -21265, -21092, -19243, -18925, -18994, -18973, -18967, -18939, -19054, -18464, -16696, -16716, -16712, -16704, -16699, -16684, -16719, -16543, -15612, -15549, -15561, -15552, -15548, -15529, -15598, -15189, -14376, -14418, -14406, -14401, -14396, -14381, -14435, -14146, -13268, -13262, -13262, -13255, -13252, -13232, -13306, -12947, -11120, -10975, -11007, -10994, -10991, -10975, -11039, -10657, -9832, -9868, -9861, -9856, -9853, -9835, -9909, -9513, -8185, -8159, -8168, -8161, -8158, -8138, -8220, -7823, -5547, -5318, -5373, -5358, -5355, -5320, -5494, -4556, -2465, -2573, -2559, -2554, -2553, -2525, -2664, -1935};