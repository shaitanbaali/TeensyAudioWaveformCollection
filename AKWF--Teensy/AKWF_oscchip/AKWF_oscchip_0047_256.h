/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0047 256 samples */
 
const int16_t AKWF_oscchip_0047_256_DATA [256] = 
{2220, 2002, 2059, 2048, 2050, 2050, 2056, 2060, 2061, 2061, 2061, 2061, 2060, 2062, 2063, 2063, 2063, 2063, 2061, 2060, 2060, 2130, 1788, 3513, 9861, 10340, 10193, 10228, 10224, 10138, 10624, 6328, 1622, 2129, 2040, 2034, 2032, 2031, 2029, 2029, 2028, 2027, 2023, 2018, 2017, 2017, 2016, 2014, 2015, 2013, 2013, 2012, 2012, 2004, 2001, 2002, 2001, 1999, 2000, 2000, 1998, 1997, 1998, 1997, 1996, 1995, 1988, 1988, 1985, 2324, 486, 13173, 33060, 31792, 31940, 31963, 31961, 31636, 33301, 23680, 1078, 1192, 1309, 1230, 1224, 1218, 1211, 1209, 1203, 1197, 1195, 1194, 1186, 971, 2149, -8239, -19613, -18371, -18585, -18588, -18592, -18368, -19534, -11456, 1202, 398, 498, 517, 519, 512, 557, 346, -162, -154, -152, -153, -153, -162, -101, -944, -1589, -1492, -1511, -1511, -1511, -1505, -1502, -1503, -1503, -1501, -1500, -1501, -1501, -1500, -1499, -1498, -1499, -1499, -1498, -1497, -1495, -1495, -1504, -1027, -775, -818, -805, -805, -806, -806, -804, -803, -804, -803, -803, -804, -803, -802, -801, -802, -801, -801, -801, -801, -802, -677, -1345, 3271, 10492, 10035, 10096, 10103, 10079, 10087, 10246, 2640, -1389, -672, -816, -817, -818, -817, -818, -819, -820, -819, -819, -819, -820, -819, -820, -822, -821, -821, -821, -822, -820, -1044, 169, -8200, -21289, -20465, -20568, -20583, -20535, -20547, -20844, -6586, 967, -366, -94, -100, -93, -92, -90, -89, -89, -83, -78, -79, -78, -105, 53, -1377, -2938, -2766, -2795, -2795, -2794, -2795, -2792, -2786, -2784, -2785, -2784, -2782, -2790, -2787, -2734, -5129, -6365, -6137, -6182, -6181, -6178, -6205, -5996, -8948, -11214, -10876, -10938, -10931, -10923, -10802, -11483, -4928};