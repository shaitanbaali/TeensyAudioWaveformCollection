/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0021 256 samples */
 
const int16_t AKWF_oscchip_0021_256_DATA [256] = 
{20284, 23005, 22427, 22533, 22539, 22541, 22543, 22543, 22543, 22542, 22540, 22539, 22537, 22535, 22532, 22529, 22525, 22521, 22519, 22515, 22511, 22505, 22501, 22497, 22492, 22487, 22481, 22476, 22471, 22466, 22461, 22456, 22450, 22445, 22439, 22434, 22428, 22422, 22417, 22411, 22405, 22400, 22394, 22388, 22382, 22376, 22370, 22365, 22359, 22353, 22347, 22341, 22335, 22329, 22323, 22318, 22311, 22305, 22300, 22294, 22288, 22281, 22276, 22270, 22264, 22258, 22252, 22246, 22240, 22234, 22228, 22223, 22217, 22210, 22204, 22198, 22193, 22187, 22180, 22175, 22169, 22163, 22157, 22150, 22145, 22139, 22133, 22127, 22121, 22115, 22109, 22103, 22098, 22092, 22085, 22079, 22074, 22068, 22062, 22056, 22050, 22044, 22038, 22032, 22026, 22021, 22014, 22009, 22003, 21997, 21991, 21985, 21980, 21973, 21967, 21962, 21957, 21591, 23276, 15977, -27125, -32187, -30928, -31210, -31210, -31211, -31211, -31209, -31206, -31205, -31201, -31198, -31194, -31189, -31185, -31179, -31174, -31169, -31163, -31156, -31150, -31144, -31137, -31130, -31123, -31116, -31109, -31102, -31094, -31087, -31078, -31072, -31064, -31056, -31047, -31040, -31033, -31024, -31016, -31008, -31000, -30992, -30983, -30976, -30969, -30961, -30953, -30944, -30936, -30928, -30920, -30912, -30903, -30815, -30940, -30842, -2089, 7373, 5451, 5819, 5822, 5726, 5945, 5448, -23488, -32384, -30456, -30823, -30815, -30696, -31031, -29951, -4658, 2549, 996, 1308, 1310, 1311, 1325, 1290, 623, 462, 501, 496, 498, 494, 512, 452, -564, -788, -735, -742, -742, -759, -691, -953, -3988, -4608, -4462, -4491, -4490, -4534, -4347, -5088, -11852, -13032, -12760, -12815, -12813, -12815, -12794, -12875, -13557, -13654, -13626, -13629, -13627, -13716, -13283, -15204, -29167, -31081, -30592, -30689, -30685, -30679, -30674, -30669, -30662, -30656, -30650, -30644, -30635, -30386, -31677, -25230};