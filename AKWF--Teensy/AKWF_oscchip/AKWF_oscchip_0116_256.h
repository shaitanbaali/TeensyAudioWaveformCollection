/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0116 256 samples */
 
const int16_t AKWF_oscchip_0116_256_DATA [256] = 
{1665, 2125, 2038, 2054, 2056, 2059, 2072, 1988, 3504, 4294, 4146, 4174, 4174, 4174, 4204, 4032, 5611, 6870, 6670, 6705, 6705, 6733, 6741, 6431, 19129, 23776, 22786, 22974, 22968, 22965, 22962, 22958, 22954, 22950, 22946, 22942, 22938, 22932, 22927, 22923, 22917, 22912, 22907, 22901, 22896, 22891, 22885, 22880, 22874, 22868, 22863, 22856, 22851, 22845, 22840, 22834, 22827, 22822, 22816, 22809, 22804, 22798, 22792, 22786, 22780, 22774, 22768, 22761, 22756, 22750, 22744, 22737, 22732, 22726, 22719, 22713, 22707, 22701, 22696, 22689, 22683, 22677, 22671, 22665, 22659, 22653, 22646, 22640, 22635, 22629, 22622, 22616, 22610, 22604, 22598, 22592, 22586, 22580, 22574, 22568, 22562, 22550, 21815, 25885, -6230, -34920, -30557, -31384, -31377, -31377, -31378, -31376, -31375, -31373, -31370, -31367, -31362, -31346, -31145, -32353, -18787, -9846, -11315, -11035, -11032, -11028, -11018, -11045, -10808, -10566, -10591, -10582, -10579, -10574, -10571, -10568, -10564, -10561, -10557, -10554, -10551, -10548, -10555, -10495, -11019, -11435, -11365, -11375, -11373, -11370, -11356, -11416, -10980, -10459, -10518, -10505, -10502, -10500, -10505, -10454, -11040, -11384, -11318, -11327, -11324, -11322, -11319, -11316, -11313, -11310, -11307, -11304, -11301, -11298, -11284, -11346, -10936, -10390, -10447, -10434, -10431, -10429, -10439, -10359, -11203, -11758, -11664, -11680, -11676, -11673, -11671, -11667, -11664, -11661, -11658, -11655, -11652, -11649, -11646, -11642, -11640, -11636, -11634, -11631, -11627, -11624, -11622, -11618, -11616, -11612, -11609, -11606, -11603, -11600, -11596, -11594, -11590, -11587, -11584, -11581, -11578, -11575, -11571, -11569, -11566, -11563, -11560, -11556, -11554, -11550, -11541, -11571, -11315, -11085, -11117, -11107, -11106, -11103, -11095, -11124, -10918, -10642, -10669, -10661, -10657, -10647, -10543, -11171, -4107, 550, -214, -68, -67, -65, -67, -39};