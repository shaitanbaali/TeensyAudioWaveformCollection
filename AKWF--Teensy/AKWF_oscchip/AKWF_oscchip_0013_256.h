/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0013 256 samples */
 
const int16_t AKWF_oscchip_0013_256_DATA [256] = 
{1694, 2050, 1974, 1985, 1985, 2013, 1885, 2439, 6819, 7402, 7257, 7285, 7285, 7317, 7152, 7877, 12564, 13138, 12983, 13013, 13009, 12975, 13104, 12498, 9270, 8936, 9014, 8991, 8984, 9010, 8859, 9517, 12760, 12987, 12918, 12929, 12922, 12911, 12936, 12775, 12051, 11997, 12005, 11994, 11989, 11909, 12282, 10463, 3400, 3024, 3136, 3098, 3091, 3240, 2465, 6164, 19175, 19514, 19386, 19422, 19419, 19533, 18900, 22058, 32373, 32469, 32380, 32402, 32391, 32326, 32406, 32317, 16045, 10376, 11527, 11294, 11284, 11298, 11232, 11330, 19720, 22276, 21731, 21822, 21812, 21737, 21891, 21392, 4958, 134, 1165, 954, 949, 867, 1109, 260, -15190, -19247, -18363, -18540, -18540, -18519, -18581, -18338, -14755, -13962, -14132, -14091, -14086, -14079, -14080, -14048, -13682, -13603, -13613, -13604, -13597, -13587, -13591, -13548, -13182, -13108, -13115, -13105, -13099, -13113, -13017, -13367, -16243, -16684, -16574, -16587, -16578, -16536, -16687, -15984, -10880, -10219, -10373, -10331, -10322, -10311, -10328, -10210, -9483, -9386, -9402, -9392, -9385, -9478, -8999, -11061, -22170, -23283, -22990, -23047, -23038, -22914, -23466, -20885, -8241, -7324, -7564, -7494, -7486, -7475, -7484, -7396, -7032, -7004, -7003, -6996, -6991, -6978, -7009, -6824, -6115, -6072, -6080, -6071, -6067, -6059, -6075, -5969, -5613, -5601, -5600, -5594, -5592, -5585, -5583, -5580, -5243, -5109, -5132, -5125, -5119, -5117, -5115, -5109, -5108, -5105, -5100, -5099, -5095, -5088, -5093, -5079, -4376, -4160, -4200, -4190, -4187, -4176, -4192, -4139, -2380, -1874, -1982, -1958, -1957, -1935, -2001, -1766, 2446, 3555, 3314, 3359, 3361, 3385, 3299, 3614, 8269, 9290, 9065, 9110, 9105, 9084, 9162, 8842, 4507, 3621, 3824, 3780, 3776, 3749, 3857, 3416, -882, -1689, -1500, -1539, -1540, -1533, -1593, -1315};