/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0122 256 samples */
 
const int16_t AKWF_oscchip_0122_256_DATA [256] = 
{2213, 1956, 2016, 2005, 2005, 2017, 1950, 2435, 3061, 2998, 3007, 3008, 3008, 3013, 2982, 3176, 3527, 3507, 3510, 3511, 3511, 3515, 3491, 3823, 4041, 4004, 4011, 4011, 4011, 4016, 3985, 4276, 4544, 4508, 4514, 4514, 4514, 4520, 4486, 4728, 5040, 5009, 5013, 5014, 5014, 5019, 4988, 5182, 5533, 5514, 5516, 5517, 5518, 5529, 5459, 6455, 7110, 7002, 7021, 7020, 7020, 7025, 6994, 7287, 7557, 7520, 7526, 7526, 7526, 7817, 6199, 17952, 33127, 31601, 31858, 31866, 31867, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31866, 31809, 31423, 34026, -3379, -27894, -23832, -24603, -24594, -24594, -24593, -24593, -24593, -24593, -24593, -24593, -24593, -24593, -24563, -24730, -23518, -21955, -22112, -22085, -22084, -22085, -22079, -22110, -21918, -21567, -21587, -21585, -21584, -21580, -21553, -21738, -19076, -17332, -17621, -17567, -17567, -17565, -17484, -17952, -13603, -9591, -10139, -10039, -10039, -10040, -10029, -10095, -9610, -8985, -9047, -9036, -9035, -9036, -9007, -9164, -8198, -6439, -6541, -6526, -6523, -6522, -6516, -6562, -5898, -5464, -5535, -5520, -5520, -5526, -5715, -4624, -14773, -24134, -22856, -23089, -23088, -23087, -23063, -23197, -22227, -20974, -21100, -21078, -21079, -21078, -21033, -21284, -19742, -16930, -17091, -17070, -17065, -17063, -17057, -17103, -16439, -16005, -16076, -16061, -16061, -16056, -15873, -16928, -6759};