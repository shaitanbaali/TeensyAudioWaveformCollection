/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0094 256 samples */
 
const int16_t AKWF_oscchip_0094_256_DATA [256] = 
{23444, 31926, 30277, 30576, 30587, 30587, 30590, 30597, 29700, 29380, 29438, 29424, 29420, 29399, 29483, 29081, 26217, 25861, 25945, 25921, 25916, 25906, 25914, 25861, 24918, 24690, 24735, 24720, 24714, 24694, 24686, 24785, 19010, 16789, 17240, 17149, 17143, 17154, 17075, 17368, 19783, 20067, 19984, 19996, 19991, 19959, 20040, 19768, 12636, 10977, 11356, 11278, 11274, 11274, 11273, 11204, 13426, 14287, 14106, 14136, 14132, 14121, 14148, 14015, 13052, 12932, 12958, 12949, 12945, 12937, 12946, 12904, 11958, 11730, 11775, 11761, 11758, 11753, 11748, 11769, 10878, 10530, 10596, 10579, 10576, 10549, 10654, 10180, 6393, 5829, 5953, 5923, 5921, 5917, 5920, 5899, 5436, 5311, 5336, 5329, 5326, 5323, 5318, 5344, 4472, 4101, 4172, 4159, 4157, 4140, 4207, 3919, 1044, 591, 700, 675, 675, 670, 678, 659, -266, -530, -472, -483, -484, -489, -467, -567, -1048, -1073, -1064, -1067, -1067, -1077, -1031, -1210, -3143, -3436, -3365, -3380, -3381, -3382, -3374, -3387, -4324, -4581, -4521, -4529, -4530, -4533, -4510, -4607, -5080, -5111, -5103, -5105, -5104, -5112, -5074, -5218, -6639, -6874, -6819, -6828, -6827, -6828, -6822, -6831, -7288, -7420, -7389, -7392, -7391, -7423, -7253, -8035, -12288, -12669, -12567, -12587, -12584, -12567, -12625, -12378, -9551, -9006, -9126, -9099, -9096, -9099, -9087, -9102, -10910, -11494, -11370, -11391, -11389, -11434, -11192, -12258, -18494, -19008, -18855, -18887, -18882, -18881, -18867, -18896, -19371, -19458, -19435, -19435, -19430, -19427, -19421, -19412, -19866, -20011, -19974, -19976, -19971, -19939, -20068, -19492, -16123, -15835, -15906, -15882, -15878, -15918, -15731, -16393, -25473, -27160, -26763, -26838, -26832, -26833, -26820, -26796, -29080, -29821, -29659, -29680, -29673, -29681, -29605, -29907, -31794, -31989, -31934, -31937, -31930, -31828, -32324, -29761};