/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0082 256 samples */
 
const int16_t AKWF_oscchip_0082_256_DATA [256] = 
{2615, 4166, 3895, 3948, 3947, 3947, 3955, 3905, 4286, 4630, 4579, 4589, 4587, 4602, 4624, 4359, 12171, 15388, 14768, 14880, 14877, 14876, 14879, 14840, 15271, 15548, 15500, 15504, 15501, 15496, 15388, 15986, 11151, 6606, 7227, 7109, 7106, 7106, 7107, 7071, 8019, 8443, 8361, 8374, 8371, 8369, 8368, 8365, 8362, 8360, 8357, 8356, 8353, 8350, 8348, 8345, 8343, 8341, 8339, 8337, 8334, 8334, 8342, 8267, 9690, 10359, 10226, 10247, 10244, 10241, 10239, 10236, 10233, 10231, 10228, 10226, 10224, 10222, 10111, 10699, 6382, 1967, 2596, 2481, 2481, 2478, 2473, 2497, 2015, 1791, 1833, 1824, 1823, 1821, 1812, 1855, 1431, 1134, 1180, 1170, 1170, 1168, 1151, 1249, 535, -198, -101, -121, -121, -121, -125, -102, -570, -799, -756, -763, -764, -781, -1107, 840, -19116, -33528, -31252, -31668, -31664, -31658, -31523, -32259, -26754, -20743, -21471, -21333, -21326, -21309, -21221, -21747, -12551, -7699, -8585, -8417, -8413, -8408, -8296, -8891, -3223, 1200, 497, 627, 628, 630, 684, 399, 2437, 4744, 4451, 4506, 4507, 4506, 4501, 4534, 4073, 3823, 3870, 3862, 3862, 3861, 3811, 4089, 1667, -261, 54, -7, -7, -25, -16, 104, -7972, -10774, -10200, -10310, -10310, -10300, -10234, -10685, -4216, -774, -1405, -1284, -1285, -1284, -1299, -1209, -2001, -2645, -2548, -2566, -2564, -2567, -2565, -2553, -3536, -3905, -3833, -3845, -3845, -3845, -3852, -3795, -4691, -5199, -5109, -5126, -5124, -5124, -5146, -5014, -6186, -7172, -7026, -7052, -7051, -7049, -7048, -7046, -7044, -7043, -7042, -7040, -7038, -7036, -7016, -7120, -5789, -4975, -5120, -5091, -5090, -5087, -5044, -5272, -3359, -1649, -1908, -1860, -1858, -1854, -1849, -1903, -417, 177, 53, 75, 78, 76, 85, 43};