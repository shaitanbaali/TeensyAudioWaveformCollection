/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0100 256 samples */
 
const int16_t AKWF_oscchip_0100_256_DATA [256] = 
{11188, 13848, 13330, 13425, 13430, 13417, 13442, 13409, 8927, 7454, 7748, 7690, 7690, 7702, 7782, 7223, 17137, 22197, 21288, 21454, 21451, 21396, 21579, 20865, 9659, 7218, 7766, 7654, 7652, 7699, 7662, 7516, 25691, 32257, 30908, 31155, 31148, 31146, 31149, 31090, 31898, 32337, 32250, 32258, 32252, 32170, 32428, 31522, 12598, 8485, 9445, 9250, 9248, 9285, 9283, 8889, 26842, 33288, 31907, 32166, 32157, 32149, 32139, 32164, 31749, 31514, 31551, 31537, 31530, 31384, 31882, 30145, -404, -6987, -5519, -5813, -5821, -5850, -5852, -5638, -16344, -20241, -19458, -19604, -19605, -19562, -19193, -21684, 12046, 30763, 27391, 28024, 28016, 28010, 28020, 27970, 27047, 26815, 26861, 26848, 26842, 26831, 26827, 26866, 24254, 23213, 23408, 23367, 23361, 23349, 23369, 23254, 22299, 22156, 22182, 22170, 22164, 22137, 22187, 22012, 16451, 14984, 15307, 15239, 15234, 15217, 15192, 15381, 9750, 7361, 7836, 7739, 7736, 7691, 7875, 7113, 406, -494, -264, -316, -317, -322, -315, -338, -1274, -1517, -1465, -1477, -1479, -1493, -1527, -1199, -9079, -12346, -11680, -11806, -11801, -11826, -11717, -12145, -15937, -16494, -16361, -16385, -16384, -16391, -16359, -16442, -19200, -19935, -19776, -19801, -19798, -19801, -19806, -19691, -23135, -24594, -24314, -24362, -24356, -24356, -24329, -24415, -25347, -25505, -25461, -25463, -25456, -25398, -25509, -25197, -10255, -5738, -6667, -6487, -6482, -6507, -6596, -5888, -23128, -31220, -29696, -29974, -29971, -29974, -29927, -30088, -31982, -32297, -32212, -32222, -32216, -32210, -32201, -32194, -32641, -32777, -32738, -32736, -32728, -32716, -32691, -32808, -30273, -29049, -29283, -29231, -29223, -29195, -29272, -28946, -25125, -24468, -24616, -24575, -24568, -24549, -24565, -24531, -20853, -19751, -19977, -19923, -19917, -19897, -19827, -20318, -11841, -7779, -8556, -8401, -8396, -8352, -8559, -7545};