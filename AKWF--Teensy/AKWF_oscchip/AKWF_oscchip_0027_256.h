/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0027 256 samples */
 
const int16_t AKWF_oscchip_0027_256_DATA [256] = 
{14804, 18155, 17457, 17587, 17593, 17596, 17598, 17599, 17599, 17599, 17599, 17599, 17598, 17596, 17594, 17593, 17590, 17588, 17585, 17582, 17580, 17575, 17572, 17570, 17566, 17562, 17559, 17555, 17551, 17546, 17542, 17539, 17534, 17529, 17526, 17522, 17517, 17513, 17508, 17504, 17500, 17495, 17490, 17486, 17481, 17477, 17473, 17468, 17463, 17459, 17454, 17449, 17444, 17441, 17436, 17431, 17426, 17422, 17417, 17413, 17408, 17403, 17398, 17394, 17389, 17385, 17380, 17375, 17371, 17366, 17361, 17357, 17352, 17348, 17343, 17338, 17333, 17329, 17324, 17320, 17315, 17310, 17306, 17301, 17296, 17292, 17287, 17283, 17278, 17273, 17269, 17264, 17259, 17254, 17250, 17245, 17241, 17236, 17231, 17227, 17222, 17218, 17213, 17209, 17204, 17199, 17195, 17190, 17186, 17181, 17176, 17171, 17166, 17163, 17158, 17153, 17149, 16671, 19116, 6879, -30947, -31129, -30946, -31047, -31050, -31049, -31049, -31047, -31044, -31040, -31037, -31033, -31029, -31024, -31019, -31013, -31007, -31001, -30995, -30989, -30982, -30976, -30969, -30962, -30956, -30949, -30941, -30934, -30926, -30765, -31387, -28873, -3096, 1765, 621, 863, 866, 868, 881, 848, 545, 498, 512, 512, 514, 513, 526, 482, 174, 138, 149, 147, 148, 145, 169, 57, -555, -615, -597, -600, -599, -843, 370, -5129, -29613, -31141, -30712, -30820, -30817, -30574, -31781, -25896, -2458, -1484, -1799, -1699, -1694, -1697, -1660, -1839, -2428, -2441, -2431, -2432, -2430, -2440, -2377, -2684, -3562, -3559, -3552, -3552, -3551, -3586, -3392, -4405, -7014, -6937, -6942, -6946, -6944, -7026, -6580, -9096, -14667, -14468, -14477, -14487, -14485, -14492, -14440, -14719, -15254, -15221, -15221, -15220, -15216, -15282, -14982, -16227, -28901, -31121, -30578, -30682, -30676, -30671, -30666, -30660, -30653, -30647, -30641, -30634, -30626, -30429, -31437, -26503};