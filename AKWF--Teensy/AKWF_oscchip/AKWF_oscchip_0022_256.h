/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0022 256 samples */
 
const int16_t AKWF_oscchip_0022_256_DATA [256] = 
{8024, 7584, 7688, 7678, 7685, 7692, 7695, 7700, 7703, 7704, 7705, 7711, 7712, 7713, 7713, 7707, 7707, 7707, 7705, 7705, 7700, 7699, 7698, 7694, 7690, 7690, 7686, 7681, 7680, 7675, 7671, 7670, 7664, 7663, 7657, 7654, 7650, 7646, 7643, 7637, 7635, 7629, 7626, 7622, 7617, 7614, 7609, 7605, 7600, 7598, 7593, 7590, 7584, 7581, 7577, 7573, 7567, 7563, 7559, 7555, 7553, 7546, 7541, 7536, 7534, 7528, 7526, 7520, 7517, 7512, 7508, 7504, 7500, 7496, 7491, 7487, 7482, 7490, 7430, 7711, 8397, 8374, 8369, 8368, 8363, 8364, 8332, 8478, 8813, 8795, 8791, 8787, 8784, 9051, 7582, 16078, 33044, 32200, 32270, 32294, 32285, 32275, 32263, 32251, 32239, 32224, 32212, 32197, 32181, 32167, 32153, 32138, 32121, 32102, 32087, 32072, 32049, 31329, 35172, 10485, -28960, -25800, -26314, -26351, -26356, -26356, -26358, -26358, -26357, -26356, -26350, -26344, -26340, -26008, -27763, -16342, -702, -2361, -2054, -2046, -2040, -2030, -2056, -1829, -1538, -1568, -1557, -1553, -1553, -1541, -1571, -1332, -1058, -1086, -1078, -1078, -1077, -1063, -1126, -627, -99, -166, -154, -153, -154, -152, -148, -147, -148, -147, -148, -147, -145, -146, -145, -145, -145, -145, -145, -145, -145, -145, -145, -146, -144, -143, -144, -143, -143, -143, -143, -143, -143, -143, -143, -143, -143, -153, -102, -370, -1067, -1059, -1055, -1058, -1057, -1057, -1058, -1056, -1055, -1056, -1055, -1056, -1053, -1329, 164, -8156, -26862, -26085, -26170, -26193, -26189, -26179, -26172, -26165, -26157, -26145, -26137, -26126, -26115, -26103, -26091, -26080, -26067, -26056, -26044, -26030, -26016, -26004, -25990, -25976, -25964, -25949, -25936, -25922, -25908, -25893, -25880, -25866, -25851, -25837, -25823, -25808, -25797, -25380, -27532, -13093};