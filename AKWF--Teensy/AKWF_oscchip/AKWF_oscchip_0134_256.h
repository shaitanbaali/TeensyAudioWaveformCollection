/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0134 256 samples */
 
const int16_t AKWF_oscchip_0134_256_DATA [256] = 
{4008, 3508, 3632, 3613, 3616, 3806, 2756, 10402, 20272, 19281, 19448, 19453, 19451, 19334, 19964, 16090, 9033, 9434, 9375, 9364, 9363, 9373, 9297, 9706, 10796, 10791, 10783, 10785, 10779, 10731, 10996, 8501, 6199, 6511, 6452, 6451, 6447, 6393, 6678, 4590, 1894, 2165, 2118, 2112, 2111, 2186, 1777, 4265, 8802, 8541, 8575, 8580, 8578, 8576, 8574, 8571, 8572, 8568, 8568, 8564, 8562, 8559, 8559, 8555, 8555, 8552, 8550, 8547, 8547, 8526, 8621, 7923, 7024, 7114, 7096, 7092, 7091, 7038, 7308, 5645, 2618, 2788, 2762, 2758, 2756, 2709, 2939, 1699, -1577, -1569, -1555, -1566, -1569, -1646, -1199, -5357, -9193, -8670, -8764, -8763, -8764, -8719, -8955, -7218, -4971, -5197, -5157, -5156, -5154, -5241, -4746, -7787, -13329, -13012, -13055, -13057, -13057, -13061, -13021, -13225, -13769, -13763, -13759, -13758, -13755, -13752, -13749, -13744, -13743, -13739, -13736, -13733, -13730, -13657, -14036, -11255, -7666, -8023, -7959, -7955, -7952, -8006, -7690, -9620, -13143, -12941, -12964, -12964, -12961, -12792, -13667, -8917, 3649, 3613, 3561, 3599, 3603, 3699, 3163, 8152, 12755, 12126, 12239, 12239, 12239, 12291, 12001, 14085, 16778, 16506, 16547, 16548, 16546, 16460, 16908, 14141, 9096, 9379, 9338, 9330, 9326, 9221, 9754, 6860, -792, -769, -738, -762, -765, -846, -399, -4557, -8393, -7870, -7966, -7966, -7964, -7894, -8277, -5498, -1907, -2268, -2206, -2204, -2204, -2090, -2717, 1154, 8209, 7807, 7861, 7872, 7869, 7531, 9289, -207, -25338, -25260, -25151, -25220, -25209, -24843, -26942, -7408, 10612, 8156, 8606, 8606, 8608, 8523, 9001, 5525, 1040, 1491, 1415, 1411, 1412, 1370, 1595, 215, -2302, -2159, -2178, -2180, -2179, -2479, -912, -9377, -31778, -31707, -31609, -31668, -31656, -31296, -33352, -13506};