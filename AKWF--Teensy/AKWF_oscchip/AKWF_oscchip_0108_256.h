/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0108 256 samples */
 
const int16_t AKWF_oscchip_0108_256_DATA [256] = 
{13311, 15556, 15115, 15194, 15197, 15197, 15197, 15197, 15195, 15195, 15193, 15191, 15190, 15188, 15188, 15167, 15600, 15792, 15754, 15757, 15755, 15754, 15740, 15780, 16253, 16339, 16314, 16315, 16311, 16320, 16292, 16338, 20010, 21171, 20926, 20968, 20963, 20959, 20957, 20931, 21353, 21557, 21512, 21514, 21509, 21512, 21472, 21601, 23533, 23894, 23800, 23813, 23807, 23802, 23794, 23786, 24244, 24390, 24350, 24350, 24344, 24338, 24336, 24303, 24723, 24933, 24885, 24886, 24880, 24881, 24847, 24938, 26391, 26656, 26585, 26591, 26585, 26581, 26570, 26558, 27482, 27774, 27702, 27707, 27700, 27694, 27690, 27656, 28074, 28284, 28238, 28239, 28231, 28234, 28190, 28322, 30213, 30604, 30508, 30517, 30510, 30506, 30494, 30479, 31836, 32304, 32203, 32212, 32204, 32200, 32176, 32238, 32709, 32759, 32735, 32730, 32721, 32520, 33168, 30746, -13357, -23606, -21323, -21772, -21773, -21775, -21776, -21784, -21337, -21167, -21201, -21194, -21193, -21208, -21127, -21461, -23898, -24163, -24088, -24100, -24095, -24092, -24088, -24083, -24078, -24073, -24069, -24062, -24056, -24051, -24045, -24050, -23594, -23415, -23444, -23431, -23426, -23420, -23414, -23408, -23402, -23396, -23391, -23384, -23378, -23372, -23366, -23360, -23354, -23347, -23341, -23336, -23329, -23323, -23317, -23311, -23304, -23298, -23292, -23285, -23279, -23273, -23267, -23260, -23254, -23248, -23242, -23236, -23230, -23222, -23221, -23196, -22723, -22594, -22615, -22603, -22597, -22591, -22585, -22579, -22573, -22566, -22560, -22555, -22548, -22540, -22545, -22489, -21997, -21916, -21931, -21921, -21915, -21907, -21905, -21888, -21411, -21276, -21297, -21286, -21280, -21274, -21268, -21263, -21256, -21251, -21244, -21239, -21233, -21227, -21221, -21215, -21210, -21204, -21198, -21193, -21187, -21151, -21220, -21065, -11563, -8991, -9556, -9440, -9435, -9429, -9420, -9457, -8568, -8183, -8256, -8238, -8235, -8176, -8468, -7045};