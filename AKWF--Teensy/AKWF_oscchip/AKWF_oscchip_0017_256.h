/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0017 256 samples */
 
const int16_t AKWF_oscchip_0017_256_DATA [256] = 
{6660, 6343, 6410, 6408, 6410, 6674, 5307, 13571, 26885, 25818, 25989, 26002, 25994, 26007, 25918, 26439, 27262, 27177, 27182, 27172, 27163, 27199, 26935, 28600, 30975, 30738, 30762, 30748, 30734, 30723, 30707, 30692, 30676, 30661, 30645, 30628, 30614, 30614, 30508, 31116, 31849, 31742, 31740, 31723, 31708, 31690, 31674, 31657, 31637, 31620, 31604, 31587, 31566, 31561, 31491, 31719, 32688, 32713, 32682, 32669, 32648, 32338, 33809, 26317, -1564, -2527, -2203, -2323, -2339, -2243, -2796, -3, 9100, 9311, 9205, 9231, 9226, 9267, 9004, 10281, 14085, 14095, 14067, 14071, 14063, 14070, 13996, 14330, 15271, 15248, 15243, 15236, 15229, 15246, 15103, 15829, 17679, 17638, 17626, 17620, 17611, 17658, 17354, 18965, 22562, 22444, 22439, 22436, 22426, 22464, 22183, 23653, 26801, 26628, 26640, 26629, 26619, 26632, 26467, 27343, 29099, 28977, 28979, 28967, 28952, 28959, 28821, 29528, 30793, 30696, 30693, 30679, 30673, 29902, 33918, 9629, -29478, -26358, -26880, -26919, -26922, -26930, -26890, -27160, -27571, -27528, -27531, -27525, -27518, -27521, -27468, -27739, -28128, -28080, -28075, -28065, -28052, -28040, -28027, -28015, -28001, -27989, -27974, -27959, -27947, -27925, -27949, -27742, -26730, -26632, -26637, -26617, -26604, -26588, -26573, -26559, -26544, -26531, -26516, -26499, -26483, -26469, -26455, -26441, -26425, -26409, -26394, -26379, -26367, -26351, -26335, -26320, -26303, -26289, -26275, -26260, -26245, -26223, -26237, -26077, -25582, -25555, -25546, -25529, -25514, -25496, -25514, -25331, -24845, -24831, -24819, -24801, -24787, -24766, -24786, -24602, -24111, -24104, -24090, -24076, -24060, -24042, -24061, -23861, -23385, -23382, -23367, -23352, -23339, -23317, -23342, -23125, -22661, -22663, -22646, -22631, -22618, -22598, -22625, -22393, -21935, -21946, -21930, -21915, -21905, -21882, -21907, -21673, -21216, -21230, -21215, -21201, -21190, -20879, -22482, -12445};