/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0030 256 samples */
 
const int16_t AKWF_oscchip_0030_256_DATA [256] = 
{16109, 33497, 30758, 31276, 31270, 31264, 31227, 31443, 28320, 26375, 26713, 26645, 26641, 26636, 26608, 26728, 25997, 24646, 24716, 24700, 24692, 24687, 24624, 24925, 23075, 20011, 20257, 20208, 20203, 20197, 20144, 20396, 18725, 16172, 16398, 16352, 16347, 16342, 16277, 16594, 14453, 11647, 11921, 11869, 11862, 11859, 11785, 12154, 9535, 6459, 6828, 6757, 6752, 6749, 6692, 6994, 4572, 2018, 2352, 2290, 2289, 2286, 2247, 2463, 636, -1083, -856, -898, -900, -902, -929, -780, -2134, -3266, -3094, -3125, -3127, -3128, -3144, -3050, -4056, -4814, -4691, -4711, -4710, -4710, -4721, -4650, -5500, -6052, -5960, -5976, -5975, -5975, -5981, -5933, -6588, -6974, -6907, -6918, -6916, -6916, -6919, -6886, -7560, -7917, -7849, -7860, -7858, -7857, -7856, -7841, -8307, -8517, -8474, -8479, -8477, -8477, -8476, -8457, -9181, -9466, -9406, -9414, -9412, -9410, -9407, -9405, -9403, -9400, -9398, -9396, -9393, -9391, -9389, -9386, -9384, -9381, -9379, -9376, -9374, -9371, -9369, -9366, -9364, -9361, -9359, -9357, -9354, -9346, -9167, -10208, -872, 7524, 6316, 6537, 6533, 6533, 6516, 6623, 5628, 4851, 4970, 4948, 4947, 4946, 4933, 5008, 4188, 3596, 3693, 3675, 3674, 3673, 3670, 3684, 3469, 3334, 3357, 3352, 3350, 3337, 3253, 3834, -5131, -10060, -9192, -9353, -9351, -9351, -9350, -9348, -9348, -9347, -9346, -9344, -9343, -9342, -9340, -9338, -9336, -9335, -9333, -9330, -9329, -9327, -9325, -9322, -9320, -9318, -9316, -9314, -9311, -9309, -9306, -9304, -9302, -9299, -9297, -9295, -9293, -9290, -9288, -9285, -9283, -9280, -9278, -9275, -9273, -9270, -9268, -9265, -9263, -9261, -9259, -9256, -9253, -9251, -9249, -9246, -9244, -9241, -9239, -9236, -9234, -9231, -9229, -9226, -9224, -9221, -9219, -9217, -9214, -9231, -9125, -9546};