/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0103 256 samples */
 
const int16_t AKWF_oscchip_0103_256_DATA [256] = 
{17564, 30958, 28742, 29169, 29161, 29158, 29113, 29347, 27666, 25917, 26153, 26103, 26099, 26090, 26065, 26210, 23290, 21814, 22070, 22017, 22011, 22002, 21924, 22351, 17840, 14489, 14997, 14897, 14892, 14887, 14947, 14583, 17295, 20217, 19851, 19911, 19908, 19894, 19814, 20270, 13102, 9185, 9904, 9766, 9762, 9762, 10031, 8517, 22589, 33936, 32163, 32478, 32472, 32467, 32441, 32545, 31755, 30833, 30938, 30911, 30904, 30894, 30864, 31009, 28823, 27655, 27870, 27820, 27814, 27805, 27758, 27975, 26078, 24539, 24785, 24730, 24723, 24717, 24651, 24961, 22860, 20376, 20694, 20626, 20620, 20609, 20576, 20764, 17887, 16318, 16595, 16537, 16532, 16525, 16484, 16689, 14797, 13282, 13510, 13461, 13457, 13434, 13428, 13560, 5883, 2849, 3433, 3321, 3317, 3292, 3045, 4559, -17015, -29821, -27634, -28033, -28032, -28030, -27981, -28245, -25828, -23733, -24027, -23969, -23965, -23956, -23946, -24008, -21689, -20755, -20941, -20900, -20895, -20888, -20842, -21074, -18311, -16570, -16877, -16812, -16808, -16803, -16757, -16973, -15194, -13551, -13793, -13744, -13739, -13723, -13706, -13891, -8468, -6280, -6726, -6636, -6634, -6627, -6572, -6899, -3053, -711, -1137, -1052, -1052, -1050, -1020, -1174, 20, 1113, 946, 979, 978, 943, 894, 1516, -17095, -25002, -23500, -23777, -23774, -23775, -23816, -23528, -26941, -29104, -28739, -28802, -28795, -28790, -28760, -28897, -27718, -26624, -26769, -26734, -26729, -26719, -26701, -26786, -24551, -23503, -23693, -23651, -23645, -23637, -23620, -23674, -23005, -22540, -22610, -22589, -22582, -22577, -22544, -22681, -21549, -20407, -20551, -20517, -20512, -20502, -20480, -20590, -18330, -17276, -17481, -17435, -17431, -17423, -17372, -17631, -14952, -13099, -13418, -13353, -13349, -13346, -13198, -13971, -8382, -2536, -3365, -3209, -3207, -3200, -3185, -3283, -1408, -530, -697, -663, -663, -672, -614, -894};