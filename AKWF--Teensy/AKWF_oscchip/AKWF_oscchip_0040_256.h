/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0040 256 samples */
 
const int16_t AKWF_oscchip_0040_256_DATA [256] = 
{2101, 2402, 2331, 2345, 2346, 2361, 2311, 2513, 4509, 4979, 4869, 4893, 4893, 4907, 4869, 4966, 8739, 10211, 9914, 9971, 9968, 9970, 9974, 9893, 12199, 13529, 13294, 13337, 13329, 13351, 13233, 13758, 16437, 16769, 16673, 16687, 16680, 16692, 16619, 16880, 19534, 20151, 20000, 20023, 20014, 20013, 19988, 20026, 21906, 22635, 22480, 22501, 22490, 22476, 22487, 22368, 22036, 22013, 22009, 21997, 21987, 21980, 21955, 22010, 22335, 22365, 22344, 22337, 22326, 22314, 22302, 22292, 22281, 22271, 22261, 22248, 22237, 22227, 22216, 22204, 22193, 22182, 22171, 22158, 22148, 22138, 22129, 22115, 22103, 22093, 22081, 22070, 22059, 22048, 22036, 22025, 22015, 22002, 21991, 21980, 21970, 21959, 21947, 21936, 21926, 21913, 21903, 21892, 21879, 21867, 21858, 21847, 21835, 21824, 21814, 21803, 21795, 21276, 23809, 10291, -30061, -31642, -31065, -31252, -31257, -31231, -31349, -30793, -28119, -27787, -27871, -27842, -27836, -27812, -27870, -27593, -24925, -24291, -24427, -24386, -24377, -24357, -24394, -24082, -23474, -23478, -23468, -23455, -23443, -23426, -23455, -23229, -22574, -22536, -22533, -22521, -22507, -22478, -22555, -22128, -20113, -19857, -19912, -19884, -19874, -19869, -19834, -19924, -20912, -21135, -21068, -21068, -21058, -21008, -21214, -19844, -17137, -17200, -17188, -17173, -17163, -17120, -17273, -16401, -13807, -13697, -13725, -13704, -13695, -13685, -13690, -13614, -13273, -13220, -13224, -13215, -13207, -13191, -13234, -12838, -12294, -12330, -12316, -12309, -12302, -12281, -12346, -11887, -10980, -10998, -10991, -10982, -10976, -10945, -11063, -10406, -8462, -8381, -8405, -8388, -8383, -8368, -8406, -8194, -7191, -7060, -7089, -7078, -7071, -7054, -7126, -6538, -5727, -5789, -5777, -5772, -5767, -5761, -5779, -5623, -5321, -5327, -5322, -5317, -5314, -5271, -5470, -4388, -1156, -1028, -1072, -1054, -1052, -1032, -1127, -626};