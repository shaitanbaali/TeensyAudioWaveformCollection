/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0070 256 samples */
 
const int16_t AKWF_oscchip_0070_256_DATA [256] = 
{448, 518, 497, 500, 500, 505, 491, 547, 1123, 1209, 1185, 1189, 1187, 1487, -125, 7844, 31012, 30725, 30711, 30751, 30750, 30747, 30743, 30738, 30734, 30729, 30723, 30719, 30714, 30407, 31661, 26711, -23561, -32019, -30125, -30511, -30521, -30516, -30549, -30375, -29830, -29827, -29826, -29819, -29816, -29603, -30658, -25714, 143, 2262, 1705, 1841, 1844, 1849, 1840, 1889, 2455, 2566, 2541, 2548, 2549, 2557, 2524, 2687, 3235, 3241, 3236, 3238, 3238, 3233, 3255, 3160, 2590, 2540, 2554, 2551, 2551, 2551, 2551, 2549, 2548, 2549, 2549, 2548, 2546, 2547, 2547, 2545, 2543, 2544, 2544, 2542, 2541, 2542, 2541, 2539, 2540, 2540, 2538, 2537, 2538, 2537, 2535, 2536, 2535, 2533, 2534, 2533, 2532, 2525, 2558, 2396, 1844, 1834, 1838, 1835, 1836, 1836, 1834, 1833, 1834, 1833, 1832, 1832, 1832, 1824, 1862, 1642, 1125, 1143, 1138, 1135, 1136, 1130, 1159, 1014, 463, 444, 449, 447, 446, 424, 535, 37, -3360, -3754, -3654, -3676, -3675, -3737, -3410, -5081, -9308, -9157, -9168, -9175, -9176, -9221, -8983, -10080, -14563, -14703, -14643, -14659, -14657, -14711, -14440, -15568, -24172, -25167, -24894, -24950, -24946, -24688, -26060, -19089, -1679, -2344, -2250, -2225, -2220, -2152, -2478, -978, 5171, 5403, 5334, 5358, 5359, 5369, 5332, 5481, 6621, 6762, 6726, 6734, 6734, 6734, 6732, 6732, 6732, 6730, 6730, 6728, 6727, 6726, 6725, 6724, 6721, 6720, 6719, 6717, 6716, 6715, 6713, 6712, 6710, 6709, 6707, 6705, 6703, 6688, 6759, 6379, 5309, 5322, 5324, 5320, 5318, 5277, 5480, 4508, 7, -254, -171, -196, -196, -249, -19, -991, -10103, -11476, -11130, -11199, -11199, -11105, -11600, -9177, -2114, -2270, -2266, -2250, -2248, -2234, -2304, -1958};