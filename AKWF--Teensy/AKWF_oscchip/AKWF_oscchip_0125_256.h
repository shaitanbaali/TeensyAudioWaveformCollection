/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0125 256 samples */
 
const int16_t AKWF_oscchip_0125_256_DATA [256] = 
{28385, 31009, 30384, 30495, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30500, 30177, 31873, 22707, -1552, -1476, -1374, -1443, -1444, -1445, -1444, -1444, -1444, -1444, -1444, -1444, -1444, -1442, -1454, -1399, -1012, -954, -967, -963, -962, -961, -967, -943, -565, -467, -488, -485, -484, -480, -505, -366, 1, 0, -2, -1, 0, -20, 76, -394, -2307, -2432, -2393, -2403, -2403, -2403, -2403, -2403, -2403, -2403, -2403, -2403, -2403, -2400, -2413, -2365, -1605, -1410, -1453, -1444, -1444, -1435, -1486, -1210, -480, -483, -487, -485, -484, -477, -515, -326, 440, 490, 475, 480, 481, 475, 500, 388, -390, -506, -478, -485, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -484, -728, 481, -5445, -29521, -31081, -30618, -30741, -30742, -30743, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30742, -30389, -32293, -22078};