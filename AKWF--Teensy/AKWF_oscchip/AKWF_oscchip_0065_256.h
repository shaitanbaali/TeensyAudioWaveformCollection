/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0065 256 samples */
 
const int16_t AKWF_oscchip_0065_256_DATA [256] = 
{608, 751, 725, 730, 731, 740, 691, 949, 1710, 1710, 1706, 1709, 1709, 1722, 1654, 1972, 3571, 3693, 3662, 3669, 3667, 3679, 3616, 3958, 4682, 4638, 4641, 4641, 4640, 4666, 4521, 5233, 7570, 7580, 7565, 7573, 7571, 7595, 7466, 8038, 11273, 11539, 11458, 11474, 11472, 11469, 11467, 11465, 11463, 11461, 11457, 11455, 11452, 11488, 11284, 12229, 15369, 15357, 15344, 15348, 15345, 15348, 15312, 15448, 16256, 16320, 16298, 16297, 16294, 16313, 16185, 16866, 18299, 18222, 18229, 18226, 18222, 18235, 18136, 18597, 20148, 20162, 20150, 20149, 20143, 20146, 20109, 20244, 21043, 21111, 21087, 21087, 21081, 21092, 21001, 21473, 22564, 22517, 22516, 22514, 22508, 22522, 22410, 22947, 24892, 24944, 24916, 24917, 24911, 24912, 24878, 24994, 25793, 25875, 25846, 25844, 25838, 25845, 25764, 26139, 27071, 27023, 27019, 27015, 27005, 26513, 29011, 16413, -31020, -32390, -31822, -32016, -32019, -32014, -32041, -31926, -31105, -31010, -31032, -31023, -31021, -30972, -31210, -29945, -26979, -27104, -27080, -27069, -27063, -27009, -27249, -26120, -21732, -21626, -21655, -21636, -21628, -21608, -21670, -21388, -19355, -19108, -19160, -19141, -19136, -19115, -19193, -18737, -17620, -17642, -17637, -17629, -17623, -17602, -17680, -17273, -15700, -15627, -15640, -15630, -15625, -15591, -15751, -14785, -13053, -13178, -13154, -13147, -13143, -13113, -13243, -12543, -10642, -10674, -10674, -10667, -10662, -10656, -10670, -10578, -10175, -10151, -10155, -10150, -10146, -10131, -10197, -9805, -9107, -9162, -9149, -9146, -9142, -9124, -9204, -8796, -7638, -7665, -7662, -7658, -7656, -7645, -7681, -7507, -6695, -6656, -6665, -6659, -6657, -6648, -6680, -6488, -6140, -6162, -6156, -6154, -6151, -6125, -6261, -5565, -3665, -3698, -3696, -3691, -3689, -3664, -3778, -3262, -853, -720, -756, -745, -745, -740, -757, -671};