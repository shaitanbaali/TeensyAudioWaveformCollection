/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0124 256 samples */
 
const int16_t AKWF_oscchip_0124_256_DATA [256] = 
{531, 581, 569, 573, 574, 658, 273, 1997, 14006, 15812, 15371, 15466, 15467, 15520, 15329, 16048, 27382, 30306, 29669, 29794, 29793, 29800, 29791, 29789, 31945, 32798, 32630, 32662, 32662, 32661, 32661, 32661, 32661, 32661, 32661, 32661, 32661, 32645, 32719, 32387, 30075, 29727, 29812, 29793, 29793, 29774, 29843, 29584, 25508, 24455, 24683, 24639, 24639, 24627, 24643, 24647, 20769, 19236, 19537, 19479, 19480, 19443, 19627, 18728, 15079, 14843, 14914, 14893, 14893, 14880, 14939, 14674, 12829, 12550, 12618, 12603, 12603, 12592, 12630, 12487, 10222, 9638, 9765, 9740, 9738, 9735, 9739, 9739, 8881, 8541, 8606, 8592, 8593, 8579, 8648, 8310, 6941, 6852, 6877, 6870, 6870, 6860, 6904, 6706, 5322, 5114, 5165, 5154, 5154, 5149, 5165, 5107, 4201, 3966, 4018, 4009, 4009, 4004, 4010, 4011, 2719, 2209, 2309, 2289, 2290, 2280, 2326, 2102, 1190, 1132, 1150, 1144, 1145, 958, 1804, -1980, -28316, -32276, -31309, -31516, -31516, -31512, -31528, -31470, -30563, -30330, -30381, -30371, -30371, -30360, -30375, -30378, -26934, -25574, -25841, -25790, -25791, -25744, -25974, -24850, -20290, -19994, -20082, -20059, -20059, -20039, -20128, -19730, -16959, -16542, -16643, -16623, -16623, -16618, -16634, -16576, -15665, -15432, -15482, -15471, -15472, -15469, -15472, -15473, -14612, -14272, -14340, -14326, -14327, -14299, -14436, -13763, -11030, -10852, -10905, -10891, -10891, -10864, -10983, -10451, -6753, -6198, -6334, -6304, -6304, -6291, -6336, -6164, -3447, -2746, -2899, -2867, -2868, -2873, -2866, -2864, -4588, -5268, -5134, -5159, -5158, -5145, -5213, -4877, -3510, -3421, -3448, -3443, -3442, -3436, -3466, -3333, -2409, -2269, -2302, -2297, -2296, -2292, -2307, -2250, -1344, -1110, -1160, -1149, -1148, -1147, -1149, -1150, -721, -550, -584, -577, -577, -571, -607, -414};