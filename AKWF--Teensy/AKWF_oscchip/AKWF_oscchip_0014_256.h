/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0014 256 samples */
 
const int16_t AKWF_oscchip_0014_256_DATA [256] = 
{16150, 27870, 25462, 25926, 25921, 25888, 25998, 25632, 18128, 16211, 16612, 16526, 16522, 16516, 16510, 16503, 16496, 16489, 16481, 16475, 16467, 16410, 16583, 15876, 6872, 4916, 5361, 5264, 5259, 5215, 5359, 4775, -981, -2053, -1813, -1865, -1872, -1976, -1528, -3433, -20071, -22626, -22014, -22140, -22138, -22023, -22530, -20254, -3669, -1382, -1964, -1836, -1831, -1828, -1823, -1818, -1818, -1814, -1809, -1808, -1807, -1805, -1800, -1798, -1798, -1797, -1796, -1790, -1788, -1788, -1786, -1787, -1786, -1782, -1778, -1779, -1779, -1777, -1776, -1777, -1776, -1774, -1769, -1768, -1769, -1768, -1766, -1766, -1767, -1766, -1765, -1761, -1758, -1759, -1759, -1758, -1756, -1757, -1757, -1756, -1755, -1751, -1748, -1749, -1747, -1746, -1746, -1747, -1745, -1744, -1745, -1741, -1738, -1739, -1738, -1736, -1737, -1737, -1736, -1735, -1735, -1733, -1728, -1728, -1729, -1726, -1730, -1715, -1315, -1197, -1225, -1214, -1212, -1233, -1161, -1398, -6264, -7502, -7236, -7285, -7285, -7306, -7223, -7515, -12446, -13550, -13295, -13341, -13335, -13314, -13378, -13095, -9808, -9132, -9285, -9248, -9242, -9208, -9328, -8830, -3893, -2972, -3176, -3128, -3124, -3088, -3228, -2607, 2799, 3633, 3438, 3483, 3485, 3483, 3445, 3680, 710, -1351, -1011, -1071, -1070, -1066, -1033, -1257, 1843, 3747, 3432, 3488, 3488, 3487, 3479, 3530, 2824, 2413, 2488, 2474, 2470, 2454, 2400, 2789, -4347, -8258, -7530, -7671, -7668, -7644, -7587, -8139, 5414, 12070, 10862, 11087, 11086, 11109, 11137, 10754, 21904, 26777, 25835, 26008, 26000, 25947, 25918, 26356, 8321, 642, 2186, 1873, 1872, 1894, 1855, 1796, 11019, 14583, 13862, 13993, 13985, 13926, 14013, 13925, -4618, -10871, -9621, -9861, -9863, -9925, -9793, -10091, -27672, -33103, -31922, -32147, -32139, -32058, -32438, -30692};