/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0145 256 samples */
 
const int16_t AKWF_oscchip_0145_256_DATA [256] = 
{15550, 17131, 16756, 16823, 16825, 16862, 16693, 17448, 22703, 23492, 23300, 23341, 23341, 23360, 23258, 23883, 25023, 24960, 24969, 24969, 24969, 24991, 24876, 25498, 27146, 27142, 27135, 27140, 27140, 27140, 27140, 27140, 27140, 27140, 27140, 27140, 27140, 27134, 27162, 27036, 26162, 26029, 26063, 26056, 26056, 26062, 26029, 26236, 26615, 26595, 26598, 26597, 26597, 26592, 26621, 26465, 26052, 26054, 26058, 26056, 26056, 26056, 26056, 26056, 26056, 26056, 26056, 26056, 26056, 26053, 26067, 26004, 25566, 25499, 25515, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25512, 25369, 26119, 22069, 11349, 11383, 11428, 11397, 11396, 11483, 11049, 13175, 21813, 22374, 22206, 22251, 22252, 22280, 22153, 22720, 26660, 27253, 27110, 27140, 27140, 27202, 26863, 28949, 32749, 32534, 32564, 32567, 32568, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32567, 32496, 32820, 31373, 21304, 19791, 20161, 20081, 20080, 19640, 22051, 7240, -19753, -18216, -18426, -18458, -18459, -18552, -18062, -20710, -27718, -27695, -27666, -27688, -27689, -27707, -27620, -28044, -29769, -29881, -29849, -29859, -29858, -29865, -29837, -29963, -30839, -30971, -30939, -30945, -30946, -30933, -31001, -30583, -29820, -29864, -29860, -29858, -29858, -29875, -29788, -30256, -31493, -31489, -31485, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31488, -31373, -31978, -28706, -20048, -20076, -20111, -20087, -20087, -19873, -21021, -14865};