/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0112 256 samples */
 
const int16_t AKWF_oscchip_0112_256_DATA [256] = 
{18, 12, 15, 14, 14, 16, 17, 16, 17, 17, 17, 17, 17, 20, 1, 89, 509, 539, 532, 533, 534, 540, 506, 691, 1071, 1049, 1052, 1052, 1050, 1051, 1051, 1051, 1051, 1051, 1051, 1051, 1051, 1050, 1049, 1049, 1049, 1049, 1049, 1049, 1049, 1049, 1047, 1046, 1047, 1047, 1047, 1047, 1045, 1331, -168, 6943, 29774, 29583, 29524, 29574, 29572, 29557, 29608, 29373, 28077, 27975, 27996, 27985, 27979, 27937, 28131, 27010, 24739, 24856, 24831, 24822, 24816, 24781, 24930, 24160, 21689, 21670, 21672, 21660, 21655, 21620, 21754, 21127, 17709, 17420, 17482, 17460, 17454, 17401, 17647, 16253, 13177, 13298, 13282, 13271, 13267, 13235, 13372, 12649, 10174, 10113, 10134, 10122, 10118, 9977, 10725, 6248, -843, -159, -275, -277, -280, -652, 1322, -8981, -33448, -32294, -32420, -32456, -32454, -32414, -32598, -31709, -28339, -28260, -28289, -28271, -28268, -28219, -28445, -27071, -24964, -25164, -25121, -25114, -25109, -25054, -25310, -23937, -20806, -20952, -20922, -20912, -20906, -20871, -21010, -20335, -17803, -17755, -17767, -17754, -17748, -17650, -18153, -15063, -10133, -10533, -10459, -10450, -10447, -10382, -10710, -8905, -4614, -4738, -4724, -4711, -4708, -4688, -4774, -4329, -2671, -2608, -2624, -2618, -2616, -2595, -2699, -2072, -980, -1063, -1050, -1047, -1046, -1045, -1043, -1044, -1042, -1041, -1041, -1040, -1039, -1035, -1054, -955, -533, -513, -521, -518, -517, -510, -547, -336, 29, -3, 5, 4, 5, 4, 5, 7, 6, 7, 7, 7, 6, -6, 57, -226, -1509, -1561, -1543, -1548, -1548, -1548, -1548, -1548, -1549, -1547, -1546, -1547, -1547, -1536, -1595, -1293, -492, -510, -509, -509, -508, -509, -508, -507, -506, -507, -506, -506, -506, -501, -531, -349};