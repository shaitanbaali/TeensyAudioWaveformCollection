/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_oscchip_0140 256 samples */
 
const int16_t AKWF_oscchip_0140_256_DATA [256] = 
{11635, 20268, 18813, 19089, 19085, 19091, 19190, 18595, 24902, 30027, 29266, 29408, 29407, 29417, 29376, 29531, 31981, 32612, 32475, 32499, 32498, 32499, 32498, 32498, 32694, 32770, 32757, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32760, 32758, 32755, 32783, 32247, 31941, 31996, 31985, 31985, 31985, 31975, 32035, 31403, 30892, 30967, 30952, 30952, 30930, 31012, 30702, 25805, 24541, 24815, 24764, 24764, 24727, 24777, 24787, 13148, 8551, 9456, 9282, 9284, 9254, 9156, 9945, -5015, -13604, -12101, -12388, -12384, -12392, -12536, -11673, -20815, -28244, -27142, -27347, -27348, -27361, -27313, -27493, -30350, -31088, -30926, -30958, -30957, -30960, -30957, -30956, -31732, -32039, -31976, -31988, -31988, -31987, -31987, -31987, -31987, -31987, -31987, -31987, -31987, -31988, -31993, -31963, -32280, -32537, -32498, -32504, -32505, -32504, -32504, -32504, -32504, -32504, -32504, -32504, -32504, -32503, -32505, -32505, -32118, -31965, -31994, -31987, -31988, -31987, -31987, -31987, -31987, -31987, -31987, -31987, -31987, -31987, -31982, -32012, -31699, -31443, -31480, -31474, -31473, -31470, -31483, -31432, -30615, -30405, -30451, -30443, -30444, -30436, -30446, -30448, -28119, -27199, -27381, -27347, -27348, -27345, -27338, -27395, -26324, -25711, -25819, -25800, -25801, -25800, -25795, -25825, -25509, -25252, -25289, -25280, -25281, -25280, -25250, -25420, -24083, -22560, -22735, -22704, -22703, -22695, -22706, -22709, -19992, -18918, -19131, -19090, -19090, -19084, -19063, -19232, -16026, -14186, -14509, -14444, -14444, -14443, -14413, -14592, -12701, -11166, -11394, -11353, -11354, -11353, -11311, -11549, -9673, -7541, -7785, -7743, -7742, -7734, -7745, -7748, -5032, -3960, -4170, -4129, -4130, -4129, -4129, -4129};