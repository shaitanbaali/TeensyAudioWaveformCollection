/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0016 256 samples */
 
const int16_t AKWF_hvoice_0016_256_DATA [256] = 
{197, 834, 1331, 1613, 1656, 1520, 1327, 1201, 1208, 1334, 1503, 1635, 1693, 1692, 1694, 1779, 2014, 2442, 3070, 3880, 4844, 5928, 7083, 8241, 9292, 10127, 10677, 10940, 11002, 10985, 10993, 11079, 11245, 11468, 11721, 11976, 12213, 12435, 12676, 13003, 13505, 14234, 15159, 16169, 17113, 17877, 18439, 18864, 19276, 19805, 20523, 21398, 22296, 23004, 23308, 23063, 22245, 20956, 19337, 17500, 15457, 13137, 10473, 7423, 4016, 383, -3308, -6848, -10001, -12571, -14398, -15399, -15603, -15128, -14175, -13009, -11943, -11268, -11176, -11708, -12776, -14225, -15906, -17740, -19729, -21865, -24078, -26245, -28223, -29918, -31273, -32224, -32717, -32705, -32164, -31130, -29716, -28096, -26413, -24740, -23116, -21547, -20002, -18392, -16596, -14558, -12291, -9777, -6994, -4010, -1011, 1738, 4054, 5887, 7243, 8160, 8731, 9079, 9292, 9394, 9386, 9323, 9319, 9496, 9937, 10678, 11703, 12987, 14521, 16312, 18351, 20547, 22707, 24628, 26140, 27139, 27603, 27567, 27109, 26306, 25201, 23819, 22170, 20293, 18271, 16197, 14165, 12189, 10175, 8034, 5760, 3480, 1439, -138, -1167, -1722, -1996, -2183, -2374, -2551, -2647, -2618, -2471, -2270, -2107, -2065, -2204, -2540, -3059, -3720, -4476, -5304, -6213, -7236, -8401, -9682, -11001, -12262, -13361, -14235, -14865, -15266, -15462, -15470, -15283, -14879, -14223, -13298, -12100, -10656, -9030, -7295, -5534, -3840, -2282, -907, 244, 1138, 1719, 1915, 1679, 1020, 35, -1113, -2237, -3176, -3845, -4222, -4328, -4192, -3843, -3308, -2621, -1836, -1038, -322, 226, 565, 719, 760, 773, 788, 764, 608, 255, -274, -889, -1475, -1975, -2420, -2895, -3462, -4124, -4816, -5460, -6015, -6478, -6866, -7183, -7405, -7493, -7404, -7107, -6597, -5900, -5089, -4271, -3554, -3013, -2649, -2397, -2168, -1881, -1491, -991, -380};