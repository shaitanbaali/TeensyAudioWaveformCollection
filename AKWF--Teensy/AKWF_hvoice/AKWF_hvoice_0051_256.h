/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0051 256 samples */
 
const int16_t AKWF_hvoice_0051_256_DATA [256] = 
{520, 1303, 1480, 1528, 1195, 1433, 2037, 2247, 2535, 2643, 3197, 3824, 4293, 4870, 4901, 4859, 5270, 5482, 5390, 5432, 5936, 6850, 7629, 8312, 9269, 9596, 10311, 10614, 10472, 11851, 12755, 13303, 13277, 12906, 14108, 15951, 16860, 17358, 17748, 17430, 19126, 20055, 19368, 19774, 19482, 20599, 21575, 20764, 21673, 22791, 23202, 24284, 25112, 24503, 24603, 24183, 23167, 24017, 25060, 26269, 24568, 19706, 18792, 21196, 22738, 25868, 31869, 31008, 16143, -2036, -9175, -5871, 713, 3508, 2217, 1432, 1753, 4617, 7159, 5887, 2836, 331, -2067, -3663, -4890, -7256, -8196, -8641, -8274, -6874, -8002, -8871, -9113, -9862, -9763, -11183, -13397, -13698, -13243, -13021, -12174, -13278, -14014, -12833, -12690, -12137, -12366, -13818, -13610, -13805, -14147, -14314, -15251, -15098, -13782, -13238, -12946, -13056, -13438, -12602, -12690, -13479, -13702, -14465, -13624, -12766, -13139, -12560, -12291, -12446, -11900, -11858, -11860, -11097, -10876, -11007, -10422, -10294, -10145, -9622, -9472, -9114, -8831, -8795, -8695, -8549, -8055, -7423, -7002, -6398, -6597, -6767, -6328, -6040, -5799, -5770, -5418, -5273, -5689, -5154, -4358, -4166, -3450, -3351, -4055, -4111, -3850, -2880, -2069, -2195, -2587, -2602, -2393, -2544, -2237, -2116, -2377, -1997, -1684, -1261, -1615, -2122, -1190, -596, -504, -410, -1425, -1784, -1250, -1388, -1171, -1375, -2065, -1356, -942, -1112, -785, -625, -585, -939, -1352, -1601, -1456, -1469, -1950, -2320, -2340, -2071, -1459, -944, -1120, -1528, -2252, -2269, -1939, -1761, -1872, -2761, -3409, -2718, -1757, -1788, -2315, -2800, -2476, -1650, -1817, -2883, -3070, -2470, -1782, -1925, -2766, -2852, -2516, -1819, -1436, -1885, -2104, -2268, -1852, -806, -878, -1209, -1024, -1579, -1626, -929, -384, 157, 154, 139, -93, -414, -166, -109};