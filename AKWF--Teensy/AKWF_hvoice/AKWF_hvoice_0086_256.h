/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0086 256 samples */
 
const int16_t AKWF_hvoice_0086_256_DATA [256] = 
{514, 1033, 1543, 2371, 3040, 3315, 3094, 2904, 3949, 5687, 6727, 6805, 6167, 5883, 6747, 7518, 7117, 6487, 6478, 7347, 8651, 8874, 7941, 7217, 7072, 6950, 6698, 6536, 6797, 7820, 8264, 6895, 5091, 4143, 4474, 5659, 6051, 5252, 4443, 4158, 4152, 4012, 3322, 2485, 2207, 2441, 2894, 3291, 3539, 3269, 2344, 1268, 482, 879, 2288, 3288, 3414, 2871, 2311, 2541, 3063, 2917, 2456, 2378, 2920, 4013, 4994, 5500, 5387, 4825, 4230, 3958, 4710, 6177, 7405, 8015, 7946, 7639, 7488, 7555, 7745, 8391, 9718, 10818, 11159, 10872, 10397, 10751, 11839, 12428, 12313, 12012, 12120, 13197, 14437, 14801, 14514, 14091, 14006, 14374, 14886, 15357, 15976, 16683, 16632, 15831, 15047, 14711, 15083, 15738, 16149, 16202, 15976, 15737, 15644, 15397, 14685, 12008, 7338, 4252, 4168, 7256, 10774, 8962, 2866, -3332, -6819, -6113, -4739, -6254, -9280, -11635, -12956, -13858, -15940, -19407, -22157, -23434, -24002, -24540, -25167, -25938, -27030, -28528, -30643, -32381, -32786, -32428, -32002, -31690, -31386, -31043, -30733, -30967, -31549, -31363, -30282, -28804, -27276, -25718, -24103, -22331, -21166, -21301, -21196, -19674, -17040, -13999, -11776, -10523, -9301, -7799, -6580, -5608, -4203, -2311, -101, 1933, 3384, 4653, 6200, 7324, 7558, 7710, 8391, 9950, 12014, 13423, 13909, 13717, 13281, 12855, 12738, 13286, 14088, 14679, 14698, 14047, 13209, 12491, 11745, 10864, 10135, 9679, 9554, 9446, 8677, 7271, 5486, 3813, 2622, 1941, 1677, 1412, 887, -139, -1652, -3220, -4591, -5569, -6210, -6643, -6950, -7089, -7306, -8016, -9044, -10068, -10784, -11072, -11043, -10809, -10315, -9603, -9393, -9852, -10589, -11112, -10761, -9707, -8460, -7396, -6692, -6322, -6241, -6244, -6193, -5642, -4398, -2761, -1083, -127, 8, -360, -742, -452};