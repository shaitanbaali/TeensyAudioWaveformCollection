/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0038 256 samples */
 
const int16_t AKWF_hvoice_0038_256_DATA [256] = 
{2533, 6593, 7674, 5633, 6644, 9938, 12754, 13808, 13743, 15070, 15687, 16849, 18481, 20511, 21167, 19472, 20016, 20626, 20768, 19599, 19691, 21023, 19645, 18018, 16237, 17219, 16507, 15597, 14861, 15247, 14605, 12029, 10735, 12028, 14181, 15328, 11632, 10836, 10027, 13010, 14216, 13782, 11955, 7839, 9864, 10771, 13096, 9699, 8042, 6805, 7605, 6970, 7412, 6868, 8131, 5625, 2801, 683, 1512, 1891, -854, -3916, -6350, -9022, -11728, -15029, -16668, -17493, -19922, -23235, -27151, -28400, -30104, -30110, -30103, -30152, -31065, -32692, -32483, -30325, -27324, -25162, -23374, -21929, -19922, -17907, -13606, -9672, -5598, -3868, -2861, -415, 2366, 5236, 5948, 7720, 8103, 8091, 7458, 7523, 8090, 8499, 8113, 6959, 6019, 4916, 3336, 2899, 3625, 3319, 1597, 46, -993, -712, 1309, 2480, 2688, 2581, 3411, 4270, 4801, 4473, 5509, 7330, 10676, 9494, 8219, 5771, 7833, 10226, 12060, 11529, 9237, 7980, 8516, 9390, 9914, 7575, 6948, 6538, 7811, 5347, 2289, 484, 1690, 2093, 1241, -1282, -2226, -2789, -854, -157, 1124, -298, -1225, -754, 3056, 4862, 3633, 1435, 2813, 5308, 7961, 6670, 5450, 5366, 6915, 7284, 5634, 5214, 4432, 6999, 6072, 4870, 2068, 2048, 3671, 4011, 5099, 2571, 1469, 1377, 1443, 2595, 3524, 5895, 3216, -288, 1209, 4356, 7779, 4898, 2572, 3158, 5403, 6530, 6498, 8474, 8531, 2761, 407, 4708, 11550, 10721, 1932, -1027, 1728, 4528, 2483, 6, 2829, 2516, -793, -5848, -4970, -903, -2656, -6284, -8697, -9732, -12594, -16950, -16807, -15582, -16565, -22135, -26794, -26227, -24936, -25548, -26625, -26790, -26903, -29330, -28996, -25708, -22815, -23045, -26304, -24451, -20757, -18109, -19481, -19391, -16121, -14167, -13381, -13210, -11225, -8910, -7811, -5886, -3380, -1378, -1957, -1734};