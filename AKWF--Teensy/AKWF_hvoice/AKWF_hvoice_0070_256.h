/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0070 256 samples */
 
const int16_t AKWF_hvoice_0070_256_DATA [256] = 
{623, 1767, 2480, 2936, 3249, 3529, 3818, 4312, 4644, 4667, 4402, 4044, 3771, 3642, 3353, 2925, 2584, 2431, 2243, 1851, 1265, 801, 641, 640, 509, 317, 53, 27, 444, 911, 962, 1064, 1597, 1834, 1979, 2334, 2917, 3058, 3450, 4089, 4538, 4687, 5033, 5639, 6093, 6330, 6374, 6480, 6772, 7092, 7473, 7906, 8159, 8150, 8117, 8375, 8730, 8923, 8850, 8818, 9210, 9884, 10265, 10471, 10692, 10928, 10983, 11272, 11699, 11851, 11732, 11447, 11153, 11058, 11029, 10670, 10262, 10160, 10217, 9802, 9273, 8842, 8357, 7817, 7579, 7588, 6596, 4868, 3694, 3543, 3354, 2837, 3242, 2844, -327, -5500, -8984, -10261, -12648, -15994, -19380, -22056, -24918, -27315, -28590, -29721, -31097, -32436, -32718, -31811, -30531, -29448, -28474, -26943, -24521, -21580, -18656, -15928, -13225, -10387, -7472, -4110, -833, 1673, 3751, 5976, 8378, 10556, 12264, 13062, 13476, 13997, 14466, 14243, 13766, 12857, 11586, 10060, 8577, 6952, 5138, 3211, 1220, -708, -2449, -4073, -5908, -7893, -9500, -10538, -11538, -12647, -13329, -13778, -13940, -13799, -13326, -12839, -11889, -10544, -9118, -7815, -6339, -4659, -2801, -1052, 421, 1858, 3672, 5562, 7181, 8362, 9138, 9834, 10719, 11553, 11924, 11847, 11311, 10662, 10313, 10082, 9012, 7441, 5942, 4865, 3801, 2616, 953, -802, -2303, -3454, -4426, -4989, -5851, -7016, -7746, -7643, -7419, -7469, -7342, -7267, -6896, -6079, -5036, -4455, -3654, -2681, -1687, -671, 758, 1887, 2418, 2959, 3963, 5181, 5895, 6167, 6480, 6714, 6902, 7023, 7014, 6270, 5230, 4488, 4041, 3550, 2875, 1851, 502, -510, -1034, -1470, -2338, -3548, -4668, -5382, -5790, -6147, -6497, -6914, -7288, -7162, -6539, -5850, -5607, -5540, -5108, -4272, -3395, -2839, -2494, -2195, -1526, -461};