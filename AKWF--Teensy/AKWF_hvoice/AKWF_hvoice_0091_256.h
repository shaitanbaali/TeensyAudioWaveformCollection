/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0091 256 samples */
 
const int16_t AKWF_hvoice_0091_256_DATA [256] = 
{220, 789, 1246, 1627, 1952, 2182, 2300, 2346, 2423, 2660, 3094, 3731, 4442, 5023, 5373, 5473, 5515, 5482, 5326, 4922, 4508, 4218, 4141, 4099, 4137, 4322, 4637, 4893, 5017, 5067, 5163, 5245, 5207, 5010, 4770, 4587, 4605, 4848, 5269, 5782, 6299, 6863, 7490, 8249, 8926, 9484, 9906, 10518, 11207, 11889, 12395, 13039, 13814, 14627, 15248, 15749, 16182, 16550, 16906, 17221, 17439, 17376, 17163, 16922, 16831, 16832, 16821, 16640, 16138, 15432, 14658, 14060, 13596, 13009, 11873, 10064, 8237, 6909, 6134, 5962, 6099, 6111, 3515, -1298, -7570, -11768, -14481, -16490, -19329, -21963, -24247, -26025, -27673, -28175, -27628, -26736, -27506, -29413, -31663, -32604, -32377, -31180, -29463, -27792, -26203, -24583, -22058, -18809, -15236, -12227, -10110, -8798, -8051, -7017, -5277, -2886, -441, 1453, 2918, 4217, 5734, 7372, 8902, 9808, 9728, 8804, 7329, 5933, 4834, 4073, 3408, 2585, 1607, 546, -245, -841, -1404, -2369, -3834, -5642, -7520, -9153, -10378, -11123, -11474, -11618, -11526, -11111, -10345, -9531, -8844, -8288, -7690, -7069, -6498, -5918, -5051, -3751, -2120, -488, 1039, 2429, 3739, 4979, 6143, 7167, 7893, 8331, 8565, 8778, 8931, 9003, 9051, 9136, 9138, 8814, 8230, 7647, 7219, 6716, 5867, 4711, 3487, 2372, 1370, 474, -283, -1065, -1923, -2912, -3629, -4025, -4123, -4279, -4521, -4809, -4990, -5101, -5099, -4947, -4540, -4071, -3631, -3340, -2884, -2223, -1376, -702, -217, 141, 591, 1057, 1484, 1829, 2212, 2659, 3124, 3488, 3603, 3477, 3153, 2869, 2577, 2244, 1763, 1324, 918, 520, 23, -457, -866, -1131, -1492, -1993, -2637, -3126, -3412, -3532, -3693, -3925, -4178, -4372, -4472, -4470, -4362, -4146, -3860, -3539, -3224, -2961, -2720, -2456, -2108, -1645, -1074, -400};