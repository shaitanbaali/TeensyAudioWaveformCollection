/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0044 256 samples */
 
const int16_t AKWF_hvoice_0044_256_DATA [256] = 
{532, 1989, 3761, 5331, 6195, 7042, 6512, 5963, 6996, 9022, 7456, 4077, 2985, 3992, 3419, 1781, 2158, 4473, 7616, 11313, 15609, 20427, 23660, 23326, 23244, 23315, 20349, 14262, 10812, 9368, 8137, 6152, 9335, 19610, 26831, 21034, 12618, 13734, 14995, 6009, -7373, -13715, -12854, -11090, -14677, -19466, -20802, -21993, -25755, -27973, -28186, -30484, -32797, -29237, -19251, -10603, -9135, -10355, -7619, -3348, -5485, -13266, -19070, -19893, -19411, -19166, -18513, -17364, -17161, -17709, -16467, -14135, -14533, -17151, -15603, -7762, 1189, 5763, 7556, 11350, 16023, 16820, 12917, 7660, 3788, 1103, -433, -290, 706, 500, -152, 1124, 3546, 3517, 607, -658, 2720, 8099, 11778, 14184, 17486, 21172, 22830, 21553, 18421, 14119, 9440, 5722, 4141, 3363, 1875, 404, 535, 2504, 3606, 1985, 730, 2093, 4608, 7916, 11518, 13756, 16859, 20824, 21607, 18451, 13820, 8206, 2675, -2161, -6256, -7438, -5595, -3288, -1709, 1030, 3862, 4138, 1902, 2555, 5364, 5857, 3089, 1337, 1905, 2795, 646, -3965, -7417, -8653, -10398, -13146, -14930, -14764, -12957, -9736, -6712, -6107, -7042, -7418, -6862, -6497, -7319, -8702, -8669, -6358, -3783, -3404, -6477, -8112, -6831, -4126, -3769, -3985, -3516, 1302, 7094, 12046, 15269, 16463, 15776, 15924, 16801, 14148, 7899, 2428, 1246, 2815, 3182, 3172, 8384, 16882, 16575, 10509, 10436, 12058, 7220, 181, -2986, -1895, 611, -1978, -6653, -6907, -7384, -12576, -17424, -18843, -19342, -19614, -18738, -14147, -7562, -4233, -4130, -2394, 347, 451, -1772, -3034, -1737, 673, 1441, -29, -876, -1574, -5230, -10160, -13299, -14994, -15541, -14108, -11507, -7274, -2349, 1005, 3122, 5532, 6875, 6740, 6078, 5680, 5627, 5977, 5289, 3615, 1273, -908, -3095, -5009, -6849, -7969, -8110, -6186, -3079, -519};