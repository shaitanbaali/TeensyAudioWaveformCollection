/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0065 256 samples */
 
const int16_t AKWF_hvoice_0065_256_DATA [256] = 
{10, 103, 312, 627, 1065, 1459, 1734, 1794, 1563, 1114, 698, 553, 799, 1348, 2020, 2650, 3125, 3250, 3049, 2623, 2058, 1537, 1432, 1864, 2612, 3504, 4291, 4775, 4856, 4498, 3687, 2722, 1932, 1537, 1637, 2277, 3192, 4247, 5346, 6349, 6945, 7199, 7170, 6992, 6800, 6764, 6837, 6919, 7036, 7237, 7519, 7774, 7963, 8069, 8006, 7735, 7296, 6780, 6214, 5703, 5315, 5084, 5031, 5239, 5665, 6132, 6498, 6639, 6433, 5872, 5209, 4617, 4068, 3383, 2495, 1486, 425, -415, -572, 155, 1038, 698, -1701, -6513, -13294, -20829, -27393, -31682, -32800, -30457, -25099, -17888, -10284, -3662, 923, 3098, 3054, 1516, -468, -1992, -2492, -1940, -782, 237, 556, -144, -2021, -4810, -7909, -10653, -12580, -13186, -12336, -10240, -7429, -4465, -1841, 19, 1021, 1293, 1086, 717, 522, 655, 1025, 1412, 1617, 1474, 901, -74, -1345, -2655, -3635, -4070, -3950, -3361, -2416, -1298, -307, 315, 509, 298, -154, -625, -875, -827, -469, 129, 810, 1364, 1684, 1695, 1355, 741, -12, -760, -1307, -1439, -1106, -402, 478, 1298, 1906, 2189, 2100, 1700, 1122, 506, 128, 212, 601, 1054, 1489, 1915, 2034, 1888, 1525, 1016, 400, 29, -85, -95, -38, 156, 435, 678, 808, 697, 399, 92, -106, -154, 21, 347, 729, 1054, 1222, 1067, 660, 137, -327, -610, -615, -431, -66, 380, 729, 756, 545, 108, -511, -1139, -1569, -1754, -1643, -1272, -878, -629, -536, -568, -678, -654, -484, -234, 14, 249, 274, 40, -355, -774, -1183, -1506, -1634, -1585, -1373, -1084, -823, -627, -530, -598, -746, -829, -820, -743, -523, -299, -163, -143, -201, -348, -437, -500, -585, -667, -585, -286};