/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0024 256 samples */
 
const int16_t AKWF_hvoice_0024_256_DATA [256] = 
{496, 1640, 2862, 3902, 4524, 4711, 4655, 4605, 4712, 4997, 5409, 5889, 6376, 6808, 7169, 7494, 7845, 8228, 8574, 8802, 8904, 8944, 8999, 9087, 9183, 9286, 9428, 9611, 9744, 9693, 9400, 8954, 8514, 8183, 7927, 7638, 7265, 6862, 6540, 6377, 6373, 6456, 6541, 6557, 6493, 6398, 6351, 6366, 6311, 5963, 5177, 4048, 2884, 2007, 1514, 1246, 975, 625, 328, 279, 562, 1068, 1578, 1914, 2022, 1972, 1883, 1836, 1797, 1621, 1155, 400, -422, -968, -1026, -612, -73, 134, 222, 342, 410, 424, 358, 230, 160, 300, 729, 1377, 2069, 2645, 3023, 3188, 3171, 3080, 3099, 3401, 3994, 4696, 5317, 5897, 6763, 8274, 10430, 12803, 14771, 15975, 16525, 16834, 17228, 17713, 18026, 17894, 17278, 16459, 15948, 16225, 17463, 19368, 21363, 22976, 24161, 25302, 26781, 28514, 29978, 30573, 30136, 29066, 27975, 27224, 26756, 26291, 25632, 24843, 24205, 24025, 24457, 25379, 26413, 27138, 27356, 27227, 27101, 27142, 27117, 26570, 25237, 23329, 21360, 19736, 18467, 17252, 15853, 14328, 12955, 12024, 11623, 11603, 11669, 11490, 10863, 9815, 8580, 7409, 6322, 5073, 3397, 1290, -920, -2837, -4318, -5551, -6798, -8133, -9417, -10470, -11253, -11887, -12522, -13235, -14058, -14982, -15954, -16913, -17842, -18830, -20026, -21462, -22967, -24293, -25311, -26144, -27022, -28004, -28904, -29477, -29645, -29574, -29509, -29580, -29768, -29996, -30224, -30450, -30672, -30914, -31241, -31698, -32216, -32621, -32769, -32710, -32623, -32626, -32605, -32280, -31484, -30339, -29164, -28223, -27562, -27050, -26561, -26053, -25541, -25040, -24567, -24141, -23758, -23323, -22693, -21806, -20744, -19691, -18749, -17834, -16802, -15623, -14407, -13314, -12356, -11398, -10331, -9201, -8175, -7418, -6952, -6669, -6412, -6022, -5384, -4469, -3371, -2272, -1310, -417};