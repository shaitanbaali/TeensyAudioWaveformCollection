/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0037 256 samples */
 
const int16_t AKWF_hvoice_0037_256_DATA [256] = 
{710, 2613, 4749, 6256, 6367, 6108, 8302, 11313, 12199, 11430, 11723, 14365, 15265, 15286, 17276, 19901, 20452, 15555, 13983, 17216, 21711, 20391, 16170, 13077, 11483, 8901, 7155, 6659, 5764, -500, -7969, -11730, -11556, -12782, -17530, -21516, -23833, -26167, -29086, -30536, -29532, -29767, -31471, -32710, -31162, -29306, -28795, -28437, -25813, -22452, -20677, -20149, -17843, -14397, -11387, -9021, -6024, -2609, -876, -190, 1717, 5540, 8560, 9336, 9301, 10281, 11052, 11389, 11781, 12994, 13208, 11489, 9474, 9013, 9652, 9195, 7618, 6520, 5686, 4609, 3022, 2703, 2798, 2363, 1203, 590, 762, 1052, 892, 1187, 1845, 2840, 3169, 3848, 5078, 6167, 6920, 7342, 9030, 9987, 10710, 10711, 11631, 12546, 13070, 13284, 13749, 14987, 15572, 14201, 12085, 11797, 13012, 13308, 11803, 9822, 7213, 5060, 3500, 3110, 2483, 289, -3205, -6562, -7901, -8537, -9513, -11016, -12447, -13961, -15634, -16170, -15708, -14909, -14709, -14769, -14659, -14143, -13535, -12953, -11744, -10078, -8791, -8241, -7581, -6407, -5336, -4145, -2984, -1179, -340, -79, -74, 874, 2353, 3027, 3398, 3615, 3578, 3434, 3114, 4321, 5123, 4994, 4079, 3541, 4741, 4443, 4065, 3764, 4614, 4718, 3596, 3053, 3170, 3712, 3916, 3708, 4581, 4754, 4905, 4250, 4079, 5121, 6314, 7062, 6727, 6342, 5846, 5457, 6019, 6648, 6908, 5519, 3818, 2883, 2899, 2920, 2027, 652, -312, -1704, -3086, -4322, -4314, -5140, -6341, -7879, -8577, -8952, -9585, -9928, -10161, -9840, -10131, -10686, -10503, -9680, -8609, -8418, -7748, -6711, -5560, -4495, -3092, -1283, -183, 602, 1291, 2308, 3092, 3849, 4588, 5561, 5354, 4440, 3438, 3909, 4542, 4049, 2748, 1598, 1302, 469, -656, -1686, -743, -635, -2061, -3904, -3502, -1874, -1698, -1201, -1291, 224};