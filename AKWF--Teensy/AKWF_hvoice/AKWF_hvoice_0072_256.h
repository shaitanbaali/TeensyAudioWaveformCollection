/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0072 256 samples */
 
const int16_t AKWF_hvoice_0072_256_DATA [256] = 
{468, 1164, 1690, 2024, 2182, 2247, 2382, 2589, 2724, 2704, 2524, 2235, 1915, 1652, 1401, 1182, 972, 820, 834, 1040, 1223, 1207, 996, 788, 724, 820, 1002, 1172, 1195, 1117, 1095, 1251, 1591, 2014, 2345, 2500, 2615, 2758, 2964, 3273, 3742, 4272, 4746, 5195, 5567, 5810, 5965, 6147, 6338, 6537, 6635, 6581, 6552, 6797, 7354, 8008, 8409, 8446, 8481, 8786, 9316, 9866, 10295, 10425, 10394, 10393, 10653, 11251, 11914, 12017, 11594, 11209, 11264, 11685, 12006, 11842, 11273, 10865, 10874, 11172, 11339, 11034, 10219, 9339, 8683, 8486, 8647, 8452, 7186, 5235, 3895, 3527, 3568, 3727, 3706, 2435, -1331, -6400, -10711, -13561, -15388, -17407, -20459, -24487, -28043, -30095, -30848, -31197, -31726, -32366, -32772, -32509, -31080, -28711, -26066, -23758, -21731, -19550, -16608, -12777, -8914, -5766, -3207, -678, 1860, 4475, 6992, 8941, 10231, 11085, 11694, 11932, 12021, 12021, 11604, 10617, 9238, 7809, 6404, 4925, 3205, 1382, -294, -1664, -2887, -4179, -5753, -7394, -8684, -9463, -9919, -10259, -10540, -10736, -10685, -10403, -9887, -9117, -8172, -7307, -6320, -5141, -3883, -2581, -1205, 123, 1355, 2524, 3542, 4547, 5620, 6660, 7465, 8119, 8524, 8697, 8762, 8735, 8499, 8081, 7621, 6985, 6152, 5216, 4264, 3258, 2208, 1122, 147, -654, -1412, -2160, -2784, -3373, -4014, -4480, -4762, -4843, -4797, -4704, -4636, -4430, -4134, -3747, -3218, -2487, -1614, -729, -25, 538, 1045, 1628, 2382, 3201, 3687, 3844, 4001, 4139, 4246, 4320, 4278, 3895, 3491, 3190, 2932, 2645, 2223, 1507, 674, 29, -444, -885, -1406, -2032, -2762, -3502, -4010, -4320, -4635, -4919, -5021, -5057, -5139, -5050, -4820, -4477, -4199, -4142, -4179, -3711, -2736, -1776, -1318, -1301, -1127, -303};