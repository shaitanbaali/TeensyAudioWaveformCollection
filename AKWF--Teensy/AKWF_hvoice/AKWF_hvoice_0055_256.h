/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0055 256 samples */
 
const int16_t AKWF_hvoice_0055_256_DATA [256] = 
{728, 376, 1492, 1525, 273, 1378, 1411, 1430, 1409, 1859, 3006, 1988, 870, 2423, 4344, 4749, 2690, 3059, 5023, 4601, 3985, 3695, 6117, 6787, 4529, 5839, 6892, 7001, 8602, 6928, 8547, 9140, 8104, 10633, 9252, 10957, 11394, 10310, 12573, 10480, 12866, 15796, 13630, 15766, 14855, 14255, 16228, 13729, 16336, 17004, 15227, 16846, 15480, 18795, 18658, 17138, 20668, 18644, 18706, 17408, 16196, 19421, 19724, 21467, 16565, 10569, 14903, 19439, 18877, 17609, 28377, 29369, -231, -21859, -11543, 4048, 4037, -1441, 8815, 22458, 13412, -2177, -5648, 727, 2516, -8096, -10310, -3410, 1742, 826, -6675, -3804, -173, -4010, -8476, -12306, -6411, -5557, -10752, -9182, -9120, -6739, -8183, -12321, -9302, -8852, -8817, -10596, -11397, -8572, -10082, -11096, -12200, -10784, -8821, -11423, -11471, -10901, -9768, -9686, -11747, -9083, -9938, -10901, -10115, -12381, -10117, -11011, -11055, -9725, -11181, -8207, -8821, -10415, -9637, -9740, -7968, -8339, -10035, -9136, -8418, -8300, -8194, -7926, -7459, -7047, -6838, -7726, -6892, -6639, -6174, -5835, -6644, -6626, -6488, -5466, -4380, -4305, -5023, -5098, -4989, -4507, -3733, -4651, -3852, -3321, -3633, -3231, -3220, -3113, -1806, -2944, -3064, -2594, -2778, -1402, -1627, -2697, -2305, -1250, -266, -1803, -2592, -2257, -1095, -706, -2162, -1131, -512, -122, -1040, -2231, -843, -929, -1023, -792, -1275, -783, -877, -1281, -1173, -964, -2208, -1551, -1012, -1589, -949, -1478, -1965, -2072, -511, -284, -2229, -1980, -918, -1614, -2158, -1667, -1264, -1974, -3143, -1902, -867, -995, -1877, -1838, -1658, -2547, -2371, -2280, -2255, -1393, -1969, -2064, -1437, -2638, -1363, -1282, -1766, -1160, -2036, -888, -2260, -1830, -735, -926, -831, -2251, -193, 838, -136, -12, -1578, 303, 949, -414};