/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0003 256 samples */
 
const int16_t AKWF_hvoice_0003_256_DATA [256] = 
{793, 1935, 2781, 3532, 4439, 5664, 7188, 8813, 10242, 11196, 11589, 11616, 11635, 11957, 12700, 13758, 14914, 16036, 17150, 18401, 19899, 21593, 23295, 24795, 25954, 26785, 27414, 27971, 28547, 29184, 29885, 30618, 31303, 31807, 32007, 31892, 31635, 31537, 31814, 32377, 32771, 32393, 30852, 28241, 25121, 22196, 19904, 18290, 17109, 16078, 15095, 14217, 13524, 13023, 12654, 12359, 12112, 11865, 11488, 10801, 9660, 8052, 6133, 4123, 2171, 293, -1627, -3703, -5904, -8042, -9824, -11020, -11638, -11913, -12186, -12708, -13499, -14396, -15218, -15874, -16392, -16823, -17156, -17347, -17403, -17441, -17675, -18312, -19423, -20920, -22592, -24152, -25319, -25870, -25685, -24793, -23355, -21639, -19915, -18388, -17151, -16170, -15338, -14571, -13862, -13336, -13182, -13532, -14354, -15428, -16463, -17214, -17583, -17604, -17355, -16884, -16194, -15292, -14241, -13145, -12129, -11267, -10553, -9923, -9276, -8515, -7583, -6459, -5161, -3768, -2399, -1202, -303, 278, 635, 930, 1301, 1787, 2344, 2931, 3589, 4428, 5544, 6893, 8293, 9504, 10334, 10727, 10771, 10656, 10612, 10826, 11356, 12092, 12819, 13357, 13709, 14070, 14685, 15677, 16945, 18214, 19202, 19746, 19834, 19564, 19087, 18570, 18160, 17936, 17868, 17836, 17719, 17495, 17249, 17099, 17085, 17110, 16998, 16594, 15855, 14873, 13829, 12893, 12166, 11623, 11131, 10520, 9666, 8540, 7233, 5894, 4655, 3577, 2595, 1544, 254, -1364, -3220, -5045, -6544, -7562, -8184, -8705, -9432, -10517, -11894, -13352, -14692, -15851, -16885, -17908, -18999, -20137, -21213, -22097, -22708, -23076, -23343, -23701, -24289, -25124, -26087, -27003, -27724, -28176, -28370, -28346, -28145, -27783, -27268, -26601, -25749, -24670, -23349, -21835, -20291, -18951, -17993, -17424, -17039, -16530, -15691, -14527, -13231, -12044, -11066, -10205, -9297, -8244, -7051, -5785, -4498, -3193, -1840, -418};