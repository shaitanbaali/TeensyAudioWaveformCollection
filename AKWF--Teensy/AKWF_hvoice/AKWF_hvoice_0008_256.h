/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0008 256 samples */
 
const int16_t AKWF_hvoice_0008_256_DATA [256] = 
{947, 3452, 5893, 8306, 10666, 12973, 15230, 17429, 19577, 21668, 23669, 25558, 27298, 28840, 30152, 31218, 32009, 32505, 32736, 32749, 32546, 32125, 31522, 30749, 29800, 28697, 27449, 26066, 24561, 22943, 21222, 19399, 17474, 15450, 13327, 11112, 8820, 6457, 4039, 1593, -863, -3293, -5656, -7924, -10049, -11990, -13711, -15173, -16349, -17233, -17827, -18161, -18274, -18204, -17997, -17692, -17322, -16924, -16524, -16142, -15787, -15458, -15153, -14864, -14578, -14271, -13922, -13510, -13020, -12442, -11774, -11014, -10178, -9292, -8383, -7472, -6571, -5693, -4858, -4108, -3476, -2986, -2650, -2455, -2382, -2410, -2512, -2667, -2853, -3045, -3221, -3363, -3442, -3439, -3339, -3126, -2799, -2370, -1849, -1256, -628, 7, 623, 1199, 1737, 2236, 2688, 3090, 3428, 3692, 3888, 4030, 4136, 4233, 4344, 4480, 4651, 4851, 5062, 5264, 5428, 5527, 5546, 5477, 5312, 5051, 4690, 4216, 3625, 2924, 2120, 1236, 299, -687, -1708, -2745, -3794, -4841, -5878, -6916, -7951, -8970, -9976, -10960, -11909, -12821, -13679, -14460, -15160, -15764, -16261, -16647, -16912, -17048, -17071, -16989, -16800, -16514, -16134, -15658, -15109, -14497, -13808, -13047, -12213, -11287, -10284, -9210, -8035, -6789, -5508, -4152, -2798, -1611, -583, 397, 1318, 2149, 2937, 3705, 4457, 5236, 6068, 6957, 7915, 8945, 10031, 11158, 12308, 13451, 14553, 15576, 16471, 17200, 17747, 18091, 18239, 18199, 17973, 17580, 17051, 16414, 15724, 15036, 14396, 13839, 13379, 12998, 12669, 12361, 12035, 11663, 11210, 10642, 9923, 9028, 7944, 6672, 5222, 3621, 1903, 104, -1727, -3541, -5287, -6918, -8410, -9753, -10947, -12009, -12944, -13764, -14495, -15162, -15793, -16411, -17024, -17627, -18205, -18727, -19157, -19457, -19586, -19514, -19217, -18679, -17891, -16847, -15551, -14017, -12264, -10327, -8234, -6011, -3691, -1244};