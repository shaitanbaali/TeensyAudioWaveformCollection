/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0025 256 samples */
 
const int16_t AKWF_hvoice_0025_256_DATA [256] = 
{240, 804, 1364, 1955, 2575, 3212, 3846, 4485, 5149, 5841, 6540, 7236, 7934, 8657, 9404, 10155, 10884, 11596, 12304, 13018, 13734, 14443, 15149, 15870, 16597, 17334, 18112, 18960, 19887, 20852, 21795, 22712, 23648, 24624, 25616, 26540, 27355, 28097, 28816, 29512, 30143, 30675, 31134, 31568, 31966, 32281, 32489, 32624, 32725, 32770, 32691, 32436, 32051, 31604, 31102, 30468, 29643, 28666, 27624, 26556, 25413, 24135, 22738, 21306, 19877, 18419, 16881, 15264, 13638, 12032, 10404, 8717, 6977, 5242, 3567, 1901, 201, -1529, -3212, -4781, -6258, -7710, -9147, -10520, -11775, -12922, -14014, -15077, -16088, -17010, -17857, -18664, -19442, -20162, -20796, -21355, -21878, -22372, -22804, -23147, -23411, -23635, -23842, -24010, -24114, -24160, -24179, -24196, -24207, -24197, -24166, -24126, -24077, -24011, -23925, -23823, -23713, -23578, -23402, -23180, -22934, -22679, -22406, -22101, -21761, -21400, -21035, -20653, -20242, -19807, -19359, -18893, -18390, -17833, -17230, -16612, -15982, -15306, -14568, -13778, -12975, -12181, -11366, -10502, -9604, -8706, -7834, -6974, -6088, -5183, -4296, -3446, -2624, -1801, -970, -164, 597, 1336, 2071, 2804, 3493, 4103, 4657, 5185, 5692, 6149, 6518, 6809, 7061, 7292, 7480, 7603, 7664, 7693, 7704, 7678, 7593, 7454, 7287, 7110, 6902, 6642, 6336, 6010, 5677, 5319, 4909, 4454, 3989, 3534, 3086, 2616, 2122, 1631, 1164, 721, 284, -158, -597, -1025, -1456, -1898, -2348, -2787, -3203, -3608, -4019, -4429, -4816, -5165, -5480, -5782, -6077, -6348, -6586, -6797, -6993, -7178, -7348, -7493, -7619, -7738, -7847, -7933, -7989, -8026, -8053, -8066, -8049, -7995, -7915, -7821, -7716, -7582, -7415, -7222, -7019, -6808, -6582, -6335, -6073, -5803, -5520, -5217, -4888, -4545, -4194, -3827, -3429, -3002, -2559, -2108, -1642, -1127, -682, -279};