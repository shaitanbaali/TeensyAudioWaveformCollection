/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0022 256 samples */
 
const int16_t AKWF_hvoice_0022_256_DATA [256] = 
{305, 789, 846, 1041, 1585, 2009, 2176, 2437, 2811, 3053, 3235, 3567, 3965, 4080, 3744, 3205, 2962, 3249, 3742, 4059, 4153, 4038, 3795, 3801, 4213, 4543, 4427, 4350, 4773, 5163, 5029, 5040, 5606, 5938, 5786, 6123, 7157, 7835, 7807, 8029, 8877, 9557, 9723, 10096, 10978, 11583, 11689, 12282, 13627, 14504, 14359, 14231, 14873, 15597, 15603, 15159, 15244, 16011, 16350, 15733, 15072, 14852, 14439, 13911, 14046, 14270, 13414, 12165, 11840, 11826, 11135, 10501, 10428, 9555, 7367, 5934, 6309, 6484, 6019, 7546, 9256, 4505, -5767, -12421, -13332, -14981, -18378, -18455, -16197, -17144, -21183, -24936, -28576, -32100, -32409, -29087, -26173, -25168, -23337, -20201, -18949, -20223, -20529, -17925, -14070, -10690, -7588, -4393, -1964, -1104, -1186, -1380, -1754, -2010, -1039, 968, 2120, 1532, 221, -1198, -3168, -5504, -7272, -7998, -7921, -7575, -7549, -8059, -8965, -10262, -11673, -12247, -11752, -10792, -9439, -7713, -6376, -5970, -5937, -5629, -5020, -4022, -2254, 55, 1960, 2885, 3035, 2928, 2849, 2795, 2939, 3520, 4233, 4505, 4236, 3709, 3093, 2418, 1690, 895, 187, -138, -65, 1, -361, -1179, -2162, -2889, -3012, -2575, -2000, -1513, -1185, -941, -574, -306, -472, -546, 162, 1297, 2225, 2876, 3156, 3031, 3072, 3569, 3803, 3433, 3354, 3962, 4193, 3247, 1957, 1451, 1653, 1717, 1297, 861, 885, 1070, 682, -352, -1243, -1548, -1621, -1572, -1268, -1209, -1531, -1491, -1085, -1391, -2457, -2754, -1756, -842, -807, -793, -413, -204, -104, 172, 25, -602, -552, 357, 863, 525, 264, 426, 309, -263, -665, -870, -1266, -1453, -1091, -938, -1413, -1852, -2059, -2433, -2671, -2492, -2466, -2725, -2656, -2205, -1905, -1905, -1941, -1734, -1306, -1007, -824, -355};