/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0062 256 samples */
 
const int16_t AKWF_hvoice_0062_256_DATA [256] = 
{5778, 16783, 28942, 31193, 21294, 8081, -8756, -25365, -32556, -30079, -22932, -14840, -5980, 4475, 11000, 17039, 24042, 23184, 16431, 7976, -1628, -9749, -14695, -15499, -15872, -15911, -10898, -3536, 2285, 8797, 13379, 12873, 10686, 8420, 4410, -36, -4222, -10251, -13425, -12452, -8865, -3493, -487, 3247, 6544, 6353, 7869, 8693, 4866, 1800, -1475, -5649, -6597, -6117, -5172, -4211, -2695, 412, 1381, 3387, 6492, 6021, 4381, 1540, -1233, -2816, -2261, -1630, -3977, -4875, -3849, -1838, 971, 3988, 4421, 1688, 463, 1338, 2035, 878, -702, -1507, -3468, -4658, -1900, 419, 458, 1429, 199, -1405, 1050, 2624, 2284, 1199, -933, -2885, -2285, -120, -95, -856, -1058, -879, -1545, -646, 3938, 3224, -777, -400, -528, -1084, -62, 517, 27, -2895, -3246, 509, 957, 278, 1969, 1204, -1527, -891, 729, -595, -1329, 919, 45, -2378, -59, 1038, -1443, 62, 2113, -231, -1385, 689, 809, -887, -956, 267, 894, 463, 308, 574, -819, -1438, 477, 968, -428, -670, -62, 200, 186, 209, 941, 564, -345, 199, -106, -827, 25, 890, -334, -763, 196, -497, -1040, 75, 949, 18, 192, 2788, 1568, -1528, -126, -21, -2528, -431, 2363, 1017, -846, 71, 472, -2047, -1810, 2221, 2337, -248, 696, 88, -1930, 352, 2227, 565, -1347, -1248, 36, -207, -691, 423, 676, -974, 6, 2595, 1018, -1282, 10, -247, -2460, -867, 581, 783, 1680, 427, 281, -17, -110, 1095, 211, 232, -293, -1630, -497, 695, 690, 12, 324, 1447, 1555, 1948, 832, -472, -839, -2000, -1462, 1318, 3039, 1831, -13, -85, 263, -87, 2122, 3213, -939, -2750, -1375, -1481, 1122, 4947, 4969, 525, -5297, -9332, -9731, -3437};