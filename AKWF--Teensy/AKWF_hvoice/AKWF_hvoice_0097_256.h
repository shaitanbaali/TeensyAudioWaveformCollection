/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0097 256 samples */
 
const int16_t AKWF_hvoice_0097_256_DATA [256] = 
{211, 1213, 2389, 3559, 4524, 5371, 6249, 7134, 7984, 8692, 9237, 9761, 10298, 10593, 10612, 10525, 10483, 10624, 10813, 10788, 10605, 10432, 10276, 10061, 9796, 9502, 9216, 8938, 8504, 7861, 7172, 6527, 5919, 5347, 4873, 4500, 4238, 4008, 3706, 3416, 3262, 3211, 3198, 3137, 2993, 2809, 2619, 2397, 2159, 2071, 2175, 2481, 2881, 3231, 3552, 3957, 4471, 5102, 5716, 6213, 6701, 7286, 7892, 8448, 8883, 9242, 9763, 10466, 11152, 11723, 12186, 12620, 13127, 13648, 14063, 14425, 14831, 15216, 15506, 15669, 15724, 15836, 16056, 16277, 16407, 16353, 16111, 15648, 15074, 14540, 14084, 13698, 13275, 12722, 12210, 11907, 11094, 9285, 6331, 2539, -1000, -3944, -6884, -10091, -13449, -16595, -18994, -20845, -22651, -24347, -25606, -26493, -27146, -27977, -29185, -30415, -31409, -32119, -32589, -32770, -32662, -32265, -31575, -30525, -29060, -27010, -24624, -22161, -19703, -17249, -14826, -12468, -10328, -8470, -6649, -4752, -2917, -1224, 313, 1815, 3537, 5427, 7308, 9049, 10567, 11793, 12658, 13151, 13280, 13169, 12891, 12294, 11316, 10071, 8665, 7272, 5923, 4551, 3223, 2158, 1232, 225, -998, -2521, -4081, -5494, -6878, -8375, -9896, -11353, -12702, -13970, -15096, -16000, -16394, -16373, -16229, -16056, -15782, -15347, -14706, -14012, -13390, -12693, -11764, -10702, -9604, -8634, -7770, -6659, -5215, -3600, -1952, -390, 1108, 2642, 4113, 5408, 6527, 7518, 8443, 9327, 10081, 10671, 11080, 11349, 11573, 11791, 12018, 12215, 12277, 12173, 11880, 11414, 10744, 9947, 9090, 8175, 7164, 6063, 4878, 3670, 2477, 1350, 302, -679, -1616, -2532, -3437, -4330, -5239, -6233, -7221, -8085, -8785, -9344, -9852, -10375, -10785, -10993, -10959, -10720, -10345, -9882, -9328, -8703, -8039, -7340, -6578, -5751, -4858, -3980, -3189, -2421, -1595, -599};