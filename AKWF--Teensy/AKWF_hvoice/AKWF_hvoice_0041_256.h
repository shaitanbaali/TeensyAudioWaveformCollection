/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0041 256 samples */
 
const int16_t AKWF_hvoice_0041_256_DATA [256] = 
{1184, 2403, 4450, 5463, 8799, 11363, 13823, 11571, 10416, 8855, 9141, 8196, 6637, 11626, 25031, 32652, 23899, 14500, 14583, 12908, 3375, -7135, -12337, -14133, -13509, -13501, -11869, -8365, -8655, -12952, -13091, -8389, -7051, -9786, -9361, -3551, 3915, 5782, 2813, -687, -2537, -6449, -11071, -13111, -13509, -14581, -14955, -11901, -6751, -3314, -3216, -2188, 3961, 9351, 8537, 5355, 6184, 7311, 5647, 2703, 1066, -1005, -5069, -9732, -10946, -9074, -9319, -12736, -12673, -7145, -1338, 442, 1320, 4016, 7474, 8429, 7188, 6279, 5096, 1531, -2975, -4958, -5485, -7993, -11692, -12926, -10096, -6457, -4460, -3914, -1936, 1084, 3520, 4640, 5933, 6795, 6556, 5342, 4542, 3350, 805, -3369, -6702, -7758, -7095, -6759, -5669, -3735, -529, 2505, 5189, 7041, 8230, 9230, 10155, 11793, 12485, 11740, 9587, 7516, 5507, 3828, 6169, 9979, 10003, 5375, 4776, 7232, 7015, 3311, -403, -2434, -3494, -3624, -4802, -5034, -4548, -4722, -5542, -4304, -2181, -2429, -4014, -3693, -773, 2568, 3745, 3096, 2390, 2558, 2313, 1889, 1976, 2089, 973, 556, 1203, 2642, 2408, 1493, 4606, 16374, 25821, 22101, 13024, 11665, 12056, 5760, -3322, -9087, -11721, -12656, -12799, -11226, -8265, -8042, -12431, -13493, -8604, -4937, -6744, -7359, -2438, 4790, 8017, 5876, 2090, -1539, -6971, -13000, -15530, -15299, -16598, -17734, -14917, -8131, -3038, -2128, -3504, -3494, -1587, 285, 1772, 3465, 5363, 6294, 6896, 7477, 5040, -2130, -9953, -13432, -14053, -14885, -15694, -13751, -8079, -1779, 2415, 4905, 7423, 8821, 8776, 9340, 11054, 11720, 9878, 7727, 6598, 4932, 1160, -3895, -7495, -8238, -6982, -5312, -3028, 36, 3088, 5155, 6312, 6866, 6232, 4105, 1890, 935, 1483, 1933, 1828, 1788, 2481, 2639, 1309, -439, -875, -99};