/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0079 256 samples */
 
const int16_t AKWF_hvoice_0079_256_DATA [256] = 
{1208, 4668, 6478, 6572, 5758, 4719, 3985, 4411, 6567, 9667, 12180, 13335, 13411, 12881, 12097, 11751, 12647, 14711, 16919, 18293, 18722, 18508, 17886, 17263, 17358, 18535, 20279, 21713, 22470, 22580, 22083, 21176, 20468, 20583, 21483, 22670, 23774, 24561, 24680, 23938, 22759, 21882, 21657, 21997, 22840, 23994, 24836, 24660, 23504, 22072, 20921, 20259, 20274, 21066, 22186, 22780, 22449, 21423, 20061, 18611, 17514, 17265, 17851, 18701, 19339, 19537, 19019, 17581, 15631, 14003, 13165, 13020, 13376, 14050, 14522, 14142, 12838, 11299, 10154, 9555, 9330, 9332, 9373, 9125, 8392, 7416, 6694, 6439, 6432, 6325, 5985, 5416, 4627, 3726, 3133, 3226, 3847, 4469, 4723, 4529, 3797, 2510, 1187, 578, 920, 1857, 3010, 4130, 4810, 4659, 3851, 3052, 2759, 3005, 3705, 4802, 5918, 6473, 6273, 5882, 6081, 7043, 8302, 9371, 10105, 10475, 10464, 10350, 10894, 12563, 14525, 15062, 13430, 10922, 9465, 9719, 11279, 13787, 16563, 17703, 15417, 10662, 6629, 5636, 7194, 9770, 12364, 13848, 12501, 8067, 3073, 604, 1237, 3201, 4785, 5345, 4358, 1472, -2326, -4761, -4541, -2840, -1926, -2811, -5085, -8209, -11650, -13963, -13604, -10988, -8702, -8892, -11445, -15180, -19278, -22737, -23789, -21822, -18650, -16849, -17350, -19548, -22812, -26468, -29020, -29226, -27487, -25582, -24760, -25104, -26391, -28387, -30356, -31208, -30619, -29472, -28838, -29041, -29787, -30815, -31825, -32185, -31410, -29907, -28727, -28500, -29085, -30233, -31713, -32745, -32405, -30534, -28124, -26131, -24951, -24866, -26157, -28200, -29575, -29345, -27833, -25787, -23683, -22002, -21343, -21807, -22665, -23135, -23002, -22378, -21388, -20191, -18949, -17764, -16707, -15857, -15260, -14821, -14446, -14056, -13577, -12904, -12037, -11087, -10156, -9250, -8272, -7116, -5895, -4924, -4359, -4088, -3911, -3710, -3205, -1939};