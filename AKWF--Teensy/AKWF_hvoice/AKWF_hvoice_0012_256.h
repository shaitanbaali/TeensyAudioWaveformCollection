/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0012 256 samples */
 
const int16_t AKWF_hvoice_0012_256_DATA [256] = 
{587, 1585, 2559, 3507, 4432, 5261, 6057, 6868, 7640, 8450, 9312, 10266, 11291, 12237, 13112, 13979, 14891, 16032, 17074, 17876, 18735, 19628, 20544, 21488, 22639, 23759, 24586, 25168, 25951, 26784, 27404, 27735, 28012, 28220, 28504, 28238, 26677, 24326, 22754, 22428, 22083, 20592, 17721, 14403, 12159, 11599, 11057, 8965, 5488, 1169, -3249, -6346, -7919, -9514, -12270, -15706, -18600, -20533, -21673, -22437, -23348, -24591, -26344, -29006, -31658, -32782, -32334, -31340, -30526, -29854, -29317, -28615, -27228, -24905, -22347, -20340, -19191, -18570, -17761, -16178, -13790, -10826, -7585, -4809, -2872, -1219, 1035, 3724, 5958, 7429, 8337, 8953, 9696, 10832, 12177, 13527, 14621, 15235, 15603, 16214, 16954, 17137, 16771, 16350, 15994, 15516, 14997, 14461, 14032, 13766, 13406, 12805, 12228, 11831, 11414, 10878, 10471, 10182, 9704, 9032, 8398, 7870, 7488, 7234, 6904, 6499, 6184, 5857, 5438, 5124, 5071, 5033, 4773, 4299, 3555, 2452, 1179, 10, -876, -1504, -2116, -2956, -4030, -5063, -5905, -6737, -7589, -8669, -10191, -12051, -13882, -15379, -16494, -17303, -17937, -18465, -18899, -19189, -19420, -19660, -19842, -20096, -20450, -20763, -20719, -20331, -19566, -18473, -17101, -15565, -13897, -12183, -10476, -8826, -7204, -5663, -4164, -2631, -1041, 668, 2626, 4831, 7044, 9073, 10836, 12344, 13708, 14944, 16044, 16938, 17560, 17939, 18181, 18394, 18580, 18640, 18590, 18362, 17879, 17117, 16075, 14833, 13511, 12210, 10901, 9433, 7702, 5778, 3875, 2125, 560, -962, -2602, -4299, -5969, -7547, -8971, -10258, -11491, -12769, -14000, -15102, -16059, -16864, -17540, -18056, -18370, -18461, -18350, -18141, -17918, -17771, -17626, -17388, -17004, -16529, -16040, -15559, -14978, -14173, -13141, -11953, -10779, -9756, -8918, -8161, -7394, -6599, -5835, -5149, -4533, -3883, -3116, -2153, -1238, -349};