/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0082 256 samples */
 
const int16_t AKWF_hvoice_0082_256_DATA [256] = 
{338, 1170, 2087, 2934, 3676, 4344, 4964, 5689, 6704, 7920, 9172, 10338, 11286, 11941, 12315, 12420, 12320, 12150, 11984, 11778, 11476, 11062, 10487, 9782, 9175, 8826, 8666, 8580, 8479, 8231, 7787, 7165, 6382, 5516, 4654, 3854, 3194, 2706, 2380, 2180, 2103, 2224, 2566, 3048, 3599, 4146, 4589, 4916, 5213, 5551, 5952, 6433, 6984, 7599, 8270, 9016, 9873, 10795, 11721, 12625, 13457, 14201, 14845, 15389, 15820, 16063, 16095, 16014, 15912, 15827, 15792, 15814, 15860, 15913, 15948, 15951, 15878, 15585, 15023, 14256, 13344, 12367, 11428, 10586, 9974, 9668, 9503, 9345, 8814, 6982, 3484, -1108, -6265, -11396, -15732, -19124, -22170, -25280, -28210, -30560, -32168, -32788, -32465, -31720, -31061, -30603, -30329, -30175, -30051, -29890, -29519, -28759, -27523, -25567, -22871, -19692, -16217, -12626, -8965, -5283, -1661, 1867, 4990, 7339, 8862, 9648, 9832, 9753, 9690, 9693, 9746, 9795, 9676, 9289, 8645, 7768, 6705, 5515, 4234, 2724, 872, -1343, -4042, -7111, -10168, -13034, -15476, -17330, -18671, -19688, -20511, -21128, -21512, -21601, -21259, -20531, -19620, -18674, -17773, -16971, -16213, -15349, -14290, -12931, -11198, -9157, -6913, -4531, -2073, 427, 2857, 5204, 7356, 9136, 10490, 11338, 11632, 11483, 10983, 10275, 9591, 9080, 8701, 8379, 8042, 7538, 6827, 6047, 5310, 4576, 3741, 2735, 1433, -225, -2111, -4110, -6034, -7622, -8765, -9415, -9544, -9318, -8953, -8552, -8138, -7715, -7192, -6446, -5562, -4800, -4249, -3869, -3612, -3226, -2328, -907, 719, 2324, 3700, 4656, 5291, 5930, 6679, 7325, 7691, 7703, 7245, 6414, 5554, 4853, 4243, 3585, 2876, 2159, 1479, 978, 774, 661, 311, -340, -1183, -2116, -2993, -3652, -4100, -4413, -4634, -4752, -4763, -4612, -4203, -3552, -2747, -1832, -958, -255};