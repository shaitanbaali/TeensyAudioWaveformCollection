/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0026 256 samples */
 
const int16_t AKWF_hvoice_0026_256_DATA [256] = 
{323, 1769, 2914, 3923, 5339, 6668, 8028, 9314, 10222, 11228, 12154, 12381, 12632, 13112, 13272, 13506, 13951, 14085, 14366, 14819, 15043, 15542, 16133, 16793, 18123, 19853, 21632, 23766, 25898, 27583, 28956, 30041, 30873, 31793, 32552, 32763, 32736, 32253, 31234, 29952, 28259, 26218, 24131, 21880, 19351, 16958, 14717, 12420, 10159, 7803, 5455, 3426, 1447, -620, -2582, -4549, -6612, -8694, -10663, -12394, -13925, -15506, -17157, -18729, -20237, -21630, -22782, -23641, -24127, -24162, -23842, -23238, -22413, -21432, -20388, -19301, -18169, -16912, -15459, -14033, -12812, -11768, -10961, -10476, -10302, -10423, -10673, -11076, -11698, -12457, -13280, -14117, -15026, -15919, -16752, -17517, -18167, -18780, -19345, -19826, -20191, -20476, -20697, -20725, -20672, -20571, -20436, -20403, -20367, -20297, -20218, -20019, -19580, -18924, -18107, -17093, -15973, -14745, -13379, -11956, -10393, -8629, -6737, -4789, -2810, -874, 954, 2625, 4073, 5339, 6413, 7180, 7675, 7932, 7917, 7671, 7273, 6725, 6148, 5535, 4806, 4044, 3241, 2375, 1579, 867, 256, -134, -379, -604, -811, -1017, -1275, -1571, -1883, -2140, -2257, -2266, -2214, -2074, -1866, -1638, -1394, -1026, -482, 222, 1117, 2155, 3327, 4600, 5883, 7209, 8557, 9845, 11043, 12145, 13061, 13783, 14322, 14652, 14830, 14878, 14799, 14556, 14148, 13580, 12822, 11904, 10910, 9913, 8967, 8061, 7187, 6360, 5509, 4553, 3549, 2588, 1684, 819, 55, -517, -981, -1495, -1995, -2390, -2716, -3024, -3259, -3309, -3225, -3116, -2965, -2724, -2354, -1931, -1493, -974, -390, 112, 505, 862, 1125, 1293, 1392, 1396, 1357, 1201, 865, 354, -302, -1029, -1916, -2821, -3577, -4231, -4846, -5397, -5867, -6327, -6812, -7263, -7606, -7677, -7655, -7542, -7191, -6757, -6375, -5946, -5337, -4710, -3965, -2886, -1767, -552};