/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0064 256 samples */
 
const int16_t AKWF_hvoice_0064_256_DATA [256] = 
{80, 192, 282, 398, 577, 817, 1038, 1192, 1268, 1277, 1214, 1092, 914, 722, 558, 433, 341, 273, 224, 197, 188, 195, 199, 232, 331, 482, 647, 804, 972, 1146, 1265, 1289, 1202, 1105, 1141, 1443, 2101, 3159, 4599, 6227, 7835, 8994, 9498, 9175, 8566, 8047, 7538, 6726, 5674, 4685, 3938, 3471, 3178, 2950, 2984, 3432, 3912, 4117, 4036, 3789, 3535, 3310, 2973, 2659, 2787, 3356, 4116, 4903, 5690, 6546, 7529, 8399, 8969, 9424, 9932, 10351, 10550, 10432, 10089, 9790, 9591, 9351, 9056, 8813, 8658, 8573, 8522, 8488, 8487, 8536, 8575, 8563, 8551, 8528, 8255, 7639, 6675, 5595, 4770, 4331, 4261, 4524, 5158, 6196, 7644, 7970, 5957, 1100, -6098, -13501, -19833, -24934, -28933, -31635, -32778, -31898, -29432, -26187, -22414, -17841, -12847, -7895, -4053, -1900, -1285, -1662, -2386, -2978, -2850, -1908, -307, 1623, 3600, 5467, 7269, 8691, 9349, 9077, 7883, 5602, 2118, -2511, -7991, -13021, -16787, -18979, -19812, -19654, -18794, -17208, -15087, -12630, -10012, -7225, -4579, -2404, -1200, -1211, -2014, -3051, -3571, -3266, -2084, -307, 1661, 3460, 4770, 5591, 6082, 6256, 6039, 5087, 3091, 336, -2804, -5858, -8539, -10643, -12014, -12177, -11196, -9557, -7766, -6122, -4718, -3458, -2434, -1855, -1516, -1121, -781, -679, -811, -1003, -580, 700, 2375, 4047, 5621, 7034, 8170, 8747, 8350, 7155, 5548, 3758, 1825, -161, -2134, -3733, -4741, -5127, -4973, -4256, -3103, -1723, -430, 298, 507, 473, 399, 353, 242, -52, -366, -514, -349, 147, 879, 1731, 2587, 3345, 3873, 4052, 3697, 2895, 1820, 730, -161, -896, -1595, -2238, -2757, -3000, -2914, -2599, -2163, -1642, -1081, -595, -261, -158, -201, -239, -199, -66};