/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0098 256 samples */
 
const int16_t AKWF_hvoice_0098_256_DATA [256] = 
{518, 1339, 1940, 2172, 2114, 1994, 1996, 2202, 2544, 2476, 1775, 663, 110, 661, 1675, 2260, 1752, 895, 477, 701, 1098, 1223, 1166, 1178, 1525, 2252, 3178, 4096, 4833, 5374, 5913, 6451, 6825, 6691, 6056, 5275, 4680, 4439, 4598, 5051, 5480, 5580, 5607, 5987, 6570, 6945, 6781, 6580, 6720, 7293, 7921, 8538, 9443, 10654, 11810, 12250, 12561, 13169, 14022, 13546, 11703, 9824, 9452, 10067, 9679, 8371, 7247, 7769, 8928, 9693, 9677, 9490, 9150, 8150, 6805, 6183, 7597, 8930, 8086, 4343, 1752, 2306, 4776, 7095, 9831, 9671, 1785, -13344, -26219, -29519, -29260, -30232, -32600, -29659, -23768, -17503, -12604, -6858, -3624, -4956, -10231, -13257, -11525, -6899, -2398, 77, 1755, 3992, 6675, 7772, 4967, -663, -7385, -13501, -19089, -22406, -22375, -19209, -16075, -14277, -12573, -9705, -6455, -5686, -6755, -7870, -6824, -4657, -1979, 1187, 5209, 8756, 10656, 10722, 9406, 6797, 3075, -1178, -5200, -8329, -10020, -10107, -8942, -7487, -6304, -5492, -5190, -5644, -6464, -6780, -6203, -4777, -2564, 460, 3771, 6672, 8849, 10334, 10559, 9109, 6133, 2986, 684, -399, -595, -514, -552, -803, -1132, -1229, -1575, -2678, -4650, -6419, -6800, -5708, -3669, -1376, 1338, 4118, 6334, 7218, 7306, 6895, 5967, 4355, 2813, 2101, 2216, 2629, 2640, 2339, 1893, 1319, 170, -1755, -3781, -5195, -5697, -5755, -5243, -3867, -1411, 1066, 2676, 3326, 3494, 3366, 2713, 1836, 1236, 1304, 1562, 1789, 1905, 1969, 1565, 468, -1172, -2781, -3905, -4554, -4812, -4768, -4340, -3763, -3135, -2412, -1238, -248, 21, -468, -908, -537, 208, 754, 786, 945, 1280, 1484, 1080, 295, -317, -634, -891, -1581, -2596, -3375, -3392, -2618, -2107, -2078, -2223, -1805, -996, -251};