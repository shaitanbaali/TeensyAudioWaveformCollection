/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0030 256 samples */
 
const int16_t AKWF_hvoice_0030_256_DATA [256] = 
{972, 1407, 810, 2502, 3961, 3321, 2879, 4513, 6012, 5912, 6332, 8858, 12004, 12207, 12320, 13573, 13799, 10645, 8986, 12102, 14709, 16801, 24066, 32005, 31487, 25657, 22110, 19609, 14975, 14898, 20149, 22231, 21801, 25132, 29865, 28861, 24126, 21297, 19496, 14600, 10195, 8465, 8398, 9229, 11156, 13397, 12141, 7288, 2938, 919, 85, -1275, -3119, -3865, -4649, -6482, -8333, -9197, -9405, -9441, -8863, -7755, -8525, -10365, -10444, -9600, -10133, -11911, -12847, -12898, -12910, -10986, -6792, -3163, -1493, -863, -964, -2736, -5491, -6315, -4704, -2696, -800, 1571, 4097, 5526, 5918, 6286, 5960, 4013, 1601, 58, -405, -378, 589, 2515, 3558, 2722, 959, -727, -2430, -4050, -4971, -5600, -6794, -8173, -9127, -9983, -10778, -10992, -10630, -10660, -11365, -12213, -12874, -13342, -13715, -14071, -14575, -15319, -15604, -14828, -13151, -11197, -9395, -7772, -6942, -7398, -8430, -8901, -8472, -7410, -5823, -3651, -1627, -75, 1568, 3125, 3804, 3583, 3179, 2862, 2379, 2291, 3300, 4905, 6406, 7434, 7776, 7403, 6970, 6587, 5443, 4254, 3723, 3203, 1879, 1230, 1949, 2204, 1323, 800, 376, -1262, -3199, -3907, -3914, -4395, -5172, -5939, -6694, -7135, -7082, -7152, -7116, -6750, -6787, -7316, -7704, -7525, -7177, -6748, -6014, -5279, -4605, -3854, -2802, -1455, -31, 760, 793, 688, 717, 1114, 1853, 3054, 4641, 6205, 7559, 7860, 7467, 7266, 7023, 6197, 5238, 5623, 6364, 6286, 6487, 7934, 8936, 7919, 6626, 6160, 4559, 1849, 376, 464, -270, -1407, -1389, -1420, -2496, -3393, -3486, -4538, -6613, -7652, -9095, -11053, -12283, -12014, -11963, -12182, -11231, -9949, -10229, -10964, -10651, -10512, -11788, -12487, -11851, -11223, -10918, -9669, -6763, -5343, -4740, -3322, -1975, -1691, -2396, -1917, -1071, -253};