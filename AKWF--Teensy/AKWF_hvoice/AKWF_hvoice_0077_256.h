/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0077 256 samples */
 
const int16_t AKWF_hvoice_0077_256_DATA [256] = 
{702, 1817, 2637, 3314, 4011, 4907, 5992, 7190, 8403, 9354, 9869, 10030, 9944, 9771, 9840, 10267, 10761, 11051, 11106, 10986, 10752, 10508, 10312, 10037, 9497, 8737, 7969, 7299, 6654, 5955, 5244, 4601, 4077, 3804, 3834, 3860, 3501, 2808, 2067, 1452, 1191, 1458, 2007, 2436, 2658, 2830, 3065, 3461, 4100, 4943, 5897, 6874, 7708, 8274, 8651, 8967, 9326, 9940, 10898, 11920, 12739, 13317, 13700, 13948, 14176, 14460, 14742, 14912, 14961, 14952, 14923, 14903, 14921, 14918, 14778, 14457, 13908, 13105, 12211, 11423, 10774, 10212, 9704, 9383, 9414, 9519, 9313, 8434, 5830, 944, -5019, -10626, -15215, -18013, -18948, -19279, -20121, -21465, -22954, -24403, -25749, -26997, -28310, -29965, -31676, -32671, -32670, -31691, -29790, -27237, -24280, -21131, -17980, -14934, -12268, -10237, -8735, -7490, -6290, -4800, -2773, -306, 2520, 5491, 8276, 10699, 12466, 13308, 13287, 12480, 11078, 9406, 7719, 6246, 5246, 4650, 4151, 3540, 2460, 564, -1904, -4457, -6917, -9254, -11491, -13626, -15707, -17605, -18932, -19555, -19656, -19420, -19025, -18659, -18384, -18175, -18004, -17755, -17330, -16603, -15289, -13326, -10895, -8083, -5267, -2894, -1053, 395, 1601, 2795, 4197, 5721, 7047, 8046, 8822, 9470, 10105, 10923, 11832, 12408, 12435, 11892, 10780, 9313, 7855, 6538, 5293, 4055, 2820, 1599, 403, -818, -2072, -3366, -4733, -6073, -7235, -8153, -8740, -8957, -8915, -8745, -8531, -8392, -8352, -8190, -7684, -6859, -5777, -4543, -3426, -2597, -1848, -912, 234, 1500, 2777, 3818, 4395, 4716, 5203, 5953, 6763, 7500, 7918, 7743, 7115, 6439, 5907, 5462, 5037, 4576, 4006, 3317, 2486, 1518, 511, -437, -1269, -1895, -2331, -2787, -3442, -4178, -4788, -5191, -5316, -5160, -4900, -4730, -4595, -4293, -3742, -2903, -1761, -605};