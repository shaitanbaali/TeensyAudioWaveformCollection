/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0101 256 samples */
 
const int16_t AKWF_hvoice_0101_256_DATA [256] = 
{807, 2673, 3944, 4545, 4790, 4978, 5481, 6521, 7958, 9631, 10693, 10805, 10639, 10701, 11323, 12214, 12159, 11108, 9962, 9241, 9131, 9213, 8881, 8389, 8344, 8261, 7419, 5972, 4228, 2938, 2417, 2293, 2248, 2314, 2503, 2472, 2184, 1918, 1838, 2075, 2344, 2089, 1626, 1559, 2084, 3201, 4466, 5565, 6479, 7300, 7925, 8281, 8440, 8544, 8999, 9852, 10854, 11793, 12520, 13074, 13550, 13972, 14287, 14477, 14549, 14395, 13902, 13325, 12890, 12884, 13351, 13852, 14102, 13927, 13407, 12704, 11990, 11534, 11293, 11129, 10715, 9578, 8178, 7209, 7032, 7806, 8518, 8389, 8091, 8192, 7342, 4607, -1322, -9746, -16197, -19193, -18916, -17301, -16865, -17775, -19050, -20547, -22941, -25963, -29300, -31810, -32726, -32641, -32162, -30985, -28779, -25360, -21074, -17341, -14764, -14019, -14484, -15089, -14879, -12739, -9066, -4415, 186, 4037, 6854, 8659, 9541, 9584, 9133, 8415, 7727, 7160, 6764, 6592, 7123, 8225, 9504, 10052, 8251, 4492, -357, -4850, -8012, -9913, -10953, -11403, -11285, -11333, -12004, -13500, -15625, -17339, -18338, -19335, -20586, -21730, -22232, -21228, -18983, -16041, -13021, -10243, -8123, -7053, -6814, -7178, -6990, -5605, -3080, 207, 3536, 6558, 8797, 10211, 10740, 10705, 10738, 10910, 10929, 10641, 9937, 9409, 9788, 10537, 10981, 10461, 8736, 6294, 3544, 1060, -978, -2355, -3159, -3645, -4043, -4524, -5160, -6090, -7142, -8063, -8766, -9260, -9656, -10058, -9873, -8596, -6759, -4844, -3478, -2743, -2211, -1628, -1146, -721, 155, 1540, 3243, 4784, 5421, 5533, 5843, 6650, 8056, 9073, 8893, 7705, 5923, 4409, 3495, 3286, 3566, 3845, 3835, 3179, 1931, 166, -1771, -3495, -4740, -5248, -5298, -5193, -5406, -6261, -7050, -7190, -6525, -5244, -4430, -4474, -4885, -5181, -4984, -4273, -3001, -1259};