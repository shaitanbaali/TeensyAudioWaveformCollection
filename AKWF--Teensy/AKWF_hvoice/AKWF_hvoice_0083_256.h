/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0083 256 samples */
 
const int16_t AKWF_hvoice_0083_256_DATA [256] = 
{740, 1995, 3257, 4621, 6004, 7390, 8784, 10184, 11590, 12980, 14332, 15643, 16890, 18080, 19205, 20267, 21268, 22214, 23113, 23980, 24819, 25635, 26425, 27185, 27908, 28581, 29195, 29740, 30211, 30611, 30950, 31225, 31438, 31587, 31675, 31703, 31676, 31600, 31487, 31351, 31205, 31060, 30923, 30800, 30692, 30598, 30510, 30422, 30335, 30242, 30136, 30017, 29889, 29757, 29625, 29499, 29380, 29270, 29171, 29083, 29003, 28930, 28858, 28787, 28718, 28649, 28578, 28500, 28411, 28303, 28174, 28019, 27829, 27610, 27367, 27106, 26833, 26561, 26292, 26030, 25781, 25541, 25309, 25080, 24846, 24605, 24354, 24091, 23820, 23544, 23270, 23006, 22762, 22542, 22348, 22181, 22039, 21921, 21823, 21748, 21700, 21682, 21690, 21709, 21717, 21683, 21578, 21375, 21060, 20639, 20101, 19458, 18723, 17903, 17006, 16043, 15004, 13911, 12773, 11592, 10386, 9152, 7891, 6615, 5325, 4022, 2719, 1393, 42, -1333, -2745, -4189, -5655, -7140, -8616, -10062, -11470, -12824, -14127, -15374, -16571, -17707, -18810, -19881, -20921, -21946, -22950, -23923, -24878, -25803, -26691, -27542, -28353, -29127, -29865, -30553, -31171, -31704, -32135, -32458, -32669, -32762, -32762, -32725, -32609, -32455, -32275, -32079, -31871, -31661, -31446, -31231, -31017, -30805, -30596, -30392, -30190, -29993, -29798, -29608, -29423, -29239, -29059, -28881, -28706, -28541, -28388, -28250, -28130, -28028, -27943, -27876, -27815, -27753, -27680, -27592, -27484, -27355, -27207, -27047, -26873, -26696, -26520, -26349, -26185, -26027, -25873, -25726, -25580, -25432, -25284, -25131, -24975, -24815, -24651, -24480, -24297, -24101, -23889, -23664, -23430, -23200, -22986, -22812, -22697, -22651, -22677, -22763, -22891, -23029, -23148, -23216, -23218, -23142, -22987, -22747, -22408, -21957, -21375, -20653, -19789, -18776, -17645, -16421, -15136, -13805, -12465, -11122, -9793, -8486, -7196, -5905, -4611, -3306, -1972, -572};