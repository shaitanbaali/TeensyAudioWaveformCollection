/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0021 256 samples */
 
const int16_t AKWF_hvoice_0021_256_DATA [256] = 
{1167, 3437, 4967, 4541, 2651, 2058, 3911, 4902, 3123, 1618, 2374, 3559, 3713, 2896, 1273, 181, 1240, 3220, 3657, 2561, 1589, 1758, 3002, 4109, 3876, 3335, 4075, 5453, 5947, 5572, 5198, 5618, 7435, 9460, 9269, 7390, 7278, 9679, 11472, 10673, 8924, 8767, 10500, 11867, 11009, 9388, 10061, 12720, 14049, 12750, 10861, 10569, 12074, 13688, 13639, 12442, 12124, 12744, 12550, 11442, 10845, 11596, 13402, 14342, 12406, 9260, 8448, 9806, 10793, 11215, 11204, 8772, 4407, 2543, 4647, 6536, 6814, 9546, 12355, 3827, -15924, -27018, -18852, -7552, -8149, -14537, -19044, -24432, -30732, -32786, -30250, -25351, -18094, -11819, -13754, -23152, -28496, -22056, -9583, -1615, -227, -795, -1296, -2762, -4236, -3494, -275, 4366, 7969, 6034, -2270, -10385, -12092, -9139, -6686, -6112, -6746, -9546, -14578, -18870, -19802, -17560, -13357, -8896, -7182, -9436, -12470, -12541, -9339, -4409, 722, 4230, 4818, 3252, 1442, 1052, 2940, 6291, 8847, 9101, 7118, 3555, -5, -1315, -274, 805, 618, -634, -3292, -6986, -9504, -9419, -7609, -5635, -4241, -3998, -5185, -6579, -6231, -3568, -17, 2500, 3267, 3172, 3494, 4339, 5133, 5843, 6747, 7630, 8108, 8025, 6984, 4801, 2753, 2410, 2921, 2472, 1368, 441, -1015, -2992, -3864, -3457, -3263, -3564, -3455, -2993, -2833, -2940, -2617, -1397, 43, 806, 1450, 2685, 3469, 3094, 2970, 4098, 5462, 5996, 5656, 4800, 3818, 2971, 2139, 1181, 382, -36, -250, -718, -2167, -4383, -5628, -5081, -4132, -4096, -4723, -5183, -4698, -3343, -2800, -3799, -3851, -1323, 1311, 1592, 818, 1169, 2250, 2565, 1909, 1259, 1734, 3105, 3800, 2845, 760, -1262, -1837, -802, -346, -1818, -3218, -3098, -3243, -4483, -5091, -4404, -3248, -2347, -2640, -4072, -4166, -1639};