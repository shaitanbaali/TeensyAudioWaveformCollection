/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0028 256 samples */
 
const int16_t AKWF_hvoice_0028_256_DATA [256] = 
{1576, 1157, 770, 5211, 7054, 5464, 8081, 13414, 13814, 13806, 17563, 18060, 14439, 15797, 19379, 19830, 21901, 25593, 26723, 25624, 26512, 29036, 29039, 30233, 32490, 30967, 26656, 26647, 26949, 26644, 27092, 30836, 31611, 28609, 27129, 27981, 26366, 21356, 21157, 20646, 16990, 14636, 17189, 19448, 19144, 20685, 22740, 20680, 16419, 15324, 13987, 12562, 12113, 12691, 13426, 12992, 14614, 16221, 16102, 14966, 14659, 12703, 9972, 8194, 7484, 6340, 6419, 6979, 5912, 4069, 4111, 4303, 3134, 1882, 373, -2539, -5386, -7005, -8373, -9867, -10923, -10958, -11308, -12683, -13620, -14341, -15563, -17741, -19299, -21174, -23397, -24322, -23816, -23237, -23425, -22986, -23165, -23980, -24319, -24163, -24514, -25052, -25120, -25061, -25230, -24937, -23486, -21958, -20934, -19875, -18947, -18314, -18169, -17398, -16733, -16600, -16479, -15979, -15264, -14144, -12569, -11079, -10255, -9866, -9905, -10322, -10699, -10807, -10782, -10623, -10416, -10158, -9935, -9556, -9270, -8982, -9050, -9725, -10353, -10904, -11396, -11474, -11350, -11401, -11609, -11484, -11440, -11322, -10944, -10667, -10673, -10763, -10832, -11108, -11196, -10752, -9990, -9333, -8558, -7164, -4988, -2604, -1818, -1540, -1373, -2113, -3636, -2615, -38, 544, 1045, 3714, 5520, 4793, 5928, 8258, 8170, 6382, 7182, 7725, 6411, 6397, 8379, 8894, 7998, 8134, 8247, 7260, 7044, 7500, 6840, 5778, 4559, 2992, 1532, 1083, 958, 707, 810, 979, 1103, 1382, 1816, 1566, 16, -2301, -4248, -5571, -6051, -5328, -3955, -2854, -3324, -3924, -4360, -5102, -6068, -5848, -5834, -6761, -6904, -5851, -5481, -5548, -4752, -4418, -5333, -5874, -4634, -4360, -4543, -3966, -3862, -5075, -5699, -4776, -3426, -1996, -1018, -1425, -3087, -3906, -4419, -5125, -4210, -1357, -195, -867, 392, 1053, -806, -2162, -335, 746, -851, -528};