/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0076 256 samples */
 
const int16_t AKWF_hvoice_0076_256_DATA [256] = 
{158, 466, 803, 1179, 1562, 1937, 2299, 2637, 2956, 3277, 3618, 3998, 4426, 4903, 5433, 5985, 6534, 7065, 7551, 8007, 8450, 8888, 9356, 9866, 10424, 11014, 11589, 12114, 12575, 12973, 13344, 13711, 14094, 14494, 14893, 15287, 15649, 15961, 16217, 16419, 16583, 16732, 16880, 17050, 17239, 17433, 17628, 17818, 18002, 18191, 18399, 18622, 18872, 19126, 19378, 19616, 19817, 19979, 20098, 20211, 20357, 20557, 20835, 21174, 21562, 21981, 22400, 22801, 23180, 23541, 23904, 24273, 24661, 25062, 25447, 25799, 26120, 26408, 26690, 26995, 27331, 27693, 28022, 28232, 28260, 28044, 27597, 26950, 26144, 25208, 24144, 22940, 21595, 20071, 18387, 16529, 14511, 12418, 10297, 8166, 6061, 3936, 1752, -522, -2898, -5318, -7707, -10004, -12177, -14222, -16125, -17909, -19595, -21201, -22766, -24271, -25677, -26953, -28062, -29011, -29825, -30523, -31130, -31649, -32074, -32420, -32660, -32764, -32735, -32579, -32314, -31971, -31565, -31116, -30616, -30056, -29425, -28727, -27978, -27236, -26521, -25863, -25254, -24662, -24063, -23443, -22799, -22137, -21450, -20756, -20050, -19354, -18701, -18101, -17555, -17063, -16603, -16160, -15746, -15364, -15020, -14730, -14463, -14203, -13938, -13651, -13339, -13003, -12644, -12267, -11879, -11482, -11087, -10706, -10342, -9993, -9658, -9342, -9043, -8764, -8504, -8244, -7976, -7683, -7362, -7008, -6624, -6228, -5833, -5446, -5049, -4657, -4269, -3889, -3528, -3181, -2848, -2517, -2189, -1851, -1519, -1191, -861, -527, -192, 132, 425, 664, 845, 991, 1123, 1273, 1438, 1580, 1696, 1773, 1824, 1883, 1963, 2070, 2199, 2320, 2411, 2456, 2446, 2371, 2234, 2047, 1824, 1584, 1342, 1090, 809, 499, 181, -112, -354, -526, -616, -642, -630, -604, -594, -607, -653, -726, -785, -814, -794, -727, -641, -568, -499, -427, -318, -118};