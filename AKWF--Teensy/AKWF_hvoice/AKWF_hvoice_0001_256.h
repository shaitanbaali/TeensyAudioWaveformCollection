/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0001 256 samples */
 
const int16_t AKWF_hvoice_0001_256_DATA [256] = 
{461, 1816, 3178, 4362, 5283, 6062, 6892, 7877, 9000, 10138, 11116, 11820, 12253, 12517, 12725, 12948, 13251, 13729, 14509, 15715, 17398, 19430, 21531, 23383, 24764, 25649, 26201, 26652, 27194, 27881, 28642, 29367, 29990, 30514, 30992, 31463, 31903, 32257, 32497, 32649, 32748, 32743, 32425, 31449, 29510, 26558, 22883, 19084, 15824, 13562, 12432, 12231, 12565, 13044, 13381, 13425, 13136, 12542, 11705, 10700, 9589, 8381, 7013, 5345, 3233, 668, -2168, -4900, -7080, -8444, -9029, -9144, -9207, -9512, -10130, -10970, -11919, -12941, -14074, -15317, -16568, -17652, -18387, -18685, -18582, -18218, -17786, -17499, -17556, -18098, -19178, -20711, -22489, -24199, -25466, -25999, -25685, -24637, -23135, -21472, -19824, -18205, -16591, -15043, -13715, -12777, -12293, -12198, -12385, -12798, -13458, -14376, -15438, -16402, -16963, -16887, -16094, -14712, -13054, -11512, -10425, -9928, -9908, -10085, -10160, -9928, -9296, -8230, -6733, -4906, -2965, -1187, 224, 1289, 2187, 3101, 4060, 4919, 5492, 5718, 5708, 5687, 5891, 6482, 7502, 8868, 10362, 11706, 12695, 13274, 13549, 13684, 13784, 13875, 13953, 14051, 14236, 14561, 15024, 15587, 16223, 16923, 17673, 18417, 19059, 19502, 19679, 19550, 19108, 18394, 17539, 16740, 16186, 15960, 16015, 16234, 16511, 16775, 16961, 16981, 16742, 16210, 15447, 14561, 13644, 12728, 11798, 10845, 9844, 8740, 7482, 6050, 4523, 3069, 1817, 763, -234, -1360, -2721, -4275, -5899, -7454, -8847, -10057, -11115, -12098, -13128, -14296, -15604, -16964, -18230, -19285, -20106, -20743, -21286, -21812, -22336, -22820, -23183, -23355, -23362, -23371, -23637, -24354, -25528, -26932, -28216, -29073, -29341, -29009, -28173, -27009, -25737, -24568, -23596, -22708, -21649, -20228, -18484, -16739, -15381, -14592, -14238, -13953, -13375, -12347, -10946, -9378, -7867, -6559, -5493, -4604, -3747, -2815, -1813, -720};