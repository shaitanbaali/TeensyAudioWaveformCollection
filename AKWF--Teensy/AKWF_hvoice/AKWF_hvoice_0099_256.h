/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0099 256 samples */
 
const int16_t AKWF_hvoice_0099_256_DATA [256] = 
{495, 1804, 2921, 4010, 5153, 6378, 7469, 8200, 8653, 8965, 9330, 9826, 10302, 10643, 10821, 10888, 11027, 11242, 11197, 10789, 10048, 9207, 8682, 8444, 8294, 7998, 7354, 6510, 5687, 5024, 4589, 4222, 3770, 3210, 2573, 2021, 1634, 1406, 1288, 1229, 1209, 1224, 1279, 1402, 1586, 1791, 1999, 2181, 2413, 2880, 3513, 4166, 4759, 5256, 5740, 6293, 6882, 7461, 8050, 8676, 9343, 10030, 10483, 10634, 10757, 11037, 11651, 12473, 12969, 13074, 13077, 13186, 13549, 13977, 14117, 14026, 13935, 13862, 13704, 13464, 13173, 13069, 13336, 13632, 13683, 13488, 13163, 12921, 12827, 12735, 12559, 12309, 11994, 11490, 10878, 10424, 10226, 10354, 10650, 10991, 11035, 10449, 8873, 5855, 2211, -1316, -4232, -6483, -8520, -10679, -12625, -14147, -15531, -17026, -18807, -20817, -22791, -24687, -26826, -29094, -31064, -32407, -32791, -32430, -31576, -30474, -29169, -27905, -26895, -26013, -25069, -23937, -22589, -21101, -19529, -17655, -15374, -12911, -10419, -7900, -5344, -2652, 3, 2065, 3475, 4339, 5032, 5974, 7105, 8166, 9074, 9881, 10602, 11225, 11518, 11302, 10656, 9685, 8533, 7252, 5827, 4258, 2702, 1190, -333, -1871, -3229, -4399, -5522, -6801, -8529, -10556, -12613, -14408, -15796, -16727, -17157, -17275, -17210, -17183, -17304, -17306, -16989, -16311, -15352, -14440, -13688, -13005, -12262, -11288, -10025, -8323, -6290, -4119, -2102, -624, 531, 1845, 3407, 5129, 6637, 7607, 8349, 9259, 10257, 11155, 11883, 12456, 12895, 13197, 13104, 12609, 12186, 11970, 11596, 10892, 9852, 8713, 7928, 7321, 6294, 4966, 3807, 2922, 2278, 1423, -66, -1779, -3295, -4493, -5440, -6283, -7099, -7788, -8290, -8753, -9230, -9579, -9757, -9796, -9808, -10021, -10321, -10352, -10035, -9398, -8631, -7905, -7166, -6249, -5206, -4125, -3131, -2274, -1462, -585};