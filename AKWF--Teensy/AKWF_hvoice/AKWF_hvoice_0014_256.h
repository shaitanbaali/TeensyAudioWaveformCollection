/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0014 256 samples */
 
const int16_t AKWF_hvoice_0014_256_DATA [256] = 
{282, 538, 1042, 1812, 2303, 2862, 3453, 3968, 4762, 5520, 5947, 6530, 7283, 7983, 8338, 8138, 7506, 6446, 5323, 3884, 2213, 2134, 3263, 4455, 5555, 6579, 7384, 7618, 7641, 7066, 6049, 5601, 4786, 4043, 3778, 3289, 3276, 3599, 4340, 5779, 7121, 9071, 11851, 14620, 16729, 18808, 21177, 23466, 25368, 26357, 27006, 26637, 25872, 25209, 23242, 21093, 18506, 15439, 13375, 11640, 10096, 9371, 9349, 8736, 10707, 12560, 12588, 13936, 14636, 15143, 14313, 10797, 6203, 1287, -2799, -7904, -13308, -20568, -26568, -28233, -28563, -29600, -32046, -32726, -31318, -28553, -25558, -24161, -23274, -21022, -16474, -10558, -5518, -1618, 1976, 6976, 11328, 14945, 17566, 18239, 18311, 17665, 17342, 16702, 15512, 14015, 12428, 11376, 10624, 10796, 11277, 12002, 12733, 13208, 14541, 15684, 16527, 16675, 16070, 15237, 13554, 11831, 10133, 7943, 5477, 2517, -463, -3303, -6656, -10603, -14744, -18729, -22559, -25634, -27957, -29229, -29473, -28766, -27091, -24692, -21570, -18215, -14815, -11517, -8837, -6358, -4004, -2004, -268, 1032, 2005, 2876, 3722, 4523, 5360, 6157, 6690, 7415, 8331, 9292, 10151, 10776, 11396, 12057, 12980, 13899, 14887, 15859, 16811, 17907, 18791, 19055, 18406, 17042, 15044, 12410, 9280, 5621, 1730, -2152, -5889, -9215, -12041, -14411, -16372, -17864, -18963, -19524, -19496, -19104, -18413, -17422, -16226, -14867, -13420, -11843, -10279, -8827, -7409, -5974, -4614, -3387, -2315, -1336, -482, -104, -448, -967, -859, -269, 318, 801, 1672, 3456, 5877, 8447, 10523, 11910, 13041, 14299, 15314, 15324, 14436, 13224, 12043, 11005, 9306, 5630, 834, -2902, -6518, -10758, -15375, -20661, -24334, -26049, -27482, -28438, -29388, -29616, -28057, -25945, -24482, -22932, -20938, -18440, -15035, -11655, -9123, -7205, -5455, -3617, -1947, -708, -228, -105};