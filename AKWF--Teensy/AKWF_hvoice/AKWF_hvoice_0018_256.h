/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0018 256 samples */
 
const int16_t AKWF_hvoice_0018_256_DATA [256] = 
{264, 766, 1089, 1245, 1320, 1377, 1601, 2050, 2281, 2085, 1993, 2451, 3066, 3305, 3297, 3422, 3656, 3733, 3694, 3898, 4421, 4816, 4836, 4887, 5284, 5586, 5441, 5332, 5645, 6054, 6337, 6619, 6847, 7026, 7347, 7714, 8013, 8495, 9059, 9319, 9610, 10261, 10747, 10994, 11628, 12517, 13225, 14016, 14896, 15278, 15310, 15582, 15810, 15960, 16485, 16914, 16714, 16661, 17151, 17108, 16192, 15591, 15541, 15181, 14865, 15191, 15199, 14415, 13873, 13711, 13175, 12663, 12414, 11124, 8800, 7555, 7629, 7179, 6658, 8063, 9157, 5223, -2782, -9068, -12545, -16961, -22310, -24805, -24498, -24457, -24921, -25089, -26432, -29401, -31499, -31847, -32250, -32728, -31288, -27714, -23507, -19708, -16651, -14344, -12611, -11307, -10108, -8715, -7481, -6324, -4135, -1010, 1249, 1909, 2010, 1975, 1140, -507, -2230, -3733, -4828, -5132, -4930, -5090, -5903, -6978, -8106, -9309, -10550, -11783, -12686, -12681, -11806, -10627, -9424, -8372, -7670, -7107, -6273, -5333, -4693, -4082, -3060, -1744, -331, 1205, 2593, 3355, 3699, 4150, 4557, 4457, 3973, 3637, 3614, 3716, 3691, 3404, 2877, 2285, 1729, 1035, 54, -943, -1571, -1896, -2127, -2114, -1898, -1922, -2124, -2017, -1780, -1884, -1941, -1366, -510, 138, 773, 1636, 2466, 3013, 3375, 3598, 3561, 3418, 3572, 4013, 4250, 4111, 3950, 3889, 3610, 3027, 2349, 1675, 1159, 976, 772, 269, -23, 74, -49, -574, -1108, -1559, -1910, -1986, -2050, -2278, -2211, -1649, -1187, -1174, -1244, -1117, -902, -654, -372, -241, -317, -286, -23, 119, -7, -94, 55, 217, 210, 175, 106, -227, -665, -880, -1158, -1708, -2044, -1903, -1766, -2000, -2339, -2483, -2416, -2195, -1832, -1536, -1557, -1710, -1662, -1576, -1698, -1761, -1545, -1269, -919, -330};