/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0053 256 samples */
 
const int16_t AKWF_hvoice_0053_256_DATA [256] = 
{2377, 2355, 615, 3202, 673, 1686, 3156, 2305, 4077, 3292, 3570, 5114, 3193, 5484, 4648, 4701, 7303, 4185, 7101, 8131, 4984, 10079, 8299, 7507, 12833, 7706, 12512, 12469, 9543, 16609, 10544, 15254, 15589, 12133, 20099, 14160, 17070, 21329, 15490, 21535, 21075, 18711, 24485, 21036, 22714, 24152, 21911, 25219, 22532, 25310, 25508, 23381, 28055, 23323, 26020, 27148, 24814, 29837, 23530, 24720, 26739, 22315, 24993, 24594, 31599, 25749, 15280, 18002, 8967, 2282, 4648, 275, 195, 2996, -1430, 818, 2838, -502, 3338, 1568, 614, 454, -2334, -1363, -6206, -4353, -6270, -10191, -5841, -12322, -9329, -9347, -15247, -7798, -14179, -14443, -9720, -17173, -11783, -13400, -15798, -12229, -14638, -13626, -14664, -13292, -15462, -14920, -12242, -17782, -12439, -14288, -17521, -11388, -17257, -13948, -12761, -18247, -10896, -16466, -15470, -11563, -17935, -12071, -15382, -14820, -12085, -16285, -11830, -13365, -13313, -10988, -12897, -11462, -11281, -12010, -11022, -10827, -10852, -10605, -9642, -10863, -9523, -8839, -10617, -6926, -9046, -8615, -6415, -8713, -6690, -6161, -6988, -6105, -6121, -6845, -5408, -5455, -6138, -3792, -5609, -4565, -2998, -4817, -3342, -2489, -4814, -1728, -3710, -4089, -1224, -3817, -2957, -1458, -2847, -1781, -1906, -1765, -2521, -536, -1708, -2534, 1097, -3018, -157, -89, -2802, 1190, -2109, -1138, -49, -2254, -664, -1073, -1285, -1555, 41, -2266, -868, 1, -3608, 827, -2064, -2872, -283, -2010, -1658, -2113, -1136, -1672, -3104, -1089, -1781, -3127, -1138, -3063, -2548, -1329, -3472, -1931, -1605, -2963, -3155, -1718, -3220, -3408, -1603, -3173, -3381, -922, -4156, -2261, -1093, -4899, -373, -2875, -2578, -961, -3330, -251, -2705, -1246, -1758, -1784, -11, -2990, 1022, -1461, -1115, 2045, -3187, 2043, 599, -1410, 3068, -438};