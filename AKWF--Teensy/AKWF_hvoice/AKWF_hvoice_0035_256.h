/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0035 256 samples */
 
const int16_t AKWF_hvoice_0035_256_DATA [256] = 
{1540, 3190, 3047, 4607, 6481, 7175, 8152, 11373, 14918, 13901, 12454, 14449, 16041, 13785, 12791, 14444, 14015, 10843, 11801, 16373, 16164, 15269, 17495, 17998, 14209, 11884, 11755, 9763, 8485, 10485, 13247, 12858, 11965, 11904, 11064, 9734, 8960, 8918, 8858, 9646, 11289, 12953, 14347, 15045, 16897, 17222, 15719, 16426, 16902, 15360, 14605, 16798, 17598, 16773, 16820, 18879, 19693, 18960, 20370, 20273, 18538, 18975, 20714, 19959, 18926, 19689, 19577, 17751, 17921, 19120, 17933, 15971, 16634, 19040, 19202, 18949, 20687, 21592, 20455, 20722, 22327, 22699, 22904, 25086, 27248, 27004, 26149, 26444, 25149, 23666, 23652, 23696, 22511, 21545, 21790, 21031, 20093, 18832, 16818, 13743, 11289, 8898, 5520, 2949, 1124, -857, -3192, -4859, -7101, -10211, -12251, -14105, -16482, -19053, -20645, -21407, -22970, -24577, -25334, -26364, -28795, -30376, -30641, -31470, -32618, -32464, -30986, -30870, -30891, -29532, -28872, -29205, -28688, -27251, -26638, -25546, -23179, -21132, -19590, -17554, -15654, -14888, -13379, -11350, -10540, -9889, -8079, -6467, -6060, -4890, -3088, -3043, -3972, -3530, -2959, -3993, -5194, -4953, -4971, -6227, -6946, -7068, -8326, -10480, -11529, -12627, -15050, -17218, -18125, -19568, -21640, -22569, -23359, -25101, -27110, -27849, -28337, -29604, -30126, -29806, -29348, -28941, -28369, -27866, -27134, -26235, -25435, -24150, -22145, -19563, -17719, -16072, -13353, -10599, -8786, -7037, -4065, -1170, 498, 2680, 6409, 9377, 11878, 16823, 21118, 22664, 24034, 24982, 22974, 20416, 20977, 21175, 19103, 18789, 20688, 19371, 16285, 16312, 15972, 11802, 8639, 8019, 4736, -224, -2190, -3658, -7450, -10232, -10706, -12864, -16243, -16503, -15621, -16755, -17670, -16903, -17768, -20750, -22649, -22925, -23714, -24714, -23450, -20504, -18422, -16593, -13743, -11016, -8927, -6957, -5078, -4200, -4230, -4021, -2977, -1033};