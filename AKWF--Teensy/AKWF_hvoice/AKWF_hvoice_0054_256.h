/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0054 256 samples */
 
const int16_t AKWF_hvoice_0054_256_DATA [256] = 
{821, 585, 726, 455, 840, 1347, 470, 611, 1990, 3601, 2330, 2166, 4584, 3200, 2929, 4038, 3932, 3816, 3700, 5065, 6196, 4244, 4990, 8392, 7178, 6585, 8511, 9144, 8570, 8901, 9429, 10334, 11542, 10259, 10964, 13115, 13277, 13340, 15229, 17033, 16150, 15882, 17312, 16875, 15873, 16287, 17687, 19221, 17432, 19225, 21460, 19075, 20553, 22843, 22227, 21226, 21350, 21946, 21349, 21554, 23155, 22689, 18108, 17111, 22188, 20187, 17047, 26484, 32948, 17137, -1567, 1650, 3787, -8282, -7693, 6372, 10745, 3905, 3857, 10846, 7500, -2050, -1275, 1155, -6651, -9868, -4800, -4915, -8028, -6711, -3927, -4313, -7762, -7241, -5680, -9680, -12869, -10354, -11561, -14178, -13262, -11676, -10122, -11869, -12069, -9142, -10786, -13645, -11653, -11954, -14305, -12710, -12677, -13476, -13099, -12524, -11595, -12069, -12285, -12094, -11671, -13621, -12600, -11577, -13288, -11740, -11351, -12636, -11547, -11955, -10152, -10436, -10887, -9612, -10827, -10460, -9877, -9313, -9086, -9759, -9218, -8064, -8456, -9295, -7735, -7066, -8299, -7046, -6985, -7186, -6125, -6079, -6711, -6853, -4539, -5139, -6389, -4408, -4394, -4903, -3951, -3318, -3731, -3260, -3415, -4086, -2811, -3570, -2689, -1942, -2904, -1638, -2280, -2887, -2358, -1491, -723, -2923, -2039, -426, -2192, -1826, -1881, 217, -616, -2106, 677, -137, -1741, -257, -559, -882, -1989, -1218, 322, -2388, -865, 140, -1447, -1335, -1897, 405, -1178, -2348, -162, -1233, -2278, -1870, -916, -894, -2273, -803, -175, -2057, -2367, -1330, -1800, -2693, -2246, -1519, -1794, -1914, -2264, -1921, -897, -2345, -1856, -1248, -2676, -2013, -2154, -2121, -2252, -2354, -720, -1554, -3106, -1554, -1007, -1167, -1725, -1777, -502, -876, -2341, -912, 72, -1264, -1314, -149, 869, -405, -524, 1641, 1026, -448};