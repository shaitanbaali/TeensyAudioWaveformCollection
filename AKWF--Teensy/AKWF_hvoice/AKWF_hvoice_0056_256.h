/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0056 256 samples */
 
const int16_t AKWF_hvoice_0056_256_DATA [256] = 
{1032, 8458, 15524, 20404, 25649, 23856, 20152, 15413, 8141, 4046, 918, -1623, -2710, -4853, -8776, -12642, -18935, -24605, -28692, -32635, -30990, -28357, -22713, -14454, -8990, -2858, 462, 1352, 2730, 3477, 4865, 8452, 11462, 14279, 16772, 15267, 13326, 8685, 2404, -1667, -6525, -7887, -6898, -5659, -2094, 14, 910, 1603, 490, -298, 589, 1518, 4657, 8596, 10798, 13510, 12693, 9838, 6397, 236, -4004, -7778, -10530, -10814, -11234, -11165, -11074, -12249, -13552, -14327, -15449, -13849, -11073, -7331, -1134, 3127, 7519, 10256, 10244, 10249, 8602, 7127, 6654, 6148, 6327, 6798, 5773, 4402, 1950, -2060, -4702, -7704, -8973, -7926, -6815, -3591, -884, 955, 2708, 2730, 2517, 2385, 2021, 2554, 3636, 4240, 5274, 4934, 3114, 1124, -2855, -6043, -8663, -10941, -10808, -10500, -9115, -7243, -6086, -4822, -4076, -3766, -2812, -1474, 259, 3512, 6054, 8628, 10639, 10264, 9767, 7649, 5138, 3500, 1641, 982, 879, 488, 262, -494, -2133, -3389, -5001, -6020, -5491, -4876, -2723, -432, 1209, 3065, 3357, 3192, 2673, 1506, 905, 417, 137, 423, 372, -127, -736, -2570, -4334, -5714, -7199, -6850, -6087, -4672, -2431, -906, 745, 1825, 2360, 2929, 3275, 3758, 4917, 5953, 6938, 7910, 7237, 6308, 4496, 1879, 267, -1460, -2234, -2156, -2150, -1688, -1490, -1730, -1920, -2328, -2678, -2335, -1939, -797, 743, 1775, 3074, 3241, 2687, 1965, 301, -784, -1498, -2044, -1782, -1601, -1771, -1931, -2620, -3489, -3794, -4162, -3629, -2521, -1289, 684, 2120, 3468, 4486, 4754, 5044, 5161, 5259, 5626, 6024, 6093, 6163, 5705, 4962, 4074, 2706, 1735, 670, 46, 165, 267, 905, 1435, 1384, 1323, 880, 263, 386, 709, 1194, 2275, 2038, 510, -700, -3521, -4459, -1592};