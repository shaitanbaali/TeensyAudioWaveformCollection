/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0093 256 samples */
 
const int16_t AKWF_hvoice_0093_256_DATA [256] = 
{344, 1623, 2414, 2578, 2544, 2540, 3525, 4770, 6492, 7469, 8070, 7847, 7533, 7111, 6918, 6833, 6921, 7044, 7250, 7128, 6846, 6323, 6016, 6065, 6246, 6426, 5911, 5034, 3492, 2524, 1887, 2429, 3036, 3669, 3725, 3488, 3256, 3166, 3355, 3627, 3976, 4255, 4575, 4885, 5590, 6571, 8162, 9691, 11098, 11867, 12226, 12144, 12181, 12495, 13505, 14975, 16294, 17196, 17207, 17033, 16671, 16794, 17038, 17567, 17643, 17407, 16246, 14995, 13766, 13260, 13242, 13463, 13156, 11491, 9083, 5985, 4206, 3448, 5128, 6168, 6865, 1062, -6672, -17939, -23289, -24337, -19966, -15668, -14846, -17232, -22654, -27412, -31279, -32439, -32120, -30288, -29791, -29773, -31453, -31223, -29435, -24684, -19631, -15773, -14610, -16025, -17880, -18980, -16631, -12486, -6189, -1592, 1985, 2799, 3348, 3439, 4807, 6446, 8370, 9272, 9132, 8156, 7177, 7406, 8588, 11014, 12248, 12461, 9568, 6060, 1499, -949, -2439, -2096, -1932, -1913, -2922, -4422, -6518, -8487, -10358, -11696, -12768, -13642, -14309, -14843, -14647, -13952, -12131, -10309, -8308, -7649, -7653, -8841, -9335, -9007, -6801, -3679, -293, 2313, 3815, 4728, 5298, 6074, 6824, 7551, 8453, 9430, 10568, 11341, 11531, 11725, 11882, 12716, 13027, 12590, 10891, 8525, 6450, 4929, 4313, 4115, 4166, 3844, 3003, 1273, -732, -2909, -4229, -5199, -5598, -6241, -6954, -7692, -8202, -8347, -8037, -7402, -6611, -6072, -6146, -6374, -6692, -6127, -5234, -3817, -2500, -1202, -133, 680, 1029, 1237, 1333, 1984, 2818, 4036, 4862, 5424, 5494, 5430, 5312, 5208, 5097, 4986, 4721, 4140, 3272, 2138, 1521, 1167, 1500, 1298, 716, -739, -2207, -3244, -3808, -3943, -4374, -4837, -5394, -5740, -5916, -6016, -6017, -5846, -5599, -5260, -5111, -5009, -5060, -4772, -4200, -2969, -1630, -513};