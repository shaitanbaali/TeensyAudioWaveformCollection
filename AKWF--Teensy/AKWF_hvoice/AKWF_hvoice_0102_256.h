/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0102 256 samples */
 
const int16_t AKWF_hvoice_0102_256_DATA [256] = 
{765, 2341, 2653, 1711, 623, 104, 677, 1863, 2914, 3410, 3058, 2716, 3297, 4677, 6485, 7305, 6428, 4886, 3546, 3004, 3183, 3691, 4313, 5261, 6270, 6480, 6004, 5356, 5133, 5863, 6546, 6044, 4928, 3958, 3938, 5033, 6651, 8316, 9625, 10483, 10570, 10142, 9985, 10092, 9834, 9212, 8538, 8398, 9383, 10443, 10507, 10090, 9906, 9929, 9871, 8861, 6944, 6173, 7016, 8277, 8975, 8264, 6985, 6817, 7863, 9595, 11159, 12007, 12095, 11541, 11166, 11457, 12594, 14368, 15648, 16067, 15976, 15792, 15823, 16024, 16155, 16307, 16871, 17478, 17497, 17060, 16487, 16441, 17296, 17876, 17382, 15862, 13811, 12367, 11846, 11879, 12069, 12224, 12434, 13184, 13442, 11492, 6874, -1229, -9937, -17039, -22766, -27491, -30832, -32573, -32405, -30711, -29135, -28390, -28630, -29411, -30241, -30916, -31535, -31634, -30532, -27742, -22801, -16793, -10543, -5156, -936, 1950, 3657, 3976, 3131, 1940, 846, 15, -658, -1351, -1762, -1104, -101, 217, -1149, -4901, -9383, -13248, -15942, -17684, -19269, -20951, -21590, -20815, -18971, -16704, -14685, -12998, -11381, -10163, -10158, -10763, -11173, -10599, -8661, -6254, -4076, -2367, -1012, 150, 1189, 2032, 2449, 1676, -170, -2701, -4942, -5570, -5115, -4607, -4559, -5045, -5275, -4676, -4158, -4475, -5687, -7394, -8242, -7940, -7255, -6717, -6497, -6163, -4787, -2780, -1139, -84, 612, 1082, 1294, 1187, 742, 794, 1743, 2821, 3510, 3940, 4338, 4854, 5331, 5288, 4749, 4035, 3063, 1397, -535, -2167, -2640, -1423, 335, 1699, 2093, 1561, 769, 56, -684, -1492, -2059, -2284, -2178, -1737, -795, 535, 2208, 3322, 3032, 1872, 498, -563, -1239, -2061, -3195, -3554, -2771, -1182, 397, 480, -602, -1469, -1679, -1389, -1297, -2085, -2990, -3109, -2776, -2510, -1955, -735};