/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0034 256 samples */
 
const int16_t AKWF_hvoice_0034_256_DATA [256] = 
{429, 1698, 3094, 4999, 6407, 6965, 7951, 8992, 9407, 9922, 10810, 12315, 15017, 18641, 22377, 26536, 30323, 32099, 32658, 32617, 31141, 29051, 27388, 25858, 24567, 23349, 21145, 18606, 16609, 14162, 11384, 8986, 6565, 4358, 3026, 2241, 1337, 637, 180, -347, -362, -213, -507, -408, 1, -262, -1216, -2615, -4267, -5327, -5510, -5432, -5050, -4148, -3063, -1862, -536, 478, 1200, 2312, 3755, 5122, 6754, 8651, 10790, 13218, 14773, 14947, 14324, 13153, 11768, 10313, 8627, 6918, 5264, 3500, 1628, -225, -1957, -3379, -4416, -5302, -6201, -7106, -7840, -8187, -8274, -8527, -9059, -9425, -9542, -9491, -9199, -8948, -8832, -8859, -9435, -10473, -11458, -12187, -12332, -11730, -10891, -10063, -9077, -7971, -6734, -5370, -4092, -2865, -1505, -199, 908, 1971, 2922, 3601, 3932, 3789, 3205, 2452, 1701, 997, 451, -118, -988, -2024, -3029, -3970, -4666, -4720, -4179, -3853, -4202, -4556, -4208, -3619, -3900, -5056, -5869, -5858, -6028, -7034, -8286, -9048, -9247, -9507, -10361, -11459, -12015, -11637, -10493, -9359, -8802, -8298, -6982, -5168, -3708, -2607, -1268, 564, 2377, 3378, 3776, 4197, 4635, 4882, 4901, 4780, 4703, 4652, 4686, 5125, 5828, 6132, 5777, 5299, 5283, 5569, 5461, 4721, 3812, 3167, 2527, 1360, -379, -2162, -3420, -4327, -5614, -7395, -9007, -9901, -10222, -10545, -10959, -10899, -10188, -9220, -8359, -7572, -6559, -5299, -4245, -3736, -3695, -3531, -2880, -2166, -1978, -2145, -2131, -1591, -1017, -1132, -1446, -1135, -565, -243, -90, 84, 385, 800, 1019, 901, 582, -5, -849, -1506, -2170, -3499, -5009, -5864, -6481, -7475, -8883, -10100, -9877, -8935, -9393, -10451, -10269, -9396, -8742, -8871, -9859, -10061, -8595, -7156, -6764, -6518, -5449, -3408, -966, 291, -282, -448};