/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0061 256 samples */
 
const int16_t AKWF_hvoice_0061_256_DATA [256] = 
{4877, 22647, 32769, 27590, 25335, 19212, 1568, -7057, -8453, -18017, -26501, -25090, -21874, -24095, -23513, -13180, -5201, -3211, 6001, 15610, 15775, 18908, 24251, 20712, 13694, 11345, 10350, 3091, -7534, -12951, -14724, -18074, -18888, -15611, -16563, -17595, -8679, 611, 220, 1890, 9560, 13151, 15798, 16391, 13699, 11006, 7080, 5548, 889, -5784, -8056, -11140, -13287, -12169, -12072, -12696, -10817, -4547, 382, 2498, 4800, 7064, 10747, 11801, 9466, 7997, 7893, 5812, 1205, -2235, -4056, -7871, -10326, -7334, -7783, -10927, -6546, -3374, -4110, 71, 4296, 4803, 5211, 7502, 8097, 6794, 4984, 3701, 2677, -981, -2490, -1873, -5998, -8634, -5857, -5142, -5947, -4175, -1939, -1549, -815, 2725, 5302, 4593, 4211, 4823, 3268, 3378, 4097, -298, -2452, -1105, -2863, -4789, -4481, -5704, -5715, -1617, -342, -3888, -2528, 3391, 2775, 1432, 4203, 3564, 1048, 2785, 4348, 426, -1024, 127, -2417, -3256, -2504, -2316, -2497, -2930, -757, -324, -1969, -853, 2156, 3955, 1928, -344, 1989, 2534, 1021, 988, -292, -61, -311, -1282, -49, -1359, -3501, -872, -38, -1532, -898, -504, 1104, 1304, 704, 2128, 786, -50, 983, 1678, 1541, 15, 60, -171, -1271, -797, -139, -944, -849, 246, 248, 216, -284, 328, 1680, -330, -388, 2230, 1321, -226, 603, 139, -1156, 1287, 2011, -754, -203, 104, -569, 465, 838, -465, -1587, -301, 1909, 1, -2436, 180, 1580, 256, 770, -112, -1125, 1045, 700, -713, 83, 282, 321, 97, -329, -260, -701, -326, 436, -800, -1022, 1488, 1179, 665, 2625, 802, 266, 2705, 1836, 2084, 2339, 86, 335, 1869, 1322, 286, 5, -57, 322, -406, -2070, -1270, 947, 2371, 3345, 2120, -1185, -7778, -9629, -2460};