/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0007 256 samples */
 
const int16_t AKWF_hvoice_0007_256_DATA [256] = 
{515, 1523, 2487, 3201, 3456, 3359, 3174, 3085, 3259, 3803, 4634, 5564, 6394, 6980, 7365, 7754, 8326, 9181, 10324, 11650, 12992, 14177, 15082, 15739, 16323, 17005, 17844, 18808, 19839, 20887, 21881, 22704, 23264, 23606, 23899, 24329, 25023, 26005, 27151, 28236, 29040, 29502, 29790, 30152, 30667, 31225, 31663, 31912, 32039, 32150, 32296, 32482, 32670, 32768, 32667, 32306, 31710, 31012, 30419, 30094, 30054, 30125, 30017, 29556, 28840, 28158, 27767, 27713, 27839, 27927, 27843, 27542, 27025, 26320, 25481, 24597, 23795, 23171, 22741, 22474, 22312, 22179, 21967, 21524, 20733, 19668, 18607, 17859, 17569, 17605, 17678, 17569, 17228, 16731, 16176, 15605, 15007, 14384, 13751, 13111, 12429, 11646, 10750, 9818, 8981, 8311, 7780, 7308, 6859, 6449, 6043, 5497, 4689, 3686, 2750, 2098, 1700, 1351, 935, 536, 238, -93, -768, -1974, -3587, -5260, -6679, -7745, -8523, -9139, -9717, -10334, -11030, -11839, -12785, -13833, -14853, -15630, -16042, -16211, -16443, -16988, -17853, -18803, -19567, -20043, -20291, -20415, -20513, -20689, -21120, -22004, -23331, -24766, -25803, -26086, -25673, -24951, -24345, -24066, -24099, -24320, -24584, -24789, -24886, -24887, -24826, -24706, -24491, -24198, -23948, -23874, -23998, -24201, -24321, -24290, -24133, -23864, -23464, -22979, -22581, -22487, -22768, -23231, -23552, -23518, -23137, -22587, -22078, -21733, -21580, -21616, -21824, -22169, -22571, -22877, -22923, -22690, -22344, -22121, -22157, -22401, -22700, -22934, -23026, -22867, -22356, -21518, -20577, -19866, -19591, -19645, -19671, -19339, -18583, -17675, -17041, -16914, -17177, -17455, -17361, -16767, -15871, -15024, -14511, -14386, -14433, -14327, -13851, -12970, -11826, -10668, -9712, -9075, -8752, -8570, -8280, -7730, -6887, -5838, -4767, -3861, -3256, -3053, -3232, -3609, -3936, -3947, -3458, -2585, -1682, -1031, -777, -846, -826, -315};