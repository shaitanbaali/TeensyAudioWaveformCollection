/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0088 256 samples */
 
const int16_t AKWF_hvoice_0088_256_DATA [256] = 
{402, 1012, 1795, 2589, 3367, 4156, 4952, 5747, 6553, 7363, 8170, 8982, 9798, 10604, 11415, 12224, 13032, 13835, 14641, 15438, 16218, 16977, 17708, 18420, 19119, 19813, 20517, 21235, 21960, 22709, 23494, 24332, 25234, 26184, 27152, 28112, 29027, 29890, 30690, 31394, 31978, 32411, 32680, 32770, 32743, 32601, 32350, 32013, 31608, 31152, 30675, 30202, 29745, 29312, 28899, 28483, 28060, 27618, 27151, 26649, 26085, 25438, 24690, 23839, 22889, 21852, 20721, 19505, 18202, 16834, 15410, 13957, 12465, 10943, 9407, 7861, 6310, 4768, 3213, 1662, 137, -1366, -2831, -4259, -5658, -7006, -8295, -9524, -10681, -11786, -12846, -13866, -14860, -15833, -16788, -17736, -18685, -19641, -20613, -21589, -22558, -23493, -24384, -25217, -25989, -26680, -27271, -27734, -28062, -28263, -28347, -28327, -28207, -27993, -27705, -27360, -26979, -26578, -26175, -25774, -25376, -24978, -24578, -24175, -23768, -23349, -22904, -22419, -21886, -21306, -20677, -20002, -19272, -18488, -17654, -16776, -15865, -14920, -13944, -12942, -11919, -10890, -9861, -8824, -7789, -6762, -5757, -4787, -3853, -2955, -2100, -1288, -524, 183, 847, 1469, 2048, 2590, 3098, 3569, 4021, 4451, 4874, 5302, 5734, 6175, 6610, 7033, 7440, 7826, 8184, 8503, 8760, 8939, 9031, 9040, 8970, 8822, 8594, 8290, 7916, 7489, 7024, 6523, 6000, 5465, 4917, 4375, 3844, 3330, 2839, 2361, 1885, 1408, 922, 424, -82, -610, -1168, -1756, -2378, -3025, -3682, -4354, -5035, -5717, -6399, -7071, -7736, -8397, -9047, -9682, -10290, -10854, -11379, -11859, -12291, -12666, -12976, -13215, -13387, -13495, -13547, -13553, -13513, -13434, -13325, -13195, -13053, -12904, -12756, -12610, -12461, -12305, -12143, -11976, -11798, -11593, -11344, -11041, -10677, -10251, -9769, -9234, -8642, -7999, -7311, -6587, -5838, -5071, -4293, -3506, -2709, -1912, -1108, -254};