/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0027 256 samples */
 
const int16_t AKWF_hvoice_0027_256_DATA [256] = 
{776, 1839, 2445, 3087, 3888, 4740, 5731, 6973, 8235, 9873, 12612, 15687, 17955, 19578, 21615, 23355, 23844, 24211, 25318, 27059, 29367, 31533, 32547, 32761, 32634, 31874, 30485, 28879, 27249, 25726, 24476, 22789, 20346, 18253, 16891, 15432, 13546, 11247, 8737, 6571, 4906, 3364, 1704, 348, -563, -1770, -3453, -4909, -5885, -6274, -6286, -6654, -7663, -8924, -10125, -11202, -12011, -12573, -12707, -12223, -11632, -11563, -11737, -11628, -11320, -11109, -11146, -11118, -10606, -9536, -8055, -6319, -4553, -2894, -1305, 64, 1055, 1869, 2974, 4485, 6016, 7220, 8175, 9021, 9642, 9851, 9703, 9444, 9256, 8986, 8353, 7365, 6065, 4570, 3136, 1749, 384, -689, -1501, -2395, -3448, -4584, -5789, -6926, -7999, -9116, -10200, -11093, -11709, -12039, -12219, -12342, -12465, -12784, -13517, -14524, -15357, -15714, -15683, -15444, -14962, -14325, -13910, -13684, -13297, -12719, -12121, -11465, -10652, -9790, -8991, -8076, -6818, -5457, -4073, -2508, -958, 225, 1224, 2361, 3481, 4447, 5280, 5943, 6411, 6700, 6969, 7247, 7423, 7495, 7435, 7018, 6173, 5163, 4091, 3067, 2271, 1692, 1151, 645, 159, -384, -975, -1553, -2048, -2504, -3024, -3541, -3844, -3933, -3956, -3931, -3743, -3474, -3453, -3785, -4216, -4547, -4843, -5044, -5165, -5360, -5507, -5587, -5693, -5791, -5787, -5698, -5510, -5374, -5428, -5488, -5340, -4901, -4277, -3566, -2699, -1646, -648, 82, 761, 1523, 2134, 2498, 2700, 2774, 2828, 2912, 3018, 3054, 2939, 2704, 2249, 1394, 352, -575, -1472, -2166, -2694, -3331, -4000, -4553, -4956, -5392, -6053, -6567, -6836, -7200, -7561, -7891, -8156, -8082, -7998, -8084, -8057, -7817, -7669, -7720, -8032, -8324, -8218, -8061, -8194, -8354, -8071, -7563, -6986, -6133, -5473, -5032, -3890, -2652, -2209, -2029, -1496, -406};