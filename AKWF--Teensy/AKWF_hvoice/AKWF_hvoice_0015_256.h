/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0015 256 samples */
 
const int16_t AKWF_hvoice_0015_256_DATA [256] = 
{740, 2220, 3916, 5437, 7205, 8604, 10075, 11488, 11661, 12646, 13354, 12382, 12347, 12420, 12743, 11518, 10441, 11390, 11080, 11708, 10322, 12464, 16630, 13776, 15314, 17358, 18691, 19333, 18823, 20929, 22791, 21539, 16854, 18814, 19700, 19808, 18778, 15943, 16649, 16321, 16000, 15375, 14409, 15367, 16294, 18493, 18834, 16996, 16421, 15310, 13699, 8923, -3247, -13361, -15679, -14448, -13802, -20432, -24531, -24573, -22544, -20538, -23809, -25418, -24445, -20999, -16018, -13667, -11599, -8453, -3851, 309, 3666, 4421, 3906, 4442, 4026, 4075, 2836, 2459, 1577, 1429, 2350, 3807, 7897, 9922, 11278, 12080, 11811, 12469, 13795, 14701, 16256, 17517, 17696, 19371, 19828, 19179, 17298, 13321, 9412, 5384, 1770, -1830, -5230, -8457, -11423, -12368, -13628, -14379, -14627, -14916, -14339, -14563, -15178, -15592, -15213, -15070, -13929, -12043, -10326, -8322, -8043, -8317, -8780, -9716, -10402, -10678, -10762, -10848, -9846, -8035, -5260, -2312, 160, 2938, 5560, 7542, 9068, 10600, 12238, 14184, 15342, 15609, 16073, 16651, 17364, 17494, 16319, 14299, 12040, 9521, 7086, 4925, 2870, 1493, 529, 176, 379, 321, 184, -273, -919, -1894, -2973, -3737, -4635, -5326, -6059, -6735, -7164, -7817, -8889, -10558, -12216, -13378, -14506, -15552, -16239, -16290, -15389, -13604, -11410, -9069, -6797, -4469, -2138, -321, 1072, 2403, 3831, 5171, 6284, 7131, 7817, 8458, 8992, 9275, 9179, 8609, 7783, 7060, 6476, 6115, 6005, 6069, 6553, 7389, 8243, 8828, 8835, 8556, 8149, 7119, 5612, 3812, 2016, 378, -1136, -2471, -3788, -5153, -6701, -8418, -11728, -17653, -21998, -23166, -25204, -27633, -31018, -32745, -30560, -28682, -28530, -29131, -28481, -26766, -24422, -23329, -23931, -22438, -19647, -16171, -12803, -11746, -10731, -8560, -6785, -5185, -4188, -4005, -3770, -3245, -2276, -633};