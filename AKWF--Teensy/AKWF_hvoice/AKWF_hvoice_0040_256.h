/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0040 256 samples */
 
const int16_t AKWF_hvoice_0040_256_DATA [256] = 
{3599, 8471, 11631, 14148, 12873, 13996, 18703, 21515, 19458, 18186, 19926, 21226, 23790, 25722, 24742, 23945, 25886, 26366, 23739, 21318, 18262, 15269, 13145, 10638, 7214, 3927, -28, -4292, -6762, -9426, -14123, -18196, -20373, -22148, -24462, -26834, -29596, -30947, -30845, -31050, -32217, -32768, -31968, -30718, -29557, -29250, -29040, -27887, -25528, -23617, -22647, -21666, -20022, -17632, -15490, -13761, -11733, -8983, -6643, -4458, -1899, -28, 898, 2032, 4190, 5500, 7067, 8625, 10299, 11921, 13831, 15450, 16752, 18533, 20579, 20753, 19389, 18189, 18777, 19761, 19284, 18057, 17173, 17622, 18142, 17531, 16256, 14555, 13686, 12867, 11147, 8883, 6768, 5772, 4853, 4244, 3853, 2437, 1016, -259, -167, -503, -1871, -3871, -5398, -5771, -6212, -7755, -9665, -10450, -9690, -9027, -9901, -11165, -11276, -9306, -8025, -7619, -7816, -6649, -3639, -230, 2225, 2838, 2334, 2639, 5609, 8205, 7302, 5724, 6986, 9007, 10508, 11835, 12828, 13624, 16129, 18954, 19646, 18298, 16333, 15769, 16401, 15801, 13248, 11197, 9649, 8581, 8630, 7806, 4973, 2990, 2896, 1604, -952, -3629, -6178, -8162, -9232, -10652, -12534, -14331, -15939, -17202, -17859, -19293, -21427, -22752, -22831, -22939, -23580, -24528, -24997, -24536, -23563, -23081, -22755, -22236, -21087, -19175, -17676, -16982, -16395, -14672, -12531, -10785, -9276, -8102, -6315, -3940, -1704, -445, 1106, 3942, 6768, 7792, 8442, 9673, 11050, 11433, 11980, 12694, 13292, 14137, 14983, 15500, 16292, 17187, 17728, 17755, 18986, 18284, 16437, 14554, 15036, 15353, 14426, 13090, 11902, 12019, 12607, 11458, 9652, 7581, 6632, 4738, 3000, 792, -1117, -2616, -3169, -3623, -3676, -4874, -6235, -7258, -6733, -6629, -7133, -8252, -9274, -9372, -8751, -8561, -10240, -10655, -10414, -10097, -10028, -10155, -9121, -9041, -6855, -6277, -4827, -1294};