/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0084 256 samples */
 
const int16_t AKWF_hvoice_0084_256_DATA [256] = 
{353, 1265, 3132, 5214, 7189, 9204, 11239, 13234, 15159, 16995, 18728, 20350, 21858, 23246, 24539, 25733, 26845, 27894, 28881, 29804, 30655, 31403, 32017, 32469, 32725, 32773, 32704, 32415, 31930, 31250, 30345, 29199, 27802, 26179, 24361, 22404, 20341, 18223, 16079, 13939, 11828, 9752, 7731, 5803, 3992, 2315, 790, -592, -1823, -2914, -3865, -4678, -5346, -5876, -6274, -6552, -6723, -6803, -6809, -6753, -6650, -6506, -6331, -6127, -5897, -5641, -5362, -5064, -4743, -4399, -4036, -3656, -3257, -2834, -2384, -1906, -1404, -880, -344, 193, 722, 1233, 1711, 2154, 2567, 2963, 3351, 3748, 4162, 4599, 5077, 5592, 6155, 6792, 7531, 8415, 9488, 10758, 12214, 13827, 15509, 17204, 18855, 20402, 21820, 23087, 24180, 25095, 25789, 26226, 26380, 26232, 25783, 25062, 24102, 22959, 21667, 20263, 18784, 17242, 15655, 14044, 12373, 10644, 8838, 6934, 4936, 2860, 702, -1485, -3680, -5864, -7994, -10090, -12138, -14112, -16006, -17802, -19466, -21019, -22434, -23711, -24867, -25901, -26831, -27679, -28457, -29178, -29851, -30466, -31014, -31456, -31748, -31851, -31746, -31418, -30879, -30141, -29226, -28149, -26914, -25517, -23968, -22282, -20516, -18682, -16822, -14981, -13179, -11433, -9767, -8161, -6647, -5243, -3949, -2782, -1741, -824, -27, 650, 1210, 1643, 1947, 2119, 2165, 2096, 1933, 1704, 1429, 1133, 835, 542, 263, 1, -236, -447, -619, -751, -834, -875, -882, -858, -817, -764, -701, -637, -571, -511, -459, -421, -397, -389, -396, -421, -468, -551, -702, -946, -1305, -1800, -2440, -3214, -4108, -5118, -6238, -7487, -8865, -10377, -11993, -13668, -15339, -16941, -18405, -19682, -20748, -21587, -22211, -22608, -22775, -22698, -22371, -21793, -20971, -19942, -18731, -17379, -15925, -14367, -12741, -11064, -9344, -7594, -5849, -4050, -2033, -343};