/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0031 256 samples */
 
const int16_t AKWF_hvoice_0031_256_DATA [256] = 
{495, 1315, 2881, 5441, 6959, 8300, 10212, 11348, 12087, 12384, 12128, 12572, 12114, 13345, 15942, 17629, 17551, 18155, 18301, 16582, 15137, 14289, 13803, 14961, 19377, 25951, 30692, 32484, 32562, 30092, 25508, 22216, 20176, 16767, 13675, 13637, 13310, 11315, 9615, 9291, 7326, 6553, 5574, 3056, 168, -356, -596, -2997, -7187, -10833, -13321, -15062, -15040, -12885, -10081, -6052, -1669, -189, -864, -945, -12, -42, -700, -1073, -952, -64, 1567, 3095, 3282, 3766, 4653, 4834, 4076, 4218, 5064, 4667, 2535, -494, -4700, -9000, -11830, -13640, -15342, -15750, -15116, -14757, -14683, -14310, -13977, -14739, -15874, -16802, -17617, -18029, -17186, -15760, -14808, -13915, -12817, -11839, -10533, -7928, -4571, -1833, 339, 1816, 1946, 987, -133, -1424, -2951, -4147, -4791, -5136, -5120, -4413, -3663, -3928, -4761, -5842, -7204, -8499, -9216, -9789, -10669, -11643, -12698, -13823, -14433, -13922, -12575, -10851, -8697, -6381, -4230, -2436, -970, -4, 230, 125, 188, 473, 1141, 2472, 3950, 5043, 5800, 6075, 5986, 5885, 5850, 5571, 4913, 3873, 2265, 235, -1833, -3756, -5346, -6697, -7762, -8045, -7639, -6923, -5914, -5171, -5094, -5216, -5061, -4438, -3458, -1855, -445, 1, 201, 804, 1578, 2904, 4456, 5221, 5600, 5931, 6283, 6861, 7312, 7058, 6219, 4839, 3167, 2254, 2233, 2481, 2809, 2934, 2180, 1198, 987, 852, 797, 1230, 1185, 578, 426, 325, 81, 271, 611, 462, 175, 416, 987, 1683, 2839, 3865, 3754, 3413, 3134, 2384, 2051, 1688, 931, 479, -143, -1537, -2532, -2818, -3528, -3928, -3458, -3550, -3907, -3050, -2399, -3255, -3814, -4563, -6466, -7710, -8484, -9746, -10680, -10629, -10277, -9964, -8719, -6873, -5823, -5187, -4392, -3911, -3063, -2136, -2062, -2129, -1405, -415};