/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0063 256 samples */
 
const int16_t AKWF_hvoice_0063_256_DATA [256] = 
{7116, 20905, 30841, 32768, 27087, 14863, 166, -8869, -9563, -7293, -5075, -4835, -9789, -18138, -24132, -23789, -18596, -12277, -5398, -707, -1100, -2742, -1211, 2567, 7490, 13191, 16536, 15620, 11512, 7755, 5616, 4580, 4923, 4584, 2266, -2338, -7231, -11004, -13162, -11778, -9553, -8183, -7454, -8200, -8189, -7209, -4993, -751, 3010, 5188, 5959, 5902, 5878, 5794, 6513, 7671, 7536, 6235, 4266, 1979, -16, -1583, -2207, -2422, -3621, -4751, -5342, -6040, -6401, -5646, -3931, -2748, -2021, -1058, -772, -606, 682, 2153, 2724, 2997, 3396, 3068, 2594, 2560, 2573, 2139, 1193, 780, -92, -1311, -2071, -2274, -2109, -3010, -3028, -2774, -3880, -4008, -2873, -1772, -880, 111, 744, 362, 142, 479, 751, 1887, 3350, 3457, 2475, 1162, -108, -541, -205, 539, 415, -512, -1264, -2128, -3083, -3323, -2501, -1525, -821, -790, -741, -581, -1154, -434, 843, 861, 934, 1275, 1293, 869, 737, 880, 244, -310, -257, -603, -1004, -1386, -1573, -1083, -1085, -952, -508, -905, -1094, -623, -50, 633, 1253, 1534, 1591, 1563, 1289, 718, 612, 1054, 1055, 863, 578, -31, -356, -525, -890, -744, -613, -637, -157, -634, -924, -224, -212, -305, 327, 664, 125, -46, 114, -345, 104, 912, 1004, 1012, 861, 642, 278, 67, 90, -34, -144, -109, 62, 254, 75, 181, 273, -56, -326, -634, -285, -374, -1319, -874, -297, -765, -312, 604, 127, -934, -695, 109, 29, 653, 1519, 1149, 445, -222, -30, 225, 21, 780, 1157, 724, 244, 35, 798, 1090, 1033, 1900, 1950, 1255, 1312, 1447, 1476, 1847, 1969, 2058, 1799, 1035, 558, 382, 431, 628, 1563, 2603, 1673, -1025, -4948, -8140, -8079, -2856};