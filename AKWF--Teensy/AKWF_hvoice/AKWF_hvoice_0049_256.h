/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0049 256 samples */
 
const int16_t AKWF_hvoice_0049_256_DATA [256] = 
{2984, 9753, 20937, 26913, 29336, 29491, 21478, 14364, 5623, -3009, -7580, -12003, -14769, -16876, -20121, -24175, -27242, -31459, -32173, -30108, -26316, -16191, -7398, 3616, 13449, 17951, 22182, 20981, 18383, 16131, 12823, 11489, 11114, 9819, 8310, 5657, -63, -4645, -10052, -14172, -13777, -13109, -7925, -1836, 3008, 8827, 10212, 10222, 8750, 4777, 2345, 43, -1634, -1759, -2469, -4464, -6481, -10835, -15288, -17853, -20698, -18802, -15356, -10267, -2136, 3434, 9531, 13234, 14112, 14879, 13799, 12994, 13096, 13049, 12731, 12466, 9454, 5649, 916, -5691, -9695, -13743, -15178, -13606, -11985, -7749, -4454, -2011, 187, 368, 433, 655, 724, 1666, 3142, 3593, 4094, 3064, 220, -2281, -6403, -9097, -10196, -10763, -7986, -5184, -1640, 2303, 4434, 6497, 7384, 7639, 8154, 8677, 9189, 10289, 10434, 9451, 8013, 3801, -168, -4647, -9201, -11235, -13130, -12598, -11012, -9306, -6519, -4878, -3639, -2529, -1889, -863, 1384, 3360, 5689, 7813, 7705, 7412, 5204, 2112, -272, -3359, -4499, -4779, -4384, -2404, -1011, 458, 1619, 1855, 2157, 2651, 3127, 4360, 5845, 6625, 7627, 6910, 5254, 3034, -901, -3785, -6917, -9024, -9251, -9350, -7895, -6418, -5225, -3915, -3039, -2283, -926, 754, 2597, 5324, 6981, 8406, 8927, 7674, 6465, 3891, 1547, -104, -1759, -1984, -1952, -1803, -1374, -1444, -1796, -1870, -1994, -1637, -401, 686, 2502, 3910, 4266, 4500, 2928, 1079, -868, -3296, -4363, -5220, -5259, -4459, -3955, -3260, -2796, -2849, -2632, -1899, -1075, 1032, 3217, 5059, 7141, 7538, 7543, 6756, 5083, 3844, 2230, 1167, 578, 56, -77, -279, -831, -1337, -1819, -2342, -1918, -1304, -64, 1876, 3099, 4577, 4970, 4201, 3408, 1527, 116, -504, -1140, -1414, -1620, -3560, -5988, -6700, -7996, -3933};