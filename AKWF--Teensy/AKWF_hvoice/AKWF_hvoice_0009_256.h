/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0009 256 samples */
 
const int16_t AKWF_hvoice_0009_256_DATA [256] = 
{417, 1101, 1781, 2496, 3184, 3943, 4702, 5255, 6031, 7101, 8154, 9558, 10921, 12105, 13722, 15183, 16720, 18459, 19996, 21615, 23540, 25163, 26064, 27387, 28996, 30049, 31101, 32143, 32562, 32748, 32481, 30289, 26414, 22152, 17687, 13165, 9591, 7024, 5108, 3634, 1934, 612, 352, 654, 653, 29, -792, -1287, -1749, -2678, -3716, -4766, -5589, -6191, -6828, -7226, -7049, -7176, -8595, -10669, -12491, -14151, -15974, -17809, -19340, -20345, -21265, -22605, -24209, -25505, -26086, -26189, -25807, -24560, -22369, -19892, -17804, -15866, -13554, -10811, -8350, -6750, -5523, -4104, -2941, -2343, -1882, -1274, -471, 455, 1366, 2480, 4071, 5547, 6320, 6530, 6662, 6959, 7322, 7761, 8506, 9666, 10929, 11961, 12769, 13538, 14462, 15500, 16496, 17546, 18722, 19705, 20206, 20221, 19844, 19248, 18419, 17192, 15686, 14083, 12322, 10405, 8495, 6655, 4998, 3588, 2477, 1792, 1521, 1442, 1211, 592, -404, -1573, -2774, -4001, -5498, -7013, -7724, -8298, -9476, -10370, -10986, -12086, -13077, -13622, -14284, -15053, -15830, -16753, -17661, -18352, -18865, -19203, -19245, -18906, -18234, -17362, -16378, -15268, -14076, -12944, -11741, -10384, -9021, -7795, -6750, -5929, -5429, -5174, -5058, -4958, -4746, -4256, -3490, -2532, -1425, -260, 864, 1910, 2940, 3993, 5048, 6063, 7023, 7910, 8727, 9464, 10077, 10626, 11231, 11869, 12412, 12834, 13152, 13246, 13028, 12525, 11867, 11094, 10264, 9434, 8553, 7476, 6022, 4332, 2633, 1053, -269, -1397, -2432, -3316, -3984, -4519, -5118, -5758, -6400, -7225, -8204, -9152, -10123, -11220, -12380, -13530, -14666, -15636, -16336, -16834, -17166, -17380, -17554, -17729, -17825, -17778, -17633, -17417, -17044, -16468, -15687, -14835, -13939, -12925, -11833, -10726, -9576, -8437, -7325, -6256, -5262, -4337, -3444, -2568, -1851, -1313, -812, -237};