/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0013 256 samples */
 
const int16_t AKWF_hvoice_0013_256_DATA [256] = 
{393, 1306, 2043, 2651, 3201, 3789, 4433, 5099, 5823, 6593, 7289, 8056, 9087, 10252, 11302, 12244, 13063, 13695, 14366, 15325, 16388, 17246, 18261, 19604, 20722, 21712, 22867, 24369, 25897, 26838, 27373, 28177, 29407, 30276, 30108, 29486, 28603, 27630, 27022, 27171, 27214, 25701, 22828, 20629, 20456, 20759, 19026, 15377, 11229, 7416, 4201, 1933, 217, -2178, -5656, -9305, -11717, -12922, -14197, -16320, -19007, -21897, -25451, -29086, -31237, -31681, -31454, -31708, -32325, -32751, -32559, -31795, -30577, -29262, -28573, -28769, -29089, -28516, -26676, -23984, -21013, -18019, -15253, -12843, -10629, -8127, -5397, -2999, -1419, -431, 719, 2542, 4864, 7282, 9543, 11614, 13252, 14453, 15555, 16665, 17463, 17602, 17358, 17170, 17315, 17545, 17599, 17812, 18166, 18172, 17601, 16831, 16248, 15698, 14971, 14094, 13203, 12327, 11348, 10415, 9915, 9837, 9582, 8921, 8145, 7543, 7033, 6531, 6213, 6105, 5899, 5298, 4372, 3482, 2822, 2369, 2080, 1883, 1542, 849, -19, -644, -955, -1364, -2196, -3454, -4905, -6330, -7630, -8732, -9603, -10344, -11116, -11915, -12705, -13464, -14310, -15312, -16453, -17692, -18930, -19946, -20565, -20760, -20675, -20420, -20056, -19517, -18865, -18229, -17654, -17124, -16648, -16125, -15355, -14227, -12700, -10827, -8726, -6523, -4346, -2406, -624, 1124, 2841, 4421, 5853, 7221, 8617, 10085, 11676, 13433, 15165, 16675, 17748, 18414, 18732, 18796, 18690, 18540, 18306, 17871, 17280, 16611, 15981, 15222, 14294, 13142, 11814, 10251, 8516, 6571, 4570, 2604, 746, -1007, -2612, -4158, -5842, -7592, -9302, -10878, -12280, -13544, -14782, -15952, -17087, -18121, -18978, -19501, -19807, -20068, -20360, -20535, -20480, -20156, -19671, -19131, -18516, -17835, -17082, -16251, -15320, -14387, -13469, -12523, -11457, -10267, -8969, -7629, -6292, -4985, -3791, -2716, -1647, -573};