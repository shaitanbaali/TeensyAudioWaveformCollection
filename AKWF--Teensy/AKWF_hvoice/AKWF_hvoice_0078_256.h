/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0078 256 samples */
 
const int16_t AKWF_hvoice_0078_256_DATA [256] = 
{320, 1083, 1888, 2684, 3481, 4224, 4841, 5320, 5677, 5932, 6078, 6104, 5993, 5670, 5153, 4614, 4193, 3958, 3999, 4242, 4378, 4232, 3858, 3335, 2781, 2403, 2254, 2137, 1863, 1446, 948, 457, 198, 314, 658, 1046, 1389, 1631, 1760, 1825, 1871, 1936, 2046, 2221, 2502, 2911, 3459, 4175, 5009, 5878, 6721, 7420, 7873, 8142, 8357, 8585, 8797, 8972, 9058, 8960, 8737, 8641, 8805, 9138, 9538, 9856, 9831, 9423, 8939, 8628, 8477, 8395, 8285, 7946, 7284, 6537, 6002, 5738, 5738, 5944, 6199, 6376, 6464, 6486, 6469, 6425, 6366, 6340, 6412, 6572, 6763, 6952, 7178, 7477, 7886, 8499, 9301, 10100, 10773, 11338, 11860, 12357, 12822, 13234, 13456, 13346, 13027, 12771, 12693, 12768, 12966, 13219, 13506, 13710, 13585, 12976, 11433, 8448, 4342, -126, -4479, -8237, -11090, -13337, -15549, -17843, -19868, -21414, -22526, -23277, -23900, -24911, -26472, -28257, -29985, -31438, -32396, -32775, -32481, -31466, -29770, -27395, -24524, -21529, -18592, -15765, -13068, -10577, -8417, -6614, -5067, -3705, -2335, -697, 1223, 3362, 5646, 7921, 10086, 11957, 13226, 13830, 13827, 13299, 12396, 11239, 9889, 8275, 6378, 4436, 2700, 1235, 61, -863, -1825, -3046, -4544, -6337, -8365, -10482, -12616, -14642, -16466, -18044, -19239, -20018, -20413, -20458, -20171, -19507, -18517, -17316, -15991, -14688, -13575, -12634, -11756, -10849, -9697, -8099, -6162, -4105, -2061, -132, 1651, 3348, 5110, 6893, 8446, 9651, 10475, 10876, 10962, 10887, 10746, 10588, 10454, 10318, 10144, 9904, 9527, 8974, 8299, 7559, 6724, 5685, 4392, 2860, 1102, -688, -2232, -3432, -4309, -4880, -5236, -5465, -5619, -5741, -5854, -5979, -6131, -6328, -6600, -6937, -7280, -7586, -7684, -7353, -6607, -5552, -4295, -3083, -2136, -1410, -793, -187};