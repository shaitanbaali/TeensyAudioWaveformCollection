/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0052 256 samples */
 
const int16_t AKWF_hvoice_0052_256_DATA [256] = 
{298, 1191, 1985, 2153, 2319, 2212, 1954, 2115, 2772, 3887, 4688, 4303, 4356, 4773, 5087, 5753, 5605, 6103, 6885, 6603, 7043, 7477, 7500, 9026, 9660, 10257, 11297, 11004, 12297, 13267, 13233, 14407, 14170, 14953, 16379, 16136, 17529, 18363, 18390, 20118, 20165, 20157, 21249, 20854, 22206, 23432, 23006, 23751, 23470, 24081, 25321, 25165, 26463, 26709, 26384, 26989, 26265, 26367, 27112, 28285, 29004, 25735, 22264, 22309, 24188, 25579, 27436, 31946, 31001, 18756, 4226, -2467, -2024, 1406, 2288, 609, 425, 676, 2419, 4645, 4402, 3954, 2538, 658, -670, -3262, -4750, -6487, -8632, -8834, -9521, -9887, -10468, -11494, -10820, -11197, -11531, -11237, -12714, -13048, -13473, -14625, -14528, -14807, -14664, -14308, -14600, -14713, -15269, -15627, -15666, -15245, -14779, -15151, -15314, -15281, -15107, -14517, -14791, -14577, -14381, -15286, -14903, -15036, -15290, -14672, -15232, -14870, -14560, -14617, -13634, -13521, -13632, -13157, -12917, -12507, -12213, -12612, -12536, -12054, -11904, -11181, -10544, -10530, -10173, -9871, -10008, -9443, -9202, -9103, -8387, -8441, -8572, -8385, -8066, -7318, -6357, -5989, -6092, -6058, -6271, -5510, -4569, -4919, -4880, -5025, -5104, -4231, -3850, -4144, -3622, -3672, -3496, -2996, -3281, -2965, -2284, -2405, -2417, -2293, -1753, -1130, -1454, -2179, -2444, -1763, -1304, -1236, -1287, -1520, -997, -685, -868, -1076, -1374, -1291, -1003, -1266, -1615, -1605, -1419, -1383, -1262, -1904, -2034, -1314, -1612, -1654, -1540, -1939, -2201, -1880, -1126, -1133, -1746, -1958, -2221, -2653, -2304, -1801, -1895, -2424, -2917, -2538, -1977, -1876, -2230, -2475, -2633, -2745, -2635, -2637, -2865, -2696, -2443, -2551, -2194, -2424, -2430, -1855, -2089, -1962, -2253, -2152, -1680, -1878, -1602, -1538, -1590, -1880, -2134, -1166, -654, -391, -103, -280};