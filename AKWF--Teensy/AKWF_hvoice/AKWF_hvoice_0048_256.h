/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0048 256 samples */
 
const int16_t AKWF_hvoice_0048_256_DATA [256] = 
{1617, 4645, 7855, 11238, 14723, 17783, 20208, 21853, 22678, 22503, 21438, 19616, 17174, 14114, 10565, 6734, 2940, -632, -3765, -6322, -8235, -9499, -9991, -9720, -8874, -7617, -5833, -3587, -1131, 1244, 3483, 5549, 7314, 8599, 9533, 10303, 10881, 11078, 10950, 10714, 10529, 10154, 9564, 8903, 8617, 8639, 8561, 8064, 7380, 6733, 5970, 5135, 4319, 3579, 2697, 1955, 1394, 1018, 943, 1598, 2771, 4115, 5272, 6222, 6897, 7176, 6814, 5759, 4486, 3308, 2070, -84, -3361, -7128, -10615, -13832, -16844, -19338, -20906, -21277, -20582, -19078, -17134, -14911, -12475, -9891, -7202, -4580, -2422, -960, -65, 269, -135, -1327, -3100, -5118, -7048, -8950, -10858, -12802, -14618, -16321, -17604, -18393, -18671, -18447, -17541, -16092, -14725, -13661, -12638, -11179, -9317, -7348, -5485, -3358, -736, 2108, 4914, 7816, 10655, 13081, 15275, 17387, 19048, 19754, 19630, 19158, 18404, 16846, 14386, 11480, 8563, 5348, 2044, -938, -3426, -5722, -7673, -8862, -9083, -8647, -7622, -5827, -3167, -235, 2616, 5540, 8610, 11196, 12800, 13866, 14872, 15491, 15193, 14124, 12788, 11288, 9449, 7436, 5522, 3934, 2478, 1169, 146, -593, -1161, -1590, -1649, -1246, -705, -271, 353, 1357, 2610, 3702, 4845, 6073, 7299, 8216, 9098, 10218, 11313, 11973, 12060, 11924, 11536, 10551, 8643, 6319, 3927, 1381, -1427, -3981, -5892, -7200, -7738, -7023, -5264, -3267, -1413, 638, 2723, 4331, 4974, 4834, 4076, 2497, -199, -3803, -7885, -12382, -17168, -21763, -25638, -28679, -30961, -32407, -32739, -32009, -30605, -28632, -25905, -22556, -18994, -15403, -11707, -8036, -4671, -1816, 592, 2747, 4613, 6019, 7016, 7806, 8250, 8322, 8169, 7744, 6876, 5534, 3818, 1970, 127, -1641, -3309, -4712, -5816, -6587, -6867, -6637, -6009, -4980, -3354, -1047};