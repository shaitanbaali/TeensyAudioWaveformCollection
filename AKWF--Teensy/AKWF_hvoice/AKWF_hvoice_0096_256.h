/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0096 256 samples */
 
const int16_t AKWF_hvoice_0096_256_DATA [256] = 
{164, 342, 250, 181, 234, 504, 629, 317, 83, 282, 455, 343, 223, 217, 246, 589, 1114, 1088, 970, 1670, 2444, 2231, 1648, 1506, 2108, 3947, 5486, 3782, 613, 1112, 4411, 5470, 4277, 3904, 4632, 5363, 5753, 5548, 5180, 6091, 7686, 7113, 4754, 4491, 6814, 8042, 7644, 7769, 7666, 6778, 7198, 8363, 7742, 7012, 8299, 9344, 8264, 6636, 5951, 6484, 7842, 8497, 7743, 7192, 7341, 6803, 5783, 5540, 6023, 7428, 9441, 8151, 1391, -3968, -15, 8066, 8699, 4970, 8682, 11459, -5619, -29896, -29517, -7916, 2433, -6043, -15761, -19570, -21388, -19896, -13829, -6047, 1765, 6422, 1734, -11011, -17961, -8567, 7922, 12814, 3968, -6167, -11629, -14255, -13345, -8288, -3568, -3538, -8257, -15983, -22346, -19792, -7695, 2640, 2319, -4460, -8714, -7828, -3648, 2417, 7766, 8550, 4493, -1127, -6002, -7556, -3239, 2564, 2605, -2829, -8516, -11933, -12034, -7886, -2516, -123, -437, -2174, -5312, -6852, -3349, 3142, 7429, 7405, 4191, -377, -3431, -1999, 3029, 6503, 4854, -111, -4877, -7498, -6160, -1732, 868, 219, -603, -1818, -4159, -4031, -196, 3909, 6037, 5316, 1759, -1173, -115, 3183, 4967, 4426, 3119, 1549, -954, -2597, -1504, 25, 724, 1857, 1154, -2631, -4164, -884, 2132, 1742, 940, 2274, 3407, 1639, -959, 26, 3894, 5136, 1891, -1114, -329, 1904, 1871, -422, -1906, -773, 847, 368, -1543, -2032, 322, 2529, 690, -2889, -2642, 967, 2672, 1130, -306, -253, 201, 767, 631, -747, -686, 1383, 1153, -1965, -3580, -2110, 318, 753, -1371, -2979, -2174, -759, -199, -987, -2485, -1337, 2083, 1995, -1260, -2039, -530, 306, 724, 345, -1093, -1145, 207, 315, -686, -1018, -718, -249, 145, -134, -639, -382};