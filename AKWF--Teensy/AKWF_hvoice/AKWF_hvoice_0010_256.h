/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0010 256 samples */
 
const int16_t AKWF_hvoice_0010_256_DATA [256] = 
{203, 862, 1566, 2377, 3319, 4444, 5695, 7080, 8605, 10374, 12160, 13852, 15503, 17039, 18529, 19981, 20995, 22136, 23531, 24427, 25476, 26306, 26677, 27514, 28755, 29772, 30173, 30465, 31041, 31744, 32305, 32439, 32732, 32359, 29734, 25478, 19878, 13894, 8424, 3746, 114, -2515, -3441, -3094, -3050, -3138, -1757, 147, 729, 439, 210, -207, -1538, -4016, -7012, -9821, -12374, -14583, -16689, -18393, -19318, -20227, -21836, -23722, -25006, -25550, -25834, -26069, -25577, -24324, -23273, -22605, -21819, -20332, -18096, -15686, -13477, -11197, -8833, -7082, -6166, -5593, -4841, -3826, -3191, -3014, -2728, -2426, -2245, -2204, -1960, -1000, 700, 2800, 5126, 7951, 10969, 13517, 15398, 16829, 18304, 19798, 21147, 22368, 23386, 24029, 24022, 23252, 22076, 20858, 19641, 18353, 17115, 15934, 14779, 13667, 12637, 11877, 11477, 11382, 11540, 11717, 11847, 11870, 11593, 10865, 9759, 8410, 6882, 5269, 3651, 2178, 785, -791, -2575, -4524, -6615, -8692, -10664, -12396, -13840, -15035, -16020, -16812, -17398, -17741, -17840, -17705, -17248, -16456, -15587, -14787, -14048, -13407, -12929, -12691, -12633, -12658, -12750, -12921, -13208, -13533, -13752, -13839, -13771, -13340, -12362, -10896, -9118, -7156, -5063, -2939, -964, 839, 2554, 4205, 5738, 7075, 8167, 9019, 9604, 9974, 10143, 10178, 10161, 10187, 10175, 10158, 10205, 10254, 10346, 10460, 10708, 11138, 11730, 12371, 12944, 13422, 13786, 13927, 13818, 13545, 13145, 12636, 11952, 11003, 9577, 7447, 4885, 2361, -18, -2199, -4092, -6000, -7854, -9249, -10269, -11157, -11824, -12236, -12521, -12730, -12841, -12886, -13101, -13630, -14233, -14663, -15063, -15392, -15622, -16032, -16625, -17185, -17632, -18117, -18531, -18660, -18620, -18477, -18062, -17338, -16397, -15302, -13960, -12365, -10638, -8829, -7172, -5839, -4650, -3528, -2625, -1853, -1137, -444};