/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0017 256 samples */
 
const int16_t AKWF_hvoice_0017_256_DATA [256] = 
{269, 1311, 2331, 3314, 4247, 5082, 5877, 6669, 7341, 7847, 8336, 8819, 9207, 9533, 9584, 9437, 9357, 9270, 9142, 8966, 8600, 8181, 7774, 7342, 6858, 6366, 5839, 5342, 4861, 4436, 4071, 3656, 3184, 2762, 2357, 2258, 2304, 2256, 2196, 2087, 2032, 2248, 2491, 2650, 2889, 3291, 3729, 4241, 4643, 4911, 5338, 5898, 6480, 7100, 7561, 7950, 8285, 8593, 8941, 9272, 9512, 9738, 9953, 10207, 10563, 10871, 11108, 11363, 11645, 11921, 12204, 12377, 12483, 12560, 12613, 12673, 12726, 12781, 12802, 12685, 12569, 12505, 12487, 12555, 12627, 12689, 12834, 13097, 13240, 13299, 13435, 13613, 13757, 13860, 13500, 12991, 12600, 12237, 11994, 11727, 11310, 11100, 11534, 11427, 10805, 8755, 4992, 1387, -2357, -5940, -9544, -13314, -17107, -19967, -22458, -24738, -26766, -28296, -29391, -29569, -29733, -30006, -30465, -31249, -31915, -32536, -32780, -32728, -32262, -31476, -30449, -29181, -27483, -25455, -22735, -19762, -16490, -13251, -10220, -7438, -4981, -2844, -1069, 669, 2389, 4011, 5586, 6695, 7519, 8331, 9098, 9997, 10887, 11688, 12313, 12507, 12359, 11557, 10574, 9365, 8010, 6452, 4683, 2607, 591, -1485, -3533, -5596, -7328, -8884, -10048, -11080, -12238, -13377, -14537, -15564, -16300, -16918, -17413, -17792, -18078, -18151, -18020, -17689, -17175, -16389, -15374, -13985, -12363, -10709, -9026, -7461, -5871, -4095, -2346, -653, 874, 2154, 3402, 4656, 5783, 6793, 7806, 8822, 9975, 11209, 11938, 12422, 12704, 12859, 12973, 12954, 12558, 12085, 11628, 11015, 10131, 9145, 7943, 6965, 6216, 5312, 4293, 3215, 2065, 932, -216, -1413, -2578, -3438, -4235, -5056, -5902, -6887, -7765, -8478, -9052, -9484, -9694, -9662, -9641, -9600, -9622, -9666, -9339, -8818, -8132, -7362, -6643, -5889, -4997, -4111, -3303, -2474, -1582, -664};