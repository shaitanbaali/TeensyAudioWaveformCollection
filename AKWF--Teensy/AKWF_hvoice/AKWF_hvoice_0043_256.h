/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0043 256 samples */
 
const int16_t AKWF_hvoice_0043_256_DATA [256] = 
{1303, 3558, 4631, 5723, 5923, 6699, 7566, 8506, 9620, 10254, 10969, 10172, 10145, 9437, 8571, 6792, 6345, 7097, 7634, 8116, 6912, 7005, 6874, 8617, 10501, 12514, 13900, 12494, 12302, 11781, 14434, 15445, 17571, 17262, 18123, 17518, 18802, 18920, 20352, 20080, 18769, 16379, 14574, 15129, 14970, 13371, 9438, 5824, 3565, 1524, -141, -3318, -6771, -11479, -15666, -18752, -19905, -21648, -24162, -27742, -29816, -30931, -30860, -30740, -31146, -31723, -32757, -32517, -31401, -29405, -27820, -27215, -26116, -24057, -20653, -17807, -15298, -13667, -12074, -10436, -7693, -4775, -2041, -345, 731, 2430, 5131, 8576, 11036, 12819, 13693, 14516, 15346, 16603, 17850, 18139, 17411, 16186, 15178, 14817, 14550, 13605, 12199, 10634, 9298, 7609, 6659, 5670, 4635, 3495, 2400, 2356, 2803, 3748, 3869, 3859, 4042, 4709, 5885, 7687, 9642, 10468, 10267, 11192, 13384, 15134, 14913, 14002, 13455, 12463, 11630, 10754, 10349, 10054, 8768, 8194, 7397, 6651, 3383, 894, 817, 1634, 1471, -1189, -3734, -5384, -5964, -5745, -5256, -4611, -5066, -7316, -8846, -9745, -9353, -10104, -11430, -12161, -12702, -13214, -14657, -15287, -14676, -14180, -13343, -12896, -12251, -12216, -12286, -10935, -9476, -6880, -6174, -5140, -4530, -2536, -969, 614, 2498, 4914, 5947, 6111, 5865, 6495, 7721, 9180, 10777, 10941, 11166, 10070, 10252, 10752, 11878, 12289, 11608, 10782, 9737, 8070, 7533, 8108, 9424, 9424, 8426, 7617, 7604, 9423, 10062, 9873, 9576, 9212, 8189, 7515, 9129, 10617, 9488, 7361, 5395, 4784, 4592, 3480, 2256, -222, -2508, -5989, -8281, -9219, -9948, -11707, -14286, -16461, -18054, -19586, -20379, -20697, -20667, -20991, -21908, -21582, -20528, -19627, -19869, -20407, -19362, -18304, -16717, -15709, -14544, -13263, -12031, -10384, -8422, -5905, -3603, -2888, -2242, -700};