/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0036 256 samples */
 
const int16_t AKWF_hvoice_0036_256_DATA [256] = 
{627, 2880, 4388, 4516, 4682, 5906, 6531, 5870, 5398, 6279, 7675, 7504, 6231, 5844, 6159, 5767, 4895, 5452, 7436, 9213, 11076, 13260, 15674, 18323, 21589, 25713, 29238, 31005, 31687, 32438, 32768, 31473, 29785, 29773, 29925, 27805, 23664, 19995, 17056, 13604, 9536, 5542, 2679, 499, -1819, -3613, -4082, -4046, -4314, -5013, -6099, -6924, -6754, -5788, -4455, -3516, -3248, -3002, -2592, -2464, -2584, -2621, -2679, -2972, -4019, -5297, -5428, -4561, -3934, -3476, -2651, -1252, 763, 2677, 4194, 5818, 7433, 8488, 9289, 10423, 11774, 12991, 13551, 13126, 11764, 9724, 7362, 4735, 1822, -1084, -3659, -5902, -8016, -10118, -12063, -13539, -14848, -16311, -17455, -17789, -17515, -16962, -16110, -14973, -13510, -11955, -10731, -9702, -8553, -7356, -6536, -6124, -5867, -5683, -5545, -5417, -5248, -4852, -4181, -3602, -3272, -2932, -2456, -1858, -1076, -87, 1210, 2950, 4838, 6375, 7393, 8064, 8373, 7982, 7040, 6048, 5267, 4285, 2714, 681, -1393, -3317, -5546, -8064, -10171, -11716, -13006, -14292, -15401, -15903, -15709, -15295, -14973, -14335, -13138, -11686, -10373, -9222, -7985, -6668, -5563, -4857, -4214, -3333, -2411, -1778, -1451, -1173, -967, -870, -791, -611, -82, 863, 2020, 3259, 4587, 5865, 6946, 7803, 8550, 9200, 9590, 9854, 10116, 10034, 9214, 7699, 5944, 4121, 1974, -563, -2975, -4823, -6534, -8458, -10184, -11464, -12280, -12870, -13268, -13139, -12409, -11433, -10374, -9058, -7483, -5983, -4700, -3395, -1966, -744, 8, 527, 984, 1117, 689, 21, -331, -520, -920, -1420, -1574, -1669, -2111, -2597, -2697, -2404, -2181, -2236, -1968, -1197, -718, -1002, -1396, -1573, -1977, -2750, -3747, -4441, -4848, -5461, -6364, -7221, -7769, -8057, -8259, -8730, -8696, -7729, -6398, -5302, -4429, -3280, -1747, -364};