/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0094 256 samples */
 
const int16_t AKWF_hvoice_0094_256_DATA [256] = 
{342, 863, 1272, 1629, 1936, 2222, 2522, 2836, 3213, 3535, 3774, 3854, 3891, 3924, 4073, 4289, 4546, 4730, 4853, 4903, 4932, 4971, 5030, 5157, 5323, 5524, 5683, 5779, 5801, 5843, 5952, 6158, 6336, 6476, 6557, 6657, 6818, 7080, 7393, 7784, 8273, 8844, 9457, 10081, 10790, 11564, 12433, 13146, 13735, 14183, 14614, 14941, 15085, 14968, 14669, 14238, 13735, 13143, 12425, 11634, 10791, 9926, 9116, 8377, 7780, 7111, 6362, 5499, 4662, 3920, 3438, 3175, 2745, 1431, -1177, -4753, -8631, -12234, -15575, -18807, -21914, -24879, -27694, -30173, -32078, -32719, -32017, -30141, -27655, -25149, -22679, -20277, -17680, -14853, -11783, -8916, -6387, -4673, -3572, -3015, -2650, -2177, -1517, -613, 207, 873, 1292, 1772, 2394, 3299, 4248, 5135, 5664, 5661, 5013, 3727, 2189, 547, -1014, -2671, -4515, -6571, -8609, -10500, -11893, -12688, -12751, -12212, -11405, -10508, -9690, -8778, -7686, -6262, -4716, -3137, -1865, -878, -231, 276, 739, 1250, 1914, 2641, 3364, 3901, 4292, 4506, 4886, 5419, 6178, 6795, 7226, 7320, 7172, 6773, 6066, 5237, 4339, 3494, 2513, 1398, 81, -1138, -2207, -3006, -3525, -3782, -3769, -3671, -3515, -3393, -3087, -2606, -1872, -1131, -453, 31, 326, 471, 556, 731, 1009, 1376, 1734, 2062, 2282, 2418, 2505, 2711, 3056, 3515, 3844, 3899, 3647, 3166, 2643, 2131, 1696, 1248, 748, 74, -733, -1653, -2420, -2960, -3245, -3415, -3563, -3737, -3911, -4069, -4208, -4201, -4020, -3634, -3227, -2914, -2782, -2694, -2545, -2249, -1829, -1355, -864, -485, -192, 4, 177, 380, 667, 1047, 1413, 1674, 1679, 1555, 1377, 1313, 1291, 1265, 1157, 987, 762, 454, 108, -245, -452, -568, -619, -735, -877, -1002, -975, -807, -501, -125};