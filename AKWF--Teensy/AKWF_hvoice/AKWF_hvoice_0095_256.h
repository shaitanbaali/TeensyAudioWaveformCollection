/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0095 256 samples */
 
const int16_t AKWF_hvoice_0095_256_DATA [256] = 
{311, 1742, 3651, 3383, 2222, 2703, 3884, 3653, 2530, 1888, 1956, 3286, 5306, 4887, 1690, 610, 3317, 5465, 4893, 4121, 4520, 5296, 5878, 5921, 5475, 5863, 7508, 7903, 5847, 4537, 6199, 8068, 8094, 8067, 8194, 7375, 7223, 8430, 8437, 7449, 8122, 9529, 9178, 7583, 6445, 6470, 7654, 8748, 8425, 7683, 7677, 7421, 6422, 5838, 6036, 7058, 9188, 9601, 4413, -2604, -2296, 5503, 9393, 6144, 7077, 12417, 2631, -22780, -33376, -16964, -412, -2689, -12995, -19044, -21938, -22073, -17423, -9867, -1536, 5312, 4561, -6222, -17197, -13934, 1925, 12496, 8087, -2479, -10019, -14099, -14881, -11030, -5538, -3469, -6449, -13457, -21379, -22895, -13536, -971, 3082, -2004, -7770, -8908, -5869, -175, 6088, 9003, 6575, 1213, -4380, -7787, -5570, 532, 3142, -650, -6688, -11289, -13029, -10346, -4812, -1031, -321, -1438, -4297, -6982, -5400, 555, 6215, 7984, 5907, 1508, -2641, -3094, 1016, 5668, 6052, 1975, -3212, -7049, -7425, -3728, 47, 429, -348, -1256, -3560, -4685, -1956, 2401, 5545, 6112, 3402, -315, -839, 1981, 4591, 4901, 3804, 2366, 38, -2302, -2169, -563, 328, 1474, 1799, -1251, -4210, -2420, 1188, 2010, 1079, 1726, 3290, 2588, -194, -751, 2520, 5218, 3391, -227, -886, 1166, 2146, 474, -1631, -1423, 312, 693, -924, -2213, -801, 1978, 1700, -1810, -3268, -472, 2313, 1798, 113, -343, -52, 531, 822, -317, -1038, 667, 1563, -851, -3373, -3009, -651, 781, -571, -2704, -2749, -1389, -429, -650, -2163, -2283, 924, 2575, -229, -2371, -1362, -135, 649, 750, -969, -2022, -527, 447, -744, -1840, -1783, -1117, -202, -257, -1480, -1681, -428, 408, 369, 123, 72, 919, 2097, 1423, -413, -8, 2182, 2564, 879, -255};