/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0047 256 samples */
 
const int16_t AKWF_hvoice_0047_256_DATA [256] = 
{1027, 3291, 4603, 5046, 5988, 7974, 9398, 10500, 12691, 16242, 22462, 30153, 32848, 28416, 25227, 25991, 22711, 13379, 5015, 1045, -1642, -4406, -8086, -11121, -11997, -12341, -14567, -15678, -14835, -16370, -19372, -18773, -14296, -10331, -8132, -6930, -4136, 36, 1401, -2391, -6929, -8771, -10463, -13586, -15666, -15067, -14115, -13102, -11465, -8777, -6622, -6433, -8110, -8645, -6973, -6269, -7455, -7498, -4388, -1005, 844, 1306, 1472, 1445, 560, -1609, -3879, -4811, -5145, -4764, -2711, 732, 3399, 5047, 6320, 7194, 7334, 6230, 3706, 1252, 417, 261, -309, -514, 227, 1441, 3069, 4737, 4872, 3492, 2223, 2053, 2895, 4677, 5597, 6014, 7570, 11180, 12776, 11629, 8441, 5943, 4216, 2945, 7, -3205, -4337, -3573, -2670, -2017, -1556, -2208, -2732, -2329, -1187, -916, -1031, -1013, 1185, 4517, 6849, 6435, 5805, 5770, 6223, 4471, 1856, 309, 733, 431, 273, 872, 2545, 3654, 5406, 8432, 10969, 10778, 10128, 12274, 14975, 16501, 19558, 26325, 29268, 26932, 25002, 24652, 19375, 9958, 110, -7978, -13122, -17143, -23425, -28484, -27805, -26067, -26148, -24824, -22337, -21915, -20656, -17598, -13873, -8919, -3925, -1179, 3575, 11428, 14450, 10919, 6382, 3133, -1509, -7359, -14685, -21515, -25167, -26340, -27278, -26295, -22739, -20182, -18100, -13918, -8571, -5355, -3261, -369, 4666, 11524, 16821, 18329, 19233, 21846, 22013, 17988, 11656, 4685, -1914, -6282, -9724, -13535, -16276, -16709, -14926, -11159, -7199, -5377, -4031, -386, 4599, 8436, 10914, 13120, 16674, 22514, 27473, 27026, 22629, 18197, 14509, 9309, 2214, -5626, -12138, -14907, -14784, -13263, -11698, -9124, -6128, -1806, 2108, 4541, 4390, 4235, 5844, 8603, 9505, 8072, 6389, 6709, 7240, 5127, 11, -4604, -6455, -7347, -9060, -10156, -8787, -6066, -3034, -670};