/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0089 256 samples */
 
const int16_t AKWF_hvoice_0089_256_DATA [256] = 
{160, 460, 744, 1017, 1269, 1497, 1686, 1823, 1908, 1942, 1935, 1888, 1802, 1684, 1543, 1396, 1247, 1100, 965, 849, 757, 696, 667, 659, 665, 675, 688, 700, 701, 687, 655, 604, 542, 470, 389, 299, 215, 144, 93, 62, 58, 96, 177, 290, 435, 610, 813, 1043, 1293, 1569, 1865, 2180, 2517, 2883, 3294, 3764, 4289, 4867, 5483, 6127, 6795, 7477, 8159, 8833, 9492, 10128, 10742, 11322, 11868, 12375, 12856, 13337, 13841, 14388, 14988, 15663, 16464, 17438, 18587, 19894, 21312, 22825, 24428, 26066, 27660, 29119, 30364, 31379, 32139, 32619, 32775, 32603, 32139, 31447, 30582, 29581, 28481, 27330, 26177, 25076, 24039, 23066, 22133, 21224, 20322, 19413, 18470, 17448, 16320, 15072, 13715, 12239, 10647, 8930, 7108, 5218, 3267, 1252, -796, -2863, -4912, -6905, -8867, -10764, -12562, -14230, -15740, -17091, -18294, -19312, -20130, -20755, -21202, -21498, -21665, -21718, -21679, -21574, -21438, -21298, -21170, -21051, -20925, -20781, -20615, -20416, -20155, -19791, -19293, -18654, -17881, -16973, -15915, -14720, -13393, -11988, -10542, -9070, -7600, -6163, -4787, -3518, -2363, -1322, -409, 384, 1059, 1620, 2085, 2463, 2762, 2999, 3179, 3310, 3403, 3459, 3486, 3487, 3462, 3413, 3345, 3252, 3124, 2949, 2730, 2461, 2131, 1726, 1231, 645, -13, -749, -1579, -2488, -3464, -4482, -5511, -6556, -7604, -8615, -9557, -10400, -11126, -11750, -12264, -12673, -12983, -13203, -13354, -13464, -13554, -13638, -13716, -13793, -13876, -13968, -14063, -14149, -14218, -14258, -14267, -14239, -14156, -14010, -13792, -13504, -13155, -12734, -12243, -11690, -11088, -10448, -9775, -9080, -8374, -7682, -7008, -6370, -5767, -5208, -4692, -4220, -3793, -3408, -3057, -2736, -2441, -2164, -1903, -1651, -1406, -1164, -919, -668, -406, -119};