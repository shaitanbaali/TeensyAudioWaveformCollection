/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0100 256 samples */
 
const int16_t AKWF_hvoice_0100_256_DATA [256] = 
{686, 1759, 2936, 4016, 4825, 5383, 5838, 6302, 6910, 7692, 8733, 9843, 10544, 10890, 11166, 11662, 12667, 13565, 13552, 13001, 12466, 12700, 14073, 15239, 15299, 14695, 14016, 13767, 13897, 13494, 12456, 11905, 12163, 12928, 13505, 12846, 11296, 9726, 8677, 8426, 8777, 9633, 10143, 9586, 8277, 6658, 5795, 6170, 6846, 7165, 7188, 7148, 6969, 6618, 6048, 5552, 6128, 7487, 8353, 8433, 7930, 7641, 8527, 9922, 10794, 11013, 10843, 10647, 10581, 10854, 11544, 12930, 14976, 15855, 14984, 13774, 13141, 13580, 14142, 11618, 6803, 3522, 3101, 5791, 8369, 6681, 1845, -3564, -7574, -9476, -10304, -10974, -11659, -12191, -13680, -16694, -20436, -24116, -26434, -27212, -26870, -26139, -25992, -26714, -28677, -31059, -32458, -32756, -32384, -31668, -30602, -29106, -26977, -25483, -25696, -26649, -27304, -26479, -23945, -20886, -18034, -15394, -12912, -11616, -11540, -12083, -12182, -9813, -5653, -1550, 1327, 2238, 2155, 2235, 2721, 3353, 4328, 5975, 7842, 9524, 10608, 11010, 10777, 10048, 8875, 7546, 7362, 8442, 9874, 10794, 10166, 8348, 6173, 4237, 2722, 1940, 2460, 3311, 3388, 2139, -594, -3175, -4459, -4854, -4979, -5176, -5473, -5963, -6725, -8281, -10329, -11248, -10750, -9315, -8061, -8710, -10597, -12126, -12454, -11179, -9375, -8081, -7695, -8231, -8761, -8644, -7660, -5943, -4451, -3598, -3173, -2816, -2004, -778, 147, 705, 1490, 2652, 4004, 5104, 5341, 5280, 5927, 6990, 7752, 7978, 7724, 7755, 8613, 9439, 9549, 9150, 8605, 8147, 7780, 7382, 6944, 6757, 6755, 6336, 5520, 4848, 4313, 3458, 2210, 573, -595, -282, 590, 894, 113, -1736, -3732, -5261, -5805, -5364, -4267, -2977, -2956, -4403, -6248, -7622, -7614, -6548, -5253, -4275, -3909, -4033, -4620, -5061, -4682, -3707, -2501, -1533, -1025, -332};