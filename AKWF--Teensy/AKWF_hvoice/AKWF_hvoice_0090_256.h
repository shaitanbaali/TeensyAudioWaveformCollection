/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0090 256 samples */
 
const int16_t AKWF_hvoice_0090_256_DATA [256] = 
{254, 954, 1514, 2092, 2649, 3198, 3727, 4242, 4743, 5226, 5693, 6142, 6570, 6979, 7366, 7733, 8088, 8429, 8755, 9067, 9373, 9675, 9969, 10262, 10559, 10866, 11181, 11506, 11845, 12202, 12575, 12969, 13383, 13824, 14289, 14783, 15303, 15851, 16435, 17049, 17708, 18401, 19120, 19869, 20648, 21452, 22276, 23100, 23930, 24764, 25596, 26408, 27194, 27950, 28675, 29364, 30004, 30585, 31109, 31577, 31971, 32294, 32535, 32690, 32762, 32754, 32646, 32436, 32130, 31734, 31246, 30661, 29985, 29225, 28393, 27490, 26512, 25470, 24373, 23226, 22032, 20786, 19494, 18174, 16830, 15457, 14060, 12647, 11236, 9828, 8436, 7055, 5698, 4370, 3079, 1825, 604, -583, -1729, -2842, -3922, -4957, -5956, -6912, -7828, -8704, -9536, -10320, -11059, -11755, -12406, -13019, -13582, -14111, -14606, -15062, -15488, -15880, -16243, -16588, -16898, -17179, -17432, -17658, -17859, -18030, -18166, -18266, -18335, -18375, -18380, -18348, -18285, -18188, -18062, -17903, -17707, -17482, -17229, -16941, -16616, -16262, -15879, -15472, -15046, -14597, -14132, -13655, -13165, -12669, -12163, -11653, -11140, -10627, -10113, -9603, -9098, -8600, -8119, -7646, -7190, -6758, -6350, -5974, -5623, -5303, -5024, -4783, -4573, -4406, -4273, -4171, -4103, -4063, -4049, -4060, -4105, -4177, -4271, -4388, -4530, -4697, -4891, -5102, -5327, -5571, -5835, -6103, -6380, -6660, -6937, -7213, -7487, -7750, -8008, -8259, -8499, -8740, -8977, -9211, -9449, -9692, -9934, -10171, -10403, -10631, -10847, -11059, -11260, -11454, -11643, -11821, -11996, -12171, -12342, -12511, -12677, -12837, -12991, -13138, -13272, -13394, -13499, -13586, -13648, -13691, -13703, -13682, -13635, -13559, -13449, -13305, -13130, -12921, -12682, -12406, -12091, -11738, -11347, -10920, -10452, -9944, -9395, -8808, -8191, -7546, -6870, -6180, -5475, -4766, -4052, -3342, -2637, -1932, -1240, -539};