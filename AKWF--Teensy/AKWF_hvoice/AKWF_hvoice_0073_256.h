/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0073 256 samples */
 
const int16_t AKWF_hvoice_0073_256_DATA [256] = 
{525, 1327, 1980, 2450, 2753, 2911, 2917, 2815, 2673, 2543, 2459, 2400, 2340, 2288, 2258, 2218, 2143, 2071, 2040, 2042, 2047, 2075, 2136, 2255, 2426, 2626, 2866, 3153, 3454, 3758, 4048, 4295, 4501, 4670, 4806, 4947, 5131, 5328, 5513, 5654, 5764, 5894, 6065, 6242, 6474, 6826, 7317, 7927, 8601, 9262, 9813, 10183, 10274, 10031, 9470, 8618, 7511, 6258, 4973, 3808, 2869, 2230, 1945, 2031, 2453, 3149, 4007, 4849, 5513, 5874, 5807, 5245, 4298, 3160, 1899, 445, -1274, -3344, -5942, -9146, -12939, -17163, -21507, -25610, -29118, -31618, -32745, -32209, -29958, -26107, -20894, -14627, -7768, -890, 5401, 10618, 14522, 16800, 17344, 16265, 13898, 10472, 6330, 1893, -2439, -6300, -9444, -11866, -13566, -14518, -14782, -14511, -13849, -12859, -11588, -10064, -8322, -6392, -4195, -1718, 923, 3573, 6133, 8449, 10382, 11753, 12415, 12304, 11415, 9698, 7208, 4115, 623, -2994, -6446, -9487, -11882, -13370, -13848, -13322, -11847, -9582, -6768, -3653, -537, 2330, 4824, 6805, 8190, 8941, 9158, 8870, 8127, 7040, 5766, 4449, 3204, 2116, 1210, 484, -147, -789, -1530, -2413, -3419, -4408, -5281, -5932, -6186, -5918, -5094, -3748, -1928, 214, 2511, 4695, 6490, 7728, 8351, 8308, 7608, 6318, 4628, 2694, 695, -1184, -2723, -3822, -4426, -4534, -4222, -3613, -2783, -1858, -1022, -333, 160, 446, 526, 471, 346, 261, 266, 328, 422, 555, 705, 802, 797, 683, 404, -97, -806, -1629, -2481, -3263, -3807, -4034, -3872, -3313, -2460, -1443, -315, 787, 1674, 2220, 2391, 2205, 1700, 887, -179, -1293, -2281, -3003, -3399, -3436, -3117, -2446, -1532, -531, 454, 1360, 2066, 2509, 2665, 2485, 2038, 1404, 643, -168, -881, -1425, -1703, -1652, -1246, -448};