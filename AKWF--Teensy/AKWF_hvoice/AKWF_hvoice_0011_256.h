/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0011 256 samples */
 
const int16_t AKWF_hvoice_0011_256_DATA [256] = 
{206, 810, 1275, 1716, 2227, 2898, 3815, 5021, 6496, 8179, 10019, 11967, 13968, 15962, 17863, 19621, 21213, 22607, 23818, 24844, 25604, 26100, 26407, 26591, 26780, 27049, 27432, 28058, 28932, 29950, 31027, 31963, 32590, 32765, 32247, 30803, 28083, 23752, 18009, 11482, 5058, -193, -3669, -5314, -5423, -4583, -3150, -1313, 538, 1953, 2532, 2138, 839, -1392, -4493, -8263, -12421, -16480, -19911, -22352, -23713, -24270, -24453, -24561, -24735, -24944, -25086, -25064, -24733, -24011, -22932, -21578, -19982, -18136, -16081, -13905, -11762, -9928, -8710, -8331, -8769, -9709, -10734, -11511, -11820, -11546, -10649, -9099, -6914, -4121, -804, 2841, 6617, 10314, 13652, 16350, 18123, 18853, 18703, 17971, 17010, 16127, 15485, 15120, 14986, 15035, 15270, 15688, 16262, 16954, 17700, 18394, 18905, 19109, 18957, 18473, 17729, 16853, 15964, 15100, 14249, 13366, 12385, 11245, 9881, 8251, 6377, 4317, 2189, 140, -1732, -3380, -4791, -5987, -6984, -7779, -8370, -8775, -9043, -9279, -9625, -10228, -11199, -12543, -14141, -15813, -17365, -18660, -19637, -20274, -20577, -20554, -20217, -19600, -18758, -17770, -16718, -15661, -14665, -13765, -12954, -12192, -11415, -10573, -9652, -8663, -7657, -6695, -5798, -4956, -4132, -3288, -2414, -1512, -586, 355, 1318, 2346, 3494, 4808, 6304, 7919, 9543, 11067, 12378, 13407, 14133, 14569, 14749, 14706, 14456, 14017, 13425, 12733, 12017, 11373, 10867, 10506, 10223, 9882, 9359, 8639, 7763, 6782, 5759, 4710, 3600, 2459, 1327, 184, -968, -2114, -3277, -4492, -5752, -7060, -8466, -9993, -11579, -13112, -14472, -15572, -16415, -17065, -17555, -17869, -17983, -17901, -17662, -17355, -17101, -16955, -16907, -16927, -16938, -16892, -16780, -16583, -16271, -15847, -15332, -14700, -13920, -13016, -12007, -10905, -9767, -8646, -7580, -6578, -5601, -4617, -3599, -2531, -1471, -511};