/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0032 256 samples */
 
const int16_t AKWF_hvoice_0032_256_DATA [256] = 
{682, 1660, 4032, 6380, 7797, 9716, 11278, 12082, 12342, 12264, 12453, 12321, 14655, 17175, 17685, 17974, 18392, 16569, 14989, 14169, 13879, 16599, 23031, 29543, 32289, 32717, 30137, 25151, 21820, 19359, 15180, 13457, 13645, 11973, 9787, 9300, 7306, 6475, 5064, 1869, -369, -296, -2005, -6297, -10542, -13356, -15196, -14709, -12037, -8557, -3498, -325, -661, -1020, -57, -79, -782, -1127, -680, 637, 2640, 3288, 3622, 4603, 4812, 4031, 4425, 5153, 3858, 973, -3201, -8112, -11580, -13643, -15457, -15675, -14968, -14749, -14557, -14028, -14456, -15721, -16766, -17678, -18006, -16823, -15370, -14431, -13296, -12154, -10896, -8246, -4566, -1574, 750, 2021, 1608, 380, -916, -2582, -4017, -4782, -5159, -5054, -4147, -3648, -4311, -5382, -6787, -8300, -9186, -9821, -10807, -11888, -13111, -14227, -14308, -13094, -11298, -8995, -6424, -4064, -2124, -607, 172, 179, 133, 370, 985, 2385, 4010, 5192, 5925, 6075, 5927, 5881, 5705, 5089, 4004, 2256, -2, -2268, -4304, -5954, -7345, -8055, -7787, -7059, -5959, -5152, -5123, -5221, -4875, -4028, -2547, -768, -27, 172, 811, 1714, 3307, 4815, 5411, 5792, 6152, 6722, 7292, 7084, 6135, 4510, 2782, 2173, 2350, 2682, 2971, 2360, 1249, 980, 815, 888, 1319, 895, 436, 383, 112, 232, 609, 420, 179, 584, 1250, 2244, 3604, 3869, 3450, 3147, 2360, 2015, 1486, 714, 265, -924, -2347, -2760, -3468, -3915, -3421, -3689, -3748, -2575, -2803, -3679, -4300, -6210, -7706, -8591, -9993, -10763, -10487, -10172, -9352, -7352, -5953, -5229, -4384, -3819, -2792, -1998, -2181, -1771, -779, 441, 2128, 2372, 2587, 2956, 2400, 1843, 1464, 522, 572, 810, 1046, 1201, 936, 418, 399, -250, -1517, -2324, -3512, -5284, -5363, -4790, -4461, -1775};