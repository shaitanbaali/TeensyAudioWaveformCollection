/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0006 256 samples */
 
const int16_t AKWF_hvoice_0006_256_DATA [256] = 
{923, 2178, 2710, 2654, 2315, 2248, 3028, 4884, 7548, 10350, 12605, 14055, 14921, 15680, 16796, 18528, 20878, 23670, 26586, 29229, 31246, 32429, 32768, 32401, 31520, 30309, 28951, 27665, 26645, 25911, 25336, 24800, 24320, 24004, 23856, 23663, 23142, 22195, 20960, 19622, 18243, 16800, 15295, 13775, 12265, 10680, 8894, 6922, 4932, 3152, 1802, 977, 604, 489, 384, 103, -412, -1130, -1991, -2859, -3529, -3865, -3970, -4161, -4689, -5457, -6036, -5974, -5073, -3431, -1371, 576, 1736, 1494, -340, -3304, -6414, -8637, -9332, -8366, -6049, -2938, 294, 3016, 4792, 5466, 5205, 4389, 3433, 2616, 1991, 1476, 1002, 584, 264, 17, -264, -693, -1351, -2309, -3646, -5371, -7270, -8909, -9843, -9892, -9337, -8803, -8890, -9863, -11603, -13793, -16192, -18734, -21348, -23834, -25924, -27377, -28066, -27945, -27002, -25338, -23256, -21167, -19372, -17969, -16991, -16532, -16726, -17550, -18672, -19518, -19506, -18264, -15782, -12487, -9068, -6141, -3910, -2090, -279, 1627, 3349, 4471, 4771, 4332, 3490, 2753, 2652, 3514, 5250, 7341, 9142, 10300, 10887, 11194, 11451, 11675, 11711, 11398, 10732, 9887, 9146, 8710, 8512, 8238, 7581, 6478, 5136, 3908, 3069, 2693, 2697, 2940, 3269, 3531, 3539, 3043, 1826, -121, -2537, -4951, -6895, -8120, -8653, -8755, -8821, -9230, -10107, -11199, -11995, -12047, -11254, -9956, -8737, -8111, -8270, -8959, -9596, -9645, -8989, -7961, -7047, -6495, -6163, -5700, -4874, -3682, -2241, -711, 722, 1907, 2736, 3151, 3211, 3043, 2747, 2393, 2009, 1599, 1271, 1243, 1580, 2046, 2305, 2190, 1849, 1644, 1659, 1501, 887, 116, -458, -881, -1182, -1151, -823, -738, -1524, -3387, -5901, -8146, -9275, -9074, -7948, -6571, -5618, -5500, -6184, -7245, -8068, -8096, -7097, -5265, -3028, -805};