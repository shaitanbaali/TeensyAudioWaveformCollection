/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0019 256 samples */
 
const int16_t AKWF_hvoice_0019_256_DATA [256] = 
{666, 1869, 2649, 3053, 3214, 3556, 4017, 3593, 2016, 841, 1232, 2376, 3152, 3414, 3374, 3330, 3712, 4024, 3332, 2122, 1951, 2960, 3726, 3868, 4454, 5550, 6026, 6057, 6772, 7411, 6695, 5943, 6864, 8031, 7765, 7633, 8814, 9422, 8609, 8351, 9289, 9597, 8999, 9116, 9709, 9365, 8926, 9594, 10001, 9141, 8698, 9378, 9390, 8556, 8781, 9817, 9818, 9413, 10092, 10571, 9336, 7893, 7799, 8333, 8455, 7538, 4832, 1472, 555, 2163, 3326, 4968, 9865, 11434, 258, -17766, -28416, -30551, -32244, -31732, -23595, -12538, -5639, -1877, -428, -4298, -10973, -13347, -10434, -6818, -3166, 2332, 7224, 7485, 3212, -3737, -12602, -20817, -24287, -22341, -18820, -15809, -11952, -7687, -5855, -6665, -8043, -9551, -10567, -8345, -2535, 3012, 6128, 8042, 8560, 5838, 389, -5243, -9731, -12537, -12341, -9357, -6091, -4121, -3011, -2749, -4117, -6695, -8569, -8221, -5537, -1284, 3245, 6414, 7302, 6692, 5642, 3496, -357, -3957, -5174, -4484, -3190, -1784, -1168, -1982, -2919, -3036, -3286, -3959, -3838, -2154, 765, 3907, 5878, 6013, 5228, 4536, 3648, 2092, 329, -502, 67, 1128, 1607, 1274, -4, -1980, -3038, -2552, -2215, -2474, -1420, 1306, 3412, 3487, 2735, 2724, 3294, 3335, 2538, 1850, 2059, 2559, 2252, 1106, 89, -277, -494, -1288, -2654, -3549, -3009, -1496, -108, 730, 1325, 2202, 3204, 3108, 1386, -415, -721, -26, 451, 575, 652, 529, 236, -37, -944, -2885, -4242, -3615, -2201, -1415, -1024, -481, 245, 755, 306, -950, -1720, -1339, -235, 785, 672, -556, -1092, -288, -75, -1317, -2397, -2595, -2360, -1487, -527, -871, -1849, -1575, -363, 155, -208, -732, -1019, -607, 342, 625, -58, -544, -223, 315, 512, 238, -293, -298};