/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0069 256 samples */
 
const int16_t AKWF_hvoice_0069_256_DATA [256] = 
{45, 31, 24, 136, 402, 748, 1058, 1289, 1501, 1749, 2031, 2292, 2504, 2719, 3023, 3438, 3861, 4165, 4289, 4327, 4459, 4801, 5332, 5899, 6355, 6601, 6603, 6373, 5977, 5568, 5324, 5411, 5884, 6625, 7410, 8038, 8453, 8684, 8813, 8956, 9182, 9554, 10133, 10969, 11983, 12990, 13818, 14371, 14698, 14943, 15222, 15569, 15967, 16413, 16956, 17611, 18274, 18736, 18805, 18440, 17800, 17146, 16679, 16449, 16392, 16417, 16440, 16358, 16080, 15550, 14800, 13907, 12979, 12070, 11156, 10252, 9517, 9030, 8583, 7639, 5566, 2004, -2941, -8565, -14106, -18980, -22918, -25893, -27944, -29136, -29709, -30045, -30540, -31345, -32242, -32757, -32467, -31245, -29250, -26766, -24063, -21343, -18842, -16791, -15384, -14543, -13942, -13176, -12024, -10593, -9188, -8056, -7254, -6745, -6505, -6561, -6884, -7268, -7357, -6890, -5905, -4712, -3675, -2970, -2539, -2261, -2121, -2169, -2383, -2555, -2422, -1902, -1193, -643, -508, -770, -1232, -1705, -2135, -2556, -2947, -3161, -3052, -2601, -1972, -1418, -1130, -1134, -1300, -1482, -1581, -1515, -1214, -654, 113, 924, 1536, 1809, 1775, 1607, 1528, 1677, 2042, 2502, 2944, 3329, 3627, 3787, 3766, 3588, 3350, 3180, 3142, 3173, 3139, 2949, 2617, 2244, 1939, 1751, 1638, 1550, 1450, 1329, 1202, 1075, 958, 865, 798, 716, 565, 308, -24, -341, -524, -476, -206, 188, 572, 817, 834, 605, 194, -263, -615, -760, -696, -477, -192, 51, 159, 56, -289, -814, -1371, -1803, -2007, -1992, -1852, -1693, -1588, -1567, -1634, -1759, -1891, -1984, -2013, -1985, -1911, -1808, -1704, -1623, -1576, -1552, -1542, -1525, -1484, -1424, -1362, -1297, -1236, -1187, -1155, -1141, -1160, -1204, -1242, -1264, -1266, -1253, -1240, -1227, -1172, -996, -663, -185};