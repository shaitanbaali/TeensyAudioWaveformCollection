/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0039 256 samples */
 
const int16_t AKWF_hvoice_0039_256_DATA [256] = 
{1696, 4646, 6923, 9202, 11800, 14741, 17436, 19718, 21543, 22848, 24250, 25311, 26262, 26957, 27480, 28008, 28438, 28850, 29362, 30084, 30082, 29357, 28738, 28475, 28233, 27684, 26876, 26027, 24803, 23842, 22502, 20916, 19123, 17380, 16045, 14392, 12523, 10932, 9329, 7121, 4423, 2226, 329, -1109, -2293, -3637, -5083, -6409, -7436, -8292, -9207, -9770, -10303, -10562, -10670, -10247, -9407, -9056, -9141, -9479, -9429, -8627, -7308, -6077, -5395, -4629, -3672, -2630, -1546, -483, 674, 2177, 3487, 4835, 6535, 8303, 9722, 11006, 12386, 13617, 14607, 15693, 16929, 17675, 18025, 18231, 18463, 18717, 18902, 18519, 17520, 16484, 15024, 13925, 12372, 10342, 8296, 5923, 3818, 1729, -326, -2129, -4018, -5803, -7673, -8901, -9916, -11140, -12715, -14543, -15903, -16823, -17630, -18750, -20145, -21106, -22352, -23466, -24480, -25281, -25933, -26971, -28131, -29705, -30891, -31485, -31693, -32175, -32658, -32715, -32265, -31045, -29357, -27535, -25702, -23835, -21608, -19641, -17423, -14975, -12305, -9622, -7585, -5042, -2115, 1337, 4497, 7350, 9899, 12009, 13861, 15665, 17396, 18854, 19940, 20903, 21459, 22178, 23166, 23906, 24125, 24043, 23633, 23210, 23172, 22822, 22756, 22929, 22747, 22073, 21010, 20294, 19902, 19411, 18715, 17966, 16985, 16142, 15141, 13416, 11918, 10248, 8061, 5794, 2867, 992, -417, -2011, -3811, -5801, -7306, -8876, -10607, -12399, -13903, -14290, -14027, -13955, -14171, -14381, -13675, -13357, -12857, -11600, -9742, -7257, -5599, -4619, -3990, -3785, -3033, -1922, -550, 889, 2511, 3869, 4483, 4944, 5428, 6568, 7906, 8481, 9001, 9193, 9628, 10709, 11821, 12723, 13016, 13211, 13388, 13639, 14413, 15626, 16831, 17711, 17699, 17529, 17904, 18942, 19706, 20015, 20329, 20149, 19687, 19101, 18770, 18445, 17557, 15745, 12927, 9900, 7459, 5667, 3552, 756};