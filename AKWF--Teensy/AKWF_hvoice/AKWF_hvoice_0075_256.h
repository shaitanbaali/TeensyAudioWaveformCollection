/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0075 256 samples */
 
const int16_t AKWF_hvoice_0075_256_DATA [256] = 
{9, 3, 9, 48, 75, 84, 142, 270, 485, 857, 1373, 2003, 2677, 3302, 3900, 4464, 5241, 6397, 7671, 8938, 10025, 10916, 11547, 12047, 12815, 13651, 14845, 16052, 16298, 15786, 14516, 13634, 13793, 14327, 14923, 15040, 14641, 13907, 12969, 11897, 10914, 10930, 11451, 11585, 11182, 9983, 8815, 8360, 8137, 7798, 7402, 7035, 6847, 6833, 6646, 6289, 6160, 6233, 6249, 6164, 5879, 5780, 6470, 7367, 7981, 8224, 8061, 8143, 8724, 9430, 10114, 10924, 11818, 12088, 11858, 11485, 11493, 13132, 15143, 15905, 15711, 14733, 14489, 16065, 15595, 11336, 6579, 2745, 3683, 8351, 9423, 6637, 1151, -4640, -7465, -8687, -9985, -11225, -11748, -12706, -15003, -18235, -22151, -24813, -25893, -26574, -27263, -27897, -28471, -29344, -30416, -31515, -32341, -32454, -32381, -32704, -32452, -30826, -28847, -27005, -26159, -26347, -26148, -25268, -23680, -21586, -18983, -16195, -13720, -11789, -10914, -10263, -9183, -7558, -5324, -2796, -36, 2319, 4082, 4659, 4295, 4268, 4867, 6747, 9116, 10704, 11409, 10961, 10108, 9277, 8944, 9435, 9820, 9682, 9092, 8203, 8020, 8404, 7399, 5155, 2678, 803, 1205, 2326, 2138, 910, -1101, -2989, -4338, -5736, -7493, -8060, -7068, -6038, -5576, -7432, -10687, -12485, -12768, -11636, -10138, -9160, -8876, -9591, -10544, -11423, -11387, -10088, -8704, -7618, -6568, -5456, -4797, -4558, -4649, -4534, -2857, -718, 252, 658, 1188, 2334, 4455, 5467, 4470, 3569, 3498, 4551, 6312, 7430, 7884, 8063, 7902, 6561, 4997, 4524, 4911, 6125, 6895, 6496, 5719, 4961, 3822, 2185, 1289, 1291, 2192, 3329, 2912, 1512, 91, -909, -1101, -937, -650, -482, -515, -843, -1501, -1851, -1773, -1625, -1523, -1480, -1442, -1288, -1111, -1116, -1146, -984, -779, -651, -558, -473, -314, -87};