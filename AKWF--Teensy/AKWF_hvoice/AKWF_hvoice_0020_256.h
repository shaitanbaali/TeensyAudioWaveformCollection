/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0020 256 samples */
 
const int16_t AKWF_hvoice_0020_256_DATA [256] = 
{806, 2357, 2159, 744, 707, 3107, 4138, 2615, 1246, 2023, 3998, 4917, 3840, 2421, 2976, 5117, 5925, 4290, 2886, 4100, 6108, 5720, 3664, 3549, 5613, 6464, 5262, 4293, 4376, 4845, 5806, 6487, 5786, 5053, 5678, 6394, 6698, 7489, 8091, 7784, 7622, 8355, 9262, 9877, 10662, 11658, 11594, 10405, 11409, 15305, 16669, 13205, 11070, 14674, 19264, 18541, 14327, 13359, 17286, 20167, 17798, 14756, 16528, 19150, 17043, 14163, 15692, 17868, 16293, 13238, 11113, 10145, 12054, 14757, 11483, 5416, 7782, 12469, 1605, -13928, -6775, 10086, 1228, -23322, -25063, -8889, -8090, -23187, -29301, -23646, -21885, -27273, -30877, -29106, -26173, -26888, -31123, -32723, -27032, -20399, -22514, -29087, -27365, -17760, -12865, -16590, -19698, -15914, -9074, -5570, -6995, -9141, -6512, -302, 2142, -923, -2016, 2371, 5830, 3586, 805, 3093, 6609, 5168, 1065, 607, 3514, 4067, 609, -2702, -2385, -496, -1561, -5065, -6053, -4528, -5289, -8106, -8293, -6568, -7266, -9392, -9246, -7731, -7295, -7486, -7282, -6705, -5859, -5250, -5170, -4373, -1883, 103, -821, -2277, -436, 3186, 4446, 3430, 2926, 3793, 5230, 6436, 6627, 6182, 6343, 6691, 5917, 4954, 5877, 7486, 6472, 3342, 2431, 4780, 5986, 3346, 383, 601, 1983, 1354, -304, -1145, -1491, -1155, -383, -1497, -3629, -2956, -828, -1609, -3704, -3440, -2052, -1894, -2378, -2368, -1767, -989, -952, -1500, -1247, -437, 47, 594, 941, 579, 571, 1230, 1546, 1821, 2161, 1175, -255, 530, 2799, 2881, 209, -1753, -714, 1738, 1969, -1146, -3669, -2110, 524, -482, -3231, -3137, -1700, -2672, -4042, -2859, -1438, -2548, -4568, -4521, -2691, -1569, -2023, -3041, -3729, -3207, -1263, -220, -1647, -2727, -1070, 294, -863, -1349, 476, 1400, 47, -587};