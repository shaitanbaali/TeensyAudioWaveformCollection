/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0045 256 samples */
 
const int16_t AKWF_hvoice_0045_256_DATA [256] = 
{1576, 5038, 5941, 6450, 8037, 11704, 12214, 9772, 6349, 7092, 9233, 8533, 5502, 4398, 7957, 10218, 9302, 7061, 8862, 10820, 10968, 11241, 15846, 23662, 25864, 22951, 24731, 31900, 29625, 18402, 12505, 11166, 8126, 1109, -7789, -13969, -12917, -13177, -19277, -25438, -26410, -23855, -24587, -29931, -32213, -27867, -24885, -25161, -23843, -20660, -15723, -11262, -10630, -10914, -8559, -6329, -7368, -9985, -11750, -10768, -10329, -12206, -12706, -11393, -11058, -11089, -10216, -9938, -9743, -9296, -8899, -7126, -4060, -1899, -781, 1147, 4483, 8176, 10141, 10569, 11584, 12796, 12867, 12282, 12007, 10869, 9674, 8486, 7250, 5663, 4450, 3411, 2276, 1657, 1298, 1301, 1490, 2302, 3396, 4054, 5330, 7064, 8767, 8458, 7525, 6827, 6371, 5631, 4452, 3682, 3205, 3784, 4150, 3776, 2821, 1888, 1128, -928, -3124, -5207, -6482, -7755, -7774, -7539, -6974, -5460, -3161, -1698, -767, 1021, 2843, 3636, 4093, 5134, 6170, 6861, 7899, 8490, 8693, 9427, 10800, 10876, 9749, 10573, 14950, 19145, 17328, 13625, 15900, 20652, 18095, 10303, 7143, 10010, 12874, 11396, 7097, 5152, 7562, 9262, 4951, -3417, -7724, -6932, -8770, -15529, -20418, -19895, -17785, -17744, -19990, -20575, -18323, -16432, -17151, -17966, -18169, -17653, -16144, -14258, -12936, -11196, -10470, -9562, -8322, -7137, -8376, -10787, -12256, -10602, -9978, -11948, -13266, -10592, -7963, -8069, -8855, -7623, -5050, -3568, -3634, -3308, -1433, 2270, 5351, 6291, 6199, 8752, 11679, 11721, 9343, 8181, 8110, 7798, 6669, 6406, 6385, 6867, 7422, 8650, 8524, 8413, 8927, 9529, 8244, 6347, 5854, 5474, 4881, 4919, 6593, 7888, 9283, 11063, 11300, 9340, 6789, 5140, 2387, -1822, -5421, -6777, -7190, -8060, -8719, -9023, -8237, -6791, -5857, -6617, -7004, -5528, -3483, -2966, -3425, -1816};