/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0081 256 samples */
 
const int16_t AKWF_hvoice_0081_256_DATA [256] = 
{529, 1355, 2171, 3038, 3977, 4959, 5957, 6955, 7935, 8897, 9842, 10761, 11648, 12511, 13325, 14036, 14584, 14968, 15189, 15234, 15136, 15053, 15210, 15694, 16335, 16904, 17268, 17446, 17591, 17835, 17988, 17504, 15959, 13370, 9863, 5473, 440, -4399, -8189, -10678, -12257, -13417, -14450, -15515, -16781, -18329, -20002, -21507, -22608, -23409, -24278, -25528, -27141, -28851, -30424, -31740, -32589, -32751, -32203, -31094, -29589, -27794, -25757, -23420, -20725, -17851, -15031, -12430, -10078, -8036, -6334, -4920, -3647, -2389, -1076, 358, 1998, 3852, 5860, 8022, 10295, 12541, 14564, 16255, 17607, 18618, 19299, 19663, 19639, 19173, 18303, 17094, 15563, 13790, 12015, 10492, 9283, 8319, 7477, 6678, 5825, 4744, 3342, 1679, -156, -2102, -4097, -6167, -8311, -10489, -12622, -14635, -16500, -18104, -19304, -20068, -20469, -20575, -20445, -20137, -19694, -19154, -18549, -17951, -17408, -16909, -16435, -15972, -15474, -14818, -13859, -12573, -11040, -9278, -7335, -5313, -3284, -1294, 600, 2406, 4099, 5649, 7025, 8191, 9163, 9970, 10621, 11150, 11623, 12103, 12621, 13127, 13567, 13921, 14147, 14185, 14013, 13669, 13221, 12713, 12150, 11482, 10680, 9736, 8615, 7268, 5726, 4108, 2509, 988, -356, -1442, -2230, -2810, -3318, -3828, -4385, -5062, -5908, -6847, -7730, -8437, -8946, -9235, -9289, -9139, -8864, -8537, -8191, -7769, -7173, -6369, -5418, -4386, -3321, -2259, -1239, -284, 622, 1548, 2543, 3604, 4674, 5707, 6693, 7599, 8412, 9125, 9754, 10321, 10846, 11332, 11799, 12251, 12674, 13059, 13402, 13663, 13728, 13508, 13020, 12336, 11522, 10625, 9735, 8931, 8238, 7581, 6847, 5983, 5026, 4028, 3028, 2079, 1275, 687, 263, -107, -539, -1049, -1602, -2177, -2751, -3257, -3636, -3866, -3953, -3901, -3724, -3443, -3076, -2644, -2155, -1596, -976, -251};