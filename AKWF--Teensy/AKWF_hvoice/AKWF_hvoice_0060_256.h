/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0060 256 samples */
 
const int16_t AKWF_hvoice_0060_256_DATA [256] = 
{6115, 17748, 26451, 28130, 21065, 6047, -11957, -26551, -32716, -28998, -18681, -6878, 1626, 4311, 2245, -750, -793, 3749, 11368, 18482, 21962, 19331, 10347, -1025, -10392, -15635, -15974, -12375, -7984, -5298, -4656, -5273, -5775, -4152, 474, 6396, 11632, 14520, 13601, 9250, 3396, -1855, -5116, -5839, -5200, -4739, -4837, -5977, -7270, -7366, -5699, -2054, 2379, 6076, 8073, 8073, 6727, 4336, 1787, 443, -164, -727, -1629, -2801, -3808, -5134, -5970, -5106, -3273, -1183, 1140, 3052, 4031, 3851, 3125, 2834, 2358, 1773, 1444, 860, -330, -2219, -3579, -4059, -4244, -3684, -2296, -882, -27, 626, 1387, 1984, 2282, 2584, 2935, 2524, 1485, 393, -759, -1706, -2303, -2392, -2078, -1867, -1920, -1757, -1041, -358, 583, 1833, 2420, 2360, 1886, 1192, 433, -321, -590, -410, -680, -1184, -1262, -1216, -1308, -1356, -1020, -87, 591, 559, 731, 1001, 812, 387, 164, 327, 255, -219, -421, -390, -741, -947, -733, -569, -142, 211, 179, 332, 193, -113, 77, 256, 297, 417, 536, 388, -180, -823, -978, -742, -613, -313, 351, 642, 371, -3, 102, 427, 130, 315, 834, 674, 289, -219, -307, -536, -990, -484, 184, 56, -290, -164, 131, 4, -245, 120, 513, 260, 240, 626, 571, 210, -103, -281, -282, -541, -454, 171, 332, 35, -127, 41, 245, 331, 350, 496, 384, -265, -536, -569, -520, -139, 162, 344, 344, -42, -153, -24, -67, 54, 216, 297, 383, 164, -293, -322, 112, 401, 694, 1019, 1061, 870, 122, -272, 84, 379, 808, 1099, 1201, 918, 69, -313, -28, 261, 385, 613, 568, -15, -463, -530, 448, 1588, 1529, 586, -1615, -4612, -6026, -2649};