/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0050 256 samples */
 
const int16_t AKWF_hvoice_0050_256_DATA [256] = 
{1356, 1441, 317, 69, 212, 2104, 3622, 1817, 1463, 2645, 2339, 3909, 4023, 1724, 3163, 3462, 3535, 5376, 4143, 4348, 6005, 6222, 6674, 6180, 5572, 7236, 9653, 10068, 8853, 7363, 8233, 10517, 10764, 11826, 12617, 12125, 13884, 14328, 13929, 14186, 13619, 14047, 14027, 14841, 16126, 17139, 16703, 15233, 16587, 17764, 18990, 19828, 18780, 18913, 18580, 17463, 16744, 18681, 22001, 21839, 14552, 7534, 12716, 21855, 24105, 25429, 28919, 20710, -7467, -31485, -24766, 1385, 20436, 23510, 15496, 8681, 5721, -1582, -8525, -12254, -10536, -1315, 4346, 2581, -748, -3195, -4938, -4691, -6752, -10058, -10030, -10281, -6860, -3059, -6330, -8677, -11576, -13117, -9239, -10671, -12845, -10322, -9156, -7050, -7565, -12721, -13005, -11722, -11807, -9179, -11035, -12921, -9790, -9860, -10027, -9660, -13378, -11844, -8962, -10945, -10295, -10588, -12383, -10105, -8747, -9236, -9842, -11859, -10528, -9412, -10221, -7912, -7328, -9300, -9679, -9724, -8837, -7251, -8343, -7907, -6447, -7858, -7352, -6719, -7316, -5802, -5506, -6523, -5761, -6910, -6853, -4335, -4843, -4708, -4909, -5339, -3844, -3724, -3833, -3771, -3690, -3761, -3831, -2732, -2460, -2696, -3191, -3447, -2151, -2063, -2707, -2362, -2032, -1133, -1051, -1999, -1501, -1479, -1653, -1139, -1599, -1174, -352, -11, 424, -918, -1548, -737, -1169, -1160, -993, -797, -57, 101, -186, -522, -1080, -1160, -1589, -1212, 456, 480, -897, -1744, -1549, -618, 120, -660, -877, -1048, -1125, -50, -922, -1926, -2176, -869, 641, -537, -1327, -2037, -2929, -1612, -186, 65, -296, -1518, -1741, -1069, -1376, -2561, -2622, -516, 1431, 622, -1522, -3005, -2334, 238, 1386, -66, -1990, -2079, -351, 1081, -603, -2330, -1380, 1567, 3122, 1037, -965, -1244, 179, 2311, 1560, 68};