/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0029 256 samples */
 
const int16_t AKWF_hvoice_0029_256_DATA [256] = 
{832, 3743, 7111, 9939, 14065, 18793, 20540, 19324, 16979, 16470, 17476, 18293, 19745, 22121, 24936, 27183, 28970, 30918, 32236, 32754, 31766, 30225, 28911, 26847, 23707, 20614, 18934, 18642, 19670, 20562, 20384, 18565, 15092, 11713, 8971, 6506, 4109, 1561, -386, -1618, -3013, -4480, -5856, -6946, -7846, -8687, -9232, -9961, -11827, -14556, -16557, -16826, -15781, -14629, -14138, -13800, -13421, -13274, -13432, -13456, -12846, -12056, -11144, -9861, -8342, -7103, -6723, -6258, -4727, -2423, -243, 1087, 1731, 2286, 2823, 3350, 4220, 5429, 6694, 7550, 8106, 8727, 8852, 8330, 7870, 8076, 8888, 9373, 9003, 8054, 6775, 5410, 4177, 3293, 2687, 2023, 1085, 52, -938, -2009, -3306, -4528, -5287, -5859, -6760, -8182, -9874, -11454, -12717, -13462, -13585, -13437, -13401, -13648, -14065, -14492, -14993, -15415, -15537, -15277, -14739, -14276, -13948, -13590, -13057, -12193, -10948, -9369, -7706, -6341, -5466, -4831, -4047, -3187, -2336, -1223, 291, 1854, 2981, 3723, 4452, 5225, 5969, 6786, 7634, 8239, 8407, 8310, 8198, 8040, 7946, 8301, 8961, 9244, 8931, 8416, 7723, 6681, 5605, 5132, 5200, 5080, 4431, 3391, 2361, 1482, 406, -775, -1557, -2109, -3131, -4675, -6071, -7167, -8167, -8661, -8158, -7541, -7545, -7765, -7932, -8491, -9510, -9935, -9358, -8695, -8446, -8080, -7252, -6520, -6171, -5437, -3926, -2405, -1303, -421, 349, 927, 1307, 2254, 3678, 4722, 5660, 6735, 7431, 7250, 6744, 6839, 7328, 7485, 7432, 7585, 7534, 6878, 6065, 5610, 5454, 4974, 4134, 2961, 1698, 357, -1319, -2882, -3850, -4666, -5600, -6758, -7586, -7976, -9199, -10812, -11199, -10994, -11268, -12097, -12716, -12597, -12997, -14150, -13901, -12658, -12459, -12226, -11211, -9898, -9659, -9836, -8774, -6993, -6253, -5461, -3607, -1743, -1134, -400};