/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0023 256 samples */
 
const int16_t AKWF_hvoice_0023_256_DATA [256] = 
{462, 1125, 1743, 2316, 2841, 3329, 3791, 4223, 4616, 4972, 5300, 5608, 5885, 6109, 6272, 6383, 6456, 6497, 6494, 6437, 6331, 6196, 6045, 5874, 5678, 5456, 5218, 4973, 4721, 4453, 4167, 3868, 3565, 3254, 2928, 2580, 2222, 1864, 1506, 1141, 766, 385, 18, -330, -663, -985, -1299, -1605, -1901, -2202, -2508, -2810, -3104, -3382, -3644, -3897, -4141, -4371, -4591, -4804, -5016, -5224, -5414, -5577, -5714, -5832, -5934, -6014, -6065, -6089, -6095, -6085, -6062, -6025, -5976, -5920, -5856, -5771, -5655, -5504, -5330, -5135, -4915, -4663, -4377, -4063, -3731, -3375, -2983, -2556, -2094, -1614, -1126, -570, -89, 101, 549, 1252, 1938, 2629, 3311, 3989, 4669, 5346, 6019, 6690, 7365, 8054, 8753, 9456, 10173, 10905, 11656, 12426, 13217, 14057, 14969, 15953, 16982, 18028, 19093, 20203, 21366, 22549, 23691, 24754, 25743, 26685, 27582, 28413, 29153, 29815, 30419, 30984, 31485, 31889, 32208, 32464, 32664, 32765, 32744, 32576, 32274, 31893, 31429, 30852, 30144, 29329, 28453, 27546, 26594, 25580, 24511, 23418, 22326, 21229, 20111, 18966, 17815, 16669, 15515, 14336, 13129, 11911, 10704, 9507, 8297, 7073, 5851, 4651, 3485, 2340, 1196, 69, -1045, -2149, -3242, -4347, -5454, -6555, -7663, -8791, -9945, -11102, -12234, -13338, -14431, -15521, -16590, -17613, -18575, -19490, -20377, -21232, -22033, -22765, -23441, -24078, -24682, -25231, -25717, -26149, -26541, -26895, -27191, -27409, -27554, -27646, -27695, -27685, -27592, -27416, -27181, -26913, -26616, -26277, -25895, -25482, -25054, -24623, -24175, -23705, -23220, -22726, -22214, -21673, -21092, -20482, -19860, -19227, -18572, -17892, -17188, -16483, -15790, -15107, -14424, -13743, -13062, -12373, -11669, -10933, -10175, -9412, -8647, -7872, -7082, -6277, -5479, -4698, -3921, -3145, -2368, -1608, -885, -184};