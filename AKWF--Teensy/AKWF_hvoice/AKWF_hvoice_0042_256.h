/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0042 256 samples */
 
const int16_t AKWF_hvoice_0042_256_DATA [256] = 
{2305, 6425, 10885, 15005, 17455, 16594, 17946, 21704, 24574, 23838, 23476, 24084, 24444, 26081, 28077, 27344, 25462, 24520, 23681, 20689, 17798, 14468, 10575, 6764, 4182, 1957, -968, -5493, -9409, -11308, -12831, -15973, -19598, -22048, -23811, -25556, -27752, -30215, -31863, -31862, -31727, -32332, -32766, -32061, -31001, -30324, -29949, -29458, -28085, -26273, -24429, -22810, -20693, -18651, -17029, -14839, -11954, -8903, -7175, -6028, -4589, -2087, 1108, 3016, 4051, 5268, 7642, 10191, 12167, 13366, 14139, 15397, 17165, 18826, 19390, 19370, 19012, 19084, 19434, 19866, 19343, 18238, 17971, 18171, 18608, 18498, 17736, 16283, 15109, 14520, 12939, 10400, 7723, 6026, 5416, 4643, 3551, 1823, 699, 560, -47, -1517, -3416, -4794, -5598, -6071, -7017, -8516, -9285, -9048, -8163, -8539, -8309, -9650, -10283, -9406, -7546, -6453, -7557, -5994, -2853, 1003, 3062, 1750, 1020, 2541, 6916, 7959, 5623, 5448, 7607, 10846, 11940, 13008, 13402, 14384, 16090, 17115, 17806, 18124, 16091, 13571, 13597, 15535, 14241, 11405, 8870, 7749, 8208, 9063, 6708, 3201, 2727, 2922, 485, -2811, -5217, -7460, -9524, -10927, -12915, -14703, -16481, -18082, -19449, -20484, -21856, -23521, -24186, -24629, -25159, -26062, -26550, -26499, -25757, -24559, -24155, -23684, -22462, -20734, -19439, -18415, -17192, -15821, -13825, -11329, -9306, -8015, -6610, -4234, -1856, -146, 952, 2462, 5027, 7173, 8171, 8799, 10550, 12590, 13653, 14253, 14973, 16246, 17604, 18248, 18383, 18827, 19521, 19609, 19390, 19183, 18637, 17380, 16054, 14960, 14458, 14122, 13213, 12190, 11967, 12343, 11363, 9110, 7369, 5948, 4349, 2097, -223, -1964, -3406, -4245, -5058, -5452, -6415, -7784, -8637, -8928, -9102, -10083, -11339, -11635, -10632, -9684, -10391, -11336, -11979, -10380, -9085, -8869, -9725, -9520, -7038, -4920, -3164, -1424};