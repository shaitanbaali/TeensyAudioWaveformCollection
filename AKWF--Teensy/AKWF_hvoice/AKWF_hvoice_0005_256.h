/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0005 256 samples */
 
const int16_t AKWF_hvoice_0005_256_DATA [256] = 
{454, 1067, 1269, 1667, 2632, 3932, 5300, 6698, 8344, 10475, 12888, 14996, 16343, 17008, 17587, 18660, 20295, 22289, 24525, 26708, 28077, 27832, 25957, 23404, 21243, 19806, 18948, 18708, 19276, 20576, 22172, 23729, 25416, 27552, 29990, 31992, 32774, 32124, 30465, 28246, 25411, 21757, 17615, 13949, 11802, 11569, 12845, 14710, 15998, 15770, 13963, 11464, 9352, 8166, 7902, 8473, 9658, 10659, 10355, 8289, 5134, 2035, -324, -1961, -3090, -3797, -4213, -4579, -5088, -5721, -6195, -6098, -5165, -3496, -1540, 159, 1146, 1037, -418, -3025, -6033, -8589, -10278, -11312, -12236, -13520, -15365, -17552, -19382, -20024, -19019, -16554, -13357, -10365, -8347, -7526, -7540, -7862, -8331, -9163, -10498, -12171, -13899, -15595, -17451, -19625, -21912, -23663, -24037, -22657, -20015, -17102, -14629, -12799, -11796, -11984, -13400, -15279, -16594, -17087, -17457, -18573, -20624, -22974, -24659, -24956, -23719, -21446, -18960, -16918, -15591, -14968, -14842, -14797, -14354, -13288, -11780, -10247, -9062, -8486, -8689, -9621, -10914, -11958, -12203, -11436, -9842, -7891, -6072, -4697, -3884, -3629, -3684, -3444, -2277, -131, 2313, 4226, 5339, 6017, 6699, 7479, 8162, 8568, 8739, 8829, 8769, 8150, 6620, 4569, 3144, 3254, 4743, 6738, 8684, 10596, 12384, 13417, 13147, 11888, 10532, 9629, 9005, 8205, 7099, 5864, 4628, 3381, 2177, 1285, 1063, 1599, 2508, 3140, 3063, 2334, 1393, 649, 196, -168, -773, -1787, -3040, -4234, -5268, -6289, -7426, -8550, -9401, -9854, -9879, -9411, -8526, -7668, -7378, -7751, -8292, -8435, -8158, -7943, -8226, -8961, -9610, -9611, -8964, -8264, -8074, -8331, -8485, -8355, -8562, -9747, -11684, -13421, -14214, -14112, -13541, -12562, -10923, -8706, -6537, -5161, -4750, -4662, -4242, -3662, -3656, -4640, -6026, -6562, -5716, -4170, -2751, -1755, -1094, -376};