/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0033 256 samples */
 
const int16_t AKWF_hvoice_0033_256_DATA [256] = 
{688, 2556, 4898, 7849, 10495, 11676, 11130, 9900, 9451, 10298, 12013, 13922, 15595, 16836, 17559, 17892, 18203, 18857, 19811, 20491, 20498, 20296, 20946, 23047, 25987, 28323, 29197, 29003, 28647, 28712, 29323, 30437, 31829, 32740, 32468, 31298, 30248, 29950, 30188, 30166, 29349, 28062, 26928, 26063, 25189, 24188, 23157, 22272, 21514, 20764, 20126, 19618, 18778, 17184, 15037, 13070, 11814, 11172, 10658, 9875, 8777, 7488, 6092, 4671, 3335, 2113, 928, -316, -1660, -2869, -3777, -4519, -5529, -7051, -8905, -10697, -12082, -13037, -13710, -14189, -14646, -15359, -16416, -17553, -18437, -19006, -19481, -19999, -20516, -20879, -21059, -21187, -21397, -21739, -22249, -22910, -23564, -23990, -23923, -23470, -23013, -22750, -22651, -22593, -22521, -22513, -22581, -22578, -22463, -22245, -21854, -21235, -20406, -19530, -18953, -18943, -19260, -19358, -18949, -18292, -17577, -16675, -15521, -14490, -13892, -13588, -13183, -12586, -12070, -11710, -11200, -10325, -9212, -8143, -7275, -6578, -6031, -5583, -5165, -4729, -4170, -3420, -2481, -1559, -897, -344, 400, 1319, 2159, 2763, 3241, 3782, 4373, 4877, 5340, 5979, 6769, 7480, 7949, 8200, 8351, 8363, 8151, 7830, 7617, 7543, 7608, 7831, 8146, 8412, 8558, 8634, 8684, 8687, 8694, 8923, 9436, 9951, 10221, 10280, 10255, 10069, 9635, 9162, 8778, 8322, 7695, 7117, 6698, 6167, 5361, 4472, 3659, 2853, 2071, 1399, 912, 450, -107, -605, -968, -1179, -1402, -1676, -1889, -2114, -2578, -3296, -3923, -4311, -4682, -5133, -5446, -5528, -5617, -5961, -6499, -7049, -7701, -8486, -9004, -9048, -9033, -9291, -9487, -9287, -9263, -10014, -10910, -11125, -10865, -10917, -11284, -11313, -10794, -10223, -10306, -11364, -12689, -13299, -13023, -12524, -12207, -11678, -10469, -9185, -9018, -9730, -9670, -8334, -6980, -6413, -5871, -4600, -2758, -944};