/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0057 256 samples */
 
const int16_t AKWF_hvoice_0057_256_DATA [256] = 
{7216, 18754, 28444, 32728, 28684, 16297, -1449, -19030, -30347, -31820, -25095, -14155, -3786, 1505, 490, -4588, -10558, -14067, -11360, -1054, 12877, 24008, 28732, 26617, 18366, 6619, -4810, -12323, -13456, -8687, -2402, 570, -1053, -5564, -11246, -16696, -19190, -15988, -7425, 3252, 12747, 17724, 17035, 12403, 6236, 215, -3201, -2005, 2464, 6358, 6653, 3005, -2824, -8994, -14152, -16216, -13448, -6528, 1258, 6640, 8426, 7170, 3749, -149, -2540, -2450, 737, 6548, 11133, 10765, 6645, 1255, -4657, -9403, -11412, -10494, -6167, -76, 3625, 3040, 172, -2528, -4317, -4928, -3815, -503, 4805, 9665, 10892, 8275, 3522, -1555, -4863, -5718, -5036, -3192, -453, 1785, 1936, -493, -4127, -6758, -6827, -4270, -771, 2336, 5251, 7410, 6551, 2479, -1460, -2788, -2297, -1253, 189, 1547, 2341, 1903, -595, -4119, -6551, -6780, -4860, -2077, 248, 2148, 3506, 3237, 1159, -1049, -1836, -1150, 359, 1993, 2856, 2846, 2134, 488, -1965, -4060, -4687, -3803, -2198, -718, 328, 1139, 1520, 918, -555, -1794, -1347, 703, 2221, 2410, 2324, 2439, 1736, -369, -2539, -3135, -2240, -1051, -53, 1004, 1734, 1336, -210, -1514, -1720, -1478, -826, 673, 2386, 3110, 2489, 1102, -324, -1438, -2156, -1900, -470, 752, 812, 539, 125, -853, -1546, -1233, -355, 900, 2238, 2731, 2090, 909, -336, -1259, -1150, -47, 842, 1128, 1310, 1049, 2, -1176, -2082, -2278, -895, 1237, 2236, 2040, 1650, 976, -537, -2107, -2445, -1549, -90, 1380, 2060, 1560, 800, 135, -918, -1663, -1150, 195, 1712, 2782, 2411, 1135, 357, -384, -1564, -2094, -1236, 430, 1796, 2240, 1923, 1469, 1248, 984, 539, 333, 669, 1272, 1252, 871, 1068, 1405, 860, -756, -3316, -6075, -6798, -2754};