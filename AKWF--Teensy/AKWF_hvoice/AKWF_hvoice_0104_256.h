/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0104 256 samples */
 
const int16_t AKWF_hvoice_0104_256_DATA [256] = 
{1005, 4344, 7646, 10836, 13842, 16661, 19302, 21770, 24097, 26288, 28295, 30038, 31397, 32296, 32728, 32715, 32300, 31543, 30518, 29275, 27787, 25961, 23724, 21081, 18142, 15034, 11837, 8618, 5414, 2238, -906, -4049, -7192, -10255, -13165, -15848, -18241, -20309, -22020, -23382, -24470, -25359, -26061, -26526, -26676, -26456, -25866, -24951, -23792, -22466, -21031, -19494, -17810, -15954, -13926, -11750, -9488, -7202, -4946, -2792, -774, 1121, 2922, 4668, 6362, 7951, 9363, 10536, 11434, 12075, 12514, 12820, 13047, 13208, 13273, 13194, 12926, 12451, 11777, 10945, 10020, 9069, 8149, 7274, 6411, 5523, 4584, 3586, 2554, 1536, 599, -184, -792, -1268, -1679, -2087, -2503, -2892, -3197, -3369, -3379, -3240, -2999, -2728, -2494, -2322, -2186, -2018, -1753, -1376, -929, -502, -187, -37, -59, -248, -576, -978, -1385, -1769, -2133, -2461, -2682, -2706, -2500, -2107, -1608, -1064, -499, 49, 505, 803, 944, 1000, 1047, 1107, 1148, 1139, 1072, 933, 700, 385, 50, -219, -393, -539, -757, -1081, -1468, -1838, -2145, -2390, -2571, -2674, -2687, -2627, -2539, -2457, -2385, -2289, -2123, -1839, -1410, -859, -262, 285, 722, 1063, 1391, 1771, 2216, 2703, 3198, 3685, 4145, 4523, 4757, 4830, 4778, 4666, 4556, 4478, 4415, 4306, 4078, 3694, 3182, 2624, 2102, 1652, 1275, 937, 596, 212, -233, -716, -1166, -1524, -1781, -1972, -2138, -2284, -2390, -2460, -2535, -2646, -2781, -2883, -2897, -2811, -2661, -2488, -2322, -2173, -2038, -1895, -1710, -1457, -1154, -875, -692, -633, -681, -794, -923, -1034, -1106, -1130, -1107, -1066, -1098, -1405, -2250, -3744, -5705, -7744, -9484, -10832, -11987, -13167, -14431, -15670, -16724, -17530, -18071, -18279, -18060, -17373, -16282, -14911, -13342, -11592, -9628, -7412, -4912, -2024};