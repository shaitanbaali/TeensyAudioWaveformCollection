/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0058 256 samples */
 
const int16_t AKWF_hvoice_0058_256_DATA [256] = 
{8435, 22061, 28550, 24997, 11316, -8664, -25927, -32673, -27727, -16208, -3931, 4200, 7197, 7042, 7825, 12273, 17293, 18291, 12244, 1415, -9543, -18252, -20050, -14599, -7280, -1783, 662, 1770, 3516, 5932, 10189, 14169, 12714, 5765, -2590, -9479, -12941, -11791, -7520, -3814, -2144, -941, 269, 2631, 6994, 10253, 10090, 6946, 1341, -4437, -7588, -7314, -5200, -3432, -3029, -2808, -1575, 433, 3350, 6720, 7870, 5912, 2511, -1005, -3858, -4894, -3802, -2185, -2203, -3155, -2655, -1023, 966, 3584, 5552, 5006, 2421, -11, -1707, -2436, -2133, -1527, -1530, -2312, -2504, -1900, -274, 2412, 3643, 3021, 2175, 494, -1345, -1356, -410, -70, -743, -1464, -1871, -2572, -2090, 791, 3028, 2707, 1721, 335, -930, -1014, -195, 775, 229, -1166, -1522, -1707, -1949, -753, 1356, 1809, 1181, 1180, 582, -774, -753, 97, -120, -859, -1330, -753, -340, -700, 610, 1626, 910, 34, -343, 42, -275, -548, 354, 446, -686, -1420, -754, 220, 650, 1295, 1103, 178, -637, -1148, -837, 121, 1066, 1016, -23, -779, -972, -1220, -272, 1236, 1105, 645, 319, -666, -880, -269, 694, 1155, 571, -206, -540, -699, -732, 186, 756, 212, 100, 263, -81, -192, 164, 758, 809, 198, -303, -919, -1449, -789, 664, 1402, 945, -206, -879, -473, -327, 263, 1473, 1032, -535, -964, -793, -811, 196, 1574, 945, -674, -714, -444, -531, 502, 1642, 1106, -466, -1342, -1531, -975, 365, 1095, 1228, 435, -557, -282, 121, 674, 1253, 745, -492, -1180, -335, 783, 699, 708, 578, -479, -824, 89, 1863, 2360, 1053, 299, -161, -1116, -821, 311, 354, -673, -1551, -593, 1139, 2598, 3972, 2441, -2550, -8147, -9787, -3725};