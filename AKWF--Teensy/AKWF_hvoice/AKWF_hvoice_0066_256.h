/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0066 256 samples */
 
const int16_t AKWF_hvoice_0066_256_DATA [256] = 
{130, 636, 1284, 1785, 1946, 1821, 1696, 1786, 2182, 2759, 3265, 3527, 3606, 3627, 3725, 3934, 4150, 4213, 4079, 3867, 3746, 3817, 4033, 4255, 4370, 4348, 4305, 4367, 4541, 4745, 4905, 4984, 5027, 5151, 5371, 5590, 5685, 5632, 5538, 5676, 6275, 7422, 8946, 10505, 11718, 12414, 12645, 12681, 12834, 13272, 13867, 14453, 14837, 14911, 14678, 14218, 13525, 12619, 11570, 10475, 9468, 8693, 8188, 7831, 7482, 6966, 6216, 5342, 4603, 4212, 4242, 4485, 4587, 4246, 3405, 2357, 1709, 1793, 2285, 2162, 143, -4701, -12041, -20273, -27307, -31529, -32573, -31376, -29699, -29085, -30015, -31742, -32793, -31872, -28560, -23333, -17366, -11887, -7584, -4475, -2166, -68, 2092, 4262, 6229, 7764, 8657, 8754, 7911, 6061, 3327, 176, -2785, -5032, -6422, -7239, -8036, -9272, -10942, -12589, -13604, -13496, -12250, -10250, -8094, -6201, -4743, -3488, -2071, -259, 1876, 4016, 5618, 6359, 6219, 5491, 4627, 4056, 3818, 3635, 3100, 1918, 117, -1806, -3265, -3866, -3608, -2922, -2392, -2383, -2788, -3198, -3103, -2338, -1185, -118, 566, 888, 1245, 2028, 3257, 4492, 5209, 5071, 4163, 3066, 2392, 2412, 2896, 3409, 3476, 2932, 1964, 933, 115, -364, -587, -680, -686, -603, -473, -396, -562, -1052, -1675, -2034, -1741, -662, 965, 2523, 3379, 3213, 2190, 912, 113, 150, 956, 2052, 2848, 2887, 2219, 1144, 92, -623, -1003, -1296, -1663, -2147, -2653, -2955, -2954, -2794, -2660, -2625, -2699, -2718, -2536, -2152, -1711, -1332, -1069, -834, -489, -13, 420, 620, 482, 76, -350, -536, -385, -26, 315, 471, 370, 51, -381, -765, -1034, -1165, -1148, -1044, -961, -947, -1000, -1122, -1244, -1292, -1228, -1089, -920, -726, -540, -385, -259, -111};