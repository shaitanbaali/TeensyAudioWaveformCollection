/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0071 256 samples */
 
const int16_t AKWF_hvoice_0071_256_DATA [256] = 
{372, 1103, 1569, 1691, 1695, 1792, 2063, 2478, 3088, 3729, 4148, 4182, 3855, 3387, 3064, 2925, 2877, 2922, 3031, 3033, 2750, 2281, 1938, 1937, 2272, 2802, 3434, 3938, 4243, 4540, 4948, 5497, 6155, 6885, 7452, 7874, 8132, 8181, 8023, 7872, 7627, 7302, 7100, 7072, 7027, 6740, 6192, 5498, 4893, 4429, 4074, 3869, 3899, 4041, 4294, 4518, 4632, 4627, 4563, 4341, 4324, 4733, 5143, 4733, 3347, 1560, -220, -1311, -715, 1534, 3117, 856, -5846, -15461, -24934, -31316, -32787, -29817, -24289, -18502, -14794, -14108, -15353, -15818, -13090, -6556, 2264, 10448, 15574, 16494, 13585, 8710, 3936, 1139, 751, 1496, 1206, -1448, -6499, -12726, -18250, -21362, -21234, -18216, -13548, -8818, -5342, -3548, -2843, -1852, 484, 4283, 8823, 12751, 14739, 14074, 11206, 7121, 3250, 608, -603, -1037, -1697, -3497, -6369, -9669, -12340, -13469, -12492, -9897, -6545, -3367, -1049, 295, 1248, 2318, 3926, 6185, 8723, 10759, 11495, 10520, 8051, 4792, 1673, -552, -1659, -2171, -2709, -3577, -4914, -6432, -7440, -7308, -6086, -3874, -1246, 1095, 2552, 3239, 3470, 3807, 4589, 5704, 6662, 7041, 6562, 5179, 3134, 1007, -653, -1682, -2247, -2418, -2607, -3069, -3711, -4126, -4068, -3336, -2066, -742, 396, 1391, 2185, 2607, 2756, 2777, 2955, 3285, 3388, 2889, 1996, 1016, 220, -444, -1188, -2107, -2890, -3432, -3821, -4070, -4054, -3720, -2949, -1829, -871, -320, -67, 126, 342, 774, 1289, 1874, 2409, 2637, 2260, 1525, 536, -500, -1304, -1716, -1937, -2057, -2099, -2376, -2832, -3133, -3046, -2780, -2168, -1334, -470, 329, 1043, 1362, 1206, 956, 973, 1326, 1772, 2086, 2139, 1748, 1030, 233, -424, -886, -990, -756, -493, -304, -174, -96, -123, -52};