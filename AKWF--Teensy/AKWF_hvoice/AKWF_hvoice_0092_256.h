/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0092 256 samples */
 
const int16_t AKWF_hvoice_0092_256_DATA [256] = 
{108, 371, 687, 1081, 1616, 2341, 3129, 3765, 4142, 4282, 4375, 4501, 4662, 4756, 4739, 4591, 4326, 3946, 3420, 3013, 2829, 3013, 3290, 3562, 3670, 3783, 3946, 4233, 4588, 4996, 5485, 5942, 6319, 6456, 6437, 6314, 6396, 6684, 7166, 7610, 7949, 8195, 8530, 9083, 9864, 10773, 11694, 12565, 13303, 13874, 14255, 14381, 14352, 14205, 14069, 13784, 13329, 12571, 11799, 11094, 10665, 10347, 10112, 9887, 9689, 9496, 9244, 9022, 8857, 8904, 8722, 8217, 7097, 5857, 4631, 3624, 3105, 2840, 2506, 656, -2525, -7005, -11136, -14775, -17741, -20528, -23169, -25760, -28433, -30829, -32471, -32357, -30838, -28142, -25532, -23087, -21024, -18913, -16603, -13793, -10639, -7538, -4986, -3484, -2775, -2692, -2436, -1855, -601, 755, 1843, 2154, 1931, 1587, 1559, 1898, 2353, 2698, 2531, 1745, 122, -1975, -4082, -5743, -6931, -7985, -9162, -10554, -11864, -12872, -13167, -12775, -11624, -10092, -8501, -7124, -6026, -4979, -3832, -2285, -620, 1049, 2146, 2745, 2830, 2940, 3213, 3795, 4518, 5190, 5696, 5829, 5737, 5476, 5502, 5724, 6128, 6211, 5853, 4956, 3677, 2291, 909, -263, -1253, -2070, -2890, -3664, -4382, -4791, -4797, -4363, -3593, -2732, -1869, -1104, -435, 142, 641, 1162, 1714, 2246, 2537, 2556, 2326, 2157, 2126, 2320, 2544, 2750, 2853, 2928, 2987, 3047, 3111, 3161, 3117, 2946, 2626, 2136, 1474, 676, -162, -914, -1581, -2255, -2995, -3753, -4369, -4753, -4899, -4804, -4589, -4289, -3960, -3566, -3115, -2589, -2094, -1646, -1268, -966, -753, -688, -613, -492, -208, 32, 232, 352, 514, 710, 926, 1109, 1236, 1279, 1171, 950, 638, 389, 185, 7, -265, -582, -889, -1180, -1441, -1668, -1735, -1709, -1648, -1576, -1430, -1123, -703, -236};