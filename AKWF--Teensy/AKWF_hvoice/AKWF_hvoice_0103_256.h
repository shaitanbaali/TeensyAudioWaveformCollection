/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0103 256 samples */
 
const int16_t AKWF_hvoice_0103_256_DATA [256] = 
{5721, 15152, 20421, 21236, 17582, 10286, 844, -8435, -15327, -18871, -18833, -15801, -10738, -5105, -278, 2578, 3052, 1455, -1376, -4207, -6018, -6142, -4309, -778, 3476, 7115, 9110, 8794, 6147, 1689, -3577, -8371, -11491, -12251, -10562, -6850, -1998, 2788, 6445, 8317, 8166, 6166, 2928, -686, -3665, -5304, -5483, -4396, -2454, -229, 1605, 2643, 2682, 1763, 196, -1498, -2780, -3233, -2679, -1192, 863, 2932, 4447, 5066, 4546, 3072, 1059, -1025, -2716, -3601, -3576, -2679, -1105, 731, 2233, 3062, 3226, 2829, 2056, 1094, 164, -508, -729, -455, 159, 809, 1224, 1290, 1021, 371, -550, -1441, -1959, -1873, -1135, 29, 1244, 2283, 2941, 3045, 2503, 1421, 32, -1279, -2260, -2748, -2628, -1857, -679, 614, 1649, 2183, 2138, 1566, 578, -524, -1453, -1965, -1961, -1510, -836, -108, 441, 647, 408, -257, -1182, -1985, -2333, -2046, -1178, 45, 1307, 2297, 2701, 2351, 1256, -318, -1994, -3372, -4197, -4310, -3672, -2337, -545, 1258, 2573, 3146, 2969, 2189, 1050, -172, -1205, -1834, -1938, -1597, -981, -280, 340, 692, 738, 491, 73, -329, -532, -493, -231, 239, 852, 1451, 1878, 2093, 2135, 2030, 1752, 1288, 724, 195, -221, -459, -494, -291, 230, 1112, 2158, 3131, 3920, 4421, 4532, 4132, 3190, 1886, 624, -257, -602, -416, 242, 1163, 2181, 3126, 3836, 4252, 4439, 4466, 4383, 4249, 4128, 4107, 4243, 4475, 4590, 4428, 4049, 3660, 3417, 3358, 3556, 4099, 4938, 5870, 6603, 6845, 6491, 5642, 4411, 2953, 1530, 532, 302, 869, 1964, 3219, 4301, 4999, 5211, 4920, 4023, 2488, 587, -1253, -2648, -3258, -2431, -144, 2266, 2960, 569, -5110, -13166, -21697, -28687, -32445, -31851, -26316, -16260, -3552};