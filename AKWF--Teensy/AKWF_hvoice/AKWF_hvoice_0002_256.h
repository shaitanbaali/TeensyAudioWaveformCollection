/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0002 256 samples */
 
const int16_t AKWF_hvoice_0002_256_DATA [256] = 
{1488, 4552, 7866, 11195, 14429, 17703, 20620, 23219, 25798, 27892, 29270, 30566, 31644, 32440, 32782, 32255, 31216, 30567, 30210, 29877, 29301, 28300, 27080, 25764, 24013, 21613, 18953, 16001, 13012, 10362, 7918, 4897, 1535, -1652, -4786, -7986, -11222, -14424, -17366, -19650, -21294, -22879, -24704, -26139, -26793, -26948, -27173, -27423, -27395, -27191, -27021, -26624, -26079, -25596, -24821, -23586, -22010, -20306, -18530, -16594, -14299, -11704, -9188, -6907, -4550, -2079, 246, 2262, 4065, 5800, 7517, 9166, 10656, 12079, 13362, 14560, 15793, 17131, 18466, 19709, 20891, 21999, 22942, 23566, 23810, 23752, 23554, 23177, 22489, 21547, 20560, 19504, 18280, 16864, 15400, 13960, 12449, 10817, 9102, 7350, 5484, 3488, 1495, -439, -2373, -4350, -6414, -8521, -10662, -12895, -15119, -17122, -18862, -20378, -21565, -22382, -22893, -23135, -23139, -22919, -22469, -21818, -21034, -20180, -19254, -18170, -16945, -15648, -14255, -12706, -10961, -9099, -7169, -5132, -3059, -1026, 969, 2926, 4859, 6772, 8637, 10456, 12110, 13511, 14664, 15545, 16148, 16444, 16494, 16332, 16047, 15811, 15647, 15479, 15201, 14779, 14254, 13641, 12913, 12033, 10998, 9815, 8562, 7239, 5797, 4245, 2659, 1120, -412, -1959, -3451, -4789, -5929, -6935, -7970, -9087, -10187, -11129, -11882, -12540, -13211, -13898, -14493, -14952, -15359, -15815, -16258, -16612, -16826, -16815, -16606, -16202, -15598, -14819, -13846, -12738, -11591, -10400, -9113, -7738, -6352, -5028, -3749, -2455, -1138, 121, 1247, 2250, 3237, 4216, 5125, 5957, 6716, 7371, 7924, 8339, 8630, 8702, 8479, 8061, 7484, 6738, 5769, 4492, 3051, 1733, 493, -763, -2021, -3240, -4391, -5527, -6720, -7827, -8678, -9328, -9989, -10750, -11505, -12182, -12839, -13581, -14339, -14944, -15360, -15571, -15493, -15125, -14593, -13751, -12446, -10779, -8872, -6709, -4122, -1170};