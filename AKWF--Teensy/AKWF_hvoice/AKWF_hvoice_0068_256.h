/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0068 256 samples */
 
const int16_t AKWF_hvoice_0068_256_DATA [256] = 
{262, 784, 1154, 1250, 1074, 744, 452, 397, 685, 1255, 1937, 2490, 2723, 2580, 2168, 1686, 1360, 1321, 1522, 1832, 2107, 2255, 2271, 2240, 2229, 2268, 2348, 2413, 2424, 2410, 2429, 2540, 2784, 3161, 3648, 4217, 4812, 5342, 5745, 5953, 5922, 5673, 5313, 4971, 4787, 4864, 5194, 5702, 6260, 6720, 6945, 6880, 6538, 5993, 5356, 4725, 4180, 3780, 3556, 3535, 3736, 4119, 4581, 4968, 5108, 4890, 4364, 3674, 2963, 2302, 1667, 954, 91, -760, -1176, -846, 34, 611, -431, -4279, -11053, -19450, -27190, -32002, -32475, -28275, -20425, -10933, -2276, 3477, 5716, 5120, 3019, 689, -980, -1626, -1290, -221, 1222, 2626, 3465, 3186, 1410, -1867, -6054, -10260, -13433, -14821, -14111, -11537, -7751, -3628, -66, 2340, 3395, 3312, 2498, 1444, 606, 304, 649, 1521, 2612, 3511, 3823, 3284, 1883, -176, -2470, -4477, -5792, -6191, -5673, -4428, -2786, -1133, 217, 1039, 1275, 1031, 525, 45, -144, 131, 875, 1892, 2855, 3415, 3318, 2516, 1182, -349, -1666, -2455, -2594, -2096, -1150, -43, 937, 1579, 1784, 1597, 1181, 722, 401, 299, 423, 717, 1107, 1476, 1728, 1775, 1548, 1056, 390, -297, -845, -1104, -1012, -615, -47, 514, 898, 1027, 898, 578, 190, -143, -341, -370, -230, 37, 366, 667, 848, 844, 616, 190, -321, -778, -1051, -1077, -873, -544, -208, 30, 100, -8, -275, -664, -1107, -1494, -1736, -1756, -1548, -1168, -731, -358, -139, -88, -191, -378, -546, -617, -594, -496, -365, -291, -313, -412, -554, -713, -815, -837, -802, -732, -644, -561, -480, -384, -296, -230, -201, -191, -140, 22, 317, 709, 1088, 1306, 1256, 937, 455, -6, -251, -176};