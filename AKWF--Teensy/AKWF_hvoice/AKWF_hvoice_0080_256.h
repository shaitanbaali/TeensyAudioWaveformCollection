/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0080 256 samples */
 
const int16_t AKWF_hvoice_0080_256_DATA [256] = 
{409, 1001, 1482, 1985, 2548, 3276, 4210, 5236, 6193, 6990, 7633, 8156, 8588, 8975, 9409, 9962, 10635, 11381, 12156, 12935, 13667, 14302, 14832, 15280, 15693, 16089, 16480, 16892, 17334, 17763, 18075, 18198, 18136, 17927, 17583, 17160, 16820, 16744, 16958, 17296, 17553, 17637, 17613, 17648, 17844, 17976, 17566, 16313, 14287, 11544, 8115, 4285, 704, -2002, -3741, -4939, -6029, -7232, -8604, -10170, -11941, -13765, -15348, -16533, -17484, -18594, -20194, -22233, -24464, -26706, -28851, -30654, -31903, -32575, -32769, -32582, -32102, -31421, -30617, -29734, -28854, -28063, -27429, -26919, -26423, -25872, -25241, -24511, -23701, -22804, -21747, -20463, -18930, -17145, -15088, -12761, -10304, -7930, -5703, -3664, -1819, -143, 1373, 2733, 3956, 5044, 5996, 6798, 7472, 8135, 8927, 9899, 10985, 12122, 13268, 14342, 15216, 15821, 16168, 16295, 16234, 16009, 15589, 14948, 14104, 13108, 11994, 10804, 9608, 8505, 7514, 6603, 5693, 4731, 3736, 2752, 1798, 868, -91, -1135, -2277, -3574, -5111, -6859, -8620, -10195, -11500, -12556, -13387, -14020, -14505, -14900, -15247, -15551, -15798, -15976, -16095, -16175, -16243, -16295, -16296, -16205, -16017, -15744, -15409, -15029, -14577, -14008, -13299, -12438, -11391, -10127, -8713, -7235, -5767, -4349, -3036, -1851, -794, 146, 975, 1711, 2408, 3129, 3920, 4799, 5840, 7073, 8421, 9755, 10996, 12098, 12989, 13613, 13997, 14265, 14538, 14863, 15183, 15411, 15519, 15504, 15358, 15091, 14756, 14452, 14242, 14105, 13972, 13790, 13532, 13192, 12755, 12226, 11603, 10871, 10042, 9132, 8151, 7113, 6089, 5180, 4442, 3858, 3395, 3029, 2708, 2305, 1716, 943, 89, -751, -1530, -2198, -2670, -2939, -3103, -3315, -3665, -4103, -4520, -4854, -5058, -5051, -4757, -4228, -3637, -3136, -2773, -2509, -2312, -2150, -1948, -1606, -1093, -441};