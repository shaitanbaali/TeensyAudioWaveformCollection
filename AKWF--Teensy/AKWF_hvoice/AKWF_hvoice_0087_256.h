/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0087 256 samples */
 
const int16_t AKWF_hvoice_0087_256_DATA [256] = 
{250, 939, 1496, 2054, 2615, 3173, 3723, 4272, 4819, 5364, 5905, 6446, 6981, 7517, 8055, 8590, 9120, 9642, 10160, 10673, 11178, 11677, 12167, 12647, 13121, 13588, 14049, 14501, 14946, 15384, 15821, 16252, 16683, 17110, 17540, 17982, 18435, 18906, 19392, 19897, 20432, 20999, 21597, 22229, 22878, 23549, 24242, 24951, 25665, 26373, 27071, 27762, 28437, 29082, 29694, 30266, 30802, 31291, 31726, 32091, 32381, 32596, 32731, 32769, 32706, 32526, 32237, 31838, 31321, 30678, 29909, 29030, 28044, 26939, 25728, 24412, 22998, 21515, 19942, 18282, 16553, 14762, 12927, 11062, 9137, 7187, 5226, 3273, 1320, -615, -2533, -4412, -6225, -7980, -9680, -11306, -12852, -14310, -15668, -16948, -18135, -19228, -20223, -21117, -21917, -22630, -23244, -23761, -24184, -24517, -24769, -24938, -25022, -25030, -24973, -24855, -24683, -24462, -24194, -23890, -23561, -23205, -22826, -22432, -22024, -21607, -21186, -20757, -20324, -19889, -19455, -19023, -18591, -18159, -17731, -17310, -16894, -16479, -16069, -15658, -15247, -14836, -14420, -13995, -13559, -13106, -12635, -12152, -11649, -11130, -10594, -10039, -9477, -8901, -8314, -7717, -7113, -6504, -5895, -5277, -4653, -4030, -3410, -2798, -2191, -1592, -1002, -439, 97, 603, 1078, 1519, 1915, 2264, 2567, 2824, 3033, 3191, 3300, 3363, 3380, 3348, 3266, 3136, 2959, 2739, 2474, 2162, 1805, 1408, 979, 517, 26, -487, -1022, -1569, -2121, -2682, -3242, -3801, -4353, -4894, -5429, -5951, -6460, -6951, -7423, -7876, -8312, -8725, -9107, -9461, -9785, -10081, -10346, -10578, -10778, -10946, -11085, -11198, -11282, -11341, -11374, -11383, -11366, -11324, -11261, -11173, -11062, -10928, -10768, -10583, -10377, -10147, -9892, -9614, -9316, -8998, -8659, -8303, -7931, -7541, -7135, -6713, -6275, -5816, -5342, -4849, -4340, -3815, -3273, -2716, -2147, -1571, -984, -393};