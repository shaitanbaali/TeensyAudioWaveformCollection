/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0004 256 samples */
 
const int16_t AKWF_hvoice_0004_256_DATA [256] = 
{768, 1502, 1561, 1424, 1489, 1834, 2213, 2485, 2837, 3446, 4358, 5639, 7247, 8913, 10374, 11647, 13051, 14797, 16581, 17999, 19257, 21011, 23539, 26343, 28649, 30247, 31510, 32535, 32722, 31421, 28816, 25924, 23760, 22631, 22345, 22909, 24491, 26711, 28402, 28482, 27072, 25452, 24739, 24772, 24523, 23299, 21250, 18919, 16606, 14321, 12158, 10354, 9109, 8530, 8601, 9110, 9640, 9790, 9410, 8586, 7449, 6184, 5207, 4967, 5419, 5862, 5421, 3699, 1019, -1848, -4089, -5211, -5325, -5040, -4917, -4998, -5023, -5002, -5306, -6108, -7015, -7433, -7153, -6338, -5113, -3566, -2105, -1504, -2278, -4029, -5639, -6199, -5774, -5245, -5499, -6744, -8520, -10268, -11713, -12617, -12470, -10786, -7826, -4806, -3088, -3224, -4809, -7113, -9612, -12021, -14154, -15896, -17301, -18540, -19730, -20877, -21814, -22178, -21646, -20239, -18334, -16351, -14555, -13229, -12764, -13350, -14660, -16134, -17521, -18878, -20121, -20917, -21155, -21186, -21307, -21220, -20349, -18552, -16172, -13502, -10632, -7858, -5856, -5185, -5692, -6705, -7649, -8277, -8412, -7817, -6383, -4360, -2290, -674, 313, 891, 1535, 2573, 3858, 4933, 5465, 5455, 5113, 4658, 4286, 4178, 4424, 4995, 5863, 6967, 8022, 8574, 8398, 7760, 7116, 6650, 6289, 6061, 6098, 6208, 5844, 4713, 3198, 2012, 1526, 1551, 1710, 1757, 1601, 1341, 1258, 1570, 2114, 2410, 2043, 939, -713, -2634, -4439, -5768, -6606, -7249, -7828, -8069, -7636, -6619, -5424, -4343, -3526, -3325, -4118, -5633, -6911, -7200, -6709, -6202, -5976, -5641, -4894, -4053, -3617, -3675, -3955, -4265, -4675, -5202, -5556, -5443, -4992, -4716, -4997, -5551, -5538, -4454, -2803, -1647, -1594, -2345, -3195, -3773, -4109, -4193, -4023, -3951, -4368, -5131, -5605, -5327, -4557, -3945, -3650, -3381, -3069, -2694, -1855, -434};