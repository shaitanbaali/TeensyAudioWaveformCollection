/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0085 256 samples */
 
const int16_t AKWF_hvoice_0085_256_DATA [256] = 
{440, 1005, 1554, 2131, 2713, 3306, 3910, 4519, 5140, 5768, 6401, 7040, 7680, 8326, 8977, 9628, 10280, 10936, 11589, 12246, 12907, 13571, 14236, 14909, 15588, 16282, 16997, 17726, 18468, 19232, 20014, 20819, 21644, 22471, 23303, 24135, 24963, 25782, 26580, 27344, 28085, 28790, 29454, 30073, 30635, 31143, 31600, 31991, 32307, 32542, 32695, 32765, 32743, 32621, 32389, 32053, 31617, 31078, 30426, 29668, 28807, 27858, 26816, 25682, 24460, 23165, 21805, 20383, 18896, 17353, 15763, 14140, 12492, 10803, 9095, 7370, 5655, 3947, 2237, 547, -1108, -2729, -4294, -5823, -7303, -8725, -10084, -11379, -12613, -13790, -14904, -15948, -16928, -17844, -18701, -19492, -20217, -20879, -21479, -22022, -22505, -22930, -23300, -23621, -23894, -24122, -24307, -24456, -24570, -24652, -24704, -24728, -24727, -24700, -24647, -24570, -24469, -24343, -24194, -24018, -23815, -23589, -23339, -23063, -22761, -22439, -22090, -21715, -21313, -20884, -20430, -19948, -19438, -18895, -18317, -17712, -17082, -16418, -15723, -14997, -14245, -13475, -12686, -11871, -11042, -10199, -9348, -8500, -7640, -6780, -5925, -5075, -4238, -3414, -2596, -1800, -1027, -276, 443, 1137, 1800, 2421, 3005, 3551, 4052, 4511, 4925, 5293, 5618, 5898, 6132, 6324, 6473, 6581, 6650, 6676, 6661, 6608, 6518, 6395, 6233, 6037, 5812, 5557, 5277, 4972, 4640, 4290, 3923, 3539, 3142, 2730, 2308, 1877, 1440, 994, 547, 94, -361, -824, -1291, -1755, -2220, -2680, -3138, -3588, -4033, -4464, -4888, -5302, -5704, -6092, -6465, -6821, -7162, -7486, -7790, -8074, -8336, -8576, -8793, -8986, -9151, -9290, -9402, -9487, -9539, -9561, -9553, -9514, -9446, -9347, -9217, -9059, -8875, -8662, -8425, -8163, -7876, -7571, -7240, -6884, -6508, -6114, -5702, -5272, -4824, -4359, -3883, -3395, -2897, -2387, -1869, -1337, -817, -218};