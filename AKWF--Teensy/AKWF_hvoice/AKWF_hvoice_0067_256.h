/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0067 256 samples */
 
const int16_t AKWF_hvoice_0067_256_DATA [256] = 
{135, 446, 650, 757, 784, 784, 817, 965, 1275, 1741, 2303, 2885, 3381, 3740, 3887, 3749, 3320, 2674, 1948, 1298, 844, 602, 543, 617, 804, 1114, 1553, 2080, 2663, 3233, 3737, 4140, 4429, 4579, 4614, 4544, 4386, 4188, 4016, 3944, 4079, 4472, 5081, 5837, 6633, 7371, 7976, 8413, 8648, 8684, 8569, 8381, 8217, 8159, 8255, 8519, 8911, 9366, 9805, 10149, 10321, 10277, 10007, 9512, 8837, 8063, 7271, 6539, 5927, 5469, 5169, 5012, 4986, 5070, 5207, 5294, 5219, 4903, 4308, 3491, 2605, 1788, 1057, 266, -893, -2740, -5466, -9068, -13311, -17856, -22390, -26480, -29763, -31938, -32770, -32169, -30205, -27082, -23108, -18588, -13829, -9127, -4722, -840, 2344, 4765, 6423, 7436, 7933, 8012, 7724, 7094, 6119, 4813, 3194, 1291, -901, -3260, -5645, -7896, -9835, -11329, -12328, -12784, -12681, -12008, -10827, -9211, -7291, -5229, -3157, -1168, 642, 2232, 3553, 4583, 5317, 5753, 5902, 5777, 5408, 4842, 4135, 3344, 2474, 1520, 502, -554, -1603, -2563, -3389, -4066, -4532, -4716, -4601, -4195, -3562, -2776, -1899, -948, 48, 1050, 2014, 2885, 3604, 4134, 4425, 4484, 4343, 4047, 3662, 3233, 2767, 2253, 1709, 1142, 556, -33, -604, -1137, -1592, -1914, -2070, -2049, -1847, -1473, -984, -450, 70, 563, 1026, 1478, 1916, 2304, 2572, 2665, 2562, 2279, 1844, 1299, 691, 90, -457, -926, -1300, -1588, -1800, -1926, -1959, -1899, -1745, -1499, -1191, -878, -618, -457, -441, -551, -741, -983, -1248, -1501, -1705, -1817, -1786, -1611, -1304, -892, -420, 41, 444, 676, 679, 450, 49, -425, -841, -1122, -1262, -1282, -1246, -1184, -1081, -922, -731, -541, -419, -397, -452, -512, -533, -487, -399, -317, -236, -116};