/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0074 256 samples */
 
const int16_t AKWF_hvoice_0074_256_DATA [256] = 
{314, 1132, 1995, 2778, 3380, 3852, 4302, 4791, 5394, 6068, 6693, 7216, 7622, 7942, 8295, 8739, 9231, 9731, 10152, 10431, 10579, 10610, 10584, 10566, 10544, 10466, 10352, 10262, 10202, 10138, 10063, 9993, 9945, 9984, 10113, 10169, 10046, 9769, 9386, 9037, 8836, 8702, 8483, 8153, 7711, 7270, 7037, 7030, 7148, 7296, 7338, 7247, 7159, 7153, 7209, 7291, 7361, 7384, 7420, 7538, 7743, 8014, 8346, 8726, 9155, 9642, 10157, 10651, 11104, 11520, 11917, 12325, 12748, 13147, 13490, 13837, 14246, 14721, 15268, 15792, 16171, 16392, 16476, 16495, 16582, 16720, 16787, 16750, 16705, 16645, 16364, 15709, 14338, 12118, 9416, 6599, 3772, 967, -1898, -4994, -8095, -10811, -13098, -15050, -16798, -18558, -20358, -22084, -23697, -25280, -26884, -28444, -29873, -31063, -31928, -32477, -32749, -32708, -32299, -31541, -30466, -29172, -27757, -26302, -24825, -23335, -21865, -20396, -18871, -17282, -15663, -14042, -12414, -10724, -8907, -6879, -4794, -2860, -1146, 332, 1596, 2704, 3650, 4318, 4696, 4880, 4941, 4917, 4832, 4701, 4529, 4354, 4199, 3975, 3580, 2988, 2183, 1213, 159, -948, -2092, -3229, -4310, -5310, -6201, -6998, -7695, -8298, -8815, -9254, -9649, -10034, -10393, -10716, -10965, -11087, -11105, -11057, -10939, -10705, -10363, -9958, -9506, -8987, -8386, -7647, -6765, -5833, -4933, -4063, -3216, -2382, -1548, -755, -63, 579, 1267, 2013, 2770, 3494, 4087, 4562, 5086, 5710, 6333, 6875, 7240, 7389, 7464, 7594, 7717, 7748, 7625, 7288, 6831, 6403, 6037, 5711, 5382, 4990, 4509, 3905, 3195, 2492, 1850, 1262, 706, 57, -787, -1727, -2665, -3496, -4138, -4613, -4984, -5286, -5541, -5755, -5935, -6067, -6110, -6046, -5878, -5625, -5378, -5190, -5016, -4801, -4499, -4067, -3524, -2892, -2220, -1542, -888, -269};