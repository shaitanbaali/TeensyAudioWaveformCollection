/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0059 256 samples */
 
const int16_t AKWF_hvoice_0059_256_DATA [256] = 
{7461, 19621, 29791, 32758, 25596, 11912, -2971, -12424, -14584, -11821, -6365, -3645, -7611, -14806, -21123, -23196, -18738, -9992, -427, 5853, 6612, 4774, 2991, 3263, 6909, 12297, 16158, 15995, 11542, 5095, -669, -4157, -4381, -2926, -2703, -4616, -7699, -11426, -13836, -13110, -9666, -4864, -1697, -200, 728, 262, 352, 2867, 5877, 8290, 9477, 8670, 6575, 3736, 1612, 844, 216, -164, -1229, -3225, -5035, -6639, -6898, -6188, -5385, -4127, -2683, -1531, -1338, -742, 605, 1957, 3225, 4388, 5016, 4197, 2854, 2093, 1903, 1557, 845, 607, 46, -1875, -3473, -3670, -3704, -3384, -2789, -2625, -2419, -2345, -1786, -572, 303, 963, 1668, 2291, 2121, 1726, 1942, 2183, 1593, 480, 742, 1039, -382, -1106, -845, -1133, -1908, -2279, -1614, -1604, -2400, -1598, -605, -1113, -1271, -397, 52, -89, 341, 1023, 758, 676, 1248, 1137, 817, 952, 707, 341, 152, -203, -525, -826, -1070, -1151, -1346, -1501, -908, -78, -74, -71, 268, -101, -508, -209, 167, 160, 213, 797, 1267, 496, -136, 294, 138, -295, 38, 495, 185, -329, -452, -595, -692, -415, 91, 297, 290, 326, 89, 377, 911, 520, 479, 1071, 594, -42, 213, 607, 526, 263, 571, 278, -1013, -1105, 59, 236, 96, 553, 392, -180, -464, -162, 181, -62, 374, 1201, 636, -385, -63, 262, -325, -34, 873, 482, -525, -587, -513, -941, -1149, -371, 899, 434, -94, 774, 683, 42, 36, 805, 1038, 296, 539, 1086, 440, -246, 11, 686, 678, 884, 1345, 870, 294, 67, 154, 524, 1128, 1685, 1653, 1313, 1331, 1027, 379, 453, 128, -759, -499, 304, 1034, 1705, 1584, -175, -4249, -8107, -8189, -2833};