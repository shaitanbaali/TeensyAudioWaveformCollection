/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_hvoice_0046 256 samples */
 
const int16_t AKWF_hvoice_0046_256_DATA [256] = 
{2020, 4023, 5450, 6176, 9971, 13273, 17735, 20240, 19163, 18581, 21997, 25115, 21797, 19481, 20537, 21882, 21917, 22223, 21118, 20707, 22772, 22254, 18345, 15555, 14147, 10926, 7143, 3195, -967, -3761, -6921, -11443, -15355, -17800, -21426, -25046, -27087, -28608, -30416, -31709, -32533, -32728, -32104, -31747, -32115, -31897, -30526, -29339, -28952, -28614, -27842, -26592, -24794, -23197, -21905, -19940, -17391, -14824, -12425, -10080, -7625, -4419, -638, 2004, 3430, 5664, 8988, 11385, 12247, 12870, 14433, 16394, 17817, 17846, 17911, 19320, 21118, 21877, 22129, 23098, 24354, 24594, 23358, 22074, 21496, 20580, 18357, 16010, 14263, 12956, 11413, 9875, 8559, 7754, 6654, 5141, 3800, 3150, 2223, 593, -1061, -2226, -3207, -4299, -5570, -6840, -8021, -8968, -9762, -10449, -11335, -11838, -12127, -12250, -12856, -13131, -12740, -12381, -11715, -10557, -9996, -9529, -8222, -6257, -5463, -4660, -2673, -562, 1422, 3374, 6027, 9108, 12027, 15483, 17912, 19267, 20855, 22687, 22536, 20982, 21785, 22069, 20379, 19546, 20211, 19854, 19413, 19609, 18413, 17145, 16895, 14995, 11617, 9375, 7092, 4021, 998, -2528, -6137, -8800, -11733, -15684, -18660, -20697, -23253, -25496, -27060, -28472, -29661, -30221, -30483, -30624, -30421, -30094, -29888, -29281, -28520, -27997, -27306, -26144, -24858, -23431, -21557, -19443, -17089, -14363, -11793, -9351, -6528, -3713, -1297, 1317, 4478, 6821, 8248, 10248, 12582, 14124, 14563, 15147, 16051, 16855, 17779, 17500, 17535, 18330, 19428, 19561, 19419, 20524, 21411, 21007, 19280, 17687, 17281, 16619, 15095, 13206, 11889, 11279, 10442, 9013, 7574, 6385, 5544, 3746, 1797, -293, -1953, -3743, -5263, -6465, -7559, -8639, -9608, -10266, -10709, -11371, -11664, -11827, -11594, -11051, -9980, -9871, -10025, -9609, -7574, -6669, -6111, -5918, -5310, -4292, -2752, -1539, -1654, -1052};