/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cheeze_0005 256 samples */
 
const int16_t AKWF_cheeze_0005_256_DATA [256] = 
{241, 671, 1082, 1495, 1912, 2326, 2742, 3158, 3570, 3983, 4395, 4809, 5223, 5635, 6044, 6456, 6866, 7278, 7688, 8094, 8502, 8908, 9314, 9723, 10127, 10527, 10930, 11332, 11734, 12133, 12530, 12926, 13324, 13719, 14112, 14506, 14894, 15284, 15671, 16061, 16443, 16825, 17207, 17586, 17965, 18339, 18711, 19086, 19453, 19821, 20186, 20546, 20908, 21266, 21620, 21974, 22325, 22670, 23015, 23357, 23694, 24031, 24360, 24686, 25011, 25333, 25650, 25963, 26271, 26577, 26877, 27173, 27467, 27751, 28032, 28310, 28583, 28849, 29109, 29361, 29607, 29851, 30086, 30312, 30533, 30746, 30951, 31147, 31334, 31511, 31682, 31841, 31989, 32129, 32255, 32369, 32473, 32560, 32634, 32691, 32734, 32761, 32769, 32759, 32726, 32673, 32593, 32492, 32362, 32200, 32010, 31782, 31517, 31208, 30853, 30448, 29985, 29457, 28857, 28172, 27395, 26509, 25500, 24341, 23006, 21459, 19660, 17564, 15090, 12155, 8668, 4527, -312, -5775, -11666, -17371, -22180, -25608, -27724, -28986, -29810, -30404, -30875, -31263, -31590, -31866, -32096, -32283, -32436, -32555, -32646, -32712, -32752, -32768, -32765, -32743, -32700, -32640, -32566, -32476, -32373, -32255, -32126, -31984, -31833, -31671, -31497, -31314, -31122, -30923, -30714, -30496, -30272, -30041, -29801, -29556, -29305, -29047, -28782, -28512, -28237, -27956, -27672, -27381, -27084, -26785, -26478, -26173, -25861, -25542, -25222, -24898, -24570, -24239, -23904, -23567, -23224, -22881, -22537, -22185, -21831, -21477, -21120, -20761, -20397, -20031, -19665, -19294, -18923, -18550, -18174, -17796, -17415, -17035, -16654, -16268, -15879, -15491, -15102, -14712, -14319, -13926, -13530, -13136, -12739, -12340, -11940, -11539, -11137, -10733, -10331, -9928, -9521, -9113, -8708, -8298, -7891, -7482, -7070, -6658, -6248, -5837, -5424, -5014, -4600, -4186, -3775, -3359, -2943, -2530, -2116, -1703, -1288, -875, -450, -70};