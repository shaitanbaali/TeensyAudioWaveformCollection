/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cheeze_0001 256 samples */
 
const int16_t AKWF_cheeze_0001_256_DATA [256] = 
{403, 1165, 1825, 2510, 3190, 3866, 4545, 5219, 5893, 6567, 7233, 7898, 8564, 9221, 9879, 10530, 11177, 11823, 12465, 13099, 13729, 14353, 14973, 15587, 16196, 16796, 17389, 17978, 18557, 19133, 19696, 20253, 20801, 21343, 21874, 22398, 22913, 23414, 23909, 24390, 24866, 25331, 25779, 26218, 26649, 27065, 27471, 27862, 28241, 28608, 28960, 29300, 29626, 29936, 30231, 30514, 30781, 31033, 31266, 31487, 31690, 31877, 32046, 32200, 32335, 32451, 32550, 32632, 32695, 32740, 32763, 32768, 32754, 32720, 32668, 32593, 32497, 32382, 32245, 32087, 31909, 31709, 31485, 31241, 30975, 30686, 30378, 30044, 29691, 29315, 28914, 28495, 28051, 27585, 27096, 26585, 26051, 25499, 24924, 24326, 23709, 23067, 22409, 21731, 21029, 20309, 19570, 18814, 18041, 17248, 16438, 15609, 14769, 13915, 13047, 12163, 11265, 10357, 9446, 8513, 7574, 6630, 5676, 4720, 3758, 2787, 1815, 840, -133, -1103, -2077, -3050, -4018, -4984, -5941, -6892, -7841, -8778, -9707, -10626, -11531, -12426, -13311, -14184, -15039, -15876, -16701, -17510, -18303, -19076, -19832, -20565, -21283, -21981, -22659, -23317, -23949, -24562, -25156, -25728, -26279, -26805, -27309, -27792, -28250, -28687, -29104, -29495, -29861, -30210, -30532, -30834, -31112, -31370, -31603, -31818, -32007, -32177, -32321, -32448, -32554, -32638, -32701, -32742, -32766, -32768, -32751, -32713, -32657, -32583, -32491, -32379, -32251, -32101, -31938, -31756, -31555, -31341, -31109, -30862, -30600, -30320, -30027, -29719, -29395, -29060, -28711, -28345, -27969, -27576, -27174, -26763, -26334, -25895, -25444, -24981, -24509, -24027, -23533, -23029, -22519, -21997, -21466, -20924, -20375, -19817, -19256, -18682, -18099, -17512, -16916, -16316, -15712, -15095, -14477, -13851, -13220, -12589, -11949, -11303, -10656, -10000, -9342, -8685, -8021, -7355, -6686, -6014, -5340, -4667, -3989, -3309, -2629, -1949, -1273, -588};