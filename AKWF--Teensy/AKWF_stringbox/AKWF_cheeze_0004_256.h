/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cheeze_0004 256 samples */
 
const int16_t AKWF_cheeze_0004_256_DATA [256] = 
{218, 737, 1181, 1644, 2105, 2565, 3027, 3483, 3941, 4402, 4861, 5320, 5774, 6228, 6685, 7141, 7594, 8049, 8499, 8950, 9401, 9850, 10297, 10742, 11188, 11630, 12074, 12515, 12953, 13387, 13823, 14259, 14692, 15121, 15550, 15974, 16398, 16819, 17241, 17658, 18071, 18483, 18891, 19297, 19703, 20102, 20499, 20894, 21285, 21672, 22057, 22437, 22813, 23188, 23556, 23920, 24282, 24637, 24989, 25338, 25682, 26018, 26350, 26678, 27001, 27318, 27628, 27928, 28227, 28520, 28807, 29084, 29352, 29616, 29871, 30122, 30359, 30588, 30810, 31022, 31225, 31418, 31600, 31769, 31930, 32079, 32213, 32332, 32440, 32536, 32615, 32682, 32727, 32758, 32769, 32761, 32737, 32688, 32617, 32524, 32405, 32258, 32085, 31883, 31646, 31378, 31075, 30728, 30342, 29913, 29434, 28902, 28316, 27666, 26949, 26166, 25300, 24346, 23302, 22149, 20888, 19513, 17990, 16327, 14508, 12517, 10369, 8040, 5523, 2854, 53, -2851, -5772, -8682, -11488, -14110, -16509, -18642, -20511, -22144, -23557, -24777, -25845, -26774, -27594, -28323, -28967, -29538, -30042, -30487, -30881, -31226, -31531, -31794, -32017, -32209, -32369, -32500, -32601, -32677, -32730, -32760, -32769, -32758, -32727, -32678, -32612, -32532, -32433, -32322, -32197, -32058, -31905, -31741, -31567, -31381, -31183, -30974, -30757, -30531, -30296, -30053, -29798, -29537, -29270, -28995, -28712, -28423, -28125, -27822, -27513, -27200, -26879, -26550, -26218, -25882, -25539, -25194, -24842, -24485, -24125, -23757, -23390, -23020, -22642, -22260, -21875, -21485, -21099, -20702, -20303, -19903, -19501, -19095, -18686, -18273, -17859, -17442, -17023, -16601, -16176, -15749, -15320, -14889, -14459, -14027, -13589, -13151, -12710, -12273, -11829, -11384, -10939, -10494, -10047, -9600, -9146, -8696, -8243, -7788, -7337, -6882, -6426, -5969, -5511, -5053, -4597, -4138, -3679, -3219, -2758, -2300, -1841, -1379, -918, -458};