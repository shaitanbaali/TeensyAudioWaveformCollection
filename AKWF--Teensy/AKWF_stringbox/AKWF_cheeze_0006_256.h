/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cheeze_0006 256 samples */
 
const int16_t AKWF_cheeze_0006_256_DATA [256] = 
{145, 540, 921, 1308, 1695, 2079, 2468, 2851, 3237, 3624, 4007, 4392, 4776, 5158, 5543, 5925, 6307, 6687, 7070, 7453, 7835, 8214, 8593, 8971, 9350, 9728, 10104, 10481, 10853, 11230, 11604, 11976, 12350, 12720, 13088, 13458, 13827, 14193, 14562, 14926, 15288, 15651, 16011, 16371, 16732, 17086, 17443, 17798, 18148, 18500, 18848, 19195, 19540, 19885, 20226, 20566, 20905, 21241, 21575, 21907, 22235, 22562, 22886, 23208, 23529, 23845, 24162, 24470, 24779, 25085, 25387, 25685, 25981, 26276, 26563, 26848, 27131, 27407, 27680, 27952, 28217, 28477, 28731, 28981, 29227, 29468, 29701, 29929, 30152, 30371, 30579, 30783, 30979, 31168, 31348, 31520, 31684, 31838, 31985, 32119, 32244, 32357, 32458, 32547, 32622, 32682, 32728, 32757, 32768, 32761, 32734, 32685, 32614, 32514, 32386, 32230, 32035, 31805, 31533, 31211, 30834, 30404, 29898, 29309, 28626, 27828, 26897, 25798, 24480, 22904, 20978, 18606, 15605, 11748, 6708, 129, -8195, -17685, -25982, -30474, -31760, -32087, -32310, -32473, -32590, -32674, -32731, -32760, -32768, -32757, -32727, -32679, -32617, -32538, -32445, -32338, -32221, -32090, -31950, -31801, -31640, -31472, -31294, -31107, -30912, -30713, -30503, -30289, -30067, -29838, -29604, -29364, -29121, -28868, -28616, -28355, -28090, -27821, -27546, -27269, -26988, -26701, -26412, -26120, -25821, -25523, -25221, -24914, -24605, -24292, -23977, -23662, -23341, -23017, -22691, -22363, -22035, -21703, -21367, -21031, -20691, -20351, -20010, -19665, -19319, -18969, -18620, -18271, -17919, -17563, -17205, -16848, -16489, -16130, -15770, -15405, -15040, -14676, -14311, -13943, -13574, -13204, -12834, -12463, -12091, -11718, -11343, -10967, -10595, -10218, -9838, -9461, -9083, -8702, -8326, -7944, -7561, -7182, -6797, -6415, -6035, -5650, -5265, -4883, -4496, -4112, -3730, -3346, -2958, -2572, -2188, -1802, -1416, -1030, -647, -253};