/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cheeze_0003 256 samples */
 
const int16_t AKWF_cheeze_0003_256_DATA [256] = 
{94, 591, 1116, 1631, 2147, 2662, 3179, 3693, 4207, 4724, 5234, 5746, 6257, 6766, 7277, 7785, 8288, 8795, 9300, 9800, 10305, 10800, 11295, 11793, 12285, 12775, 13264, 13748, 14232, 14713, 15189, 15667, 16140, 16607, 17075, 17540, 18000, 18454, 18907, 19355, 19803, 20246, 20680, 21113, 21543, 21966, 22386, 22801, 23207, 23614, 24013, 24406, 24794, 25175, 25549, 25920, 26284, 26639, 26990, 27331, 27665, 27994, 28312, 28622, 28926, 29219, 29504, 29783, 30049, 30304, 30549, 30785, 31011, 31225, 31426, 31615, 31792, 31958, 32107, 32246, 32367, 32472, 32568, 32641, 32700, 32743, 32765, 32768, 32752, 32717, 32660, 32581, 32478, 32351, 32199, 32022, 31818, 31587, 31321, 31025, 30699, 30337, 29942, 29507, 29033, 28519, 27963, 27362, 26716, 26019, 25271, 24468, 23612, 22702, 21729, 20697, 19598, 18434, 17209, 15918, 14554, 13131, 11635, 10080, 8479, 6809, 5097, 3343, 1554, -246, -2051, -3867, -5662, -7431, -9168, -10841, -12463, -14023, -15511, -16921, -18256, -19514, -20699, -21809, -22845, -23804, -24704, -25535, -26308, -27024, -27680, -28286, -28845, -29353, -29820, -30245, -30627, -30973, -31283, -31560, -31804, -32016, -32198, -32355, -32486, -32588, -32666, -32723, -32759, -32769, -32761, -32735, -32687, -32624, -32544, -32446, -32331, -32204, -32061, -31901, -31732, -31547, -31349, -31140, -30923, -30690, -30445, -30192, -29930, -29655, -29372, -29080, -28777, -28468, -28152, -27825, -27492, -27151, -26801, -26446, -26084, -25714, -25339, -24955, -24569, -24177, -23778, -23375, -22966, -22549, -22130, -21707, -21279, -20843, -20406, -19964, -19520, -19070, -18615, -18159, -17698, -17234, -16769, -16297, -15824, -15347, -14869, -14389, -13903, -13417, -12929, -12437, -11943, -11450, -10952, -10452, -9953, -9452, -8948, -8442, -7936, -7426, -6919, -6411, -5898, -5386, -4871, -4357, -3845, -3328, -2811, -2297, -1780, -1265, -747, -219};