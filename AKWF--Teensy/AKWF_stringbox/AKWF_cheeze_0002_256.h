/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_cheeze_0002 256 samples */
 
const int16_t AKWF_cheeze_0002_256_DATA [256] = 
{86, 562, 1171, 1753, 2339, 2927, 3516, 4103, 4688, 5268, 5851, 6432, 7015, 7588, 8164, 8741, 9311, 9881, 10446, 11009, 11573, 12130, 12687, 13241, 13788, 14331, 14877, 15413, 15948, 16479, 17002, 17524, 18040, 18551, 19057, 19557, 20052, 20543, 21026, 21504, 21977, 22440, 22900, 23351, 23797, 24235, 24663, 25085, 25498, 25903, 26302, 26691, 27067, 27438, 27799, 28152, 28493, 28820, 29140, 29449, 29745, 30033, 30306, 30567, 30817, 31053, 31275, 31484, 31677, 31856, 32022, 32173, 32307, 32425, 32526, 32610, 32678, 32728, 32758, 32769, 32761, 32734, 32684, 32615, 32524, 32411, 32275, 32115, 31931, 31723, 31490, 31233, 30948, 30635, 30295, 29928, 29531, 29107, 28651, 28162, 27648, 27101, 26518, 25907, 25259, 24578, 23872, 23125, 22343, 21532, 20684, 19803, 18895, 17948, 16967, 15957, 14922, 13850, 12752, 11626, 10475, 9307, 8115, 6902, 5673, 4427, 3171, 1915, 644, -626, -1899, -3171, -4430, -5678, -6925, -8149, -9359, -10552, -11711, -12855, -13972, -15059, -16117, -17147, -18134, -19098, -20026, -20917, -21777, -22596, -23382, -24133, -24850, -25533, -26182, -26789, -27368, -27914, -28426, -28906, -29352, -29770, -30157, -30515, -30843, -31141, -31412, -31657, -31876, -32072, -32239, -32384, -32502, -32599, -32673, -32728, -32760, -32769, -32761, -32732, -32684, -32616, -32533, -32433, -32314, -32177, -32026, -31861, -31677, -31482, -31271, -31046, -30807, -30555, -30292, -30013, -29724, -29424, -29114, -28790, -28457, -28111, -27757, -27394, -27020, -26638, -26244, -25845, -25435, -25018, -24593, -24159, -23717, -23268, -22815, -22353, -21884, -21410, -20927, -20445, -19950, -19452, -18947, -18437, -17923, -17407, -16882, -16353, -15818, -15283, -14743, -14200, -13653, -13101, -12545, -11990, -11430, -10866, -10300, -9730, -9159, -8588, -8012, -7436, -6857, -6274, -5691, -5110, -4526, -3940, -3352, -2763, -2180, -1593, -1007, -401};