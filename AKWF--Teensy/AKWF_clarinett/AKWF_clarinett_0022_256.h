/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0022 256 samples */
 
const int16_t AKWF_clarinett_0022_256_DATA [256] = 
{594, 1514, 2358, 3136, 3874, 4603, 5386, 6225, 7093, 8034, 9074, 10167, 11253, 12301, 13299, 14283, 15256, 16162, 16948, 17629, 18209, 18560, 18695, 18836, 19088, 19460, 19967, 20588, 21294, 22011, 22768, 23649, 24599, 25512, 26421, 27386, 28418, 29519, 30519, 31253, 31833, 32354, 32697, 32775, 32731, 32522, 31907, 30847, 29641, 28378, 26987, 25434, 23582, 21477, 19283, 17011, 14625, 12184, 9719, 7272, 4856, 2350, -353, -3007, -5323, -7630, -10206, -12647, -14679, -16702, -18835, -20674, -22078, -23268, -24293, -25017, -25407, -25525, -25350, -24790, -23889, -22788, -21522, -20106, -18610, -17183, -15694, -13953, -12151, -10482, -8947, -7573, -6065, -4222, -2469, -1005, 480, 2090, 3668, 5140, 6420, 7545, 8718, 9889, 10743, 11310, 11853, 12355, 12707, 12877, 12829, 12619, 12327, 11934, 11413, 10741, 9901, 8993, 8097, 7095, 5944, 4850, 3905, 3000, 2092, 1074, -2, -781, -1306, -2060, -2983, -3622, -4075, -4719, -5508, -6286, -7057, -7810, -8616, -9567, -10486, -11205, -11863, -12565, -13330, -14160, -14928, -15578, -16221, -16907, -17601, -18299, -19043, -19820, -20547, -21226, -21907, -22574, -23167, -23717, -24301, -24917, -25541, -26197, -26909, -27649, -28396, -29241, -30242, -31121, -31674, -31944, -31975, -31888, -31741, -31460, -30993, -30236, -29165, -27842, -26267, -24428, -22352, -20046, -17572, -14959, -12296, -9683, -7015, -4094, -1170, 1475, 4064, 6780, 9376, 11691, 13862, 15954, 17953, 19799, 21329, 22517, 23658, 24778, 25562, 25979, 26253, 26362, 26188, 25657, 24682, 23376, 21939, 20405, 18779, 17008, 15073, 13052, 11017, 8985, 6936, 4985, 3211, 1476, -277, -1862, -3266, -4688, -6146, -7434, -8510, -9450, -10301, -11145, -11911, -12421, -12725, -12927, -13088, -13270, -13363, -13223, -12858, -12294, -11557, -10696, -9786, -8865, -7910, -6896, -5820, -4695, -3445, -2123, -1049, -223};