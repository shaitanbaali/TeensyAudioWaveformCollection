/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0011 256 samples */
 
const int16_t AKWF_clarinett_0011_256_DATA [256] = 
{411, 1264, 2099, 2935, 3769, 4606, 5455, 6327, 7223, 8125, 9011, 9860, 10679, 11475, 12280, 13112, 13971, 14842, 15704, 16523, 17298, 18041, 18773, 19526, 20302, 21083, 21833, 22527, 23155, 23733, 24289, 24856, 25439, 26031, 26608, 27149, 27643, 28099, 28522, 28922, 29299, 29654, 29987, 30301, 30603, 30886, 31148, 31383, 31587, 31763, 31915, 32051, 32169, 32268, 32358, 32450, 32551, 32659, 32744, 32769, 32718, 32581, 32398, 32206, 32033, 31876, 31712, 31511, 31258, 30951, 30590, 30166, 29673, 29110, 28491, 27841, 27172, 26493, 25795, 25071, 24317, 23529, 22714, 21896, 21089, 20303, 19521, 18688, 17773, 16763, 15686, 14608, 13582, 12614, 11698, 10800, 9882, 8943, 7990, 7052, 6168, 5351, 4583, 3825, 3019, 2149, 1238, 345, -455, -1131, -1707, -2223, -2726, -3246, -3768, -4285, -4777, -5235, -5664, -6059, -6420, -6742, -7027, -7285, -7535, -7792, -8057, -8304, -8503, -8631, -8692, -8719, -8755, -8833, -8955, -9099, -9244, -9368, -9470, -9563, -9653, -9744, -9837, -9941, -10073, -10247, -10466, -10722, -10996, -11271, -11541, -11817, -12116, -12451, -12829, -13237, -13655, -14065, -14463, -14854, -15257, -15685, -16143, -16626, -17125, -17628, -18133, -18637, -19140, -19649, -20159, -20666, -21162, -21634, -22082, -22506, -22897, -23253, -23570, -23851, -24099, -24320, -24520, -24696, -24852, -24997, -25136, -25266, -25375, -25447, -25471, -25450, -25390, -25300, -25187, -25054, -24902, -24736, -24560, -24375, -24188, -24002, -23820, -23645, -23473, -23299, -23116, -22925, -22725, -22518, -22303, -22084, -21855, -21619, -21375, -21123, -20866, -20606, -20340, -20072, -19802, -19541, -19303, -19091, -18891, -18668, -18385, -18022, -17604, -17166, -16759, -16405, -16081, -15740, -15344, -14863, -14314, -13719, -13100, -12461, -11807, -11143, -10480, -9837, -9197, -8542, -7845, -7084, -6271, -5430, -4574, -3732, -2900, -2070, -1248, -399};