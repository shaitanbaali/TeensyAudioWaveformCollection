/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0024 256 samples */
 
const int16_t AKWF_clarinett_0024_256_DATA [256] = 
{958, 2549, 3885, 4925, 5592, 5872, 5985, 6102, 6138, 6020, 5815, 5600, 5433, 5379, 5482, 5795, 6307, 6898, 7567, 8470, 9677, 11183, 12967, 14886, 16797, 18777, 20927, 23163, 25401, 27477, 28970, 29960, 30938, 31947, 32603, 32777, 32729, 32495, 31924, 30973, 29754, 28382, 27100, 26184, 25558, 25040, 24511, 23742, 22812, 22193, 22007, 22073, 22291, 22500, 22586, 22570, 22461, 22466, 22854, 23319, 23380, 23105, 22746, 22389, 22165, 22078, 21921, 21614, 21283, 20956, 20485, 19779, 18766, 17387, 15822, 14321, 12823, 11156, 9366, 7695, 6139, 4433, 2605, 977, -303, -1240, -1833, -2246, -2619, -2784, -2530, -1889, -958, 368, 2382, 4915, 7346, 9555, 12060, 14889, 17341, 19056, 20620, 22390, 24008, 25178, 25750, 25493, 24717, 24003, 23402, 22828, 22157, 20929, 19111, 17109, 15163, 13638, 12760, 12013, 10955, 9822, 8911, 8085, 7123, 6116, 5253, 4557, 4052, 3669, 3085, 2218, 1314, 506, -215, -843, -1589, -2663, -4041, -5669, -7460, -9274, -11038, -12701, -14252, -15796, -17357, -18920, -20475, -21835, -22875, -23824, -24862, -25815, -26522, -26977, -27194, -27221, -27149, -27020, -26866, -26699, -26488, -26225, -25938, -25642, -25318, -24959, -24530, -23997, -23443, -22977, -22620, -22368, -22238, -22239, -22384, -22705, -23187, -23743, -24317, -24897, -25452, -25888, -26134, -26243, -26258, -26341, -26727, -27286, -27727, -27913, -27631, -26899, -26172, -25569, -24714, -23421, -21830, -20041, -18168, -16357, -14518, -12457, -10314, -8318, -6487, -4768, -3218, -2029, -1258, -798, -592, -565, -644, -1040, -1928, -2881, -3434, -3835, -4484, -5450, -6813, -8418, -9806, -10861, -11856, -12876, -13877, -14863, -15792, -16610, -17293, -17824, -18122, -18077, -17861, -17800, -17861, -17858, -17734, -17400, -16859, -16330, -15890, -15434, -14880, -14039, -12742, -11163, -9521, -7788, -5887, -3943, -2187, -576};