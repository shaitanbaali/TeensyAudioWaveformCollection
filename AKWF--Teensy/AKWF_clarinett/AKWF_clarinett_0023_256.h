/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0023 256 samples */
 
const int16_t AKWF_clarinett_0023_256_DATA [256] = 
{926, 2690, 4289, 5729, 7025, 8212, 9423, 10677, 11707, 12415, 12911, 13306, 13829, 14620, 15647, 16854, 18055, 19105, 19991, 20700, 21164, 21357, 21478, 21680, 21758, 21524, 21168, 20867, 20239, 18927, 17366, 16016, 14792, 13607, 12373, 10924, 9602, 8799, 8529, 8800, 9119, 8754, 7987, 7430, 7157, 7161, 7390, 7774, 8016, 7520, 6610, 6300, 6430, 6143, 5467, 4865, 4462, 4289, 4464, 5225, 6488, 7756, 9002, 10716, 12945, 15267, 17529, 19854, 22159, 24229, 25952, 27304, 28276, 28935, 29298, 29228, 28713, 28201, 27900, 27262, 26053, 24746, 23665, 23024, 22960, 22933, 22518, 22339, 22848, 23539, 23982, 24373, 24879, 25346, 25626, 25748, 25749, 25512, 24896, 24168, 23716, 23210, 22163, 20935, 20083, 19510, 18995, 18553, 18245, 18006, 17697, 17421, 17455, 17625, 17466, 17060, 16796, 16644, 16359, 15900, 15339, 14614, 13519, 12123, 10837, 9630, 7930, 5727, 3742, 2079, 165, -2110, -4517, -6927, -9140, -11040, -12620, -13904, -15166, -16513, -17739, -18733, -19415, -19760, -20085, -20581, -21066, -21429, -21711, -21935, -22197, -22564, -22933, -23218, -23319, -23139, -22833, -22566, -22116, -21241, -20104, -18921, -17586, -15977, -14280, -12723, -11243, -9727, -8178, -6620, -5118, -3792, -2670, -1764, -1060, -504, -157, -145, -441, -1002, -1677, -2066, -2438, -3788, -5942, -7853, -9370, -10869, -12351, -13714, -14914, -15917, -16715, -17256, -17590, -17928, -18363, -18848, -19383, -20026, -20772, -21395, -21852, -22498, -23474, -24577, -25687, -26629, -27316, -28187, -29483, -30689, -31463, -32021, -32504, -32757, -32765, -32624, -32291, -31872, -31422, -30877, -30160, -29374, -28622, -27730, -26476, -25071, -23815, -22606, -21275, -19962, -18819, -17879, -17204, -16610, -15749, -14873, -14514, -14503, -14364, -14105, -13918, -13748, -13462, -13023, -12390, -11573, -10644, -9617, -8439, -7136, -5788, -4380, -2742, -874};