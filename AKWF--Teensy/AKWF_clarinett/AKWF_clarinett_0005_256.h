/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0005 256 samples */
 
const int16_t AKWF_clarinett_0005_256_DATA [256] = 
{132, 229, 217, 296, 647, 1226, 1752, 2010, 2077, 2169, 2406, 2777, 3284, 3935, 4674, 5345, 5888, 6398, 7018, 7786, 8690, 9724, 10887, 12083, 13208, 14244, 15334, 16611, 18029, 19373, 20461, 21359, 22339, 23576, 24926, 26088, 26877, 27448, 28075, 28857, 29677, 30398, 30971, 31381, 31585, 31581, 31431, 31211, 30944, 30669, 30433, 30238, 30021, 29744, 29410, 29023, 28589, 28124, 27677, 27281, 26931, 26598, 26269, 26003, 25914, 26040, 26222, 26245, 26070, 25929, 26070, 26496, 27016, 27476, 27860, 28175, 28400, 28558, 28777, 29141, 29577, 29911, 30056, 30009, 29759, 29280, 28659, 28059, 27542, 26926, 25964, 24623, 23077, 21524, 20002, 18398, 16632, 14748, 12896, 11217, 9682, 8106, 6386, 4623, 3018, 1678, 588, -229, -748, -1118, -1629, -2379, -3093, -3402, -3237, -2795, -2277, -1718, -1171, -708, -353, 2, 460, 948, 1239, 1171, 822, 408, 51, -334, -902, -1692, -2720, -4051, -5699, -7469, -9085, -10465, -11825, -13407, -15215, -17056, -18753, -20307, -21817, -23359, -24895, -26326, -27580, -28684, -29691, -30637, -31470, -32119, -32552, -32759, -32739, -32496, -32019, -31315, -30394, -29360, -28318, -27298, -26318, -25392, -24508, -23572, -22486, -21296, -20108, -19011, -18022, -17178, -16508, -16000, -15593, -15265, -15051, -15006, -15150, -15447, -15856, -16363, -17000, -17799, -18751, -19834, -21028, -22301, -23503, -24490, -25297, -26076, -26940, -27842, -28689, -29430, -30040, -30435, -30573, -30474, -30195, -29757, -29136, -28304, -27266, -26113, -24948, -23777, -22622, -21509, -20425, -19244, -17822, -16213, -14692, -13465, -12463, -11491, -10428, -9332, -8277, -7292, -6410, -5745, -5336, -5080, -4819, -4501, -4228, -4126, -4196, -4319, -4394, -4408, -4350, -4198, -3974, -3817, -3832, -3961, -4030, -3933, -3695, -3360, -2941, -2472, -2033, -1658, -1337, -1051, -799, -568, -330, -72};