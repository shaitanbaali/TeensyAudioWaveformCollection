/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0020 256 samples */
 
const int16_t AKWF_clarinett_0020_256_DATA [256] = 
{617, 2195, 3575, 4875, 6123, 7357, 8629, 9970, 11402, 12820, 14116, 15306, 16399, 17393, 18108, 18377, 18068, 17457, 16754, 15611, 14160, 12800, 11646, 10643, 9514, 8555, 8108, 8312, 8889, 9404, 10258, 11576, 12998, 14596, 16429, 18218, 19772, 21038, 22367, 23767, 24755, 25511, 26268, 26884, 27524, 28461, 29435, 30202, 30605, 31020, 31736, 32398, 32751, 32741, 32528, 32068, 31094, 29781, 28305, 26444, 24210, 21768, 19364, 17097, 14904, 12606, 10135, 7795, 5501, 2967, 414, -2058, -4576, -6786, -8429, -9845, -11161, -12325, -13198, -13643, -13557, -13227, -12946, -12782, -12489, -11709, -10618, -9377, -8026, -6655, -5277, -3620, -1863, -414, 612, 1288, 1899, 2217, 2037, 1648, 1284, 1122, 1185, 1385, 1514, 1776, 2372, 3141, 3910, 4510, 5115, 5788, 6401, 6842, 7036, 6911, 6684, 6663, 6557, 6173, 5538, 4627, 3489, 2387, 1308, 91, -1054, -2013, -2798, -3492, -4179, -4808, -5332, -5731, -6159, -6707, -7373, -8005, -8514, -9188, -9914, -10371, -10747, -11130, -11429, -11647, -11829, -12087, -12487, -13045, -13420, -13699, -14565, -15544, -16152, -16693, -17344, -18190, -19024, -19646, -19917, -19998, -20077, -20159, -20175, -20026, -19761, -19472, -19259, -19148, -19151, -19363, -19753, -20230, -20686, -21157, -21875, -22690, -23400, -23966, -24468, -25031, -25441, -25607, -25615, -25481, -25210, -24749, -24241, -23870, -23339, -22496, -21460, -20230, -18845, -17671, -16552, -15073, -13503, -11934, -10129, -8023, -5680, -3462, -1339, 952, 3173, 5233, 7314, 9385, 11346, 13289, 14945, 15952, 16661, 17304, 17866, 18213, 18166, 17574, 16599, 15563, 14369, 12935, 11195, 9331, 7551, 6018, 4517, 2699, 972, -415, -1483, -2695, -4311, -5679, -6799, -8037, -9235, -10289, -11215, -12029, -12726, -13234, -13574, -13793, -13598, -12988, -12364, -11499, -10143, -8328, -6409, -4845, -3121, -1096};