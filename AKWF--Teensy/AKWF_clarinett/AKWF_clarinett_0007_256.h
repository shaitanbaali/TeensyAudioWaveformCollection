/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0007 256 samples */
 
const int16_t AKWF_clarinett_0007_256_DATA [256] = 
{257, 1107, 1921, 2719, 3525, 4382, 5305, 6252, 7172, 8036, 8853, 9667, 10508, 11352, 12178, 12947, 13650, 14305, 14921, 15501, 16052, 16562, 17033, 17472, 17882, 18274, 18645, 18969, 19223, 19405, 19541, 19669, 19796, 19889, 19904, 19823, 19666, 19471, 19261, 19048, 18876, 18785, 18778, 18819, 18859, 18889, 18915, 18943, 18976, 19014, 19053, 19094, 19145, 19232, 19377, 19578, 19829, 20116, 20436, 20795, 21199, 21661, 22142, 22598, 22986, 23328, 23701, 24167, 24722, 25303, 25843, 26334, 26789, 27225, 27648, 28061, 28473, 28891, 29315, 29739, 30155, 30566, 30960, 31330, 31672, 31981, 32252, 32482, 32660, 32758, 32767, 32729, 32603, 32414, 32165, 31834, 31412, 30898, 30302, 29649, 28944, 28165, 27277, 26265, 25152, 24007, 22867, 21728, 20542, 19270, 17912, 16505, 15094, 13694, 12275, 10788, 9216, 7570, 5909, 4261, 2631, 1008, -633, -2290, -3922, -5502, -7015, -8461, -9882, -11268, -12617, -13931, -15208, -16436, -17582, -18593, -19475, -20265, -20987, -21664, -22295, -22887, -23449, -23973, -24438, -24829, -25154, -25430, -25678, -25901, -26077, -26186, -26226, -26215, -26172, -26103, -26015, -25920, -25833, -25743, -25611, -25406, -25134, -24834, -24548, -24281, -24021, -23759, -23491, -23215, -22922, -22600, -22259, -21931, -21633, -21368, -21110, -20832, -20535, -20246, -19993, -19787, -19621, -19488, -19386, -19312, -19247, -19183, -19121, -19080, -19077, -19116, -19181, -19255, -19331, -19429, -19577, -19787, -20044, -20310, -20559, -20793, -21002, -21185, -21340, -21483, -21639, -21812, -21985, -22141, -22276, -22370, -22380, -22280, -22081, -21847, -21636, -21450, -21259, -21037, -20779, -20480, -20131, -19722, -19272, -18814, -18367, -17927, -17475, -16993, -16486, -15946, -15365, -14743, -14101, -13459, -12829, -12210, -11603, -11006, -10422, -9862, -9333, -8831, -8290, -7650, -6895, -6095, -5357, -4716, -4124, -3514, -2840, -2115, -1354, -543};