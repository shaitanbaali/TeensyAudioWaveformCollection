/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0002 256 samples */
 
const int16_t AKWF_clarinett_0002_256_DATA [256] = 
{1161, 3216, 4984, 6491, 7709, 8645, 9338, 9842, 10330, 10898, 11666, 12898, 14428, 15447, 15592, 15398, 15425, 15660, 16000, 16419, 16805, 17053, 17142, 17034, 16760, 16511, 16401, 16344, 16216, 16042, 15986, 16083, 15987, 15374, 14469, 13741, 13296, 13003, 12795, 12632, 12427, 12139, 11777, 11337, 10693, 9702, 8528, 7576, 6954, 6487, 6108, 5667, 4843, 3718, 2885, 2665, 2765, 2857, 2924, 2965, 2963, 3094, 3529, 4095, 4478, 4607, 4513, 4217, 3911, 3850, 4107, 4793, 5938, 7133, 7952, 8467, 8921, 9385, 9910, 10555, 11304, 12112, 12972, 13812, 14584, 15400, 16446, 17584, 18376, 18708, 18907, 19226, 19673, 20257, 20964, 21700, 22411, 22982, 23194, 23185, 23539, 24474, 25462, 26021, 26238, 26359, 26444, 26553, 26755, 26978, 27097, 27090, 26966, 26717, 26373, 25996, 25520, 24752, 23653, 22471, 21420, 20362, 19003, 17331, 15594, 13906, 12088, 9861, 7358, 5101, 3275, 1499, -501, -2651, -4804, -6861, -8628, -9913, -10943, -12082, -13332, -14487, -15467, -16190, -16521, -16578, -16683, -16945, -17170, -17189, -17176, -17488, -18052, -18189, -17547, -16599, -15885, -15455, -15360, -15609, -15735, -15281, -14487, -13884, -13588, -13426, -13312, -13278, -13353, -13484, -13511, -13350, -13073, -12779, -12388, -11692, -10680, -9751, -9203, -8851, -8394, -7782, -6969, -5908, -4877, -4212, -3843, -3402, -2791, -2188, -1733, -1430, -1305, -1345, -1369, -1260, -1168, -1307, -1678, -2167, -2746, -3397, -4072, -4824, -5796, -6999, -8244, -9357, -10476, -11860, -13455, -14992, -16339, -17564, -18740, -19894, -21047, -22223, -23496, -24946, -26364, -27324, -27812, -28312, -29104, -29994, -30758, -31369, -31835, -32147, -32331, -32390, -32393, -32561, -32772, -32719, -31959, -30731, -29700, -28842, -27768, -26305, -24678, -23080, -21474, -19780, -17984, -15988, -13718, -11357, -9281, -7541, -5952, -4436, -2841, -896};