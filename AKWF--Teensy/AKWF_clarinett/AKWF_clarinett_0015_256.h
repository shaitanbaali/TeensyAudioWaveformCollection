/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0015 256 samples */
 
const int16_t AKWF_clarinett_0015_256_DATA [256] = 
{450, 1067, 1541, 2452, 3660, 4816, 5295, 5572, 6405, 7475, 8440, 8978, 9658, 10776, 11340, 11473, 11786, 12426, 13205, 13554, 13809, 14369, 15075, 15678, 15881, 16247, 16944, 17353, 17816, 18724, 19574, 20188, 20650, 21003, 21373, 21997, 22657, 23071, 23483, 23958, 24401, 24688, 24811, 25115, 25384, 25268, 25483, 26108, 26454, 26725, 27154, 27521, 27840, 28232, 28804, 29446, 29757, 29822, 29889, 30390, 31073, 31256, 31221, 31286, 31653, 32010, 31999, 32001, 32104, 32131, 32134, 32156, 32188, 32217, 32220, 32073, 31837, 31755, 31700, 31530, 31187, 30864, 30819, 30470, 29774, 29493, 29325, 28881, 28321, 27766, 27311, 26973, 26665, 26173, 25525, 24846, 24256, 23666, 22819, 21987, 21302, 20449, 19534, 18779, 18242, 17719, 16771, 15823, 15198, 14557, 13823, 13031, 12223, 11368, 10347, 9348, 8519, 7827, 7068, 5984, 5014, 4334, 3562, 2934, 2629, 1984, 995, 143, -525, -1067, -1673, -2327, -2942, -3502, -4055, -4699, -5483, -6401, -7347, -8102, -8492, -8958, -9667, -10410, -11104, -11718, -12275, -12834, -13471, -14061, -14572, -15126, -15641, -16065, -16621, -17304, -17954, -18516, -18996, -19513, -20071, -20618, -20965, -21231, -21774, -22408, -22957, -23495, -23901, -24076, -24504, -25184, -25614, -25779, -25843, -26184, -26727, -27171, -27489, -27825, -28574, -29225, -29358, -29539, -29908, -30328, -30478, -30342, -30417, -30804, -31367, -31471, -31262, -31489, -31668, -31593, -31921, -32379, -32484, -32367, -32279, -32560, -32782, -32647, -32423, -32257, -32208, -32254, -32262, -31994, -31542, -31066, -30656, -30350, -30122, -29783, -29283, -28796, -28353, -27929, -27558, -27027, -26030, -25073, -24478, -24096, -23613, -22754, -21825, -20984, -20275, -19560, -18719, -17758, -16920, -16429, -15671, -14562, -13623, -12960, -12444, -11508, -10371, -9602, -9026, -8427, -7602, -6596, -5551, -4543, -3627, -2807, -2295, -1998, -1356, -427};