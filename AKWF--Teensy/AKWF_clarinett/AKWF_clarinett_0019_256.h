/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0019 256 samples */
 
const int16_t AKWF_clarinett_0019_256_DATA [256] = 
{569, 1418, 2105, 2763, 3455, 4247, 5186, 6033, 6650, 7334, 8283, 9167, 9751, 10422, 11505, 12544, 13151, 13586, 14087, 14674, 15394, 16056, 16414, 16746, 17391, 18168, 18824, 19423, 20085, 20752, 21334, 21836, 22254, 22692, 23367, 24128, 24631, 24967, 25396, 25952, 26693, 27423, 27608, 27410, 27540, 28016, 28436, 28734, 28948, 29104, 29287, 29527, 29859, 30242, 30457, 30483, 30534, 30685, 30876, 31088, 31284, 31455, 31760, 32225, 32506, 32463, 32348, 32292, 32336, 32494, 32409, 31877, 31458, 31502, 31586, 31407, 31066, 30621, 30230, 30053, 29823, 29288, 28746, 28496, 28335, 28044, 27670, 27257, 26839, 26491, 26097, 25492, 24818, 24318, 23893, 23345, 22720, 22141, 21579, 20973, 20367, 19867, 19408, 18827, 18133, 17451, 16769, 15978, 15141, 14446, 13889, 13322, 12706, 12013, 11248, 10472, 9696, 8899, 8083, 7261, 6433, 5589, 4739, 4005, 3402, 2721, 1893, 1081, 347, -421, -1261, -2104, -2904, -3686, -4463, -5210, -5922, -6675, -7512, -8345, -9104, -9854, -10664, -11442, -12112, -12707, -13256, -13808, -14412, -15064, -15758, -16446, -17064, -17672, -18374, -19074, -19645, -20121, -20557, -21019, -21630, -22286, -22773, -23162, -23611, -24132, -24715, -25301, -25772, -26150, -26528, -26932, -27377, -27837, -28246, -28599, -28947, -29289, -29579, -29799, -29915, -29954, -30107, -30404, -30665, -30843, -30994, -31143, -31327, -31562, -31809, -32048, -32280, -32497, -32594, -32535, -32530, -32678, -32773, -32697, -32500, -32216, -32000, -31964, -31905, -31668, -31354, -31053, -30756, -30458, -30157, -29840, -29518, -29220, -28880, -28405, -27942, -27688, -27420, -26829, -26071, -25401, -24829, -24310, -23846, -23416, -22974, -22466, -21875, -21193, -20451, -19723, -18983, -18131, -17214, -16387, -15654, -14944, -14219, -13423, -12556, -11673, -10809, -10045, -9359, -8568, -7656, -6792, -6023, -5182, -4250, -3441, -2801, -2097, -1254, -327};