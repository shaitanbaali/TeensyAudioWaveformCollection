/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0014 256 samples */
 
const int16_t AKWF_clarinett_0014_256_DATA [256] = 
{465, 1167, 1870, 2592, 3132, 3884, 4949, 5469, 5813, 6536, 7361, 8018, 8397, 9075, 10051, 10914, 11718, 12483, 13173, 13718, 14233, 15027, 15776, 16238, 16534, 16941, 17584, 18058, 18421, 18898, 19473, 20043, 20482, 20845, 21134, 21315, 21583, 21995, 22411, 22832, 23287, 23816, 24378, 24905, 25330, 25806, 26463, 27102, 27557, 27796, 28257, 28860, 29196, 29395, 29592, 29874, 30075, 30182, 30441, 30661, 30757, 31020, 31382, 31698, 31975, 32137, 32155, 32251, 32443, 32609, 32740, 32737, 32479, 32301, 32301, 32248, 31902, 31359, 31274, 31300, 31012, 30519, 30026, 29701, 29507, 29253, 28773, 28297, 27881, 27409, 26879, 26281, 25608, 24909, 24270, 23776, 23271, 22641, 21918, 21273, 20783, 20086, 19347, 18836, 18077, 17180, 16544, 15747, 14791, 14046, 13387, 12706, 12015, 11114, 10039, 9220, 8441, 7502, 6767, 6120, 5367, 4825, 4260, 3295, 2568, 2079, 1353, 605, -69, -767, -1537, -2320, -2909, -3522, -4297, -4965, -5529, -6092, -6789, -7439, -7832, -8424, -9188, -9786, -10373, -10996, -11566, -12080, -12583, -13174, -13927, -14761, -15353, -15872, -16525, -17172, -17790, -18388, -18913, -19449, -20102, -20578, -20952, -21563, -22114, -22491, -22877, -23233, -23570, -24016, -24534, -25024, -25311, -25643, -26230, -26586, -26824, -27296, -27884, -28432, -28815, -29199, -29599, -29871, -30218, -30662, -30925, -31217, -31598, -31596, -31489, -31606, -31721, -31777, -31806, -31980, -32183, -32193, -32414, -32703, -32530, -32407, -32556, -32681, -32555, -32213, -32137, -32137, -31944, -31551, -31200, -31068, -30739, -30188, -29622, -29243, -28987, -28600, -27995, -27264, -26626, -25984, -25243, -24350, -23692, -23340, -22515, -21663, -21259, -20603, -19752, -19033, -18367, -17688, -16942, -16221, -15528, -14772, -14060, -13342, -12342, -11434, -10782, -9985, -9049, -8129, -7421, -6674, -5629, -4677, -3874, -3117, -2411, -1723, -1020, -263};