/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0008 256 samples */
 
const int16_t AKWF_clarinett_0008_256_DATA [256] = 
{601, 1645, 2605, 3524, 4451, 5453, 6537, 7649, 8739, 9777, 10759, 11703, 12595, 13432, 14233, 15008, 15765, 16507, 17238, 17959, 18673, 19344, 19951, 20487, 20976, 21446, 21926, 22402, 22856, 23273, 23654, 23996, 24304, 24572, 24805, 25011, 25188, 25343, 25494, 25660, 25849, 26040, 26195, 26303, 26363, 26387, 26387, 26363, 26314, 26237, 26136, 26011, 25857, 25678, 25475, 25245, 24991, 24712, 24416, 24113, 23818, 23525, 23223, 22897, 22546, 22200, 21902, 21675, 21509, 21373, 21242, 21117, 21018, 20968, 20973, 21019, 21093, 21182, 21285, 21392, 21499, 21604, 21701, 21782, 21843, 21886, 21933, 22004, 22100, 22192, 22248, 22256, 22228, 22189, 22157, 22128, 22111, 22110, 22127, 22153, 22162, 22140, 22091, 22044, 22020, 22016, 22014, 21988, 21922, 21817, 21666, 21466, 21212, 20880, 20445, 19901, 19253, 18515, 17709, 16821, 15851, 14799, 13665, 12471, 11239, 9962, 8664, 7355, 6055, 4761, 3465, 2139, 784, -577, -1904, -3169, -4370, -5548, -6733, -7930, -9127, -10282, -11380, -12428, -13439, -14440, -15433, -16398, -17330, -18221, -19064, -19871, -20631, -21345, -22023, -22674, -23298, -23907, -24494, -25062, -25617, -26169, -26735, -27320, -27904, -28473, -29014, -29524, -30000, -30428, -30801, -31149, -31486, -31825, -32145, -32411, -32596, -32703, -32755, -32768, -32752, -32690, -32568, -32377, -32125, -31821, -31474, -31088, -30672, -30225, -29759, -29277, -28773, -28254, -27721, -27194, -26691, -26215, -25780, -25407, -25104, -24865, -24658, -24452, -24243, -24047, -23882, -23753, -23655, -23575, -23506, -23445, -23386, -23319, -23239, -23150, -23055, -22959, -22858, -22746, -22615, -22466, -22293, -22095, -21875, -21625, -21337, -21000, -20615, -20202, -19789, -19383, -18972, -18550, -18111, -17648, -17140, -16559, -15894, -15165, -14406, -13631, -12842, -12017, -11145, -10228, -9294, -8369, -7471, -6579, -5654, -4672, -3639, -2583, -1516, -424};