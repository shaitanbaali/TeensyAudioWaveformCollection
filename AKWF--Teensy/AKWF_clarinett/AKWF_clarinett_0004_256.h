/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0004 256 samples */
 
const int16_t AKWF_clarinett_0004_256_DATA [256] = 
{203, 808, 1439, 2162, 2999, 3898, 4763, 5540, 6294, 7093, 7913, 8620, 9104, 9461, 9936, 10611, 11319, 11852, 12187, 12408, 12574, 12678, 12722, 12720, 12664, 12533, 12336, 12101, 11851, 11608, 11419, 11315, 11299, 11357, 11500, 11746, 12103, 12587, 13251, 14114, 15152, 16271, 17427, 18680, 20096, 21638, 23222, 24757, 26209, 27541, 28704, 29740, 30724, 31634, 32347, 32729, 32770, 32728, 32436, 31930, 31280, 30496, 29477, 28101, 26445, 24820, 23420, 22073, 20439, 18448, 16328, 14312, 12444, 10728, 9190, 7834, 6619, 5538, 4612, 3891, 3366, 2958, 2614, 2327, 2109, 1949, 1863, 1886, 2003, 2115, 2145, 2070, 1868, 1519, 1069, 611, 168, -326, -945, -1676, -2512, -3441, -4441, -5456, -6456, -7449, -8461, -9455, -10280, -10826, -11151, -11405, -11644, -11842, -11974, -12039, -12064, -12070, -12023, -11832, -11460, -10952, -10357, -9700, -9017, -8357, -7715, -7029, -6278, -5494, -4701, -3918, -3264, -2897, -2787, -2685, -2417, -2104, -1988, -2151, -2483, -2859, -3272, -3798, -4489, -5289, -6059, -6736, -7413, -8215, -9145, -10122, -11073, -11991, -12916, -13842, -14744, -15586, -16357, -17076, -17765, -18424, -19093, -19794, -20482, -21101, -21637, -22075, -22403, -22636, -22870, -23188, -23534, -23781, -23889, -23926, -23975, -24038, -24094, -24130, -24117, -23978, -23672, -23244, -22755, -22218, -21629, -21003, -20324, -19511, -18535, -17438, -16266, -15058, -13852, -12704, -11619, -10494, -9273, -8022, -6842, -5775, -4778, -3783, -2800, -1859, -971, -143, 624, 1334, 1981, 2565, 3089, 3558, 3993, 4367, 4617, 4716, 4693, 4592, 4426, 4228, 4032, 3830, 3583, 3276, 2890, 2379, 1743, 1095, 573, 179, -181, -571, -970, -1363, -1735, -2105, -2510, -2923, -3209, -3263, -3133, -2951, -2774, -2625, -2543, -2534, -2512, -2399, -2200, -1943, -1643, -1284, -857, -340};