/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0010 256 samples */
 
const int16_t AKWF_clarinett_0010_256_DATA [256] = 
{440, 1710, 3005, 4304, 5550, 6753, 7912, 9039, 10152, 11237, 12289, 13298, 14250, 15144, 15986, 16775, 17521, 18226, 18896, 19540, 20163, 20767, 21370, 21984, 22622, 23276, 23906, 24482, 24979, 25419, 25839, 26278, 26755, 27252, 27744, 28209, 28637, 29046, 29453, 29869, 30296, 30720, 31129, 31518, 31882, 32203, 32461, 32636, 32732, 32765, 32766, 32754, 32721, 32654, 32538, 32368, 32149, 31871, 31529, 31113, 30639, 30151, 29694, 29287, 28915, 28543, 28140, 27699, 27239, 26776, 26323, 25883, 25460, 25055, 24677, 24329, 23998, 23670, 23330, 22979, 22642, 22341, 22097, 21904, 21726, 21530, 21290, 21011, 20723, 20458, 20233, 20029, 19809, 19536, 19192, 18799, 18395, 18014, 17669, 17343, 17013, 16661, 16277, 15869, 15431, 14963, 14465, 13937, 13377, 12789, 12175, 11530, 10854, 10133, 9372, 8596, 7822, 7071, 6340, 5597, 4824, 4014, 3169, 2301, 1406, 481, -452, -1362, -2216, -2993, -3718, -4412, -5099, -5785, -6466, -7144, -7828, -8517, -9205, -9882, -10546, -11192, -11828, -12460, -13083, -13714, -14335, -14937, -15515, -16072, -16629, -17214, -17838, -18491, -19167, -19840, -20515, -21188, -21841, -22461, -23045, -23589, -24117, -24633, -25137, -25628, -26097, -26539, -26958, -27347, -27693, -27991, -28237, -28443, -28619, -28773, -28904, -29008, -29074, -29099, -29084, -29042, -28985, -28923, -28853, -28756, -28613, -28416, -28176, -27924, -27692, -27489, -27307, -27123, -26916, -26686, -26439, -26186, -25937, -25692, -25453, -25237, -25051, -24898, -24766, -24640, -24503, -24360, -24228, -24131, -24089, -24095, -24121, -24135, -24115, -24068, -24022, -24008, -24039, -24098, -24150, -24158, -24106, -24002, -23851, -23665, -23439, -23175, -22893, -22607, -22321, -22016, -21655, -21209, -20681, -20075, -19404, -18682, -17899, -17074, -16234, -15394, -14549, -13696, -12822, -11933, -11027, -10070, -9020, -7853, -6590, -5305, -4070, -2920, -1821, -692};