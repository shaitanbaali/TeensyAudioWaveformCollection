/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0009 256 samples */
 
const int16_t AKWF_clarinett_0009_256_DATA [256] = 
{546, 1514, 2467, 3473, 4550, 5701, 6887, 8048, 9158, 10236, 11284, 12325, 13350, 14348, 15288, 16156, 16957, 17718, 18468, 19214, 19947, 20640, 21282, 21878, 22458, 23042, 23641, 24244, 24840, 25423, 25995, 26545, 27065, 27547, 27995, 28426, 28848, 29262, 29653, 30003, 30301, 30563, 30805, 31054, 31308, 31561, 31805, 32037, 32253, 32441, 32587, 32684, 32741, 32766, 32765, 32747, 32670, 32513, 32273, 31960, 31598, 31199, 30762, 30326, 29931, 29602, 29307, 28960, 28501, 27929, 27296, 26675, 26095, 25537, 24996, 24454, 23914, 23374, 22813, 22229, 21622, 20985, 20315, 19614, 18892, 18177, 17486, 16822, 16204, 15643, 15144, 14705, 14310, 13948, 13620, 13329, 13078, 12869, 12697, 12559, 12452, 12370, 12311, 12271, 12243, 12223, 12211, 12206, 12200, 12181, 12122, 12013, 11851, 11640, 11382, 11076, 10724, 10339, 9928, 9483, 9013, 8516, 7990, 7423, 6781, 6039, 5210, 4304, 3354, 2372, 1362, 337, -698, -1744, -2794, -3838, -4878, -5908, -6948, -7996, -9052, -10113, -11181, -12259, -13341, -14388, -15365, -16257, -17095, -17930, -18787, -19660, -20513, -21313, -22054, -22743, -23375, -23955, -24481, -24957, -25400, -25812, -26193, -26552, -26894, -27223, -27533, -27817, -28069, -28294, -28515, -28744, -28982, -29215, -29420, -29587, -29719, -29823, -29905, -29965, -30002, -30017, -30010, -29981, -29935, -29877, -29810, -29728, -29621, -29481, -29311, -29124, -28926, -28727, -28522, -28306, -28082, -27850, -27597, -27311, -26982, -26623, -26269, -25945, -25656, -25387, -25117, -24835, -24546, -24245, -23931, -23605, -23273, -22950, -22639, -22342, -22072, -21840, -21649, -21485, -21321, -21135, -20929, -20708, -20474, -20231, -19977, -19720, -19468, -19220, -18955, -18654, -18302, -17905, -17482, -17041, -16579, -16097, -15587, -15049, -14484, -13856, -13148, -12349, -11483, -10597, -9716, -8833, -7905, -6891, -5767, -4597, -3441, -2362, -1360, -379};