/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0013 256 samples */
 
const int16_t AKWF_clarinett_0013_256_DATA [256] = 
{298, 981, 1699, 2449, 3219, 4000, 4790, 5574, 6329, 7028, 7655, 8225, 8763, 9303, 9859, 10422, 10980, 11513, 12016, 12490, 12932, 13327, 13667, 13953, 14197, 14421, 14650, 14889, 15139, 15402, 15680, 15970, 16279, 16600, 16923, 17248, 17575, 17906, 18243, 18587, 18936, 19297, 19685, 20111, 20580, 21081, 21612, 22152, 22694, 23239, 23780, 24306, 24820, 25308, 25785, 26273, 26793, 27351, 27930, 28490, 28994, 29424, 29789, 30119, 30451, 30807, 31175, 31542, 31878, 32159, 32382, 32552, 32682, 32763, 32762, 32750, 32750, 32676, 32430, 32089, 31672, 31200, 30696, 30159, 29584, 28979, 28348, 27692, 27014, 26290, 25504, 24654, 23753, 22825, 21907, 21001, 20112, 19239, 18374, 17520, 16678, 15834, 14981, 14109, 13212, 12299, 11370, 10432, 9487, 8545, 7587, 6619, 5643, 4658, 3666, 2669, 1657, 637, -380, -1394, -2383, -3354, -4308, -5233, -6133, -7003, -7835, -8650, -9447, -10232, -11005, -11746, -12432, -13053, -13598, -14078, -14506, -14895, -15254, -15574, -15840, -16040, -16166, -16227, -16232, -16196, -16132, -16041, -15920, -15759, -15554, -15307, -15030, -14742, -14459, -14190, -13937, -13693, -13456, -13221, -13000, -12802, -12645, -12538, -12482, -12483, -12551, -12693, -12916, -13203, -13531, -13876, -14224, -14583, -14968, -15400, -15887, -16425, -17017, -17665, -18367, -19129, -19931, -20765, -21611, -22460, -23304, -24123, -24888, -25591, -26226, -26795, -27309, -27766, -28163, -28504, -28793, -29036, -29240, -29393, -29485, -29509, -29462, -29349, -29177, -28955, -28688, -28377, -28023, -27618, -27168, -26675, -26147, -25576, -24974, -24336, -23677, -23012, -22356, -21712, -21085, -20463, -19836, -19207, -18568, -17942, -17348, -16798, -16292, -15819, -15357, -14894, -14427, -13950, -13466, -12961, -12433, -11884, -11316, -10736, -10149, -9547, -8934, -8310, -7671, -7026, -6369, -5694, -5003, -4292, -3566, -2858, -2174, -1533, -928, -312};