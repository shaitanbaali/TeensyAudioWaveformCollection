/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0016 256 samples */
 
const int16_t AKWF_clarinett_0016_256_DATA [256] = 
{727, 2181, 3515, 4711, 5828, 6717, 7937, 8825, 9940, 11127, 12364, 13573, 14672, 15651, 16654, 17460, 18237, 18941, 19702, 20701, 21691, 22773, 23761, 24643, 25629, 26480, 27143, 27649, 28253, 28822, 29513, 30111, 30695, 31495, 31972, 32183, 32364, 32125, 31920, 31637, 31093, 30566, 29757, 28993, 28346, 27395, 26581, 25394, 24157, 22823, 21395, 19824, 18335, 16694, 15010, 13442, 11763, 10403, 8988, 7465, 6077, 4418, 2980, 1583, 87, -1347, -2766, -4070, -5335, -6492, -7643, -8611, -9540, -10544, -11530, -12640, -13728, -14853, -15741, -16692, -17607, -18607, -19617, -20535, -21418, -22482, -23457, -24384, -25236, -26170, -27132, -27875, -28510, -29231, -29933, -30566, -31194, -31630, -32039, -32541, -32657, -32743, -32705, -32426, -31956, -31448, -30820, -30043, -29121, -28390, -27409, -26269, -25081, -23825, -22522, -20983, -19331, -17580, -15848, -14036, -12316, -10596, -8802, -7245, -5740, -4183, -2733, -1189, 322, 1772, 3255, 4667, 6018, 7431, 8523, 9518, 10517, 11408, 12422, 13465, 14377, 15395, 16287, 17462, 18504, 19505, 20591, 21560, 22533, 23365, 24111, 24838, 25694, 26538, 27396, 28171, 28854, 29492, 30033, 30490, 30925, 31242, 31381, 31588, 31792, 31842, 31790, 31548, 31164, 30826, 30244, 29624, 28727, 27653, 26587, 25304, 24115, 22710, 21410, 19938, 18638, 17196, 15664, 14232, 12616, 11012, 9135, 7329, 5624, 3971, 2434, 942, -336, -1613, -2633, -3544, -4379, -5586, -6836, -7905, -9119, -10435, -11542, -12752, -14090, -14815, -15751, -16650, -17420, -18430, -19420, -20565, -21611, -22757, -23873, -24792, -25584, -26301, -27155, -27947, -28710, -29371, -30047, -30792, -31298, -31780, -32168, -32188, -32429, -32263, -32186, -32048, -31695, -31518, -30991, -30424, -29809, -28771, -27490, -26392, -25297, -23675, -22112, -20605, -18873, -17229, -15615, -13948, -12462, -10922, -9422, -7900, -6216, -4386, -2519, -847};