/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0021 256 samples */
 
const int16_t AKWF_clarinett_0021_256_DATA [256] = 
{310, 1396, 2433, 3565, 4969, 6392, 7680, 8914, 10186, 11719, 13301, 14406, 15131, 15695, 16348, 17234, 17939, 18357, 18804, 19344, 19932, 20562, 21227, 21994, 22900, 23928, 25063, 26250, 27454, 28638, 29709, 30562, 31384, 32284, 32768, 32761, 32731, 32563, 32014, 31098, 29908, 28514, 26999, 25322, 23479, 21663, 19714, 17101, 14305, 12049, 10053, 7989, 5804, 3511, 1330, -768, -2926, -5116, -7265, -9266, -11066, -12721, -14256, -15731, -17085, -18098, -18811, -19339, -19620, -19596, -19253, -18617, -17775, -16852, -16063, -15279, -14222, -13043, -11929, -10853, -9801, -8697, -7586, -6713, -5904, -4798, -3536, -2294, -1034, 227, 1257, 2050, 2892, 3758, 4500, 4988, 5121, 5237, 5540, 5840, 6044, 6120, 6046, 5814, 5594, 5556, 5595, 5609, 5524, 5338, 5155, 5032, 5013, 5033, 5013, 5043, 5177, 5423, 5675, 5602, 5242, 4871, 4416, 3767, 2937, 1956, 989, 73, -1005, -2177, -3206, -4189, -5255, -6295, -7229, -8114, -8969, -9748, -10481, -11281, -12135, -13010, -13969, -15026, -15919, -16605, -17345, -18243, -19342, -20528, -21643, -22586, -23338, -24249, -25413, -26470, -27336, -28059, -28772, -29660, -30366, -30619, -30890, -31332, -31551, -31499, -31334, -31053, -30609, -30034, -29335, -28255, -26732, -25099, -23385, -21491, -19378, -16980, -14389, -11715, -8900, -6010, -3207, -505, 2149, 4720, 7107, 9314, 11361, 13166, 14713, 16110, 17364, 18380, 19135, 19646, 19948, 20097, 20162, 20170, 20089, 19841, 19252, 18463, 17772, 16989, 15891, 14621, 13289, 11983, 10695, 9262, 7678, 6046, 4458, 2987, 1697, 568, -612, -1833, -2852, -3631, -4189, -4684, -5265, -5791, -6163, -6339, -6390, -6585, -6910, -7217, -7469, -7639, -7782, -7926, -7983, -7945, -7868, -7829, -7955, -7997, -7661, -7226, -6868, -6385, -5774, -5273, -4904, -4590, -4211, -3648, -2908, -2034, -1256, -553};