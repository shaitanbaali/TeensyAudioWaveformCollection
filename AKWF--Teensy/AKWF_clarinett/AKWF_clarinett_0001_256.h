/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0001 256 samples */
 
const int16_t AKWF_clarinett_0001_256_DATA [256] = 
{262, 1030, 1873, 2821, 3522, 4228, 5039, 5856, 6380, 6677, 7165, 7619, 7807, 7645, 7190, 6618, 6162, 5516, 4683, 4212, 3977, 3865, 4029, 4524, 5332, 6318, 7474, 8764, 10082, 11577, 13259, 14703, 16089, 17612, 18992, 20224, 21391, 22409, 23378, 24439, 25609, 26752, 27734, 28674, 29696, 30811, 31505, 31966, 32612, 32740, 32257, 31515, 30687, 29630, 28060, 26456, 24957, 23396, 21857, 20426, 19149, 17883, 16607, 15446, 14186, 12827, 11648, 10562, 9477, 8329, 7175, 6040, 4875, 3578, 2208, 1118, -26, -1383, -2359, -3206, -4141, -4802, -5198, -5462, -5684, -5831, -5906, -6177, -6542, -6790, -6918, -7099, -7431, -7448, -7191, -6896, -6369, -5578, -4639, -3834, -3069, -2023, -735, 542, 1520, 2325, 3079, 3827, 4269, 4388, 4446, 4334, 4078, 3848, 3424, 2870, 2578, 2382, 2124, 1803, 1638, 1669, 1582, 1345, 1007, 617, 97, -604, -1421, -2192, -2844, -3519, -4184, -4754, -5111, -5411, -5760, -5823, -5886, -6244, -6445, -6472, -6542, -6974, -7449, -7578, -7883, -8432, -8965, -9153, -9109, -9204, -9551, -9953, -10096, -10263, -10538, -10840, -11294, -12003, -12983, -14037, -15139, -16419, -17684, -18924, -20311, -21550, -22511, -23333, -24121, -24837, -25282, -25564, -25860, -26290, -26709, -27002, -27239, -27341, -27368, -27641, -27923, -27938, -27735, -27472, -27220, -26716, -26050, -25383, -24667, -23799, -22720, -21512, -20225, -18888, -17494, -15885, -13976, -12226, -10583, -8758, -6797, -4865, -3113, -1317, 561, 2402, 4254, 6070, 7722, 9210, 10459, 11368, 12205, 13014, 13561, 13853, 13969, 14003, 13799, 13271, 12500, 11577, 10583, 9554, 8415, 7187, 6058, 5019, 4049, 3197, 2310, 1324, 396, -395, -1113, -2036, -3018, -3802, -4282, -4737, -5409, -5915, -6149, -6184, -6203, -6167, -5936, -5552, -5022, -4346, -3539, -2687, -1865, -811};