/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0012 256 samples */
 
const int16_t AKWF_clarinett_0012_256_DATA [256] = 
{292, 1188, 2097, 2959, 3835, 4744, 5645, 6348, 6933, 7555, 8106, 8466, 8564, 8560, 8468, 8188, 7744, 7265, 6934, 6651, 6490, 6674, 7074, 7633, 8430, 9415, 10555, 11847, 13294, 14827, 16316, 17840, 19392, 20757, 21935, 23019, 24136, 25133, 25989, 27070, 28087, 28848, 29710, 30585, 31284, 31773, 32220, 32671, 32787, 32549, 31896, 31060, 29959, 28496, 26985, 25465, 23869, 22408, 21069, 19731, 18454, 17249, 16075, 14891, 13782, 12878, 12041, 11123, 10050, 8895, 7706, 6477, 5116, 3670, 2364, 1084, -170, -1231, -2247, -3184, -3742, -4194, -4717, -5193, -5475, -5588, -5845, -6080, -6134, -6101, -5971, -5763, -5563, -5352, -5057, -4571, -3996, -3435, -2783, -2030, -1224, -414, 357, 1076, 1841, 2553, 3030, 3258, 3293, 3216, 2982, 2646, 2314, 1956, 1706, 1724, 1711, 1670, 1822, 1942, 1935, 1870, 1754, 1636, 1553, 1147, 419, -256, -954, -1757, -2681, -3599, -4418, -5161, -5982, -6854, -7454, -7933, -8417, -8774, -9048, -9292, -9489, -9755, -10144, -10517, -10858, -11176, -11435, -11656, -11861, -12033, -12156, -12241, -12359, -12549, -12819, -13114, -13582, -14408, -15459, -16513, -17447, -18685, -20090, -21280, -22550, -23769, -24580, -25393, -26245, -26830, -27299, -27671, -27845, -27976, -28137, -28275, -28405, -28517, -28567, -28671, -28776, -28622, -28367, -28111, -27734, -27108, -26237, -25325, -24330, -23166, -21784, -20273, -18753, -17297, -15769, -14079, -12360, -10680, -8990, -7119, -5186, -3380, -1721, -149, 1447, 3119, 4785, 6306, 7659, 8862, 9924, 10745, 11296, 11617, 11820, 11953, 11992, 11856, 11534, 11082, 10477, 9738, 8921, 8058, 7178, 6299, 5468, 4653, 3753, 2967, 2283, 1420, 590, -115, -889, -1653, -2364, -3086, -3741, -4298, -4781, -5199, -5530, -5715, -5679, -5430, -5128, -4755, -4264, -3700, -3025, -2210, -1350, -494};