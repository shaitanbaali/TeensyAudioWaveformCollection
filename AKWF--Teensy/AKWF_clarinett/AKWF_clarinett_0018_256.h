/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0018 256 samples */
 
const int16_t AKWF_clarinett_0018_256_DATA [256] = 
{420, 1091, 1767, 2422, 3051, 3672, 4259, 4768, 5314, 5996, 6650, 7156, 7670, 8287, 8845, 9291, 9825, 10477, 10991, 11386, 11962, 12691, 13307, 13844, 14466, 15130, 15749, 16304, 16770, 17317, 18129, 18894, 19372, 19874, 20579, 21302, 21951, 22580, 23190, 23706, 24151, 24686, 25282, 25770, 26177, 26650, 27167, 27654, 28108, 28533, 28932, 29320, 29636, 29846, 30063, 30359, 30677, 30982, 31272, 31536, 31787, 32004, 32128, 32176, 32264, 32336, 32203, 31984, 31943, 31952, 31802, 31582, 31407, 31199, 30903, 30649, 30511, 30328, 30024, 29717, 29456, 29211, 28957, 28630, 28226, 27830, 27425, 26936, 26359, 25706, 25017, 24376, 23741, 23049, 22379, 21787, 21155, 20413, 19633, 18865, 18184, 17609, 17007, 16357, 15801, 15319, 14760, 14151, 13646, 13193, 12650, 12018, 11334, 10634, 9966, 9343, 8749, 8121, 7406, 6707, 6082, 5440, 4728, 3961, 3159, 2388, 1683, 1036, 423, -206, -860, -1525, -2185, -2829, -3462, -4097, -4721, -5309, -5871, -6420, -6946, -7451, -8021, -8667, -9228, -9679, -10241, -10910, -11483, -11977, -12561, -13236, -13929, -14620, -15302, -15990, -16724, -17484, -18230, -18935, -19572, -20179, -20785, -21418, -22069, -22610, -23021, -23500, -24076, -24599, -25054, -25507, -25951, -26356, -26742, -27143, -27554, -27954, -28373, -28839, -29308, -29742, -30131, -30471, -30809, -31168, -31473, -31710, -31951, -32217, -32490, -32721, -32773, -32736, -32720, -32727, -32688, -32631, -32605, -32534, -32336, -32099, -31904, -31697, -31444, -31196, -30967, -30691, -30350, -30021, -29718, -29422, -29087, -28587, -27983, -27467, -27006, -26479, -25896, -25271, -24642, -24048, -23431, -22731, -21972, -21179, -20426, -19749, -19108, -18475, -17807, -17099, -16382, -15678, -15032, -14420, -13773, -13092, -12386, -11694, -11086, -10453, -9678, -8899, -8245, -7572, -6779, -6005, -5330, -4541, -3596, -2742, -2061, -1433, -820, -195};