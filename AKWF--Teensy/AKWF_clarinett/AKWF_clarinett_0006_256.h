/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0006 256 samples */
 
const int16_t AKWF_clarinett_0006_256_DATA [256] = 
{235, 992, 1783, 2605, 3450, 4312, 5167, 5979, 6737, 7434, 8071, 8650, 9157, 9587, 9934, 10219, 10479, 10727, 10986, 11305, 11722, 12191, 12595, 12860, 13051, 13319, 13756, 14320, 14907, 15453, 15977, 16503, 17049, 17609, 18203, 18839, 19511, 20218, 20947, 21698, 22481, 23300, 24140, 24967, 25739, 26461, 27147, 27813, 28454, 29070, 29667, 30245, 30768, 31200, 31537, 31814, 32070, 32313, 32518, 32665, 32751, 32769, 32743, 32657, 32511, 32301, 32037, 31748, 31482, 31250, 31080, 31018, 31088, 31208, 31248, 31152, 30973, 30804, 30675, 30576, 30509, 30481, 30450, 30329, 30065, 29687, 29257, 28814, 28335, 27785, 27144, 26425, 25652, 24828, 23963, 23087, 22222, 21354, 20427, 19379, 18232, 17020, 15770, 14499, 13214, 11915, 10627, 9368, 8163, 7023, 5894, 4746, 3583, 2421, 1283, 183, -892, -1916, -2886, -3805, -4664, -5470, -6242, -7000, -7749, -8480, -9166, -9811, -10430, -11040, -11648, -12255, -12870, -13500, -14142, -14797, -15467, -16149, -16827, -17496, -18160, -18824, -19500, -20162, -20765, -21297, -21747, -22090, -22318, -22466, -22637, -22889, -23192, -23485, -23733, -23932, -24055, -24084, -24029, -23933, -23832, -23728, -23624, -23522, -23431, -23359, -23323, -23318, -23312, -23268, -23196, -23160, -23225, -23379, -23524, -23569, -23517, -23432, -23379, -23361, -23379, -23438, -23536, -23636, -23696, -23710, -23678, -23604, -23486, -23362, -23287, -23270, -23277, -23260, -23207, -23116, -22972, -22770, -22543, -22349, -22205, -22087, -21960, -21812, -21635, -21412, -21129, -20813, -20521, -20275, -20060, -19846, -19624, -19373, -19046, -18611, -18100, -17598, -17152, -16749, -16360, -15971, -15576, -15159, -14694, -14194, -13686, -13190, -12711, -12251, -11802, -11374, -10991, -10675, -10422, -10173, -9884, -9555, -9215, -8901, -8602, -8289, -7929, -7516, -7081, -6645, -6213, -5755, -5247, -4688, -4075, -3403, -2677, -1923, -1183, -461};