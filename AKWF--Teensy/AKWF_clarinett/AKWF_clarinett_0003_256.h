/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0003 256 samples */
 
const int16_t AKWF_clarinett_0003_256_DATA [256] = 
{823, 2526, 4170, 5617, 6913, 8369, 10181, 12163, 14039, 15758, 17376, 18898, 20350, 21833, 23368, 24794, 25914, 26835, 27872, 29128, 30355, 31280, 31891, 32321, 32626, 32767, 32708, 32470, 32186, 31953, 31692, 31243, 30590, 29874, 29204, 28576, 27961, 27344, 26817, 26482, 26253, 25855, 25178, 24385, 23677, 23075, 22576, 22191, 21837, 21358, 20739, 20080, 19441, 18826, 18262, 17748, 17274, 16844, 16400, 15819, 15068, 14266, 13539, 12913, 12415, 12071, 11833, 11641, 11468, 11227, 10851, 10434, 10158, 10032, 9853, 9457, 8954, 8594, 8427, 8237, 7827, 7251, 6682, 6188, 5708, 5195, 4661, 4138, 3645, 3214, 2884, 2662, 2522, 2453, 2428, 2411, 2393, 2392, 2418, 2481, 2639, 2891, 3070, 3013, 2734, 2312, 1781, 1209, 739, 330, -323, -1379, -2612, -3683, -4552, -5420, -6417, -7498, -8661, -9886, -11047, -12014, -12863, -13817, -14943, -16088, -17090, -17943, -18689, -19351, -19876, -20205, -20368, -20526, -20770, -21065, -21374, -21674, -21791, -21570, -21179, -21004, -21140, -21307, -21253, -21032, -20828, -20699, -20567, -20372, -20109, -19750, -19277, -18766, -18326, -17964, -17571, -17086, -16543, -15976, -15413, -14911, -14537, -14289, -14147, -14101, -14159, -14317, -14561, -14867, -15220, -15581, -15894, -16165, -16495, -16930, -17376, -17698, -17868, -17949, -17999, -17918, -17521, -16783, -15953, -15252, -14635, -13965, -13208, -12411, -11621, -10845, -10087, -9362, -8640, -7894, -7131, -6367, -5619, -4905, -4221, -3587, -3028, -2576, -2187, -1765, -1292, -897, -710, -685, -681, -640, -633, -737, -927, -1130, -1307, -1481, -1661, -1869, -2219, -2792, -3500, -4175, -4783, -5395, -6065, -6772, -7486, -8194, -8854, -9421, -9904, -10322, -10681, -11004, -11326, -11626, -11810, -11819, -11705, -11556, -11377, -11103, -10702, -10175, -9519, -8745, -7912, -7067, -6210, -5350, -4482, -3492, -2242, -725};