/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0025 256 samples */
 
const int16_t AKWF_clarinett_0025_256_DATA [256] = 
{629, 1827, 3145, 4610, 6253, 7930, 9408, 10708, 12016, 13368, 14674, 15894, 16988, 17894, 18721, 19617, 20591, 21581, 22543, 23393, 24076, 24624, 25082, 25507, 26011, 26582, 27063, 27384, 27558, 27571, 27532, 27604, 27697, 27580, 27202, 26632, 25888, 25016, 24075, 22992, 21662, 20098, 18367, 16522, 14705, 13004, 11402, 9885, 8356, 6586, 4655, 2916, 1456, 95, -1242, -2587, -3981, -5348, -6538, -7568, -8693, -9972, -11103, -11883, -12448, -12965, -13435, -13825, -14159, -14505, -14891, -15200, -15338, -15387, -15457, -15554, -15682, -15810, -15778, -15497, -15045, -14476, -13835, -13217, -12592, -11804, -10830, -9826, -8891, -7848, -6476, -4942, -3544, -2286, -1015, 309, 1678, 3059, 4424, 5725, 6937, 8077, 9123, 10048, 10850, 11472, 11871, 12140, 12396, 12608, 12653, 12527, 12335, 12126, 11907, 11695, 11444, 11076, 10601, 10066, 9489, 8945, 8460, 7874, 7023, 5948, 4747, 3456, 2130, 811, -591, -2140, -3772, -5449, -7196, -9065, -11038, -12996, -14863, -16683, -18433, -20124, -21794, -23406, -24916, -26315, -27594, -28745, -29760, -30628, -31343, -31879, -32255, -32541, -32737, -32752, -32543, -32140, -31578, -30889, -30124, -29268, -28270, -27102, -25724, -24077, -22309, -20596, -18888, -17078, -15179, -13168, -11085, -9073, -7235, -5496, -3732, -1947, -173, 1554, 3122, 4457, 5663, 6808, 7848, 8724, 9468, 10171, 10855, 11470, 11997, 12425, 12732, 12985, 13294, 13643, 13922, 14102, 14216, 14280, 14272, 14170, 13995, 13784, 13533, 13221, 12830, 12312, 11643, 10877, 10073, 9268, 8500, 7768, 6992, 6118, 5198, 4267, 3291, 2219, 1088, -1, -1017, -2000, -2960, -3876, -4720, -5516, -6300, -7047, -7665, -8142, -8620, -9180, -9663, -9906, -9992, -10079, -10176, -10238, -10252, -10150, -9878, -9531, -9231, -8906, -8378, -7647, -6918, -6259, -5553, -4735, -3804, -2732, -1574, -425};