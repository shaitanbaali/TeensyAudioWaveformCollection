/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_clarinett_0017 256 samples */
 
const int16_t AKWF_clarinett_0017_256_DATA [256] = 
{508, 1413, 2069, 2590, 3157, 3822, 4587, 5242, 5725, 6172, 6688, 7422, 8234, 8887, 9362, 9693, 10149, 10857, 11600, 12293, 12923, 13539, 14265, 14958, 15459, 15897, 16379, 17001, 17741, 18363, 18886, 19507, 20209, 20930, 21539, 21948, 22390, 22963, 23538, 24043, 24427, 24753, 25179, 25612, 25945, 26430, 27171, 27821, 28248, 28466, 28623, 29016, 29526, 29935, 30228, 30418, 30621, 30904, 31268, 31639, 31826, 31865, 31880, 31886, 31890, 31854, 31771, 31781, 31855, 31738, 31472, 31237, 31077, 31011, 30999, 30977, 30772, 30352, 29957, 29592, 29104, 28541, 28009, 27494, 26969, 26390, 25745, 25054, 24377, 23818, 23332, 22806, 22248, 21689, 21234, 20918, 20513, 19959, 19436, 18950, 18410, 17888, 17470, 16999, 16347, 15638, 14952, 14341, 13741, 12956, 12035, 11114, 10278, 9574, 8800, 7874, 7141, 6645, 6024, 5314, 4794, 4332, 3726, 3144, 2689, 2203, 1632, 1048, 479, -30, -543, -1152, -1831, -2549, -3262, -3951, -4630, -5311, -6022, -6784, -7604, -8387, -9017, -9599, -10207, -10838, -11464, -11975, -12428, -13021, -13685, -14291, -14868, -15458, -16004, -16495, -17051, -17676, -18244, -18790, -19429, -20048, -20534, -21118, -21908, -22510, -22871, -23425, -24135, -24665, -25149, -25811, -26428, -26841, -27136, -27401, -27819, -28364, -28793, -29137, -29519, -29897, -30226, -30535, -30836, -31075, -31268, -31516, -31808, -32082, -32320, -32501, -32641, -32751, -32748, -32635, -32593, -32604, -32496, -32295, -32081, -31894, -31762, -31573, -31261, -30825, -30301, -29769, -29324, -29087, -28878, -28481, -27952, -27363, -26840, -26409, -25959, -25430, -24741, -24058, -23622, -23166, -22470, -21776, -21188, -20542, -19836, -19169, -18557, -17992, -17341, -16480, -15738, -15264, -14677, -13868, -13037, -12281, -11676, -11151, -10581, -9937, -9209, -8570, -8023, -7245, -6284, -5510, -4915, -4370, -3712, -2811, -1970, -1357, -831, -255};