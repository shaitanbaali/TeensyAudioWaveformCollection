/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0005 256 samples */
 
const int16_t AKWF_raw_0005_256_DATA [256] = 
{5807, 32604, 29945, 28120, 26258, 24362, 22463, 20569, 18672, 16774, 14881, 12983, 11085, 9191, 7294, 5396, 3503, 1605, -293, -2186, -4084, -5981, -7874, -9773, -11670, -13563, -15462, -17358, -19252, -21151, -23047, -24941, -26841, -28165, -33099, -13840, 2059, 404, 2054, 3191, 4329, 5468, 6604, 7742, 8881, 10017, 11156, 12295, 13431, 14570, 15708, 16844, 17984, 19122, 20258, 21398, 22536, 23671, 24811, 25949, 27085, 28225, 29362, 30185, 33055, 15608, 7269, 8456, 7672, 7185, 6698, 6213, 5727, 5241, 4757, 4272, 3786, 3303, 2819, 2334, 1852, 1368, 887, 409, -85, -408, -1593, -2501, -1842, -1409, -938, -468, 1, 470, 941, 1411, 1881, 2351, 2820, 3291, 3761, 4231, 4702, 5171, 5641, 6112, 6582, 7052, 7522, 7944, 8668, 8006, 4480, 4319, 3955, 3618, 3282, 2945, 2610, 2273, 1937, 1601, 1264, 928, 591, 255, -80, -416, -754, -1089, -1425, -1772, -2047, -2622, -4600, -4309, -3891, -3511, -3124, -2737, -2349, -1961, -1574, -1186, -799, -411, -23, 363, 751, 1139, 1526, 1914, 2302, 2689, 3077, 3464, 3823, 4359, 4057, 2379, 2156, 1801, 1465, 1128, 793, 456, 119, -216, -552, -889, -1225, -1561, -1898, -2233, -2570, -2906, -3243, -3579, -3945, -4109, -5151, -8985, -8527, -8039, -7578, -7109, -6639, -6169, -5699, -5228, -4758, -4289, -3818, -3348, -2878, -2408, -1938, -1469, -998, -528, -58, 412, 881, 1348, 1819, 2304, 1269, 586, 148, -345, -833, -1318, -1806, -2293, -2778, -3266, -3753, -4238, -4726, -5212, -5698, -6186, -6672, -7159, -7646, -8544, -6795, -22956, -33572, -30189, -29450, -28297, -27143, -25988, -24835, -23680, -22525, -21372, -20217, -19061, -17909, -16754, -15599, -14446, -13290, -12136, -10984, -9828, -8673, -7520, -6364, -5210, -4057, -2904, -1753, -578};