/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0019 256 samples */
 
const int16_t AKWF_raw_0019_256_DATA [256] = 
{211, 863, 1505, 2147, 2788, 3431, 4076, 4719, 5362, 6003, 6646, 7289, 7934, 8574, 9216, 9860, 10503, 11147, 11790, 12430, 13074, 13718, 14360, 15005, 15646, 16288, 16933, 17576, 18220, 18863, 19504, 20147, 20791, 21433, 22077, 22719, 23360, 24005, 24649, 25291, 25935, 26575, 27219, 27863, 28506, 29149, 29791, 30432, 30982, 31917, 31448, 7103, -1570, -3965, -7721, -11276, -14830, -18368, -21883, -24479, -33339, 6848, 35342, 27353, 26137, 23863, 21584, 19313, 17044, 14765, 12485, 10212, 7934, 5668, 3392, 1081, -1060, -3565, -24499, -26291, -25085, -24681, -24151, -23625, -23102, -22577, -22057, -21537, -21019, -20505, -19993, -19480, -18970, -18461, -17956, -17455, -16952, -16452, -15952, -15455, -14961, -14471, -13980, -13491, -13004, -12518, -12038, -11557, -11077, -10601, -10124, -9651, -9183, -8713, -8245, -7779, -7321, -6851, -6328, -5801, -5275, -4755, -4234, -3712, -3192, -2673, -2154, -1642, -1126, -612, -100, 411, 920, 1427, 1937, 2442, 2948, 3454, 3953, 4455, 4956, 5455, 5955, 6453, 6945, 7441, 7935, 8426, 8918, 9407, 9894, 10382, 10869, 11353, 11838, 12318, 12799, 13281, 13760, 14239, 14715, 15188, 15663, 16138, 16609, 17078, 17549, 18016, 18483, 18951, 19413, 19876, 20339, 20800, 21260, 21720, 22112, 22750, 22514, 5737, -1286, -4041, -7719, -11276, -14829, -18375, -21903, -24476, -33340, 6847, 35329, 27341, 26132, 23864, 21586, 19306, 17031, 14753, 12486, 10211, 7934, 5655, 3379, 1070, -1083, -3400, -28899, -32070, -30453, -29995, -29351, -28709, -28063, -27421, -26779, -26138, -25494, -24851, -24207, -23567, -22924, -22280, -21637, -20993, -20350, -19710, -19066, -18423, -17780, -17135, -16494, -15851, -15208, -14564, -13921, -13278, -12636, -11994, -11350, -10706, -10064, -9423, -8778, -8136, -7492, -6848, -6207, -5565, -4921, -4279, -3635, -2991, -2352, -1708, -1066, -412};