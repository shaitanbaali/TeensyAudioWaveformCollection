/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0012 256 samples */
 
const int16_t AKWF_raw_0012_256_DATA [256] = 
{114, 284, 451, 618, 785, 952, 1119, 1286, 1453, 1793, 1004, 4960, 30731, 27847, 23678, 19916, 16076, 12226, 8376, 4536, 685, -3163, -7004, -10855, -14703, -18381, -23053, -19645, -14325, -11954, -9000, -6124, -3243, -367, 2508, 5391, 8266, 11143, 14025, 16899, 19777, 22659, 25279, 29535, 26325, 6573, 6052, 4524, 3114, 1705, 295, -1115, -2532, -3952, -5370, -6797, -8223, -9652, -11086, -12522, -13774, -16219, -12964, -2220, -2464, -1643, -972, -293, 387, 1083, 1784, 2429, 3073, 3719, 4362, 5007, 5651, 6292, 6878, 7851, 3332, 1458, 1518, 1165, 871, 578, 285, -7, -299, -593, -886, -1179, -1471, -1765, -2058, -2379, -2665, -2678, -22764, -26976, -25769, -25791, -25624, -25457, -25289, -25122, -24955, -24788, -24620, -24454, -24287, -24119, -23952, -23785, -23618, -23451, -23283, -23117, -22950, -22782, -22615, -22448, -22281, -22113, -21947, -21779, -21612, -21445, -21278, -21111, -20944, -20776, -20609, -20442, -20275, -20108, -19941, -19773, -19607, -19439, -19272, -19105, -18938, -18771, -18604, -18436, -18269, -18102, -17935, -17768, -17601, -17434, -17266, -17099, -16932, -16765, -16598, -16431, -16263, -16096, -15929, -15762, -15595, -15428, -15260, -15094, -14926, -14759, -14592, -14424, -14257, -14091, -13923, -13756, -13589, -13421, -13255, -13087, -12920, -12754, -12586, -12419, -12252, -12084, -11918, -11750, -11583, -11416, -11249, -11082, -10914, -10747, -10580, -10413, -10246, -10079, -9912, -9745, -9577, -9410, -9243, -9076, -8909, -8742, -8575, -8408, -8240, -8073, -7906, -7739, -7572, -7405, -7237, -7070, -6903, -6736, -6569, -6402, -6234, -6068, -5900, -5733, -5566, -5398, -5231, -5065, -4897, -4730, -4563, -4396, -4229, -4061, -3895, -3727, -3560, -3393, -3226, -3059, -2892, -2724, -2558, -2390, -2223, -2056, -1889, -1721, -1555, -1387, -1220, -1053, -886, -719, -552, -384, -218, -48};