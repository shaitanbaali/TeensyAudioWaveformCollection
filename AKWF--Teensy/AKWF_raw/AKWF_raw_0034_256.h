/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0034 256 samples */
 
const int16_t AKWF_raw_0034_256_DATA [256] = 
{32488, 31449, 30432, 29411, 28390, 27369, 26347, 25327, 24305, 23283, 22263, 21241, 20218, 19199, 18178, 17155, 16135, 15113, 14091, 13071, 12049, 11027, 10007, 8985, 7963, 6944, 5920, 4899, 3879, 2857, 1835, 815, -207, -1227, -2248, -3271, -4290, -5312, -6335, -7514, -7600, -12732, -26113, -23494, -21768, -19933, -18084, -16234, -14391, -12542, -10693, -8849, -7000, -5151, -3306, -1456, 390, 2235, 4085, 5931, 7776, 9627, 11474, 13320, 15170, 17015, 18862, 20712, 22556, 24404, 26255, 27801, 31274, 26014, -6991, -483, -7606, -10120, -8971, -8349, -7642, -6933, -6224, -5517, -4808, -4099, -3392, -2682, -1974, -1267, -558, 150, 1013, 833, 10910, 13912, 11259, 9778, 8113, 6444, 4781, 3115, 1447, -216, -1882, -3550, -5215, -6974, -8048, -19434, -21818, -19643, -18453, -17106, -15758, -14413, -13067, -11719, -10375, -9028, -7681, -6336, -4988, -3643, -2298, -949, 395, 1740, 3088, 4434, 5778, 7127, 8473, 9818, 11101, 12731, 13002, 1651, -2452, -5683, -9141, -12552, -15842, -20004, -12581, -8796, -8776, -7956, -7248, -6541, -5834, -5127, -4419, -3713, -3005, -2297, -1591, -883, -176, 698, 447, 5695, 14696, 11955, 10486, 8817, 7146, 5479, 3811, 2140, 474, -1195, -2866, -4532, -6531, -6366, -17219, -31838, -27860, -26354, -24454, -22554, -20660, -18758, -16860, -14964, -13063, -11165, -9269, -7368, -5471, -3574, -1672, 224, 2121, 4022, 5919, 7816, 9653, 11855, 12583, 2728, 1487, 1040, 380, -242, -867, -1492, -2115, -2740, -3365, -3988, -4614, -5239, -5862, -6487, -7111, -7735, -8361, -8985, -9609, -10234, -10858, -11482, -12107, -12731, -13356, -13981, -14605, -15228, -15854, -16478, -17102, -17727, -18352, -18976, -19601, -20224, -20849, -21475, -22098, -22723, -23347, -23970, -24596, -25221, -25844, -26470, -27094, -27717, -28343, -28967, -29570, -30050, -31699, -10777};