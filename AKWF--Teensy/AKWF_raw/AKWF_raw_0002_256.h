/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0002 256 samples */
 
const int16_t AKWF_raw_0002_256_DATA [256] = 
{223, 753, 1250, 1755, 2258, 2762, 3267, 3768, 4272, 4777, 5280, 5785, 6287, 6790, 7295, 7799, 8302, 8807, 9309, 9814, 10318, 10822, 11327, 11830, 12333, 12837, 13342, 13845, 14350, 14852, 15357, 15860, 16366, 16871, 17373, 17877, 18381, 18886, 19391, 19895, 20396, 20901, 21405, 21910, 22416, 22919, 23422, 23928, 24432, 24937, 25438, 25943, 26449, 26953, 27458, 27961, 28464, 28970, 29475, 29979, 30484, 30986, 31491, 31983, 32543, 32573, 32019, 31528, 31024, 30520, 30017, 29512, 29011, 28506, 28004, 27500, 26996, 26493, 25991, 25485, 24982, 24479, 23972, 23472, 22967, 22464, 21960, 21456, 20953, 20451, 19947, 19442, 18939, 18433, 17933, 17430, 16925, 16422, 15916, 15412, 14911, 14407, 13902, 13399, 12898, 12393, 11890, 11385, 10882, 10379, 9877, 9372, 8868, 8364, 7860, 7360, 6855, 6349, 5846, 5343, 4839, 4339, 3833, 3329, 2826, 2321, 1820, 1316, 812, 307, -194, -699, -1199, -1703, -2208, -2711, -3216, -3717, -4220, -4724, -5229, -5732, -6237, -6738, -7242, -7746, -8251, -8756, -9257, -9760, -10264, -10769, -11273, -11771, -12277, -12781, -13284, -13789, -14292, -14793, -15299, -15801, -16307, -16811, -17312, -17816, -18320, -18824, -19328, -19831, -20333, -20837, -21342, -21845, -22350, -22851, -23355, -23859, -24364, -24868, -25370, -25873, -26376, -26882, -27385, -27889, -28391, -28894, -29398, -29902, -30407, -30910, -31364, -32094, -31763, -23030, -22094, -21934, -21561, -21224, -20886, -20545, -20205, -19865, -19519, -19175, -18828, -18482, -18135, -17783, -17431, -17080, -16727, -16372, -16014, -15657, -15298, -14938, -14578, -14215, -13851, -13486, -13120, -12753, -12384, -12015, -11643, -11269, -10896, -10523, -10146, -9768, -9389, -9009, -8628, -8246, -7862, -7476, -7089, -6701, -6313, -5923, -5531, -5139, -4743, -4349, -3955, -3556, -3156, -2756, -2353, -1953, -1550, -1144, -737, -328};