/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0013 256 samples */
 
const int16_t AKWF_raw_0013_256_DATA [256] = 
{90, 411, 727, 1042, 1359, 1674, 1991, 2307, 2623, 2940, 3255, 3572, 3888, 4204, 4520, 4837, 5152, 5469, 5785, 6101, 6417, 6734, 7050, 7366, 7682, 7997, 8315, 8631, 8947, 9263, 9579, 9896, 10212, 10528, 10843, 11161, 11476, 11792, 12108, 12425, 12740, 13057, 13373, 13689, 14006, 14321, 14638, 14954, 15270, 15586, 15903, 16218, 16535, 16851, 17167, 17484, 17800, 18115, 18432, 18748, 19064, 19381, 19696, 20013, 20330, 20645, 20961, 21278, 21594, 21910, 22226, 22542, 22858, 23174, 23491, 23806, 24123, 24438, 24755, 25072, 25387, 25704, 26020, 26336, 26652, 26969, 27284, 27601, 27917, 28233, 28549, 28865, 29181, 29498, 29814, 30129, 30447, 30762, 31079, 31395, 31458, 33181, 27389, 4287, 4167, 3120, 2163, 1223, 281, -656, -1598, -2539, -3478, -4419, -5361, -6299, -7241, -8182, -9121, -10063, -11003, -11943, -12884, -13825, -14764, -15707, -16646, -17586, -18528, -19468, -20407, -21349, -21825, -25414, -17137, 33007, 30127, 28792, 27353, 25869, 24386, 22906, 21425, 19944, 18468, 16987, 15509, 14034, 12557, 11081, 9609, 8133, 6660, 5189, 3716, 2246, 778, -693, -2160, -3627, -5096, -6561, -8025, -9491, -10954, -12417, -13880, -15340, -16801, -18263, -19720, -21178, -22638, -24094, -25530, -26961, -28290, -29546, -31263, -25801, -23576, -23690, -23301, -22985, -22668, -22353, -22036, -21721, -21404, -21088, -20772, -20456, -20139, -19823, -19507, -19190, -18875, -18558, -18242, -17926, -17611, -17294, -16978, -16661, -16345, -16030, -15713, -15397, -15081, -14765, -14448, -14133, -13816, -13500, -13184, -12868, -12551, -12235, -11919, -11603, -11288, -10970, -10655, -10338, -10023, -9706, -9390, -9073, -8758, -8442, -8125, -7809, -7493, -7177, -6860, -6545, -6228, -5913, -5596, -5280, -4964, -4647, -4331, -4016, -3699, -3382, -3067, -2750, -2434, -2118, -1802, -1486, -1170, -854, -538, -217};