/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0017 256 samples */
 
const int16_t AKWF_raw_0017_256_DATA [256] = 
{288, 1060, 1816, 2574, 3332, 4090, 4850, 5607, 6366, 7125, 7883, 8641, 9401, 10158, 10917, 11677, 12434, 13193, 13952, 14709, 15469, 16228, 16985, 17744, 18503, 19261, 20020, 20779, 21536, 22295, 23054, 23812, 24571, 25329, 26087, 26847, 27605, 28363, 29123, 29881, 30602, 31437, 32121, 15110, 10173, 8901, 6780, 4785, 2795, 802, -1192, -3182, -5177, -7170, -9160, -11156, -13148, -15138, -17134, -19127, -21118, -23113, -24567, -29414, -12110, 3046, 1483, 3029, 4091, 5154, 6219, 7281, 8344, 9409, 10370, 11964, 10685, 2186, 207, 571, 3270, 4522, 3768, 3306, 2794, 2282, 1771, 1258, 705, 440, -1107, -5992, -5390, -4861, -4342, -3816, -3288, -2761, -2233, -1705, -1179, -651, -124, 402, 930, 1458, 1984, 2512, 3040, 4022, 2061, 22643, 34403, 31614, 31691, 31325, 30957, 30589, 30221, 29853, 29486, 29118, 28750, 28383, 28015, 27646, 27279, 26913, 26544, 26176, 25809, 25441, 25073, 24705, 24338, 23971, 23602, 23235, 22868, 22499, 22131, 21764, 21397, 21028, 20661, 20293, 19925, 19557, 19190, 18822, 18455, 18086, 17719, 17352, 16983, 16616, 16249, 15881, 15512, 15146, 14777, 14409, 14042, 13674, 13307, 12938, 12571, 12204, 11836, 11467, 11101, 10733, 10364, 9997, 9630, 9261, 8894, 8526, 8159, 7791, 7423, 7056, 6688, 6320, 5952, 5586, 5217, 4849, 4482, 4114, 3745, 3378, 3011, 2643, 2275, 1908, 1540, 1172, 804, 437, 70, -298, -665, -1033, -1402, -1769, -2136, -2504, -2872, -3240, -3607, -3974, -4343, -4710, -5092, -5553, -5203, -24950, -29533, -27545, -27008, -26248, -25490, -24732, -23972, -23215, -22457, -21698, -20940, -20181, -19422, -18665, -17906, -17146, -16389, -15630, -14871, -14113, -13354, -12595, -11838, -11079, -10320, -9562, -8803, -8044, -7287, -6527, -5769, -5011, -4252, -3494, -2736, -1978, -1222, -450};