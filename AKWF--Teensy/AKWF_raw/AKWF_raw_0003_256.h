/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0003 256 samples */
 
const int16_t AKWF_raw_0003_256_DATA [256] = 
{7630, 28205, 29260, 28659, 28508, 28246, 27984, 27724, 27464, 27203, 26943, 26683, 26424, 26165, 25905, 25646, 25388, 25130, 24871, 24614, 24355, 24098, 23842, 23585, 23328, 23072, 22814, 22559, 22304, 22048, 21794, 21539, 21283, 21029, 20775, 20521, 20268, 20014, 19760, 19507, 19255, 19002, 18749, 18497, 18246, 17995, 17743, 17492, 17241, 16991, 16739, 16491, 16240, 15991, 15742, 15492, 15243, 14995, 14746, 14498, 14251, 14003, 13755, 13508, 13261, 13015, 12768, 12522, 12276, 12030, 11784, 11540, 11295, 11050, 10805, 10560, 10316, 10073, 9830, 9586, 9343, 9100, 8857, 8616, 8373, 8131, 7891, 7649, 7408, 7167, 6925, 6685, 6445, 6205, 5965, 5726, 5487, 5248, 5009, 4770, 4533, 4295, 4057, 3820, 3582, 3345, 3109, 2872, 2635, 2400, 2164, 1928, 1694, 1458, 1223, 988, 754, 520, 286, 53, -180, -412, -645, -878, -1110, -1343, -1575, -1806, -2038, -2269, -2499, -2730, -2960, -3191, -3421, -3650, -3880, -4110, -4338, -4566, -4796, -5023, -5252, -5480, -5707, -5934, -6161, -6388, -6615, -6841, -7066, -7293, -7519, -7743, -7969, -8194, -8418, -8643, -8868, -9091, -9314, -9537, -9760, -9984, -10207, -10429, -10651, -10873, -11095, -11316, -11537, -11758, -11980, -12199, -12420, -12640, -12859, -13080, -13299, -13517, -13737, -13955, -14173, -14391, -14606, -14804, -15002, -15145, -15294, -15442, -15588, -15734, -15880, -16025, -16169, -16312, -16455, -16597, -16739, -16879, -17020, -17160, -17299, -17437, -17575, -17713, -17849, -17984, -18120, -18255, -18388, -18521, -18655, -18786, -18917, -19047, -19178, -19306, -19436, -19564, -19691, -19818, -19944, -20069, -20194, -20318, -20442, -20565, -20687, -20808, -20929, -21049, -21169, -21288, -21406, -21524, -21641, -21758, -21873, -21988, -22102, -22217, -22330, -22442, -22555, -22665, -22776, -22885, -22995, -23103, -23211, -23319, -23532, -22776, -27201, -19525};