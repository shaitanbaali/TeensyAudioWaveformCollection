/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0023 256 samples */
 
const int16_t AKWF_raw_0023_256_DATA [256] = 
{1088, 4602, 8037, 11459, 15095, 13640, 12363, 11998, 11437, 10898, 10360, 9822, 9283, 8746, 8206, 7667, 7129, 6591, 6052, 5515, 4976, 4437, 3899, 3360, 2822, 2284, 1745, 1207, 668, 135, -408, -939, 266, 1679, 2931, 4219, 5500, 6784, 8069, 9349, 10489, 11994, 5698, -16395, -34566, -30542, -30239, -29324, -28411, -27495, -26580, -25668, -24753, -23838, -22925, -22009, -21095, -20183, -19267, -18352, -17439, -16524, -15611, -14696, -13781, -12866, -11953, -11038, -10125, -9211, -8294, -7382, -6468, -5552, -4639, -3724, -2809, -1621, -2219, 10925, 18119, 16285, 16233, 15905, 15576, 15249, 14925, 14601, 14277, 13956, 13636, 13318, 13000, 12683, 12368, 12054, 11742, 11431, 11121, 10813, 10505, 10199, 9894, 9591, 9289, 8988, 8689, 8390, 8092, 7797, 7502, 7209, 6918, 6626, 6337, 6049, 5761, 5475, 5192, 4909, 4626, 4347, 4068, 3789, 3513, 3237, 2963, 2691, 2419, 2148, 1879, 1612, 1345, 1080, 817, 554, 293, 32, -225, -483, -739, -994, -1247, -1500, -1750, -2001, -2250, -2497, -2743, -2988, -3231, -3473, -3714, -3953, -4192, -4429, -4664, -4899, -5132, -5364, -5595, -5825, -6045, -6263, -6512, -6739, -6969, -7197, -7424, -7650, -7874, -8097, -8320, -8540, -8761, -8979, -9197, -9413, -9628, -9842, -10056, -10267, -10478, -10687, -10895, -11103, -11309, -11514, -11717, -11920, -12122, -12321, -12521, -12719, -12915, -13111, -13305, -13498, -13690, -13881, -14071, -14260, -14447, -14634, -14819, -15002, -15185, -15367, -15547, -15727, -15905, -16082, -16258, -16433, -16606, -16779, -16950, -17120, -17290, -17457, -17624, -17790, -17953, -18117, -18278, -18439, -18600, -18758, -18915, -19071, -19226, -19380, -19533, -19685, -19835, -19985, -20133, -20279, -20425, -20570, -20713, -20856, -20997, -21137, -21276, -21413, -21550, -21685, -21820, -21953, -22084, -22216, -22345, -22102, -24228, -13631};