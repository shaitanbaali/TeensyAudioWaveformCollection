/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0036 256 samples */
 
const int16_t AKWF_raw_0036_256_DATA [256] = 
{509, 1456, 2352, 3221, 4057, 4857, 5623, 6350, 7041, 7695, 8309, 8888, 9429, 9930, 10397, 10828, 11222, 11583, 11909, 12204, 12466, 12698, 12898, 13072, 13218, 13338, 13433, 13505, 13555, 13583, 13592, 13582, 13556, 13516, 13460, 13390, 13310, 13223, 13121, 12996, 12846, 12674, 12482, 12269, 12034, 11777, 11499, 11201, 10884, 10551, 10234, 9987, 9850, 9818, 9884, 10057, 10353, 10787, 11375, 12124, 13054, 14189, 15549, 17137, 18887, 20401, 20599, 19177, 17357, 16022, 14881, 13454, 11754, 10026, 8378, 6755, 5110, 3457, 1807, 185, -1378, -2866, -4268, -5598, -6865, -8060, -9176, -10218, -11183, -12071, -12884, -13620, -14279, -14864, -15374, -15813, -16183, -16483, -16720, -16893, -17006, -17062, -17065, -17022, -16967, -16948, -16986, -17072, -17200, -17375, -17611, -17913, -18284, -18727, -19249, -19858, -20560, -21369, -22167, -22544, -22393, -22107, -21925, -21692, -21177, -20354, -19345, -18242, -17063, -15807, -14483, -13113, -11726, -10327, -8923, -7526, -6135, -4757, -3399, -2056, -733, 582, 1922, 3268, 4590, 5901, 7200, 8481, 9749, 11008, 12260, 13512, 14763, 16018, 17289, 18573, 19878, 21217, 22590, 24009, 25486, 27024, 28632, 30339, 32022, 32791, 31999, 30541, 29432, 28586, 27509, 26110, 24612, 23150, 21693, 20198, 18670, 17124, 15586, 14061, 12541, 11031, 9538, 8058, 6602, 5170, 3757, 2369, 1008, -329, -1634, -2892, -4091, -5222, -6292, -7306, -8255, -9138, -9955, -10706, -11391, -12011, -12565, -13056, -13485, -13851, -14158, -14408, -14601, -14743, -14833, -14874, -14879, -14875, -14889, -14925, -14974, -15038, -15122, -15233, -15373, -15541, -15741, -15973, -16242, -16550, -16896, -17287, -17724, -18185, -18439, -18271, -17886, -17566, -17299, -16940, -16455, -15900, -15312, -14688, -14017, -13298, -12541, -11756, -10944, -10111, -9260, -8371, -7432, -6448, -5438, -4425, -3416, -2410, -1416, -421};