/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0025 256 samples */
 
const int16_t AKWF_raw_0025_256_DATA [256] = 
{645, 2317, 3957, 5600, 7242, 8885, 10531, 12172, 13817, 15464, 17105, 18749, 20395, 21921, 24162, 21150, 17941, 17492, 16504, 15597, 14688, 13779, 12872, 11963, 11054, 10148, 9238, 8330, 7422, 6512, 5605, 4697, 3787, 2880, 1971, 1062, 155, -752, -1662, -2569, -3477, -4387, -5294, -6202, -7112, -8019, -8928, -9837, -10744, -11653, -12562, -13468, -14378, -15286, -16193, -17103, -18011, -18918, -19828, -20736, -21644, -22553, -23461, -24369, -25278, -26186, -27093, -28003, -28910, -29819, -30266, -33589, -20906, -2743, -764, 3842, 8105, 11929, 17644, 28252, 27085, 25794, 24583, 23347, 22107, 20868, 19632, 18392, 17153, 15916, 14676, 13437, 12200, 10960, 9722, 8485, 7245, 6007, 4769, 3529, 2292, 1053, -187, -1423, -2662, -3901, -5527, -4623, -22572, -31903, -27993, -26673, -24948, -23219, -21489, -19765, -18035, -16306, -14582, -12851, -11124, -9398, -7669, -5941, -4216, -2485, -759, 967, 2697, 4423, 6150, 7880, 9606, 11333, 13063, 14788, 16516, 18247, 19971, 21701, 23429, 24715, 28801, 11739, -139, 764, -843, -2064, -3289, -4512, -5733, -6958, -8182, -9403, -10628, -11851, -13073, -14298, -15521, -16743, -17967, -19189, -20412, -21637, -22859, -24082, -25307, -26528, -27752, -28454, -32442, -17790, -101, -1497, 364, 1085, 12346, 15074, 13530, 12914, 12151, 11389, 10629, 9867, 9106, 8345, 7583, 6822, 6061, 5298, 4537, 3776, 3014, 2254, 1493, 730, -29, -790, -1798, -1177, -9773, -15077, -8271, -3464, 1735, 6454, 13242, 24891, 23457, 21923, 20470, 18989, 17504, 16019, 14538, 13052, 11569, 10087, 8602, 7119, 5638, 4152, 2669, 1187, -297, -1779, -3262, -4748, -6230, -7713, -9199, -10680, -12164, -13735, -14730, -18145, -31876, -30672, -28876, -27276, -25635, -23990, -22345, -20704, -19058, -17413, -15772, -14126, -12482, -10841, -9195, -7551, -5909, -4266, -2627, -955};