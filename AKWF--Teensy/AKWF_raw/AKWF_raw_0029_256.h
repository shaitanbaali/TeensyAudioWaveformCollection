/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0029 256 samples */
 
const int16_t AKWF_raw_0029_256_DATA [256] = 
{31894, 28649, 25469, 22280, 19093, 15903, 12710, 9524, 5993, 4745, -7961, -24444, -18850, -16012, -12730, -9448, -6174, -2891, 390, 3663, 6948, 10228, 13503, 16787, 20067, 23318, 26441, 30805, 6511, -4254, -7240, -11905, -16203, -21739, -3600, 4437, 2549, 2535, 2238, 1942, 1645, 1347, 1052, 755, 458, 161, -134, -431, -727, -1025, -1321, -1617, -1914, -2211, -2507, -2769, -3247, -2605, -1164, -1076, -797, -545, -295, -45, 206, 457, 707, 958, 1208, 1460, 1711, 1960, 2211, 2462, 2711, 2964, 3206, 3107, 2856, 2627, 2394, 2161, 1927, 1694, 1461, 1227, 994, 760, 527, 294, 61, -172, -404, -638, -919, -877, -2286, -7005, -6345, -5846, -5338, -4825, -4309, -3796, -3281, -2767, -2253, -1738, -1224, -710, -196, 318, 831, 1346, 1847, 2424, 2682, 1146, 784, 491, 178, -131, -440, -749, -1060, -1371, -1681, -1990, -2300, -2610, -2919, -3230, -3540, -3849, -4160, -4469, -4778, -5089, -5399, -5709, -6019, -6304, -6744, -6474, -4671, -4553, -4337, -4134, -3930, -3727, -3524, -3320, -3117, -2914, -2710, -2507, -2304, -2100, -1897, -1694, -1491, -1287, -1084, -880, -678, -474, -270, -68, 135, 339, 542, 806, 666, 2570, 5445, 4785, 4575, 4295, 4015, 3736, 3455, 3175, 2895, 2615, 2334, 2055, 1774, 1494, 1214, 934, 654, 374, 94, -186, -465, -746, -1026, -1306, -1586, -1867, -2146, -2427, -2706, -2987, -3267, -3547, -3828, -4147, -4207, -5377, -10702, -10309, -9793, -9331, -8856, -8380, -7903, -7428, -6951, -6476, -6000, -5523, -5047, -4572, -4095, -3619, -3144, -2667, -2192, -1715, -1238, -763, -287, 189, 664, 1140, 1616, 2092, 2568, 3045, 3519, 3982, 4502, 4856, 271, -1301, -2092, -3069, -4019, -4966, -5917, -6866, -7814, -8596, -10443, -6568};