/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0024 256 samples */
 
const int16_t AKWF_raw_0024_256_DATA [256] = 
{230, 713, 1186, 1662, 2136, 2612, 3090, 3566, 4044, 4522, 4999, 5478, 5957, 6435, 6915, 7396, 7876, 8357, 8839, 9320, 9803, 10286, 10768, 11252, 11735, 12218, 12704, 13188, 13673, 14159, 14645, 15132, 15619, 16106, 16594, 17082, 17571, 18059, 18549, 19038, 19528, 20019, 20510, 21001, 21494, 21984, 22478, 22972, 23388, 24282, 22972, 16755, 15194, 13348, 11540, 9727, 7918, 6111, 4299, 2490, 682, -1130, -2938, -4746, -6558, -8367, -10200, -11835, -14491, -15904, -14191, -12870, -11481, -10091, -8704, -7315, -5924, -4537, -3148, -1758, -372, 1017, 2408, 3794, 5184, 6574, 7960, 9350, 10740, 12127, 13517, 15033, 15705, 21874, 24720, 22191, 20655, 18961, 17267, 15569, 13876, 12180, 10483, 8790, 7094, 5397, 3704, 2008, 310, -1381, -3077, -4774, -6466, -8164, -9860, -11561, -13332, -14477, -29404, -32783, -31186, -30684, -30010, -29338, -28666, -27993, -27320, -26649, -25975, -25303, -24631, -23958, -23286, -22613, -21939, -21268, -20595, -19922, -19250, -18578, -17905, -17233, -16560, -15887, -15216, -14542, -13869, -13198, -12525, -11851, -11181, -10507, -9835, -9162, -8489, -7817, -7145, -6471, -5799, -5127, -4454, -3781, -3110, -2436, -1764, -1092, -418, 252, 925, 1598, 2270, 2943, 3616, 4287, 4961, 5634, 6305, 6978, 7652, 8323, 8996, 9669, 10341, 11014, 11686, 12358, 13032, 13704, 14376, 15049, 15722, 16394, 17067, 17739, 18411, 19085, 19757, 20429, 21103, 21774, 22446, 23121, 23795, 24411, 25340, 24679, 21856, 19251, 16616, 13972, 11329, 8693, 6049, 3407, 771, -1872, -4514, -7151, -9795, -12436, -15073, -17717, -20357, -22996, -25559, -28570, -29837, -15335, -13603, -13431, -12862, -12357, -11851, -11345, -10840, -10334, -9828, -9323, -8816, -8310, -7805, -7300, -6793, -6288, -5782, -5276, -4771, -4265, -3759, -3253, -2747, -2242, -1736, -1231, -727, -212};