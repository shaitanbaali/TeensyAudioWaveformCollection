/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0006 256 samples */
 
const int16_t AKWF_raw_0006_256_DATA [256] = 
{1236, 3087, 4901, 6720, 8538, 10357, 12465, 12690, 23520, 31937, 27013, 24288, 21204, 18129, 15046, 11963, 8888, 5805, 2723, -352, -3435, -6516, -9592, -12676, -15757, -18832, -21884, -25058, -27844, -21471, -18206, -15970, -13491, -11047, -8603, -6153, -3710, -1264, 1184, 3626, 6073, 8522, 10964, 13411, 15860, 18302, 20750, 23198, 25636, 27999, 30929, 25630, 22916, 22716, 21979, 21315, 20652, 19991, 19327, 18663, 18002, 17338, 16676, 16014, 15350, 14688, 14026, 13362, 12699, 12037, 11373, 10712, 10049, 9386, 8724, 8062, 7398, 6735, 6072, 5409, 4748, 4084, 3421, 2760, 2097, 1433, 770, 108, -554, -1216, -1879, -2542, -3204, -3867, -4530, -5193, -5856, -6518, -7181, -7844, -8506, -9168, -9832, -10494, -11158, -11821, -12482, -13145, -13808, -14470, -15133, -15796, -16458, -17122, -17785, -18446, -19110, -19797, -20287, -21674, -24014, -21404, -18922, -16438, -13948, -11453, -8961, -6471, -3974, -1484, 1006, 3503, 5992, 8485, 10981, 13470, 15963, 18168, 22164, 16033, 6108, 5650, 3628, 1845, 67, -1716, -3500, -5280, -7064, -8847, -10626, -12410, -14192, -15972, -17757, -19539, -21042, -24337, -10959, -3728, -4487, -3608, -2974, -2340, -1706, -1071, -437, 195, 829, 1463, 2096, 2732, 3366, 3999, 4633, 5267, 5900, 6535, 7106, 8064, 6730, 4420, 3829, 2939, 2094, 1249, 404, -441, -1285, -2130, -2975, -3850, -4509, -7623, -8017, -6914, -6127, -5288, -4448, -3610, -2772, -1932, -1094, -254, 587, 1424, 2263, 3173, 3612, 6071, 15856, 15133, 14207, 13373, 12517, 11656, 10797, 9940, 9080, 8221, 7363, 6503, 5645, 4787, 3927, 3069, 2210, 1350, 493, -365, -1225, -2083, -2942, -3801, -4659, -5518, -6507, -6638, -10411, -29313, -27978, -25976, -24211, -22395, -20574, -18753, -16937, -15115, -13295, -11478, -9656, -7836, -6019, -4200, -2387, -535};