/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0014 256 samples */
 
const int16_t AKWF_raw_0014_256_DATA [256] = 
{333, 818, 1294, 1771, 2247, 2724, 3202, 3678, 4156, 4633, 5109, 5587, 6064, 6540, 7017, 7495, 7972, 8449, 8927, 9403, 9880, 10357, 10833, 11311, 11788, 12265, 12743, 13220, 13696, 14174, 14650, 15127, 15604, 16081, 16558, 17036, 17513, 17990, 18467, 18943, 19420, 19898, 20374, 20851, 21329, 21806, 22283, 22760, 23237, 23715, 24191, 24667, 25145, 25623, 26099, 26576, 27053, 27530, 28008, 28485, 28961, 29439, 29916, 30392, 30870, 31346, 31816, 32319, 32677, 32220, 31649, 31107, 30555, 30003, 29455, 28904, 28352, 27802, 27251, 26699, 26150, 25599, 25048, 24498, 23947, 23396, 22846, 22294, 21741, 21191, 20640, 20089, 19538, 18986, 18435, 17884, 17332, 16781, 16230, 15677, 15127, 14575, 14024, 13472, 12921, 12368, 11817, 11265, 10713, 10161, 9609, 9058, 8506, 7953, 7401, 6850, 6298, 5745, 5194, 4641, 4089, 3537, 2984, 2432, 1880, 1327, 775, 223, -329, -881, -1433, -1987, -2539, -3092, -3646, -4197, -4750, -5304, -5855, -6408, -6963, -7514, -8067, -8621, -9173, -9727, -10280, -10832, -11386, -11940, -12492, -13047, -13600, -14152, -14706, -15260, -15813, -16367, -16920, -17473, -18028, -18581, -19135, -19689, -20242, -20795, -21351, -21903, -22457, -23013, -23565, -24120, -24675, -25227, -25782, -26337, -26890, -27445, -27999, -28552, -29107, -29662, -30216, -30771, -31326, -31868, -32476, -32609, -32065, -31611, -31148, -30671, -30197, -29721, -29247, -28772, -28297, -27822, -27346, -26872, -26398, -25922, -25447, -24972, -24496, -24021, -23546, -23070, -22595, -22120, -21644, -21170, -20693, -20218, -19743, -19266, -18791, -18316, -17841, -17364, -16889, -16413, -15937, -15461, -14985, -14509, -14034, -13557, -13081, -12606, -12129, -11653, -11177, -10700, -10225, -9748, -9272, -8796, -8319, -7842, -7367, -6890, -6413, -5937, -5460, -4983, -4507, -4031, -3553, -3078, -2600, -2123, -1647, -1170, -694, -209};