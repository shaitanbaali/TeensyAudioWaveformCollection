/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0027 256 samples */
 
const int16_t AKWF_raw_0027_256_DATA [256] = 
{242, 788, 1321, 1857, 2392, 2927, 3463, 3999, 4534, 5070, 5604, 6140, 6676, 7211, 7747, 8283, 8817, 9354, 9890, 10424, 10960, 11495, 12030, 12567, 13102, 13637, 14173, 14708, 15244, 15780, 16315, 16850, 17386, 17921, 18457, 18993, 19527, 20063, 20599, 21134, 21670, 22206, 22740, 23276, 23812, 24347, 24882, 25419, 25953, 26489, 27025, 27560, 28096, 28632, 29166, 29702, 30238, 30773, 31267, 31977, 31902, 21663, 18885, 17356, 15517, 13730, 11942, 10149, 8361, 6572, 4781, 2994, 1203, -588, -2373, -4164, -5956, -7742, -9532, -11323, -13110, -14902, -16747, -18205, -21349, -29340, -28852, -28345, -27881, -27399, -26917, -26435, -25952, -25468, -24985, -24501, -24017, -23533, -23048, -22562, -22077, -21590, -21103, -20618, -20131, -19643, -19156, -18669, -18180, -17691, -17202, -16713, -16224, -15734, -15243, -14753, -14261, -13770, -13279, -12786, -12293, -11802, -11308, -10814, -10322, -9826, -9332, -8838, -8342, -7847, -7351, -6854, -6358, -5862, -5364, -4867, -4369, -3870, -3372, -2874, -2374, -1875, -1375, -873, -374, 126, 628, 1129, 1632, 2134, 2636, 3140, 3643, 4146, 4651, 5155, 5659, 6165, 6670, 7176, 7682, 8189, 8691, 9188, 9655, 10090, 10535, 10977, 11421, 11866, 12312, 12760, 13210, 13659, 14110, 14563, 15015, 15471, 15926, 16383, 16841, 17299, 17760, 18266, 18494, 19798, 31226, 30259, 27741, 25613, 23419, 21227, 19029, 16837, 14644, 12445, 10253, 8059, 5862, 3670, 1475, -721, -2912, -5107, -7305, -9495, -11691, -13887, -16078, -18275, -20471, -22662, -24859, -26972, -29582, -30059, -21254, -20587, -20114, -19561, -19026, -18491, -17955, -17420, -16884, -16349, -15814, -15278, -14743, -14207, -13671, -13136, -12601, -12065, -11530, -10994, -10458, -9924, -9387, -8852, -8317, -7781, -7246, -6711, -6174, -5639, -5104, -4568, -4032, -3498, -2962, -2426, -1892, -1356, -822, -277};