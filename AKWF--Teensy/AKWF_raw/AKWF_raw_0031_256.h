/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0031 256 samples */
 
const int16_t AKWF_raw_0031_256_DATA [256] = 
{-577, -1411, -5711, -29498, -24435, -17284, -10605, -4665, 4967, 24290, 15938, 6908, -1854, -10393, -20657, -23152, -3844, -12, 4504, 8949, 13402, 17404, 24178, 14101, 1540, 2587, 1218, 220, -776, -1776, -2774, -3767, -4753, -5850, -3934, -2812, -2339, -1724, -1126, -530, 67, 663, 1260, 1857, 2476, 2930, 4105, 7034, 5411, 3746, 2109, 377, -706, -4922, -10369, -6450, -3388, -202, 2976, 6281, 6546, 4687, 3113, 1488, -141, -1765, -3391, -5019, -6644, -8193, -10228, -7225, -4979, -4541, -3729, -2968, -2206, -1449, -687, 73, 833, 1594, 2355, 3114, 3875, 4636, 5372, 6244, 6497, 4844, 3953, 3030, 2109, 1186, 265, -656, -1580, -2501, -3419, -4322, -5358, -3700, -1706, -159, 1533, 2861, 5993, 8134, 5937, 4308, 2580, 846, -785, -2900, -4187, -1763, 522, 2770, 5310, 6649, 1462, 184, -892, -2018, -3180, -4165, -3326, -2409, -1577, -728, 171, 703, 5603, 6168, 4319, 2984, 1563, 127, -1167, -3094, -5860, -3962, -2050, -160, 1733, 3580, 5755, 4037, 1614, 87, -1621, -3286, -5116, -4942, -3957, -3318, -2609, -1906, -1204, -503, 200, 901, 1612, 2272, 3079, 7873, 6198, 3214, 538, -2122, -7090, -5998, -3086, -579, 1991, 4578, 7218, 3355, 319, -1781, -4028, -6665, -3575, -664, 964, 2254, 1361, 399, -539, -1425, -2638, -2976, -1937, -1067, -117, 475, 2851, 5536, 4159, 3260, 2282, 1305, 329, -665, -1557, -2796, -10021, -9324, -7224, -5460, -3637, -1819, 3, 1857, 3455, 6720, 6500, 3538, 1076, -1469, -4009, -6505, -9334, -7019, -3566, -1019, 1690, 4513, 6741, 5853, 4630, 3496, 2341, 1184, 31, -1124, -2280, -3432, -4554, -5884, -4897, -3439, -2541, -1529, -527, 472, 1470, 2472, 3472, 4465, 5465, 6730, 5733, 4093, 2594, 1038};