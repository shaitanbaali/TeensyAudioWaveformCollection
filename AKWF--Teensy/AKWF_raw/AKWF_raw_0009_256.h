/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0009 256 samples */
 
const int16_t AKWF_raw_0009_256_DATA [256] = 
{267, 820, 1363, 1908, 2451, 2995, 3539, 4298, 3613, 9554, 27927, 26220, 25568, 24790, 23998, 23205, 22416, 21624, 20831, 20041, 19248, 18457, 17667, 16874, 16082, 15293, 14500, 13708, 12918, 12126, 11334, 10543, 9751, 8961, 8169, 7376, 6586, 5795, 5002, 4212, 3420, 2628, 1837, 1045, 254, -535, -1328, -2120, -2910, -3702, -4494, -5285, -6076, -6868, -7657, -8450, -9242, -10033, -10825, -11616, -12406, -13200, -13990, -14781, -15574, -16365, -17155, -17951, -18707, -19644, -20551, -19807, -19057, -18316, -17572, -16827, -16080, -15336, -14590, -13846, -13103, -12356, -11610, -10866, -10119, -9375, -8632, -7885, -7139, -6395, -5649, -4905, -4161, -3414, -2669, -1924, -1178, -435, 309, 1056, 1800, 2545, 3292, 4035, 4781, 5527, 6271, 7017, 7763, 8506, 9252, 9998, 10742, 11488, 12234, 12977, 13723, 14469, 15213, 15959, 16704, 17448, 18194, 18939, 19684, 20430, 21175, 21919, 22665, 23410, 24155, 24902, 25519, 26940, 24756, 13093, 11779, 10106, 8464, 6827, 5189, 3555, 1917, 280, -1353, -2992, -4629, -6263, -7902, -9539, -11172, -12811, -14448, -16092, -17742, -19162, -30453, -31999, -30243, -29229, -28095, -26964, -25832, -24699, -23568, -22435, -21301, -20171, -19038, -17904, -16772, -15639, -14506, -13374, -12241, -11108, -9976, -8842, -7708, -6577, -5442, -4308, -3177, -2042, -909, 222, 1358, 2491, 3623, 4759, 5891, 7025, 8161, 9293, 10426, 11402, 13361, 9936, 3538, 2471, 554, -1236, -3023, -4813, -6605, -8393, -10185, -11978, -13766, -15560, -17353, -19142, -20937, -22731, -24522, -26317, -28014, -30314, -30001, -19852, -19281, -18780, -18220, -17677, -17132, -16588, -16044, -15500, -14957, -14413, -13867, -13324, -12780, -12235, -11693, -11149, -10603, -10060, -9516, -8972, -8429, -7885, -7340, -6797, -6253, -5708, -5166, -4620, -4075, -3532, -2988, -2444, -1901, -1357, -814, -261};