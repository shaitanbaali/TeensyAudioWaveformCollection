/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0008 256 samples */
 
const int16_t AKWF_raw_0008_256_DATA [256] = 
{730, 2681, 4592, 6508, 8423, 10340, 12260, 14175, 16151, 17681, 25779, 26699, 24271, 22565, 20740, 18914, 17094, 15268, 13443, 11622, 9797, 7972, 6151, 4326, 2501, 680, -1145, -2969, -4790, -6617, -8439, -10261, -12088, -13612, -17007, -7925, 474, 158, 1482, 2552, 3623, 4697, 5766, 6839, 7911, 8981, 10054, 11126, 12196, 13268, 14340, 15410, 16483, 17555, 18625, 19697, 20770, 21839, 22913, 23984, 25036, 26068, 27554, 13012, 8870, 9113, 8378, 7787, 7198, 6609, 6017, 5429, 4839, 4249, 3659, 3069, 2478, 1890, 1299, 710, 109, -682, 43, -26092, -32799, -29636, -28623, -27277, -25933, -24591, -23244, -21902, -20559, -19214, -17871, -16528, -15182, -13840, -12498, -11151, -9809, -8466, -7120, -5779, -4434, -3088, -1747, -403, 941, 2283, 3627, 4972, 6319, 7739, 8554, 21044, 23392, 21191, 19985, 18621, 17259, 15898, 14534, 13172, 11812, 10447, 9086, 7725, 6361, 4999, 3638, 2274, 913, -448, -1812, -3172, -4534, -5898, -7258, -8621, -9985, -11345, -12707, -14071, -15431, -16795, -18157, -19517, -20881, -22244, -23604, -24968, -26330, -27691, -28944, -30801, -30409, -4917, -1276, -814, 442, 1569, 2697, 3827, 4954, 6082, 7213, 8339, 9467, 10597, 11723, 12852, 13982, 15108, 16238, 17367, 18493, 19623, 20752, 21593, 24261, 12054, 4527, 5272, 4361, 3702, 3043, 2384, 1726, 1066, 408, -250, -910, -1809, -1096, -7665, -30404, -28296, -27091, -25812, -24509, -23205, -21904, -20601, -19298, -17999, -16697, -15394, -14096, -12794, -11493, -10196, -8896, -7595, -6299, -4999, -3700, -2405, -1105, 191, 1487, 2840, 3812, 6253, 18460, 17184, 14704, 12543, 10328, 8109, 5887, 3672, 1453, -768, -2982, -5202, -7424, -9638, -11859, -14080, -16293, -18514, -20735, -22949, -24960, -28271, -24880, -15715, -14747, -12665, -10745, -8829, -6914, -4997, -3086, -1136};