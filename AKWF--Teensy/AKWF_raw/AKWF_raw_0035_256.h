/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0035 256 samples */
 
const int16_t AKWF_raw_0035_256_DATA [256] = 
{5272, 31819, 29379, 27703, 25994, 24247, 22492, 20736, 18973, 17202, 15432, 13654, 11868, 10082, 8289, 6488, 4688, 2912, 941, 724, 2200, 3487, 4816, 6160, 7512, 8872, 10244, 11623, 13015, 14419, 15762, 17099, 18441, 19779, 21118, 22461, 23801, 25143, 26488, 27829, 28692, 32373, 22444, -9771, -15536, -12914, -11735, -10248, -8765, -7278, -5792, -4309, -2841, -1281, -175, -834, -1634, -2398, -3172, -3945, -4719, -5493, -6266, -7040, -7814, -8587, -9361, -10134, -10908, -11682, -12456, -13229, -13767, -15822, -10330, 1127, -550, 1576, 4255, 2853, 1989, 990, 204, 1278, 3163, 1901, -14970, -18533, -16997, -16604, -16029, -15455, -14881, -14306, -13732, -13158, -12582, -12008, -11434, -10858, -10285, -9710, -9134, -8561, -7987, -7412, -6837, -6263, -5688, -5114, -4539, -3964, -3390, -2816, -2241, -1667, -1112, -457, -291, -2043, -3946, -5807, -7683, -9556, -11427, -13228, -15170, -17354, 4323, 32907, 29978, 28284, 26490, 24663, 22831, 21005, 19176, 17345, 15520, 13689, 11859, 10034, 8203, 6374, 4548, 2753, 764, 574, 2112, 3447, 4816, 6190, 7561, 8930, 10304, 11676, 13045, 14419, 15790, 17159, 18533, 19904, 21274, 22647, 24018, 25389, 26762, 28132, 29018, 32757, 22697, -9789, -15514, -12901, -11723, -10237, -8755, -7271, -5786, -4305, -2837, -1279, -172, -816, -1600, -2346, -3104, -3861, -4618, -5376, -6132, -6889, -7647, -8404, -9160, -9918, -10674, -11431, -12189, -12946, -13673, -14507, -15141, -1845, 166, 1457, 4221, 2829, 1973, 982, 201, 1276, 2945, 2643, -7323, -19310, -17054, -16795, -16213, -15631, -15051, -14469, -13889, -13308, -12726, -12145, -11564, -10983, -10402, -9821, -9239, -8659, -8078, -7496, -6915, -6334, -5753, -5173, -4591, -4009, -3429, -2847, -2265, -1686, -1124, -463, -291, -2038, -3937, -5794, -7666, -9536, -11403, -13273, -15136, -17038};