/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0021 256 samples */
 
const int16_t AKWF_raw_0021_256_DATA [256] = 
{284, 729, 1164, 1601, 2037, 2474, 2912, 3348, 3785, 4223, 4659, 5096, 5534, 5970, 6407, 6844, 7281, 7719, 8156, 8592, 9029, 9466, 9903, 10340, 10778, 11214, 11652, 12088, 12525, 12962, 13399, 13836, 14273, 14710, 15147, 15584, 16021, 16458, 16896, 17332, 17769, 18206, 18643, 19080, 19517, 19953, 20391, 20828, 21264, 21702, 22139, 22575, 23013, 23450, 23886, 24323, 24761, 25197, 25635, 26072, 26508, 26945, 27383, 27820, 28257, 28693, 29130, 29023, 32370, 16690, -2548, 33, -870, -1228, -1585, -1941, -2299, -2655, -3013, -3552, -2912, -7298, -32198, -32040, -31211, -30641, -30011, -29379, -28746, -28116, -27483, -26852, -26222, -25589, -24958, -24327, -23694, -23063, -22432, -21800, -21169, -20537, -19905, -19274, -18642, -18010, -17379, -16748, -16115, -15485, -14853, -14221, -13590, -12958, -12326, -11695, -11063, -10432, -9801, -9169, -8537, -7906, -7274, -6642, -6012, -5379, -4748, -4116, -3484, -2853, -2222, -1442, -1578, 1993, 29130, 30172, 29139, 28678, 28112, 27545, 26978, 26413, 25846, 25279, 24713, 24146, 23579, 23014, 22447, 21880, 21314, 20746, 20181, 19615, 19048, 18482, 17915, 17348, 16782, 16215, 15648, 15082, 14517, 13950, 13384, 12817, 12250, 11684, 11117, 10550, 9984, 9418, 8851, 8285, 7718, 7151, 6586, 6019, 5452, 4886, 4319, 3752, 3186, 2620, 2053, 1488, 920, 354, -211, -778, -1345, -1911, -2478, -3043, -3610, -4177, -4743, -5309, -5877, -6443, -7009, -7576, -8142, -8708, -9275, -9841, -10408, -10975, -11541, -12107, -12674, -13240, -13807, -14374, -14939, -15506, -16073, -16639, -17206, -17772, -18338, -18905, -19472, -20037, -20605, -21171, -21737, -22304, -22870, -23436, -24004, -24570, -25136, -25703, -26268, -26835, -27402, -27968, -28535, -29102, -29668, -30234, -30801, -31036, -33444, -25626, -2731, -3925, -3207, -2768, -2331, -1894, -1458, -1020, -585, -141};