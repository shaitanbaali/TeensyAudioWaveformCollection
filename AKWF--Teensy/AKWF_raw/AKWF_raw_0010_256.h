/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0010 256 samples */
 
const int16_t AKWF_raw_0010_256_DATA [256] = 
{29877, 28589, 27329, 26066, 24802, 23538, 22271, 21009, 19745, 18478, 17216, 15951, 14684, 13423, 12157, 10891, 9630, 8364, 7098, 5836, 4570, 3305, 2043, 776, -487, -1749, -3017, -4280, -5544, -6810, -8073, -9337, -10603, -11866, -13130, -14396, -15660, -16923, -18248, -19178, -21752, -32034, -31221, -29844, -28640, -27402, -26160, -24918, -23679, -22438, -21197, -19958, -18715, -17475, -16236, -14994, -13753, -12514, -11272, -10032, -8792, -7549, -6309, -5070, -3828, -2588, -1348, -106, 1132, 2372, 3616, 4854, 6095, 7337, 8575, 9817, 11059, 12298, 13539, 14781, 16020, 17262, 18503, 19741, 20984, 22225, 23464, 24706, 25946, 27097, 28792, 27928, 21714, 19695, 17351, 15050, 12744, 10443, 8142, 5836, 3536, 1234, -1071, -3371, -5674, -7979, -10278, -12582, -14886, -17185, -19489, -21794, -24093, -26356, -28797, -30705, -18576, -15792, -15265, -14204, -13222, -12243, -11260, -10279, -9299, -8317, -7336, -6356, -5373, -4392, -3412, -2429, -1449, -468, 514, 1493, 2475, 3458, 4437, 5418, 6400, 7380, 8362, 9344, 10323, 11305, 12287, 13267, 14249, 15231, 16211, 17193, 18174, 19155, 20137, 21228, 21599, 26638, 29405, 27801, 27004, 26079, 25154, 24226, 23301, 22374, 21448, 20523, 19597, 18670, 17744, 16818, 15891, 14967, 14040, 13113, 12189, 11261, 10335, 9411, 8483, 7557, 6632, 5705, 4779, 3854, 2927, 2001, 1076, 148, -776, -1701, -2629, -3554, -4480, -5407, -6332, -7258, -8185, -9110, -10036, -10964, -11887, -12814, -13741, -14662, -15457, -17125, -6942, -1124, 735, 3432, 6016, 8599, 11176, 13760, 16341, 18919, 21503, 23557, 28924, 13186, -1526, 296, -915, -1656, -2391, -3129, -3933, -1388, -428, -208, 175, 538, 913, 175, -192, -365, -733, 31, -16870, -21128, -18495, -17355, -15981, -14609, -13239, -11866, -10493, -9124, -7750, -6378, -5008, -3636, -2269, -873};