/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0007 256 samples */
 
const int16_t AKWF_raw_0007_256_DATA [256] = 
{780, 1912, 3023, 4137, 5250, 6364, 7479, 8591, 9706, 10821, 12233, 11697, 25695, 32885, 29820, 28759, 27387, 26010, 24633, 23260, 21883, 20506, 19133, 17756, 16380, 15006, 13629, 12254, 10880, 9503, 8128, 6753, 5376, 4002, 2626, 1249, -124, -1499, -2877, -4250, -5626, -7003, -8376, -9752, -11130, -12503, -13879, -15255, -16627, -18004, -19381, -20753, -22131, -23443, -25128, -25231, -17661, -15706, -13949, -12125, -10314, -8498, -6687, -4875, -3061, -1249, 561, 2377, 4187, 6000, 7815, 9625, 11438, 13253, 15063, 16877, 18691, 20501, 22315, 24130, 25938, 27687, 29742, 30825, 10592, 6852, 6656, 5614, 4702, 3791, 2879, 1966, 1057, 143, -767, -1677, -2591, -3501, -4412, -5326, -6236, -7148, -8060, -8971, -9882, -10795, -11705, -12617, -13530, -14440, -15352, -16158, -17616, -15270, -11677, -11281, -10335, -9474, -8615, -7753, -6893, -6033, -5170, -4309, -3450, -2588, -1728, -868, -5, 854, 1714, 2576, 3436, 4297, 5160, 6019, 6878, 7730, 9076, 8801, 8080, 7459, 6820, 6181, 5546, 4910, 4275, 3643, 3009, 2377, 1747, 1116, 487, -138, -765, -1392, -2016, -2641, -3263, -3885, -4502, -5119, -5730, -6330, -6930, -7528, -8123, -8717, -9309, -9900, -10487, -11028, -11862, -9050, -7458, -7139, -6553, -6003, -5454, -4906, -4356, -3806, -3258, -2709, -2159, -1612, -1062, -513, 35, 584, 1133, 1682, 2232, 2781, 3330, 3879, 4427, 4976, 5526, 6075, 6624, 7173, 7721, 8341, 8490, 11022, 14094, 12732, 11947, 11068, 10188, 9311, 8432, 7552, 6675, 5795, 4916, 4039, 3160, 2281, 1403, 524, -354, -1232, -2111, -2989, -3868, -4747, -5626, -6702, -6431, -22102, -27013, -24588, -23713, -22599, -21484, -20371, -19257, -18142, -17030, -15915, -14800, -13688, -12573, -11458, -10346, -9231, -8116, -7004, -5888, -4775, -3662, -2548, -1438, -305};