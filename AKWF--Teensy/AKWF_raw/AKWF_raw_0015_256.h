/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0015 256 samples */
 
const int16_t AKWF_raw_0015_256_DATA [256] = 
{67, 247, 424, 601, 777, 953, 1130, 1308, 1484, 1661, 1837, 2015, 2192, 2368, 2544, 2722, 2899, 3075, 3252, 3430, 3606, 3783, 3959, 4137, 4314, 4489, 4667, 4844, 5021, 5197, 5373, 5551, 5728, 5905, 6081, 6259, 6435, 6612, 6788, 6966, 7143, 7319, 7495, 7673, 7850, 8026, 8203, 8380, 8557, 8734, 8910, 9087, 9265, 9441, 9617, 9794, 9972, 10148, 10325, 10502, 10679, 10856, 11032, 11209, 11387, 11348, 12671, 4857, -1388, -908, -1694, -2283, -2873, -3463, -4053, -4642, -5232, -5820, -6411, -7001, -7590, -8180, -8770, -9358, -9948, -10539, -11127, -11717, -12307, -12692, -14401, -4240, 877, -193, 0, 0, 0, 0, 0, 0, 0, 102, -480, 6846, 9533, 8715, 8637, 8450, 8254, 8048, 7842, 7638, 7434, 7228, 7023, 6820, 6615, 6411, 6207, 6003, 5798, 5594, 5391, 5187, 4983, 4779, 4577, 4374, 4169, 3967, 3765, 3561, 3358, 3156, 2954, 2752, 2549, 2346, 2145, 1944, 1742, 1541, 1339, 1137, 935, 733, 367, 1159, -2367, -29922, -24097, -17458, -11221, -4448, -348, -1999, -3557, -5111, -6677, -8243, -9813, -11379, -12945, -14515, -16080, -17648, -19217, -20782, -22350, -23919, -25484, -27053, -28424, -30902, -29286, 2994, -7641, -15363, -13445, -13544, -13368, -13190, -13014, -12837, -12660, -12483, -12306, -12130, -11953, -11776, -11599, -11423, -11246, -11068, -10892, -10715, -10539, -10361, -10184, -10008, -9832, -9654, -9477, -9301, -9124, -8947, -8770, -8593, -8417, -8240, -8062, -7886, -7710, -7533, -7355, -7179, -7002, -6826, -6648, -6471, -6295, -6118, -5941, -5764, -5587, -5411, -5234, -5057, -4880, -4704, -4526, -4350, -4173, -3997, -3819, -3642, -3466, -3290, -3111, -2935, -2759, -2582, -2405, -2228, -2051, -1875, -1697, -1520, -1344, -1168, -990, -813, -637, -461, -284, -103};