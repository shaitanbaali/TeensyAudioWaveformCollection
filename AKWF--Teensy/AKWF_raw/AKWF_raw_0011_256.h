/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0011 256 samples */
 
const int16_t AKWF_raw_0011_256_DATA [256] = 
{31481, 26698, 22010, 17310, 12614, 7912, 3203, -1491, -6194, -10978, -15155, -22908, -23892, -18115, -13497, -8677, -3869, 950, 5770, 10578, 15399, 20126, 25339, 28526, 18853, 14831, 11282, 7607, 3951, 286, -3372, -7029, -10694, -14351, -17834, -22390, -21783, -12380, -10307, -7512, -4813, -2111, 582, 3281, 5983, 8677, 11376, 13894, 17513, 14730, 8585, 7320, 5224, 3251, 1283, -691, -2663, -4632, -6607, -8579, -10434, -13003, -9297, -5778, -4788, -3286, -1857, -426, 1001, 2430, 3862, 5290, 6711, 8144, 9629, 6214, 4453, 3578, 2503, 1454, 407, -641, -1690, -2737, -3786, -4807, -5981, -6517, -3599, -2763, -2033, -1271, -515, 243, 999, 1756, 2514, 3271, 3989, 4945, 4756, 2678, 2257, 1671, 1108, 543, -20, -583, -1147, -1710, -2270, -2839, -3404, -2346, -1739, -1379, -962, -553, -144, 265, 674, 1083, 1493, 1902, 2282, 2843, 1786, 929, 757, 447, 156, -134, -425, -715, -1007, -1297, -1574, -1935, -1887, -1211, -1049, -830, -619, -408, -197, 13, 224, 434, 646, 845, 1121, 925, 494, 382, 213, 53, -106, -266, -426, -586, -746, -906, -1056, -1267, -879, -578, -506, -387, -275, -162, -49, 63, 175, 287, 395, 532, 521, 290, 222, 134, 49, -35, -119, -204, -289, -374, -460, -538, -657, -516, -308, -278, -215, -158, -100, -42, 15, 73, 131, 188, 244, 314, 224, 138, 101, 56, 11, -33, -77, -123, -167, -212, -256, -303, -343, -209, -159, -133, -101, -70, -40, -9, 21, 52, 83, 112, 147, 161, 90, 67, 43, 19, -4, -27, -51, -74, -98, -121, -475, 1316, -7800, -22091, -18729, -17695, -16294, -14893, -13496, -12094, -10694, -9297, -7895, -6495, -5097, -3698, -2302, -878};