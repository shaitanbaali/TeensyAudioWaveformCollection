/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0018 256 samples */
 
const int16_t AKWF_raw_0018_256_DATA [256] = 
{49, 327, 664, 988, 1316, 1645, 1977, 2307, 2639, 2973, 3308, 3644, 3980, 4315, 4653, 4992, 5332, 5673, 6016, 6357, 6702, 7046, 7391, 7738, 8087, 8433, 8783, 9135, 9490, 9822, 10137, 10455, 10772, 11090, 11405, 11719, 12034, 12349, 12663, 12977, 13287, 13599, 13910, 14221, 14531, 14841, 15149, 15457, 15764, 16071, 16379, 16684, 16988, 17293, 17598, 17902, 18203, 18504, 18807, 19108, 19409, 19708, 20006, 20305, 20602, 20901, 21196, 21493, 21787, 22082, 22378, 22671, 22964, 23256, 23547, 23838, 24129, 24421, 24710, 24998, 25286, 25573, 25860, 26146, 26431, 26716, 27001, 27286, 27570, 27851, 28133, 28415, 28695, 28974, 29307, 28951, 31644, 23593, -16543, -32874, -28691, -28236, -27103, -26004, -24896, -23793, -22691, -21584, -20476, -19372, -18266, -17164, -16059, -14952, -13845, -12740, -11638, -10533, -9427, -8321, -7215, -6109, -5009, -3904, -2788, -1820, -136, -1741, -8348, -14235, -20700, -25612, -24125, -22883, -21790, -20638, -19489, -18345, -17201, -16051, -14901, -13757, -12607, -11464, -10318, -9170, -8021, -6873, -5727, -4584, -3413, -2597, -284, -1434, -26466, -28099, -25863, -25188, -24151, -23140, -22130, -21115, -20101, -19087, -18074, -17065, -16049, -15037, -14023, -13007, -11997, -10986, -9970, -8958, -7944, -6929, -5920, -4907, -3895, -2837, -1937, -1081, 7149, 6826, 3091, 404, -2521, -5406, -8300, -11205, -14105, -17017, -19680, -22913, -26464, 982, 32959, 31563, 30860, 30191, 29392, 28597, 27807, 27016, 26220, 25428, 24633, 23837, 23049, 22256, 21460, 20668, 19872, 19080, 18291, 17495, 16700, 15907, 15111, 14321, 13530, 12734, 11941, 11148, 10351, 9563, 8769, 7974, 7182, 6387, 5594, 4803, 4009, 3214, 2421, 1627, 836, 45, -748, -1543, -2336, -3131, -3880, -4892, -4456, -3424, -3236, -2875, -2542, -2208, -1872, -1540, -1206, -871, -538, -191};