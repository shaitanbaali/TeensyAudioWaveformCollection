/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0026 256 samples */
 
const int16_t AKWF_raw_0026_256_DATA [256] = 
{210, 564, 911, 1258, 1606, 1953, 2302, 2649, 2997, 3346, 3692, 4041, 4389, 4736, 5085, 5433, 5780, 6128, 6476, 6824, 7172, 7520, 7867, 8215, 8564, 8911, 9259, 9607, 9954, 10303, 10650, 10998, 11347, 11694, 12042, 12390, 12738, 13086, 13433, 13781, 14128, 14477, 14825, 15173, 15521, 15868, 16216, 16564, 16912, 17261, 17607, 17955, 18303, 18652, 18999, 19347, 19696, 20042, 20391, 20739, 21086, 21435, 21782, 22129, 22478, 22826, 23174, 23521, 23869, 24217, 24565, 24913, 25260, 25609, 25956, 26304, 26653, 27000, 27349, 27696, 28043, 28392, 28740, 29088, 29435, 29783, 30131, 30479, 30827, 31174, 31523, 31871, 32206, 32601, 32639, 31711, 30707, 29723, 28736, 27748, 26764, 25780, 24795, 23814, 22834, 21853, 20876, 19899, 18923, 17951, 16977, 16003, 15033, 14063, 13095, 12128, 11161, 10196, 9235, 8271, 7310, 6352, 5392, 4434, 3479, 2522, 1569, 618, -335, -1284, -2233, -3182, -4126, -5072, -6017, -6958, -7900, -8842, -9779, -10718, -11656, -12589, -13525, -14458, -15391, -16310, -17226, -18107, -18946, -19788, -20623, -21456, -22285, -23108, -23931, -24748, -25559, -26370, -27175, -27979, -28767, -29574, -32107, -32225, -31765, -31440, -31091, -30744, -30396, -30048, -29701, -29352, -29004, -28657, -28309, -27961, -27613, -27265, -26917, -26570, -26222, -25873, -25526, -25178, -24830, -24483, -24134, -23787, -23439, -23091, -22743, -22395, -22048, -21699, -21352, -21004, -20656, -20309, -19960, -19613, -19265, -18916, -18570, -18221, -17873, -17526, -17177, -16830, -16482, -16134, -15786, -15438, -15090, -14741, -14395, -14047, -13699, -13352, -13003, -12655, -12308, -11959, -11612, -11264, -10916, -10568, -10220, -9873, -9525, -9177, -8828, -8481, -8134, -7785, -7438, -7089, -6741, -6394, -6046, -5698, -5351, -5002, -4655, -4307, -3959, -3611, -3263, -2916, -2567, -2220, -1871, -1524, -1176, -828, -482, -128};