/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0032 256 samples */
 
const int16_t AKWF_raw_0032_256_DATA [256] = 
{197, 705, 1203, 1702, 2201, 2700, 3201, 3700, 4199, 4700, 5198, 5698, 6198, 6697, 7196, 7697, 8195, 8695, 9196, 9694, 10194, 10694, 11193, 11692, 12192, 12691, 13191, 13691, 14189, 14690, 15189, 15689, 16189, 16688, 17187, 17688, 18187, 18686, 19186, 19685, 20184, 20685, 21184, 21683, 22183, 22682, 23311, 23082, 27235, 32505, 30175, 28862, 27384, 25907, 24433, 22954, 21478, 20004, 18525, 17049, 15575, 14096, 12621, 11145, 9667, 8192, 6716, 5238, 3764, 2287, 698, -169, -4018, -23307, -23000, -21557, -20450, -19277, -18102, -16926, -15755, -14578, -13403, -12230, -11054, -9881, -8707, -7531, -6356, -5183, -4008, -2833, -1661, -484, 689, 1862, 3039, 4212, 5386, 6562, 7735, 8910, 10085, 11259, 12433, 13609, 14782, 15957, 17133, 18305, 19480, 20656, 21828, 23005, 24179, 25352, 26528, 27703, 28876, 29553, 33400, 20658, 585, 2790, 1793, 1293, 794, 295, -205, -704, -1203, -1703, -2202, -2701, -3202, -3701, -4200, -4700, -5199, -5699, -6199, -6698, -7197, -7697, -8196, -8696, -9196, -9695, -10195, -10694, -11193, -11693, -12193, -12692, -13192, -13691, -14190, -14691, -15190, -15689, -16189, -16688, -17187, -17688, -18187, -18686, -19187, -19685, -20185, -20685, -21184, -21684, -22183, -22682, -23312, -23083, -27234, -32499, -30167, -28852, -27372, -25893, -24419, -22939, -21462, -19986, -18508, -17032, -15557, -14078, -12603, -11129, -9651, -8178, -6703, -5225, -3754, -2280, -692, 169, 4005, 23308, 23000, 21557, 20449, 19277, 18101, 16926, 15754, 14578, 13402, 12230, 11054, 9880, 8707, 7531, 6356, 5183, 4007, 2832, 1660, 483, -690, -1863, -3040, -4213, -5387, -6563, -7736, -8911, -10086, -11259, -12434, -13609, -14782, -15957, -17134, -18306, -19481, -20657, -21829, -23005, -24180, -25352, -26528, -27703, -28876, -29553, -33400, -20658, -586, -2791, -1794, -1295, -797, -289};