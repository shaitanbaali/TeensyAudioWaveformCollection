/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0004 256 samples */
 
const int16_t AKWF_raw_0004_256_DATA [256] = 
{139, 661, 1170, 1682, 2194, 2705, 3218, 3729, 4242, 4754, 5266, 5777, 6290, 6802, 7314, 7827, 8337, 8850, 9362, 9874, 10386, 10899, 11409, 11922, 12434, 12945, 13459, 13970, 14482, 14994, 15507, 16018, 16531, 17042, 17555, 18067, 18578, 19090, 19603, 20115, 20626, 21139, 21650, 22163, 22675, 23186, 23699, 24212, 24722, 25234, 25747, 26258, 26771, 27283, 27795, 28307, 28819, 29330, 29843, 30355, 30867, 31379, 31879, 32441, 32616, 32075, 31557, 31037, 30516, 29995, 29474, 28954, 28433, 27912, 27393, 26873, 26352, 25833, 25314, 24794, 24276, 23756, 23236, 22719, 22200, 21681, 21165, 20646, 20127, 19611, 19092, 18575, 18058, 17540, 17024, 16508, 15991, 15475, 14958, 14443, 13927, 13411, 12895, 12381, 11865, 11350, 10836, 10321, 9805, 9291, 8777, 8263, 7749, 7235, 6722, 6209, 5694, 5182, 4670, 4156, 3644, 3132, 2619, 2107, 1595, 1084, 572, 62, -449, -961, -1472, -1983, -2493, -3003, -3514, -4023, -4533, -5044, -5552, -6062, -6572, -7080, -7589, -8099, -8606, -9115, -9624, -10131, -10639, -11147, -11654, -12163, -12670, -13176, -13684, -14191, -14697, -15204, -15710, -16215, -16722, -17227, -17733, -18239, -18743, -19249, -19754, -20258, -20763, -21267, -21771, -22276, -22780, -23283, -23788, -24291, -24794, -25298, -25801, -26303, -26806, -27309, -27812, -28292, -28762, -29133, -29500, -29865, -30227, -30593, -30916, -31404, -32563, -32125, -31591, -31085, -30574, -30062, -29549, -29038, -28525, -28013, -27502, -26990, -26477, -25966, -25453, -24940, -24430, -23917, -23405, -22893, -22381, -21869, -21358, -20845, -20333, -19822, -19309, -18797, -18285, -17774, -17261, -16750, -16237, -15725, -15214, -14701, -14190, -13677, -13165, -12653, -12142, -11628, -11118, -10606, -10093, -9582, -9069, -8557, -8045, -7534, -7021, -6510, -5997, -5485, -4973, -4461, -3949, -3438, -2925, -2413, -1902, -1390, -880, -359};