/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0016 256 samples */
 
const int16_t AKWF_raw_0016_256_DATA [256] = 
{-1489, 23725, 33068, 29130, 27957, 26357, 24755, 23157, 21557, 19955, 18357, 16757, 15155, 13558, 11956, 10355, 8758, 7156, 5554, 3957, 2356, 755, -842, -2443, -4044, -5641, -7244, -8844, -10442, -12044, -13643, -15242, -16844, -18443, -20041, -21645, -23243, -24842, -26445, -28039, -29293, -32845, -8617, 1922, 1344, 3114, 4537, 5962, 7381, 8805, 10229, 11648, 13072, 14496, 15915, 17339, 18762, 20182, 21607, 23029, 24449, 25874, 27295, 28688, 30097, 31898, 12620, 7639, 8102, 7340, 6760, 6181, 5601, 5020, 4442, 3862, 3283, 2704, 2124, 1544, 965, 380, -170, -850, -2401, -2013, -1415, -871, -316, 237, 792, 1346, 1900, 2455, 3010, 3565, 4121, 4675, 5229, 5784, 6338, 6893, 7448, 7923, 8894, 6376, 4151, 4120, 3667, 3279, 2890, 2502, 2114, 1725, 1336, 949, 560, 171, -217, -605, -994, -1382, -1806, -1995, -3436, -4695, -4027, -3651, -3226, -2802, -2378, -1953, -1529, -1106, -681, -257, 166, 590, 1014, 1438, 1863, 2286, 2711, 3135, 3558, 3961, 4504, 3037, 2189, 1952, 1584, 1234, 885, 535, 185, -164, -512, -862, -1213, -1562, -1912, -2261, -2611, -2961, -3310, -3660, -4087, -4014, -6747, -9200, -8280, -7914, -7459, -7005, -6550, -6095, -5642, -5187, -4732, -4278, -3823, -3369, -2915, -2460, -2005, -1551, -1096, -642, -188, 266, 721, 1174, 1603, 2192, 1914, 825, 495, 52, -374, -801, -1228, -1655, -2081, -2508, -2936, -3362, -3789, -4217, -4643, -5070, -5498, -5924, -6351, -6777, -7204, -7631, -8239, -7654, -12309, -32593, -31520, -30603, -29753, -28868, -27983, -27098, -26214, -25327, -24444, -23558, -22672, -21789, -20903, -20017, -19134, -18247, -17362, -16478, -15592, -14707, -13823, -12938, -12052, -11169, -10283, -9397, -8513, -7627, -6742, -5858, -4971, -4087, -3203, -2318, -1436, -536};