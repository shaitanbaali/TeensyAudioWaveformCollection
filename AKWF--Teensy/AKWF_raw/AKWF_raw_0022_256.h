/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0022 256 samples */
 
const int16_t AKWF_raw_0022_256_DATA [256] = 
{215, 1015, 1800, 2586, 3372, 4159, 4947, 5733, 6520, 7308, 8093, 8881, 9669, 10454, 11241, 12029, 12814, 13603, 14390, 15176, 15963, 16750, 17536, 18325, 19111, 19897, 20300, 23152, 13029, -1717, 389, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 421, -1865, 10216, 26087, 22658, 22096, 21079, 20063, 19044, 18022, 16999, 15974, 14946, 13918, 12886, 11851, 10819, 9781, 8741, 7702, 6658, 5611, 4567, 3517, 2005, 3439, -12851, -26658, -23283, -22929, -22087, -21240, -20383, -19521, -18652, -17775, -16885, -15994, -15091, -14182, -13274, -12364, -11455, -10545, -9632, -8723, -7810, -6896, -5984, -5070, -4156, -3242, -2326, -1408, -493, 423, 1341, 2258, 3178, 4098, 5016, 5937, 6859, 7780, 8703, 9625, 10547, 11473, 12396, 13321, 14247, 15173, 16099, 17028, 17954, 18883, 19812, 20741, 21671, 22149, 25480, 12635, -2720, -1459, -2962, -4034, -5103, -6176, -7248, -8316, -9388, -10460, -11529, -12601, -13672, -14742, -15814, -16885, -17954, -19027, -20097, -21167, -22239, -23078, -25435, -20974, 547, -87, -21, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -91, 291, -925, -29415, -31860, -29520, -28333, -26961, -25593, -24219, -22847, -21478, -20105, -18733, -17363, -15990, -14620, -13249, -11876, -10506, -9134, -7761, -6392, -5020, -3520, -2846, 1275, 21588, 21246, 19946, 18947, 17888, 16825, 15762, 14703, 13640, 12577, 11518, 10454, 9393, 8333, 7269, 6208, 5147, 4084, 3024, 1962, 898, -161, -1223, -2285, -3345, -4408, -5471, -6530, -7592, -8655, -9715, -10778, -11840, -12900, -13962, -15025, -16085, -17147, -18210, -19271, -20332, -21395, -22455, -23517, -24580, -25640, -26703, -27765, -28824, -29886, -30945, -32024};