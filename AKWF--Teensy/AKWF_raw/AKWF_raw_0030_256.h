/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0030 256 samples */
 
const int16_t AKWF_raw_0030_256_DATA [256] = 
{138, 523, 901, 1279, 1657, 2036, 2415, 2792, 3170, 3549, 3926, 4305, 4683, 5061, 5439, 5817, 6195, 6572, 6950, 7328, 7705, 8083, 8460, 8838, 9215, 9591, 9969, 10346, 10722, 11100, 11477, 11853, 12231, 12607, 12983, 13360, 13737, 14113, 14489, 14866, 15242, 15618, 15994, 16370, 16746, 17122, 17498, 17874, 18249, 18624, 19000, 19375, 19751, 20127, 20501, 20877, 21253, 21627, 22002, 22378, 22752, 23127, 23502, 23877, 24252, 24626, 25001, 25375, 25750, 26124, 26498, 26871, 27246, 27621, 27994, 28368, 28743, 29115, 29490, 29863, 30237, 30611, 30984, 30878, 33865, 11414, -1062, 1119, 361, 55, -252, -558, -865, -1171, -1478, -1785, -2091, -2398, -2705, -3011, -3318, -3624, -3931, -4237, -4544, -4851, -5158, -5464, -6199, -4202, -18022, -31363, -28211, -27865, -27075, -26287, -25496, -24707, -23919, -23128, -22338, -21550, -20759, -19970, -19182, -18391, -17602, -16813, -16022, -15234, -14444, -13654, -12865, -12076, -11285, -10497, -9707, -8916, -8129, -7339, -6548, -5760, -4970, -4179, -3392, -2601, -1812, -1007, -49, -424, 26458, 33425, 30967, 30574, 29865, 29157, 28451, 27741, 27033, 26326, 25617, 24910, 24202, 23493, 22786, 22078, 21369, 20662, 19954, 19246, 18538, 17830, 17121, 16414, 15706, 14998, 14291, 13582, 12874, 12167, 11458, 10750, 10043, 9334, 8626, 7919, 7210, 6502, 5795, 5086, 4378, 3671, 2962, 2254, 1547, 838, 131, -576, -1285, -1992, -2700, -3409, -4115, -4824, -5533, -6239, -6948, -7656, -8363, -9072, -9780, -10487, -11195, -11904, -12611, -13320, -14028, -14735, -15444, -16152, -16858, -17568, -18275, -18983, -19692, -20399, -21106, -21815, -22522, -23230, -23939, -24646, -25354, -26063, -26770, -27478, -28045, -29497, -27240, -6808, -5766, -5606, -5166, -4784, -4401, -4018, -3636, -3252, -2869, -2486, -2103, -1719, -1337, -954, -573, -183};