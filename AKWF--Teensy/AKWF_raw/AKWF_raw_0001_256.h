/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0001 256 samples */
 
const int16_t AKWF_raw_0001_256_DATA [256] = 
{29667, 29365, 29060, 28745, 28423, 28091, 27750, 27401, 27043, 26676, 26301, 25917, 25524, 25124, 24714, 24293, 23867, 23431, 22985, 22533, 22070, 21601, 21109, 20629, 20150, 19664, 19178, 18693, 18209, 17723, 17238, 16754, 16268, 15783, 15299, 14813, 14328, 13844, 13358, 12874, 12388, 11902, 11418, 10934, 10448, 9963, 9478, 8993, 8508, 8023, 7537, 7053, 6568, 6083, 5598, 5112, 4628, 4143, 3658, 3172, 2688, 2202, 1718, 1233, 747, 263, -221, -707, -1191, -1677, -2162, -2646, -3131, -3617, -4101, -4586, -5072, -5556, -6041, -6527, -7011, -7496, -7982, -8467, -8952, -9437, -9921, -10407, -10892, -11376, -11861, -12347, -12831, -13317, -13802, -14286, -14772, -15257, -15741, -16227, -16711, -17196, -17682, -18166, -18651, -19137, -19621, -20107, -20592, -21076, -21561, -22047, -22531, -23017, -23502, -23986, -24472, -24957, -25441, -25927, -26412, -26897, -27382, -27867, -28351, -28373, -31289, -19842, 21084, 21147, 20322, 19944, 19432, 18920, 18407, 17896, 17384, 16871, 16360, 15847, 15335, 14824, 14312, 13799, 13288, 12775, 12263, 11751, 11240, 10727, 10216, 9704, 9191, 8680, 8167, 7656, 7144, 6631, 6119, 5607, 5095, 4583, 4072, 3559, 3048, 2535, 2023, 1511, 1000, 487, -24, -535, -1049, -1559, -2072, -2584, -3095, -3608, -4121, -4631, -5144, -5656, -6167, -6680, -7192, -7704, -8216, -8728, -9239, -9808, -9956, -13523, 7810, 10763, 9399, 9020, 8509, 7997, 7485, 6973, 6461, 5948, 5437, 4924, 4412, 3901, 3389, 2876, 2365, 1853, 1340, 830, 316, -195, -707, -1219, -1731, -2242, -2755, -3267, -3778, -4291, -4803, -5315, -5827, -6339, -6850, -7363, -7875, -8386, -8899, -9410, -9923, -10435, -10947, -11458, -11972, -12482, -12995, -13507, -14019, -14531, -15044, -15554, -16067, -16579, -17090, -17604, -18115, -18627, -19139, -19651, -20163, -20864, -20355, -26341};