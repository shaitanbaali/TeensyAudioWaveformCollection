/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0020 256 samples */
 
const int16_t AKWF_raw_0020_256_DATA [256] = 
{351, 1045, 1725, 2408, 3089, 3771, 4455, 5137, 5820, 6503, 7184, 7867, 8551, 9232, 9915, 10599, 11402, 11369, 15286, 23631, 21041, 19314, 17462, 15603, 13745, 11890, 10031, 8175, 6319, 4460, 2604, 748, -1110, -2965, -4822, -6681, -8535, -10393, -12253, -14106, -15964, -17588, -20650, -15605, -6972, -5685, -3186, -870, 1439, 3756, 6072, 8383, 10700, 13016, 15326, 17659, 19852, 22632, 27564, 25527, 23010, 20626, 18215, 15805, 13390, 10979, 8568, 6152, 3742, 1330, -1084, -3707, -4795, -13037, -28938, -19772, -12183, -4393, 3428, 10943, 20262, 19136, 9922, 7631, 4177, 888, -2395, -5688, -8977, -12261, -15554, -18842, -22117, -25359, -28992, -22860, -20277, -20050, -19304, -18630, -17957, -17284, -16608, -15935, -15262, -14587, -13914, -13240, -12566, -11893, -11219, -10545, -9872, -9197, -8523, -7851, -7176, -6502, -5830, -5155, -4481, -3808, -3134, -2459, -1786, -1112, -439, 234, 908, 1581, 2255, 2930, 3603, 4276, 4951, 5624, 6298, 6972, 7646, 8319, 8993, 9667, 10341, 11015, 11800, 11813, 15476, 23137, 20638, 18944, 17134, 15315, 13499, 11686, 9867, 8053, 6239, 4421, 2606, 792, -1026, -2840, -4654, -6473, -8286, -10102, -11919, -13733, -15548, -17138, -20125, -15227, -6822, -5553, -3106, -837, 1426, 3695, 5964, 8227, 10497, 12765, 15029, 17323, 19427, 22308, 29470, 27488, 24713, 22147, 19543, 16940, 14331, 11727, 9122, 6513, 3911, 1305, -1303, -4258, -4832, -23042, -26875, -15682, -7407, 1320, 9779, 19964, 21519, 10104, 7982, 4761, 1689, -1374, -4425, -7479, -10524, -13560, -16580, -19606, -22585, -25373, -29285, -27122, -20810, -20944, -20117, -19434, -18752, -18069, -17386, -16705, -16021, -15338, -14657, -13973, -13290, -12609, -11926, -11242, -10562, -9879, -9195, -8513, -7831, -7148, -6466, -5783, -5100, -4419, -3735, -3053, -2370, -1688, -1008, -314};