/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_raw_0028 256 samples */
 
const int16_t AKWF_raw_0028_256_DATA [256] = 
{949, 2710, 4436, 6167, 7895, 9635, 11314, 13203, 18707, 17718, 15579, 13715, 11799, 9888, 7973, 6057, 4147, 2232, 317, -1592, -3508, -5422, -7333, -9249, -11163, -13074, -14954, -17008, -18438, -11061, -9474, -8952, -8171, -7429, -6688, -5945, -5203, -4461, -3718, -2977, -2234, -1491, -750, -7, 735, 1476, 2219, 2961, 3703, 4445, 5188, 5929, 6672, 7415, 8155, 8899, 9641, 10382, 11126, 11867, 12609, 13352, 14094, 14835, 15579, 16320, 17062, 17710, 18914, 17906, 350, -2427, -3768, -5490, -6771, -10488, -380, 20319, 17418, 16517, 15338, 14149, 12960, 11774, 10584, 9395, 8208, 7019, 5830, 4644, 3454, 2266, 1049, 46, -2012, -3983, -3075, -2483, -1839, -1195, -552, 91, 734, 1377, 2021, 2665, 3308, 3952, 4597, 5239, 5883, 6528, 7169, 7814, 8459, 9101, 9745, 10389, 11031, 11676, 12320, 12963, 13607, 14251, 14894, 15538, 16181, 16825, 17468, 18020, 19135, 16543, 13201, 12135, 10643, 9217, 7790, 6361, 4935, 3506, 2077, 652, -1220, -189, -13931, -33993, -29782, -28782, -27275, -25771, -24272, -22769, -21270, -19773, -18273, -16777, -15284, -13788, -12297, -10817, -9308, -7815, -6322, -4826, -3335, -1844, -351, 1136, 2625, 4115, 5599, 7086, 8572, 9950, 11974, 11047, 2838, 1082, -1010, -3060, -5114, -7166, -9214, -11269, -13321, -15369, -17424, -19475, -21523, -23577, -25628, -27655, -29678, -32110, -16863, -11882, -11288, -9711, -8275, -6844, -5410, -3975, -2543, -1109, 387, 1459, 4339, 14088, 13515, 12660, 11912, 11139, 10363, 9589, 8816, 8041, 7266, 6494, 5717, 4944, 4170, 3396, 2621, 1848, 1072, 299, -474, -1249, -2022, -2797, -3573, -4346, -5120, -5895, -6668, -7443, -8218, -8991, -9765, -10540, -11313, -12105, -12785, -13884, -19251, -18210, -16303, -14609, -12877, -11149, -9415, -7684, -5955, -4225, -2498, -736};