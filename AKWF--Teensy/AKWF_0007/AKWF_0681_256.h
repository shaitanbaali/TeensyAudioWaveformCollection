/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0681 256 samples */
 
const int16_t AKWF_0681_256_DATA [256] = 
{594, 1808, 3186, 4703, 6287, 8016, 9738, 11570, 13325, 15096, 16822, 18385, 19788, 21033, 21802, 22234, 22298, 21992, 21212, 20262, 19047, 17854, 16439, 15131, 13842, 12674, 11788, 11116, 10813, 10909, 11334, 12032, 12994, 14032, 14956, 15847, 16445, 16617, 16607, 16353, 15878, 15520, 15190, 14964, 14898, 14827, 14591, 14193, 13639, 12876, 12149, 11376, 10515, 9620, 8784, 7990, 7115, 6097, 4810, 3301, 1719, 63, -1424, -2728, -3600, -4303, -4693, -4973, -5057, -5039, -4760, -4378, -3802, -3105, -2119, -985, 583, 2343, 4253, 6265, 8396, 10435, 12444, 14169, 15666, 16643, 17176, 17014, 16308, 15171, 13725, 11928, 10057, 8118, 6267, 4721, 3424, 2294, 1563, 1053, 545, 49, -612, -1420, -2272, -3061, -3898, -4547, -5086, -5329, -5405, -5263, -4933, -4477, -3840, -3075, -2331, -1544, -687, 233, 1317, 2648, 4140, 5629, 7083, 8542, 9865, 11056, 12167, 13262, 14353, 15453, 16350, 17130, 17612, 17914, 17999, 17700, 17278, 16589, 15710, 14680, 13511, 12341, 11252, 10406, 9880, 9516, 9382, 9291, 9150, 8800, 8258, 7313, 6054, 4473, 2635, 747, -1168, -3184, -4893, -6388, -7428, -8161, -8492, -8571, -8428, -8145, -7788, -7530, -7306, -7199, -7149, -7310, -7497, -7893, -8181, -8484, -8805, -9211, -9701, -10108, -10596, -10994, -11390, -11731, -12051, -12384, -12677, -13070, -13494, -13937, -14491, -14936, -15536, -16089, -16492, -16889, -17058, -17137, -16962, -16704, -16403, -16024, -15671, -15300, -15077, -15049, -15215, -15726, -16567, -17743, -19179, -20886, -22607, -24276, -25933, -27567, -28931, -30121, -31083, -31830, -32383, -32723, -32732, -32418, -31779, -30712, -29431, -27717, -25602, -23296, -20782, -18118, -15579, -13012, -10525, -8238, -6046, -3942, -2134, -455, 931, 1907, 2480, 2631, 2358, 1746, 935, 169, -550, -1030, -1197, -1211, -908, -257};