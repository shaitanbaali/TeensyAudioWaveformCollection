/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0617 256 samples */
 
const int16_t AKWF_0617_256_DATA [256] = 
{751, 3341, 5937, 7564, 8661, 9501, 10176, 10766, 10916, 10752, 10591, 10401, 10199, 9988, 9774, 9561, 9351, 9148, 8953, 8770, 8600, 8446, 8312, 8196, 8105, 8042, 8005, 8003, 8038, 8117, 8243, 8427, 8676, 8999, 9405, 9891, 10447, 11065, 11729, 12423, 13134, 13852, 14565, 15270, 15961, 16634, 17290, 17928, 18545, 19144, 19724, 20285, 20832, 21358, 21870, 22370, 22848, 23375, 23483, 25588, 26769, 25902, 25428, 24886, 24339, 23787, 23230, 22666, 22097, 21523, 20941, 20354, 19760, 19161, 18559, 17953, 17346, 16743, 16146, 15566, 15014, 14507, 14080, 13810, 13900, 14194, 14318, 14363, 14418, 14533, 14894, 15236, 15442, 15698, 16045, 16692, 17588, 18090, 18222, 18192, 18064, 17868, 17623, 17340, 17031, 16703, 16361, 16006, 15644, 15276, 14904, 14530, 14157, 13786, 13419, 13059, 12708, 12368, 12042, 11734, 11446, 10956, 11992, 5904, -8783, -8048, -8779, -9325, -9900, -10500, -11127, -11777, -12447, -13137, -13844, -14591, -15007, -15182, -15397, -15608, -15818, -16022, -16217, -16395, -16546, -16654, -16697, -16648, -16461, -16059, -15283, -13636, -11159, -9204, -7727, -6368, -5004, -3244, -1324, 73, 1422, 2860, 4684, 7162, 9006, 9888, 10338, 10551, 10618, 10586, 10484, 10334, 10157, 9962, 9755, 9542, 9328, 9116, 8907, 8707, 8515, 8336, 8173, 8026, 7900, 7485, 9077, 2047, -31177, -33141, -32533, -32617, -32536, -32440, -32329, -32202, -32059, -31899, -31721, -31524, -31308, -31072, -30815, -30537, -30237, -29916, -29573, -29210, -28832, -28438, -28034, -27629, -27226, -26832, -26453, -26092, -25751, -25427, -25121, -24830, -24556, -24296, -24053, -23823, -23608, -23407, -23219, -23044, -22881, -22730, -22590, -22460, -22341, -22228, -22121, -22018, -21914, -21808, -21691, -21555, -21384, -21157, -20845, -20397, -19723, -18537, -16516, -14477, -12920, -11470, -10029, -8319, -6243, -4534, -2930, -1237};