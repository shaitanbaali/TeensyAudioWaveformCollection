/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0636 256 samples */
 
const int16_t AKWF_0636_256_DATA [256] = 
{7139, 10651, 12883, 14719, 16277, 17646, 18873, 19984, 21004, 21948, 22819, 23632, 24392, 25099, 25762, 26383, 26962, 27505, 28011, 28483, 28922, 29329, 29705, 30050, 30366, 30653, 30912, 31142, 31345, 31521, 31670, 31792, 31888, 31745, 32868, 28408, 2260, -2374, 97, 3, -7, 113, -458, 2756, 9063, 11319, 13315, 14919, 16285, 17480, 18537, 19476, 20318, 21070, 21740, 22337, 22862, 23319, 23714, 24044, 24315, 24526, 24611, 25016, 23775, 14379, 10030, 7315, 5160, 3482, 2176, 1200, 520, 121, -2, -9, -14, 77, -5257, -8933, -10713, -12319, -13663, -14841, -15904, -16874, -17767, -18601, -19380, -20112, -20806, -21462, -22085, -22679, -23245, -23786, -24304, -24798, -25272, -25727, -26162, -26578, -26979, -27362, -27730, -28082, -28419, -28741, -29050, -29344, -29624, -29892, -30147, -30389, -30618, -30835, -31040, -31233, -31413, -31583, -31740, -31886, -32020, -32143, -32255, -32357, -32446, -32524, -32592, -32649, -32695, -32729, -32677, -33076, -30428, -26686, -25314, -24037, -22998, -22088, -21273, -20533, -19846, -19207, -18607, -18041, -17503, -16991, -16501, -16031, -15582, -15147, -14727, -14324, -13931, -13551, -13182, -12824, -12476, -12139, -11808, -11487, -11174, -10868, -10571, -10279, -9994, -9717, -9445, -9179, -8919, -8665, -8415, -8172, -7933, -7699, -7472, -7248, -7028, -6813, -6603, -6397, -6195, -5997, -5804, -5614, -5428, -5246, -5068, -4892, -4722, -4555, -4391, -4230, -4073, -3920, -3770, -3623, -3480, -3340, -3203, -3069, -2938, -2811, -2686, -2564, -2446, -2331, -2218, -2109, -2002, -1899, -1798, -1701, -1606, -1513, -1424, -1339, -1255, -1174, -1096, -1021, -948, -878, -811, -747, -685, -626, -571, -517, -466, -418, -372, -329, -289, -251, -216, -185, -155, -127, -103, -81, -62, -45, -31, -20, -11, -5, -1, 0, -1, -1, 0, 0, 0, 0};