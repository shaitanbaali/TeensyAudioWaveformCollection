/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0637 256 samples */
 
const int16_t AKWF_0637_256_DATA [256] = 
{1900, 4900, 7880, 10866, 13804, 16661, 19396, 21958, 24320, 26447, 28300, 29861, 31104, 32008, 32566, 32767, 32612, 32103, 31251, 30074, 28587, 26816, 24795, 22548, 20116, 17541, 14850, 12095, 9317, 6544, 3831, 1208, -1294, -3632, -5785, -7729, -9435, -10893, -12092, -13020, -13677, -14064, -14189, -14062, -13697, -13115, -12332, -11374, -10271, -9045, -7727, -6350, -4937, -3520, -2129, -785, 481, 1649, 2704, 3624, 4395, 5010, 5459, 5738, 5847, 5789, 5570, 5197, 4683, 4041, 3285, 2435, 1507, 521, -498, -1536, -2573, -3583, -4553, -5464, -6297, -7043, -7687, -8216, -8627, -8911, -9066, -9090, -8986, -8757, -8407, -7946, -7385, -6729, -5998, -5202, -4352, -3469, -2565, -1654, -754, 123, 964, 1754, 2484, 3145, 3724, 4219, 4623, 4930, 5142, 5258, 5278, 5208, 5050, 4814, 4504, 4129, 3700, 3227, 2720, 2189, 1647, 1105, 572, 60, -423, -867, -1265, -1609, -1896, -2118, -2273, -2360, -2377, -2325, -2207, -2025, -1783, -1485, -1139, -753, -331, 117, 583, 1061, 1540, 2011, 2467, 2901, 3304, 3671, 3995, 4270, 4493, 4661, 4768, 4816, 4803, 4728, 4593, 4401, 4152, 3851, 3505, 3114, 2685, 2223, 1735, 1226, 704, 173, -360, -888, -1409, -1914, -2399, -2861, -3292, -3692, -4056, -4381, -4664, -4907, -5104, -5256, -5363, -5425, -5441, -5414, -5343, -5230, -5077, -4886, -4659, -4397, -4105, -3783, -3437, -3069, -2682, -2280, -1869, -1450, -1030, -615, -207, 185, 557, 904, 1217, 1490, 1718, 1891, 2005, 2052, 2024, 1917, 1724, 1440, 1063, 586, 11, -664, -1441, -2314, -3277, -4328, -5453, -6644, -7891, -9170, -10471, -11775, -13055, -14295, -15471, -16551, -17520, -18351, -19017, -19499, -19775, -19825, -19634, -19189, -18484, -17508, -16264, -14758, -12991, -10984, -8752, -6316, -3711, -898};