/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0605 256 samples */
 
const int16_t AKWF_0605_256_DATA [256] = 
{903, 3191, 3087, 3108, 3114, 3116, 3119, 3122, 3123, 3126, 3127, 3129, 3130, 3130, 3132, 3132, 3132, 3132, 3132, 3132, 3130, 3130, 3129, 3127, 3127, 3127, 3126, 3124, 3123, 3122, 3121, 3119, 3119, 3117, 3116, 3114, 3113, 3111, 3110, 3109, 3107, 3106, 3104, 3103, 3101, 3099, 3098, 3096, 3095, 3094, 3091, 3090, 3089, 3087, 3086, 3083, 3082, 3081, 3078, 3077, 3076, 3074, 3072, 3071, 3069, 3067, 3066, 3064, 3062, 3061, 3059, 3058, 3056, 3054, 3053, 3051, 3050, 3048, 3046, 3045, 3043, 3041, 3040, 3038, 3036, 3035, 3033, 3031, 3030, 3029, 3026, 3025, 3024, 3022, 3021, 3019, 3016, 3016, 3014, 3012, 3011, 3009, 3007, 3005, 3004, 3002, 3000, 2999, 2998, 2996, 2994, 2993, 2991, 2989, 2988, 2986, 2984, 2983, 2981, 2979, 2978, 2976, 2976, 2973, 2971, 2970, 2968, 2967, 2965, 2963, 2962, 2961, 2959, 2957, 2956, 2954, 2952, 2951, 2949, 2947, 2946, 2944, 2943, 2941, 2940, 2939, 2936, 2935, 2933, 2932, 2931, 2928, 2927, 2926, 2924, 2923, 2921, 2918, 2918, 2916, 2915, 2913, 2911, 2910, 2908, 2907, 2905, 2903, 2902, 2900, 2899, 2897, 2895, 2894, 2893, 2890, 2889, 2888, 2886, 2885, 2882, 2881, 2880, 2878, 2877, 2875, 2873, 2872, 2870, 2869, 2867, 2865, 2864, 2862, 2861, 2859, 2858, 2857, 2854, 2854, 2852, 2850, 2849, 2847, 2845, 2844, 2842, 2841, 2839, 2838, 2836, 2834, 2828, 2829, 2836, 990, -838, -2443, -4096, -5739, -7377, -9015, -10646, -12274, -13901, -15521, -17139, -18756, -20365, -21971, -23583, -25206, -26831, -28456, -30038, -31830, -32287, -30547, -28924, -27285, -25644, -24000, -22357, -20718, -19072, -17429, -15790, -14147, -12505, -10866, -9223, -7584, -5946, -4307, -2675, -1008};