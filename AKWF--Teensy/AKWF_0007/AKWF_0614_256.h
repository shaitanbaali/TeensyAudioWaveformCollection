/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0614 256 samples */
 
const int16_t AKWF_0614_256_DATA [256] = 
{522, 2223, 4053, 6036, 8129, 10294, 12488, 14651, 16735, 18687, 20446, 21970, 23211, 24132, 24710, 24918, 24919, 24918, 24917, 24908, 24883, 24829, 24725, 24547, 24266, 23847, 23252, 22450, 21405, 20084, 18473, 16556, 14328, 11813, 9029, 6016, 2839, -443, -3754, -7000, -10104, -12973, -15511, -17653, -19327, -20474, -21059, -21353, -21656, -21961, -22269, -22577, -22886, -23193, -23497, -23797, -24089, -24368, -24632, -24879, -25099, -25293, -25453, -25574, -25650, -25676, -25645, -25552, -25393, -25162, -24853, -24464, -23990, -23428, -22780, -22039, -21208, -20291, -19286, -18196, -17032, -15792, -14487, -13129, -11719, -10271, -8801, -7314, -5839, -4391, -2975, -1608, -304, 932, 2083, 3140, 4096, 4937, 5659, 6254, 6714, 7036, 7214, 7255, 7225, 6741, 4891, 1580, -1952, 2698, 2765, -7819, -5273, 8400, 14683, 13422, 7970, -1941, -5441, -5099, -5176, -5174, -5160, -5129, -5063, -4945, -4753, -4461, -4043, -3476, -2737, -1809, -689, 625, 2127, 3784, 5572, 7442, 9338, 11210, 12992, 14617, 16032, 17180, 18016, 18507, 18643, 18635, 18626, 18561, 18348, 17841, 16861, 15232, 12809, 9555, 5540, 956, -3844, -8455, -12433, -15354, -16857, -17072, -17005, -16580, -14920, -11218, -5475, 974, 5813, 7230, 7142, 7167, 7168, 7163, 7149, 7123, 7072, 6988, 6855, 6659, 6381, 6001, 5503, 4868, 4076, 3116, 1975, 646, -870, -2574, -4458, -6498, -8679, -10974, -13342, -15752, -18165, -20525, -22798, -24934, -26882, -28610, -30075, -31242, -32089, -32596, -32750, -32745, -32745, -32736, -32702, -32616, -32439, -32117, -31593, -30805, -29695, -28219, -26353, -24087, -21459, -18527, -15370, -12117, -8898, -5855, -3150, -911, 741, 1700, 2000, 1648, 327, 20, -1982, 2330, 3272, -6327, -6830, -6683, -6712, -6702, -6679, -6634, -6552, -6415, -6206, -5902, -5480, -4919, -4199, -3301, -2223, -898};