/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0698 256 samples */
 
const int16_t AKWF_0698_256_DATA [256] = 
{15424, 33250, 25064, 20758, 17961, 15687, 13777, 12565, 11629, 10499, 9401, 8330, 7296, 6308, 5440, 4214, 6678, 9032, 9209, 9179, 8896, 8478, 7977, 7430, 6848, 6261, 5670, 5087, 4515, 3966, 3438, 2971, 2366, 2602, 4872, 6044, 6921, 7643, 8262, 8813, 9316, 9789, 10237, 10674, 11106, 11552, 11887, 13017, 14651, 15748, 16765, 17691, 18555, 19367, 20135, 20865, 21558, 22216, 22849, 23449, 24021, 24568, 25089, 25584, 26058, 26505, 26928, 27335, 27713, 28069, 28408, 28724, 29022, 29292, 29544, 29780, 29989, 30183, 30357, 30510, 30641, 30754, 30845, 30919, 30977, 30877, 31554, 27229, 19174, 14862, 11130, 8063, 5520, 3421, 1756, 502, -488, -327, -4252, -12074, -16275, -19893, -22902, -25429, -27545, -29287, -30663, -31687, -32345, -32849, -30920, -28214, -26668, -25251, -24001, -22866, -21814, -20829, -19900, -19015, -18174, -17372, -16599, -15857, -15145, -14453, -13789, -13147, -12524, -11924, -11340, -10776, -10231, -9700, -9186, -8689, -8210, -7741, -7290, -6854, -6429, -6023, -5622, -5241, -4874, -4518, -4174, -3845, -3527, -3219, -2926, -2646, -2375, -2122, -1876, -1646, -1424, -1212, -1013, -830, -653, -488, -334, -196, -66, 53, 162, 257, 343, 416, 481, 535, 576, 603, 612, 734, -1514, -3772, -5141, -6398, -7513, -8535, -9483, -10372, -11214, -12012, -12779, -13511, -14212, -14891, -15547, -16175, -16786, -17377, -17951, -18506, -19048, -19570, -20079, -20571, -21051, -21517, -21966, -22404, -22832, -23247, -23649, -24038, -24416, -24783, -25135, -25481, -25811, -26135, -26446, -26743, -27034, -27316, -27581, -27838, -28089, -28324, -28554, -28768, -28975, -29172, -29359, -29534, -29701, -29859, -30004, -30143, -30273, -30388, -30494, -30594, -30684, -30763, -30832, -30891, -30939, -30977, -31009, -31007, -31058, -31087, -24300, -18476, -14817, -11597, -8864, -6526, -4540, -2876, -1519, -457};