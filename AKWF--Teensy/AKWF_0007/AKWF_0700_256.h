/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0700 256 samples */
 
const int16_t AKWF_0700_256_DATA [256] = 
{667, 2188, 3541, 4802, 5981, 7091, 8141, 9133, 10076, 10973, 11821, 12628, 13395, 14121, 14809, 15459, 16070, 16646, 17189, 17692, 18161, 18595, 18995, 19360, 19692, 19987, 20250, 20480, 20674, 20836, 20965, 21017, 20871, 22647, -20866, -32054, -25434, -23150, -20595, -18273, -16125, -14115, -12230, -10446, -8756, -7157, -5632, -4183, -2810, -1499, -256, 920, 2039, 3098, 4095, 5039, 5924, 6751, 7526, 8244, 8908, 9521, 10080, 10587, 11043, 11445, 11798, 12101, 12353, 12556, 12710, 12783, 12996, 12069, 10047, 8788, 7676, 6691, 5789, 4954, 4174, 3438, 2744, 2087, 1460, 864, 297, -244, -760, -1251, -1722, -2168, -2594, -3000, -3383, -3747, -4093, -4420, -4727, -5016, -5286, -5540, -5776, -5993, -6196, -6382, -6551, -6702, -6838, -6960, -7064, -7154, -7229, -7290, -7335, -7365, -7382, -7386, -7384, -7382, -7379, -7379, -7376, -7373, -7371, -7369, -7368, -7366, -7362, -7362, -7359, -7357, -7356, -7352, -7351, -7350, -7347, -7345, -7342, -7340, -7338, -7335, -7334, -7333, -7330, -7328, -7327, -7324, -7323, -7321, -7320, -7317, -7316, -7313, -7312, -7309, -7308, -7307, -7306, -7304, -7302, -7301, -7298, -7297, -7295, -7294, -7292, -7291, -7288, -7287, -7285, -7283, -7282, -7279, -7278, -7278, -7277, -7275, -7273, -7272, -7272, -7269, -7267, -7267, -7265, -7263, -7262, -7261, -7261, -7260, -7258, -7257, -7256, -7255, -7253, -7252, -7251, -7250, -7249, -7250, -7247, -7246, -7246, -7245, -7243, -7241, -7242, -7241, -7240, -7240, -7239, -7238, -7234, -7233, -7234, -7233, -7232, -7233, -7231, -7230, -7231, -7228, -7228, -7224, -7229, -7347, -6810, -5711, -5076, -4611, -4175, -3791, -3442, -3123, -2829, -2557, -2305, -2072, -1859, -1661, -1479, -1311, -1156, -1015, -886, -769, -664, -567, -477, -401, -339, -291, -257, -232, -219, -212};