/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0621 256 samples */
 
const int16_t AKWF_0621_256_DATA [256] = 
{2439, 4356, 5788, 7048, 8184, 9232, 10212, 11134, 12010, 12848, 13647, 14417, 15159, 15873, 16565, 17235, 17883, 18512, 19122, 19714, 20290, 20849, 21392, 21920, 22433, 22932, 23416, 23887, 24343, 24788, 25218, 25635, 26041, 26433, 26813, 27180, 27535, 27879, 28210, 28528, 28835, 29131, 29414, 29687, 29947, 30195, 30432, 30657, 30871, 31073, 31265, 31444, 31612, 31768, 31914, 32047, 32170, 32280, 32381, 32468, 32545, 32611, 32664, 32707, 32730, 32768, 32734, 29942, 27526, 25866, 24363, 23017, 21776, 20618, 19533, 18502, 17521, 16588, 15692, 14834, 14011, 13219, 12457, 11724, 11017, 10337, 9683, 9052, 8445, 7862, 7300, 6762, 6247, 5751, 5278, 4827, 4394, 3984, 3594, 3224, 2876, 2547, 2238, 1950, 1682, 1433, 1205, 996, 807, 639, 489, 360, 251, 160, 90, 41, 9, -1, 0, 0, 0, 0, -40, 147, -825, -3873, -5698, -7257, -8641, -9896, -11058, -12149, -13175, -14151, -15082, -15971, -16824, -17644, -18430, -19190, -19922, -20626, -21306, -21963, -22595, -23205, -23795, -24361, -24908, -25435, -25941, -26427, -26895, -27341, -27771, -28181, -28572, -28944, -29298, -29633, -29951, -30249, -30530, -30794, -31039, -31265, -31474, -31665, -31837, -31993, -32130, -32249, -32351, -32435, -32501, -32537, -32605, -32485, -30049, -28118, -26733, -25487, -24366, -23328, -22360, -21447, -20577, -19749, -18955, -18191, -17457, -16748, -16061, -15397, -14754, -14130, -13525, -12937, -12365, -11812, -11273, -10748, -10239, -9745, -9263, -8796, -8343, -7903, -7476, -7060, -6659, -6271, -5893, -5529, -5177, -4836, -4508, -4192, -3887, -3594, -3313, -3043, -2786, -2540, -2304, -2082, -1871, -1669, -1482, -1303, -1137, -983, -839, -707, -587, -476, -378, -292, -216, -152, -100, -57, -27, -8, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0};