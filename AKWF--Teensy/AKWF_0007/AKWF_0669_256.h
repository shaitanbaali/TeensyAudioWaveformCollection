/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0669 256 samples */
 
const int16_t AKWF_0669_256_DATA [256] = 
{915, 2211, 3306, 4301, 5218, 6073, 6879, 7641, 8368, 9062, 9725, 10364, 10979, 11569, 12140, 12692, 13225, 13741, 14240, 14721, 15188, 15640, 16077, 16500, 16909, 17304, 17686, 18055, 18410, 18755, 19086, 19405, 19712, 20006, 20288, 20559, 20817, 21064, 21301, 21524, 21736, 21937, 22126, 22305, 22471, 22627, 22771, 22904, 23026, 23137, 23236, 23325, 23403, 23468, 23523, 23568, 23601, 23589, 23752, 23054, 19428, 17151, 15357, 13778, 12356, 11057, 9854, 8726, 7672, 6676, 5735, 4845, 4003, 3205, 2452, 1736, 1060, 425, -175, -739, -1266, -1759, -2217, -2640, -3029, -3385, -3706, -3995, -4252, -4473, -4662, -4819, -4942, -5022, -5098, -5091, -1917, 776, 2565, 4177, 5604, 6909, 8116, 9239, 10294, 11288, 12223, 13110, 13950, 14744, 15498, 16213, 16885, 17523, 18124, 18688, 19219, 19715, 20175, 20604, 20999, 21362, 21692, 21989, 22252, 22485, 22687, 22855, 22992, 23098, 23094, 23491, 21822, 14425, 9994, 6547, 3665, 1255, -736, -2351, -3604, -4554, -4861, -6117, -13162, -17727, -21103, -23932, -26301, -28265, -29854, -31094, -31960, -32627, -32416, -27322, -23641, -21014, -18710, -16691, -14883, -13260, -11797, -10476, -9292, -8242, -7435, -6701, -6030, -5451, -4969, -4583, -4374, -3820, -5858, -10915, -13630, -16472, -18889, -20229, -21296, -22144, -22852, -23501, -24027, -25008, -26829, -28100, -29177, -30079, -30806, -31353, -31701, -31986, -29954, -27789, -26466, -25257, -24183, -23204, -22294, -21438, -20631, -19862, -19129, -18427, -17754, -17104, -16482, -15878, -15296, -14734, -14189, -13663, -13154, -12661, -12184, -11722, -11274, -10842, -10423, -10019, -9628, -9251, -8886, -8534, -8196, -7870, -7557, -7256, -6968, -6691, -6428, -6175, -5936, -5707, -5491, -5287, -5094, -4913, -4744, -4587, -4441, -4307, -4185, -4073, -3975, -3888, -3811, -3747, -3694, -3651, -3597, -3693, -3172, -619};