/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0677 256 samples */
 
const int16_t AKWF_0677_256_DATA [256] = 
{1030, 4842, 8509, 12070, 15465, 18652, 21590, 24232, 26557, 28538, 30147, 31380, 32225, 32680, 32754, 32462, 31821, 30852, 29587, 28062, 26306, 24365, 22284, 20094, 17848, 15589, 13349, 11176, 9104, 7161, 5382, 3789, 2396, 1227, 283, -428, -909, -1166, -1208, -1051, -714, -216, 415, 1157, 1981, 2857, 3760, 4662, 5534, 6355, 7102, 7753, 8295, 8715, 8999, 9146, 9152, 9016, 8746, 8348, 7834, 7214, 6509, 5731, 4900, 4038, 3163, 2292, 1448, 646, -95, -762, -1342, -1826, -2202, -2470, -2624, -2664, -2595, -2421, -2149, -1789, -1353, -855, -307, 275, 875, 1479, 2069, 2632, 3153, 3619, 4020, 4344, 4585, 4737, 4795, 4758, 4626, 4402, 4091, 3700, 3234, 2706, 2124, 1501, 851, 185, -483, -1140, -1775, -2373, -2923, -3417, -3845, -4200, -4475, -4667, -4773, -4794, -4727, -4579, -4352, -4053, -3688, -3266, -2798, -2293, -1761, -1216, -669, -129, 389, 875, 1322, 1715, 2050, 2318, 2513, 2629, 2665, 2617, 2485, 2269, 1974, 1602, 1159, 651, 85, -530, -1185, -1873, -2579, -3295, -4011, -4714, -5395, -6046, -6654, -7212, -7713, -8147, -8509, -8798, -9004, -9128, -9167, -9123, -8995, -8787, -8502, -8145, -7721, -7238, -6702, -6122, -5509, -4869, -4214, -3555, -2901, -2262, -1650, -1074, -543, -67, 344, 684, 945, 1122, 1208, 1199, 1091, 883, 571, 155, -360, -979, -1696, -2508, -3409, -4397, -5462, -6600, -7803, -9060, -10368, -11714, -13086, -14482, -15887, -17289, -18685, -20061, -21405, -22714, -23974, -25176, -26316, -27384, -28369, -29270, -30078, -30788, -31396, -31896, -32286, -32564, -32726, -32770, -32700, -32512, -32208, -31787, -31255, -30612, -29859, -29006, -28050, -26998, -25858, -24629, -23321, -21940, -20487, -18974, -17406, -15784, -14122, -12424, -10693, -8939, -7169, -5387, -3605, -1788};