/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0619 256 samples */
 
const int16_t AKWF_0619_256_DATA [256] = 
{533, 2562, 3381, 9506, 27119, 26486, 26531, 26517, 26485, 26453, 26422, 26390, 26359, 26327, 26296, 26265, 26017, 27156, 17342, 11506, 12264, 11710, 11359, 11009, 10658, 10308, 9956, 9605, 9255, 8904, 8554, 8204, 7852, 7501, 7150, 6800, 6449, 6099, 5747, 5396, 5045, 4695, 4345, 3994, 3642, 3291, 2941, 2590, 2240, 1890, 1538, 1187, 836, 485, 136, -214, -566, -917, -1267, -1618, -1968, -2319, -2670, -3021, -3372, -3896, -3268, -7833, -24732, -24382, -24618, -24807, -24982, -25158, -25331, -25506, -25680, -25855, -26029, -26203, -26378, -26552, -26727, -26902, -27076, -27251, -27424, -27600, -27774, -27948, -28123, -28297, -28472, -28646, -28821, -28995, -29169, -29345, -29518, -29693, -29868, -30042, -30217, -30390, -30566, -30740, -30914, -31089, -31263, -31438, -31613, -31787, -31962, -32135, -32311, -32267, -33607, -23726, -16917, -16223, -14302, -12566, -10822, -9075, -7329, -5573, -3817, -2057, -290, 1634, 2494, 8194, 24395, 23975, 24168, 24302, 24414, 24523, 24626, 24725, 24820, 24926, 24919, 25741, 25967, 26949, 17684, 12137, 12819, 12261, 11894, 11524, 11155, 10785, 10413, 10041, 9668, 9293, 8918, 8543, 8165, 7787, 7408, 7028, 6648, 6266, 5882, 5499, 5115, 4727, 4347, 4003, 3662, 3321, 2979, 2638, 2299, 1959, 1618, 1279, 939, 600, 261, -78, -416, -755, -1092, -1430, -1768, -2106, -2443, -2781, -3117, -3617, -3032, -7338, -23232, -22863, -23047, -23188, -23316, -23445, -23573, -23702, -23832, -23978, -24022, -24542, -25887, -25988, -26171, -26343, -26516, -26688, -26862, -27036, -27212, -27387, -27562, -27738, -27915, -28093, -28271, -28449, -28629, -28808, -28988, -29169, -29350, -29532, -29715, -29897, -30080, -30265, -30450, -30635, -30820, -31007, -31193, -31381, -31569, -31757, -31947, -31923, -33253, -23613, -16849, -16033, -14030, -12209, -10383, -8559, -6738, -4915, -3098, -1242};