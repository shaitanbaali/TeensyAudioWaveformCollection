/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0604 256 samples */
 
const int16_t AKWF_0604_256_DATA [256] = 
{3738, 13084, 22454, 31078, 27322, 20024, 13500, 6501, 28, -325, -237, -271, -273, -275, -278, -279, -281, -283, -284, -285, -287, -288, -288, -289, -290, -291, -291, -292, -291, -293, -294, -293, -293, -294, -293, -294, -295, -294, -294, -294, -294, -294, -294, -294, -294, -294, -294, -295, -294, -294, -293, -294, -293, -293, -293, -293, -293, -293, -293, -293, -293, -294, -292, -291, -292, -291, -291, -291, -291, -291, -291, -292, -291, -291, -290, -291, -290, -290, -290, -290, -290, -290, -291, -289, -288, -289, -288, -288, -288, -288, -288, -289, -288, -288, -287, -288, -287, -287, -287, -287, -287, -288, -287, -285, -286, -286, -285, -285, -285, -285, -285, -286, -285, -284, -285, -284, -284, -284, -284, -284, -284, -285, -283, -282, -283, -282, -282, -282, -282, -282, -282, -283, -282, -281, -282, -281, -281, -281, -281, -281, -281, -282, -281, -279, -280, -279, -279, -279, -279, -279, -279, -280, -279, -278, -279, -278, -278, -278, -278, -278, -278, -279, -278, -276, -277, -276, -276, -276, -276, -276, -276, -277, -276, -275, -276, -276, -275, -275, -275, -275, -275, -276, -275, -273, -274, -273, -273, -273, -273, -273, -273, -274, -273, -272, -273, -273, -272, -272, -272, -272, -272, -273, -272, -271, -270, -271, -270, -270, -270, -270, -270, -270, -271, -270, -269, -270, -269, -269, -269, -269, -269, -269, -270, -269, -267, -268, -267, -267, -267, -267, -267, -267, -267, -268, -267, -266, -267, -266, -266, -266, -266, -266, -266, -267, -312, -280, -257, -13451, -29545, -21343, -7808, 144, -364, -259, -247, -246};