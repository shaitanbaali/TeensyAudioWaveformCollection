/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0660 256 samples */
 
const int16_t AKWF_0660_256_DATA [256] = 
{2909, 5901, 7902, 9492, 10811, 11940, 12931, 13811, 14607, 15335, 16002, 16622, 17200, 17739, 18247, 18728, 19181, 19612, 20025, 20412, 20628, 20958, 21314, 21658, 21994, 22317, 22631, 22937, 23232, 23518, 23795, 24061, 24322, 24575, 24817, 25052, 25281, 25502, 25716, 25923, 26124, 26318, 26507, 26690, 26869, 27042, 27211, 27374, 27534, 27689, 27841, 27988, 28131, 28270, 28405, 28538, 28666, 28791, 28913, 29032, 29148, 29260, 29368, 29475, 29577, 29677, 29775, 29869, 29961, 30050, 30138, 30220, 30302, 30381, 30456, 30530, 30601, 30671, 30737, 30802, 30863, 30922, 30979, 31035, 31088, 31140, 31188, 31235, 31280, 31322, 31362, 31400, 31438, 31471, 31503, 31535, 31563, 31590, 31614, 31637, 31658, 31678, 31695, 31709, 31723, 31736, 31746, 31753, 31760, 31765, 31768, 31770, 31768, 31766, 31762, 31757, 31749, 31739, 31728, 31717, 31702, 31686, 31669, 31649, 31285, 33113, 24445, 548, -1508, -3841, -5426, -6681, -7715, -8597, -9368, -10042, -10646, -11189, -11680, -12126, -12535, -12908, -13253, -13571, -13863, -14144, -14365, -14675, -18359, -19703, -20206, -20747, -21208, -21627, -22016, -22383, -22726, -23056, -23367, -23667, -23955, -24232, -24498, -24755, -25002, -25242, -25476, -25700, -25920, -26132, -26337, -26539, -26733, -26922, -27107, -27287, -27462, -27633, -27798, -27961, -28120, -28273, -28423, -28569, -28714, -28851, -28987, -29121, -29249, -29376, -29501, -29621, -29738, -29851, -29965, -30073, -30179, -30283, -30384, -30483, -30579, -30674, -30763, -30852, -30939, -31023, -31104, -31186, -31263, -31337, -31411, -31482, -31550, -31617, -31682, -31744, -31806, -31864, -31920, -31975, -32028, -32080, -32128, -32174, -32220, -32263, -32305, -32345, -32382, -32420, -32453, -32486, -32516, -32544, -32572, -32597, -32621, -32642, -32662, -32680, -32697, -32711, -32724, -32735, -32745, -32752, -32758, -32763, -32765, -32766, -32765, -32763, -32727, -32630, -33466, -6794};