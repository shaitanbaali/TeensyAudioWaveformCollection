/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0606 256 samples */
 
const int16_t AKWF_0606_256_DATA [256] = 
{627, 2233, 3709, 5130, 6495, 7805, 9067, 10278, 11447, 12574, 13658, 14704, 15714, 16686, 17623, 18528, 19398, 20236, 21044, 21818, 22564, 23280, 23964, 24623, 25251, 25850, 26423, 26969, 27485, 27977, 28440, 28875, 29287, 29670, 30029, 30362, 30667, 30947, 31203, 31432, 31636, 31814, 31967, 32096, 32198, 32276, 32329, 32242, 32785, 29975, 20079, 14352, 9815, 5903, 2449, -682, -3541, -6175, -8621, -10890, -13000, -14969, -16798, -18496, -20074, -21529, -22868, -24098, -25214, -26222, -27127, -27924, -28617, -29208, -29697, -30084, -30366, -30427, -31164, -24936, -15997, -11105, -6788, -3074, 252, 3270, 6036, 8599, 10974, 13178, 15237, 17152, 18932, 20590, 22123, 23540, 24846, 26037, 27122, 28103, 28976, 29747, 30415, 30981, 31448, 31814, 32072, 32184, 32574, 26745, 20273, 16544, 13225, 10326, 7711, 5318, 3091, 1010, -943, -2793, -4546, -6210, -7798, -9308, -10748, -12127, -13441, -14694, -15895, -17038, -18128, -19168, -20157, -21098, -21991, -22835, -23635, -24391, -25099, -25765, -26386, -26963, -27499, -27991, -28441, -28849, -29216, -29540, -29824, -30066, -30267, -30428, -30547, -30574, -30810, -29976, -20920, -14354, -9886, -5969, -2520, 580, 3415, 6036, 8462, 10723, 12836, 14806, 16651, 18375, 19981, 21478, 22871, 24159, 25346, 26437, 27428, 28328, 29133, 29844, 30466, 30995, 31435, 31786, 32046, 32121, 32684, 29503, 22891, 19298, 16220, 13560, 11167, 8982, 6955, 5054, 3268, 1573, -37, -1570, -3039, -4448, -5796, -7094, -8342, -9539, -10697, -11810, -12880, -13915, -14911, -15868, -16793, -17682, -18536, -19360, -20151, -20909, -21637, -22335, -23001, -23639, -24248, -24826, -25377, -25899, -26392, -26859, -27298, -27709, -28093, -28450, -28779, -29082, -29356, -29606, -29829, -30025, -30195, -30339, -30456, -30548, -30614, -30620, -30749, -30268, -24013, -19315, -16156, -13373, -10906, -8669, -6605, -4677, -2870, -1130};