/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0667 256 samples */
 
const int16_t AKWF_0667_256_DATA [256] = 
{100, 306, 506, 704, 901, 1096, 1289, 1480, 1670, 1858, 2044, 2229, 2413, 2594, 2775, 2954, 3130, 3305, 3479, 3651, 3822, 3991, 4158, 4325, 4488, 4651, 4814, 4973, 5132, 5289, 5444, 5598, 5750, 5901, 6051, 6200, 6346, 6491, 6636, 6778, 6919, 7059, 7197, 7334, 7470, 7603, 7736, 7867, 7997, 8126, 8253, 8379, 8503, 8626, 8748, 8868, 8987, 9104, 9221, 9336, 9450, 9562, 9673, 9783, 9892, 9998, 10104, 10208, 10310, 10412, 10513, 10612, 10709, 10805, 10901, 10995, 11088, 11179, 11268, 11357, 11444, 11530, 11615, 11698, 11780, 11862, 11941, 12019, 12097, 12172, 12246, 12320, 12392, 12462, 12531, 12599, 12666, 12732, 12796, 12859, 12921, 12981, 13040, 13098, 13154, 13210, 13263, 13317, 13368, 13418, 13468, 13515, 13561, 13607, 13650, 13693, 13735, 13774, 13814, 13852, 13888, 13923, 13957, 13990, 14021, 14051, 14080, 14108, 14133, 14159, 14183, 14205, 14227, 14247, 14266, 14284, 14300, 14315, 14329, 14341, 14352, 14363, 14372, 14379, 14385, 14390, 14394, 14397, 14398, 14398, 14208, 15160, 7446, -3832, -9818, -15049, -19354, -22968, -25959, -28379, -30262, -31609, -32461, -32705, -32128, -31744, -31470, -31238, -31041, -30874, -30735, -30621, -30530, -30449, -30476, -30147, -28149, -26890, -25933, -25093, -24335, -23641, -22994, -22382, -21803, -21251, -20720, -20209, -19716, -19238, -18775, -18325, -17885, -17456, -17039, -16629, -16230, -15839, -15453, -15076, -14706, -14341, -13984, -13632, -13285, -12944, -12608, -12275, -11949, -11627, -11309, -10996, -10686, -10380, -10079, -9780, -9485, -9195, -8906, -8621, -8341, -8062, -7786, -7515, -7245, -6978, -6715, -6452, -6195, -5938, -5685, -5435, -5185, -4939, -4696, -4454, -4215, -3978, -3743, -3510, -3281, -3052, -2826, -2602, -2380, -2160, -1942, -1725, -1511, -1299, -1088, -879, -673, -467, -265, -60};