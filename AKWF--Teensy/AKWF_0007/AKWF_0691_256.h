/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0691 256 samples */
 
const int16_t AKWF_0691_256_DATA [256] = 
{16822, 15927, 15913, 15733, 15580, 15424, 15271, 15117, 14962, 15063, 13538, 20371, 33353, 32107, 31940, 31648, 31338, 31027, 30715, 30404, 30092, 29780, 29468, 29154, 28842, 28531, 28218, 27905, 27592, 27279, 26967, 26653, 26340, 26027, 25716, 25180, 26048, 19962, 9467, 10205, 9897, 9727, 9567, 9411, 9252, 9094, 8937, 8781, 8623, 8465, 8309, 8152, 7996, 7843, 7497, 8363, 1228, -4884, -3974, -4141, -4144, -4145, -4145, -4146, -4148, -4148, -4149, -4149, -4148, -4147, -4149, -4149, -4147, -4148, -4147, -4147, -4148, -4186, -3999, -4712, -11326, -11993, -11625, -11516, -11362, -11207, -11052, -10895, -10741, -10586, -10430, -10276, -10120, -9965, -9808, -9736, -9133, -13034, -14598, -13885, -13650, -13342, -13031, -12725, -12414, -12106, -11796, -11487, -11178, -10870, -10559, -10251, -9942, -9634, -9323, -9016, -8706, -8397, -8090, -7781, -7471, -7164, -6854, -6546, -6239, -5930, -5622, -5314, -5005, -4698, -4388, -4086, -4011, -4021, -4016, -4015, -4013, -4011, -4010, -4009, -4007, -4006, -4004, -4003, -4002, -4001, -3999, -3998, -3997, -3997, -3994, -3994, -3991, -3990, -3990, -3989, -3988, -3986, -3985, -3983, -3983, -3982, -3980, -3980, -3977, -3978, -3976, -3975, -3975, -3973, -3972, -3970, -3970, -3969, -3967, -3968, -3965, -3964, -3963, -3962, -3962, -3959, -3960, -3958, -3956, -3956, -3955, -3955, -3952, -3952, -3951, -3948, -3949, -3947, -3947, -3946, -3943, -3943, -3942, -3942, -3940, -3938, -3939, -3936, -3936, -3935, -3933, -3934, -3931, -3930, -3929, -3928, -3928, -3925, -3926, -3924, -3922, -3922, -3921, -3921, -3919, -3917, -3917, -3915, -3916, -3913, -3912, -3912, -3909, -3910, -3908, -3907, -3907, -3905, -3905, -3903, -3901, -3902, -3900, -3900, -3897, -3896, -3896, -3894, -3895, -3892, -3891, -3891, -3888, -3889, -3887, -3886, -3886, -3884, -3884, -3883};