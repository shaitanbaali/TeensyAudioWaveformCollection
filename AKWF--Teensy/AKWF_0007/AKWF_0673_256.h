/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0673 256 samples */
 
const int16_t AKWF_0673_256_DATA [256] = 
{8676, 13630, 16793, 19327, 21409, 23168, 24677, 25977, 27108, 28093, 28950, 29693, 30335, 30886, 31351, 31742, 32062, 32315, 32509, 32648, 32732, 32767, 32757, 32701, 32605, 32472, 32300, 32095, 31856, 31585, 31287, 30960, 30606, 30228, 29825, 29399, 28954, 28488, 28001, 27496, 26975, 26437, 25884, 25315, 24732, 24139, 23532, 22911, 22282, 21642, 20992, 20334, 19667, 18993, 18312, 17623, 16928, 16229, 15524, 14813, 14101, 13384, 12664, 11941, 11215, 10488, 9760, 9031, 8301, 7570, 6839, 6110, 5381, 4650, 3924, 3199, 2475, 1755, 1035, 318, -390, -1100, -1806, -2506, -3206, -3898, -4586, -5269, -5948, -6621, -7288, -7949, -8605, -9255, -9898, -10534, -11165, -11788, -12404, -13014, -13614, -14208, -14796, -15374, -15945, -16507, -17062, -17609, -18148, -18676, -19197, -19710, -20212, -20706, -21193, -21667, -22134, -22592, -23039, -23478, -23908, -24327, -24736, -25136, -25524, -25906, -26277, -26634, -26986, -27326, -27656, -27976, -28284, -28585, -28874, -29152, -29420, -29679, -29926, -30165, -30391, -30607, -30813, -31011, -31195, -31371, -31534, -31688, -31833, -31966, -32090, -32202, -32305, -32398, -32478, -32551, -32613, -32663, -32704, -32736, -32757, -32767, -32767, -32759, -32740, -32711, -32672, -32624, -32566, -32498, -32421, -32334, -32237, -32133, -32017, -31892, -31758, -31615, -31464, -31303, -31133, -30953, -30767, -30571, -30365, -30153, -29931, -29700, -29463, -29216, -28960, -28698, -28427, -28149, -27863, -27569, -27267, -26958, -26642, -26320, -25988, -25650, -25306, -24955, -24597, -24234, -23862, -23483, -23102, -22712, -22316, -21914, -21506, -21093, -20675, -20249, -19822, -19387, -18947, -18502, -18052, -17597, -17139, -16676, -16208, -15736, -15261, -14780, -14296, -13810, -13317, -12823, -12326, -11824, -11320, -10814, -10304, -9792, -9277, -8759, -8239, -7718, -7194, -6670, -6142, -5612, -5084, -4551, -4018, -3485, -2950, -2414, -1878, -1341, -815, -213};