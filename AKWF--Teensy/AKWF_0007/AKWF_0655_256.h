/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0655 256 samples */
 
const int16_t AKWF_0655_256_DATA [256] = 
{1750, 4581, 6868, 8850, 10589, 12135, 13524, 14770, 15898, 16921, 17845, 18683, 19439, 20118, 20725, 21263, 21736, 22146, 22493, 22780, 23010, 23181, 23156, 23952, 17634, 11776, 10417, 8944, 7831, 6894, 6086, 5374, 4740, 4174, 3660, 3194, 2774, 2391, 2043, 1730, 1446, 1191, 965, 765, 592, 442, 317, 216, 138, 81, 49, 40, 38, 37, 37, 38, 37, 35, 36, 36, 36, 36, 36, 36, 35, 36, 34, 32, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 46, 96, -287, 10546, 16775, 18748, 20691, 22207, 23482, 24588, 25564, 26431, 27212, 27917, 28553, 29130, 29653, 30126, 30554, 30938, 31281, 31585, 31852, 32083, 32279, 32442, 32570, 32666, 32349, 34355, 21664, 5297, 1897, -1801, -4562, -6868, -8856, -10594, -12140, -13527, -14775, -15904, -16926, -17850, -18689, -19445, -20123, -20730, -21269, -21740, -22150, -22499, -22786, -23015, -23187, -23161, -23957, -17640, -11781, -10423, -8950, -7837, -6899, -6091, -5381, -4746, -4178, -3665, -3201, -2779, -2396, -2050, -1735, -1452, -1197, -972, -772, -597, -448, -323, -221, -143, -88, -55, -43, -44, -43, -44, -42, -41, -42, -41, -41, -41, -41, -42, -39, -38, -39, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -40, -34, -66, -125, -128, -142, -190, 198, -10595, -16803, -18772, -20709, -22221, -23495, -24600, -25574, -26439, -27219, -27922, -28558, -29135, -29659, -30130, -30559, -30942, -31284, -31587, -31849, -32073, -32265, -32436, -32567, -32665, -32350, -34358, -21675, -5312, -1866};