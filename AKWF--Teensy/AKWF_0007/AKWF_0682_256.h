/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0682 256 samples */
 
const int16_t AKWF_0682_256_DATA [256] = 
{1452, 4326, 5722, 7025, 8181, 9258, 10284, 11271, 12236, 13184, 14117, 15045, 15971, 16893, 17819, 18749, 19680, 20621, 21570, 22526, 23494, 24474, 25463, 26467, 27485, 28515, 29565, 30489, 32300, 28188, 30936, 31649, 30259, 29325, 28379, 27465, 26586, 25734, 24911, 24116, 23346, 22599, 21876, 21175, 20492, 19832, 19190, 18564, 17957, 17364, 16788, 16228, 15679, 15144, 14623, 14114, 13616, 13129, 12653, 12187, 11730, 11283, 10845, 10415, 9993, 9578, 9171, 8769, 8377, 7990, 7607, 7232, 6861, 6495, 6135, 5778, 5427, 5080, 4735, 4395, 4059, 3725, 3393, 3066, 2740, 2416, 2096, 1777, 1459, 1144, 830, 517, 207, -104, -414, -722, -1032, -1340, -1648, -1957, -2265, -2574, -2883, -3192, -3502, -3815, -4126, -4439, -4753, -5069, -5386, -5705, -6026, -6348, -6673, -6998, -7328, -7661, -7993, -8330, -8670, -9012, -9358, -9708, -10059, -10414, -10774, -11137, -11504, -11874, -12250, -12629, -13011, -13400, -13794, -14190, -14594, -15001, -15414, -15832, -16257, -16687, -17122, -17564, -18011, -18466, -18925, -19392, -19867, -20348, -20834, -21330, -21832, -22342, -22860, -23386, -23919, -24462, -25013, -25572, -26140, -26717, -27303, -27900, -28504, -29120, -29745, -30379, -31018, -31589, -32833, -24498, -30921, -32332, -31188, -30603, -29969, -29346, -28734, -28133, -27542, -26961, -26390, -25829, -25278, -24737, -24202, -23679, -23164, -22656, -22158, -21667, -21184, -20710, -20242, -19781, -19329, -18883, -18443, -18011, -17586, -17164, -16752, -16344, -15942, -15546, -15156, -14770, -14391, -14016, -13645, -13281, -12920, -12564, -12214, -11866, -11524, -11186, -10850, -10519, -10192, -9868, -9548, -9231, -8917, -8606, -8299, -7994, -7693, -7394, -7098, -6803, -6511, -6221, -5935, -5649, -5366, -5084, -4805, -4526, -4250, -3974, -3701, -3429, -3157, -2888, -2618, -2350, -2083, -1817, -1550, -1285, -1020, -755, -492, -224};