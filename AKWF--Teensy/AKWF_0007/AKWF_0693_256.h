/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0693 256 samples */
 
const int16_t AKWF_0693_256_DATA [256] = 
{316, 1188, 1936, 2740, 3577, 4455, 5375, 5535, 4887, 4468, 4515, 4994, 5175, 4943, 4683, 4273, 4355, 4778, 4956, 4907, 4933, 4841, 4039, 2938, 2615, 2979, 2659, 1548, 1054, 2607, 3955, 4956, 18548, 25105, 26484, 28337, 28733, 29044, 30912, 32502, 32469, 31734, 31844, 31757, 32243, 32486, 32279, 30909, 30839, 29377, 27910, 27624, 28305, 28389, 27847, 27884, 27255, 27144, 29830, 9325, -11209, -11179, -11124, -11138, -11058, -10580, -11213, -11415, -11332, -11291, -11110, -11176, -12286, -12792, -12177, -12594, -14043, -14830, -15325, -14873, -13863, -12971, -12118, -12034, -12037, -12135, -12137, -12170, -11501, -11007, -10433, -10193, -10491, -10497, -9313, -7403, -5440, -3772, -3600, -5185, -5809, -5205, -4455, -4175, -5230, -5152, -5633, -6195, -6560, -6113, -5227, -3361, -2206, -2183, -2916, -3355, -3007, -2473, -1965, -1660, -917, 299, 1266, 1433, 533, -264, -25, -64, -470, -1042, -1368, -1391, -646, 311, 428, 33, -98, -447, -1776, -2486, -2788, -3130, -2994, -3137, -3209, -3263, -3438, -3774, -4086, -4871, -5687, -6274, -6963, -6633, -6286, -6261, -6115, -6244, -6379, -6158, -6645, -7232, -7182, -6991, -6731, -7537, -8859, -9308, -9862, -10267, -10152, -8634, -7239, -6651, -6629, -6640, -6686, -6320, -5541, -5193, -4771, -4251, -3966, -3124, -2586, -2456, -2494, -2884, -3016, -2681, -2185, -1938, -1903, -1776, -1061, -584, -398, -362, -279, -390, -1264, -1661, -1719, -1888, -1810, -1592, -1657, -1701, -1647, -1568, -1282, -1112, -1293, -2085, -2860, -3279, -3823, -3922, -3852, -3738, -3081, -2547, -2424, -2281, -2090, -2321, -2500, -2346, -2218, -2304, -2303, -2327, -2316, -1812, -1775, -2120, -2166, -2152, -2090, -1846, -1601, -986, -438, -280, -214, -314, -369, -219, -111, -152, -113, -231, -643, -1151, -892, -204};