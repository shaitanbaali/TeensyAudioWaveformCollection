/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0649 256 samples */
 
const int16_t AKWF_0649_256_DATA [256] = 
{270, 273, 276, 279, 281, 283, 286, 288, 289, 291, 292, 293, 295, 296, 296, 296, 297, 299, 298, 457, -404, 7122, 11495, 11071, 11607, 11995, 12384, 12773, 13161, 13549, 13937, 14324, 14712, 15098, 15485, 15874, 16260, 16646, 17034, 17420, 17805, 18191, 18577, 18962, 19349, 19734, 20120, 20505, 20890, 21275, 21660, 22045, 22429, 22814, 23198, 23583, 23968, 24352, 24736, 25119, 25503, 25887, 26271, 26655, 27038, 27420, 27804, 28187, 28570, 28953, 29336, 29718, 30099, 30477, 30888, 30797, 30358, 29971, 29574, 29177, 28780, 28383, 27986, 27590, 27193, 26794, 26398, 26000, 25604, 25208, 24811, 24414, 24017, 23620, 23224, 22828, 22431, 22035, 21639, 21242, 20847, 20451, 20054, 19659, 19263, 18868, 18472, 18077, 17682, 17287, 16891, 16495, 16101, 15706, 15311, 14918, 14523, 14128, 13734, 13340, 12945, 12552, 12158, 11764, 11371, 10935, 10750, 9590, 333, -410, -210, -256, -258, -260, -263, -265, -266, -267, -268, -270, -271, -272, -274, -274, -275, -274, -275, -434, 424, -7064, -11423, -11010, -11553, -11949, -12344, -12739, -13132, -13525, -13918, -14309, -14702, -15092, -15481, -15872, -16260, -16648, -17037, -17423, -17810, -18197, -18583, -18968, -19353, -19737, -20120, -20504, -20886, -21268, -21650, -22035, -22392, -22887, -23831, -24486, -25058, -25592, -26100, -26587, -27058, -27517, -27965, -28402, -28831, -29252, -29667, -30075, -30477, -30874, -31265, -31651, -32004, -32534, -32164, -30634, -30359, -29942, -29545, -29147, -28750, -28352, -27955, -27559, -27161, -26764, -26367, -25970, -25573, -25176, -24779, -24382, -23986, -23588, -23192, -22796, -22399, -22003, -21607, -21210, -20815, -20419, -20023, -19627, -19232, -18835, -18441, -18045, -17649, -17254, -16859, -16464, -16070, -15675, -15280, -14885, -14490, -14097, -13703, -13307, -12914, -12520, -12126, -11732, -11339, -10946, -10553, -10153};