/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0690 256 samples */
 
const int16_t AKWF_0690_256_DATA [256] = 
{2843, 7695, 10008, 11958, 13515, 14812, 15913, 16855, 17667, 18370, 18978, 19503, 19958, 20343, 20668, 20940, 21159, 21331, 21459, 21546, 21594, 21607, 21585, 21530, 21446, 21335, 21197, 21035, 20850, 20644, 20419, 20176, 19917, 19644, 19357, 19060, 18754, 18437, 18115, 17786, 17455, 17121, 16787, 16454, 16123, 15797, 15479, 15178, 14926, 14763, 14716, 14784, 14951, 15190, 15476, 15800, 16157, 16536, 16933, 17335, 17730, 18121, 18525, 18974, 19505, 20125, 20837, 21617, 22435, 23275, 24126, 24978, 25822, 26649, 27443, 28199, 28909, 29561, 30154, 30686, 31155, 31561, 31906, 32191, 32416, 32584, 32698, 32757, 32769, 32736, 32654, 32531, 32367, 32165, 31927, 31653, 31347, 31012, 30645, 30250, 29826, 29353, 28816, 28200, 27490, 26689, 25809, 24858, 23842, 22768, 21631, 20426, 19147, 17755, 16276, 14247, 10124, 7420, 5788, 3805, 1669, -465, -2511, -4416, -6170, -7776, -9240, -10576, -11796, -12906, -13919, -14845, -15688, -16459, -17162, -17800, -18381, -18911, -19387, -19816, -20202, -20542, -20844, -21109, -21335, -21526, -21684, -21808, -21903, -21968, -22002, -22009, -21990, -21945, -21875, -21784, -21669, -21534, -21377, -21203, -21010, -20800, -20575, -20334, -20080, -19816, -19537, -19250, -18953, -18650, -18339, -18023, -17702, -17377, -17052, -16726, -16402, -16081, -15773, -15505, -15307, -15193, -15176, -15247, -15395, -15595, -15836, -16107, -16406, -16726, -17057, -17394, -17731, -18065, -18416, -18813, -19277, -19818, -20441, -21129, -21869, -22640, -23420, -24210, -25002, -25781, -26542, -27276, -27970, -28622, -29227, -29778, -30273, -30716, -31103, -31435, -31712, -31938, -32116, -32243, -32323, -32358, -32353, -32307, -32219, -32096, -31938, -31745, -31520, -31265, -30979, -30666, -30328, -29958, -29555, -29100, -28576, -27976, -27294, -26529, -25690, -24785, -23822, -22808, -21734, -20601, -19408, -18134, -16738, -15283, -12622, -8677, -6697, -5049, -3103, -1008};