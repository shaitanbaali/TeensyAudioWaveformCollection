/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0620 256 samples */
 
const int16_t AKWF_0620_256_DATA [256] = 
{432, 1653, 2814, 3950, 5057, 6135, 7189, 8213, 9214, 10191, 11142, 12070, 12976, 13857, 14718, 15557, 16373, 17168, 17944, 18695, 19429, 20141, 20832, 21504, 22155, 22786, 23398, 23990, 24561, 25114, 25647, 26160, 26654, 27129, 27584, 28020, 28436, 28834, 29213, 29571, 29911, 30232, 30533, 30816, 31080, 31323, 31549, 31755, 31941, 32110, 32258, 32388, 32499, 32591, 32663, 32711, 32749, 32781, 30701, 28714, 27350, 26099, 24968, 23919, 22929, 21993, 21097, 20234, 19404, 18601, 17819, 17061, 16321, 15598, 14892, 14201, 13523, 12859, 12206, 11563, 10934, 10314, 9702, 9101, 8507, 7922, 7347, 6776, 6215, 5661, 5113, 4571, 4038, 3508, 2986, 2470, 1959, 1454, 954, 459, -29, -513, -993, -1467, -1936, -2402, -2862, -3318, -3770, -4216, -4659, -5099, -5533, -5963, -6390, -6811, -7231, -7645, -8055, -8463, -8866, -9265, -9662, -10053, -10441, -10827, -11209, -11586, -11961, -12332, -12700, -13065, -13425, -13783, -14137, -14488, -14835, -15181, -15522, -15859, -16195, -16526, -16855, -17180, -17502, -17822, -18139, -18451, -18762, -19068, -19372, -19673, -19971, -20265, -20557, -20847, -21132, -21416, -21696, -21973, -22247, -22519, -22787, -23053, -23316, -23576, -23833, -24086, -24338, -24587, -24832, -25076, -25303, -25606, -25456, -24940, -24905, -24917, -24983, -25079, -25196, -25330, -25474, -25629, -25791, -25958, -26130, -26305, -26482, -26662, -26843, -27024, -27207, -27390, -27571, -27753, -27933, -28113, -28290, -28466, -28641, -28813, -28983, -29151, -29316, -29478, -29637, -29793, -29946, -30097, -30243, -30385, -30525, -30660, -30791, -30918, -31042, -31161, -31275, -31386, -31492, -31593, -31689, -31780, -31867, -31949, -32026, -32097, -32164, -32225, -32280, -32330, -32375, -32413, -32447, -32474, -32495, -32478, -32630, -32010, -27564, -24378, -21876, -19633, -17581, -15677, -13889, -12190, -10572, -9022, -7529, -6091, -4702, -3356, -2055, -767};