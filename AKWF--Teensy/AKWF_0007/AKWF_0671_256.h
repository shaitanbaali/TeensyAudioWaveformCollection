/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0671 256 samples */
 
const int16_t AKWF_0671_256_DATA [256] = 
{345, 1630, 2885, 4140, 5389, 6630, 7863, 9081, 10286, 11478, 12649, 13802, 14936, 16043, 17130, 18191, 19221, 20226, 21199, 22139, 23048, 23922, 24759, 25561, 26324, 27048, 27733, 28377, 28978, 29539, 30054, 30527, 30956, 31339, 31678, 31972, 32220, 32420, 32576, 32686, 32751, 32769, 32741, 32668, 32550, 32388, 32180, 31930, 31637, 31301, 30923, 30505, 30046, 29548, 29013, 28439, 27829, 27184, 26505, 25793, 25050, 24275, 23471, 22641, 21782, 20898, 19991, 19059, 18110, 17138, 16147, 15143, 14119, 13083, 12036, 10975, 9904, 8827, 7742, 6650, 5556, 4458, 3358, 2261, 1160, 66, -1022, -2111, -3192, -4262, -5329, -6384, -7425, -8459, -9478, -10481, -11472, -12445, -13402, -14343, -15264, -16165, -17050, -17912, -18752, -19574, -20370, -21144, -21897, -22623, -23327, -24006, -24658, -25289, -25893, -26470, -27023, -27550, -28050, -28525, -28974, -29397, -29795, -30166, -30512, -30833, -31126, -31395, -31640, -31859, -32054, -32225, -32372, -32495, -32594, -32671, -32726, -32758, -32768, -32758, -32727, -32676, -32605, -32513, -32404, -32276, -32131, -31968, -31788, -31592, -31381, -31152, -30911, -30657, -30386, -30105, -29811, -29503, -29186, -28858, -28519, -28171, -27813, -27446, -27070, -26688, -26298, -25901, -25498, -25090, -24677, -24260, -23835, -23410, -22980, -22546, -22111, -21674, -21234, -20794, -20351, -19910, -19468, -19025, -18584, -18142, -17702, -17263, -16828, -16391, -15960, -15531, -15104, -14681, -14261, -13843, -13432, -13023, -12618, -12218, -11824, -11433, -11048, -10667, -10293, -9924, -9561, -9203, -8853, -8508, -8167, -7835, -7507, -7186, -6874, -6568, -6268, -5974, -5688, -5409, -5138, -4872, -4614, -4365, -4120, -3885, -3657, -3436, -3222, -3015, -2817, -2626, -2443, -2266, -2099, -1938, -1785, -1640, -1502, -1371, -1250, -1135, -1027, -928, -836, -753, -678, -610, -549, -496, -451, -414, -385, -363, -350, -344};