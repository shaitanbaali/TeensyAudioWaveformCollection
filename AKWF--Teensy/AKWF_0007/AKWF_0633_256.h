/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0633 256 samples */
 
const int16_t AKWF_0633_256_DATA [256] = 
{134, 512, 1035, 1668, 2393, 3199, 4074, 5009, 5997, 7031, 8101, 9205, 10335, 11482, 12646, 13819, 14990, 16163, 17327, 18475, 19609, 20719, 21799, 22851, 23865, 24837, 25767, 26647, 27475, 28251, 28967, 29621, 30214, 30740, 31199, 31588, 31905, 32151, 31910, 34212, 22438, -1069, 211, 46, -50, -359, -847, -1455, -2163, -2958, -3828, -4760, -5748, -6785, -7861, -8972, -10110, -11266, -12440, -13619, -14799, -15979, -17148, -18301, -19436, -20545, -21623, -22669, -23673, -24634, -25547, -26408, -27213, -27961, -28645, -29265, -29817, -30300, -30710, -31048, -31309, -31493, -31609, -31600, -30981, -29838, -28393, -26703, -24830, -22824, -20719, -18561, -16390, -14233, -12134, -10121, -8220, -6468, -4885, -3491, -2315, -1365, -657, -197, -21, 84, 635, 1509, 2595, 3849, 5248, 6760, 8359, 10031, 11752, 13497, 15259, 17011, 18737, 20426, 22057, 23615, 25090, 26465, 27727, 28871, 29881, 30749, 31470, 32037, 32156, 33910, 26963, 666, -191, 100, 5, -46, -344, -817, -1407, -2096, -2869, -3716, -4623, -5587, -6600, -7650, -8737, -9850, -10983, -12134, -13293, -14455, -15618, -16773, -17914, -19042, -20145, -21220, -22268, -23276, -24246, -25173, -26050, -26876, -27649, -28362, -29015, -29605, -30128, -30585, -30972, -31287, -31529, -31690, -31812, -31671, -30327, -28104, -25376, -22308, -19058, -15746, -12508, -9462, -6701, -4328, -2422, -1035, -221, 5, -5, -1, 0, 0, 0, 0, 0, 1, 2, 1, 378, 1212, 2303, 3594, 5054, 6644, 8333, 10103, 11926, 13773, 15633, 17479, 19286, 21045, 22729, 24322, 25812, 27180, 28411, 29498, 30427, 31188, 31776, 31609, 34927, 13326, -2406, 199, -1624, -3391, -5509, -7885, -10427, -13069, -15740, -18367, -20900, -23276, -25438, -27349, -28962, -30240, -31140, -31743, -31588, -27253, -19961, -12254, -5589, -1254, 33, -22, -3, 0};