/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0607 256 samples */
 
const int16_t AKWF_0607_256_DATA [256] = 
{656, 2255, 3806, 5346, 6865, 8364, 9840, 11284, 12702, 14088, 15436, 16749, 18025, 19255, 20446, 21590, 22686, 23735, 24733, 25676, 26569, 27405, 28182, 28905, 29568, 30170, 30711, 31190, 31608, 31961, 32250, 32476, 32636, 32722, 32791, 32377, 30995, 29133, 26934, 24478, 21810, 18971, 16011, 12949, 9819, 6659, 3480, 316, -2799, -5861, -8839, -11702, -14447, -17045, -19475, -21732, -23792, -25640, -27273, -28672, -29830, -30743, -31397, -31796, -31932, -31179, -29603, -27639, -25370, -22858, -20151, -17299, -14323, -11258, -8146, -4994, -1839, 1287, 4377, 7400, 10326, 13149, 15845, 18386, 20769, 22971, 24975, 26775, 28353, 29700, 30812, 31677, 32287, 32651, 32730, 32241, 31359, 30279, 29034, 27652, 26158, 24565, 22883, 21132, 19314, 17441, 15527, 13573, 11588, 9587, 7567, 5538, 3514, 1490, -519, -2506, -4475, -6412, -8309, -10171, -11983, -13741, -15446, -17088, -18663, -20170, -21602, -22954, -24227, -25412, -26510, -27518, -28430, -29246, -29966, -30583, -31099, -31512, -31819, -32017, -32140, -31962, -30874, -29246, -27304, -25097, -22683, -20111, -17396, -14578, -11689, -8736, -5757, -2776, 200, 3137, 6020, 8838, 11560, 14175, 16673, 19028, 21231, 23273, 25133, 26806, 28286, 29553, 30611, 31449, 32060, 32445, 32606, 32374, 31781, 31027, 30146, 29156, 28075, 26920, 25692, 24404, 23063, 21669, 20235, 18763, 17255, 15720, 14163, 12580, 10984, 9374, 7753, 6130, 4504, 2876, 1258, -352, -1956, -3540, -5111, -6661, -8185, -9686, -11159, -12596, -14002, -15374, -16702, -17993, -19239, -20437, -21591, -22695, -23743, -24742, -25685, -26571, -27399, -28167, -28873, -29519, -30102, -30619, -31073, -31460, -31781, -32036, -32223, -32341, -32401, -32324, -31874, -31199, -30393, -29473, -28459, -27367, -26201, -24972, -23689, -22353, -20973, -19556, -18100, -16614, -15103, -13566, -12012, -10446, -8863, -7274, -5682, -4086, -2498, -882};