/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0656 256 samples */
 
const int16_t AKWF_0656_256_DATA [256] = 
{23306, 23313, 23317, 23321, 23325, 23328, 23328, 23330, 23330, 23329, 23328, 23327, 23324, 23322, 23320, 23317, 23314, 23310, 23307, 23303, 23298, 23294, 23289, 23285, 23279, 23275, 22875, 24999, 13741, -1715, 491, 76, 73, 69, 66, 64, 61, 58, 56, 55, 53, 51, 51, 49, 47, 47, 45, 46, 44, 42, 43, 43, 41, 40, 41, 41, 41, 40, 41, 38, 37, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 37, 38, 35, 34, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 615, -2508, 19319, 35217, 32206, 32762, 32760, 32756, 32752, 32748, 32744, 32738, 32733, 32728, 32722, 32715, 32708, 32702, 32696, 32687, 32681, 32673, 32666, 32658, 32651, 32643, 32635, 32627, 32390, 33501, 29380, -20081, -24200, -23087, -23320, -23323, -23325, -23327, -23329, -23328, -23329, -23326, -23325, -23323, -23321, -23319, -23316, -23313, -23309, -23305, -23301, -23297, -23293, -23289, -23283, -23279, -23274, -22876, -24985, -13822, 1682, -482, -76, -71, -69, -66, -63, -61, -58, -56, -54, -53, -51, -49, -48, -47, -47, -45, -43, -44, -43, -42, -41, -41, -42, -39, -38, -39, -38, -38, -38, -38, -39, -38, -35, -36, -36, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -615, 2507, -19318, -35215, -32204, -32761, -32758, -32754, -32751, -32747, -32741, -32737, -32732, -32725, -32720, -32714, -32708, -32700, -32693, -32687, -32679, -32672, -32664, -32656, -32649, -32641, -32633, -32625, -32617, -32609, -32601};