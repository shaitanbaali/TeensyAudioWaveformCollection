/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0628 256 samples */
 
const int16_t AKWF_0628_256_DATA [256] = 
{9816, 10428, 11029, 11630, 12231, 12834, 13436, 14037, 14640, 15243, 15844, 16446, 17049, 17650, 18252, 18855, 19456, 20058, 20661, 21262, 21864, 22467, 23068, 23670, 24273, 24874, 25477, 26079, 26680, 27283, 27884, 28486, 29089, 29690, 30292, 30895, 31451, 32176, 32116, 24239, 7689, -1161, 295, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -40, 146, -534, -9260, -10582, -10990, -11631, -12232, -12834, -13437, -14038, -14640, -15243, -15845, -16446, -17049, -17650, -18252, -18855, -19456, -20058, -20661, -21262, -21864, -22467, -23068, -23671, -24273, -24874, -25477, -26079, -26680, -27283, -27885, -28486, -29089, -29691, -30292, -30895, -31451, -32176, -32116, -24239, -7690, 1160, -296, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};