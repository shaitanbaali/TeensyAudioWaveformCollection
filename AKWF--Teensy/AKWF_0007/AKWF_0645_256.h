/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0645 256 samples */
 
const int16_t AKWF_0645_256_DATA [256] = 
{5106, 8422, 10726, 12689, 14405, 15947, 17356, 18651, 19854, 20978, 22025, 23009, 23932, 24797, 25610, 26373, 27084, 27752, 28374, 28950, 29485, 29977, 30427, 30837, 31207, 31535, 31826, 32078, 32289, 32462, 32596, 32636, 32960, 31733, 26446, 23634, 21439, 19557, 17892, 16394, 15022, 13753, 12576, 11476, 10446, 9482, 8576, 7725, 6929, 6181, 5482, 4829, 4220, 3655, 3134, 2653, 2215, 1818, 1460, 1142, 863, 623, 423, 262, 139, 55, 6, 16, 49, 60, 70, 76, 80, 82, 83, 81, 79, 77, 72, 67, 62, 56, 49, 42, 34, 28, 19, 13, -7, 177, 322, 365, 398, 415, 425, 428, 427, 420, 412, 400, 386, 371, 354, 337, 319, 300, 281, 261, 241, 221, 202, 183, 164, 146, 128, 112, 96, 80, 67, 54, 42, 31, 23, 15, 8, -13, 19, -64, -4878, -8486, -10711, -12689, -14405, -15948, -17356, -18651, -19855, -20979, -22025, -23009, -23933, -24797, -25610, -26373, -27085, -27753, -28374, -28950, -29485, -29977, -30427, -30837, -31207, -31535, -31826, -32078, -32289, -32462, -32596, -32636, -32960, -31733, -26446, -23634, -21440, -19557, -17893, -16395, -15022, -13753, -12576, -11476, -10446, -9483, -8577, -7726, -6930, -6182, -5482, -4830, -4221, -3656, -3135, -2654, -2216, -1819, -1460, -1143, -864, -624, -424, -263, -140, -56, -9, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};