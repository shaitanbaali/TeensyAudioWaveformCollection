/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0629 256 samples */
 
const int16_t AKWF_0629_256_DATA [256] = 
{977, 2398, 3790, 5185, 6580, 7976, 9375, 10769, 12166, 13564, 14958, 16355, 17753, 19147, 20545, 21942, 23337, 24734, 26132, 27526, 28924, 30303, 31774, 32720, 32487, 32266, 32047, 31825, 31601, 31379, 31157, 30935, 30713, 30491, 30269, 30046, 29823, 29601, 29379, 29157, 28935, 28712, 28491, 28268, 28045, 27823, 27601, 27379, 27157, 26929, 26729, 26394, 25493, 24541, 23605, 22662, 21720, 20780, 19838, 18896, 17956, 17013, 16072, 15132, 14189, 13248, 12307, 11364, 10424, 9483, 8540, 7600, 6658, 5716, 4776, 3834, 2891, 1956, 1000, 118, -21, 7, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -10, 33, -595, -1703, -2741, -3794, -4847, -5897, -6950, -8003, -9053, -10107, -11159, -12209, -13263, -14315, -15366, -16419, -17471, -18521, -19575, -20627, -21678, -22731, -23783, -24834, -25887, -26938, -27991, -29044, -30094, -31131, -32254, -32695, -32370, -32122, -31861, -31599, -31337, -31075, -30813, -30551, -30290, -30028, -29765, -29504, -29242, -28979, -28717, -28455, -28193, -27931, -27669, -27407, -27145, -26875, -26651, -25925, -24790, -23711, -22621, -21530, -20441, -19351, -18260, -17171, -16081, -14990, -13902, -12811, -11720, -10632, -9541, -8450, -7362, -6271, -5180, -4092, -3001, -1922, -783, 4, -3, -3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};