/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0624 256 samples */
 
const int16_t AKWF_0624_256_DATA [256] = 
{870, 3735, 6567, 9381, 12120, 14738, 17189, 19413, 21379, 23042, 24363, 25323, 25899, 26076, 26071, 26072, 26063, 26029, 25943, 25764, 25434, 24886, 24052, 22849, 21214, 19093, 16440, 13257, 9566, 5408, 890, -3869, -8735, -13518, -18049, -22153, -25641, -28376, -30241, -31116, -31212, -31201, -31205, -31203, -31198, -31185, -31159, -31114, -31039, -30924, -30756, -30522, -30207, -29797, -29280, -28639, -27866, -26953, -25891, -24683, -23331, -21839, -20222, -18494, -16673, -14792, -12874, -10948, -9055, -7223, -5486, -3887, -2452, -1210, -195, 579, 1093, 1323, 1363, 1036, -124, -744, -699, -694, -623, -411, 47, 842, 1994, 3432, 4985, 6406, 7441, 7870, 7881, 7802, 7261, 5493, 1722, -4227, -11462, -18215, -22303, -23004, -22924, -22951, -22949, -22943, -22928, -22898, -22843, -22753, -22612, -22405, -22114, -21722, -21205, -20548, -19732, -18739, -17558, -16181, -14597, -12813, -10834, -8665, -6334, -3861, -1269, 1394, 4098, 6802, 9450, 12003, 14416, 16632, 18619, 20333, 21734, 22800, 23509, 23832, 23864, 23860, 23857, 23835, 23771, 23629, 23353, 22878, 22132, 21033, 19509, 17502, 14959, 11873, 8260, 4159, -327, -5083, -9970, -14793, -19379, -23543, -27092, -29879, -31783, -32676, -32773, -32762, -32768, -32767, -32766, -32764, -32759, -32750, -32734, -32711, -32676, -32625, -32555, -32462, -32341, -32186, -31991, -31753, -31464, -31119, -30714, -30242, -29700, -29084, -28390, -27617, -26762, -25826, -24810, -23714, -22542, -21302, -19994, -18627, -17214, -15758, -14269, -12765, -11251, -9741, -8254, -6796, -5382, -4032, -2749, -1553, -456, 534, 1405, 2147, 2754, 3218, 3535, 3697, 3724, 3690, 3327, 1842, -1680, -7464, -14410, -20366, -22952, -23002, -23000, -23010, -23006, -22996, -22975, -22934, -22862, -22746, -22571, -22319, -21971, -21507, -20904, -20147, -19215, -18090, -16764, -15230, -13479, -11519, -9360, -7013, -4509, -1810};