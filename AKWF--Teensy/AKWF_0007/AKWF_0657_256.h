/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0657 256 samples */
 
const int16_t AKWF_0657_256_DATA [256] = 
{23246, 23251, 23256, 23259, 23262, 23264, 23265, 23265, 23265, 23265, 23262, 23261, 23260, 23257, 23254, 23101, 23901, 20659, 359, -59, 105, 52, 49, 47, 46, 43, 42, 41, 39, 37, 37, 34, 35, 34, 32, 33, 33, 30, 29, 30, 29, 30, 29, 27, 28, 28, 28, 28, 28, 28, 28, 28, 28, 27, 28, 26, 24, 25, 25, 22, 121, 138, 123, 115, 107, 99, 91, 84, 79, 71, 66, 60, 54, 50, 46, 42, 39, 35, 32, 30, 28, 27, 25, 24, 25, 24, 25, 24, 24, 25, 24, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 523, -2203, 11286, 35088, 32245, 32764, 32761, 32759, 32755, 32751, 32746, 32742, 32736, 32730, 32724, 32718, 32712, 32706, 32469, 33581, 29461, -20020, -24140, -23025, -23257, -23260, -23262, -23263, -23262, -23262, -23263, -23261, -23259, -23257, -23255, -23251, -23099, -23899, -20657, -357, 60, -104, -51, -48, -47, -45, -43, -41, -39, -38, -36, -35, -34, -34, -33, -30, -31, -31, -30, -28, -29, -28, -28, -29, -28, -26, -25, -26, -25, -25, -25, -25, -25, -25, -25, -25, -25, -25, -26, -25, -23, -23, -24, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -522, 2204, -11285, -35086, -32244, -32762, -32760, -32757, -32753, -32749, -32745, -32739, -32733, -32729, -32724, -32716, -32709, -32703, -32697, -32689, -32682};