/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0601 256 samples */
 
const int16_t AKWF_0601_256_DATA [256] = 
{4331, 8095, 7393, 7524, 7524, 7524, 7523, 7521, 7519, 7518, 7516, 7514, 7511, 7509, 7507, 7504, 7502, 7498, 7496, 7492, 7489, 7486, 7483, 7498, 7414, 7690, 12705, 13613, 13853, 14259, 14636, 15014, 15394, 15770, 16148, 16525, 16901, 17277, 17655, 18030, 18406, 18782, 19157, 19532, 19908, 20282, 20657, 21031, 21404, 21778, 22153, 22525, 22898, 23271, 23644, 24017, 24390, 24761, 25133, 25506, 25876, 26248, 26619, 26990, 27361, 27731, 28101, 28472, 28841, 29211, 29581, 29950, 30319, 30688, 31056, 31425, 31794, 32148, 32574, 32542, 31793, 31085, 30370, 29658, 28942, 28227, 27513, 26798, 26084, 25371, 24656, 23942, 23229, 22515, 21803, 21090, 20377, 19665, 18954, 18241, 17530, 16819, 16107, 15398, 14688, 13904, 13580, 11358, -767, -1920, -2473, -3206, -3900, -4596, -5291, -5983, -6677, -7370, -8061, -8753, -9443, -10132, -10822, -11511, -12198, -12887, -13574, -14262, -14948, -15634, -16319, -17005, -17689, -18373, -19058, -19740, -20424, -21108, -21789, -22470, -23153, -23832, -24513, -25194, -25873, -26545, -27254, -27783, -27579, -27307, -27052, -26791, -26531, -26272, -26011, -25750, -25490, -25229, -24968, -24708, -24447, -24186, -23926, -23665, -23405, -23144, -22883, -22622, -22362, -22101, -21841, -21581, -21320, -21061, -20800, -20541, -20281, -20022, -19762, -19502, -19243, -18984, -18724, -18466, -18207, -17949, -17690, -17432, -17173, -16914, -16656, -16399, -16141, -15883, -15626, -15368, -15111, -14853, -14596, -14340, -14083, -13826, -13570, -13313, -13057, -12801, -12545, -12288, -12033, -11777, -11522, -11267, -11011, -10756, -10503, -10247, -9992, -9738, -9484, -9229, -8975, -8721, -8468, -8214, -7960, -7707, -7454, -7200, -6947, -6694, -6441, -6189, -5937, -5684, -5433, -5181, -4928, -4676, -4425, -4173, -3922, -3671, -3419, -3168, -2918, -2666, -2416, -2166, -1916, -1666, -1416, -1166, -916, -666, -418, -164};