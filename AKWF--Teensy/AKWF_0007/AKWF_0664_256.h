/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0664 256 samples */
 
const int16_t AKWF_0664_256_DATA [256] = 
{1033, 2928, 4634, 6221, 7697, 9073, 10360, 11558, 12677, 13724, 14696, 15601, 16441, 17215, 17931, 18586, 19180, 19719, 20202, 20628, 21000, 21317, 21581, 21792, 21950, 21933, 22622, 17141, 10756, 8141, 5732, 3742, 1999, 446, -962, -2256, -3444, -4546, -5573, -6528, -7419, -8252, -9028, -9753, -10429, -11055, -11639, -12179, -12675, -13130, -13545, -13919, -14256, -14555, -14814, -15038, -15225, -15374, -15487, -15493, -15899, -13588, -9837, -8390, -7074, -5995, -5050, -4203, -3433, -2721, -2064, -1450, -863, -308, 219, 721, 1202, 1660, 2098, 2519, 2921, 3307, 3678, 4034, 4376, 4705, 5020, 5324, 5616, 5894, 6164, 6421, 6668, 6905, 7132, 7348, 7555, 7752, 7939, 8118, 8288, 8448, 8600, 8743, 8876, 9002, 9118, 9226, 9327, 9418, 9501, 9577, 9644, 9703, 9754, 9796, 9831, 9858, 9877, 9895, 9860, 10439, 10940, 11165, 11368, 11538, 11687, 11818, 11938, 12044, 12163, 12301, 12408, 12508, 12602, 12690, 12773, 12852, 12929, 13002, 13071, 13137, 13201, 13263, 13321, 13378, 13433, 13484, 13535, 13583, 13630, 13675, 13717, 13758, 13797, 13834, 13870, 13904, 13937, 13968, 13997, 14025, 14051, 14075, 14098, 14119, 14139, 14158, 14175, 14190, 14203, 14215, 14226, 14235, 14243, 14248, 14253, 14256, 14257, 14169, 14620, 10994, 6506, 4697, 3030, 1659, 457, -612, -1583, -2472, -3290, -4048, -4752, -5407, -6018, -6589, -7120, -7616, -8077, -8505, -8901, -9269, -9604, -9912, -10193, -10444, -10669, -10868, -11040, -11186, -11307, -11401, -11481, -11509, -11539, -15655, -18408, -19855, -21142, -22224, -23176, -24031, -24807, -25517, -26176, -26783, -27348, -27876, -28367, -28825, -29253, -29650, -30020, -30365, -30682, -30977, -31246, -31492, -31715, -31916, -32096, -32253, -32389, -32504, -32599, -32671, -32718, -32642, -33255, -23839, -15659, -11928, -8529, -5688, -3203, -940};