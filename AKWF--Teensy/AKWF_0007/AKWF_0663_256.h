/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0663 256 samples */
 
const int16_t AKWF_0663_256_DATA [256] = 
{2275, 5220, 7190, 8762, 10064, 11179, 12159, 13028, 13815, 14532, 15189, 15797, 16362, 16888, 17381, 17845, 18281, 18694, 19084, 19453, 19805, 20138, 20455, 20757, 21044, 21319, 21580, 21830, 22068, 22295, 22512, 22719, 22916, 23104, 23283, 23454, 23615, 23770, 23917, 24055, 24187, 24311, 24428, 24539, 24642, 24738, 24829, 24912, 24990, 25062, 25127, 25187, 25240, 25287, 25329, 25366, 25396, 25421, 25439, 25451, 25231, 26460, 20729, 4878, 3469, 1875, 772, -113, -855, -1500, -2069, -2578, -3041, -3464, -3853, -4214, -4551, -4864, -5159, -5437, -5698, -5946, -6181, -6403, -6614, -6815, -7006, -7189, -7363, -7529, -7687, -7838, -7983, -8120, -8253, -8378, -8498, -8612, -8722, -8826, -8925, -9019, -9109, -9193, -9274, -9350, -9422, -9490, -9554, -9613, -9670, -9722, -9770, -9814, -9855, -9893, -9925, -9956, -9982, -10006, -10026, -10042, -10054, -10064, -10056, -10037, -10276, -586, 3389, 3916, 4729, 5303, 5773, 6171, 6518, 6823, 7095, 7339, 7558, 7758, 7941, 8106, 8256, 8394, 8518, 8632, 8735, 8826, 8910, 8983, 9048, 9105, 9153, 9194, 9226, 9250, 9046, 10241, 4711, -10598, -11951, -13482, -14534, -15375, -16074, -16675, -17201, -17665, -18080, -18455, -18793, -19100, -19380, -19635, -19869, -20081, -20273, -20448, -20607, -20750, -20877, -20991, -21090, -21176, -21250, -21311, -21360, -21396, -21397, -21346, -21914, -2515, 5532, 6594, 8237, 9395, 10344, 11151, 11851, 12468, 13017, 13510, 13956, 14359, 14727, 15061, 15366, 15644, 15896, 16126, 16333, 16521, 16689, 16838, 16969, 17084, 17181, 17262, 17328, 17377, 17052, 19006, 9971, -15044, -17256, -19756, -21477, -22851, -23994, -24976, -25836, -26595, -27275, -27887, -28440, -28944, -29402, -29819, -30200, -30547, -30863, -31150, -31409, -31642, -31852, -32039, -32201, -32344, -32464, -32563, -32643, -32703, -32713, -32651, -33446, -7194};