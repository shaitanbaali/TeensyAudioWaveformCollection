/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0670 256 samples */
 
const int16_t AKWF_0670_256_DATA [256] = 
{748, 1836, 2900, 3962, 5021, 6074, 7122, 8160, 9191, 10212, 11220, 12220, 13204, 14171, 15127, 16065, 16984, 17888, 18771, 19632, 20475, 21295, 22089, 22864, 23612, 24334, 25031, 25703, 26346, 26961, 27548, 28105, 28633, 29132, 29598, 30035, 30440, 30813, 31155, 31463, 31740, 31985, 32196, 32374, 32519, 32630, 32709, 32755, 32768, 32748, 32696, 32612, 32495, 32345, 32165, 31952, 31709, 31436, 31130, 30796, 30432, 30040, 29619, 29172, 28696, 28193, 27666, 27112, 26534, 25932, 25306, 24660, 23991, 23299, 22591, 21860, 21112, 20347, 19563, 18764, 17952, 17124, 16280, 15427, 14560, 13684, 12798, 11901, 10998, 10087, 9167, 8244, 7317, 6384, 5449, 4513, 3573, 2635, 1696, 759, -175, -1107, -2038, -2961, -3882, -4797, -5704, -6603, -7498, -8379, -9255, -10121, -10974, -11820, -12651, -13470, -14278, -15072, -15851, -16620, -17372, -18106, -18829, -19535, -20223, -20896, -21552, -22189, -22811, -23414, -24000, -24567, -25115, -25646, -26157, -26649, -27123, -27578, -28013, -28429, -28825, -29202, -29559, -29898, -30216, -30516, -30797, -31058, -31300, -31523, -31727, -31913, -32080, -32227, -32357, -32469, -32562, -32638, -32696, -32737, -32761, -32768, -32760, -32733, -32692, -32634, -32562, -32472, -32368, -32251, -32119, -31973, -31813, -31638, -31453, -31253, -31042, -30819, -30583, -30336, -30078, -29809, -29531, -29242, -28943, -28634, -28317, -27990, -27657, -27313, -26964, -26606, -26242, -25871, -25493, -25108, -24719, -24324, -23922, -23519, -23109, -22694, -22276, -21855, -21431, -21003, -20571, -20137, -19703, -19265, -18824, -18384, -17940, -17496, -17054, -16607, -16162, -15718, -15273, -14825, -14380, -13938, -13494, -13052, -12610, -12172, -11733, -11297, -10862, -10431, -10001, -9573, -9148, -8725, -8306, -7888, -7473, -7063, -6656, -6250, -5850, -5452, -5056, -4668, -4281, -3898, -3518, -3144, -2774, -2408, -2044, -1685, -1332, -980, -653, -207};