/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0659 256 samples */
 
const int16_t AKWF_0659_256_DATA [256] = 
{467, 1373, 2204, 2993, 3743, 4461, 5152, 5812, 6451, 7066, 7660, 8234, 8790, 9327, 9847, 10351, 10837, 11309, 11765, 12206, 12633, 13045, 13443, 13828, 14198, 14554, 14897, 15227, 15543, 15848, 16137, 16414, 16677, 16929, 17167, 17392, 17604, 17804, 17992, 18165, 18325, 18475, 18611, 18734, 18844, 18942, 19027, 19099, 19159, 19207, 19241, 18490, 22758, -15073, -32144, -25396, -24162, -22366, -20725, -19203, -17773, -16417, -15129, -13897, -12712, -11576, -10480, -9421, -8401, -7413, -6457, -5534, -4637, -3769, -2931, -2118, -1330, -571, 165, 877, 1563, 2227, 2869, 3483, 4078, 4649, 5196, 5722, 6224, 6705, 7164, 7600, 8013, 8405, 8776, 9123, 9450, 9754, 10037, 10297, 10536, 10754, 10950, 11122, 11275, 11407, 11514, 11602, 11668, 11689, 11824, 11001, 9542, 8655, 7849, 7132, 6470, 5853, 5272, 4719, 4193, 3690, 3205, 2740, 2292, 1858, 1440, 1036, 644, 266, -100, -455, -799, -1131, -1453, -1764, -2065, -2356, -2636, -2908, -3169, -3420, -3662, -3895, -4118, -4332, -4536, -4731, -4918, -5094, -5261, -5420, -5569, -5709, -5841, -5963, -6076, -6179, -6275, -6361, -6438, -6505, -6564, -6615, -6656, -6688, -6710, -6725, -6730, -6729, -6727, -6726, -6724, -6722, -6721, -6719, -6717, -6715, -6714, -6712, -6710, -6708, -6707, -6705, -6704, -6702, -6700, -6698, -6697, -6695, -6693, -6691, -6689, -6688, -6686, -6684, -6682, -6681, -6678, -6677, -6675, -6673, -6671, -6670, -6668, -6666, -6665, -6663, -6661, -6659, -6658, -6656, -6654, -6652, -6651, -6649, -6647, -6645, -6644, -6641, -6639, -6637, -6636, -6634, -6632, -6631, -6629, -6627, -6625, -6624, -6622, -6620, -6618, -6617, -6615, -6613, -6611, -6610, -6607, -6606, -6604, -6603, -6601, -6599, -6597, -6596, -6593, -6591, -6590, -6569, -6651, -6267, -4146, -2696, -1527, -465};