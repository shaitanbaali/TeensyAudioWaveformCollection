/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0627 256 samples */
 
const int16_t AKWF_0627_256_DATA [256] = 
{2698, 3134, 3562, 3990, 4418, 4848, 5278, 5705, 6134, 6563, 6991, 7421, 7849, 8277, 8706, 9136, 9565, 9992, 10422, 10851, 11280, 11709, 12136, 12566, 12995, 13424, 13853, 14281, 14710, 15140, 15568, 15996, 16425, 16854, 17283, 17711, 18139, 18568, 18999, 19427, 19855, 20285, 20713, 21142, 21571, 21999, 22428, 22857, 23287, 23715, 24143, 24572, 25001, 25431, 25858, 26287, 26716, 27145, 27575, 28002, 28431, 28861, 29290, 29718, 30147, 30575, 31004, 31433, 31854, 32302, 32652, 31630, 30235, 28913, 27581, 26245, 24908, 23575, 22240, 20903, 19571, 18235, 16899, 15566, 14230, 12894, 11562, 10225, 8890, 7557, 6211, 4937, 3374, 155, -42, 14, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -11, 36, -133, -2550, -3176, -3552, -3991, -4419, -4849, -5278, -5706, -6134, -6564, -6992, -7421, -7850, -8278, -8707, -9137, -9566, -9993, -10423, -10851, -11281, -11710, -12137, -12566, -12995, -13425, -13853, -14281, -14711, -15140, -15568, -15996, -16426, -16854, -17283, -17712, -18140, -18569, -18999, -19427, -19855, -20285, -20713, -21142, -21572, -21999, -22428, -22858, -23287, -23715, -24144, -24572, -25002, -25431, -25858, -26287, -26716, -27145, -27575, -28002, -28431, -28861, -29290, -29718, -30147, -30575, -31004, -31433, -31854, -32302, -32652, -31630, -30235, -28914, -27581, -26245, -24908, -23576, -22240, -20904, -19572, -18235, -16900, -15567, -14230, -12894, -11562, -10225, -8891, -7558, -6212, -4937, -3375, -156, 41, -15, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};