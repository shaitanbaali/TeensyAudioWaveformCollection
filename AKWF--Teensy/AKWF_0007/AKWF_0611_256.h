/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0611 256 samples */
 
const int16_t AKWF_0611_256_DATA [256] = 
{1707, 6265, 10741, 15103, 19214, 22959, 26230, 28916, 30944, 32247, 32775, 32505, 31431, 29579, 26975, 23686, 19801, 15394, 10597, 5522, 278, -1793, -947, 822, 3231, 5943, 8704, 11272, 13447, 15074, 16008, 16163, 15483, 13964, 11636, 8565, 4873, 689, -3828, -8478, -13087, -17458, -21391, -24732, -27323, -29040, -29801, -29557, -28298, -26050, -22888, -18928, -14291, -9202, -3571, 570, 1067, 986, 455, -414, -1519, -2783, -4130, -5501, -6840, -8089, -9202, -10141, -10864, -11347, -11562, -11498, -11145, -10499, -9573, -8373, -6921, -5247, -3374, -1341, 803, 3030, 5287, 7523, 9703, 11771, 13684, 15407, 16896, 18116, 19045, 19654, 19929, 19859, 19441, 18678, 17578, 16162, 14450, 12470, 10260, 7855, 5299, 2647, -100, -1465, -1401, -871, 13, 1120, 2356, 3632, 4870, 6009, 6983, 7742, 8245, 8457, 8359, 7940, 7200, 6153, 4815, 3224, 1418, -558, -2647, -4793, -6939, -9017, -10970, -12744, -14277, -15528, -16458, -17030, -17226, -17033, -16452, -15489, -14162, -12507, -10556, -8357, -5974, -3451, -862, 1246, 87, -1356, -2741, -4381, -6132, -7932, -9725, -11444, -13036, -14452, -15642, -16567, -17197, -17498, -17452, -17047, -16279, -15144, -13654, -11832, -9695, -7274, -4617, -1755, 1260, 4370, 7534, 10687, 13770, 16676, 19300, 21651, 23689, 25368, 26653, 27523, 27955, 27933, 27460, 26536, 25175, 23390, 21217, 18688, 15835, 12717, 9379, 5896, 2201, -936, -1118, 240, 2263, 4721, 7362, 10003, 12471, 14604, 16287, 17409, 17888, 17674, 16743, 15105, 12780, 9836, 6361, 2445, -1776, -6166, -10599, -14909, -18951, -22604, -25720, -28194, -29941, -30882, -30979, -30215, -28602, -26175, -22997, -19171, -14792, -10012, -4881, 25, 483, -928, -2870, -5317, -8003, -10767, -13443, -15883, -17980, -19618, -20710, -21197, -21031, -20193, -18680, -16522, -13763, -10467, -6726, -2536};