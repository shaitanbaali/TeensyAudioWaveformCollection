/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0610 256 samples */
 
const int16_t AKWF_0610_256_DATA [256] = 
{2423, 5979, 9463, 12957, 16448, 19941, 23439, 26845, 30696, 31771, 28077, 24609, 21110, 17612, 14105, 10598, 7118, 3555, 298, -197, -104, -135, -139, -144, -147, -151, -154, -157, -160, -162, -164, -166, -168, -169, -170, -172, -173, -175, -175, -176, -178, -178, -179, -178, -179, -180, -180, -179, -181, -182, -181, -181, -181, -182, -181, -182, -182, -183, -182, -182, -182, -182, -182, -182, -182, -182, -182, -182, -182, -182, -182, -183, -182, -181, -182, -181, -181, -181, -181, -181, -181, -181, -181, -181, -181, -181, -181, -181, -181, -181, -182, -180, -179, -180, -179, -179, -179, -179, -179, -179, -179, -179, -179, -179, -179, -180, -179, -179, -178, -179, -178, -178, -178, -178, -178, -178, -178, -178, -178, -178, -178, -179, -178, -177, -178, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -177, -178, -176, -175, -176, -175, -175, -175, -175, -175, -175, -175, -175, -175, -175, -175, -176, -175, -175, -174, -175, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -174, -175, -174, -172, -173, -173, -172, -172, -172, -172, -172, -172, -172, -172, -172, -172, -172, -173, -172, -171, -172, -171, -171, -171, -171, -171, -171, -171, -171, -171, -171, -171, -172, -207, -46, -1505, -4729, -7771, -10836, -13909, -16981, -20046, -23068, -26329, -28423, -25693, -22532, -19485, -16402, -13322, -10247, -7169, -4101, -960, 39, -110, -70, -66, -62, -59, -56, -52, -50, -47, -45, -43, -42, -40, -38, -36, -35, -33, -32, -31, -30, -30, -29, -28, -29, -28, -27, -26, -26, -26, -25, -24, -25, -24, -24};