/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0654 256 samples */
 
const int16_t AKWF_0654_256_DATA [256] = 
{1841, 5154, 8269, 11212, 13925, 16365, 18496, 20268, 21661, 22651, 23211, 23358, 23327, 23252, 23095, 22841, 22482, 22006, 21410, 20697, 19861, 18912, 17863, 16717, 15491, 14204, 12865, 11502, 10133, 8772, 7447, 6177, 4981, 3879, 2891, 2027, 1309, 743, 341, 109, 47, 49, 46, 45, 43, 43, 42, 40, 41, 39, 37, 38, 37, 38, 35, 34, 35, 35, 35, 34, 35, 33, 32, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 32, 41, 112, 283, 580, 1021, 1622, 2390, 3326, 4435, 5704, 7125, 8687, 10368, 12148, 14007, 15912, 17840, 19766, 21650, 23471, 25201, 26803, 28259, 29545, 30634, 31514, 32168, 32585, 32752, 32738, 32608, 32301, 31772, 30987, 29919, 28558, 26899, 24938, 22695, 20190, 17439, 14487, 11369, 8115, 4790, 1439, -1896, -5147, -8270, -11218, -13933, -16373, -18503, -20276, -21669, -22659, -23219, -23365, -23335, -23260, -23103, -22850, -22490, -22014, -21418, -20705, -19869, -18920, -17871, -16725, -15499, -14212, -12873, -11511, -10141, -8780, -7456, -6186, -4988, -3888, -2900, -2036, -1318, -752, -349, -118, -56, -57, -54, -53, -52, -51, -49, -48, -49, -47, -46, -46, -47, -44, -43, -44, -43, -43, -43, -44, -43, -41, -42, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42, -41, -50, -120, -292, -589, -1029, -1630, -2398, -3335, -4443, -5712, -7133, -8695, -10375, -12154, -14015, -15919, -17848, -19773, -21658, -23479, -25209, -26810, -28267, -29552, -30641, -31521, -32176, -32592, -32760, -32744, -32615, -32309, -31780, -30994, -29925, -28564, -26905, -24946, -22703, -20199, -17447, -14495, -11376, -8129, -4813, -1402};