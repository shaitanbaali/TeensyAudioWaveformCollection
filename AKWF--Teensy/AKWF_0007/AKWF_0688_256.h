/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0688 256 samples */
 
const int16_t AKWF_0688_256_DATA [256] = 
{503, 1296, 2073, 2850, 3626, 4400, 5174, 5944, 6715, 7483, 8250, 9015, 9780, 10540, 11302, 12062, 12818, 13574, 14330, 15082, 15835, 16584, 17331, 18079, 18815, 19448, 19858, 20058, 20157, 20202, 20182, 20090, 19967, 19867, 19796, 19748, 19723, 19740, 19811, 19935, 20099, 20306, 20557, 20856, 21195, 21567, 21974, 22413, 22881, 23375, 23893, 24429, 24985, 25560, 26148, 26751, 27365, 27988, 28623, 29264, 29912, 30567, 31226, 31889, 32508, 32782, 32375, 31316, 29935, 28386, 26648, 24692, 22591, 20516, 18547, 16656, 14832, 13109, 11541, 10146, 8902, 7787, 6808, 5979, 5294, 4734, 4285, 3941, 3702, 3562, 3505, 3522, 3607, 3759, 3970, 4232, 4537, 4884, 5269, 5690, 6138, 6612, 7110, 7629, 8165, 8719, 9264, 9713, 9975, 10077, 10103, 10090, 10031, 9918, 9765, 9622, 9509, 9424, 9359, 9322, 9327, 9382, 9482, 9618, 9795, 10012, 10273, 10570, 10901, 11262, 11653, 12072, 12518, 12985, 13475, 13981, 14506, 15049, 15603, 16170, 16750, 17338, 17938, 18545, 19158, 19778, 20406, 21034, 21652, 22055, 21811, 20755, 19175, 17359, 15359, 13129, 10659, 8083, 5581, 3029, 1649, -11064, -17521, -15585, -14009, -12060, -11005, -11122, -11528, -11808, -11832, -11563, -11052, -10336, -9471, -8485, -7426, -6305, -5148, -3969, -2773, -1577, -380, 774, 728, -1193, -3862, -7048, -10555, -13841, -16869, -19595, -21873, -23750, -25273, -26427, -27259, -27830, -28156, -28270, -28216, -28014, -27685, -27255, -26740, -26153, -25507, -24813, -24083, -23317, -22544, -21956, -21714, -21672, -21706, -21833, -22035, -22215, -22340, -22424, -22456, -22405, -22272, -22075, -21811, -21477, -21082, -20635, -20141, -19600, -19022, -18412, -17772, -17105, -16420, -15715, -14993, -14261, -13516, -12760, -12000, -11230, -10458, -9682, -8900, -8118, -7334, -6549, -5763, -4976, -4190, -3403, -2620, -1834, -1054, -257};