/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0686 256 samples */
 
const int16_t AKWF_0686_256_DATA [256] = 
{4839, 8472, 12633, 15465, 16500, 17264, 18227, 19409, 20731, 22098, 23441, 24723, 25917, 27009, 27996, 28878, 29651, 30326, 30901, 31384, 31783, 32102, 32346, 32523, 32638, 32697, 32706, 32671, 32595, 32484, 32343, 32176, 31986, 31778, 31485, 31630, 28591, 23449, 22252, 19071, 16030, 14108, 12982, 12205, 11490, 10705, 9810, 8820, 7766, 6672, 5569, 4481, 3416, 2391, 1415, 489, -380, -1192, -1946, -2640, -3275, -3854, -4376, -4844, -5258, -5621, -5935, -6203, -6427, -6608, -6749, -6853, -6922, -6958, -6965, -6942, -6894, -6821, -6727, -6613, -6481, -6334, -6172, -5999, -5813, -5619, -5417, -5208, -4994, -4777, -4556, -4334, -4112, -3889, -3668, -3447, -3229, -3015, -2805, -2598, -2397, -2202, -2010, -1825, -1646, -1473, -1308, -1147, -994, -849, -709, -577, -451, -333, -222, -117, -18, 73, 158, 238, 311, 378, 439, 495, 546, 590, 631, 667, 697, 724, 747, 765, 779, 791, 798, 803, 805, 803, 799, 791, 783, 772, 760, 746, 731, 682, 767, 352, -3957, -6858, -7075, -8623, -10808, -12799, -14296, -15300, -15950, -16395, -16753, -17105, -17493, -17936, -18438, -18995, -19595, -20228, -20885, -21552, -22226, -22899, -23561, -24211, -24847, -25461, -26054, -26624, -27169, -27689, -28184, -28650, -29090, -29502, -29888, -30246, -30577, -30882, -31163, -31416, -31644, -31849, -32030, -32188, -32323, -32437, -32531, -32604, -32658, -32694, -32713, -32715, -32662, -32844, -31272, -26581, -24974, -24562, -22817, -20651, -18696, -17186, -16116, -15371, -14816, -14344, -13884, -13390, -12843, -12240, -11579, -10873, -10130, -9358, -8570, -7772, -6972, -6177, -5390, -4617, -3863, -3129, -2414, -1725, -980, -789, 2080, 6931, 6027, 5047, 4011, 3066, 2252, 1563, 996, 537, 168, -118, -340, -505, -625, -706, -756, -779, -783, -771, -741, -734};