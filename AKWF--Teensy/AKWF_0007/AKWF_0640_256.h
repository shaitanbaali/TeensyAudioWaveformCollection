/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0640 256 samples */
 
const int16_t AKWF_0640_256_DATA [256] = 
{471, 1375, 2257, 3138, 4013, 4883, 5749, 6605, 7455, 8298, 9131, 9957, 10773, 11577, 12372, 13156, 13927, 14689, 15438, 16176, 16902, 17616, 18315, 19003, 19675, 20333, 20978, 21607, 22220, 22820, 23402, 23968, 24520, 25053, 25570, 26069, 26549, 27011, 27455, 27878, 28282, 28666, 29031, 29377, 29706, 30015, 30308, 30583, 30840, 31081, 31305, 31512, 31704, 31878, 32037, 32180, 32306, 32417, 32513, 32594, 32659, 32708, 32743, 32762, 32767, 32756, 32729, 32688, 32631, 32558, 32470, 32368, 32248, 32113, 31963, 31797, 31615, 31417, 31203, 30973, 30727, 30465, 30186, 29891, 29580, 29251, 28908, 28547, 28169, 27776, 27365, 26938, 26494, 26033, 25555, 25061, 24549, 24021, 23476, 22912, 22333, 21735, 21118, 20484, 19830, 19152, 18451, 17722, 16969, 16194, 15390, 14564, 13725, 12871, 12007, 11137, 10256, 9371, 8483, 7590, 6693, 5797, 4897, 3997, 3099, 2200, 1303, 408, -484, -1372, -2257, -3139, -4014, -4884, -5749, -6606, -7456, -8299, -9131, -9957, -10773, -11577, -12372, -13157, -13927, -14689, -15439, -16176, -16902, -17617, -18315, -19004, -19676, -20334, -20979, -21607, -22220, -22820, -23402, -23968, -24520, -25054, -25570, -26069, -26549, -27011, -27455, -27878, -28282, -28667, -29031, -29378, -29706, -30015, -30308, -30583, -30840, -31081, -31305, -31512, -31704, -31878, -32036, -32179, -32306, -32417, -32513, -32594, -32659, -32708, -32743, -32763, -32767, -32755, -32730, -32688, -32631, -32558, -32470, -32366, -32248, -32113, -31963, -31797, -31615, -31417, -31203, -30973, -30727, -30464, -30186, -29891, -29580, -29251, -28908, -28547, -28169, -27776, -27365, -26938, -26494, -26033, -25556, -25061, -24549, -24021, -23476, -22912, -22333, -21735, -21118, -20484, -19830, -19153, -18451, -17722, -16969, -16194, -15390, -14565, -13726, -12871, -12008, -11138, -10256, -9372, -8484, -7590, -6694, -5797, -4898, -3998, -3100, -2202, -1308, -397};