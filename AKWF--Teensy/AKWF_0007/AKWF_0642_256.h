/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0642 256 samples */
 
const int16_t AKWF_0642_256_DATA [256] = 
{1082, 2483, 3779, 5039, 6266, 7466, 8644, 9794, 10924, 12033, 13117, 14179, 15219, 16233, 17226, 18194, 19133, 20050, 20939, 21800, 22635, 23441, 24215, 24962, 25677, 26359, 27012, 27632, 28218, 28772, 29290, 29774, 30225, 30638, 31016, 31358, 31663, 31931, 32164, 32358, 32515, 32634, 32698, 32824, 32263, 30778, 29469, 28194, 26957, 25745, 24559, 23400, 22261, 21145, 20054, 18981, 17933, 16911, 15908, 14932, 13982, 13056, 12157, 11286, 10440, 9624, 8838, 8080, 7354, 6659, 5994, 5363, 4764, 4197, 3667, 3170, 2706, 2280, 1888, 1532, 1214, 931, 685, 477, 306, 173, 78, 19, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, -6, 15, -1043, -2495, -3777, -5040, -6267, -7467, -8645, -9795, -10925, -12034, -13117, -14180, -15220, -16233, -17226, -18194, -19134, -20050, -20940, -21800, -22635, -23441, -24215, -24962, -25677, -26360, -27013, -27632, -28218, -28772, -29290, -29774, -30225, -30638, -31016, -31358, -31663, -31931, -32164, -32358, -32515, -32634, -32698, -32824, -32263, -30778, -29469, -28194, -26957, -25746, -24560, -23400, -22262, -21145, -20054, -18982, -17934, -16911, -15909, -14933, -13983, -13056, -12158, -11286, -10441, -9625, -8839, -8080, -7355, -6660, -5995, -5364, -4765, -4198, -3668, -3171, -2707, -2281, -1889, -1533, -1215, -932, -686, -478, -307, -174, -79, -20, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};