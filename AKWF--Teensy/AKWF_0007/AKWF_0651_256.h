/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0651 256 samples */
 
const int16_t AKWF_0651_256_DATA [256] = 
{1113, 2934, 4607, 6196, 7704, 9141, 10517, 11830, 13089, 14298, 15455, 16569, 17636, 18659, 19643, 20587, 21489, 22356, 23184, 23975, 24730, 25450, 26133, 26783, 27398, 27977, 28525, 29037, 29516, 29962, 30374, 30754, 31101, 31414, 31695, 31944, 32158, 32341, 32493, 32610, 32692, 32736, 32824, 30981, 29163, 28023, 26983, 26054, 25206, 24414, 23666, 22959, 22281, 21630, 21005, 20399, 19814, 19246, 18691, 18153, 17626, 17111, 16609, 16117, 15634, 15160, 14696, 14239, 13790, 13350, 12915, 12488, 12068, 11653, 11245, 10842, 10445, 10054, 9666, 9284, 8908, 8536, 8169, 7805, 7446, 7092, 6742, 6395, 6053, 5714, 5379, 5048, 4720, 4395, 4075, 3758, 3443, 3133, 2825, 2520, 2220, 1921, 1625, 1334, 1045, 758, 475, 193, -85, -359, -632, -902, -1170, -1435, -1697, -1956, -2213, -2468, -2719, -2970, -3217, -3461, -3704, -3945, -4182, -4417, -4650, -4881, -5109, -5334, -5559, -5782, -6000, -6217, -6432, -6646, -6856, -7065, -7270, -7475, -7677, -7876, -8075, -8271, -8463, -8655, -8846, -9032, -9217, -9401, -9582, -9762, -9939, -10113, -10287, -10459, -10628, -10795, -10960, -11123, -11284, -11444, -11601, -11756, -11909, -12061, -12211, -12358, -12504, -12649, -12790, -12930, -13068, -13204, -13337, -13470, -13601, -13729, -13856, -13981, -14104, -14224, -14343, -14461, -14576, -14689, -14801, -14911, -15018, -15125, -15229, -15331, -15432, -15530, -15626, -15722, -15814, -15907, -15995, -16082, -16168, -16253, -16335, -16415, -16494, -16569, -16644, -16717, -16788, -16857, -16925, -16990, -17055, -17117, -17177, -17234, -17291, -17346, -17400, -17450, -17500, -17547, -17594, -17637, -17679, -17720, -17759, -17795, -17830, -17862, -17894, -17924, -17952, -17978, -18001, -18024, -18045, -18064, -18081, -18095, -18108, -18121, -18131, -18139, -18145, -18149, -18152, -18153, -18068, -18478, -15941, -10669, -7735, -5126, -2845, -740};