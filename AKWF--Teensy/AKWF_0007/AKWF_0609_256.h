/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0609 256 samples */
 
const int16_t AKWF_0609_256_DATA [256] = 
{1280, 3363, 5414, 7470, 9512, 11533, 13525, 15468, 17359, 19186, 20931, 22594, 24161, 25617, 26962, 28184, 29272, 30224, 31032, 31689, 32194, 32544, 32731, 32767, 32752, 32738, 32715, 32672, 32583, 32418, 32134, 31683, 31013, 30078, 28834, 27251, 25326, 23062, 20495, 17695, 14733, 11713, 8763, 5992, 3527, 1490, -31, -958, -1246, -1242, -1201, -921, -21, 1956, 5350, 10177, 15946, 21741, 26461, 28974, 29298, 29250, 29249, 29201, 29082, 28827, 28352, 27558, 26358, 24666, 22433, 19665, 16395, 12729, 8836, 4898, 1149, -2166, -4842, -6693, -7544, -7630, -7458, -6181, -2643, 2388, 5684, 6019, 5964, 5978, 5962, 5923, 5837, 5677, 5404, 4977, 4354, 3497, 2373, 958, -743, -2725, -4956, -7374, -9916, -12494, -15002, -17348, -19427, -21139, -22414, -23186, -23417, -23404, -23398, -23370, -23288, -23094, -22705, -22018, -20924, -19325, -17133, -14315, -10884, -6898, -2506, 2105, 6714, 11041, 14831, 17844, 19873, 20748, 20805, 20777, 20620, 20034, 18640, 16108, 12393, 7872, 3285, -410, -2260, -2448, -2242, -833, 3082, 8650, 12298, 12668, 12608, 12625, 12621, 12615, 12609, 12599, 12586, 12568, 12541, 12504, 12452, 12384, 12294, 12178, 12030, 11848, 11623, 11351, 11028, 10645, 10199, 9686, 9098, 8432, 7688, 6859, 5943, 4944, 3855, 2679, 1424, 85, -1328, -2810, -4361, -5964, -7611, -9301, -11013, -12739, -14472, -16189, -17883, -19544, -21148, -22690, -24157, -25529, -26801, -27961, -28991, -29891, -30647, -31253, -31704, -31996, -32119, -32120, -32106, -32093, -32080, -32066, -32050, -32033, -32014, -31992, -31966, -31932, -31891, -31840, -31776, -31696, -31598, -31479, -31334, -31158, -30949, -30703, -30414, -30078, -29691, -29247, -28745, -28177, -27541, -26835, -26052, -25190, -24250, -23225, -22116, -20925, -19647, -18284, -16842, -15316, -13712, -12038, -10289, -8479, -6612, -4692, -2732, -695};