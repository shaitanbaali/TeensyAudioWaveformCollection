/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0661 256 samples */
 
const int16_t AKWF_0661_256_DATA [256] = 
{138, 472, 781, 1076, 1356, 1624, 1882, 2128, 2364, 2591, 2810, 3021, 3225, 3420, 3610, 3795, 3973, 4146, 4314, 4476, 4634, 4788, 4937, 5082, 5224, 5361, 5495, 5626, 5753, 5877, 5998, 6115, 6231, 6343, 6453, 6560, 6664, 6766, 6866, 6962, 7058, 7151, 7241, 7330, 7417, 7501, 7583, 7664, 7743, 7819, 7894, 7968, 8039, 8109, 8177, 8244, 8309, 8373, 8435, 8495, 8554, 8612, 8667, 8722, 8775, 8827, 8877, 8926, 8973, 9020, 9065, 9109, 9151, 9192, 9232, 9271, 9308, 9344, 9380, 9414, 9446, 9477, 9508, 9537, 9565, 9592, 9618, 9642, 9666, 9689, 9710, 9730, 9749, 9767, 9784, 9800, 9815, 9829, 9842, 9853, 9864, 9873, 9882, 9890, 9896, 9901, 9906, 9909, 9911, 9913, 9895, 9945, 9834, 2448, 61, -410, -993, -1420, -1774, -2077, -2345, -2584, -2801, -2999, -3182, -3351, -3510, -3658, -3798, -3930, -4056, -4175, -4288, -4397, -4502, -4600, -4696, -4788, -4877, -4962, -5045, -5123, -5200, -5275, -5347, -5417, -5485, -5550, -5614, -5676, -5736, -5795, -5852, -5907, -5961, -6015, -6065, -6115, -6164, -6211, -6258, -6302, -6347, -6390, -6431, -6472, -6512, -6550, -6589, -6626, -6662, -6697, -6732, -6766, -6799, -6830, -6862, -6893, -6923, -6952, -6980, -7008, -7035, -7061, -7087, -7112, -7136, -7160, -7183, -7206, -7228, -7249, -7270, -7290, -7310, -7329, -7348, -7365, -7383, -7400, -7416, -7432, -7448, -7462, -7476, -7490, -7504, -7517, -7529, -7540, -7552, -7563, -7573, -7584, -7593, -7603, -7611, -7619, -7626, -7634, -7641, -7647, -7653, -7659, -7663, -7668, -7672, -7676, -7679, -7682, -7685, -7686, -7687, -7688, -7689, -7690, -7690, -7689, -7749, -7160, -9702, -20582, -9944, -8562, -6970, -5845, -4938, -4167, -3485, -2881, -2334, -1838, -1381, -959, -567, -192};