/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0647 256 samples */
 
const int16_t AKWF_0647_256_DATA [256] = 
{2936, 6761, 7613, 6604, 4601, 2318, 238, -1377, -2463, -3069, -3302, -3290, -3144, -3415, -587, -21789, -28329, -15746, -7144, -562, 3138, 4319, 3728, 2151, 243, -1542, -2969, -3952, -4521, -4765, -4791, -4693, -4549, -4409, -4295, -4219, -4176, -4157, -4154, -4158, -4163, -4165, -4160, -4152, -4139, -4124, -4105, -4088, -4071, -4053, -4037, -4020, -4006, -3989, -3973, -3960, -3942, -3929, -3915, -3897, -3884, -3870, -3852, -3839, -3826, -3808, -3793, -3780, -3742, -3852, -3036, -957, 259, 704, 559, 61, -563, -1157, -1622, -1926, -2069, -2082, -2003, -1870, -1711, -1548, -1393, -1250, -1122, -1004, -896, -792, -687, -588, -488, -388, -290, -191, -97, -1, 91, 180, 267, 353, 438, 518, 596, 675, 752, 826, 900, 970, 1039, 1105, 1171, 1236, 1302, 1361, 1422, 1480, 1537, 1594, 2149, -626, 14353, 28373, 14021, 4339, -2997, -6936, -7977, -7006, -4951, -2578, -402, 1301, 2452, 3100, 3353, 3346, 3195, 3461, 628, 21820, 28355, 15767, 7165, 583, -3117, -4297, -3706, -2129, -221, 1563, 2990, 3974, 4542, 4787, 4810, 4713, 4567, 4427, 4313, 4234, 4193, 4173, 4169, 4174, 4177, 4178, 4174, 4167, 4153, 4136, 4120, 4100, 4083, 4065, 4048, 4032, 4016, 3999, 3984, 3970, 3952, 3939, 3920, 3907, 3894, 3875, 3862, 3847, 3830, 3817, 3804, 3786, 3746, 3857, 3045, 962, -255, -698, -552, -56, 568, 1162, 1627, 1928, 2071, 2085, 2006, 1872, 1714, 1552, 1396, 1254, 1124, 1006, 896, 790, 690, 589, 488, 390, 291, 193, 96, 6, -85, -178, -266, -351, -437, -519, -597, -676, -754, -826, -898, -971, -1040, -1106, -1172, -1237, -1303, -1362, -1423, -1481, -1538, -1595, -2150, 625, -14354, -28386, -14033, -4278};