/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0615 256 samples */
 
const int16_t AKWF_0615_256_DATA [256] = 
{6814, 6818, 6822, 6825, 6828, 6830, 6832, 6833, 6835, 6836, 6837, 6837, 6838, 6838, 6838, 6837, 6837, 6837, 6836, 6835, 6834, 6833, 6832, 6831, 6830, 6828, 6828, 6826, 6825, 6824, 6822, 6821, 6819, 6817, 6816, 6814, 6812, 6811, 6810, 6807, 6806, 6805, 6802, 6801, 6799, 6797, 6796, 6794, 6792, 6791, 6788, 6787, 6785, 6783, 6781, 6780, 6778, 6776, 6775, 6772, 6771, 6876, 6353, 8265, 31268, 33178, 32655, 32757, 32753, 32748, 32744, 32738, 32732, 32726, 32721, 32714, 32707, 32700, 32693, 32686, 32679, 32671, 32664, 32657, 32649, 32641, 32633, 32625, 32616, 32609, 32600, 32593, 32584, 32575, 32567, 32559, 32550, 32542, 32534, 32525, 32516, 32507, 32500, 32491, 32482, 32473, 32465, 32456, 32448, 32440, 32431, 32422, 32414, 32405, 32396, 32387, 32378, 32369, 32361, 32353, 32345, 32336, 32327, 32318, 32309, 31398, 36245, 10195, -23846, -18836, -19775, -19779, -19783, -19785, -19788, -19789, -19790, -19789, -19789, -19789, -19787, -19785, -19784, -19781, -19779, -19776, -19774, -19770, -19766, -19763, -19759, -19756, -19752, -19747, -19744, -19739, -19734, -19730, -19725, -19721, -19716, -19711, -19706, -19702, -19697, -19692, -19687, -19682, -19677, -19672, -19667, -19662, -19657, -19652, -19647, -19642, -19636, -19632, -19626, -19621, -19616, -19611, -19605, -19600, -19595, -19590, -19585, -19579, -19574, -19569, -19564, -19558, -19553, -19548, -19543, -19537, -19532, -19527, -19522, -19517, -19512, -19506, -19501, -19496, -19491, -19485, -19480, -19475, -19470, -19464, -19459, -19454, -19449, -19444, -19438, -19433, -19428, -19423, -19418, -19412, -19407, -19402, -19397, -19392, -19386, -19381, -19376, -19371, -19366, -19360, -19355, -19350, -19345, -19340, -19334, -19329, -19324, -19319, -19313, -19309, -19303, -19298, -19293, -19288, -19283, -19278, -19272, -19267, -19262, -19257, -19251, -19246, -19241, -19236, -19231, -19225};