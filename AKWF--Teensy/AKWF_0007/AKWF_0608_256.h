/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0608 256 samples */
 
const int16_t AKWF_0608_256_DATA [256] = 
{678, 2208, 3696, 5175, 6640, 8085, 9513, 10913, 12290, 13640, 14955, 16241, 17492, 18704, 19877, 21012, 22100, 23145, 24145, 25094, 25995, 26845, 27642, 28386, 29074, 29706, 30282, 30799, 31257, 31656, 31995, 32272, 32489, 32644, 32729, 32795, 32463, 31204, 29464, 27409, 25096, 22579, 19907, 17102, 14201, 11241, 8235, 5213, 2209, -766, -3686, -6522, -9267, -11893, -14377, -16716, -18882, -20862, -22650, -24226, -25583, -26713, -27605, -28255, -28658, -28827, -28187, -26727, -24891, -22754, -20379, -17823, -15115, -12290, -9386, -6421, -3424, -430, 2552, 5494, 8364, 11159, 13849, 16411, 18841, 21115, 23214, 25136, 26859, 28372, 29673, 30745, 31584, 32184, 32545, 32646, 32214, 31391, 30374, 29195, 27889, 26471, 24957, 23365, 21699, 19970, 18194, 16371, 14510, 12627, 10718, 8794, 6868, 4936, 3008, 1097, -800, -2675, -4518, -6333, -8106, -9832, -11514, -13139, -14706, -16214, -17652, -19020, -20315, -21531, -22667, -23720, -24684, -25560, -26345, -27036, -27633, -28132, -28533, -28834, -29033, -29146, -29069, -28442, -27476, -26316, -25002, -23571, -22040, -20438, -18784, -17089, -15377, -13663, -11956, -10276, -8636, -7044, -5518, -4069, -2702, -1435, -273, 776, 1703, 2503, 3170, 3699, 4108, 4369, 4362, 11728, 24493, 32002, 32622, 31976, 31321, 30494, 29565, 28551, 27456, 26295, 25077, 23803, 22482, 21123, 19721, 18289, 16832, 15346, 13843, 12324, 10789, 9248, 7703, 6151, 4605, 3062, 1524, 0, -1512, -3009, -4484, -5941, -7373, -8774, -10149, -11491, -12796, -14068, -15300, -16488, -17636, -18738, -19790, -20796, -21751, -22653, -23502, -24294, -25030, -25710, -26329, -26889, -27388, -27824, -28199, -28512, -28759, -28943, -29061, -29124, -29071, -28664, -28036, -27277, -26410, -25455, -24420, -23317, -22156, -20937, -19671, -18365, -17018, -15637, -14229, -12793, -11334, -9861, -8368, -6868, -5359, -3845, -2334, -793};