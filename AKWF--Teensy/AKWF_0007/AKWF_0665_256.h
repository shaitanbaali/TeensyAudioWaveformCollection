/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0665 256 samples */
 
const int16_t AKWF_0665_256_DATA [256] = 
{1299, 3665, 5566, 7207, 8647, 9931, 11088, 12135, 13091, 13967, 14771, 15513, 16197, 16826, 17409, 17946, 18438, 18891, 19306, 19682, 20024, 20333, 20608, 20851, 21063, 21243, 21394, 21515, 21608, 21414, 22781, 15703, 2782, 754, -1495, -3134, -4479, -5630, -6639, -7533, -8338, -9068, -9733, -10341, -10901, -11415, -11890, -12328, -12732, -13105, -13448, -13762, -14050, -14313, -14550, -14766, -14957, -15126, -15275, -15401, -15508, -15593, -15660, -15591, -16220, -13384, -5062, -3498, -2161, -1159, -333, 371, 992, 1546, 2049, 2509, 2933, 3327, 3694, 4038, 4361, 4666, 4955, 5227, 5486, 5732, 5965, 6188, 6401, 6602, 6796, 6981, 7157, 7325, 7485, 7638, 7784, 7923, 8056, 8183, 8302, 8416, 8525, 8627, 8725, 8817, 8904, 8985, 9061, 9132, 9199, 9261, 9317, 9369, 9418, 9460, 9499, 9533, 9562, 9587, 9607, 9624, 9635, 9671, 9523, 10492, 11657, 11835, 12060, 12223, 12357, 12474, 12575, 12667, 12750, 12825, 12894, 12959, 13019, 13075, 13127, 13176, 13223, 13266, 13307, 13347, 13384, 13419, 13453, 13485, 13515, 13544, 13570, 13597, 13621, 13644, 13667, 13687, 13707, 13726, 13743, 13760, 13776, 13790, 13804, 13817, 13828, 13839, 13849, 13858, 13867, 13875, 13880, 13887, 13892, 13896, 13900, 13902, 13904, 13905, 13906, 13905, 13904, 13733, 14608, 10068, 1022, -434, -1979, -3110, -4036, -4827, -5521, -6136, -6687, -7188, -7643, -8060, -8444, -8795, -9119, -9419, -9694, -9948, -10181, -10394, -10589, -10766, -10926, -11071, -11199, -11312, -11409, -11493, -11561, -11616, -11656, -11817, -11110, -17619, -22978, -23946, -25133, -26003, -26731, -27354, -27902, -28391, -28830, -29228, -29591, -29923, -30228, -30507, -30765, -31004, -31222, -31422, -31607, -31775, -31928, -32068, -32193, -32305, -32404, -32491, -32566, -32628, -32679, -32719, -32747, -32358, -34477, -20841, -4408, -1829};