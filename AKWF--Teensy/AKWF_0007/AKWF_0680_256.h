/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0680 256 samples */
 
const int16_t AKWF_0680_256_DATA [256] = 
{3342, 8245, 6053, 3069, 7508, 6848, 7913, 8736, 5950, 9585, 5815, 2620, 4596, 4122, 3169, 295, -1737, -1278, 394, 691, 3451, 1973, 1577, 1558, 6100, 3868, 8823, 5848, 5799, 4544, 4290, 2496, 9141, 8340, 4447, 6596, 13139, 10134, 12698, 15713, 13010, 19291, 16460, 19197, 19564, 19220, 16717, 17544, 14999, 16675, 16886, 10075, 12931, 12632, 6471, 8319, 5908, 6846, 2267, 5176, 1502, 2585, 2617, 1932, -1532, -275, -1759, -957, 1375, 4636, 4320, 3245, 6659, 4954, 7625, 7452, 6584, 9525, 6209, 6532, 10427, 13597, 14195, 19718, 17769, 20928, 25496, 28361, 31228, 32767, 29748, 26533, 23888, 27307, 20446, 17565, 14669, 3877, 441, -3888, -5297, -11623, -13264, -13745, -16581, -20261, -21217, -28054, -21607, -22466, -17009, -21973, -19245, -18966, -17172, -14425, -16850, -10485, -8734, -10264, -5254, -2323, 1508, 2140, 7120, 12227, 11698, 13143, 18649, 22052, 21121, 18950, 16434, 17959, 15451, 13603, 15000, 13448, 10828, 8169, 5889, 5138, 381, -1961, -8731, -11461, -17640, -13097, -16622, -20256, -19570, -18682, -24267, -24170, -20910, -23975, -20346, -24675, -19168, -14960, -11355, -10562, -9648, -3666, 254, -883, -1427, -279, 3728, 7117, 3919, 2515, 7958, 6819, 4287, 3912, 8313, 6823, 3504, 7251, 8574, 9284, 10638, 8217, 6963, 2101, 4149, 3881, 1660, -4476, -9525, -7566, -10343, -9234, -17959, -17259, -18986, -17742, -23151, -22485, -25029, -26181, -27630, -24128, -23478, -18394, -21427, -23258, -19379, -21030, -22277, -18623, -19140, -18186, -18229, -17135, -19996, -16874, -14675, -11403, -8818, -10806, -6212, -2204, -3594, -4963, -2500, -5185, -3271, -5722, -4094, -127, -1852, -3319, -1418, -3678, -3358, -2152, -8, -2342, 341, -725, -1945, -1539, 402, 353, -37, -2557, 2094, 3226, -534, 2765, 4405, 3320, 6612, 2388};