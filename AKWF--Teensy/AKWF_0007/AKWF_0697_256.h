/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0697 256 samples */
 
const int16_t AKWF_0697_256_DATA [256] = 
{542, 1253, 4029, 9178, 11829, 14203, 16328, 18276, 20077, 21754, 23306, 24737, 26044, 27235, 28304, 29255, 30080, 30791, 31389, 31873, 32244, 32515, 32679, 32759, 32742, 32649, 32478, 32238, 31940, 31591, 31194, 30773, 30328, 29870, 29408, 28957, 28523, 28108, 27732, 27403, 27117, 26877, 26702, 26586, 26525, 26529, 26590, 26704, 26879, 27099, 27365, 27670, 28005, 28361, 28739, 29123, 29507, 29887, 30254, 30607, 30928, 31219, 31471, 31687, 31854, 31973, 32044, 32060, 32028, 31942, 31802, 31608, 31366, 31073, 30742, 30364, 29946, 29495, 29007, 28496, 27950, 27389, 26809, 26211, 25602, 24985, 24361, 23728, 23090, 22457, 21818, 21178, 20544, 19901, 19259, 18623, 17974, 17326, 16675, 16015, 15351, 14673, 13983, 13283, 12564, 11828, 11076, 10296, 9503, 8683, 7830, 6883, 5892, 4889, 3863, 2810, 1738, 642, -473, -1612, -2769, -3963, -5093, -6167, -7252, -8333, -9414, -10484, -11557, -12626, -13679, -14728, -15762, -16775, -17768, -18738, -19681, -20593, -21465, -22304, -23099, -23852, -24557, -25215, -25819, -26366, -26860, -27299, -27687, -28007, -28272, -28485, -28639, -28732, -28782, -28769, -28710, -28605, -28455, -28258, -28023, -27752, -27453, -27124, -26777, -26412, -26033, -25654, -25270, -24902, -24539, -24189, -23861, -23568, -23303, -23072, -22873, -22721, -22611, -22544, -22520, -22545, -22610, -22716, -22871, -23058, -23277, -23539, -23819, -24122, -24440, -24775, -25116, -25459, -25799, -26132, -26450, -26753, -27030, -27286, -27506, -27699, -27850, -27966, -28036, -28066, -28054, -28000, -27900, -27755, -27569, -27342, -27068, -26762, -26421, -26042, -25633, -25192, -24730, -24240, -23731, -23207, -22660, -22101, -21533, -20958, -20376, -19789, -19195, -18605, -18005, -17406, -16810, -16212, -15606, -15006, -14404, -13793, -13185, -12565, -11945, -11311, -10672, -10018, -9353, -8677, -7980, -7267, -6532, -5784, -5009, -4214, -3355, -2417, -1468, -485};