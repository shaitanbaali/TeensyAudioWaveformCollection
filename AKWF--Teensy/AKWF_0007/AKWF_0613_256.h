/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0613 256 samples */
 
const int16_t AKWF_0613_256_DATA [256] = 
{17712, 19607, 19200, 19272, 19274, 19274, 19274, 19274, 19274, 19274, 19273, 19274, 19274, 19273, 19274, 19274, 19274, 19273, 19274, 19274, 19274, 19274, 19274, 19274, 19274, 19274, 19273, 19274, 19273, 19273, 18856, 21124, 7606, -7540, -5259, -5689, -5685, -5685, -5684, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5684, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5685, -5682, -6003, -4296, -15678, -25768, -24069, -24381, -24381, -24382, -24383, -24382, -24382, -24382, -24382, -24382, -24382, -24382, -24382, -24382, -24382, -24382, -24382, -24382, -24383, -24382, -24382, -24383, -24382, -24382, -24382, -24382, -24382, -24382, -24383, -24383, -24382, -24383, -24382, -24382, -24382, -24382, -24383, -24382, -24382, -24381, -24382, -24383, -24382, -24382, -24382, -24383, -24382, -24383, -24382, -24382, -24382, -24383, -24353, -24198, -25353, -1549, 6455, 4719, 5031, 5012, 5083, 4988, -101, 5132, 6799, 6478, 9092, 9571, 9454, 9432, 13443, 14432, 14207, 14248, 14248, 14248, 14248, 14248, 14247, 14248, 14248, 14247, 14248, 14248, 14247, 14248, 14248, 14248, 14247, 14248, 14248, 14248, 14248, 14248, 14248, 14242, 14091, 14967, 5546, 904, 1842, 1671, 1670, 1670, 1670, 1670, 1670, 1670, 1671, 1671, 1670, 1669, 1600, 1971, 448, -10051, -10591, -10428, -10470, -10469, -10473, -10630, -9719, -21827, -26947, -25903, -26118, -26139, -26161, -26182, -26203, -26225, -26247, -26268, -26289, -26310, -26331, -26353, -26374, -26395, -26415, -26437, -26458, -26479, -26500, -26521, -26542, -26562, -26584, -26605, -26626, -26646, -26667, -26688, -26709, -26729, -26750, -26770, -26875, -26437, -30175, -32675, -32242, -32354, -32379, -32407, -32434, -32461, -32487, -32512, -32541, -32563, -32599, -32795, -32306, -31138, -31016, -30815, -30648, -30494, -30350, -30211, -29732, -31600, -7035, 4133, 719, -3272, -3435, 3230, 1345};