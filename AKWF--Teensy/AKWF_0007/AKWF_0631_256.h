/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0631 256 samples */
 
const int16_t AKWF_0631_256_DATA [256] = 
{32767, 32768, 32767, 32764, 32751, 32720, 32656, 32541, 32349, 32055, 31628, 31037, 30254, 29254, 28012, 26516, 24769, 22767, 20534, 18106, 15513, 12814, 10076, 7354, 4733, 2285, 76, -1819, -3343, -4329, -5607, -2952, 13130, 13920, 13093, 10814, 5896, -361, -5382, -3919, 5350, 5807, 5172, 3039, -1811, -8264, -13927, -12653, 4254, 6551, 5984, 6016, 5738, 5080, 3828, 1786, -1131, -4870, -9218, -13770, -18031, -21176, -24947, -18341, 22650, 24751, 24082, 24133, 23792, 23025, 21614, 19395, 16291, 12389, 7969, 3431, -706, -3805, -6187, -4092, 12723, 15028, 14088, 12287, 7735, 1291, -4302, -5274, 3851, 6005, 5220, 3599, -716, -6951, -14042, -10303, 22175, 23815, 23279, 23298, 22967, 22222, 20850, 18692, 15672, 11878, 7580, 3167, -856, -3867, -6198, -4092, 12723, 15028, 14087, 12285, 7731, 1284, -4312, -5284, 3863, 6022, 5224, 3532, -963, -7457, -14845, -10938, 22957, 24669, 24111, 24133, 23792, 23025, 21614, 19395, 16291, 12389, 7969, 3431, -706, -3805, -6187, -4092, 12724, 15029, 14088, 12285, 7729, 1278, -4321, -5292, 3878, 6043, 5273, 3745, -335, -6340, -12478, -11507, 4664, 5468, 5209, 5270, 5257, 5226, 5162, 5046, 4855, 4561, 4135, 3544, 2761, 1761, 518, -975, -2722, -4724, -6956, -9384, -11978, -14677, -17414, -20135, -22757, -25204, -27414, -29308, -30832, -31628, -33877, -26828, 14136, 16206, 14929, 12511, 7096, 195, -5285, -3914, 5343, 5796, 5163, 3030, -1817, -8268, -13928, -12653, 4254, 6551, 5985, 6020, 5749, 5108, 3891, 1906, -931, -4567, -8794, -13223, -17365, -20479, -23857, -18752, 13648, 15270, 14152, 11802, 6603, -20, -5301, -3898, 5332, 5785, 5152, 3021, -1824, -8271, -13929, -12653, 4254, 6551, 5984, 6016, 5738, 5080, 3828, 1786, -1131, -4870, -9218, -13770, -18031, -21313, -24425, -20007};