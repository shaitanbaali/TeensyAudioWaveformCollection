/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0675 256 samples */
 
const int16_t AKWF_0675_256_DATA [256] = 
{240, 930, 1597, 2259, 2915, 3562, 4203, 4836, 5463, 6082, 6693, 7297, 7892, 8480, 9061, 9635, 10199, 10757, 11308, 11849, 12384, 12912, 13430, 13942, 14445, 14940, 15428, 15907, 16380, 16845, 17301, 17749, 18191, 18624, 19050, 19468, 19878, 20282, 20677, 21063, 21443, 21817, 22181, 22539, 22888, 23230, 23566, 23894, 24214, 24528, 24834, 25132, 25425, 25710, 25986, 26258, 26521, 26779, 27030, 27273, 27510, 27741, 27964, 28181, 28393, 28598, 28796, 28989, 29175, 29356, 29530, 29698, 29862, 30019, 30170, 30316, 30457, 30592, 30722, 30848, 30968, 31083, 31192, 31297, 31397, 31494, 31585, 31672, 31755, 31833, 31907, 31978, 32044, 32107, 32166, 32221, 32273, 32322, 32367, 32408, 32448, 32484, 32518, 32549, 32576, 32602, 32624, 32646, 32665, 32681, 32696, 32709, 32720, 32729, 32738, 32745, 32751, 32755, 32759, 32762, 32764, 32766, 32766, 32708, 32961, 31942, 22693, 17341, 13729, 10629, 7945, 5547, 3380, 1391, -451, -2159, -3761, -5266, -6679, -8017, -9283, -10480, -11619, -12702, -13730, -14711, -15646, -16535, -17386, -18198, -18971, -19712, -20418, -21092, -21736, -22352, -22939, -23501, -24036, -24546, -25034, -25498, -25941, -26364, -26765, -27149, -27513, -27860, -28188, -28501, -28798, -29079, -29346, -29597, -29835, -30061, -30273, -30473, -30662, -30838, -31005, -31160, -31306, -31443, -31568, -31687, -31796, -31898, -31992, -32079, -32158, -32232, -32298, -32358, -32414, -32463, -32508, -32548, -32583, -32615, -32643, -32666, -32686, -32704, -32720, -32731, -32740, -32748, -32755, -32759, -32763, -32765, -32766, -32760, -32784, -32654, -31836, -30925, -30038, -29151, -28268, -27386, -26510, -25638, -24768, -23904, -23044, -22187, -21336, -20488, -19645, -18809, -17976, -17147, -16326, -15510, -14697, -13893, -13092, -12297, -11509, -10726, -9949, -9179, -8413, -7654, -6903, -6158, -5419, -4687, -3961, -3242, -2530, -1825, -1129, -426};