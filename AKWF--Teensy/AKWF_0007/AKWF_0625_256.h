/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0625 256 samples */
 
const int16_t AKWF_0625_256_DATA [256] = 
{427, 1724, 3002, 4285, 5569, 6852, 8133, 9404, 10667, 11920, 13155, 14375, 15578, 16754, 17909, 19037, 20133, 21199, 22232, 23225, 24182, 25098, 25968, 26795, 27576, 28306, 28987, 29615, 30189, 30709, 31172, 31578, 31927, 32215, 32444, 32612, 32720, 32765, 32768, 32767, 32768, 32768, 32768, 32767, 32768, 32767, 32767, 32766, 32766, 32764, 32763, 32761, 32757, 32754, 32749, 32742, 32735, 32726, 32715, 32702, 32686, 32668, 32647, 32622, 32594, 32561, 32525, 32484, 32438, 32385, 32326, 32262, 32190, 32110, 32024, 31928, 31823, 31710, 31586, 31451, 31306, 31149, 30980, 30799, 30604, 30397, 30176, 29939, 29688, 29421, 29138, 28839, 28523, 28190, 27840, 27471, 27084, 26680, 26256, 25811, 25350, 24868, 24365, 23845, 23303, 22741, 22160, 21559, 20936, 20296, 19635, 18953, 18254, 17534, 16795, 16040, 15264, 14471, 13661, 12833, 11990, 11133, 10257, 9368, 8467, 7550, 6623, 5685, 4733, 3774, 2806, 1829, 846, -143, -1137, -2133, -3134, -4138, -5139, -6142, -7144, -8140, -9134, -10124, -11103, -12078, -13044, -13997, -14942, -15874, -16789, -17692, -18579, -19446, -20299, -21129, -21937, -22726, -23491, -24232, -24949, -25637, -26301, -26936, -27541, -28118, -28665, -29178, -29661, -30111, -30526, -30910, -31258, -31571, -31847, -32089, -32294, -32462, -32595, -32688, -32747, -32766, -32766, -32766, -32766, -32766, -32766, -32767, -32766, -32766, -32764, -32762, -32759, -32754, -32748, -32740, -32731, -32717, -32700, -32681, -32656, -32626, -32589, -32547, -32497, -32439, -32371, -32293, -32204, -32103, -31989, -31861, -31717, -31558, -31382, -31186, -30971, -30736, -30478, -30199, -29896, -29567, -29214, -28833, -28424, -27988, -27522, -27026, -26500, -25944, -25354, -24734, -24081, -23395, -22677, -21925, -21140, -20324, -19474, -18591, -17679, -16733, -15758, -14755, -13721, -12659, -11573, -10459, -9321, -8163, -6981, -5781, -4565, -3333, -2090, -809};