/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0622 256 samples */
 
const int16_t AKWF_0622_256_DATA [256] = 
{3338, 7248, 9867, 12173, 14214, 16066, 17769, 19336, 20793, 22149, 23407, 24575, 25659, 26658, 27577, 28419, 29181, 29868, 30480, 31015, 31477, 31864, 32176, 32415, 32521, 32903, 30798, 26639, 24115, 21897, 19947, 18181, 16553, 15048, 13646, 12330, 11102, 9948, 8867, 7856, 6910, 6030, 5213, 4457, 3761, 3127, 2552, 2035, 1579, 1180, 839, 557, 331, 164, 55, 4, -1, -1, -1, -46, 175, -1481, -4624, -6533, -8215, -9696, -11041, -12281, -13431, -14507, -15520, -16467, -17362, -18206, -18998, -19745, -20445, -21101, -21714, -22285, -22813, -23301, -23748, -24153, -24520, -24845, -25130, -25377, -25584, -25751, -25877, -25919, -26197, -24485, -21216, -19233, -17486, -15948, -14555, -13272, -12084, -10975, -9936, -8964, -8051, -7193, -6391, -5640, -4938, -4288, -3683, -3127, -2617, -2153, -1735, -1363, -1035, -753, -515, -323, -176, -72, -14, 0, 0, -1, 41, -157, 946, 4457, 6696, 8558, 10196, 11675, 13032, 14285, 15453, 16547, 17569, 18527, 19426, 20264, 21049, 21780, 22458, 23085, 23661, 24186, 24664, 25091, 25469, 25800, 26082, 26315, 26501, 26630, 26730, 26759, 23924, 21142, 19275, 17600, 16108, 14744, 13487, 12315, 11218, 10191, 9226, 8315, 7463, 6659, 5906, 5204, 4546, 3935, 3371, 2850, 2374, 1943, 1555, 1210, 909, 650, 435, 263, 134, 48, 5, -1, 0, 0, -17, 33, -156, -3687, -6732, -8874, -10794, -12505, -14073, -15522, -16871, -18136, -19324, -20438, -21490, -22479, -23408, -24281, -25099, -25861, -26572, -27231, -27839, -28397, -28904, -29362, -29771, -30130, -30438, -30700, -30912, -31074, -31129, -31479, -29763, -25349, -22627, -20305, -18261, -16426, -14745, -13193, -11761, -10428, -9189, -8042, -6976, -5992, -5089, -4261, -3507, -2830, -2226, -1696, -1237, -851, -537, -296, -125, -26, 0, -3, 11, -49};