/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0653 256 samples */
 
const int16_t AKWF_0653_256_DATA [256] = 
{1226, 3303, 5322, 7325, 9292, 11219, 13095, 14905, 16647, 18311, 19883, 21361, 22736, 23998, 25146, 26170, 27064, 27827, 28454, 28938, 29281, 29480, 29535, 29527, 29521, 29513, 29502, 29489, 29475, 29457, 29436, 29412, 29385, 29354, 29320, 29281, 29239, 29193, 29142, 29088, 29028, 28963, 28894, 28820, 28741, 28657, 28567, 28471, 28371, 28265, 28153, 28036, 27913, 27784, 27649, 27508, 27361, 27208, 27049, 26883, 26712, 26535, 26350, 26159, 25962, 25759, 25549, 25332, 25109, 24880, 24644, 24402, 24153, 23897, 23636, 23368, 23092, 22811, 22524, 22229, 21929, 21622, 21309, 20990, 20665, 20332, 19995, 19651, 19301, 18945, 18583, 18216, 17843, 17463, 17079, 16688, 16292, 15892, 15485, 15072, 14657, 14236, 13808, 13377, 12941, 12500, 12054, 11604, 11149, 10693, 10229, 9762, 9293, 8819, 8341, 7861, 7376, 6889, 6399, 5904, 5409, 4911, 4408, 3905, 3399, 2891, 2381, 1869, 1355, 841, 325, -192, -710, -1230, -1750, -2271, -2792, -3314, -3834, -4355, -4877, -5397, -5917, -6437, -6954, -7472, -7990, -8504, -9018, -9530, -10040, -10549, -11054, -11557, -12058, -12556, -13052, -13546, -14034, -14520, -15004, -15483, -15958, -16431, -16898, -17360, -17821, -18274, -18725, -19171, -19610, -20045, -20475, -20899, -21319, -21732, -22139, -22541, -22937, -23325, -23709, -24086, -24455, -24819, -25176, -25525, -25868, -26203, -26531, -26852, -27166, -27471, -27769, -28059, -28341, -28615, -28882, -29140, -29389, -29631, -29864, -30089, -30304, -30512, -30709, -30900, -31081, -31253, -31416, -31569, -31714, -31850, -31976, -32092, -32201, -32300, -32389, -32470, -32540, -32601, -32652, -32695, -32727, -32750, -32764, -32768, -32764, -32744, -32692, -32592, -32434, -32209, -31908, -31525, -31055, -30493, -29834, -29080, -28225, -27268, -26214, -25059, -23805, -22460, -21021, -19495, -17888, -16201, -14444, -12626, -10746, -8819, -6852, -4851, -2833, -758};