/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0672 256 samples */
 
const int16_t AKWF_0672_256_DATA [256] = 
{9416, 14707, 18023, 20643, 22766, 24530, 26019, 27279, 28354, 29271, 30046, 30701, 31248, 31695, 32055, 32335, 32538, 32675, 32751, 32768, 32732, 32644, 32511, 32335, 32118, 31862, 31569, 31246, 30889, 30503, 30091, 29651, 29187, 28701, 28192, 27664, 27117, 26552, 25968, 25371, 24759, 24132, 23494, 22844, 22181, 21510, 20828, 20138, 19441, 18734, 18020, 17305, 16581, 15852, 15120, 14382, 13643, 12902, 12156, 11410, 10662, 9913, 9164, 8415, 7666, 6919, 6171, 5425, 4682, 3939, 3200, 2465, 1731, 1000, 275, -448, -1166, -1880, -2589, -3296, -3993, -4688, -5378, -6060, -6736, -7408, -8072, -8730, -9381, -10023, -10661, -11292, -11914, -12530, -13136, -13737, -14329, -14912, -15488, -16055, -16613, -17164, -17707, -18239, -18764, -19280, -19786, -20283, -20773, -21251, -21722, -22182, -22633, -23075, -23508, -23930, -24344, -24747, -25140, -25526, -25900, -26264, -26617, -26963, -27297, -27622, -27937, -28242, -28537, -28822, -29096, -29363, -29616, -29861, -30097, -30321, -30537, -30742, -30935, -31121, -31296, -31460, -31616, -31761, -31895, -32022, -32138, -32243, -32338, -32425, -32501, -32568, -32625, -32672, -32711, -32740, -32758, -32767, -32767, -32759, -32741, -32714, -32676, -32630, -32575, -32512, -32438, -32357, -32265, -32167, -32058, -31942, -31815, -31682, -31540, -31388, -31230, -31064, -30887, -30704, -30513, -30314, -30106, -29892, -29669, -29441, -29202, -28957, -28706, -28445, -28178, -27905, -27625, -27337, -27043, -26741, -26434, -26121, -25797, -25472, -25138, -24799, -24454, -24103, -23745, -23382, -23014, -22640, -22260, -21875, -21486, -21091, -20690, -20284, -19876, -19460, -19039, -18618, -18189, -17755, -17320, -16878, -16434, -15985, -15533, -15078, -14617, -14154, -13690, -13220, -12746, -12272, -11793, -11311, -10828, -10343, -9853, -9363, -8870, -8375, -7877, -7378, -6878, -6377, -5873, -5368, -4862, -4355, -3847, -3339, -2829, -2318, -1807, -1293, -796, -212};