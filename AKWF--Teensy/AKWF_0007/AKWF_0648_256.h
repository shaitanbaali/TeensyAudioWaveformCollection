/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0648 256 samples */
 
const int16_t AKWF_0648_256_DATA [256] = 
{-3, -5, 243, -1305, 5707, 26766, -966, -19120, -20201, -13474, -4467, 3129, 7676, 9047, 7997, 5568, 2752, 253, -1532, -2495, -2736, -2044, -3993, 10597, 24108, -4836, -17759, -17967, -11764, -3843, 2756, 6716, 7962, 7119, 5079, 2671, 513, -1060, -1948, -2219, -2040, -1600, -1070, -574, -182, 75, 210, 246, 218, 157, 88, 28, -16, -44, -57, -60, -56, -51, -45, -42, -43, -43, -45, -48, -51, -53, -54, -53, -53, -54, -52, -51, -50, -48, -46, -45, -59, 12, -333, -2207, -2531, -1277, 219, 1319, 1790, 1686, 1205, 571, -26, -472, -724, -793, -725, -571, -388, -214, -76, 17, 68, 83, 76, 55, 29, 5, -14, -28, -36, -39, -37, -54, 242, 310, -54, -301, -381, -328, -204, -68, 42, 107, 127, 112, 77, 35, -3, -30, -46, -52, -48, -38, -261, 1199, -5363, -24892, 1254, 18158, 18976, 12500, 3961, -3174, -7390, -8598, -7532, -5189, -2504, -144, 1529, 2416, 2620, 1910, 3950, -11027, -24907, 4929, 18276, 18522, 12153, 4001, -2801, -6889, -8185, -7328, -5235, -2759, -539, 1081, 1999, 2281, 2098, 1647, 1103, 592, 189, -78, -217, -255, -226, -163, -93, -30, 15, 43, 58, 60, 55, 50, 45, 42, 41, 43, 45, 49, 52, 53, 55, 54, 54, 55, 54, 52, 51, 50, 48, 46, 62, -13, 346, 2289, 2619, 1313, -243, -1382, -1868, -1755, -1250, -591, 29, 492, 754, 824, 750, 589, 398, 217, 73, -24, -77, -93, -85, -62, -34, -10, 10, 23, 31, 34, 35, 34, 33, 31, 31, 29, 29, 27, 25, 24, 23, 20, 17, 15, 12, 10, 7, 4, 2, 0};