/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0683 256 samples */
 
const int16_t AKWF_0683_256_DATA [256] = 
{343, 879, 1400, 1919, 2433, 2945, 3453, 3956, 4456, 4953, 5444, 5933, 6417, 6897, 7373, 7846, 8313, 8778, 9238, 9695, 10146, 10594, 11038, 11478, 11913, 12344, 12773, 13195, 13614, 14029, 14439, 14844, 15248, 15645, 16037, 16427, 16810, 17191, 17568, 17938, 18306, 18669, 19026, 19380, 19731, 20075, 20416, 20752, 21083, 21410, 21733, 22051, 22365, 22673, 22977, 23277, 23572, 23862, 24148, 24429, 24706, 24978, 25244, 25507, 25766, 26019, 26267, 26512, 26750, 26984, 27215, 27439, 27659, 27875, 28085, 28292, 28492, 28689, 28880, 29067, 29249, 29426, 29599, 29766, 29929, 30087, 30239, 30387, 30531, 30669, 30802, 30930, 31054, 31174, 31288, 31395, 31499, 31599, 31694, 31783, 31867, 31947, 32022, 32091, 32157, 32217, 32272, 32313, 32658, 32789, 32762, 32768, 32768, 32767, 32766, 32773, 32629, 32634, 32035, 31188, 30393, 29589, 28785, 27981, 27178, 26374, 25571, 24768, 23965, 23163, 22361, 21559, 20759, 19958, 19157, 18359, 17559, 16759, 15963, 15165, 14368, 13574, 12777, 11983, 11190, 10396, 9604, 8814, 8023, 7233, 6446, 5658, 4872, 4088, 3303, 2519, 1738, 956, 177, -599, -1378, -2152, -2927, -3701, -4472, -5243, -6013, -6778, -7545, -8310, -9071, -9833, -10593, -11350, -12107, -12862, -13613, -14366, -15116, -15862, -16608, -17353, -18094, -18834, -19573, -20308, -21043, -21776, -22504, -23233, -23958, -24681, -25405, -26123, -26839, -27556, -28268, -28977, -29686, -30390, -31093, -31783, -32537, -32405, -31637, -30964, -30276, -29588, -28907, -28226, -27547, -26873, -26199, -25530, -24863, -24199, -23537, -22879, -22223, -21569, -20920, -20272, -19629, -18988, -18350, -17714, -17082, -16453, -15827, -15204, -14585, -13968, -13355, -12744, -12138, -11535, -10933, -10338, -9743, -9151, -8566, -7982, -7402, -6825, -6252, -5681, -5116, -4553, -3993, -3439, -2885, -2337, -1793, -1252, -715, -172};