/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0635 256 samples */
 
const int16_t AKWF_0635_256_DATA [256] = 
{282, 1069, 2155, 3460, 4938, 6558, 8290, 10099, 11967, 13869, 15775, 17669, 19529, 21327, 23054, 24686, 26201, 27593, 28842, 29933, 30861, 31613, 32181, 32558, 32758, 32622, 32034, 31194, 30169, 28987, 27683, 26275, 24781, 23225, 21620, 19981, 18329, 16675, 15031, 13420, 11847, 10328, 8878, 7504, 6218, 5033, 3954, 2993, 2157, 1449, 877, 447, 157, 17, -2, 0, 0, 0, 0, 3, -8, 61, 535, 1305, 2269, 3387, 4633, 5986, 7420, 8918, 10466, 12039, 13627, 15214, 16779, 18315, 19805, 21231, 22588, 23861, 25036, 26109, 27066, 27901, 28607, 29177, 29589, 29746, 30861, 5552, -1297, 280, 0, 0, 0, 0, -31, 70, -396, -4899, -8940, 6970, 4436, -234, 26, 10, 0, 0, 0, -1, -14, 36, -406, -2149, -4639, -7582, -10816, -14167, -17484, -20643, -23508, -25970, -27948, -29356, -30156, -30263, -29736, -28905, -27862, -26653, -25307, -23849, -22309, -20703, -19050, -17379, -15698, -14028, -12392, -10799, -9268, -7816, -6451, -5191, -4049, -3030, -2147, -1409, -820, -386, -113, -5, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -4, 9, -79, -608, -1452, -2500, -3713, -5061, -6517, -8053, -9653, -11294, -12952, -14617, -16264, -17873, -19437, -20933, -22345, -23665, -24876, -25965, -26927, -27748, -28420, -28941, -29297, -29512, -29445, -28718, -27554, -26109, -24449, -22622, -20673, -18650, -16585, -14514, -12482, -10510, -8634, -6889, -5292, -3871, -2650, -1643, -867, -332, -50, 3, -2, -1, 0, 0, 0, 0, 0, 0, 0, 0};