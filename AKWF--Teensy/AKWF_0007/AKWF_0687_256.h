/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0687 256 samples */
 
const int16_t AKWF_0687_256_DATA [256] = 
{2751, 9390, 14723, 19019, 22394, 25007, 27003, 28506, 29635, 30475, 31094, 31551, 31885, 32128, 32306, 32435, 32527, 32594, 32642, 32676, 32701, 32720, 32732, 32741, 32747, 32753, 32756, 32758, 32759, 32760, 32761, 32762, 32763, 32764, 32763, 32764, 32763, 32763, 32764, 32763, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32763, 32764, 32765, 32764, 32764, 32763, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32765, 32763, 32764, 32764, 32765, 32764, 32764, 32764, 32765, 32764, 32763, 32763, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32763, 32765, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32763, 32764, 32764, 32764, 32764, 32764, 32764, 32764, 32763, 32764, 32764, 32764, 32764, 32764, 32764, 32765, 32764, 32764, 32764, 32764, 32764, 32764, 32763, 32764, 32765, 32763, 32764, 32764, 32764, 32763, 32764, 32764, 32764, 32755, 32761, 32679, 30741, 26042, 19150, 11081, 3239, -10715, -19767, -24012, -26975, -28892, -30158, -31005, -31575, -31958, -32218, -32393, -32511, -32591, -32647, -32684, -32710, -32727, -32738, -32747, -32752, -32756, -32757, -32759, -32761, -32762, -32763, -32763, -32763, -32763, -32764, -32764, -32764, -32764, -32764, -32764, -32763, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32763, -32764, -32764, -32763, -32763, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32764, -32765, -32764, -32764, -32764, -32763, -32763, -32764, -32763, -32764, -32763, -32764, -32763, -32763, -32764, -32764, -32765, -32765, -32764, -32764, -32764, -32764, -32763, -32764, -32764, -32764, -32763, -32764, -32763, -32764, -32764, -32763, -32764, -32764, -32764, -32764, -32764, -32763, -32764, -32764, -32764, -32764, -32764, -32764, -32763, -32765, -32764, -32764, -32763, -32763, -32764, -32764, -32764, -32764, -32764, -32761, -32747, -32782, -31505, -27390, -20872, -12883, -4576};