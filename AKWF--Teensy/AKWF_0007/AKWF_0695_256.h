/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0695 256 samples */
 
const int16_t AKWF_0695_256_DATA [256] = 
{634, 1637, 2813, 2905, 8389, 23423, 27881, 30427, 31846, 32556, 32770, 32618, 32171, 31488, 30597, 29519, 28290, 26921, 25428, 23834, 22143, 20366, 18529, 16643, 14706, 12756, 10779, 8806, 6841, 4890, 3004, 1229, -442, -2004, -3455, -4808, -6054, -7201, -8254, -9212, -10079, -10860, -11553, -12167, -12703, -13163, -13550, -13868, -14115, -14301, -14423, -14482, -14485, -14429, -14323, -14157, -13941, -13675, -13360, -13000, -12591, -12138, -11641, -11104, -10524, -9906, -9251, -8557, -7832, -7072, -6278, -5458, -4609, -3731, -2831, -1908, -963, -4, 975, 1969, 2972, 3988, 5008, 6020, 7017, 7992, 8943, 9873, 10777, 11656, 12511, 13334, 14130, 14899, 15635, 16342, 17021, 17665, 18277, 18861, 19411, 19931, 20420, 20874, 21300, 21691, 22053, 22382, 22681, 22949, 23185, 23392, 23566, 23713, 23828, 23913, 23970, 23997, 23993, 23961, 23900, 23811, 23692, 23546, 23368, 23166, 22932, 22672, 22385, 22070, 21725, 21353, 20955, 20528, 20074, 19596, 19088, 18553, 17995, 17409, 16796, 16161, 15500, 14812, 14102, 13368, 12610, 11831, 11029, 10205, 9362, 8495, 7612, 6713, 5793, 4856, 3912, 2965, 2028, 1097, 173, -741, -1647, -2539, -3420, -4288, -5142, -5982, -6806, -7611, -8400, -9172, -9929, -10662, -11377, -12076, -12750, -13405, -14041, -14655, -15249, -15821, -16370, -16898, -17405, -17891, -18355, -18798, -19219, -19619, -19996, -20352, -20686, -20999, -21292, -21566, -21817, -22045, -22256, -22445, -22615, -22764, -22893, -23003, -23090, -23160, -23208, -23238, -23249, -23238, -23210, -23159, -23090, -23002, -22894, -22763, -22616, -22446, -22257, -22047, -21818, -21567, -21297, -21005, -20691, -20355, -20000, -19622, -19224, -18803, -18360, -17896, -17411, -16902, -16371, -15820, -15244, -14647, -14027, -13388, -12726, -12040, -11332, -10606, -9856, -9086, -8297, -7485, -6652, -5802, -4933, -4046, -3139, -2217, -1282, -308};