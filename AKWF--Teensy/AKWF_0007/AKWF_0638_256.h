/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0638 256 samples */
 
const int16_t AKWF_0638_256_DATA [256] = 
{3361, 11641, 18710, 24239, 27835, 29282, 28541, 25758, 21220, 15353, 8691, 1760, -4879, -10706, -15335, -18451, -19881, -19606, -17728, -14483, -10178, -5212, -13, 5026, 9506, 13110, 15619, 16888, 16890, 15697, 13476, 10454, 6907, 3158, -495, -3773, -6430, -8298, -9272, -9321, -8492, -6900, -4714, -2131, 623, 3317, 5753, 7751, 9176, 9953, 10054, 9511, 8401, 6843, 4988, 2990, 1019, -768, -2253, -3328, -3933, -4053, -3702, -2936, -1837, -515, 914, 2336, 3628, 4703, 5486, 5926, 6010, 5750, 5181, 4363, 3372, 2297, 1220, 225, -613, -1246, -1636, -1764, -1642, -1294, -764, -104, 622, 1350, 2020, 2583, 2994, 3228, 3274, 3133, 2825, 2380, 1838, 1240, 637, 73, -416, -798, -1053, -1170, -1153, -1012, -770, -457, -101, 263, 602, 1355, 3173, 6299, 10639, 15794, 21182, 26160, 30066, 32351, 32636, 30736, 26696, 20749, 13354, 5067, -3484, -11604, -18695, -24239, -27835, -29282, -28541, -25758, -21221, -15354, -8692, -1761, 4878, 10706, 15335, 18451, 19881, 19606, 17727, 14482, 10177, 5211, 12, -5027, -9507, -13111, -15620, -16888, -16891, -15698, -13476, -10455, -6907, -3159, 494, 3773, 6429, 8297, 9271, 9320, 8492, 6899, 4713, 2130, -624, -3317, -5753, -7751, -9176, -9953, -10055, -9512, -8402, -6843, -4989, -2991, -1020, 767, 2252, 3327, 3932, 4052, 3701, 2935, 1836, 514, -915, -2336, -3629, -4704, -5487, -5927, -6011, -5751, -5182, -4364, -3373, -2298, -1221, -226, 612, 1246, 1635, 1763, 1641, 1293, 763, 103, -623, -1351, -2021, -2584, -2995, -3229, -3274, -3133, -2826, -2381, -1839, -1241, -638, -74, 415, 797, 1052, 1169, 1152, 1011, 769, 456, 100, -264, -603, -1356, -3174, -6299, -10639, -15794, -21182, -26160, -30066, -32351, -32636, -30736, -26696, -20765, -13391, -4948};