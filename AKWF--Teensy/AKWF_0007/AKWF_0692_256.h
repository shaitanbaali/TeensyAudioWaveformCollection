/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0692 256 samples */
 
const int16_t AKWF_0692_256_DATA [256] = 
{339, 1008, 1422, 3096, 10942, 15291, 18092, 20307, 22094, 23579, 24837, 25924, 26875, 27714, 28460, 29128, 29744, 30236, 30308, 30753, 31041, 31252, 31449, 31650, 31848, 32045, 32239, 32435, 32510, 32674, 32730, 32727, 32757, 32657, 32559, 32400, 32173, 31914, 31587, 31108, 30003, 27956, 23709, 19923, 17693, 14844, 11592, 8393, 5283, 2282, -560, -3198, -5605, -7768, -9714, -11485, -13100, -14566, -15901, -17116, -18210, -19196, -20078, -20868, -21577, -22204, -22767, -23267, -23710, -24104, -24452, -24755, -25015, -25243, -25743, -26162, -26182, -26360, -26574, -26730, -26879, -27001, -27087, -27144, -27177, -27181, -27150, -27083, -27015, -26908, -26757, -26602, -26418, -26193, -25949, -25683, -25384, -25058, -24705, -24325, -23910, -23463, -22979, -22385, -21684, -21135, -20504, -19817, -19107, -18364, -17606, -16843, -16065, -15283, -14480, -13621, -12785, -11968, -11148, -10323, -9509, -8695, -7886, -7087, -6303, -5535, -4774, -4029, -3301, -2588, -1892, -1211, -545, 103, 732, 1348, 1953, 2537, 3110, 3661, 4203, 4731, 5246, 5749, 6230, 6683, 7113, 7122, 7106, 7672, 8095, 8290, 8531, 8766, 8973, 9181, 9383, 9599, 9815, 10032, 10248, 10465, 10682, 10899, 11081, 11140, 11354, 11580, 11601, 11647, 11774, 11843, 11813, 11787, 11779, 11713, 11559, 11390, 11223, 11002, 10717, 10395, 9895, 9310, 9038, 8629, 8079, 7534, 6988, 6438, 5885, 5325, 4763, 4213, 3671, 3130, 2604, 2095, 1602, 1129, 666, 228, -193, -597, -980, -1337, -1678, -2003, -2301, -2581, -2842, -3082, -3305, -3505, -3685, -3854, -3999, -4126, -4240, -4338, -4413, -4476, -4524, -4556, -4576, -4562, -4651, -5195, -5458, -5224, -5199, -5323, -5380, -5427, -5472, -5492, -5482, -5455, -5403, -5322, -5218, -5082, -4896, -4721, -4525, -4265, -3982, -3691, -3366, -3005, -2613, -2195, -1757, -1276, -764, -217};