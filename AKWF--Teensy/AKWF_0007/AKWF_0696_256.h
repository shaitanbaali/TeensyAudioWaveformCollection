/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0696 256 samples */
 
const int16_t AKWF_0696_256_DATA [256] = 
{7565, 15836, 17886, 19877, 21362, 22587, 23634, 24540, 25347, 26068, 26713, 27297, 27831, 28317, 28762, 29169, 29541, 29882, 30195, 30481, 30744, 30978, 31194, 31388, 31563, 31715, 31852, 31968, 32070, 32154, 32222, 32274, 32309, 32332, 32326, 32578, 32938, 32120, 22490, 19632, 18437, 17374, 16543, 15839, 15230, 14689, 14202, 13760, 13359, 12984, 12641, 12320, 12017, 11736, 11473, 11223, 10988, 10768, 10555, 10358, 10170, 9990, 9822, 9663, 9510, 9366, 9229, 9100, 8978, 8862, 8753, 8650, 8554, 8464, 8380, 8299, 8225, 8157, 8094, 8035, 7981, 7934, 7891, 7851, 7819, 7789, 7765, 7745, 7730, 7655, 7984, 6272, 2642, 2138, 1586, 1190, 867, 594, 354, 143, -45, -214, -368, -509, -639, -756, -861, -960, -1050, -1132, -1207, -1276, -1338, -1395, -1446, -1490, -1528, -1560, -1589, -1611, -1631, -1642, -1706, -1419, -3249, -5551, -5827, -6229, -6508, -6744, -6946, -7121, -7279, -7423, -7555, -7675, -7790, -7895, -7992, -8087, -8174, -8261, -8338, -8413, -8485, -8555, -8622, -8685, -8747, -8804, -8860, -8915, -8968, -9018, -9067, -9112, -9160, -9204, -9246, -9285, -9324, -9366, -9401, -9436, -9471, -9505, -9537, -9568, -9599, -9628, -9656, -9684, -9710, -9736, -9761, -9784, -9808, -9830, -9851, -9872, -9893, -9913, -9930, -9949, -9966, -9982, -9998, -10014, -10028, -10042, -10054, -10068, -10078, -10089, -10099, -10110, -10120, -10127, -10137, -10144, -10151, -10156, -10163, -10167, -10174, -10176, -10180, -10183, -10186, -10187, -10186, -10186, -10186, -10186, -10187, -10160, -10294, -9072, -8094, -7962, -7787, -7676, -7646, -7373, -8157, -16357, -18763, -19748, -20637, -21329, -21905, -22400, -22828, -23209, -23547, -23845, -24115, -24353, -24568, -24759, -24926, -25074, -25205, -25315, -25406, -25481, -25540, -25582, -25615, -25590, -25901, -26174, -26100, -26303, -26028, -4763};