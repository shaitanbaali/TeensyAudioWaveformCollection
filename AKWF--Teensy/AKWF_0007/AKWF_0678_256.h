/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0678 256 samples */
 
const int16_t AKWF_0678_256_DATA [256] = 
{3002, 7312, 11402, 15301, 18926, 22222, 25137, 27614, 29629, 31156, 32178, 32698, 32722, 32276, 31383, 30082, 28429, 26466, 24256, 21868, 19351, 16778, 14214, 11710, 9324, 7109, 5100, 3338, 1850, 646, -255, -856, -1166, -1198, -976, -527, 115, 915, 1831, 2821, 3847, 4869, 5845, 6741, 7531, 8183, 8681, 9009, 9158, 9124, 8912, 8530, 7991, 7314, 6523, 5639, 4691, 3709, 2718, 1747, 826, -26, -782, -1427, -1946, -2328, -2569, -2663, -2617, -2436, -2130, -1715, -1205, -621, 15, 685, 1364, 2029, 2661, 3240, 3746, 4166, 4486, 4695, 4790, 4765, 4623, 4365, 3999, 3536, 2985, 2361, 1682, 962, 223, -519, -1249, -1944, -2592, -3177, -3684, -4106, -4432, -4656, -4775, -4789, -4699, -4509, -4226, -3860, -3421, -2919, -2373, -1792, -1195, -596, -9, 550, 1064, 1527, 1922, 2241, 2476, 2618, 2665, 2614, 2466, 2220, 1881, 1457, 952, 374, -262, -949, -1677, -2427, -3191, -3957, -4707, -5432, -6119, -6757, -7336, -7847, -8282, -8635, -8901, -9076, -9159, -9150, -9050, -8861, -8587, -8235, -7811, -7320, -6776, -6183, -5555, -4902, -4232, -3559, -2894, -2244, -1626, -1046, -512, -38, 369, 705, 960, 1130, 1210, 1197, 1086, 879, 574, 170, -328, -919, -1604, -2374, -3223, -4151, -5148, -6206, -7323, -8487, -9693, -10933, -12196, -13475, -14766, -16056, -17338, -18610, -19855, -21075, -22260, -23400, -24495, -25538, -26522, -27445, -28303, -29089, -29807, -30448, -31012, -31500, -31908, -32237, -32488, -32660, -32752, -32767, -32711, -32576, -32372, -32096, -31756, -31349, -30882, -30357, -29774, -29143, -28460, -27732, -26965, -26156, -25312, -24438, -23535, -22605, -21656, -20686, -19699, -18704, -17695, -16678, -15659, -14636, -13613, -12594, -11578, -10568, -9569, -8577, -7598, -6633, -5681, -4744, -3827, -2909, -2117, -772};