/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0646 256 samples */
 
const int16_t AKWF_0646_256_DATA [256] = 
{580, 1502, 2402, 3308, 4212, 5116, 6023, 6926, 7832, 8738, 9641, 10547, 11452, 12356, 13262, 14167, 15071, 15976, 16883, 17786, 18692, 19598, 20501, 21408, 22312, 23217, 24122, 25027, 25932, 26837, 27742, 28646, 29553, 30457, 31350, 32306, 32799, 32751, 32756, 32751, 32745, 32741, 32735, 32731, 32725, 32720, 32716, 32710, 32706, 32700, 32696, 32690, 32685, 32681, 32675, 32670, 32665, 32660, 32656, 32650, 32646, 32640, 32635, 32630, 32625, 32621, 32615, 32610, 32605, 32600, 32595, 32589, 32586, 32580, 32575, 32570, 32565, 32560, 32555, 32550, 32545, 32539, 32535, 32529, 32525, 32519, 32515, 32510, 32504, 32500, 32485, 32522, 32024, 31070, 30177, 29272, 28366, 27461, 26557, 25651, 24746, 23842, 22936, 22032, 21127, 20220, 19318, 18411, 17506, 16602, 15696, 14791, 13887, 12982, 12075, 11172, 10266, 9360, 8457, 7551, 6646, 5742, 4835, 3932, 3027, 2121, 1217, 312, -593, -1498, -2402, -3309, -4212, -5117, -6024, -6927, -7833, -8739, -9642, -10548, -11453, -12357, -13262, -14168, -15072, -15977, -16884, -17786, -18693, -19598, -20501, -21408, -22313, -23217, -24123, -25027, -25932, -26837, -27742, -28646, -29553, -30457, -31350, -32306, -32799, -32751, -32756, -32751, -32745, -32741, -32735, -32731, -32725, -32720, -32716, -32710, -32706, -32700, -32696, -32690, -32685, -32681, -32675, -32670, -32665, -32660, -32656, -32650, -32646, -32640, -32635, -32630, -32625, -32621, -32615, -32610, -32605, -32600, -32595, -32589, -32586, -32580, -32575, -32570, -32565, -32560, -32555, -32550, -32545, -32539, -32535, -32529, -32525, -32519, -32515, -32510, -32504, -32500, -32485, -32522, -32024, -31070, -30177, -29272, -28366, -27461, -26557, -25651, -24747, -23842, -22936, -22032, -21128, -20221, -19318, -18412, -17506, -16603, -15696, -14792, -13887, -12982, -12076, -11173, -10267, -9361, -8458, -7552, -6646, -5743, -4836, -3932, -3028, -2123, -1222, -300};