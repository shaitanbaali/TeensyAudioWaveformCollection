/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0674 256 samples */
 
const int16_t AKWF_0674_256_DATA [256] = 
{20454, 26677, 28765, 30026, 30798, 31315, 31680, 31946, 32146, 32301, 32419, 32512, 32585, 32643, 32687, 32719, 32744, 32759, 32767, 32768, 32764, 32756, 32741, 32720, 32694, 32664, 32627, 32586, 32539, 32486, 32427, 32360, 32286, 32205, 32118, 32021, 31913, 31796, 31669, 31529, 31376, 31208, 31025, 30825, 30606, 30366, 30105, 29818, 29505, 29160, 28782, 28370, 27919, 27424, 26881, 26286, 25634, 24922, 24142, 23291, 22367, 21358, 20265, 19083, 17806, 16440, 14982, 13430, 11797, 10083, 8297, 6458, 4573, 2654, 732, -1191, -3096, -4957, -6775, -8529, -10207, -11810, -13328, -14752, -16094, -17346, -18507, -19587, -20588, -21512, -22365, -23151, -23874, -24541, -25155, -25719, -26240, -26718, -27158, -27566, -27940, -28286, -28607, -28902, -29176, -29429, -29662, -29880, -30084, -30270, -30444, -30606, -30758, -30898, -31029, -31153, -31266, -31373, -31473, -31566, -31653, -31734, -31811, -31884, -31950, -32012, -32071, -32126, -32179, -32227, -32272, -32314, -32355, -32392, -32427, -32459, -32489, -32518, -32544, -32570, -32592, -32613, -32633, -32651, -32668, -32683, -32697, -32710, -32721, -32729, -32739, -32747, -32753, -32759, -32763, -32766, -32768, -32767, -32767, -32768, -32766, -32762, -32759, -32754, -32747, -32739, -32731, -32722, -32712, -32699, -32687, -32672, -32658, -32641, -32623, -32605, -32583, -32562, -32538, -32514, -32487, -32459, -32428, -32396, -32363, -32328, -32289, -32249, -32208, -32163, -32116, -32066, -32013, -31957, -31899, -31837, -31771, -31703, -31631, -31554, -31473, -31386, -31295, -31200, -31098, -30992, -30878, -30759, -30633, -30499, -30359, -30208, -30049, -29882, -29703, -29514, -29313, -29100, -28874, -28633, -28379, -28108, -27823, -27518, -27192, -26847, -26480, -26091, -25675, -25234, -24766, -24267, -23738, -23175, -22578, -21945, -21273, -20563, -19810, -19015, -18177, -17293, -16363, -15392, -14371, -13308, -12202, -11050, -9860, -8634, -7374, -6082, -4769, -3428, -2112, -564};