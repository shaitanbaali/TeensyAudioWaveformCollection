/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0623 256 samples */
 
const int16_t AKWF_0623_256_DATA [256] = 
{1873, 3342, 4431, 5376, 6215, 6972, 7660, 8286, 8858, 9380, 9850, 10275, 10654, 10987, 11277, 11523, 11725, 11884, 11997, 12082, 12068, 11374, 10833, 10440, 10089, 9771, 9477, 9201, 8941, 8693, 8456, 8228, 8008, 7796, 7590, 7390, 7196, 7007, 6822, 6643, 6468, 6295, 6128, 5963, 5803, 5646, 5490, 5339, 5190, 5045, 4902, 4762, 4625, 4490, 4358, 4227, 4099, 3974, 3851, 3731, 3612, 3496, 3381, 3270, 3160, 3052, 2946, 2842, 2741, 2641, 2544, 2448, 2354, 2262, 2172, 2084, 1998, 1913, 1831, 1751, 1672, 1596, 1521, 1448, 1377, 1308, 1240, 1174, 1110, 1048, 988, 930, 873, 818, 765, 714, 664, 617, 571, 526, 484, 444, 405, 368, 333, 299, 268, 238, 209, 183, 159, 135, 115, 95, 77, 61, 48, 36, 25, 16, 9, 5, 1, -42, 118, -514, -7638, -12891, -16684, -19956, -22757, -25171, -27222, -28940, -30336, -31411, -32126, -32807, -31846, -27309, -24481, -22162, -20111, -18265, -16577, -15013, -13559, -12206, -10937, -9751, -8645, -7609, -6647, -5754, -4926, -4166, -3473, -2842, -2276, -1774, -1333, -956, -642, -391, -201, -73, -9, 0, -1, -1, 0, 0, 0, 0, -6, -15, 59, -2724, -5427, -7150, -8672, -9968, -11080, -12034, -12834, -13487, -13998, -14354, -14642, -14505, -11959, -10070, -8688, -7470, -6397, -5434, -4570, -3790, -3089, -2467, -1916, -1437, -1028, -688, -415, -212, -76, -9, 0, -1, -1, 0, 0, 0, 33, -136, 1217, 3318, 4498, 5497, 6284, 6893, 7317, 7636, 7543, 5557, 4120, 3097, 2240, 1539, 975, 542, 236, 55, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};