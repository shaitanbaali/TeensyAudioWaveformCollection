/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0626 256 samples */
 
const int16_t AKWF_0626_256_DATA [256] = 
{5310, 15982, 17553, 10891, 3894, 2145, 2342, 4877, 6622, 5596, 5915, 7803, 11390, 17226, 18384, 18684, 21048, 20288, 20416, 20997, 21472, 21950, 22442, 22852, 23188, 23473, 23703, 23894, 24139, 24435, 24707, 24878, 24778, 24366, 23673, 22722, 21776, 18515, 16720, 16062, 15375, 14843, 14761, 13414, 11158, 9862, 8026, 6191, 6336, -1797, -25824, -25465, -22836, -23945, -22978, -20760, -17387, -13185, -7877, -5869, -9613, -16908, -27509, -30010, -28079, -26824, -25324, -23805, -22253, -21096, -17085, -11089, -10946, -10754, -10402, -9732, -11006, -12036, -13448, -12880, -13905, -16685, -17517, -19431, -18277, -16160, -18158, -19462, -20612, -21560, -22313, -22859, -23260, -23463, -23544, -23411, -23353, -20991, -19020, -18278, -17684, -14289, -9173, -8542, -7402, -6396, -5494, -4608, -4038, -4918, -6039, -5509, -847, -569, -70, 765, 1865, 3067, 4440, 7166, 6765, 5526, 3841, 1951, -752, 934, 2007, -6204, 63, 11127, 13943, 7769, -816, -4159, -5099, -3578, -1756, -3035, -3468, -2394, 206, 5649, 7377, 7040, 8880, 8568, 8013, 8606, 9095, 9659, 10271, 10954, 11656, 12320, 13034, 13798, 14590, 15474, 16435, 17308, 17999, 18433, 18604, 18457, 18463, 16503, 14925, 15155, 15305, 15708, 16412, 16583, 15027, 14653, 13707, 12756, 12548, 10185, -14577, -17859, -14113, -14184, -13492, -10971, -7385, -2929, 2501, 6275, 3561, -2904, -11924, -9692, -8259, -7776, -7451, -7468, -7634, -8310, -6160, -1851, -2366, -2776, -3097, -3123, -5183, -6995, -9242, -9492, -11333, -14954, -16671, -19474, -19294, -18157, -21092, -23283, -25304, -27094, -28640, -29892, -30886, -31668, -32211, -32533, -32657, -32766, -30520, -29589, -29709, -28730, -26601, -24455, -21942, -19105, -17505, -16557, -15981, -16687, -17481, -15176, -10523, -10049, -8738, -7240, -5431, -3673, -1119, 1915, 1884, 1393, 442, -689, -2231, 1629, 1047, -4650};