/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0684 256 samples */
 
const int16_t AKWF_0684_256_DATA [256] = 
{5545, 15915, 20408, 24203, 27030, 29153, 30699, 31754, 32408, 32716, 32746, 32545, 32163, 31638, 31013, 30335, 29631, 28942, 28293, 27703, 27202, 26795, 26494, 26304, 26227, 26259, 26390, 26618, 26923, 27303, 27734, 28201, 28695, 29200, 29698, 30185, 30641, 31057, 31429, 31744, 32002, 32191, 32311, 32361, 32344, 32259, 32101, 31877, 31592, 31244, 30850, 30400, 29908, 29377, 28813, 28213, 27594, 26956, 26296, 25625, 24948, 24263, 23575, 22884, 22197, 21507, 20817, 20136, 19449, 18764, 18087, 17400, 16716, 16025, 15333, 14635, 13923, 13202, 12472, 11726, 10964, 10186, 9383, 8569, 7729, 6868, 5926, 4915, 3895, 2864, 1804, 726, -369, -1488, -2621, -3768, -4943, -6141, -7260, -8334, -9419, -10494, -11573, -12640, -13702, -14763, -15814, -16852, -17881, -18892, -19886, -20859, -21811, -22739, -23638, -24500, -25333, -26129, -26885, -27606, -28280, -28910, -29498, -30035, -30525, -30967, -31362, -31707, -32000, -32244, -32444, -32596, -32692, -32755, -32764, -32735, -32664, -32553, -32409, -32223, -32010, -31767, -31499, -31204, -30891, -30569, -30229, -29880, -29534, -29180, -28839, -28503, -28177, -27862, -27572, -27306, -27063, -26845, -26657, -26501, -26382, -26294, -26245, -26224, -26246, -26300, -26384, -26505, -26663, -26842, -27048, -27289, -27543, -27816, -28106, -28408, -28721, -29039, -29358, -29674, -29991, -30294, -30590, -30873, -31133, -31379, -31597, -31794, -31969, -32107, -32221, -32299, -32348, -32363, -32348, -32299, -32216, -32098, -31947, -31766, -31551, -31302, -31032, -30734, -30406, -30055, -29684, -29287, -28876, -28441, -27992, -27530, -27058, -26568, -26074, -25568, -25059, -24545, -24025, -23502, -22972, -22449, -21917, -21390, -20853, -20328, -19796, -19256, -18724, -18193, -17655, -17110, -16571, -16020, -15469, -14915, -14348, -13776, -13193, -12604, -12006, -11391, -10765, -10129, -9473, -8804, -8123, -7419, -6700, -5906, -5067, -4220, -3363, -2489, -1596, -671};