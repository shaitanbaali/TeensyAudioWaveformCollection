/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0668 256 samples */
 
const int16_t AKWF_0668_256_DATA [256] = 
{480, 579, 7445, 14558, 18756, 22389, 25364, 27782, 29708, 31156, 32087, 32879, 31073, 27803, 25987, 24356, 22932, 21639, 20450, 19350, 18317, 17342, 16423, 15548, 14714, 13926, 13134, 12664, 12312, 11775, 11219, 10643, 10050, 9452, 8852, 8247, 7645, 7046, 6452, 5871, 5304, 4751, 4123, 6915, 8674, 9046, 9239, 9224, 9083, 8847, 8547, 8196, 7809, 7397, 6961, 6512, 6061, 5602, 5144, 4688, 4242, 3805, 3378, 2975, 2599, 2120, 3676, 5322, 6183, 6939, 7573, 8125, 8629, 9091, 9526, 9943, 10347, 10744, 11140, 11555, 11869, 12795, 14414, 15496, 16490, 17403, 18253, 19058, 19824, 20552, 21252, 21917, 22559, 23173, 23761, 24323, 24863, 25379, 25871, 26341, 26786, 27212, 27616, 27992, 28352, 28688, 29003, 29291, 29560, 29808, 30030, 30234, 30414, 30570, 30704, 30813, 30900, 30968, 30873, 31567, 26141, 17959, 13485, 9627, 6509, 3977, 1992, 523, -508, -580, -7450, -14567, -18765, -22397, -25370, -27788, -29714, -31165, -32097, -32878, -31146, -28001, -26249, -24660, -23268, -22000, -20827, -19732, -18696, -17716, -16784, -15891, -15038, -14219, -13432, -12675, -11948, -11243, -10568, -9916, -9285, -8680, -8097, -7532, -6992, -6469, -5969, -5484, -5024, -4581, -4157, -3752, -3365, -2995, -2646, -2313, -2002, -1707, -1429, -1166, -925, -702, -492, -301, -132, 23, 162, 281, 382, 467, 537, 585, 594, 749, -1738, -4364, -5966, -7426, -8723, -9903, -10999, -12027, -12996, -13914, -14790, -15628, -16428, -17197, -17935, -18647, -19333, -19990, -20627, -21239, -21827, -22394, -22943, -23471, -23978, -24467, -24934, -25385, -25816, -26232, -26627, -27004, -27368, -27708, -28035, -28344, -28637, -28909, -29168, -29408, -29631, -29839, -30029, -30207, -30363, -30502, -30629, -30739, -30832, -30906, -30963, -31006, -30900, -31583, -26158, -17977, -13497, -9643, -6524, -3996, -2013, -538};