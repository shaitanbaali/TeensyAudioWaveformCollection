/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0639 256 samples */
 
const int16_t AKWF_0639_256_DATA [256] = 
{1462, 5732, 8905, 11052, 12194, 12418, 11868, 10721, 9165, 7382, 5548, 3792, 2230, 936, -46, -709, -1062, -1141, -989, -660, -211, 309, 849, 1372, 1848, 2256, 2584, 2829, 2993, 3086, 3117, 3100, 3048, 2977, 2893, 2810, 2739, 2677, 2634, 2607, 2599, 2602, 2620, 2649, 2682, 2720, 2759, 2793, 2827, 2853, 2875, 2890, 2902, 2907, 2906, 2901, 2896, 2885, 2873, 2858, 2842, 2824, 2806, 2786, 2765, 2745, 2721, 2699, 2674, 2649, 2622, 2594, 2564, 2533, 2500, 2467, 2431, 2391, 2350, 2309, 2265, 2219, 2173, 2127, 2078, 2030, 1980, 1927, 1875, 1821, 1766, 1708, 1653, 1594, 1534, 1474, 1414, 1351, 1287, 1223, 1160, 1094, 1028, 963, 895, 828, 762, 694, 626, 562, 484, 509, 1482, 4074, 8230, 13481, 19156, 24502, 28843, 31698, 32768, 31982, 29460, 25495, 20479, 14834, 9027, 3461, -1541, -5707, -8897, -11053, -12195, -12418, -11869, -10722, -9165, -7382, -5549, -3793, -2231, -937, 45, 708, 1061, 1140, 988, 659, 210, -310, -850, -1373, -1849, -2257, -2585, -2830, -2994, -3086, -3118, -3101, -3049, -2978, -2894, -2811, -2740, -2678, -2635, -2608, -2600, -2603, -2621, -2650, -2683, -2721, -2760, -2794, -2828, -2854, -2876, -2891, -2902, -2908, -2907, -2902, -2897, -2886, -2873, -2859, -2843, -2825, -2807, -2787, -2766, -2746, -2722, -2699, -2675, -2650, -2623, -2595, -2565, -2534, -2501, -2468, -2432, -2392, -2351, -2310, -2266, -2220, -2174, -2128, -2079, -2031, -1981, -1928, -1876, -1822, -1767, -1709, -1654, -1595, -1535, -1475, -1414, -1352, -1288, -1224, -1161, -1095, -1028, -964, -896, -829, -762, -695, -627, -563, -485, -510, -1483, -4075, -8230, -13481, -19157, -24502, -28843, -31698, -32768, -31982, -29460, -25495, -20480, -14843, -9046, -3400};