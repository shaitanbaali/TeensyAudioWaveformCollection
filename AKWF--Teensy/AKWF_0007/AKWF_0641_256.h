/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0641 256 samples */
 
const int16_t AKWF_0641_256_DATA [256] = 
{583, 1608, 2619, 3636, 4655, 5674, 6689, 7698, 8705, 9711, 10708, 11704, 12691, 13665, 14627, 15579, 16517, 17441, 18344, 19220, 20074, 20901, 21704, 22482, 23236, 23964, 24670, 25352, 26007, 26639, 27244, 27823, 28374, 28894, 29388, 29857, 30296, 30703, 31073, 31407, 31703, 31964, 32188, 32374, 32526, 32640, 32717, 32760, 32767, 32740, 32678, 32582, 32452, 32290, 32094, 31866, 31606, 31316, 30995, 30645, 30266, 29857, 29411, 28921, 28389, 27826, 27231, 26607, 25956, 25275, 24566, 23832, 23071, 22282, 21463, 20603, 19696, 18757, 17791, 16804, 15803, 14785, 13760, 12733, 11701, 10670, 9643, 8614, 7592, 6576, 5565, 4562, 3566, 2573, 1589, 619, -340, -1283, -2210, -3123, -4015, -4891, -5749, -6584, -7399, -8194, -8962, -9711, -10435, -11132, -11806, -12453, -13073, -13665, -14232, -14768, -15281, -15770, -16239, -16689, -17117, -17519, -17895, -18242, -18562, -18854, -19119, -19364, -19586, -19781, -19951, -20095, -20213, -20305, -20373, -20419, -20441, -20438, -20413, -20371, -20311, -20227, -20120, -19992, -19841, -19671, -19488, -19292, -19077, -18843, -18591, -18320, -18031, -17727, -17409, -17077, -16727, -16362, -15986, -15603, -15210, -14807, -14422, -14086, -13780, -13475, -13166, -12860, -12554, -12245, -11937, -11631, -11328, -11043, -10784, -10544, -10312, -10084, -9861, -9641, -9416, -9188, -8957, -8721, -8485, -8250, -8012, -7792, -7663, -7642, -7667, -7709, -7813, -8003, -8241, -8495, -8768, -9064, -9375, -9704, -10064, -10449, -10845, -11252, -11670, -12094, -12522, -12949, -13371, -13786, -14190, -14580, -14956, -15317, -15658, -15979, -16277, -16550, -16800, -17026, -17223, -17390, -17525, -17627, -17698, -17735, -17734, -17697, -17623, -17509, -17357, -17165, -16934, -16661, -16347, -15989, -15586, -15139, -14638, -14078, -13460, -12783, -12056, -11289, -10489, -9660, -8809, -7935, -7048, -6147, -5228, -4291, -3340, -2375, -1398, -390};