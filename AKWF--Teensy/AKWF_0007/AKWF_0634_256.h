/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0634 256 samples */
 
const int16_t AKWF_0634_256_DATA [256] = 
{9998, 10225, 10028, 9877, 9687, 9474, 9238, 8986, 8717, 8433, 8139, 7832, 7515, 7193, 6863, 6528, 6192, 5851, 5511, 5171, 4832, 4497, 4167, 3841, 3521, 3210, 2907, 2613, 2330, 2059, 1801, 1556, 1324, 1109, 909, 724, 556, 406, 273, 159, 64, -13, 49, -654, 2393, 10649, 9988, 9945, 9776, 9579, 9360, 9120, 8862, 8589, 8302, 8004, 7694, 7377, 7051, 6720, 6385, 6046, 5706, 5366, 5025, 4688, 4354, 4024, 3700, 3382, 3073, 2772, 2482, 2202, 1935, 1680, 1438, 1211, 999, 803, 623, 460, 314, 187, 78, -13, -83, -136, -168, -181, -181, -182, -183, -182, -183, -183, -183, -183, -183, -184, -183, -184, -184, -183, -183, -184, -183, -184, -184, -183, -183, -183, -184, -184, -184, -189, -183, -228, -1451, -3862, -6876, -10286, -13914, -17572, -21102, -24371, -27233, -29583, -31332, -32425, -32753, -31126, -27876, -23861, -19424, -14917, -10620, -6804, -3708, -1493, -313, -100, -50, -343, 1218, 8810, 2329, -657, 9, -94, -95, -93, -91, -90, -90, -89, -88, -87, -87, -86, -86, -86, -86, -85, -84, -84, -84, -113, -33, -180, -7857, -2733, 513, -192, -83, -82, -81, -81, -80, -80, -80, -79, -79, -79, -79, -79, -78, -79, -79, -78, -79, -79, -79, -78, -78, -78, -79, -78, -79, -77, -78, -77, -78, -77, -77, -78, -77, -78, -78, -77, -77, -78, -77, -77, -78, -77, -77, -77, -78, -78, -78, -77, -77, -78, -77, -76, -76, -77, -77, -77, -77, -77, -76, -77, -77, -77, -77, -76, -77, -77, -76, -77, -76, -77, -77, -77, -76, -77, -77, -77, -77, -77, -78, -90, -19, -317};