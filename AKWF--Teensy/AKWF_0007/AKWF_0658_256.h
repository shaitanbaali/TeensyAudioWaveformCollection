/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0658 256 samples */
 
const int16_t AKWF_0658_256_DATA [256] = 
{23194, 23197, 23199, 23200, 23199, 22940, 24415, 5928, -1271, 294, 11, 12, 12, 11, 12, 10, 9, 10, 10, 10, 10, 10, 10, 9, 12, -4, -22, -15, -10, -6, -2, 0, 2, 4, 6, 7, 6, 7, 6, 9, 10, 11, 13, 15, 17, 20, 24, 28, 32, 36, 42, 46, 52, 58, 64, 71, 78, 85, 93, 102, 110, 119, 128, 138, 148, 158, 169, 180, 192, 203, 216, 228, 236, 272, 179, -11, 10, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 493, -2178, 22349, 34880, 32287, 32756, 32753, 32520, 33635, 29516, -19977, -24095, -22978, -23209, -23208, -22950, -24423, -5937, 1262, -304, -21, -20, -21, -20, -21, -20, -17, -18, -18, -17, -17, -17, -17, -17, -17, -17, -18, -17, -15, -16, -16, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -502, 2169, -22356, -34888, -32296, -32763, -32761, -32757, -32755, -32749};