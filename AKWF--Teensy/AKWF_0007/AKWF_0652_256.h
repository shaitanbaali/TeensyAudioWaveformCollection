/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0652 256 samples */
 
const int16_t AKWF_0652_256_DATA [256] = 
{1468, 4019, 6264, 7937, 9793, 11623, 13359, 15003, 16565, 18045, 19443, 20768, 22017, 23192, 24297, 25333, 26298, 27197, 28027, 28789, 29486, 30115, 30676, 31172, 31601, 31963, 32258, 32485, 32627, 32813, 32417, 30334, 29037, 28002, 27087, 26257, 25493, 24777, 24099, 23455, 22838, 22245, 21673, 21120, 20581, 20061, 19553, 19057, 18574, 18101, 17637, 17185, 16741, 16303, 15875, 15454, 15040, 14634, 14234, 13839, 13451, 13067, 12689, 12317, 11948, 11586, 11229, 10875, 10526, 10182, 9840, 9504, 9171, 8841, 8516, 8194, 7875, 7561, 7250, 6941, 6637, 6334, 6035, 5741, 5447, 5156, 4871, 4585, 4303, 4026, 3749, 3476, 3205, 2937, 2672, 2409, 2147, 1888, 1633, 1379, 1128, 879, 632, 388, 146, -94, -332, -567, -800, -1031, -1261, -1488, -1713, -1936, -2157, -2375, -2593, -2807, -3021, -3232, -3442, -3648, -3854, -4055, -4258, -4458, -4656, -4851, -5045, -5237, -5427, -5615, -5802, -5986, -6170, -6351, -6530, -6708, -6883, -7057, -7230, -7401, -7569, -7737, -7902, -8066, -8228, -8386, -8546, -8703, -8858, -9011, -9164, -9313, -9462, -9608, -9754, -9897, -10040, -10179, -10318, -10455, -10589, -10723, -10855, -10985, -11115, -11241, -11367, -11491, -11613, -11733, -11853, -11970, -12086, -12201, -12313, -12423, -12533, -12641, -12747, -12853, -12955, -13057, -13157, -13256, -13353, -13448, -13541, -13632, -13724, -13813, -13901, -13987, -14071, -14154, -14236, -14315, -14393, -14470, -14545, -14618, -14691, -14761, -14829, -14896, -14963, -15028, -15090, -15151, -15212, -15270, -15325, -15380, -15435, -15487, -15538, -15587, -15634, -15681, -15725, -15768, -15809, -15849, -15887, -15923, -15960, -15994, -16026, -16057, -16087, -16114, -16140, -16165, -16188, -16210, -16230, -16248, -16266, -16282, -16295, -16310, -16321, -16329, -16338, -16346, -16350, -16354, -16356, -16357, -16270, -16677, -14544, -8065, -4359, -1168};