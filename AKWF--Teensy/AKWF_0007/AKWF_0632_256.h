/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0632 256 samples */
 
const int16_t AKWF_0632_256_DATA [256] = 
{544, 2116, 3650, 5177, 6687, 8175, 9638, 11062, 12450, 13793, 15082, 16316, 17491, 18598, 19636, 20598, 21479, 22278, 22991, 23612, 24141, 24576, 24913, 25152, 25291, 25331, 25330, 25330, 25329, 25326, 25321, 25309, 25287, 25249, 25188, 25096, 24965, 24782, 24537, 24221, 23817, 23316, 22709, 21982, 21128, 20144, 19019, 17755, 16357, 14820, 13160, 11388, 9510, 7550, 5532, 3467, 1390, -671, -2698, -4652, -6508, -8242, -9820, -11219, -12421, -13400, -14143, -14639, -14871, -14897, -14894, -14895, -14895, -14896, -14895, -14895, -14893, -14891, -14887, -14882, -14874, -14863, -14848, -14828, -14803, -14771, -14731, -14681, -14620, -14548, -14462, -14359, -14241, -14103, -13946, -13767, -13564, -13337, -13083, -12801, -12491, -12151, -11778, -11375, -10938, -10469, -9966, -9430, -8860, -8260, -7625, -6960, -6266, -5542, -4792, -4018, -3221, -2404, -1572, -723, 137, 1003, 1876, 2749, 3617, 4482, 5334, 6172, 6993, 7790, 8561, 9302, 10009, 10679, 11308, 11892, 12431, 12919, 13353, 13733, 14056, 14319, 14523, 14666, 14746, 14766, 14765, 14765, 14765, 14763, 14760, 14754, 14742, 14721, 14688, 14637, 14565, 14464, 14327, 14149, 13919, 13631, 13276, 12843, 12329, 11721, 11014, 10205, 9285, 8249, 7101, 5833, 4448, 2954, 1348, -358, -2153, -4035, -5986, -7987, -10032, -12097, -14162, -16217, -18232, -20188, -22072, -23856, -25522, -27056, -28435, -29644, -30674, -31506, -32135, -32553, -32747, -32769, -32766, -32767, -32767, -32768, -32767, -32766, -32765, -32762, -32758, -32751, -32742, -32729, -32711, -32688, -32657, -32618, -32569, -32508, -32435, -32346, -32238, -32113, -31965, -31794, -31595, -31370, -31112, -30823, -30497, -30134, -29730, -29284, -28794, -28259, -27675, -27042, -26360, -25625, -24837, -23999, -23104, -22156, -21157, -20105, -18999, -17847, -16642, -15391, -14100, -12761, -11386, -9977, -8532, -7061, -5567, -4053, -2528, -960};