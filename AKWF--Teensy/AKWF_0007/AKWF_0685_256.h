/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0685 256 samples */
 
const int16_t AKWF_0685_256_DATA [256] = 
{345, 4048, 6724, 8657, 10279, 11629, 12757, 13692, 14460, 15079, 15565, 15931, 16188, 16350, 16424, 16420, 16348, 16215, 16029, 15799, 15528, 15223, 14892, 14540, 14171, 13789, 13400, 13009, 12617, 12229, 11846, 11474, 11112, 10765, 10436, 10123, 9828, 9555, 9304, 9077, 8873, 8692, 8536, 8404, 8297, 8217, 8160, 8130, 8126, 8145, 8191, 8261, 8354, 8474, 8615, 8784, 8950, 9018, 8972, 8819, 8563, 8209, 7764, 7239, 6635, 5967, 5244, 4475, 3675, 2858, 2040, 1249, 515, -25, -609, -1435, -2379, -3415, -4532, -5712, -6940, -8214, -9518, -10840, -12182, -13528, -14869, -16204, -17520, -18811, -20076, -21304, -22488, -23631, -24717, -25747, -26721, -27627, -28468, -29240, -29939, -30564, -31113, -31585, -31979, -32293, -32528, -32683, -32759, -32756, -32676, -32519, -32286, -31979, -31600, -31153, -30637, -30056, -29412, -28709, -27951, -27141, -26279, -25372, -24425, -23439, -22420, -21372, -20296, -19202, -18093, -16967, -15839, -14705, -13572, -12448, -11332, -10234, -9155, -8100, -7071, -6079, -5123, -4208, -3343, -2532, -1782, -1102, -505, -70, 297, 800, 1357, 1940, 2534, 3127, 3714, 4289, 4846, 5380, 5890, 6370, 6820, 7237, 7618, 7961, 8268, 8537, 8766, 8956, 9104, 9215, 9283, 9314, 9306, 9260, 9176, 9059, 8905, 8717, 8500, 8251, 7975, 7672, 7347, 7000, 6631, 6246, 5846, 5432, 5008, 4578, 4141, 3704, 3267, 2832, 2405, 1987, 1583, 1196, 831, 496, 202, -7, -218, -507, -825, -1162, -1511, -1867, -2224, -2582, -2935, -3282, -3620, -3945, -4259, -4557, -4836, -5099, -5341, -5562, -5760, -5936, -6089, -6215, -6316, -6391, -6439, -6461, -6456, -6426, -6369, -6285, -6175, -6042, -5883, -5702, -5496, -5269, -5024, -4756, -4471, -4171, -3856, -3528, -3190, -2842, -2488, -2131, -1772, -1416, -1069, -734, -421, -141};