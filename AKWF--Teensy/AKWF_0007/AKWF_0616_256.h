/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0616 256 samples */
 
const int16_t AKWF_0616_256_DATA [256] = 
{332, 1359, 2410, 3500, 4618, 5760, 6921, 8092, 9273, 10460, 11643, 12823, 13996, 15155, 16300, 17427, 18528, 19607, 20656, 21672, 22656, 23602, 24507, 25372, 26192, 26963, 27688, 28361, 28981, 29548, 30058, 30513, 30909, 31245, 31522, 31738, 31798, 32132, 31458, 9218, -4599, -2881, -2021, -877, 409, 1775, 3208, 4684, 6182, 7695, 9207, 10701, 12171, 13602, 14981, 16305, 17560, 18735, 19827, 20825, 21723, 22517, 23198, 23764, 24212, 24531, 24734, 24797, 23710, 21712, 19417, 16923, 14322, 11695, 9116, 6638, 4318, 2213, 357, -1208, -2449, -3348, -3881, -4041, -4037, -4041, -4042, -4044, -4045, -4045, -4046, -4047, -4046, -4046, -4046, -4046, -4046, -4047, -4046, -4044, -4045, -4044, -4043, -4042, -4042, -4042, -4041, -4040, -4040, -4038, -4037, -4037, -4036, -4035, -4035, -4033, -4032, -4031, -4030, -4030, -4032, -4032, -4023, -5173, -7375, -9911, -12656, -15493, -18334, -21082, -23670, -26034, -28107, -29845, -31206, -32149, -32687, -32626, -31869, -30878, -29747, -28512, -27199, -25825, -24416, -22975, -21521, -20071, -18625, -17201, -15812, -14458, -13155, -11913, -10734, -9629, -8606, -7668, -6822, -6074, -5429, -4890, -4459, -4141, -3935, -3847, -3839, -3836, -3834, -3832, -3829, -3828, -3826, -3824, -3822, -3820, -3819, -3817, -3816, -3814, -3813, -3811, -3810, -3808, -3807, -3806, -3804, -3803, -3802, -3801, -3800, -3798, -3798, -3797, -3795, -3794, -3793, -3791, -3791, -3790, -3789, -3787, -3786, -3786, -3785, -3783, -3782, -3781, -3780, -3779, -3778, -3777, -3776, -3775, -3774, -3774, -3772, -3771, -3770, -3769, -3767, -3767, -3766, -3765, -3764, -3763, -3762, -3762, -3760, -3759, -3758, -3756, -3755, -3755, -3754, -3753, -3751, -3750, -3749, -3748, -3748, -3746, -3745, -3744, -3743, -3743, -3742, -3740, -3739, -3733, -3752, -3599, -3029, -2295, -1463, -529};