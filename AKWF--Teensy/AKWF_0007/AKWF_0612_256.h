/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0612 256 samples */
 
const int16_t AKWF_0612_256_DATA [256] = 
{394, 598, 755, 1212, 1382, 1256, 1187, 1108, 1031, 950, 870, 1494, 1744, 1856, 1999, 2138, 2392, 2359, 1871, 2618, 25834, 28976, 28245, 28445, 28498, 28549, 28602, 28655, 28707, 28759, 28811, 28864, 28917, 28969, 29021, 29074, 29127, 29179, 29231, 29283, 29336, 29388, 29441, 29492, 29545, 29598, 29650, 29702, 29754, 29807, 29860, 29912, 29964, 30017, 30070, 30121, 30174, 30226, 30279, 30331, 30383, 30435, 30488, 30541, 30593, 30645, 30697, 30750, 30803, 30855, 30907, 30959, 31013, 31064, 31117, 31168, 31221, 31274, 31326, 31378, 31431, 31484, 31536, 31588, 31640, 31694, 31746, 31798, 31850, 31902, 31956, 32007, 32059, 32112, 32164, 32217, 32269, 32321, 32374, 32427, 32479, 32531, 32583, 32633, 32428, 33963, 13904, 6284, 7637, 7088, 6826, 6564, 6303, 6042, 5780, 5520, 5260, 5000, 4742, 4482, 4223, 3965, 3706, 3416, 3320, 1985, -137, -1206, -2185, -3042, -3826, -4558, -5245, -5900, -6529, -7131, -7918, -7356, -13417, -23788, -22527, -22683, -22618, -22554, -22490, -22426, -22362, -22299, -22234, -22170, -22106, -22042, -21977, -21913, -21849, -21785, -21721, -21657, -21593, -21529, -21464, -21401, -21336, -21272, -21208, -21145, -21080, -21016, -20952, -20888, -20823, -20759, -20695, -20631, -20567, -20503, -20439, -20375, -20310, -20247, -20182, -20118, -20054, -19990, -19926, -19862, -19798, -19734, -19669, -19605, -19541, -19477, -19413, -19349, -19285, -19220, -19156, -19092, -19028, -18964, -18900, -18836, -18772, -18708, -18644, -18579, -18515, -18451, -18387, -18322, -18259, -18195, -18069, -18273, -17314, 375, 2382, 1736, 1739, 1638, 1535, 1433, 1332, 1230, 1127, 1026, 924, 821, 720, 618, 515, 413, 225, 603, -1849, -6066, -5255, -5219, -4394, -581, -581, -716, -802, -906, -970, -908, -834, -763, -690, -618, -547, -474, -224, -296, -444, -578};