/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0694 256 samples */
 
const int16_t AKWF_0694_256_DATA [256] = 
{6139, 14920, 21344, 25988, 29157, 31124, 32036, 31903, 30731, 28623, 25795, 22473, 18907, 15332, 11917, 8802, 6078, 3768, 1865, 327, -923, -1968, -2908, -3855, -4885, -6058, -7387, -8828, -10265, -11488, -12148, -11773, -9899, -6335, -1168, 5358, 12856, 20408, 26768, 31050, 32771, 31720, 27997, 22079, 14770, 6990, -462, -6917, -11919, -15271, -16939, -17058, -15885, -13740, -10967, -7868, -4731, -1774, 862, 3076, 4838, 6169, 7103, 7722, 8113, 8359, 8550, 8756, 8977, 9137, 9133, 8869, 8283, 7361, 6141, 4684, 3073, 1406, -240, -1786, -3174, -4372, -5356, -6121, -6722, -7001, -7515, -15588, -22506, -24826, -24693, -22678, -19468, -15642, -11700, -8005, -4805, -2266, -437, 700, 1214, 1214, 834, 206, -539, -1280, -1914, -2359, -2571, -2551, -2347, -2023, -1650, -1300, -1065, -1000, -1112, -1376, -1762, -2024, -2018, -2018, -2018, -2018, -2017, -2016, -2016, -2015, -2014, -2014, -2014, -2013, -2011, -2012, -2011, -2011, -2010, -2009, -2009, -2008, -2009, -2007, -2006, -2006, -2005, -2005, -2004, -2005, -2003, -2002, -2002, -2001, -2002, -2001, -2001, -1999, -1998, -1998, -1998, -1997, -1997, -1997, -1996, -1995, -1996, -1994, -1993, -1993, -1992, -1992, -1991, -1992, -1990, -1989, -1989, -1988, -1988, -1988, -1988, -1987, -1987, -1986, -1984, -1985, -1984, -1983, -1983, -1983, -1982, -1981, -1981, -1980, -1979, -1980, -1979, -1979, -1978, -1978, -1977, -1975, -1976, -1975, -1974, -1974, -1974, -1973, -1972, -1972, -1971, -1970, -1971, -1970, -1970, -1969, -1968, -1968, -1966, -1967, -1966, -1965, -1965, -1965, -1965, -1963, -1962, -1962, -1961, -1962, -1961, -1960, -1960, -1960, -1959, -1958, -1958, -1957, -1956, -1957, -1956, -1956, -1955, -1953, -1953, -1952, -1953, -1952, -1951, -1951, -1949, -1950, -1949, -1948, -1948, -1934, -2008, -1609};