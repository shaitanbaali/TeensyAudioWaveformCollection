/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0679 256 samples */
 
const int16_t AKWF_0679_256_DATA [256] = 
{1308, 6137, 10731, 15102, 19138, 22761, 25899, 28483, 30479, 31861, 32613, 32748, 32293, 31287, 29781, 27841, 25553, 22983, 20228, 17379, 14513, 11718, 9075, 6638, 4476, 2633, 1133, 3, -755, -1148, -1197, -929, -384, 388, 1336, 2407, 3540, 4681, 5777, 6777, 7641, 8335, 8827, 9105, 9159, 8988, 8604, 8022, 7268, 6372, 5369, 4298, 3195, 2102, 1058, 92, -761, -1475, -2033, -2418, -2626, -2656, -2515, -2215, -1773, -1213, -560, 156, 905, 1658, 2383, 3051, 3640, 4124, 4485, 4712, 4795, 4731, 4521, 4173, 3697, 3109, 2428, 1676, 874, 50, -772, -1570, -2318, -2996, -3584, -4068, -4435, -4677, -4788, -4770, -4624, -4361, -3989, -3521, -2976, -2371, -1725, -1062, -399, 241, 838, 1376, 1837, 2205, 2471, 2626, 2663, 2580, 2376, 2055, 1625, 1092, 471, -228, -989, -1793, -2630, -3476, -4314, -5131, -5906, -6625, -7275, -7844, -8319, -8695, -8964, -9122, -9167, -9101, -8926, -8647, -8273, -7810, -7269, -6663, -6002, -5301, -4578, -3840, -3106, -2391, -1706, -1068, -488, 24, 454, 796, 1041, 1181, 1214, 1133, 938, 627, 202, -334, -980, -1731, -2580, -3521, -4550, -5652, -6822, -8054, -9330, -10647, -11995, -13356, -14731, -16106, -17465, -18809, -20125, -21402, -22639, -23825, -24951, -26017, -27015, -27940, -28790, -29561, -30250, -30858, -31381, -31820, -32175, -32446, -32636, -32743, -32770, -32724, -32600, -32407, -32146, -31818, -31432, -30986, -30488, -29940, -29347, -28711, -28039, -27331, -26593, -25831, -25044, -24239, -23420, -22586, -21745, -20899, -20047, -19198, -18351, -17507, -16672, -15847, -15030, -14231, -13446, -12674, -11925, -11194, -10482, -9795, -9129, -8486, -7869, -7278, -6710, -6171, -5658, -5172, -4715, -4284, -3882, -3511, -3166, -2851, -2565, -2307, -2078, -1879, -1709, -1569, -1457, -1376, -1323, -1301};