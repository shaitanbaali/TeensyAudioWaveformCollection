/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0602 256 samples */
 
const int16_t AKWF_0602_256_DATA [256] = 
{1033, 2090, 4739, 5073, 5642, 6178, 6712, 7244, 7777, 8310, 8842, 9373, 9905, 10436, 10967, 11498, 12025, 12556, 13086, 13614, 14143, 14671, 15199, 15727, 16254, 16780, 17307, 17834, 18360, 18886, 19411, 19936, 20462, 20986, 21510, 22035, 22558, 23081, 23606, 24127, 24650, 25173, 25694, 26216, 26738, 27258, 27780, 28300, 28820, 29340, 29861, 30379, 30898, 31418, 31924, 32494, 32622, 32139, 31701, 31255, 30809, 30363, 29917, 29470, 29023, 28577, 28130, 27684, 27239, 26792, 26345, 25901, 25454, 25007, 24563, 24117, 23670, 23227, 22782, 22336, 21893, 21448, 21003, 20560, 20116, 19672, 19229, 18785, 18342, 17900, 17457, 17014, 16573, 16130, 15689, 15249, 14807, 14366, 13925, 13484, 13045, 12604, 12164, 11725, 11285, 10845, 10407, 9968, 9529, 9092, 8653, 8215, 7778, 7341, 6903, 6467, 6030, 5593, 5158, 4722, 4262, 3961, 2967, 23, 354, -1608, -3492, -3610, -4051, -4441, -4831, -5222, -5610, -5999, -6389, -6776, -7165, -7553, -7940, -8328, -8715, -9101, -9488, -9874, -10260, -10646, -11031, -11416, -11802, -12186, -12570, -12955, -13339, -13723, -14107, -14490, -14873, -15256, -15639, -16021, -16404, -16785, -17167, -17549, -17931, -18311, -18694, -19074, -19454, -19835, -20214, -20594, -20975, -21354, -21734, -22113, -22491, -22871, -23250, -23628, -24005, -24383, -24761, -25139, -25516, -25893, -26270, -26647, -27023, -27400, -27776, -28151, -28528, -28903, -29278, -29652, -30027, -30401, -30769, -31179, -31015, -30440, -29924, -29396, -28868, -28341, -27813, -27285, -26759, -26231, -25703, -25176, -24649, -24122, -23596, -23068, -22541, -22016, -21489, -20964, -20439, -19912, -19387, -18863, -18337, -17814, -17289, -16764, -16242, -15717, -15193, -14671, -14148, -13625, -13104, -12581, -12059, -11538, -11016, -10495, -9976, -9455, -8934, -8415, -7894, -7376, -6857, -6337, -5819, -5302, -4783, -4265, -3749, -3232, -2716, -2191};