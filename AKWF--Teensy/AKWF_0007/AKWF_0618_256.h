/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0618 256 samples */
 
const int16_t AKWF_0618_256_DATA [256] = 
{32767, 32188, 35299, 13541, -2312, 677, 111, 103, 94, 85, 77, 69, 60, 52, 45, 37, 29, 22, 13, 7, -1, -8, -14, -22, -29, -36, -42, -50, -57, -63, -69, -76, -82, -88, -94, -101, -107, -113, -119, -126, -132, -138, -145, -149, -154, -161, -167, -173, -177, -183, -189, -194, -199, -205, -210, -215, -221, -225, -231, -235, -241, -246, -251, -255, -260, -264, -269, -274, -278, -283, -288, -292, -297, -301, -305, -309, -314, -318, -322, -326, -330, -334, -338, -341, -346, -349, -353, -357, -360, -363, -367, -371, -373, -377, -380, -383, -386, -389, -392, -396, -398, -402, -405, -408, -410, -413, -416, -418, -421, -422, -426, -428, -430, -433, -436, -437, -439, -441, -444, -445, -448, -449, -451, -453, -454, -456, -459, -460, -461, -462, -464, -465, -468, -468, -469, -470, -472, -472, -473, -476, -475, -476, -478, -477, -478, -480, -481, -480, -481, -480, -483, -484, -483, -483, -483, -483, -483, -483, -483, -483, -483, -483, -483, -483, -484, -483, -481, -480, -481, -481, -480, -478, -477, -478, -477, -475, -476, -474, -472, -472, -470, -469, -468, -468, -466, -464, -462, -461, -460, -458, -456, -454, -453, -451, -449, -447, -445, -444, -442, -439, -437, -435, -432, -430, -428, -425, -423, -420, -419, -415, -413, -411, -407, -404, -401, -399, -396, -393, -389, -387, -383, -380, -377, -373, -370, -366, -364, -360, -356, -353, -348, -345, -341, -338, -334, -330, -326, -322, -318, -314, -309, -305, -301, -297, -292, -288, -283, -279, -274, -269, -265, -260, -255, -250, -246, -241};