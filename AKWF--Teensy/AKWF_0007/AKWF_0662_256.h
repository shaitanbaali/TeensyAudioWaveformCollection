/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0662 256 samples */
 
const int16_t AKWF_0662_256_DATA [256] = 
{2143, 4537, 6243, 7635, 8805, 9821, 10718, 11520, 12248, 12915, 13527, 14096, 14625, 15119, 15583, 16021, 16432, 16821, 17191, 17540, 17872, 18188, 18488, 18775, 19049, 19310, 19558, 19797, 20023, 20239, 20446, 20643, 20832, 21011, 21182, 21346, 21501, 21648, 21789, 21922, 22049, 22169, 22281, 22388, 22488, 22582, 22669, 22750, 22826, 22896, 22960, 23018, 23072, 23119, 23160, 23196, 23227, 23253, 23272, 23287, 23301, 23323, 23179, 27443, 29228, 29457, 29817, 30070, 30277, 30454, 30608, 30744, 30866, 30977, 31078, 31169, 31256, 31335, 31408, 31478, 31542, 31603, 31660, 31713, 31763, 31811, 31856, 31899, 31938, 31976, 32011, 32046, 32078, 32107, 32136, 32162, 32188, 32212, 32234, 32254, 32273, 32292, 32309, 32325, 32339, 32352, 32365, 32376, 32385, 32394, 32401, 32409, 32414, 32418, 32422, 32425, 32427, 32428, 32428, 32427, 32425, 32422, 32418, 32413, 32408, 31912, 34481, 20736, -1502, -2622, -5200, -6883, -8240, -9388, -10388, -11269, -12061, -12782, -13439, -14047, -14609, -15132, -15623, -16083, -16515, -16923, -17310, -17675, -18022, -18352, -18664, -18963, -19247, -19518, -19776, -20022, -20257, -20481, -20694, -20898, -21093, -21279, -21456, -21623, -21783, -21936, -22082, -22219, -22349, -22471, -22588, -22698, -22801, -22897, -22987, -23071, -23149, -23221, -23287, -23346, -23401, -23449, -23493, -23530, -23562, -23588, -23609, -23624, -23638, -23660, -23515, -27789, -29578, -29808, -30168, -30422, -30630, -30806, -30960, -31096, -31218, -31330, -31430, -31523, -31608, -31688, -31762, -31830, -31895, -31956, -32012, -32065, -32115, -32163, -32208, -32251, -32291, -32328, -32363, -32397, -32428, -32458, -32486, -32513, -32538, -32561, -32583, -32603, -32622, -32640, -32657, -32672, -32686, -32699, -32711, -32720, -32731, -32738, -32745, -32752, -32757, -32761, -32764, -32766, -32767, -32767, -32767, -32765, -32763, -32759, -32754, -32749, -32382, -34322, -25254, -148};