/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0603 256 samples */
 
const int16_t AKWF_0603_256_DATA [256] = 
{1681, 7163, 7480, 7906, 8332, 8752, 9173, 9592, 10012, 10433, 10852, 11272, 11692, 12112, 12531, 12953, 13372, 13793, 14213, 14633, 15055, 15476, 15897, 16319, 16740, 17161, 17584, 18007, 18429, 18853, 19275, 19697, 20121, 20545, 20969, 21393, 21817, 22242, 22668, 23092, 23518, 23944, 24370, 24797, 25224, 25650, 26076, 26504, 26931, 27360, 27788, 28216, 28645, 29075, 29503, 29933, 30364, 30794, 31225, 31655, 32076, 32551, 32638, 32225, 31852, 31468, 31081, 30690, 30296, 29899, 29498, 29094, 28687, 28276, 27862, 27445, 27025, 26603, 26177, 25748, 25325, 24907, 24488, 24070, 23652, 23233, 22815, 22398, 21980, 21564, 21146, 20730, 20314, 19895, 19480, 19064, 18647, 18231, 17816, 17400, 16986, 16571, 16156, 15741, 15327, 14913, 14500, 14085, 13671, 13259, 12845, 12431, 12019, 11607, 11194, 10782, 10369, 9957, 9546, 9134, 8722, 8312, 7899, 7488, 7078, 6533, 6827, 2843, -6994, -7204, -7563, -7954, -8320, -8686, -9051, -9415, -9780, -10143, -10506, -10869, -11231, -11593, -11955, -12316, -12676, -13037, -13398, -13757, -14116, -14476, -14835, -15194, -15553, -15910, -16269, -16627, -16984, -17341, -17698, -18055, -18413, -18768, -19125, -19481, -19836, -20192, -20548, -20903, -21257, -21613, -21967, -22321, -22676, -23029, -23383, -23736, -24090, -24443, -24797, -25148, -25501, -25854, -26205, -26557, -26909, -27260, -27612, -27964, -28314, -28666, -29017, -29366, -29717, -30067, -30416, -30767, -31116, -31465, -31813, -32162, -32516, -32258, -31727, -31243, -30751, -30260, -29767, -29275, -28783, -28291, -27799, -27308, -26816, -26324, -25833, -25341, -24850, -24360, -23869, -23377, -22888, -22397, -21908, -21418, -20928, -20438, -19949, -19459, -18971, -18483, -17994, -17506, -17019, -16530, -16044, -15557, -15069, -14584, -14096, -13609, -13124, -12640, -12153, -11669, -11184, -10699, -10215, -9731, -9247, -8763, -8280, -7797, -7314, -6832, -6351, -5861};