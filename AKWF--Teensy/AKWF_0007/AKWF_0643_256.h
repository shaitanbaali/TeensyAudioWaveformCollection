/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0643 256 samples */
 
const int16_t AKWF_0643_256_DATA [256] = 
{771, 1772, 2699, 3601, 4481, 5345, 6195, 7031, 7855, 8668, 9468, 10259, 11039, 11806, 12565, 13312, 14047, 14772, 15487, 16188, 16879, 17558, 18225, 18880, 19523, 20153, 20771, 21375, 21965, 22543, 23105, 23655, 24191, 24713, 25218, 25710, 26186, 26647, 27094, 27523, 27937, 28337, 28717, 29084, 29434, 29766, 30082, 30381, 30662, 30926, 31174, 31403, 31615, 31811, 31985, 32145, 32286, 32409, 32514, 32601, 32670, 32719, 32749, 32778, 32024, 30987, 30070, 29167, 28286, 27422, 26572, 25736, 24913, 24099, 23299, 22508, 21728, 20961, 20203, 19455, 18720, 17995, 17280, 16580, 15888, 15209, 14542, 13887, 13244, 12615, 11997, 11392, 10803, 10225, 9662, 9112, 8576, 8054, 7549, 7057, 6581, 6120, 5673, 5244, 4830, 4430, 4049, 3683, 3334, 3002, 2686, 2387, 2105, 1841, 1593, 1364, 1152, 957, 782, 622, 481, 358, 253, 166, 97, 44, 11, 12, -744, -1780, -2698, -3602, -4482, -5346, -6196, -7032, -7856, -8668, -9469, -10260, -11039, -11807, -12565, -13313, -14047, -14773, -15488, -16188, -16880, -17559, -18225, -18881, -19524, -20153, -20771, -21376, -21965, -22543, -23106, -23655, -24192, -24713, -25219, -25710, -26186, -26647, -27094, -27523, -27938, -28337, -28718, -29084, -29434, -29766, -30082, -30381, -30662, -30926, -31174, -31403, -31615, -31811, -31985, -32145, -32286, -32409, -32514, -32601, -32670, -32719, -32749, -32778, -32024, -30988, -30070, -29167, -28286, -27422, -26572, -25736, -24913, -24099, -23299, -22508, -21729, -20961, -20203, -19456, -18721, -17996, -17281, -16580, -15888, -15209, -14543, -13887, -13244, -12615, -11997, -11392, -10804, -10225, -9662, -9113, -8576, -8055, -7549, -7058, -6582, -6121, -5674, -5245, -4830, -4431, -4050, -3684, -3335, -3003, -2687, -2388, -2106, -1842, -1594, -1365, -1153, -958, -783, -623, -482, -359, -254, -167, -98, -47, -15, -1};