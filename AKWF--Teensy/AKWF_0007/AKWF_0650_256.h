/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0650 256 samples */
 
const int16_t AKWF_0650_256_DATA [256] = 
{435, 1174, 1884, 2584, 3271, 3947, 4612, 5265, 5907, 6539, 7160, 7771, 8373, 8963, 9546, 10120, 10683, 11238, 11785, 12321, 12852, 13372, 13884, 14389, 14886, 15374, 15856, 16328, 16794, 17252, 17702, 18146, 18582, 19010, 19431, 19846, 20253, 20653, 21046, 21432, 21811, 22183, 22547, 22906, 23259, 23604, 23942, 24274, 24598, 24917, 25229, 25535, 25833, 26126, 26411, 26690, 26964, 27230, 27490, 27744, 27991, 28232, 28466, 28695, 28916, 29132, 29341, 29544, 29741, 29932, 30115, 30293, 30466, 30631, 30790, 30943, 31090, 31231, 31365, 31493, 31615, 31731, 31841, 31945, 32042, 32134, 32218, 32298, 32370, 32437, 32498, 32552, 32600, 32643, 32679, 32709, 32733, 32751, 32763, 32712, 32977, 31537, 27741, 25619, 23735, 22079, 20577, 19184, 17877, 16643, 15465, 14340, 13260, 12215, 11207, 10231, 9282, 8359, 7463, 6586, 5730, 4897, 4079, 3279, 2497, 1728, 977, 239, -486, -1197, -1894, -2582, -3256, -3919, -4572, -5212, -5843, -6464, -7074, -7676, -8268, -8849, -9423, -9987, -10541, -11089, -11628, -12157, -12679, -13193, -13698, -14197, -14687, -15168, -15644, -16112, -16571, -17025, -17470, -17907, -18339, -18763, -19179, -19590, -19992, -20389, -20778, -21161, -21537, -21907, -22268, -22624, -22973, -23316, -23653, -23982, -24305, -24622, -24933, -25236, -25534, -25825, -26109, -26388, -26660, -26925, -27185, -27439, -27686, -27927, -28161, -28389, -28612, -28828, -29038, -29243, -29439, -29631, -29816, -29996, -30169, -30336, -30497, -30652, -30801, -30944, -31080, -31212, -31336, -31454, -31567, -31674, -31774, -31869, -31957, -32039, -32116, -32186, -32251, -32309, -32362, -32409, -32449, -32483, -32511, -32534, -32550, -32561, -32504, -32805, -30761, -27041, -24961, -23087, -21443, -19941, -18548, -17243, -16005, -14825, -13699, -12613, -11567, -10558, -9577, -8626, -7702, -6800, -5921, -5065, -4227, -3408, -2606, -1821, -1054, -287};