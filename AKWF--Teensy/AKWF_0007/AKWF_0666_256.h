/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0666 256 samples */
 
const int16_t AKWF_0666_256_DATA [256] = 
{1242, 3590, 5819, 7971, 10024, 11970, 13797, 15487, 17038, 18438, 19674, 20745, 21642, 22358, 22892, 23237, 23405, 23269, 22775, 22065, 21178, 20142, 18980, 17704, 16333, 14883, 13362, 11787, 10171, 8520, 6854, 5183, 3511, 1858, 231, -1362, -2905, -4394, -5818, -7166, -8433, -9611, -10689, -11665, -12532, -13283, -13916, -14427, -14810, -15066, -15194, -15179, -15051, -14858, -14616, -14328, -14000, -13637, -13241, -12815, -12363, -11884, -11382, -10860, -10317, -9757, -9181, -8589, -7987, -7372, -6747, -6116, -5476, -4833, -4186, -3537, -2886, -2238, -1591, -947, -310, 321, 946, 1559, 2164, 2758, 3337, 3905, 4457, 4992, 5511, 6010, 6491, 6952, 7391, 7809, 8204, 8575, 8922, 9245, 9541, 9812, 10057, 10273, 10463, 10624, 10757, 10862, 10938, 10986, 11004, 11011, 11034, 11068, 11109, 11158, 11213, 11274, 11341, 11413, 11490, 11571, 11655, 11744, 11835, 11930, 12028, 12126, 12229, 12332, 12437, 12545, 12651, 12760, 12869, 12979, 13089, 13198, 13307, 13415, 13523, 13629, 13734, 13837, 13938, 14038, 14136, 14231, 14322, 14412, 14499, 14583, 14663, 14739, 14812, 14881, 14946, 15008, 15065, 15118, 15166, 15210, 15249, 15284, 15314, 15338, 15360, 15375, 15385, 15388, 15397, 15296, 14956, 14463, 13847, 13125, 12316, 11429, 10476, 9469, 8411, 7317, 6196, 5052, 3897, 2739, 1583, 441, -679, -1776, -2838, -3857, -4832, -5751, -6610, -7408, -8134, -8786, -9362, -9855, -10264, -10587, -10821, -10965, -11015, -11150, -11466, -11894, -12417, -13022, -13697, -14431, -15218, -16049, -16915, -17813, -18732, -19666, -20610, -21555, -22495, -23427, -24340, -25231, -26096, -26926, -27717, -28467, -29166, -29814, -30407, -30938, -31407, -31811, -32145, -32409, -32602, -32718, -32775, -32490, -31721, -30648, -29325, -27792, -26073, -24198, -22191, -20062, -17840, -15543, -13179, -10778, -8354, -5921, -3502, -1060};