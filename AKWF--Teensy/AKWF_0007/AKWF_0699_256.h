/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0699 256 samples */
 
const int16_t AKWF_0699_256_DATA [256] = 
{2752, 6771, 9183, 11049, 12556, 13826, 14924, 15887, 16746, 17521, 18221, 18863, 19452, 19993, 20493, 20957, 21386, 21785, 22154, 22497, 22818, 23114, 23387, 23642, 23876, 24091, 24289, 24470, 24633, 24781, 24913, 25030, 25132, 25221, 25294, 25355, 25402, 25431, 25138, 26818, 15648, 2280, 1679, -34, -1138, -2032, -2788, -3443, -4019, -4534, -5001, -5421, -5808, -6164, -6491, -6794, -7076, -7336, -7580, -7807, -8019, -8216, -8400, -8571, -8731, -8879, -9017, -9144, -9262, -9370, -9471, -9561, -9644, -9720, -9787, -9847, -9898, -9944, -9981, -10013, -10037, -10055, -9961, -10517, -7867, 2536, 4003, 4923, 5634, 6181, 6633, 7016, 7345, 7630, 7882, 8102, 8296, 8467, 8619, 8751, 8866, 8964, 9049, 9119, 9176, 9218, 9193, 9381, 8853, -6850, -12649, -13606, -14906, -15828, -16580, -17212, -17758, -18235, -18653, -19025, -19355, -19652, -19916, -20153, -20363, -20549, -20716, -20861, -20988, -21098, -21190, -21267, -21329, -21376, -21416, -21014, -23222, -9881, 5244, 6016, 7930, 9166, 10165, 11001, 11715, 12342, 12895, 13387, 13830, 14229, 14590, 14918, 15215, 15486, 15733, 15957, 16160, 16344, 16511, 16660, 16794, 16913, 17018, 17111, 17189, 17256, 17312, 17358, 17392, 17339, 17523, 17470, -7363, -16131, -17396, -19363, -20739, -21875, -22840, -23675, -24414, -25074, -25667, -26207, -26698, -27149, -27564, -27948, -28302, -28630, -28936, -29220, -29485, -29733, -29964, -30178, -30379, -30567, -30743, -30905, -31058, -31201, -31335, -31458, -31572, -31680, -31781, -31874, -31961, -32041, -32113, -32182, -32244, -32303, -32357, -32405, -32450, -32489, -32526, -32559, -32588, -32615, -32639, -32661, -32678, -32696, -32711, -32723, -32733, -32741, -32749, -32755, -32759, -32764, -32766, -32766, -32766, -32767, -32768, -32767, -32728, -32844, -32131, -25586, -16309, -8384, -3563, -1467, -694, -559, -643, -741, -774, -744, -693, -663};