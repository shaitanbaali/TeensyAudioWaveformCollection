/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0644 256 samples */
 
const int16_t AKWF_0644_256_DATA [256] = 
{7656, 10748, 12611, 14115, 15374, 16468, 17444, 18325, 19134, 19883, 20578, 21229, 21843, 22421, 22970, 23490, 23984, 24457, 24908, 25338, 25751, 26145, 26524, 26886, 27234, 27567, 27888, 28194, 28488, 28771, 29041, 29300, 29549, 29786, 30013, 30231, 30437, 30635, 30823, 31000, 31170, 31330, 31481, 31623, 31757, 31882, 31998, 32106, 32206, 32297, 32380, 32455, 32521, 32580, 32631, 32674, 32709, 32735, 32636, 33244, 30130, 23254, 21264, 19502, 18106, 16924, 15884, 14948, 14099, 13317, 12591, 11915, 11280, 10681, 10115, 9579, 9070, 8585, 8121, 7679, 7257, 6851, 6464, 6092, 5736, 5393, 5066, 4751, 4450, 4161, 3883, 3618, 3363, 3119, 2886, 2663, 2449, 2247, 2053, 1870, 1695, 1530, 1374, 1226, 1088, 957, 836, 723, 618, 522, 435, 355, 284, 220, 165, 117, 78, 46, 23, 8, 0, -1, 0, 0, 0, -27, 59, -206, -7283, -10852, -12585, -14116, -15375, -16469, -17445, -18326, -19135, -19883, -20578, -21230, -21843, -22422, -22971, -23490, -23985, -24457, -24908, -25338, -25751, -26145, -26524, -26886, -27234, -27567, -27888, -28194, -28488, -28771, -29041, -29300, -29549, -29786, -30013, -30231, -30437, -30635, -30823, -31000, -31170, -31330, -31481, -31623, -31757, -31882, -31998, -32106, -32206, -32297, -32380, -32455, -32521, -32580, -32631, -32674, -32709, -32735, -32636, -33244, -30130, -23254, -21265, -19503, -18107, -16924, -15884, -14949, -14100, -13317, -12591, -11915, -11281, -10681, -10116, -9580, -9070, -8585, -8122, -7680, -7258, -6852, -6465, -6093, -5736, -5394, -5067, -4752, -4451, -4162, -3884, -3619, -3364, -3120, -2887, -2664, -2450, -2248, -2054, -1871, -1696, -1531, -1375, -1227, -1089, -958, -837, -724, -619, -523, -436, -356, -285, -221, -166, -118, -79, -47, -24, -9, -1, 0, -1, -1, 0, 0, 0, 0};