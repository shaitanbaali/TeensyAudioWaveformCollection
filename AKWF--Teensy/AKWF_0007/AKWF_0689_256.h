/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_0689 256 samples */
 
const int16_t AKWF_0689_256_DATA [256] = 
{840, 2293, 3764, 5249, 6711, 8120, 9456, 10709, 11867, 12915, 13846, 14650, 15312, 15820, 16157, 16333, 16350, 16237, 16012, 15686, 15258, 14746, 14150, 13485, 12767, 12007, 11220, 10420, 9634, 8879, 8165, 7520, 6954, 6484, 6112, 5850, 5700, 5667, 5744, 5922, 6191, 6532, 6928, 7362, 7807, 8239, 8648, 9015, 9329, 9573, 9738, 9826, 9817, 9722, 9550, 9288, 8965, 8591, 8177, 7733, 7272, 6799, 6322, 5850, 5382, 4929, 4502, 4099, 3735, 3416, 3148, 2946, 2824, 2792, 2860, 3037, 3341, 3776, 4357, 5073, 5931, 6919, 8024, 9216, 10460, 11685, 12806, 13539, 13320, 14416, 22568, 30730, 30483, 26739, 26508, 30302, 32705, 32451, 31403, 31250, 31832, 32202, 31972, 31275, 30499, 29937, 29524, 28924, 27989, 26906, 25919, 25004, 24013, 22876, 21663, 20475, 19335, 18214, 17091, 15976, 14913, 13935, 13053, 12247, 11515, 10874, 10341, 9908, 9555, 9264, 9011, 8792, 8585, 8366, 8115, 7821, 7472, 7058, 6584, 6035, 5400, 4691, 3903, 3049, 2123, 1000, 808, -12147, -20444, -17125, -12414, -9130, -7645, -7655, -8690, -10378, -12494, -14868, -17272, -19452, -21194, -22376, -22963, -22930, -22322, -21437, -20592, -19959, -19622, -19610, -19877, -20310, -21187, -21380, -21964, -27573, -26755, -26838, -29410, -28551, -28365, -28225, -27097, -25645, -24074, -21875, -19261, -16592, -13681, -10570, -9584, -3502, 6184, 4825, 4964, 10033, 10967, 10811, 12148, 13099, 13003, 12728, 12795, 12573, 11802, 11081, 10499, 9478, 8225, 8043, 7474, 2711, 48, 2769, 2446, -373, -280, 873, 1055, 1064, 1601, 2494, 3237, 3543, 3907, 4436, 4657, 4479, 4272, 3965, 3458, 2797, 2070, 1321, 560, -224, -1012, -1769, -2494, -3190, -3841, -4431, -4956, -5397, -5752, -6002, -6127, -6124, -5981, -5683, -5226, -4597, -3804, -2854, -1746, -476};