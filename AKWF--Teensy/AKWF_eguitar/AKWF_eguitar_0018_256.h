/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0018 256 samples */
 
const int16_t AKWF_eguitar_0018_256_DATA [256] = 
{3517, 9502, 14629, 18683, 21921, 24375, 26398, 27484, 27463, 27403, 27382, 27355, 27316, 27283, 27242, 27204, 27178, 27153, 27127, 27092, 27062, 27025, 26999, 26966, 26935, 26916, 26871, 26850, 26800, 26812, 26765, 26768, 26739, 26698, 26689, 26570, 27021, 23542, 15587, 7765, 1250, -5022, -10467, -15624, -20097, -24511, -29180, -31470, -31348, -31210, -31269, -31202, -31230, -31184, -31178, -31159, -31124, -31115, -31070, -31039, -31007, -30965, -30935, -30900, -30863, -30801, -30736, -30687, -30598, -30638, -30518, -30614, -30362, -30862, -29917, -22722, -12903, -4318, 4260, 12438, 21187, 27022, 27568, 27213, 27337, 27271, 27305, 27294, 27286, 27300, 27276, 27278, 27249, 27293, 27398, 27402, 27367, 27317, 27218, 27121, 27062, 27042, 27014, 26980, 26949, 26680, 27561, 24389, 5701, -21588, -32059, -31098, -30799, -31106, -30797, -30842, -30678, -30721, -30704, -30736, -30802, -30623, -30750, -31706, -21338, 7885, 28171, 27536, 26943, 27391, 27005, 27386, 26958, 27282, 26982, 27228, 27163, 27198, 27166, 27044, 26996, 26775, 26852, 26655, 26668, 26495, 26545, 26477, 26421, 26498, 26157, 27064, 24509, 13525, -9915, -29467, -32511, -30726, -31555, -31085, -31330, -31170, -31152, -31214, -31133, -31283, -31167, -31208, -31123, -31114, -31077, -31000, -30954, -30866, -30796, -30767, -30648, -30746, -30437, -30881, -30272, -23147, -10900, 206, 12043, 23773, 27865, 27205, 27101, 27202, 27041, 27112, 27019, 27074, 27045, 27068, 27064, 27013, 27011, 26948, 26950, 26895, 26883, 26841, 26821, 26775, 26708, 26683, 26580, 26597, 26475, 26509, 26366, 26436, 26824, 23589, 14885, 6406, -1256, -8072, -14253, -19548, -24401, -29162, -31638, -31373, -31334, -31332, -31293, -31292, -31245, -31242, -31192, -31199, -31161, -31137, -31095, -31067, -31031, -30985, -30967, -30911, -30884, -30800, -30770, -30681, -30658, -30635, -30593, -30615, -30465, -31036, -27368, -18876, -10479, -3215};