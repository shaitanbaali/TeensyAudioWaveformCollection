/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0001 256 samples */
 
const int16_t AKWF_eguitar_0001_256_DATA [256] = 
{15848, 29415, 26798, 27274, 27208, 27200, 27303, 27295, 27272, 27248, 27193, 27128, 27059, 26854, 27412, 23380, 10158, 5, -6372, -10055, -11488, -10997, -8723, -4821, 407, 6498, 12956, 19523, 25461, 26838, 26460, 26654, 26370, -6441, -32584, -29463, -30011, -29971, -29937, -29991, -29979, -29902, -29800, -29680, -29563, -29381, -29457, -28813, -16820, -1458, 11404, 23144, 27622, 27037, 27129, 27103, 27084, 27072, 27044, 27013, 26985, 26957, 26933, 26889, 26810, 26743, 26565, 26436, 26707, 25585, 16311, 7859, 3050, 697, 468, 2060, 5334, 9949, 15390, 21822, 26170, 25519, 28894, 4580, -32546, -30151, -30383, -30429, -30433, -30528, -30596, -30566, -30512, -30431, -30338, -30171, -30298, -29326, -18715, -6544, 2047, 7034, 8965, 8579, 6464, 2892, -1960, -7802, -14295, -20956, -27487, -29970, -29590, -29572, -29573, -13373, 24612, 27850, 26815, 27055, 27017, 27055, 27115, 27056, 27009, 26962, 26883, 26771, 26682, 26603, 26516, 26736, 20029, 10494, 4754, 1490, 323, 923, 3086, 6660, 11301, 16597, 22566, 26478, 26440, 26390, 26370, 26339, 26322, 26255, 26165, 26083, 26014, 25959, 25908, 25863, 25825, 25789, 25755, 25732, 25704, 25658, 25609, 25552, 25501, 25455, 25404, 25353, 25297, 25247, 25197, 25140, 25083, 25022, 24946, 24856, 24725, 24634, 24586, 24566, 24165, 23487, 22936, 22485, 22061, 21564, 20940, 20086, 18877, 17194, 14670, 10583, 3797, -11543, -30751, -32831, -32463, -32573, -32579, -32589, -32599, -32619, -32613, -32567, -32507, -32451, -32392, -32320, -32264, -32204, -32214, -32226, -27302, -21446, -18657, -18231, -19943, -23284, -28226, -31928, -31864, -31782, -31743, -31700, -31652, -31604, -31545, -31480, -31425, -31359, -31271, -31198, -31130, -31070, -31026, -30983, -30941, -30907, -30738, -30533, -30491, -30437, -30390, -30318, -30265, -30207, -30152, -30095, -30038, -29993, -29820, -29702, -29657, -29441, -30224, -27022};