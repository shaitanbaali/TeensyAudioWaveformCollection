/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0006 256 samples */
 
const int16_t AKWF_eguitar_0006_256_DATA [256] = 
{338, 1527, 2711, 4025, 5511, 7344, 9842, 13292, 18057, 25958, 32651, 32748, 32647, 32619, 32569, 32502, 32436, 32361, 32290, 32226, 32161, 32105, 32054, 32008, 31935, 31862, 31782, 31705, 31627, 31544, 31470, 31393, 31319, 31240, 31160, 31088, 31009, 30935, 30855, 30785, 30716, 30634, 30555, 30476, 30410, 30328, 30254, 30176, 30105, 30030, 29953, 29880, 29804, 29733, 29658, 29584, 29517, 29440, 29363, 29290, 29216, 29147, 29071, 29000, 28926, 28857, 28780, 28712, 28638, 28566, 28499, 28426, 28355, 28294, 28205, 28130, 28056, 27985, 27913, 27837, 27758, 27688, 27613, 27534, 27456, 27382, 26686, 25584, 24536, 23487, 22443, 21432, 20423, 19449, 18483, 17539, 16624, 15746, 14918, 14107, 13311, 12564, 11815, 11094, 10395, 9714, 9051, 8399, 7763, 7150, 6555, 5986, 5443, 4904, 4411, 3929, 3454, 3019, 2599, 2199, 1829, 1478, 1116, 743, 370, -20, -361, -732, -1111, -1508, -1923, -2341, -2792, -3263, -3686, -4127, -4635, -5148, -5648, -6182, -6797, -7510, -8353, -9461, -10897, -12874, -15564, -19526, -26720, -32090, -31878, -31836, -31796, -31741, -31671, -31595, -31529, -31460, -31388, -31326, -31265, -31219, -31166, -31089, -31016, -30944, -30868, -30790, -30716, -30636, -30560, -30487, -30412, -30340, -30259, -30189, -30113, -30038, -29964, -29888, -29824, -29747, -29672, -29590, -29526, -29450, -29374, -29302, -29229, -29158, -29083, -29011, -28938, -28866, -28798, -28722, -28654, -28586, -28508, -28439, -28365, -28297, -28224, -28156, -28084, -28016, -27943, -27871, -27804, -27731, -27667, -27597, -27524, -27467, -27387, -27306, -27235, -27166, -27093, -27024, -26950, -26877, -26808, -26730, -26651, -26597, -25875, -24738, -23772, -22771, -21721, -20696, -19786, -18916, -18037, -17229, -16490, -15770, -15064, -14384, -13703, -12997, -12272, -11521, -10725, -9875, -8994, -8108, -7200, -6264, -5315, -4336, -3360, -2435, -1523, -597};