/* Adventure Kid Waveforms (AKWF) converted for use with Teensy Audio Library 
*  
*  Adventure Kid Waveforms(AKWF) Open waveforms library
*  https://www.adventurekid.se/akrt/waveforms/adventure-kid-waveforms/
*  
*  Teensy Audio Library 
*  16 bit, 44.1 kHz streaming audio library for Teensy 3.x and Teensy 4.x
*  https://www.pjrc.com/teensy/td_libs_Audio.html
*  
*  This code is in the public domain, CC0 1.0 Universal (CC0 1.0)
*  https://creativecommons.org/publicdomain/zero/1.0/
*
*  Converted by Marcelo Valeria, https://github.com/shaitanbaali
*/

/* AKWF_eguitar_0009 256 samples */
 
const int16_t AKWF_eguitar_0009_256_DATA [256] = 
{862, 3336, 7094, 11716, 17492, 24937, 31846, 32874, 32675, 32697, 32687, 32655, 32571, 32387, 32601, 30719, 20110, 8841, 601, -3862, -4535, -1908, 3949, 12466, 23440, 31813, 32203, 32049, 32051, 31973, 31856, 31741, 31642, 31565, 31496, 31437, 31398, 31362, 31331, 31267, 31190, 31119, 31047, 30972, 30897, 30824, 30747, 30670, 30601, 30525, 30456, 30376, 30306, 30232, 30157, 30088, 30012, 29949, 29877, 29801, 29724, 29654, 29587, 29509, 29440, 29367, 29298, 29226, 29154, 29085, 29012, 28944, 28873, 28802, 28737, 28664, 28592, 28523, 28452, 28386, 28314, 28244, 28168, 28099, 28023, 27950, 27881, 27807, 27742, 27670, 27598, 27537, 27445, 27407, 26986, 25876, 24728, 23683, 22661, 21590, 20545, 19787, 19164, 18504, 17805, 17152, 16575, 16015, 15486, 15043, 14560, 13965, 13443, 12962, 12366, 11554, 10646, 9774, 8899, 8085, 7282, 6517, 5697, 4974, 4287, 3509, 2436, 1257, 152, -1102, -2449, -3858, -5457, -7197, -8916, -10508, -12072, -13549, -15360, -16831, -17923, -19484, -22619, -26617, -30622, -31950, -31737, -31711, -31657, -31594, -31527, -31459, -31392, -31319, -31251, -31185, -31123, -31068, -31000, -30929, -30854, -30776, -30713, -30639, -30551, -30478, -30405, -30331, -30258, -30182, -30104, -30035, -29957, -29882, -29807, -29734, -29667, -29591, -29515, -29447, -29373, -29300, -29225, -29154, -29083, -29014, -28941, -28867, -28797, -28720, -28651, -28580, -28509, -28440, -28363, -28298, -28224, -28155, -28085, -28013, -27955, -27883, -27809, -27735, -27672, -27603, -27530, -27462, -27391, -27325, -27255, -27184, -27117, -27047, -26982, -26912, -26843, -26779, -26702, -26629, -26556, -26491, -26379, -26062, -25689, -25350, -25073, -24815, -24516, -24064, -23335, -22458, -21527, -20586, -19550, -18378, -17196, -16028, -15063, -14297, -13538, -12737, -12044, -11436, -10885, -10428, -9926, -9421, -8803, -8175, -7337, -6245, -5103, -3845, -2345, -688};